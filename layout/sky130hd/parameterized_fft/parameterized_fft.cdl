* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_fft busy clk data_in_imag[0] data_in_imag[10]
+ data_in_imag[11] data_in_imag[12] data_in_imag[13] data_in_imag[14]
+ data_in_imag[15] data_in_imag[1] data_in_imag[2] data_in_imag[3]
+ data_in_imag[4] data_in_imag[5] data_in_imag[6] data_in_imag[7]
+ data_in_imag[8] data_in_imag[9] data_in_real[0] data_in_real[10]
+ data_in_real[11] data_in_real[12] data_in_real[13] data_in_real[14]
+ data_in_real[15] data_in_real[1] data_in_real[2] data_in_real[3]
+ data_in_real[4] data_in_real[5] data_in_real[6] data_in_real[7]
+ data_in_real[8] data_in_real[9] data_out_imag[0] data_out_imag[100]
+ data_out_imag[101] data_out_imag[102] data_out_imag[103] data_out_imag[104]
+ data_out_imag[105] data_out_imag[106] data_out_imag[107] data_out_imag[108]
+ data_out_imag[109] data_out_imag[10] data_out_imag[110] data_out_imag[111]
+ data_out_imag[112] data_out_imag[113] data_out_imag[114] data_out_imag[115]
+ data_out_imag[116] data_out_imag[117] data_out_imag[118] data_out_imag[119]
+ data_out_imag[11] data_out_imag[120] data_out_imag[121] data_out_imag[122]
+ data_out_imag[123] data_out_imag[124] data_out_imag[125] data_out_imag[126]
+ data_out_imag[127] data_out_imag[12] data_out_imag[13] data_out_imag[14]
+ data_out_imag[15] data_out_imag[16] data_out_imag[17] data_out_imag[18]
+ data_out_imag[19] data_out_imag[1] data_out_imag[20] data_out_imag[21]
+ data_out_imag[22] data_out_imag[23] data_out_imag[24] data_out_imag[25]
+ data_out_imag[26] data_out_imag[27] data_out_imag[28] data_out_imag[29]
+ data_out_imag[2] data_out_imag[30] data_out_imag[31] data_out_imag[32]
+ data_out_imag[33] data_out_imag[34] data_out_imag[35] data_out_imag[36]
+ data_out_imag[37] data_out_imag[38] data_out_imag[39] data_out_imag[3]
+ data_out_imag[40] data_out_imag[41] data_out_imag[42] data_out_imag[43]
+ data_out_imag[44] data_out_imag[45] data_out_imag[46] data_out_imag[47]
+ data_out_imag[48] data_out_imag[49] data_out_imag[4] data_out_imag[50]
+ data_out_imag[51] data_out_imag[52] data_out_imag[53] data_out_imag[54]
+ data_out_imag[55] data_out_imag[56] data_out_imag[57] data_out_imag[58]
+ data_out_imag[59] data_out_imag[5] data_out_imag[60] data_out_imag[61]
+ data_out_imag[62] data_out_imag[63] data_out_imag[64] data_out_imag[65]
+ data_out_imag[66] data_out_imag[67] data_out_imag[68] data_out_imag[69]
+ data_out_imag[6] data_out_imag[70] data_out_imag[71] data_out_imag[72]
+ data_out_imag[73] data_out_imag[74] data_out_imag[75] data_out_imag[76]
+ data_out_imag[77] data_out_imag[78] data_out_imag[79] data_out_imag[7]
+ data_out_imag[80] data_out_imag[81] data_out_imag[82] data_out_imag[83]
+ data_out_imag[84] data_out_imag[85] data_out_imag[86] data_out_imag[87]
+ data_out_imag[88] data_out_imag[89] data_out_imag[8] data_out_imag[90]
+ data_out_imag[91] data_out_imag[92] data_out_imag[93] data_out_imag[94]
+ data_out_imag[95] data_out_imag[96] data_out_imag[97] data_out_imag[98]
+ data_out_imag[99] data_out_imag[9] data_out_real[0] data_out_real[100]
+ data_out_real[101] data_out_real[102] data_out_real[103] data_out_real[104]
+ data_out_real[105] data_out_real[106] data_out_real[107] data_out_real[108]
+ data_out_real[109] data_out_real[10] data_out_real[110] data_out_real[111]
+ data_out_real[112] data_out_real[113] data_out_real[114] data_out_real[115]
+ data_out_real[116] data_out_real[117] data_out_real[118] data_out_real[119]
+ data_out_real[11] data_out_real[120] data_out_real[121] data_out_real[122]
+ data_out_real[123] data_out_real[124] data_out_real[125] data_out_real[126]
+ data_out_real[127] data_out_real[12] data_out_real[13] data_out_real[14]
+ data_out_real[15] data_out_real[16] data_out_real[17] data_out_real[18]
+ data_out_real[19] data_out_real[1] data_out_real[20] data_out_real[21]
+ data_out_real[22] data_out_real[23] data_out_real[24] data_out_real[25]
+ data_out_real[26] data_out_real[27] data_out_real[28] data_out_real[29]
+ data_out_real[2] data_out_real[30] data_out_real[31] data_out_real[32]
+ data_out_real[33] data_out_real[34] data_out_real[35] data_out_real[36]
+ data_out_real[37] data_out_real[38] data_out_real[39] data_out_real[3]
+ data_out_real[40] data_out_real[41] data_out_real[42] data_out_real[43]
+ data_out_real[44] data_out_real[45] data_out_real[46] data_out_real[47]
+ data_out_real[48] data_out_real[49] data_out_real[4] data_out_real[50]
+ data_out_real[51] data_out_real[52] data_out_real[53] data_out_real[54]
+ data_out_real[55] data_out_real[56] data_out_real[57] data_out_real[58]
+ data_out_real[59] data_out_real[5] data_out_real[60] data_out_real[61]
+ data_out_real[62] data_out_real[63] data_out_real[64] data_out_real[65]
+ data_out_real[66] data_out_real[67] data_out_real[68] data_out_real[69]
+ data_out_real[6] data_out_real[70] data_out_real[71] data_out_real[72]
+ data_out_real[73] data_out_real[74] data_out_real[75] data_out_real[76]
+ data_out_real[77] data_out_real[78] data_out_real[79] data_out_real[7]
+ data_out_real[80] data_out_real[81] data_out_real[82] data_out_real[83]
+ data_out_real[84] data_out_real[85] data_out_real[86] data_out_real[87]
+ data_out_real[88] data_out_real[89] data_out_real[8] data_out_real[90]
+ data_out_real[91] data_out_real[92] data_out_real[93] data_out_real[94]
+ data_out_real[95] data_out_real[96] data_out_real[97] data_out_real[98]
+ data_out_real[99] data_out_real[9] data_ready data_valid_in
+ data_valid_out rst_n start
X_08341_ net93 VSS VSS VDD VDD _00557_ sky130_fd_sc_hd__inv_1
X_08342_ state\[3\] VSS VSS VDD VDD _00558_ sky130_fd_sc_hd__buf_8
X_08343_ _00558_ VSS VSS VDD VDD _00559_ sky130_fd_sc_hd__buf_6
X_08344_ _00559_ VSS VSS VDD VDD _00560_ sky130_fd_sc_hd__clkbuf_4
X_08345_ state\[0\] _00557_ _00560_ VSS VSS VDD VDD _00004_
+ sky130_fd_sc_hd__a21o_1
X_08346_ stage\[2\] VSS VSS VDD VDD _00561_ sky130_fd_sc_hd__buf_4
X_08347_ _00561_ _07805_ VSS VSS VDD VDD _07667_ sky130_fd_sc_hd__nor2b_4
X_08348_ _07667_ VSS VSS VDD VDD _07106_ sky130_fd_sc_hd__clkinv_8
X_08349_ _00561_ VSS VSS VDD VDD _00562_ sky130_fd_sc_hd__buf_6
X_08350_ _07809_ VSS VSS VDD VDD _00563_ sky130_fd_sc_hd__buf_6
X_08351_ _00562_ _00563_ VSS VSS VDD VDD _07166_ sky130_fd_sc_hd__nand2_8
X_08352_ _07166_ VSS VSS VDD VDD _07694_ sky130_fd_sc_hd__inv_1
X_08353_ _00562_ _07811_ VSS VSS VDD VDD _07153_ sky130_fd_sc_hd__nand2_8
X_08354_ _07153_ VSS VSS VDD VDD _07698_ sky130_fd_sc_hd__inv_1
X_08355_ _00561_ _07805_ VSS VSS VDD VDD _07133_ sky130_fd_sc_hd__nand2_8
X_08356_ _07133_ VSS VSS VDD VDD _07702_ sky130_fd_sc_hd__clkinv_2
X_08357_ _00562_ VSS VSS VDD VDD _07817_ sky130_fd_sc_hd__inv_4
X_08358_ _07817_ _00563_ VSS VSS VDD VDD _07112_ sky130_fd_sc_hd__nand2_8
X_08359_ _07112_ VSS VSS VDD VDD _07710_ sky130_fd_sc_hd__inv_1
X_08360_ _07817_ _07811_ VSS VSS VDD VDD _05892_ sky130_fd_sc_hd__nand2_8
X_08361_ _05892_ VSS VSS VDD VDD _05907_ sky130_fd_sc_hd__inv_1
X_08362_ _07824_ VSS VSS VDD VDD _00564_ sky130_fd_sc_hd__buf_4
X_08363_ _00564_ VSS VSS VDD VDD _00565_ sky130_fd_sc_hd__inv_6
X_08364_ _00565_ VSS VSS VDD VDD _00566_ sky130_fd_sc_hd__buf_4
X_08365_ _00566_ VSS VSS VDD VDD _00567_ sky130_fd_sc_hd__buf_4
X_08366_ _00567_ VSS VSS VDD VDD _00568_ sky130_fd_sc_hd__buf_6
X_08367_ _00568_ VSS VSS VDD VDD _00569_ sky130_fd_sc_hd__buf_4
X_08368_ _00569_ VSS VSS VDD VDD _07207_ sky130_fd_sc_hd__clkbuf_16
X_08369_ _07805_ _07811_ _00561_ VSS VSS VDD VDD _00570_ sky130_fd_sc_hd__o21ai_1
Xclone9 _00810_ VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_2
X_08371_ _07821_ _00563_ _00564_ VSS VSS VDD VDD _00572_ sky130_fd_sc_hd__nor3_2
X_08372_ _00570_ _00572_ VSS VSS VDD VDD _00573_ sky130_fd_sc_hd__nand2_1
X_08373_ _07706_ VSS VSS VDD VDD _07121_ sky130_fd_sc_hd__clkinv_16
X_08374_ butterfly_count\[2\] _07690_ _07799_ VSS VSS VDD
+ VDD _00574_ sky130_fd_sc_hd__nor3b_2
X_08375_ _00563_ _07811_ _00561_ VSS VSS VDD VDD _00575_ sky130_fd_sc_hd__o21ai_4
X_08376_ _00563_ _07805_ _00561_ VSS VSS VDD VDD _00576_ sky130_fd_sc_hd__mux2i_1
X_08377_ _07121_ _00574_ _00575_ _00576_ VSS VSS VDD VDD _00577_
+ sky130_fd_sc_hd__nand4_2
X_08378_ _07805_ _07811_ _00562_ VSS VSS VDD VDD _00578_ sky130_fd_sc_hd__o21bai_1
X_08379_ _07108_ _00578_ VSS VSS VDD VDD _00579_ sky130_fd_sc_hd__nand2_4
X_08380_ _00573_ _00577_ _00579_ VSS VSS VDD VDD _07109_ sky130_fd_sc_hd__a21oi_4
X_08381_ _07817_ _07110_ _07805_ _00572_ VSS VSS VDD VDD _07116_
+ sky130_fd_sc_hd__and4_1
X_08382_ _07532_ _07531_ _07550_ VSS VSS VDD VDD _00580_ sky130_fd_sc_hd__o21a_1
X_08383_ _00580_ _07549_ _07547_ VSS VSS VDD VDD _00581_ sky130_fd_sc_hd__o21a_1
X_08384_ _07546_ _00581_ _07544_ VSS VSS VDD VDD _00582_ sky130_fd_sc_hd__o21a_1
X_08385_ _07543_ _00582_ _07541_ VSS VSS VDD VDD _00583_ sky130_fd_sc_hd__o21a_1
X_08386_ _00583_ _07540_ _07538_ VSS VSS VDD VDD _00584_ sky130_fd_sc_hd__o21a_1
X_08387_ _07370_ _07369_ _07368_ VSS VSS VDD VDD _00585_ sky130_fd_sc_hd__o21a_1
X_08388_ _07367_ _00585_ _07365_ VSS VSS VDD VDD _00586_ sky130_fd_sc_hd__o21a_1
X_08389_ _07364_ _00586_ _07362_ VSS VSS VDD VDD _00587_ sky130_fd_sc_hd__o21a_1
X_08390_ _00587_ _07361_ _07359_ VSS VSS VDD VDD _00588_ sky130_fd_sc_hd__o21a_1
X_08391_ _07358_ _00588_ _07356_ VSS VSS VDD VDD _00589_ sky130_fd_sc_hd__o21a_1
X_08392_ _00589_ _07355_ VSS VSS VDD VDD _00590_ sky130_fd_sc_hd__nor2_4
X_08393_ _00590_ VSS VSS VDD VDD _00591_ sky130_fd_sc_hd__inv_2
X_08394_ _00591_ _07353_ _07352_ VSS VSS VDD VDD _00592_ sky130_fd_sc_hd__a21oi_4
X_08395_ _07690_ VSS VSS VDD VDD _00593_ sky130_fd_sc_hd__buf_6
X_08396_ _00593_ VSS VSS VDD VDD _00594_ sky130_fd_sc_hd__buf_6
X_08397_ _00592_ _00567_ _00594_ VSS VSS VDD VDD _00595_ sky130_fd_sc_hd__o21ai_4
X_08398_ _00564_ VSS VSS VDD VDD _00596_ sky130_fd_sc_hd__buf_4
X_08399_ _00596_ VSS VSS VDD VDD _00597_ sky130_fd_sc_hd__clkbuf_4
X_08400_ _00597_ VSS VSS VDD VDD _00598_ sky130_fd_sc_hd__buf_4
X_08401_ _00598_ VSS VSS VDD VDD _00599_ sky130_fd_sc_hd__buf_4
X_08402_ _00599_ _00592_ VSS VSS VDD VDD _00600_ sky130_fd_sc_hd__nor2_2
X_08403_ _07250_ _07249_ _07248_ VSS VSS VDD VDD _00601_ sky130_fd_sc_hd__o21a_1
X_08404_ _07247_ _00601_ _07245_ VSS VSS VDD VDD _00602_ sky130_fd_sc_hd__o21ai_2
X_08405_ _07244_ _00602_ VSS VSS VDD VDD _00603_ sky130_fd_sc_hd__nand2b_1
X_08406_ _07242_ _00603_ VSS VSS VDD VDD _00604_ sky130_fd_sc_hd__and2_0
X_08407_ _07241_ _00604_ _07239_ VSS VSS VDD VDD _00605_ sky130_fd_sc_hd__o21a_1
X_08408_ butterfly_count\[2\] _07690_ _07799_ VSS VSS VDD
+ VDD _00606_ sky130_fd_sc_hd__or3b_4
X_08409_ _07172_ _07175_ _07178_ VSS VSS VDD VDD _00607_ sky130_fd_sc_hd__nand3_2
X_08410_ _07169_ _07186_ _07181_ _07184_ VSS VSS VDD VDD _00608_
+ sky130_fd_sc_hd__nand4_2
X_08411_ _00606_ _00607_ _00608_ _00596_ VSS VSS VDD VDD _00609_
+ sky130_fd_sc_hd__o31ai_1
X_08412_ _07169_ _07168_ _00609_ VSS VSS VDD VDD _00610_ sky130_fd_sc_hd__nand3b_1
X_08413_ _00564_ _07168_ VSS VSS VDD VDD _00611_ sky130_fd_sc_hd__nand2b_1
X_08414_ _00606_ _00608_ _00607_ _00611_ VSS VSS VDD VDD _00612_
+ sky130_fd_sc_hd__o31ai_4
X_08415_ _07169_ _00612_ VSS VSS VDD VDD _00613_ sky130_fd_sc_hd__nand2_1
X_08416_ _07172_ _07175_ VSS VSS VDD VDD _00614_ sky130_fd_sc_hd__and2_4
X_08417_ _07186_ _07185_ _07184_ _07181_ VSS VSS VDD VDD _00615_
+ sky130_fd_sc_hd__o211ai_4
X_08418_ _07181_ _07183_ _07180_ VSS VSS VDD VDD _00616_ sky130_fd_sc_hd__a21oi_2
X_08419_ _00615_ _00616_ VSS VSS VDD VDD _00617_ sky130_fd_sc_hd__nand2_2
X_08420_ _07172_ _07174_ _00614_ _07177_ _07171_ VSS VSS VDD
+ VDD _00618_ sky130_fd_sc_hd__a221o_2
X_08421_ _07178_ _00614_ _00617_ _00618_ VSS VSS VDD VDD _00619_
+ sky130_fd_sc_hd__a31oi_4
X_08422_ _00610_ _00613_ _00619_ VSS VSS VDD VDD _00620_ sky130_fd_sc_hd__mux2i_4
X_08423_ _07805_ _00563_ _07811_ _00562_ VSS VSS VDD VDD _00621_
+ sky130_fd_sc_hd__o31a_1
X_08424_ _00564_ _00621_ VSS VSS VDD VDD _00622_ sky130_fd_sc_hd__nor2_2
X_08425_ _07132_ _07131_ _07130_ VSS VSS VDD VDD _00623_ sky130_fd_sc_hd__o21a_1
X_08426_ _07129_ _00623_ _07127_ VSS VSS VDD VDD _00624_ sky130_fd_sc_hd__o21a_1
X_08427_ _07126_ _00624_ _07124_ VSS VSS VDD VDD _00625_ sky130_fd_sc_hd__o21ai_1
X_08428_ _07124_ _07126_ _00624_ VSS VSS VDD VDD _00626_ sky130_fd_sc_hd__or3_1
X_08429_ _07123_ _00622_ _00625_ _00626_ VSS VSS VDD VDD _00627_
+ sky130_fd_sc_hd__nand4_4
X_08430_ _00570_ _00572_ VSS VSS VDD VDD _00628_ sky130_fd_sc_hd__and2_0
X_08431_ _07110_ _07106_ _00570_ _00572_ VSS VSS VDD VDD _00629_
+ sky130_fd_sc_hd__o211ai_2
X_08432_ _07111_ _07110_ VSS VSS VDD VDD _00630_ sky130_fd_sc_hd__nor2_1
X_08433_ _07107_ _07111_ VSS VSS VDD VDD _00631_ sky130_fd_sc_hd__nor2b_4
X_08434_ _07111_ _07110_ _07107_ VSS VSS VDD VDD _00632_ sky130_fd_sc_hd__and3b_1
X_08435_ _07108_ _00578_ _00630_ _00632_ _00631_ VSS VSS VDD
+ VDD _00633_ sky130_fd_sc_hd__a311oi_2
X_08436_ _00579_ _00628_ _00577_ _00633_ _00629_ VSS VSS VDD
+ VDD _07113_ sky130_fd_sc_hd__o32ai_4
X_08437_ _07120_ _07119_ _07115_ _07118_ VSS VSS VDD VDD _00634_
+ sky130_fd_sc_hd__o211a_1
X_08438_ _07117_ _07115_ _07114_ VSS VSS VDD VDD _00635_ sky130_fd_sc_hd__a21o_1
X_08439_ _07805_ _00563_ _07811_ _00562_ VSS VSS VDD VDD _00636_
+ sky130_fd_sc_hd__o31ai_4
X_08440_ _00634_ _00635_ _00565_ _00636_ VSS VSS VDD VDD _00637_
+ sky130_fd_sc_hd__o211a_4
X_08441_ _07118_ _07120_ _07115_ VSS VSS VDD VDD _00638_ sky130_fd_sc_hd__nand3_4
X_08442_ _00638_ _00606_ _07702_ _00575_ VSS VSS VDD VDD _00639_
+ sky130_fd_sc_hd__nor4b_4
X_08443_ _00639_ _00637_ _07121_ VSS VSS VDD VDD _00640_ sky130_fd_sc_hd__o21a_1
X_08444_ _07120_ _07119_ _07118_ VSS VSS VDD VDD _00641_ sky130_fd_sc_hd__o21a_1
X_08445_ _07117_ _07115_ _00641_ VSS VSS VDD VDD _00642_ sky130_fd_sc_hd__nor3_1
X_08446_ _07117_ _00641_ _07115_ VSS VSS VDD VDD _00643_ sky130_fd_sc_hd__o21a_1
X_08447_ _00639_ _00637_ _00642_ _00643_ _07121_ VSS VSS VDD
+ VDD _00644_ sky130_fd_sc_hd__o221ai_4
X_08448_ _07129_ _07126_ _07123_ VSS VSS VDD VDD _00645_ sky130_fd_sc_hd__or3_1
X_08449_ _07127_ _07123_ _07126_ VSS VSS VDD VDD _00646_ sky130_fd_sc_hd__or3_1
X_08450_ _07124_ _07123_ _00623_ _00645_ _00646_ VSS VSS VDD
+ VDD _00647_ sky130_fd_sc_hd__o221a_4
X_08451_ _00622_ _00647_ VSS VSS VDD VDD _00648_ sky130_fd_sc_hd__nand2_1
X_08452_ _07113_ _00640_ _00644_ _00648_ VSS VSS VDD VDD _00649_
+ sky130_fd_sc_hd__o211ai_4
X_08453_ _07169_ _07168_ _07178_ _07175_ _07172_ VSS VSS VDD
+ VDD _00650_ sky130_fd_sc_hd__o2111ai_1
X_08454_ _00615_ _00616_ _00564_ _00650_ VSS VSS VDD VDD _00651_
+ sky130_fd_sc_hd__a211oi_2
X_08455_ _07169_ _00565_ _00618_ _00612_ _00651_ VSS VSS VDD
+ VDD _00652_ sky130_fd_sc_hd__a311o_4
X_08456_ _00561_ _00563_ _00564_ VSS VSS VDD VDD _00653_ sky130_fd_sc_hd__a21oi_4
X_08457_ _07165_ _07164_ _07162_ VSS VSS VDD VDD _00654_ sky130_fd_sc_hd__o21a_1
X_08458_ _07149_ _07161_ _07164_ VSS VSS VDD VDD _00655_ sky130_fd_sc_hd__or3_1
X_08459_ _07152_ _07151_ _07150_ VSS VSS VDD VDD _00656_ sky130_fd_sc_hd__o21a_1
X_08460_ _07161_ _00654_ _00656_ _00655_ VSS VSS VDD VDD _00657_
+ sky130_fd_sc_hd__o22a_4
X_08461_ _07158_ _07156_ _07155_ VSS VSS VDD VDD _00658_ sky130_fd_sc_hd__a21oi_2
X_08462_ _00658_ _00653_ VSS VSS VDD VDD _00659_ sky130_fd_sc_hd__and2b_2
X_08463_ _00657_ _07159_ _00653_ _07156_ _00659_ VSS VSS VDD
+ VDD _00660_ sky130_fd_sc_hd__a41o_4
Xclone36 _00657_ _07159_ _00653_ _07156_ _00659_ VSS VSS VDD
+ VDD net36 sky130_fd_sc_hd__a41o_1
X_08465_ _07141_ _07142_ _07139_ VSS VSS VDD VDD _00662_ sky130_fd_sc_hd__o21a_1
X_08466_ _07147_ _07146_ _07145_ VSS VSS VDD VDD _00663_ sky130_fd_sc_hd__o21a_1
X_08467_ _07138_ _07144_ _07141_ VSS VSS VDD VDD _00664_ sky130_fd_sc_hd__or3_1
X_08468_ _07138_ _00662_ _00664_ _00663_ VSS VSS VDD VDD _00665_
+ sky130_fd_sc_hd__o22ai_2
X_08469_ _07136_ _00565_ _00575_ VSS VSS VDD VDD _00666_ sky130_fd_sc_hd__nand3_1
X_08470_ _07147_ _07136_ _07139_ _07142_ VSS VSS VDD VDD _00667_
+ sky130_fd_sc_hd__and4_1
X_08471_ _07145_ _00574_ _00575_ _00667_ VSS VSS VDD VDD _00668_
+ sky130_fd_sc_hd__nand4_1
X_08472_ _07135_ _00565_ _00575_ VSS VSS VDD VDD _00669_ sky130_fd_sc_hd__nand3_1
X_08473_ _00666_ _00665_ _00668_ _00669_ VSS VSS VDD VDD _00670_
+ sky130_fd_sc_hd__o211ai_2
X_08474_ _00652_ net36 _00670_ VSS VSS VDD VDD _00671_ sky130_fd_sc_hd__nor3_1
X_08475_ _00627_ _00649_ _00671_ VSS VSS VDD VDD _00672_ sky130_fd_sc_hd__a21boi_4
X_08476_ _07156_ _07159_ _00653_ _00657_ _00659_ VSS VSS VDD
+ VDD _00673_ sky130_fd_sc_hd__a41oi_4
X_08477_ _07136_ _00665_ VSS VSS VDD VDD _00674_ sky130_fd_sc_hd__xnor2_1
X_08478_ _00670_ VSS VSS VDD VDD _00675_ sky130_fd_sc_hd__buf_6
X_08479_ _00673_ _00674_ net6 VSS VSS VDD VDD _00676_ sky130_fd_sc_hd__nand3_2
X_08480_ _07155_ _00653_ VSS VSS VDD VDD _00677_ sky130_fd_sc_hd__nand2_1
X_08481_ _07156_ _00677_ VSS VSS VDD VDD _00678_ sky130_fd_sc_hd__nor2_1
X_08482_ _07156_ _07155_ _00653_ VSS VSS VDD VDD _00679_ sky130_fd_sc_hd__and3_1
X_08483_ _00657_ _07159_ _07158_ VSS VSS VDD VDD _00680_ sky130_fd_sc_hd__a21oi_2
X_08484_ _00678_ _00679_ _00680_ VSS VSS VDD VDD _00681_ sky130_fd_sc_hd__mux2i_4
X_08485_ _00676_ _00681_ _00652_ VSS VSS VDD VDD _00682_ sky130_fd_sc_hd__a21oi_4
X_08486_ _00620_ _00672_ _00682_ VSS VSS VDD VDD _00683_ sky130_fd_sc_hd__nor3_4
X_08487_ _00634_ _00635_ _00565_ _00636_ VSS VSS VDD VDD _00684_
+ sky130_fd_sc_hd__o211ai_4
X_08488_ _07121_ _07133_ _00574_ _00575_ VSS VSS VDD VDD _00685_
+ sky130_fd_sc_hd__nand4_1
X_08489_ _07706_ _00684_ _00638_ _00685_ _07116_ VSS VSS VDD
+ VDD _00686_ sky130_fd_sc_hd__o221ai_4
X_08490_ _07118_ _07120_ _07119_ VSS VSS VDD VDD _00687_ sky130_fd_sc_hd__nor3_1
X_08491_ _07706_ _00641_ _00687_ VSS VSS VDD VDD _00688_ sky130_fd_sc_hd__nor3_1
X_08492_ _00637_ _00639_ _00688_ VSS VSS VDD VDD _00689_ sky130_fd_sc_hd__o21ai_2
X_08493_ _00622_ _00647_ _00686_ _00689_ _00675_ VSS VSS VDD
+ VDD _00690_ sky130_fd_sc_hd__a221oi_2
X_08494_ _07124_ _07126_ _07123_ VSS VSS VDD VDD _00691_ sky130_fd_sc_hd__a21oi_1
X_08495_ _07127_ _07129_ _00623_ VSS VSS VDD VDD _00692_ sky130_fd_sc_hd__nor3_1
X_08496_ _00624_ _00691_ _00692_ _00622_ VSS VSS VDD VDD _00693_
+ sky130_fd_sc_hd__or4b_1
X_08497_ _07141_ _07144_ VSS VSS VDD VDD _00694_ sky130_fd_sc_hd__or2_0
X_08498_ _07142_ _07141_ _00663_ _00694_ VSS VSS VDD VDD _00695_
+ sky130_fd_sc_hd__o22ai_1
X_08499_ _07139_ _00695_ VSS VSS VDD VDD _00696_ sky130_fd_sc_hd__xor2_1
X_08500_ _00693_ _00696_ net6 VSS VSS VDD VDD _00697_ sky130_fd_sc_hd__mux2i_4
X_08501_ _00652_ VSS VSS VDD VDD _00698_ sky130_fd_sc_hd__buf_6
X_08502_ _07206_ _07205_ _07204_ _07201_ VSS VSS VDD VDD _00699_
+ sky130_fd_sc_hd__o211ai_2
X_08503_ _07201_ _07203_ _07200_ VSS VSS VDD VDD _00700_ sky130_fd_sc_hd__a21oi_2
X_08504_ _07195_ _07192_ _07198_ _07189_ VSS VSS VDD VDD _00701_
+ sky130_fd_sc_hd__nand4_4
X_08505_ _00699_ _00700_ _00701_ VSS VSS VDD VDD _00702_ sky130_fd_sc_hd__a21o_1
X_08506_ _07189_ _07192_ _07194_ VSS VSS VDD VDD _00703_ sky130_fd_sc_hd__nand3_1
X_08507_ _07189_ _07191_ _07188_ VSS VSS VDD VDD _00704_ sky130_fd_sc_hd__a21oi_2
X_08508_ _07189_ _07192_ _07195_ _07197_ VSS VSS VDD VDD _00705_
+ sky130_fd_sc_hd__nand4_4
X_08509_ _00703_ _00704_ _00705_ VSS VSS VDD VDD _00706_ sky130_fd_sc_hd__and3_4
X_08510_ _00702_ _00706_ _07690_ VSS VSS VDD VDD _00707_ sky130_fd_sc_hd__a21oi_4
X_08511_ net26 net36 _00707_ VSS VSS VDD VDD _00708_ sky130_fd_sc_hd__nor3_1
X_08512_ _00690_ _00697_ _00708_ VSS VSS VDD VDD _00709_ sky130_fd_sc_hd__o21ai_1
X_08513_ _00618_ _00565_ _07169_ _00612_ _00651_ VSS VSS VDD
+ VDD _00710_ sky130_fd_sc_hd__a311oi_4
X_08514_ _07175_ _07177_ VSS VSS VDD VDD _00711_ sky130_fd_sc_hd__and2_0
X_08515_ _07175_ _07178_ VSS VSS VDD VDD _00712_ sky130_fd_sc_hd__nand2_1
X_08516_ _00615_ _00616_ _00712_ VSS VSS VDD VDD _00713_ sky130_fd_sc_hd__a21oi_1
X_08517_ _07174_ _00711_ _00713_ _07172_ VSS VSS VDD VDD _00714_
+ sky130_fd_sc_hd__o31a_1
X_08518_ _07172_ _07174_ _00711_ _00713_ VSS VSS VDD VDD _00715_
+ sky130_fd_sc_hd__nor4_1
X_08519_ _00710_ _00714_ _00715_ VSS VSS VDD VDD _00716_ sky130_fd_sc_hd__nor3_2
X_08520_ _07159_ _00657_ VSS VSS VDD VDD _00717_ sky130_fd_sc_hd__xor2_1
X_08521_ _00710_ net36 _00717_ VSS VSS VDD VDD _00718_ sky130_fd_sc_hd__and3_1
X_08522_ _07192_ _07195_ _07198_ VSS VSS VDD VDD _00719_ sky130_fd_sc_hd__nand3_1
X_08523_ _00699_ _00700_ _00719_ VSS VSS VDD VDD _00720_ sky130_fd_sc_hd__a21oi_1
X_08524_ _07195_ _07197_ _07194_ VSS VSS VDD VDD _00721_ sky130_fd_sc_hd__a21oi_1
X_08525_ _00721_ _07192_ VSS VSS VDD VDD _00722_ sky130_fd_sc_hd__nor2b_1
X_08526_ _07191_ _00720_ _00722_ _07189_ VSS VSS VDD VDD _00723_
+ sky130_fd_sc_hd__o31a_1
X_08527_ _07189_ _07191_ _00720_ _00722_ VSS VSS VDD VDD _00724_
+ sky130_fd_sc_hd__nor4_1
X_08528_ _00723_ _00724_ _00707_ VSS VSS VDD VDD _00725_ sky130_fd_sc_hd__o21ai_0
X_08529_ _00707_ _00716_ _00718_ _00725_ VSS VSS VDD VDD _00726_
+ sky130_fd_sc_hd__o31ai_1
X_08530_ _07230_ _07229_ _07228_ VSS VSS VDD VDD _00727_ sky130_fd_sc_hd__o21ai_2
X_08531_ _07224_ _07227_ VSS VSS VDD VDD _00728_ sky130_fd_sc_hd__nor2_1
X_08532_ _07225_ _07224_ VSS VSS VDD VDD _00729_ sky130_fd_sc_hd__nor2_2
X_08533_ _07216_ _07219_ _07222_ VSS VSS VDD VDD _00730_ sky130_fd_sc_hd__nand3_1
X_08534_ _00727_ _00728_ _00729_ _00730_ VSS VSS VDD VDD _00731_
+ sky130_fd_sc_hd__a211oi_4
X_08535_ _07219_ _07221_ _07218_ VSS VSS VDD VDD _00732_ sky130_fd_sc_hd__a21o_1
X_08536_ _00732_ _07216_ _07215_ VSS VSS VDD VDD _00733_ sky130_fd_sc_hd__a21o_1
X_08537_ _07213_ _07212_ _07210_ VSS VSS VDD VDD _00734_ sky130_fd_sc_hd__o21ai_0
X_08538_ _07209_ _00734_ VSS VSS VDD VDD _00735_ sky130_fd_sc_hd__or2b_1
X_08539_ _07209_ _07212_ _00733_ _00731_ _00735_ VSS VSS VDD
+ VDD _00736_ sky130_fd_sc_hd__o41ai_4
X_08540_ _00709_ _00726_ _00736_ VSS VSS VDD VDD _00737_ sky130_fd_sc_hd__a21boi_1
X_08541_ _00610_ _00613_ _00619_ VSS VSS VDD VDD _00738_ sky130_fd_sc_hd__mux2_2
X_08542_ _00670_ _00660_ VSS VSS VDD VDD _00739_ sky130_fd_sc_hd__or2_4
X_08543_ _00627_ _00649_ _00739_ _00698_ VSS VSS VDD VDD _00740_
+ sky130_fd_sc_hd__a211o_2
X_08544_ _00676_ _00681_ _00698_ VSS VSS VDD VDD _00741_ sky130_fd_sc_hd__a21o_1
X_08545_ _07213_ _07216_ _07219_ _07222_ VSS VSS VDD VDD _00742_
+ sky130_fd_sc_hd__and4_1
X_08546_ _00727_ _00728_ _00729_ VSS VSS VDD VDD _00743_ sky130_fd_sc_hd__a21oi_2
X_08547_ _07213_ _00733_ _00742_ _00743_ _07212_ VSS VSS VDD
+ VDD _00744_ sky130_fd_sc_hd__a221oi_1
X_08548_ _07210_ _00744_ VSS VSS VDD VDD _00745_ sky130_fd_sc_hd__xor2_1
X_08549_ _07690_ VSS VSS VDD VDD _00746_ sky130_fd_sc_hd__clkinv_8
X_08550_ _00702_ _00706_ _00746_ VSS VSS VDD VDD _00747_ sky130_fd_sc_hd__a21oi_2
X_08551_ _07690_ _00596_ VSS VSS VDD VDD _00748_ sky130_fd_sc_hd__nor2_4
X_08552_ _00702_ _00706_ _00748_ VSS VSS VDD VDD _00749_ sky130_fd_sc_hd__and3_1
X_08553_ _00747_ _00749_ VSS VSS VDD VDD _00750_ sky130_fd_sc_hd__or2_1
X_08554_ _00747_ _00749_ _00736_ VSS VSS VDD VDD _00751_ sky130_fd_sc_hd__o21a_1
X_08555_ _00723_ _00724_ VSS VSS VDD VDD _00752_ sky130_fd_sc_hd__nor2_1
X_08556_ _00745_ _00750_ _00751_ _00752_ VSS VSS VDD VDD _00753_
+ sky130_fd_sc_hd__a2bb2oi_1
X_08557_ _00738_ _00740_ _00741_ _00753_ VSS VSS VDD VDD _00754_
+ sky130_fd_sc_hd__a31oi_2
X_08558_ _00736_ _00745_ VSS VSS VDD VDD _00755_ sky130_fd_sc_hd__nor2_1
X_08559_ _00683_ _00737_ _00754_ _00755_ VSS VSS VDD VDD _00756_
+ sky130_fd_sc_hd__a211oi_4
X_08560_ _00603_ _07236_ _07239_ _07242_ VSS VSS VDD VDD _00757_
+ sky130_fd_sc_hd__and4_4
X_08561_ _07236_ _07239_ _07241_ VSS VSS VDD VDD _00758_ sky130_fd_sc_hd__nand3_1
X_08562_ _07236_ _07238_ VSS VSS VDD VDD _00759_ sky130_fd_sc_hd__nand2_1
X_08563_ _00758_ _00759_ VSS VSS VDD VDD _00760_ sky130_fd_sc_hd__nand2_1
X_08564_ _07235_ _00760_ _00757_ VSS VSS VDD VDD _00761_ sky130_fd_sc_hd__or3_4
X_08565_ _00761_ _07233_ _07232_ VSS VSS VDD VDD _00762_ sky130_fd_sc_hd__a21oi_4
X_08566_ _00596_ _00762_ VSS VSS VDD VDD _00763_ sky130_fd_sc_hd__nor2_2
X_08567_ _00565_ _00762_ _07690_ VSS VSS VDD VDD _00764_ sky130_fd_sc_hd__o21ai_2
X_08568_ _07706_ _07120_ _00684_ VSS VSS VDD VDD _07128_ sky130_fd_sc_hd__nor3_4
X_08569_ _07132_ _07130_ _07131_ VSS VSS VDD VDD _00765_ sky130_fd_sc_hd__nor3_1
X_08570_ _00564_ _00621_ _00623_ _00765_ VSS VSS VDD VDD _00766_
+ sky130_fd_sc_hd__nor4_1
X_08571_ _07128_ _00766_ _00647_ VSS VSS VDD VDD _00767_ sky130_fd_sc_hd__mux2i_4
X_08572_ _07149_ _00656_ _07165_ VSS VSS VDD VDD _00768_ sky130_fd_sc_hd__o21ai_1
X_08573_ _07164_ _00768_ VSS VSS VDD VDD _00769_ sky130_fd_sc_hd__or2b_1
X_08574_ _07162_ _00769_ VSS VSS VDD VDD _00770_ sky130_fd_sc_hd__xnor2_1
X_08575_ _07144_ _00663_ VSS VSS VDD VDD _00771_ sky130_fd_sc_hd__nor2_1
X_08576_ _07142_ _00771_ VSS VSS VDD VDD _00772_ sky130_fd_sc_hd__xnor2_1
X_08577_ _00673_ net6 _00772_ VSS VSS VDD VDD _00773_ sky130_fd_sc_hd__nand3_1
X_08578_ _00767_ _00739_ _00770_ _00673_ _00773_ VSS VSS VDD
+ VDD _07173_ sky130_fd_sc_hd__o221ai_4
X_08579_ _07178_ _00617_ _07177_ _07175_ VSS VSS VDD VDD _00774_
+ sky130_fd_sc_hd__a211oi_1
X_08580_ _00711_ _00713_ _00774_ _00652_ VSS VSS VDD VDD _00775_
+ sky130_fd_sc_hd__o31a_1
X_08581_ _00707_ _00775_ VSS VSS VDD VDD _00776_ sky130_fd_sc_hd__nor2_1
X_08582_ _00699_ _00700_ _00701_ VSS VSS VDD VDD _00777_ sky130_fd_sc_hd__a21oi_4
X_08583_ _00703_ _00704_ _00705_ VSS VSS VDD VDD _00778_ sky130_fd_sc_hd__nand3_2
X_08584_ _00778_ _00777_ _00746_ VSS VSS VDD VDD _00779_ sky130_fd_sc_hd__o21ai_4
X_08585_ _07206_ _07205_ _07204_ _07201_ VSS VSS VDD VDD _00780_
+ sky130_fd_sc_hd__o211a_1
X_08586_ _07201_ _07203_ _07200_ VSS VSS VDD VDD _00781_ sky130_fd_sc_hd__a21o_1
X_08587_ _00780_ _00781_ _07198_ VSS VSS VDD VDD _00782_ sky130_fd_sc_hd__o21ai_0
X_08588_ _07192_ _07194_ _07197_ VSS VSS VDD VDD _00783_ sky130_fd_sc_hd__nor3_1
X_08589_ _00782_ _00783_ _00722_ _00720_ VSS VSS VDD VDD _00784_
+ sky130_fd_sc_hd__a211oi_2
X_08590_ _07192_ _07195_ _07194_ VSS VSS VDD VDD _00785_ sky130_fd_sc_hd__or3_1
X_08591_ _00784_ _00785_ VSS VSS VDD VDD _00786_ sky130_fd_sc_hd__nand2_2
X_08592_ _00779_ _00786_ VSS VSS VDD VDD _00787_ sky130_fd_sc_hd__nor2_2
X_08593_ net26 _00707_ _07173_ _00776_ _00787_ VSS VSS VDD
+ VDD _00788_ sky130_fd_sc_hd__o32ai_4
X_08594_ _00731_ _00733_ VSS VSS VDD VDD _00789_ sky130_fd_sc_hd__nor2_1
X_08595_ _07213_ _00789_ VSS VSS VDD VDD _00790_ sky130_fd_sc_hd__xnor2_2
X_08596_ _00565_ _00747_ _00784_ _00785_ VSS VSS VDD VDD _00791_
+ sky130_fd_sc_hd__o211ai_1
X_08597_ _00750_ _00790_ _00791_ _00751_ VSS VSS VDD VDD _00792_
+ sky130_fd_sc_hd__a2bb2oi_1
X_08598_ _00738_ _00740_ _00741_ _00792_ VSS VSS VDD VDD _00793_
+ sky130_fd_sc_hd__a31oi_2
X_08599_ _00736_ _00790_ VSS VSS VDD VDD _00794_ sky130_fd_sc_hd__nor2_1
X_08600_ _00736_ _00683_ _00788_ _00793_ _00794_ VSS VSS VDD
+ VDD _00795_ sky130_fd_sc_hd__a311oi_4
X_08601_ _00763_ _00764_ _00795_ VSS VSS VDD VDD _00796_ sky130_fd_sc_hd__mux2i_4
X_08602_ _00738_ _00740_ _00741_ VSS VSS VDD VDD _00797_ sky130_fd_sc_hd__nand3_2
X_08603_ _00627_ _00649_ _00739_ _00786_ net26 VSS VSS VDD
+ VDD _00798_ sky130_fd_sc_hd__a2111oi_0
X_08604_ _00676_ _00681_ _00786_ net26 VSS VSS VDD VDD _00799_
+ sky130_fd_sc_hd__a211oi_1
X_08605_ _00738_ _00786_ VSS VSS VDD VDD _00800_ sky130_fd_sc_hd__nor2_1
X_08606_ _00596_ _00798_ _00799_ _00800_ VSS VSS VDD VDD _00801_
+ sky130_fd_sc_hd__nor4_1
X_08607_ _00797_ _00788_ _00801_ VSS VSS VDD VDD _00802_ sky130_fd_sc_hd__o21ai_0
X_08608_ _00736_ _00750_ VSS VSS VDD VDD _00803_ sky130_fd_sc_hd__nor2_1
X_08609_ _00620_ _00672_ _00682_ _00803_ VSS VSS VDD VDD _00804_
+ sky130_fd_sc_hd__o31a_1
X_08610_ _00804_ VSS VSS VDD VDD _00805_ sky130_fd_sc_hd__buf_4
X_08611_ _00596_ _00683_ _00787_ _00805_ VSS VSS VDD VDD _00806_
+ sky130_fd_sc_hd__a31oi_1
X_08612_ _00738_ net26 _00750_ VSS VSS VDD VDD _00807_ sky130_fd_sc_hd__a21o_1
X_08613_ _00738_ _00736_ _00676_ _00681_ VSS VSS VDD VDD _00808_
+ sky130_fd_sc_hd__nand4_1
X_08614_ _00627_ _00649_ _00739_ VSS VSS VDD VDD _00809_ sky130_fd_sc_hd__a21oi_1
X_08615_ _00736_ _00807_ _00809_ _00808_ VSS VSS VDD VDD _00810_
+ sky130_fd_sc_hd__o2bb2ai_4
X_08616_ butterfly_count\[2\] VSS VSS VDD VDD _00811_ sky130_fd_sc_hd__inv_1
X_08617_ _00811_ _07799_ VSS VSS VDD VDD _00812_ sky130_fd_sc_hd__nand2_4
X_08618_ _07242_ _07236_ _07239_ _07245_ VSS VSS VDD VDD _00813_
+ sky130_fd_sc_hd__nand4_1
X_08619_ _07248_ _07250_ _07233_ VSS VSS VDD VDD _00814_ sky130_fd_sc_hd__nand3_1
X_08620_ _00812_ _00813_ _00814_ VSS VSS VDD VDD _00815_ sky130_fd_sc_hd__nor3_2
X_08621_ _00810_ _00815_ _00805_ VSS VSS VDD VDD _00816_ sky130_fd_sc_hd__a21oi_1
X_08622_ _00802_ _00806_ _00816_ VSS VSS VDD VDD _00817_ sky130_fd_sc_hd__a21o_2
X_08623_ _00756_ _00817_ _00796_ VSS VSS VDD VDD _00818_ sky130_fd_sc_hd__and3_4
X_08624_ _00818_ VSS VSS VDD VDD _00819_ sky130_fd_sc_hd__buf_8
X_08625_ _00819_ VSS VSS VDD VDD _00820_ sky130_fd_sc_hd__buf_8
X_08626_ _07239_ _07241_ _00604_ VSS VSS VDD VDD _00821_ sky130_fd_sc_hd__nor3_1
X_08627_ _00810_ VSS VSS VDD VDD _00822_ sky130_fd_sc_hd__buf_6
X_08628_ _07222_ _00743_ VSS VSS VDD VDD _00823_ sky130_fd_sc_hd__xnor2_1
X_08629_ _00620_ _00672_ _00682_ _00565_ VSS VSS VDD VDD _00824_
+ sky130_fd_sc_hd__o31ai_2
X_08630_ _00797_ _00779_ _00824_ VSS VSS VDD VDD _00825_ sky130_fd_sc_hd__o21ai_2
X_08631_ _07206_ _07205_ _07204_ VSS VSS VDD VDD _00826_ sky130_fd_sc_hd__o21a_1
X_08632_ _07203_ _00826_ VSS VSS VDD VDD _00827_ sky130_fd_sc_hd__nor2_1
X_08633_ _07201_ _00827_ VSS VSS VDD VDD _00828_ sky130_fd_sc_hd__xor2_1
X_08634_ _07186_ _07185_ _07184_ VSS VSS VDD VDD _00829_ sky130_fd_sc_hd__o21a_1
X_08635_ _07186_ _07184_ _07185_ VSS VSS VDD VDD _00830_ sky130_fd_sc_hd__nor3_1
X_08636_ _07152_ _00673_ VSS VSS VDD VDD _07182_ sky130_fd_sc_hd__nor2_1
X_08637_ _00710_ _07182_ VSS VSS VDD VDD _00831_ sky130_fd_sc_hd__nand2_1
X_08638_ _00829_ _00710_ _00830_ _00831_ VSS VSS VDD VDD _07199_
+ sky130_fd_sc_hd__o31ai_1
X_08639_ _00825_ _07199_ VSS VSS VDD VDD _00832_ sky130_fd_sc_hd__nor2_1
X_08640_ _00825_ _00828_ _00832_ VSS VSS VDD VDD _07220_ sky130_fd_sc_hd__a21oi_1
X_08641_ _00822_ _07220_ VSS VSS VDD VDD _00833_ sky130_fd_sc_hd__nand2_1
X_08642_ _00822_ _00823_ _00833_ VSS VSS VDD VDD _07237_ sky130_fd_sc_hd__o21ai_1
X_08643_ net30 _07237_ VSS VSS VDD VDD _00834_ sky130_fd_sc_hd__nand2_2
X_08644_ _00605_ _00820_ _00821_ _00834_ VSS VSS VDD VDD _07254_
+ sky130_fd_sc_hd__o31ai_4
Xclone8 _02255_ VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_2
X_08646_ _07259_ _07269_ _07258_ VSS VSS VDD VDD _00836_ sky130_fd_sc_hd__a21o_1
X_08647_ _07247_ _00601_ VSS VSS VDD VDD _00837_ sky130_fd_sc_hd__nor2_1
X_08648_ _07245_ _00837_ VSS VSS VDD VDD _00838_ sky130_fd_sc_hd__xnor2_1
X_08649_ _07230_ _07229_ _07228_ VSS VSS VDD VDD _00839_ sky130_fd_sc_hd__o21a_1
X_08650_ _07228_ _07230_ _07229_ VSS VSS VDD VDD _00840_ sky130_fd_sc_hd__nor3_1
X_08651_ _00839_ _00840_ VSS VSS VDD VDD _00841_ sky130_fd_sc_hd__nor2_1
X_08652_ _00738_ _00740_ _00741_ _00596_ VSS VSS VDD VDD _00842_
+ sky130_fd_sc_hd__a31oi_2
X_08653_ _00620_ _00672_ _00779_ _00682_ VSS VSS VDD VDD _00843_
+ sky130_fd_sc_hd__nor4_4
X_08654_ _00843_ _00842_ VSS VSS VDD VDD _00844_ sky130_fd_sc_hd__nor2_4
X_08655_ _07206_ _00844_ VSS VSS VDD VDD _07226_ sky130_fd_sc_hd__nor2_1
X_08656_ _00841_ _07226_ _00822_ VSS VSS VDD VDD _07243_ sky130_fd_sc_hd__mux2_4
X_08657_ _00838_ _07243_ _00820_ VSS VSS VDD VDD _07268_ sky130_fd_sc_hd__mux2_4
X_08658_ _07821_ _07268_ VSS VSS VDD VDD _00845_ sky130_fd_sc_hd__xor2_1
X_08659_ _07267_ _07266_ _07265_ VSS VSS VDD VDD _00846_ sky130_fd_sc_hd__o21a_1
X_08660_ _07264_ _00846_ _07262_ VSS VSS VDD VDD _00847_ sky130_fd_sc_hd__o21ai_4
X_08661_ _07261_ _00847_ VSS VSS VDD VDD _00848_ sky130_fd_sc_hd__nand2b_1
X_08662_ _07259_ _00848_ VSS VSS VDD VDD _00849_ sky130_fd_sc_hd__nand2_1
X_08663_ _00845_ _00849_ VSS VSS VDD VDD _00850_ sky130_fd_sc_hd__nor2_1
X_08664_ _07269_ _00848_ _07259_ VSS VSS VDD VDD _00851_ sky130_fd_sc_hd__o21a_1
X_08665_ _07258_ _00851_ _07256_ VSS VSS VDD VDD _00852_ sky130_fd_sc_hd__o21ai_0
X_08666_ _07258_ _07269_ _00845_ VSS VSS VDD VDD _00853_ sky130_fd_sc_hd__nor3b_1
X_08667_ _07256_ _00836_ _00850_ _00852_ _00853_ VSS VSS VDD
+ VDD _00854_ sky130_fd_sc_hd__o32a_1
X_08668_ _07253_ VSS VSS VDD VDD _00855_ sky130_fd_sc_hd__buf_6
X_08669_ _00855_ _07252_ VSS VSS VDD VDD _00856_ sky130_fd_sc_hd__nor2_1
X_08670_ _07235_ _00757_ _00760_ VSS VSS VDD VDD _00857_ sky130_fd_sc_hd__nor3_1
X_08671_ _07233_ _00857_ VSS VSS VDD VDD _00858_ sky130_fd_sc_hd__xnor2_2
X_08672_ _00597_ _00856_ _00858_ VSS VSS VDD VDD _00859_ sky130_fd_sc_hd__or3_1
X_08673_ _00856_ _00858_ _00597_ VSS VSS VDD VDD _00860_ sky130_fd_sc_hd__nand3b_1
X_08674_ _00859_ _00860_ net31 VSS VSS VDD VDD _00861_ sky130_fd_sc_hd__a21o_1
X_08675_ _07222_ _00743_ _07221_ VSS VSS VDD VDD _00862_ sky130_fd_sc_hd__a21o_1
X_08676_ _07219_ _00862_ _07218_ VSS VSS VDD VDD _00863_ sky130_fd_sc_hd__a21oi_1
X_08677_ _07216_ _00863_ VSS VSS VDD VDD _00864_ sky130_fd_sc_hd__xnor2_1
X_08678_ net9 _00864_ VSS VSS VDD VDD _00865_ sky130_fd_sc_hd__nor2_1
X_08679_ _00865_ VSS VSS VDD VDD _00866_ sky130_fd_sc_hd__inv_1
X_08680_ _00699_ _00700_ _07198_ VSS VSS VDD VDD _00867_ sky130_fd_sc_hd__a21boi_2
X_08681_ _07197_ _00867_ VSS VSS VDD VDD _00868_ sky130_fd_sc_hd__nor2_1
X_08682_ _07195_ _00868_ VSS VSS VDD VDD _00869_ sky130_fd_sc_hd__xnor2_2
X_08683_ _07132_ _00622_ _00647_ VSS VSS VDD VDD _00870_ sky130_fd_sc_hd__nand3b_4
X_08684_ _07147_ _07145_ _07146_ VSS VSS VDD VDD _00871_ sky130_fd_sc_hd__nor3_1
X_08685_ _00663_ _00871_ VSS VSS VDD VDD _00872_ sky130_fd_sc_hd__or2_0
X_08686_ _00870_ _00872_ _00675_ VSS VSS VDD VDD _07163_ sky130_fd_sc_hd__mux2i_4
X_08687_ _07178_ _00617_ VSS VSS VDD VDD _00873_ sky130_fd_sc_hd__xnor2_1
X_08688_ _00873_ _00710_ VSS VSS VDD VDD _00874_ sky130_fd_sc_hd__nor2_1
X_08689_ _07165_ _07149_ _00656_ VSS VSS VDD VDD _00875_ sky130_fd_sc_hd__or3_1
X_08690_ _00768_ _00875_ VSS VSS VDD VDD _00876_ sky130_fd_sc_hd__nand2_1
X_08691_ _00698_ _00673_ _00876_ VSS VSS VDD VDD _00877_ sky130_fd_sc_hd__nor3_2
X_08692_ _00710_ _00673_ _07163_ _00877_ _00874_ VSS VSS VDD
+ VDD _07193_ sky130_fd_sc_hd__a311o_1
X_08693_ _00593_ _07193_ VSS VSS VDD VDD _00878_ sky130_fd_sc_hd__nand2_1
X_08694_ _00747_ _00869_ VSS VSS VDD VDD _00879_ sky130_fd_sc_hd__nand2_1
X_08695_ _00878_ _00879_ _00797_ VSS VSS VDD VDD _00880_ sky130_fd_sc_hd__mux2i_2
X_08696_ _00777_ _00778_ VSS VSS VDD VDD _00881_ sky130_fd_sc_hd__nor2_1
X_08697_ _00881_ _00824_ _07193_ VSS VSS VDD VDD _00882_ sky130_fd_sc_hd__and3_1
X_08698_ _00822_ VSS VSS VDD VDD _00883_ sky130_fd_sc_hd__inv_2
X_08699_ _00869_ _00825_ _00880_ _00882_ _00883_ VSS VSS VDD
+ VDD _00884_ sky130_fd_sc_hd__a2111o_1
X_08700_ _00866_ _00884_ _00597_ _00856_ VSS VSS VDD VDD _00885_
+ sky130_fd_sc_hd__a211oi_1
X_08701_ _00566_ _00856_ _00865_ _00884_ VSS VSS VDD VDD _00886_
+ sky130_fd_sc_hd__nor4b_1
X_08702_ _00885_ _00886_ net31 VSS VSS VDD VDD _00887_ sky130_fd_sc_hd__o21ai_1
X_08703_ _00861_ _00887_ VSS VSS VDD VDD _00888_ sky130_fd_sc_hd__nand2_4
X_08704_ _07256_ _07259_ VSS VSS VDD VDD _00889_ sky130_fd_sc_hd__nand2_4
X_08705_ _00889_ _07206_ _07821_ VSS VSS VDD VDD _00890_ sky130_fd_sc_hd__nor3b_2
X_08706_ _00842_ _00843_ _00890_ _00810_ VSS VSS VDD VDD _00891_
+ sky130_fd_sc_hd__o211ai_2
X_08707_ _07821_ _00889_ VSS VSS VDD VDD _00892_ sky130_fd_sc_hd__nor2_4
X_08708_ _00797_ _00779_ _00810_ _00824_ _00892_ VSS VSS VDD
+ VDD _00893_ sky130_fd_sc_hd__o2111ai_1
X_08709_ _07821_ _00841_ VSS VSS VDD VDD _00894_ sky130_fd_sc_hd__xnor2_1
X_08710_ _07256_ _07259_ _00894_ VSS VSS VDD VDD _00895_ sky130_fd_sc_hd__nand3_1
X_08711_ _07206_ _00892_ VSS VSS VDD VDD _00896_ sky130_fd_sc_hd__nand2_1
X_08712_ _00895_ _00896_ _00810_ VSS VSS VDD VDD _00897_ sky130_fd_sc_hd__mux2_4
X_08713_ _00891_ _00893_ _00897_ VSS VSS VDD VDD _00898_ sky130_fd_sc_hd__nand3_4
X_08714_ _00756_ _00796_ _00898_ _00817_ VSS VSS VDD VDD _00899_
+ sky130_fd_sc_hd__nand4_4
X_08715_ _07821_ _00838_ VSS VSS VDD VDD _00900_ sky130_fd_sc_hd__xor2_1
X_08716_ _00847_ _00889_ _00900_ VSS VSS VDD VDD _00901_ sky130_fd_sc_hd__or3_1
X_08717_ _07270_ _07261_ _07269_ VSS VSS VDD VDD _00902_ sky130_fd_sc_hd__a21o_1
X_08718_ _07259_ _00902_ _07258_ VSS VSS VDD VDD _00903_ sky130_fd_sc_hd__a21o_1
X_08719_ _07256_ _00903_ _07255_ VSS VSS VDD VDD _00904_ sky130_fd_sc_hd__a21oi_2
X_08720_ _00899_ _00847_ _00901_ _00819_ _00904_ VSS VSS VDD
+ VDD _00905_ sky130_fd_sc_hd__o221ai_4
X_08721_ _00905_ _07252_ VSS VSS VDD VDD _00906_ sky130_fd_sc_hd__or2_4
Xclone10 _01172_ _01231_ _01245_ _01237_ VSS VSS VDD VDD net10
+ sky130_fd_sc_hd__a22oi_4
X_08723_ _00866_ _00884_ VSS VSS VDD VDD _07231_ sky130_fd_sc_hd__and2_1
X_08724_ _00858_ _07231_ _00819_ VSS VSS VDD VDD _00908_ sky130_fd_sc_hd__mux2i_4
X_08725_ _00855_ _07262_ VSS VSS VDD VDD _00909_ sky130_fd_sc_hd__nand2_1
X_08726_ _00812_ _00909_ VSS VSS VDD VDD _00910_ sky130_fd_sc_hd__nor2_1
X_08727_ _07265_ _07267_ _00910_ VSS VSS VDD VDD _00911_ sky130_fd_sc_hd__nand3_2
X_08728_ _00882_ _00880_ VSS VSS VDD VDD _00912_ sky130_fd_sc_hd__nor2_1
X_08729_ _00597_ _00883_ VSS VSS VDD VDD _00913_ sky130_fd_sc_hd__nor2_1
X_08730_ _00596_ net9 _00869_ VSS VSS VDD VDD _00914_ sky130_fd_sc_hd__nand3_1
X_08731_ _00597_ _00864_ VSS VSS VDD VDD _00915_ sky130_fd_sc_hd__nand2_1
X_08732_ _00596_ _00810_ _00864_ VSS VSS VDD VDD _00916_ sky130_fd_sc_hd__or3_1
X_08733_ _00844_ _00914_ _00915_ net9 _00916_ VSS VSS VDD
+ VDD _00917_ sky130_fd_sc_hd__o221ai_1
X_08734_ _00596_ _00869_ VSS VSS VDD VDD _00918_ sky130_fd_sc_hd__nor2_1
X_08735_ net9 _00918_ VSS VSS VDD VDD _00919_ sky130_fd_sc_hd__nand2_1
X_08736_ _00882_ _00880_ _00919_ VSS VSS VDD VDD _00920_ sky130_fd_sc_hd__nor3_1
X_08737_ _00844_ _00912_ _00913_ _00917_ _00920_ VSS VSS VDD
+ VDD _00921_ sky130_fd_sc_hd__a311oi_2
X_08738_ _00911_ _00899_ _00921_ VSS VSS VDD VDD _00922_ sky130_fd_sc_hd__or3_4
X_08739_ _00889_ _00900_ VSS VSS VDD VDD _00923_ sky130_fd_sc_hd__nor2_1
X_08740_ _00923_ VSS VSS VDD VDD _00924_ sky130_fd_sc_hd__inv_1
X_08741_ _00566_ _00858_ VSS VSS VDD VDD _00925_ sky130_fd_sc_hd__xnor2_1
X_08742_ _00597_ _00762_ VSS VSS VDD VDD _00926_ sky130_fd_sc_hd__nand2_1
X_08743_ _00566_ _00762_ VSS VSS VDD VDD _00927_ sky130_fd_sc_hd__nor2_1
X_08744_ _00795_ _00926_ _00756_ _00927_ VSS VSS VDD VDD _00928_
+ sky130_fd_sc_hd__a2bb2oi_1
X_08745_ _00748_ _00762_ VSS VSS VDD VDD _00929_ sky130_fd_sc_hd__nand2_1
X_08746_ _00795_ _00929_ _00756_ VSS VSS VDD VDD _00930_ sky130_fd_sc_hd__a21bo_1
X_08747_ _00746_ _00597_ VSS VSS VDD VDD _00931_ sky130_fd_sc_hd__nor2_2
X_08748_ _00756_ _00762_ _00931_ _00795_ VSS VSS VDD VDD _00932_
+ sky130_fd_sc_hd__nand4b_1
X_08749_ _00928_ _00930_ _00932_ _00805_ VSS VSS VDD VDD _00933_
+ sky130_fd_sc_hd__a31oi_1
X_08750_ _00819_ _00924_ _00911_ _00925_ _00933_ VSS VSS VDD
+ VDD _00934_ sky130_fd_sc_hd__o41a_1
X_08751_ _00593_ _00908_ _00922_ _00934_ VSS VSS VDD VDD _00935_
+ sky130_fd_sc_hd__o211ai_4
X_08752_ _00888_ _00906_ _00935_ VSS VSS VDD VDD _00936_ sky130_fd_sc_hd__a21o_1
X_08753_ _00936_ VSS VSS VDD VDD _00937_ sky130_fd_sc_hd__buf_6
X_08754_ _07254_ _00854_ _00937_ VSS VSS VDD VDD _07271_ sky130_fd_sc_hd__mux2_2
X_08755_ _07290_ _07289_ _07288_ VSS VSS VDD VDD _00938_ sky130_fd_sc_hd__o21a_1
X_08756_ _07287_ _00938_ _07285_ VSS VSS VDD VDD _00939_ sky130_fd_sc_hd__o21a_1
X_08757_ _07284_ _00939_ _07282_ VSS VSS VDD VDD _00940_ sky130_fd_sc_hd__o21a_1
X_08758_ _07281_ _00940_ _07279_ VSS VSS VDD VDD _00941_ sky130_fd_sc_hd__o21a_1
X_08759_ _07278_ _00941_ _07276_ VSS VSS VDD VDD _00942_ sky130_fd_sc_hd__o21a_1
X_08760_ _00942_ _07275_ VSS VSS VDD VDD _00943_ sky130_fd_sc_hd__nor2_4
X_08761_ _07273_ _00943_ VSS VSS VDD VDD _00944_ sky130_fd_sc_hd__xnor2_2
X_08762_ _00922_ _00934_ VSS VSS VDD VDD _00945_ sky130_fd_sc_hd__and2_2
X_08763_ _00888_ _00906_ _00945_ VSS VSS VDD VDD _00946_ sky130_fd_sc_hd__a21boi_2
X_08764_ _07261_ _00847_ VSS VSS VDD VDD _00947_ sky130_fd_sc_hd__nor2b_1
X_08765_ _00923_ _00848_ VSS VSS VDD VDD _00948_ sky130_fd_sc_hd__nand2_1
X_08766_ _07256_ _00836_ _07255_ VSS VSS VDD VDD _00949_ sky130_fd_sc_hd__a21oi_2
X_08767_ _00899_ _00947_ _00948_ net31 _00949_ VSS VSS VDD
+ VDD _00950_ sky130_fd_sc_hd__o221a_1
X_08768_ _07252_ _00950_ VSS VSS VDD VDD _00951_ sky130_fd_sc_hd__nand2b_1
X_08769_ _00597_ _00762_ VSS VSS VDD VDD _00952_ sky130_fd_sc_hd__xnor2_1
X_08770_ _00756_ _00796_ _00817_ _00952_ VSS VSS VDD VDD _00953_
+ sky130_fd_sc_hd__a31oi_4
X_08771_ _00795_ _00953_ VSS VSS VDD VDD _00954_ sky130_fd_sc_hd__xor2_4
X_08772_ _00593_ _00908_ _00954_ VSS VSS VDD VDD _00955_ sky130_fd_sc_hd__o21bai_2
X_08773_ _00888_ _00951_ _00955_ VSS VSS VDD VDD _00956_ sky130_fd_sc_hd__a21o_1
X_08774_ _00756_ _00796_ VSS VSS VDD VDD _00957_ sky130_fd_sc_hd__and2_1
X_08775_ _00598_ _00790_ VSS VSS VDD VDD _00958_ sky130_fd_sc_hd__xnor2_1
X_08776_ _00815_ _00958_ VSS VSS VDD VDD _00959_ sky130_fd_sc_hd__nand2_1
X_08777_ net9 _00959_ _00817_ VSS VSS VDD VDD _00960_ sky130_fd_sc_hd__o21ai_0
X_08778_ _00957_ _00960_ VSS VSS VDD VDD _00961_ sky130_fd_sc_hd__nand2_1
X_08779_ _00946_ _00956_ net30 VSS VSS VDD VDD _00962_ sky130_fd_sc_hd__o21ai_0
X_08780_ _00946_ _00956_ _00961_ _00962_ VSS VSS VDD VDD _00963_
+ sky130_fd_sc_hd__o31a_2
X_08781_ _00756_ _00796_ VSS VSS VDD VDD _00964_ sky130_fd_sc_hd__or2_2
X_08782_ _00957_ _00805_ _00964_ VSS VSS VDD VDD _00965_ sky130_fd_sc_hd__nor3b_1
X_08783_ _00805_ _00964_ VSS VSS VDD VDD _00966_ sky130_fd_sc_hd__nor2_1
X_08784_ _00946_ _00956_ VSS VSS VDD VDD _00967_ sky130_fd_sc_hd__nor2_1
X_08785_ _00965_ _00966_ _00967_ VSS VSS VDD VDD _00968_ sky130_fd_sc_hd__mux2i_4
X_08786_ _00899_ _00947_ _00948_ net31 _00949_ VSS VSS VDD
+ VDD _00969_ sky130_fd_sc_hd__o221ai_4
X_08787_ _00855_ _00969_ _00598_ _07252_ VSS VSS VDD VDD _00970_
+ sky130_fd_sc_hd__a211o_1
X_08788_ _00855_ _00598_ _00969_ VSS VSS VDD VDD _00971_ sky130_fd_sc_hd__nand3_1
X_08789_ _00593_ _00945_ _00970_ _00971_ VSS VSS VDD VDD _00972_
+ sky130_fd_sc_hd__a22oi_2
X_08790_ _00855_ _00905_ _00969_ _07252_ VSS VSS VDD VDD _00973_
+ sky130_fd_sc_hd__a31oi_1
X_08791_ _00566_ _00973_ VSS VSS VDD VDD _00974_ sky130_fd_sc_hd__nor2_1
X_08792_ _00855_ _00598_ VSS VSS VDD VDD _00975_ sky130_fd_sc_hd__nand2_1
X_08793_ _00922_ _00934_ _00950_ _00975_ VSS VSS VDD VDD _00976_
+ sky130_fd_sc_hd__a211oi_1
X_08794_ _07252_ _00855_ VSS VSS VDD VDD _00977_ sky130_fd_sc_hd__nor2b_1
X_08795_ _00566_ _00905_ _00950_ _00977_ VSS VSS VDD VDD _00978_
+ sky130_fd_sc_hd__and4_1
X_08796_ _07252_ _00598_ VSS VSS VDD VDD _00979_ sky130_fd_sc_hd__xor2_1
X_08797_ _00922_ _00934_ _00969_ _00977_ _00979_ VSS VSS VDD
+ VDD _00980_ sky130_fd_sc_hd__a221oi_1
X_08798_ _00976_ _00978_ _00980_ _00908_ VSS VSS VDD VDD _00981_
+ sky130_fd_sc_hd__o31ai_2
X_08799_ _00908_ _00972_ _00974_ _00981_ VSS VSS VDD VDD _00982_
+ sky130_fd_sc_hd__o31ai_4
X_08800_ _00888_ _00906_ _00593_ _00908_ VSS VSS VDD VDD _00983_
+ sky130_fd_sc_hd__o2bb2ai_1
X_08801_ _00888_ _00906_ _00945_ _00955_ VSS VSS VDD VDD _00984_
+ sky130_fd_sc_hd__a211oi_4
X_08802_ _00954_ _00983_ _00984_ VSS VSS VDD VDD _00985_ sky130_fd_sc_hd__a21o_1
X_08803_ _00943_ VSS VSS VDD VDD _00986_ sky130_fd_sc_hd__inv_2
X_08804_ _00986_ _07273_ _07272_ VSS VSS VDD VDD _00987_ sky130_fd_sc_hd__a21oi_4
X_08805_ _00598_ _00987_ VSS VSS VDD VDD _00988_ sky130_fd_sc_hd__nor2_1
X_08806_ _00987_ _00597_ VSS VSS VDD VDD _00989_ sky130_fd_sc_hd__nand2b_4
X_08807_ _00989_ _00593_ VSS VSS VDD VDD _00990_ sky130_fd_sc_hd__nand2_4
X_08808_ _00855_ _00905_ VSS VSS VDD VDD _00991_ sky130_fd_sc_hd__xor2_2
X_08809_ _00988_ _00990_ _00991_ VSS VSS VDD VDD _00992_ sky130_fd_sc_hd__mux2i_4
X_08810_ _07236_ _07238_ _00605_ VSS VSS VDD VDD _00993_ sky130_fd_sc_hd__nor3_1
X_08811_ _00757_ _00760_ _00993_ VSS VSS VDD VDD _00994_ sky130_fd_sc_hd__nor3_1
X_08812_ _07198_ _00780_ _00781_ VSS VSS VDD VDD _00995_ sky130_fd_sc_hd__nor3_1
X_08813_ _07147_ _00675_ VSS VSS VDD VDD _07148_ sky130_fd_sc_hd__nor2b_4
X_08814_ _07150_ _07152_ _07151_ VSS VSS VDD VDD _00996_ sky130_fd_sc_hd__nor3_1
X_08815_ _00656_ _00996_ net36 VSS VSS VDD VDD _00997_ sky130_fd_sc_hd__o21ai_0
X_08816_ _00660_ _07148_ _00997_ VSS VSS VDD VDD _07179_ sky130_fd_sc_hd__o21a_1
X_08817_ _07183_ _00829_ VSS VSS VDD VDD _00998_ sky130_fd_sc_hd__nor2_1
X_08818_ _07181_ _00998_ VSS VSS VDD VDD _00999_ sky130_fd_sc_hd__xnor2_1
X_08819_ _07179_ _00999_ _00698_ VSS VSS VDD VDD _07196_ sky130_fd_sc_hd__mux2_2
X_08820_ _07196_ _00844_ VSS VSS VDD VDD _01000_ sky130_fd_sc_hd__nand2_2
X_08821_ _00867_ _00995_ _00844_ _01000_ VSS VSS VDD VDD _07217_
+ sky130_fd_sc_hd__o31ai_4
X_08822_ _07219_ _00862_ VSS VSS VDD VDD _01001_ sky130_fd_sc_hd__xor2_1
X_08823_ _07217_ _01001_ _00883_ VSS VSS VDD VDD _07234_ sky130_fd_sc_hd__mux2_2
X_08824_ _00994_ _07234_ net30 VSS VSS VDD VDD _01002_ sky130_fd_sc_hd__mux2i_4
X_08825_ _01002_ VSS VSS VDD VDD _07251_ sky130_fd_sc_hd__inv_2
X_08826_ _00988_ _00990_ _07251_ VSS VSS VDD VDD _01003_ sky130_fd_sc_hd__mux2i_4
X_08827_ _00888_ _00906_ _00935_ VSS VSS VDD VDD _01004_ sky130_fd_sc_hd__a21oi_4
X_08828_ _00992_ _01003_ _01004_ VSS VSS VDD VDD _01005_ sky130_fd_sc_hd__mux2i_4
X_08829_ _00982_ _01005_ _00985_ VSS VSS VDD VDD _01006_ sky130_fd_sc_hd__or3_4
X_08830_ _01006_ VSS VSS VDD VDD _01007_ sky130_fd_sc_hd__buf_6
X_08831_ _00963_ _00968_ _01007_ VSS VSS VDD VDD _01008_ sky130_fd_sc_hd__a21o_4
X_08832_ _07271_ _00944_ _01008_ VSS VSS VDD VDD _01009_ sky130_fd_sc_hd__mux2_4
X_08833_ _07304_ _07303_ _07296_ VSS VSS VDD VDD _01010_ sky130_fd_sc_hd__o21a_1
X_08834_ _07295_ _01010_ _07293_ VSS VSS VDD VDD _01011_ sky130_fd_sc_hd__o21a_1
X_08835_ _07292_ _01011_ _07302_ VSS VSS VDD VDD _01012_ sky130_fd_sc_hd__o21a_1
X_08836_ _07301_ _01012_ _07299_ VSS VSS VDD VDD _01013_ sky130_fd_sc_hd__o21a_1
X_08837_ _01013_ _07298_ _07310_ VSS VSS VDD VDD _01014_ sky130_fd_sc_hd__o21ai_1
X_08838_ _07309_ _01014_ VSS VSS VDD VDD _01015_ sky130_fd_sc_hd__nand2b_2
X_08839_ _01015_ _07307_ _07306_ VSS VSS VDD VDD _01016_ sky130_fd_sc_hd__a21oi_4
X_08840_ _00855_ _00905_ VSS VSS VDD VDD _01017_ sky130_fd_sc_hd__xnor2_2
X_08841_ _00888_ _00906_ _00935_ _07251_ VSS VSS VDD VDD _01018_
+ sky130_fd_sc_hd__a211oi_2
X_08842_ _00937_ _01017_ _01018_ VSS VSS VDD VDD _01019_ sky130_fd_sc_hd__a21oi_2
X_08843_ _00982_ _01019_ VSS VSS VDD VDD _01020_ sky130_fd_sc_hd__nor2_2
X_08844_ _07290_ _07273_ _07285_ _07288_ VSS VSS VDD VDD _01021_
+ sky130_fd_sc_hd__nand4_1
X_08845_ _00812_ _01021_ VSS VSS VDD VDD _01022_ sky130_fd_sc_hd__nor2_1
X_08846_ _07276_ _07279_ _07282_ _01022_ VSS VSS VDD VDD _01023_
+ sky130_fd_sc_hd__nand4_1
X_08847_ _00936_ _01017_ _01018_ _00598_ VSS VSS VDD VDD _01024_
+ sky130_fd_sc_hd__a211oi_1
X_08848_ _00888_ _00906_ _00935_ _01002_ VSS VSS VDD VDD _01025_
+ sky130_fd_sc_hd__a211oi_2
X_08849_ _00936_ _00991_ _01025_ _00566_ VSS VSS VDD VDD _01026_
+ sky130_fd_sc_hd__a211oi_1
X_08850_ _00954_ _00983_ _00984_ VSS VSS VDD VDD _01027_ sky130_fd_sc_hd__a21oi_4
X_08851_ _01023_ _01024_ _01026_ _01027_ VSS VSS VDD VDD _01028_
+ sky130_fd_sc_hd__o31ai_2
X_08852_ _00963_ _00968_ _01028_ VSS VSS VDD VDD _01029_ sky130_fd_sc_hd__a21oi_4
X_08853_ _00566_ _00987_ VSS VSS VDD VDD _01030_ sky130_fd_sc_hd__xnor2_1
X_08854_ _01019_ _01030_ VSS VSS VDD VDD _01031_ sky130_fd_sc_hd__and2_0
X_08855_ _01019_ _01030_ VSS VSS VDD VDD _01032_ sky130_fd_sc_hd__nor2_1
X_08856_ _01020_ _01029_ _01031_ _01008_ _01032_ VSS VSS VDD
+ VDD _01033_ sky130_fd_sc_hd__a221oi_4
X_08857_ _00961_ _00964_ VSS VSS VDD VDD _01034_ sky130_fd_sc_hd__nand2_1
X_08858_ _00946_ _00956_ _01034_ VSS VSS VDD VDD _01035_ sky130_fd_sc_hd__o21bai_1
X_08859_ _00946_ _00956_ _01034_ VSS VSS VDD VDD _01036_ sky130_fd_sc_hd__or3b_1
X_08860_ _00957_ _00984_ _00964_ VSS VSS VDD VDD _01037_ sky130_fd_sc_hd__o21ai_2
X_08861_ _01035_ _01036_ _01037_ _00805_ VSS VSS VDD VDD _01038_
+ sky130_fd_sc_hd__a22oi_2
X_08862_ _00908_ _00972_ _00974_ _00981_ VSS VSS VDD VDD _01039_
+ sky130_fd_sc_hd__o31a_1
X_08863_ _01039_ VSS VSS VDD VDD _01040_ sky130_fd_sc_hd__buf_2
X_08864_ _00598_ _00987_ VSS VSS VDD VDD _01041_ sky130_fd_sc_hd__or2_0
X_08865_ _00937_ _00991_ _01041_ _01025_ VSS VSS VDD VDD _01042_
+ sky130_fd_sc_hd__a211oi_1
X_08866_ _01040_ _01042_ VSS VSS VDD VDD _01043_ sky130_fd_sc_hd__and2_0
X_08867_ _01027_ _01020_ _01038_ _01043_ VSS VSS VDD VDD _01044_
+ sky130_fd_sc_hd__a31oi_4
X_08868_ _00746_ _01040_ VSS VSS VDD VDD _01045_ sky130_fd_sc_hd__xnor2_1
X_08869_ _00566_ _00987_ _01019_ VSS VSS VDD VDD _01046_ sky130_fd_sc_hd__and3_1
X_08870_ _00599_ _00987_ VSS VSS VDD VDD _01047_ sky130_fd_sc_hd__nand2_1
X_08871_ _00937_ _00991_ _01025_ _01047_ VSS VSS VDD VDD _01048_
+ sky130_fd_sc_hd__a211oi_1
X_08872_ _00937_ _01017_ _00989_ _01018_ VSS VSS VDD VDD _01049_
+ sky130_fd_sc_hd__a211oi_1
X_08873_ _01048_ _01049_ _01040_ VSS VSS VDD VDD _01050_ sky130_fd_sc_hd__mux2i_1
X_08874_ _01045_ _01046_ _01050_ VSS VSS VDD VDD _01051_ sky130_fd_sc_hd__a21boi_2
X_08875_ _01035_ _01036_ VSS VSS VDD VDD _01052_ sky130_fd_sc_hd__and2_1
X_08876_ _00982_ _01005_ _01035_ _01036_ VSS VSS VDD VDD _01053_
+ sky130_fd_sc_hd__o211ai_1
X_08877_ _00805_ _01037_ _00985_ VSS VSS VDD VDD _01054_ sky130_fd_sc_hd__a21oi_1
X_08878_ _01007_ _01052_ _01053_ _01054_ VSS VSS VDD VDD _01055_
+ sky130_fd_sc_hd__a2bb2oi_1
X_08879_ _01044_ _01051_ _01055_ VSS VSS VDD VDD _01056_ sky130_fd_sc_hd__a21oi_2
X_08880_ _01056_ VSS VSS VDD VDD _01057_ sky130_fd_sc_hd__buf_4
X_08881_ _01016_ _01033_ _01057_ VSS VSS VDD VDD _01058_ sky130_fd_sc_hd__a21oi_1
X_08882_ _01008_ VSS VSS VDD VDD _01059_ sky130_fd_sc_hd__buf_6
X_08883_ _07271_ _00944_ net22 VSS VSS VDD VDD _01060_ sky130_fd_sc_hd__mux2i_1
X_08884_ _01016_ _01060_ _01057_ VSS VSS VDD VDD _01061_ sky130_fd_sc_hd__nand3_1
X_08885_ _00567_ _01009_ _01058_ _01061_ VSS VSS VDD VDD _01062_
+ sky130_fd_sc_hd__o31a_1
X_08886_ _01016_ _00931_ _01009_ _01033_ VSS VSS VDD VDD _01063_
+ sky130_fd_sc_hd__and4_1
X_08887_ _01016_ _00598_ VSS VSS VDD VDD _01064_ sky130_fd_sc_hd__nand2b_4
X_08888_ _01064_ _01060_ _01033_ VSS VSS VDD VDD _01065_ sky130_fd_sc_hd__nor3_1
X_08889_ _00599_ _01016_ VSS VSS VDD VDD _01066_ sky130_fd_sc_hd__or2_2
Xclone5 _01173_ _01187_ _01200_ VSS VSS VDD VDD net5 sky130_fd_sc_hd__a21oi_4
X_08891_ _00944_ _01066_ VSS VSS VDD VDD _01068_ sky130_fd_sc_hd__nor2_2
X_08892_ _01016_ _00748_ _00944_ VSS VSS VDD VDD _01069_ sky130_fd_sc_hd__and3_1
X_08893_ _01068_ _01069_ net22 VSS VSS VDD VDD _01070_ sky130_fd_sc_hd__o21ai_0
X_08894_ _07271_ _01066_ VSS VSS VDD VDD _01071_ sky130_fd_sc_hd__nor2_2
X_08895_ _01016_ _00748_ _07271_ VSS VSS VDD VDD _01072_ sky130_fd_sc_hd__and3_1
X_08896_ _00963_ _00968_ _01007_ VSS VSS VDD VDD _01073_ sky130_fd_sc_hd__a21oi_4
X_08897_ _01071_ _01072_ _01073_ VSS VSS VDD VDD _01074_ sky130_fd_sc_hd__o21ai_0
X_08898_ _01070_ _01074_ _01033_ VSS VSS VDD VDD _01075_ sky130_fd_sc_hd__a21oi_1
X_08899_ _01063_ _01065_ _01075_ VSS VSS VDD VDD _01076_ sky130_fd_sc_hd__nor3_1
X_08900_ _07330_ _07329_ _07328_ VSS VSS VDD VDD _01077_ sky130_fd_sc_hd__o21a_1
X_08901_ _07327_ _01077_ _07325_ VSS VSS VDD VDD _01078_ sky130_fd_sc_hd__o21a_1
X_08902_ _07324_ _01078_ _07322_ VSS VSS VDD VDD _01079_ sky130_fd_sc_hd__o21a_1
X_08903_ _07321_ _01079_ _07319_ VSS VSS VDD VDD _01080_ sky130_fd_sc_hd__o21a_1
X_08904_ _07318_ _01080_ _07316_ VSS VSS VDD VDD _01081_ sky130_fd_sc_hd__o21a_1
X_08905_ _01081_ _07315_ VSS VSS VDD VDD _01082_ sky130_fd_sc_hd__nor2_4
X_08906_ _01082_ VSS VSS VDD VDD _01083_ sky130_fd_sc_hd__inv_2
X_08907_ _01083_ _07313_ _07312_ VSS VSS VDD VDD _01084_ sky130_fd_sc_hd__a21oi_4
X_08908_ _00566_ _01084_ _00593_ VSS VSS VDD VDD _01085_ sky130_fd_sc_hd__o21ai_2
X_08909_ _00599_ _01084_ VSS VSS VDD VDD _01086_ sky130_fd_sc_hd__nor2_1
X_08910_ _00847_ _00845_ _00902_ VSS VSS VDD VDD _01087_ sky130_fd_sc_hd__o21bai_1
X_08911_ _07259_ _01087_ VSS VSS VDD VDD _01088_ sky130_fd_sc_hd__xnor2_1
X_08912_ _07242_ _00603_ VSS VSS VDD VDD _01089_ sky130_fd_sc_hd__nor2_1
X_08913_ _07206_ _07204_ _07205_ VSS VSS VDD VDD _01090_ sky130_fd_sc_hd__nor3_1
X_08914_ _07186_ _00710_ VSS VSS VDD VDD _07202_ sky130_fd_sc_hd__nor2_1
X_08915_ _00844_ _07202_ VSS VSS VDD VDD _01091_ sky130_fd_sc_hd__nand2_1
X_08916_ _00826_ _00844_ _01090_ _01091_ VSS VSS VDD VDD _07223_
+ sky130_fd_sc_hd__o31ai_2
X_08917_ _07227_ _00839_ VSS VSS VDD VDD _01092_ sky130_fd_sc_hd__nor2_1
X_08918_ _07225_ _01092_ VSS VSS VDD VDD _01093_ sky130_fd_sc_hd__xnor2_1
X_08919_ _07223_ _01093_ _00883_ VSS VSS VDD VDD _07240_ sky130_fd_sc_hd__mux2_1
X_08920_ _00820_ _07240_ VSS VSS VDD VDD _01094_ sky130_fd_sc_hd__nand2_2
X_08921_ _00604_ _01089_ _00820_ _01094_ VSS VSS VDD VDD _07257_
+ sky130_fd_sc_hd__o31ai_4
X_08922_ _00937_ _07257_ VSS VSS VDD VDD _01095_ sky130_fd_sc_hd__nor2_1
X_08923_ _00937_ _01088_ _01095_ VSS VSS VDD VDD _07274_ sky130_fd_sc_hd__a21oi_2
X_08924_ _07276_ _07278_ _00941_ VSS VSS VDD VDD _01096_ sky130_fd_sc_hd__nor3_1
X_08925_ _00942_ _01096_ VSS VSS VDD VDD _01097_ sky130_fd_sc_hd__nor2_1
X_08926_ _07274_ _01097_ net22 VSS VSS VDD VDD _01098_ sky130_fd_sc_hd__mux2i_4
X_08927_ _01085_ _01086_ _01098_ VSS VSS VDD VDD _01099_ sky130_fd_sc_hd__mux2i_2
X_08928_ _07307_ _01015_ VSS VSS VDD VDD _01100_ sky130_fd_sc_hd__xor2_4
X_08929_ _00599_ _01100_ _01084_ VSS VSS VDD VDD _01101_ sky130_fd_sc_hd__nor3_1
X_08930_ _01085_ _01100_ _01101_ VSS VSS VDD VDD _01102_ sky130_fd_sc_hd__a21oi_2
X_08931_ _01064_ _00593_ VSS VSS VDD VDD _01103_ sky130_fd_sc_hd__nand2_2
X_08932_ _01103_ _00944_ VSS VSS VDD VDD _01104_ sky130_fd_sc_hd__and2_4
X_08933_ _01068_ _01104_ net22 VSS VSS VDD VDD _01105_ sky130_fd_sc_hd__o21ai_4
X_08934_ _01103_ _07271_ VSS VSS VDD VDD _01106_ sky130_fd_sc_hd__and2_4
X_08935_ _01106_ _01071_ _01073_ VSS VSS VDD VDD _01107_ sky130_fd_sc_hd__o21ai_4
X_08936_ _01107_ _01105_ _01056_ VSS VSS VDD VDD _01108_ sky130_fd_sc_hd__nand3_4
X_08937_ _01099_ _01102_ net4 VSS VSS VDD VDD _01109_ sky130_fd_sc_hd__mux2i_4
X_08938_ _01062_ _01076_ _01109_ VSS VSS VDD VDD _01110_ sky130_fd_sc_hd__a21o_4
X_08939_ _01068_ _01104_ net22 VSS VSS VDD VDD _01111_ sky130_fd_sc_hd__o21a_1
X_08940_ _01071_ _01106_ _01073_ VSS VSS VDD VDD _01112_ sky130_fd_sc_hd__o21a_1
X_08941_ _01112_ _01111_ VSS VSS VDD VDD _01113_ sky130_fd_sc_hd__nor2_4
X_08942_ _00812_ VSS VSS VDD VDD _01114_ sky130_fd_sc_hd__buf_6
X_08943_ _07330_ _07322_ _07325_ _07328_ VSS VSS VDD VDD _01115_
+ sky130_fd_sc_hd__nand4_1
X_08944_ _07313_ _07316_ _07319_ VSS VSS VDD VDD _01116_ sky130_fd_sc_hd__nand3_1
X_08945_ _01114_ _01115_ _01116_ VSS VSS VDD VDD _01117_ sky130_fd_sc_hd__nor3_2
X_08946_ _00567_ _01098_ VSS VSS VDD VDD _01118_ sky130_fd_sc_hd__xnor2_1
X_08947_ _01113_ _01057_ _01117_ _01118_ VSS VSS VDD VDD _01119_
+ sky130_fd_sc_hd__nand4_2
X_08948_ _00599_ _01100_ VSS VSS VDD VDD _01120_ sky130_fd_sc_hd__xnor2_1
X_08949_ _00805_ _01037_ VSS VSS VDD VDD _01121_ sky130_fd_sc_hd__nand2_1
X_08950_ _01007_ _01052_ VSS VSS VDD VDD _01122_ sky130_fd_sc_hd__nor2_1
X_08951_ _01121_ _01122_ VSS VSS VDD VDD _01123_ sky130_fd_sc_hd__nor2_2
X_08952_ _01104_ _01106_ _01073_ VSS VSS VDD VDD _01124_ sky130_fd_sc_hd__mux2i_4
X_08953_ _01027_ _01053_ VSS VSS VDD VDD _01125_ sky130_fd_sc_hd__nand2_1
X_08954_ _01044_ _01051_ _01125_ VSS VSS VDD VDD _01126_ sky130_fd_sc_hd__a21oi_1
X_08955_ _01009_ _01066_ _01124_ _01126_ VSS VSS VDD VDD _01127_
+ sky130_fd_sc_hd__o211ai_4
X_08956_ net4 _01117_ _01120_ _01123_ _01127_ VSS VSS VDD
+ VDD _01128_ sky130_fd_sc_hd__a32oi_4
X_08957_ _00805_ _01052_ _01037_ VSS VSS VDD VDD _01129_ sky130_fd_sc_hd__and3_1
X_08958_ _01027_ _01121_ _01052_ VSS VSS VDD VDD _01130_ sky130_fd_sc_hd__a21oi_1
X_08959_ _01129_ _01130_ net32 VSS VSS VDD VDD _01131_ sky130_fd_sc_hd__mux2i_1
X_08960_ _01007_ _01052_ _01029_ VSS VSS VDD VDD _01132_ sky130_fd_sc_hd__nor3_1
X_08961_ net32 _01052_ _01132_ VSS VSS VDD VDD _01133_ sky130_fd_sc_hd__a21oi_1
X_08962_ _01027_ _01020_ _01038_ VSS VSS VDD VDD _01134_ sky130_fd_sc_hd__nand3_1
X_08963_ _01040_ _01042_ VSS VSS VDD VDD _01135_ sky130_fd_sc_hd__nand2_1
X_08964_ _00931_ _00982_ _00987_ _01019_ VSS VSS VDD VDD _01136_
+ sky130_fd_sc_hd__nand4_1
X_08965_ _00748_ _01040_ _00987_ _01019_ VSS VSS VDD VDD _01137_
+ sky130_fd_sc_hd__nand4_1
X_08966_ _01135_ _01050_ _01136_ _01137_ _00985_ VSS VSS VDD
+ VDD _01138_ sky130_fd_sc_hd__a41o_1
X_08967_ _01005_ _01134_ _01138_ VSS VSS VDD VDD _01139_ sky130_fd_sc_hd__o21ai_1
X_08968_ _01009_ _01066_ _01124_ _01139_ VSS VSS VDD VDD _01140_
+ sky130_fd_sc_hd__o211ai_1
X_08969_ _01131_ _01133_ _01140_ VSS VSS VDD VDD _01141_ sky130_fd_sc_hd__mux2_4
X_08970_ _01119_ _01128_ _01141_ VSS VSS VDD VDD _01142_ sky130_fd_sc_hd__nand3_4
X_08971_ _01005_ _01040_ VSS VSS VDD VDD _01143_ sky130_fd_sc_hd__nand2b_1
X_08972_ _00985_ _01143_ VSS VSS VDD VDD _01144_ sky130_fd_sc_hd__nand2_1
X_08973_ net32 _01029_ _01144_ VSS VSS VDD VDD _01145_ sky130_fd_sc_hd__o21a_1
X_08974_ _00982_ _01005_ VSS VSS VDD VDD _01146_ sky130_fd_sc_hd__nand2_1
X_08975_ _01143_ _01029_ _01146_ VSS VSS VDD VDD _01147_ sky130_fd_sc_hd__o21ai_0
X_08976_ _01111_ _01112_ _01033_ _01147_ VSS VSS VDD VDD _01148_
+ sky130_fd_sc_hd__o31ai_1
X_08977_ _01044_ _01051_ _01055_ VSS VSS VDD VDD _01149_ sky130_fd_sc_hd__a21boi_0
X_08978_ _01009_ _01066_ _01124_ _01149_ VSS VSS VDD VDD _01150_
+ sky130_fd_sc_hd__o211ai_1
X_08979_ _01148_ _01150_ VSS VSS VDD VDD _01151_ sky130_fd_sc_hd__and2_1
X_08980_ _01145_ _01151_ VSS VSS VDD VDD _01152_ sky130_fd_sc_hd__nand2_4
X_08981_ _07316_ _07318_ _01080_ VSS VSS VDD VDD _01153_ sky130_fd_sc_hd__nor3_1
X_08982_ _01081_ _01153_ VSS VSS VDD VDD _01154_ sky130_fd_sc_hd__nor2_1
X_08983_ _01110_ _01142_ _01152_ _01154_ VSS VSS VDD VDD _01155_
+ sky130_fd_sc_hd__o31ai_1
X_08984_ _01062_ _01076_ _01109_ VSS VSS VDD VDD _01156_ sky130_fd_sc_hd__a21oi_2
X_08985_ _01156_ VSS VSS VDD VDD _01157_ sky130_fd_sc_hd__buf_4
X_08986_ _01119_ _01128_ _01141_ VSS VSS VDD VDD _01158_ sky130_fd_sc_hd__and3_2
X_08987_ _01145_ _01148_ _01150_ VSS VSS VDD VDD _01159_ sky130_fd_sc_hd__and3_1
X_08988_ _01159_ VSS VSS VDD VDD _01160_ sky130_fd_sc_hd__buf_2
X_08989_ _07282_ _07284_ _00939_ VSS VSS VDD VDD _01161_ sky130_fd_sc_hd__nor3_1
X_08990_ _07248_ _07250_ _07249_ VSS VSS VDD VDD _01162_ sky130_fd_sc_hd__nor3_1
X_08991_ _07230_ _00822_ VSS VSS VDD VDD _07246_ sky130_fd_sc_hd__nor2_4
X_08992_ net30 _07246_ VSS VSS VDD VDD _01163_ sky130_fd_sc_hd__nand2_1
X_08993_ _00601_ net30 _01162_ _01163_ VSS VSS VDD VDD _07260_
+ sky130_fd_sc_hd__o31ai_2
X_08994_ _00937_ _07260_ VSS VSS VDD VDD _01164_ sky130_fd_sc_hd__nor2_1
X_08995_ _07262_ _07264_ _00846_ VSS VSS VDD VDD _01165_ sky130_fd_sc_hd__or3_1
X_08996_ _00847_ _01165_ _01004_ VSS VSS VDD VDD _01166_ sky130_fd_sc_hd__a21oi_1
X_08997_ _01166_ _01164_ VSS VSS VDD VDD _07280_ sky130_fd_sc_hd__nor2_1
X_08998_ _01073_ _07280_ VSS VSS VDD VDD _01167_ sky130_fd_sc_hd__nand2_1
X_08999_ _00940_ _01073_ _01161_ _01167_ VSS VSS VDD VDD _07297_
+ sky130_fd_sc_hd__o31ai_2
X_09000_ _07299_ _07301_ _01012_ VSS VSS VDD VDD _01168_ sky130_fd_sc_hd__nor3_1
X_09001_ _01013_ _01168_ VSS VSS VDD VDD _01169_ sky130_fd_sc_hd__nor2_1
X_09002_ _07297_ _01169_ net4 VSS VSS VDD VDD _07314_ sky130_fd_sc_hd__mux2_2
X_09003_ _01157_ _01158_ _01160_ _07314_ VSS VSS VDD VDD _01170_
+ sky130_fd_sc_hd__nand4_2
X_09004_ _01155_ _01170_ VSS VSS VDD VDD _01171_ sky130_fd_sc_hd__and2_1
X_09005_ _00595_ _00600_ _01171_ VSS VSS VDD VDD _01172_ sky130_fd_sc_hd__mux2i_4
X_09006_ _01156_ _01158_ _01160_ VSS VSS VDD VDD _01173_ sky130_fd_sc_hd__nand3_4
X_09007_ _07313_ _01082_ VSS VSS VDD VDD _01174_ sky130_fd_sc_hd__xor2_2
X_09008_ _00599_ _01174_ VSS VSS VDD VDD _01175_ sky130_fd_sc_hd__xnor2_1
X_09009_ _07350_ _07349_ _07348_ VSS VSS VDD VDD _01176_ sky130_fd_sc_hd__o21a_4
X_09010_ _07347_ _01176_ _07345_ VSS VSS VDD VDD _01177_ sky130_fd_sc_hd__o21a_1
X_09011_ _01177_ _07344_ _07342_ VSS VSS VDD VDD _01178_ sky130_fd_sc_hd__o21a_1
X_09012_ _07341_ _01178_ _07339_ VSS VSS VDD VDD _01179_ sky130_fd_sc_hd__o21a_1
X_09013_ _01179_ _07338_ _07336_ VSS VSS VDD VDD _01180_ sky130_fd_sc_hd__o21a_1
X_09014_ _07335_ _01180_ _07333_ VSS VSS VDD VDD _01181_ sky130_fd_sc_hd__o21a_1
X_09015_ _01181_ _07332_ VSS VSS VDD VDD _01182_ sky130_fd_sc_hd__nor2_4
X_09016_ _00594_ _01174_ _01175_ _01182_ VSS VSS VDD VDD _01183_
+ sky130_fd_sc_hd__o22ai_1
X_09017_ _01098_ VSS VSS VDD VDD _07305_ sky130_fd_sc_hd__inv_1
X_09018_ _07305_ _01100_ net4 VSS VSS VDD VDD _01184_ sky130_fd_sc_hd__mux2i_4
X_09019_ _00567_ _01084_ VSS VSS VDD VDD _01185_ sky130_fd_sc_hd__xnor2_1
X_09020_ _01184_ _01185_ VSS VSS VDD VDD _01186_ sky130_fd_sc_hd__xnor2_1
X_09021_ _01183_ _01186_ VSS VSS VDD VDD _01187_ sky130_fd_sc_hd__nor2_2
X_09022_ _07270_ _00848_ VSS VSS VDD VDD _01188_ sky130_fd_sc_hd__xnor2_1
X_09023_ _00937_ _07268_ VSS VSS VDD VDD _01189_ sky130_fd_sc_hd__nor2_1
X_09024_ _00937_ _01188_ _01189_ VSS VSS VDD VDD _07277_ sky130_fd_sc_hd__a21oi_1
X_09025_ _07279_ _07281_ _00940_ VSS VSS VDD VDD _01190_ sky130_fd_sc_hd__nor3_1
X_09026_ _00941_ _01190_ VSS VSS VDD VDD _01191_ sky130_fd_sc_hd__nor2_1
X_09027_ _07277_ _01191_ _01059_ VSS VSS VDD VDD _07308_ sky130_fd_sc_hd__mux2_1
X_09028_ _01009_ _01066_ _01124_ _01057_ _07308_ VSS VSS VDD
+ VDD _01192_ sky130_fd_sc_hd__o2111a_1
X_09029_ _07298_ _01013_ VSS VSS VDD VDD _01193_ sky130_fd_sc_hd__nor2_1
X_09030_ _07310_ _01193_ VSS VSS VDD VDD _01194_ sky130_fd_sc_hd__xor2_1
X_09031_ _01105_ _01107_ _01057_ _01194_ VSS VSS VDD VDD _01195_
+ sky130_fd_sc_hd__a31oi_2
X_09032_ _00567_ _01182_ _00593_ VSS VSS VDD VDD _01196_ sky130_fd_sc_hd__o21ai_1
X_09033_ _01192_ _01195_ _01196_ VSS VSS VDD VDD _01197_ sky130_fd_sc_hd__o21ai_1
X_09034_ _00599_ _01182_ _01192_ _01195_ VSS VSS VDD VDD _01198_
+ sky130_fd_sc_hd__or4_1
X_09035_ _01184_ _01198_ _01197_ VSS VSS VDD VDD _01199_ sky130_fd_sc_hd__nand3_1
X_09036_ _01152_ _01142_ _01110_ _01199_ VSS VSS VDD VDD _01200_
+ sky130_fd_sc_hd__nor4_4
X_09037_ _01173_ _01187_ _01200_ VSS VSS VDD VDD _01201_ sky130_fd_sc_hd__a21oi_4
X_09038_ net32 _01029_ _01144_ VSS VSS VDD VDD _01202_ sky130_fd_sc_hd__o21ai_2
X_09039_ _01110_ _01202_ _01142_ VSS VSS VDD VDD _01203_ sky130_fd_sc_hd__nor3_1
X_09040_ _01111_ _01112_ _01057_ VSS VSS VDD VDD _01204_ sky130_fd_sc_hd__or3_2
X_09041_ _01033_ _01204_ VSS VSS VDD VDD _01205_ sky130_fd_sc_hd__xnor2_2
X_09042_ _00567_ _01016_ VSS VSS VDD VDD _01206_ sky130_fd_sc_hd__nand2_1
X_09043_ _01064_ _01009_ _01057_ VSS VSS VDD VDD _01207_ sky130_fd_sc_hd__nor3_1
X_09044_ _01064_ _01009_ _01206_ _01207_ VSS VSS VDD VDD _01208_
+ sky130_fd_sc_hd__a31o_1
X_09045_ _00931_ _01009_ _01057_ VSS VSS VDD VDD _01209_ sky130_fd_sc_hd__nand3_1
X_09046_ _01009_ _01057_ _01206_ _01209_ VSS VSS VDD VDD _01210_
+ sky130_fd_sc_hd__o31ai_4
X_09047_ _01208_ _01210_ _01109_ VSS VSS VDD VDD _01211_ sky130_fd_sc_hd__nor3_4
X_09048_ _01208_ _01210_ _01109_ VSS VSS VDD VDD _01212_ sky130_fd_sc_hd__o21ai_1
X_09049_ _01205_ _01211_ _01212_ VSS VSS VDD VDD _01213_ sky130_fd_sc_hd__nor3b_1
X_09050_ _01203_ _01213_ VSS VSS VDD VDD _01214_ sky130_fd_sc_hd__nor2_2
X_09051_ _01152_ _01142_ _01110_ VSS VSS VDD VDD _01215_ sky130_fd_sc_hd__nor3_4
X_09052_ _01040_ _01005_ VSS VSS VDD VDD _01216_ sky130_fd_sc_hd__xnor2_1
X_09053_ _00985_ _01216_ VSS VSS VDD VDD _01217_ sky130_fd_sc_hd__nand2_1
X_09054_ _01105_ _01107_ _01217_ VSS VSS VDD VDD _01218_ sky130_fd_sc_hd__a21oi_1
X_09055_ _01044_ _01051_ _01202_ VSS VSS VDD VDD _01219_ sky130_fd_sc_hd__and3_1
X_09056_ _01113_ _01055_ _01139_ _01218_ _01219_ VSS VSS VDD
+ VDD _01220_ sky130_fd_sc_hd__a311o_2
X_09057_ _01220_ _01141_ VSS VSS VDD VDD _01221_ sky130_fd_sc_hd__nand2b_1
X_09058_ _01127_ _01123_ VSS VSS VDD VDD _01222_ sky130_fd_sc_hd__nand2_1
X_09059_ _01151_ VSS VSS VDD VDD _01223_ sky130_fd_sc_hd__buf_2
X_09060_ _01222_ _01223_ VSS VSS VDD VDD _01224_ sky130_fd_sc_hd__nand2_1
X_09061_ _01157_ _01221_ _01224_ VSS VSS VDD VDD _01225_ sky130_fd_sc_hd__nor3_1
X_09062_ _01215_ _01225_ VSS VSS VDD VDD _01226_ sky130_fd_sc_hd__nor2_1
X_09063_ _01192_ _01195_ VSS VSS VDD VDD _01227_ sky130_fd_sc_hd__nor2_1
X_09064_ _01110_ _01142_ _01152_ _01227_ VSS VSS VDD VDD _01228_
+ sky130_fd_sc_hd__nor4_2
X_09065_ _01157_ _01158_ _01160_ _01174_ VSS VSS VDD VDD _01229_
+ sky130_fd_sc_hd__a31oi_2
X_09066_ _01228_ _01229_ VSS VSS VDD VDD _01230_ sky130_fd_sc_hd__nor2_2
X_09067_ _01201_ _01214_ _01226_ _01230_ VSS VSS VDD VDD _01231_
+ sky130_fd_sc_hd__nor4b_4
X_09068_ _01173_ _01187_ _01200_ VSS VSS VDD VDD _01232_ sky130_fd_sc_hd__a21o_2
X_09069_ _01157_ _01221_ VSS VSS VDD VDD _01233_ sky130_fd_sc_hd__nor2_1
X_09070_ _01205_ _01224_ _01211_ _01212_ VSS VSS VDD VDD _01234_
+ sky130_fd_sc_hd__nor4b_1
X_09071_ _01215_ VSS VSS VDD VDD _01235_ sky130_fd_sc_hd__buf_6
X_09072_ _01233_ _01234_ net15 VSS VSS VDD VDD _01236_ sky130_fd_sc_hd__a21o_4
X_09073_ _01232_ _01236_ VSS VSS VDD VDD _01237_ sky130_fd_sc_hd__nand2_8
X_09074_ _00599_ _01182_ VSS VSS VDD VDD _01238_ sky130_fd_sc_hd__xnor2_2
X_09075_ _01228_ _01229_ _01238_ VSS VSS VDD VDD _01239_ sky130_fd_sc_hd__nor3_1
X_09076_ _07333_ _07335_ _01180_ VSS VSS VDD VDD _01240_ sky130_fd_sc_hd__nor3_1
X_09077_ _01181_ _01240_ VSS VSS VDD VDD _01241_ sky130_fd_sc_hd__nor2_2
X_09078_ _00600_ _00595_ _01241_ VSS VSS VDD VDD _01242_ sky130_fd_sc_hd__mux2i_2
X_09079_ _01242_ VSS VSS VDD VDD _01243_ sky130_fd_sc_hd__inv_2
X_09080_ _01228_ _01229_ _01238_ VSS VSS VDD VDD _01244_ sky130_fd_sc_hd__o21ai_0
X_09081_ _01243_ _01239_ _01244_ VSS VSS VDD VDD _01245_ sky130_fd_sc_hd__nor3b_4
X_09082_ _01172_ _01231_ _01237_ _01245_ VSS VSS VDD VDD _01246_
+ sky130_fd_sc_hd__a22o_1
X_09083_ _01246_ VSS VSS VDD VDD _01247_ sky130_fd_sc_hd__buf_4
X_09084_ _00599_ VSS VSS VDD VDD _01248_ sky130_fd_sc_hd__buf_6
X_09085_ _07368_ _07359_ _07362_ _07365_ VSS VSS VDD VDD _01249_
+ sky130_fd_sc_hd__nand4_1
X_09086_ _07370_ _07353_ _07356_ VSS VSS VDD VDD _01250_ sky130_fd_sc_hd__nand3_1
X_09087_ _01114_ _01249_ _01250_ VSS VSS VDD VDD _01251_ sky130_fd_sc_hd__nor3_1
X_09088_ _01248_ _01241_ _01251_ VSS VSS VDD VDD _01252_ sky130_fd_sc_hd__and3_1
X_09089_ _01157_ _01141_ _01160_ VSS VSS VDD VDD _01253_ sky130_fd_sc_hd__nand3_1
X_09090_ _01173_ _01187_ _01200_ _01253_ VSS VSS VDD VDD _01254_
+ sky130_fd_sc_hd__a211oi_1
X_09091_ _01183_ _01186_ VSS VSS VDD VDD _01255_ sky130_fd_sc_hd__nand2_1
X_09092_ _01197_ _01198_ _01184_ VSS VSS VDD VDD _01256_ sky130_fd_sc_hd__a21o_1
X_09093_ _01255_ _01256_ _01215_ VSS VSS VDD VDD _01257_ sky130_fd_sc_hd__mux2_2
X_09094_ _01208_ _01210_ VSS VSS VDD VDD _01258_ sky130_fd_sc_hd__or2_0
X_09095_ _01205_ _01258_ _01142_ _01152_ _01211_ VSS VSS VDD
+ VDD _01259_ sky130_fd_sc_hd__o41ai_1
X_09096_ _01212_ _01259_ VSS VSS VDD VDD _01260_ sky130_fd_sc_hd__and2_2
X_09097_ _01222_ _01254_ _01257_ _01260_ VSS VSS VDD VDD _01261_
+ sky130_fd_sc_hd__o211ai_4
X_09098_ _01033_ _01204_ VSS VSS VDD VDD _01262_ sky130_fd_sc_hd__xor2_2
X_09099_ _01262_ _01211_ _01225_ net15 VSS VSS VDD VDD _01263_
+ sky130_fd_sc_hd__o22ai_2
X_09100_ _01203_ _01233_ _01211_ _01262_ _01223_ VSS VSS VDD
+ VDD _01264_ sky130_fd_sc_hd__o221ai_1
X_09101_ _01232_ _01263_ _01260_ _01264_ VSS VSS VDD VDD _01265_
+ sky130_fd_sc_hd__a31o_1
X_09102_ _01237_ _01252_ _01261_ _01265_ VSS VSS VDD VDD _01266_
+ sky130_fd_sc_hd__a211o_4
X_09103_ _01230_ _01238_ VSS VSS VDD VDD _01267_ sky130_fd_sc_hd__xnor2_1
X_09104_ _01233_ _01234_ net15 VSS VSS VDD VDD _01268_ sky130_fd_sc_hd__a21oi_1
X_09105_ _01268_ VSS VSS VDD VDD _01269_ sky130_fd_sc_hd__clkbuf_4
X_09106_ _01201_ _01269_ _01243_ VSS VSS VDD VDD _01270_ sky130_fd_sc_hd__o21ai_2
X_09107_ _01172_ _01230_ _01237_ _01267_ _01270_ VSS VSS VDD
+ VDD _01271_ sky130_fd_sc_hd__o32ai_4
X_09108_ _01247_ _01266_ _01271_ VSS VSS VDD VDD _01272_ sky130_fd_sc_hd__a21oi_4
X_09109_ _01237_ _01252_ _01261_ _01265_ VSS VSS VDD VDD _01273_
+ sky130_fd_sc_hd__a211oi_1
X_09110_ _07336_ _07338_ _01179_ VSS VSS VDD VDD _01274_ sky130_fd_sc_hd__nor3_1
X_09111_ _01201_ _01269_ _01274_ _01180_ VSS VSS VDD VDD _01275_
+ sky130_fd_sc_hd__o22ai_2
X_09112_ _07302_ _07292_ _01011_ VSS VSS VDD VDD _01276_ sky130_fd_sc_hd__nor3_1
X_09113_ _01012_ _01276_ VSS VSS VDD VDD _01277_ sky130_fd_sc_hd__or2_0
X_09114_ _07265_ _07267_ _07266_ VSS VSS VDD VDD _01278_ sky130_fd_sc_hd__nor3_1
X_09115_ _07250_ _00820_ VSS VSS VDD VDD _07263_ sky130_fd_sc_hd__nor2_1
X_09116_ _01004_ _07263_ VSS VSS VDD VDD _01279_ sky130_fd_sc_hd__nand2_2
X_09117_ _00846_ _01278_ _01004_ _01279_ VSS VSS VDD VDD _07283_
+ sky130_fd_sc_hd__o31ai_4
X_09118_ _07285_ _07287_ _00938_ VSS VSS VDD VDD _01280_ sky130_fd_sc_hd__nor3_1
X_09119_ _00939_ _01280_ _01059_ VSS VSS VDD VDD _01281_ sky130_fd_sc_hd__o21ai_0
X_09120_ _01059_ _07283_ _01281_ VSS VSS VDD VDD _07300_ sky130_fd_sc_hd__o21a_1
X_09121_ _01108_ _07300_ VSS VSS VDD VDD _01282_ sky130_fd_sc_hd__nor2_1
X_09122_ _01108_ _01277_ _01282_ VSS VSS VDD VDD _07317_ sky130_fd_sc_hd__a21oi_2
X_09123_ _07319_ _07321_ _01079_ VSS VSS VDD VDD _01283_ sky130_fd_sc_hd__nor3_1
X_09124_ _01080_ _01283_ VSS VSS VDD VDD _01284_ sky130_fd_sc_hd__nor2_1
X_09125_ _07317_ _01284_ _01173_ VSS VSS VDD VDD _07334_ sky130_fd_sc_hd__mux2_1
X_09126_ _01201_ _01268_ _07334_ VSS VSS VDD VDD _01285_ sky130_fd_sc_hd__or3_1
X_09127_ _01275_ _01285_ VSS VSS VDD VDD _07351_ sky130_fd_sc_hd__and2_0
X_09128_ _01247_ _01273_ _07351_ VSS VSS VDD VDD _01286_ sky130_fd_sc_hd__and3_1
X_09129_ _01273_ VSS VSS VDD VDD _01287_ sky130_fd_sc_hd__buf_4
X_09130_ _07353_ _00590_ VSS VSS VDD VDD _01288_ sky130_fd_sc_hd__xor2_4
X_09131_ _01247_ _01287_ _01288_ VSS VSS VDD VDD _01289_ sky130_fd_sc_hd__a21oi_2
X_09132_ _01286_ _01289_ VSS VSS VDD VDD _01290_ sky130_fd_sc_hd__nor2_2
X_09133_ _01157_ _01223_ VSS VSS VDD VDD _01291_ sky130_fd_sc_hd__nand2_1
X_09134_ _01205_ _01202_ _01142_ VSS VSS VDD VDD _01292_ sky130_fd_sc_hd__nor3_2
X_09135_ _01157_ _01223_ VSS VSS VDD VDD _01293_ sky130_fd_sc_hd__or2_1
X_09136_ _01291_ _01292_ _01293_ VSS VSS VDD VDD _01294_ sky130_fd_sc_hd__o21ai_4
X_09137_ _01201_ VSS VSS VDD VDD _01295_ sky130_fd_sc_hd__buf_6
X_09138_ _01262_ _01211_ _01225_ net15 VSS VSS VDD VDD _01296_
+ sky130_fd_sc_hd__o22a_1
X_09139_ _01212_ _01259_ VSS VSS VDD VDD _01297_ sky130_fd_sc_hd__nand2_2
X_09140_ _01295_ _01296_ _01297_ VSS VSS VDD VDD _01298_ sky130_fd_sc_hd__nor3_1
X_09141_ _01262_ _01211_ VSS VSS VDD VDD _01299_ sky130_fd_sc_hd__nor2_1
X_09142_ _01158_ _01160_ _01205_ _01258_ _01109_ VSS VSS VDD
+ VDD _01300_ sky130_fd_sc_hd__a2111oi_2
X_09143_ _01299_ _01300_ VSS VSS VDD VDD _01301_ sky130_fd_sc_hd__nor2_2
X_09144_ _01247_ _01298_ _01301_ VSS VSS VDD VDD _01302_ sky130_fd_sc_hd__o21ai_0
X_09145_ _01232_ VSS VSS VDD VDD _01303_ sky130_fd_sc_hd__clkbuf_4
X_09146_ _01171_ VSS VSS VDD VDD _07331_ sky130_fd_sc_hd__inv_1
X_09147_ _01303_ _07331_ _01236_ VSS VSS VDD VDD _01304_ sky130_fd_sc_hd__nand3_1
X_09148_ net5 _01269_ _01241_ VSS VSS VDD VDD _01305_ sky130_fd_sc_hd__o21ai_1
X_09149_ _01248_ _00592_ VSS VSS VDD VDD _01306_ sky130_fd_sc_hd__xnor2_2
X_09150_ _01304_ _01305_ _01306_ VSS VSS VDD VDD _01307_ sky130_fd_sc_hd__a21oi_2
X_09151_ net5 _01171_ _01269_ VSS VSS VDD VDD _01308_ sky130_fd_sc_hd__nor3_1
X_09152_ _01232_ _01236_ _01241_ VSS VSS VDD VDD _01309_ sky130_fd_sc_hd__a21boi_1
X_09153_ _00567_ _00592_ VSS VSS VDD VDD _01310_ sky130_fd_sc_hd__xnor2_1
X_09154_ _01308_ _01309_ _01310_ VSS VSS VDD VDD _01311_ sky130_fd_sc_hd__nor3_1
X_09155_ _01242_ _01238_ VSS VSS VDD VDD _01312_ sky130_fd_sc_hd__xor2_1
X_09156_ net21 _01269_ _01312_ VSS VSS VDD VDD _01313_ sky130_fd_sc_hd__o21ai_0
X_09157_ _01172_ _01237_ _01313_ _01230_ VSS VSS VDD VDD _01314_
+ sky130_fd_sc_hd__o211ai_1
X_09158_ _01269_ _01295_ VSS VSS VDD VDD _01315_ sky130_fd_sc_hd__nor2_8
X_09159_ _01303_ _01236_ _01312_ VSS VSS VDD VDD _01316_ sky130_fd_sc_hd__a21oi_1
X_09160_ _01172_ _01315_ _01316_ _01230_ VSS VSS VDD VDD _01317_
+ sky130_fd_sc_hd__a211o_1
X_09161_ _01307_ _01311_ _01314_ _01317_ VSS VSS VDD VDD _01318_
+ sky130_fd_sc_hd__o211ai_1
X_09162_ _01308_ _01309_ VSS VSS VDD VDD _01319_ sky130_fd_sc_hd__nor2_1
X_09163_ _01247_ _01287_ _01319_ VSS VSS VDD VDD _01320_ sky130_fd_sc_hd__nand3_2
X_09164_ _01127_ _01123_ VSS VSS VDD VDD _01321_ sky130_fd_sc_hd__and2_1
X_09165_ _01321_ _01221_ _01213_ _01223_ VSS VSS VDD VDD _01322_
+ sky130_fd_sc_hd__o211a_1
X_09166_ _01157_ _01223_ _01142_ VSS VSS VDD VDD _01323_ sky130_fd_sc_hd__nand3_1
X_09167_ _01157_ _01223_ VSS VSS VDD VDD _01324_ sky130_fd_sc_hd__and2_0
X_09168_ _01323_ _01324_ _01220_ VSS VSS VDD VDD _01325_ sky130_fd_sc_hd__mux2i_2
X_09169_ _01303_ _01322_ _01325_ VSS VSS VDD VDD _01326_ sky130_fd_sc_hd__a21oi_2
X_09170_ _01255_ _01256_ net15 VSS VSS VDD VDD _01327_ sky130_fd_sc_hd__mux2i_4
X_09171_ _01232_ _01269_ _01297_ _01327_ VSS VSS VDD VDD _01328_
+ sky130_fd_sc_hd__a211oi_2
X_09172_ _01326_ _01328_ VSS VSS VDD VDD _01329_ sky130_fd_sc_hd__nand2_1
X_09173_ _01294_ _01302_ _01318_ _01320_ _01329_ VSS VSS VDD
+ VDD _01330_ sky130_fd_sc_hd__a221oi_1
X_09174_ _01303_ _01236_ _01241_ _01248_ VSS VSS VDD VDD _01331_
+ sky130_fd_sc_hd__a211oi_1
X_09175_ _01155_ _01170_ _01248_ VSS VSS VDD VDD _01332_ sky130_fd_sc_hd__a21oi_1
X_09176_ _01248_ _01155_ _01170_ VSS VSS VDD VDD _01333_ sky130_fd_sc_hd__nand3_1
X_09177_ net5 _01269_ _01332_ _01333_ VSS VSS VDD VDD _01334_
+ sky130_fd_sc_hd__nor4b_1
X_09178_ _01331_ _01334_ _01251_ VSS VSS VDD VDD _01335_ sky130_fd_sc_hd__o21ai_2
X_09179_ _01287_ _01335_ VSS VSS VDD VDD _01336_ sky130_fd_sc_hd__nand2_2
X_09180_ _01246_ _01328_ _01298_ VSS VSS VDD VDD _01337_ sky130_fd_sc_hd__a21o_1
X_09181_ _01299_ _01300_ VSS VSS VDD VDD _01338_ sky130_fd_sc_hd__or2_2
X_09182_ _01295_ _01296_ _01297_ _01338_ VSS VSS VDD VDD _01339_
+ sky130_fd_sc_hd__o31ai_2
X_09183_ _01247_ _01328_ _01339_ VSS VSS VDD VDD _01340_ sky130_fd_sc_hd__a21oi_2
X_09184_ _01301_ _01336_ _01337_ _01340_ VSS VSS VDD VDD _01341_
+ sky130_fd_sc_hd__a31oi_4
X_09185_ _00594_ _01290_ _01330_ _01341_ VSS VSS VDD VDD _01342_
+ sky130_fd_sc_hd__o211a_1
X_09186_ _01286_ _01289_ VSS VSS VDD VDD _01343_ sky130_fd_sc_hd__or2_1
X_09187_ _07372_ _07371_ _07390_ VSS VSS VDD VDD _01344_ sky130_fd_sc_hd__o21a_1
X_09188_ _07389_ _01344_ _07387_ VSS VSS VDD VDD _01345_ sky130_fd_sc_hd__o21a_1
X_09189_ _07386_ _01345_ _07384_ VSS VSS VDD VDD _01346_ sky130_fd_sc_hd__o21a_1
X_09190_ _07383_ _01346_ _07381_ VSS VSS VDD VDD _01347_ sky130_fd_sc_hd__o21a_1
X_09191_ _07380_ _01347_ _07378_ VSS VSS VDD VDD _01348_ sky130_fd_sc_hd__o21a_1
X_09192_ _01348_ _07377_ _07375_ VSS VSS VDD VDD _01349_ sky130_fd_sc_hd__o21a_1
X_09193_ _01349_ _07374_ VSS VSS VDD VDD _01350_ sky130_fd_sc_hd__nor2_4
X_09194_ net21 _01236_ _01257_ VSS VSS VDD VDD _01351_ sky130_fd_sc_hd__o21ai_1
X_09195_ _01350_ _01351_ VSS VSS VDD VDD _01352_ sky130_fd_sc_hd__nor2_1
X_09196_ _00568_ _01272_ _01352_ VSS VSS VDD VDD _01353_ sky130_fd_sc_hd__nand3_1
X_09197_ _01286_ _01289_ _01352_ _01272_ _01248_ VSS VSS VDD
+ VDD _01354_ sky130_fd_sc_hd__o2111ai_1
X_09198_ _01343_ _01353_ _01354_ VSS VSS VDD VDD _01355_ sky130_fd_sc_hd__o21a_1
X_09199_ _01172_ _01231_ _01245_ _01237_ VSS VSS VDD VDD _01356_
+ sky130_fd_sc_hd__a22oi_4
X_09200_ net21 _01236_ _01260_ _01257_ VSS VSS VDD VDD _01357_
+ sky130_fd_sc_hd__o211ai_4
X_09201_ _01303_ _01263_ _01260_ _01338_ _01294_ VSS VSS VDD
+ VDD _01358_ sky130_fd_sc_hd__a311oi_2
X_09202_ _01299_ _01300_ _01292_ _01291_ _01293_ VSS VSS VDD
+ VDD _01359_ sky130_fd_sc_hd__o221ai_1
X_09203_ _01295_ _01296_ _01297_ _01359_ VSS VSS VDD VDD _01360_
+ sky130_fd_sc_hd__nor4_1
X_09204_ _01323_ _01324_ _01220_ VSS VSS VDD VDD _01361_ sky130_fd_sc_hd__mux2_1
X_09205_ _01110_ _01152_ VSS VSS VDD VDD _01362_ sky130_fd_sc_hd__nor2_1
X_09206_ _01119_ _01128_ VSS VSS VDD VDD _01363_ sky130_fd_sc_hd__nand2_1
X_09207_ _01363_ _01157_ _01141_ _01160_ VSS VSS VDD VDD _01364_
+ sky130_fd_sc_hd__nand4_1
X_09208_ _01141_ _01362_ _01364_ VSS VSS VDD VDD _01365_ sky130_fd_sc_hd__o21ai_4
X_09209_ _01303_ _01322_ _01361_ _01365_ VSS VSS VDD VDD _01366_
+ sky130_fd_sc_hd__a211oi_2
X_09210_ _01303_ _01322_ _01361_ _01365_ VSS VSS VDD VDD _01367_
+ sky130_fd_sc_hd__and4_1
X_09211_ _01203_ _01233_ _01223_ VSS VSS VDD VDD _01368_ sky130_fd_sc_hd__o21ai_1
X_09212_ _01368_ net5 _01214_ _01253_ _01321_ VSS VSS VDD
+ VDD _01369_ sky130_fd_sc_hd__o311ai_4
X_09213_ _01358_ _01360_ _01366_ _01367_ _01369_ VSS VSS VDD
+ VDD _01370_ sky130_fd_sc_hd__o221ai_4
X_09214_ _01321_ _01221_ _01213_ _01223_ VSS VSS VDD VDD _01371_
+ sky130_fd_sc_hd__o211ai_1
X_09215_ _01295_ _01371_ _01361_ VSS VSS VDD VDD _01372_ sky130_fd_sc_hd__nor3_1
X_09216_ _01365_ VSS VSS VDD VDD _01373_ sky130_fd_sc_hd__inv_1
X_09217_ _01326_ _01372_ _01369_ _01373_ VSS VSS VDD VDD _01374_
+ sky130_fd_sc_hd__o211ai_2
X_09218_ _01356_ _01357_ _01370_ _01374_ VSS VSS VDD VDD _01375_
+ sky130_fd_sc_hd__o31ai_4
X_09219_ _01266_ _01356_ VSS VSS VDD VDD _01376_ sky130_fd_sc_hd__nor2_8
X_09220_ _01275_ _01285_ _01350_ _01248_ VSS VSS VDD VDD _01377_
+ sky130_fd_sc_hd__a211o_1
X_09221_ _00567_ _01350_ _00594_ VSS VSS VDD VDD _01378_ sky130_fd_sc_hd__o21ai_0
X_09222_ _01275_ _01285_ _01378_ VSS VSS VDD VDD _01379_ sky130_fd_sc_hd__nand3_2
X_09223_ _01377_ _01319_ _01379_ VSS VSS VDD VDD _01380_ sky130_fd_sc_hd__and3_1
X_09224_ _01308_ _01309_ _01310_ VSS VSS VDD VDD _01381_ sky130_fd_sc_hd__o21ai_2
X_09225_ _01304_ _01305_ _01306_ VSS VSS VDD VDD _01382_ sky130_fd_sc_hd__nand3_1
X_09226_ _01248_ _01288_ VSS VSS VDD VDD _01383_ sky130_fd_sc_hd__xnor2_1
X_09227_ _00594_ _01288_ _01383_ _01350_ VSS VSS VDD VDD _01384_
+ sky130_fd_sc_hd__o22ai_4
X_09228_ _01172_ _01231_ _01237_ _01245_ _01384_ VSS VSS VDD
+ VDD _01385_ sky130_fd_sc_hd__a221o_1
X_09229_ _01291_ _01292_ _01293_ VSS VSS VDD VDD _01386_ sky130_fd_sc_hd__o21a_1
X_09230_ _01386_ _01328_ VSS VSS VDD VDD _01387_ sky130_fd_sc_hd__nand2_1
X_09231_ _01381_ _01382_ _01387_ _01271_ _01385_ VSS VSS VDD
+ VDD _01388_ sky130_fd_sc_hd__a2111oi_4
X_09232_ _01376_ _01380_ _01388_ VSS VSS VDD VDD _01389_ sky130_fd_sc_hd__a21o_1
X_09233_ _01375_ _01341_ _01389_ VSS VSS VDD VDD _01390_ sky130_fd_sc_hd__nand3_4
X_09234_ net21 _01371_ _01325_ VSS VSS VDD VDD _01391_ sky130_fd_sc_hd__nor3_1
X_09235_ _01365_ _01391_ VSS VSS VDD VDD _01392_ sky130_fd_sc_hd__xnor2_2
X_09236_ _01303_ _01263_ _01260_ _01301_ VSS VSS VDD VDD _01393_
+ sky130_fd_sc_hd__nand4_1
X_09237_ _01303_ _01269_ _01297_ _01327_ _01294_ VSS VSS VDD
+ VDD _01394_ sky130_fd_sc_hd__a2111oi_2
X_09238_ _01339_ _01393_ _01394_ VSS VSS VDD VDD _01395_ sky130_fd_sc_hd__nand3_1
X_09239_ _01287_ _01335_ _01356_ _01395_ VSS VSS VDD VDD _01396_
+ sky130_fd_sc_hd__a211oi_1
X_09240_ _01326_ _01372_ _01396_ VSS VSS VDD VDD _01397_ sky130_fd_sc_hd__o21ai_1
X_09241_ _01392_ _01397_ VSS VSS VDD VDD _01398_ sky130_fd_sc_hd__xor2_2
X_09242_ _01342_ _01355_ _01390_ _01398_ VSS VSS VDD VDD _01399_
+ sky130_fd_sc_hd__a31oi_4
X_09243_ _01398_ _01342_ _01355_ _01390_ VSS VSS VDD VDD _01400_
+ sky130_fd_sc_hd__and4_1
X_09244_ _01400_ VSS VSS VDD VDD _01401_ sky130_fd_sc_hd__buf_6
X_09245_ _01004_ _07267_ VSS VSS VDD VDD _07286_ sky130_fd_sc_hd__nor2_4
X_09246_ _07290_ _07288_ _07289_ VSS VSS VDD VDD _01402_ sky130_fd_sc_hd__nor3_1
X_09247_ _00938_ _01402_ _01059_ VSS VSS VDD VDD _01403_ sky130_fd_sc_hd__o21ai_0
X_09248_ _07286_ _01059_ _01403_ VSS VSS VDD VDD _07291_ sky130_fd_sc_hd__o21a_1
X_09249_ _07293_ _07295_ _01010_ VSS VSS VDD VDD _01404_ sky130_fd_sc_hd__nor3_1
X_09250_ _01011_ _01404_ _01108_ VSS VSS VDD VDD _01405_ sky130_fd_sc_hd__o21ai_0
X_09251_ _01108_ _07291_ _01405_ VSS VSS VDD VDD _07320_ sky130_fd_sc_hd__o21a_1
X_09252_ _01235_ _07320_ VSS VSS VDD VDD _01406_ sky130_fd_sc_hd__nand2_1
X_09253_ _07322_ _07324_ _01078_ VSS VSS VDD VDD _01407_ sky130_fd_sc_hd__nor3_1
X_09254_ _01079_ _01235_ _01407_ VSS VSS VDD VDD _01408_ sky130_fd_sc_hd__or3_1
X_09255_ _01406_ _01408_ VSS VSS VDD VDD _07337_ sky130_fd_sc_hd__nand2_1
X_09256_ _07339_ _07341_ _01178_ VSS VSS VDD VDD _01409_ sky130_fd_sc_hd__nor3_1
X_09257_ _01179_ _01409_ VSS VSS VDD VDD _01410_ sky130_fd_sc_hd__nor2_1
X_09258_ _07337_ _01410_ _01237_ VSS VSS VDD VDD _07354_ sky130_fd_sc_hd__mux2_1
X_09259_ _01247_ _01287_ _07354_ VSS VSS VDD VDD _01411_ sky130_fd_sc_hd__nand3_1
X_09260_ _07356_ _07358_ _00588_ VSS VSS VDD VDD _01412_ sky130_fd_sc_hd__nor3_1
X_09261_ _00589_ _01412_ VSS VSS VDD VDD _01413_ sky130_fd_sc_hd__nor2_1
X_09262_ _01356_ _01266_ _01413_ VSS VSS VDD VDD _01414_ sky130_fd_sc_hd__o21ai_1
X_09263_ _01411_ _01414_ _00568_ VSS VSS VDD VDD _01415_ sky130_fd_sc_hd__a21oi_1
X_09264_ _00568_ _01411_ _01414_ VSS VSS VDD VDD _01416_ sky130_fd_sc_hd__and3_1
X_09265_ _07393_ _07404_ _07407_ _07410_ VSS VSS VDD VDD _01417_
+ sky130_fd_sc_hd__nand4_1
X_09266_ _07395_ _07398_ _07401_ VSS VSS VDD VDD _01418_ sky130_fd_sc_hd__nand3_1
X_09267_ _01114_ _01417_ _01418_ VSS VSS VDD VDD _01419_ sky130_fd_sc_hd__nor3_1
X_09268_ _01415_ _01416_ _01419_ VSS VSS VDD VDD _01420_ sky130_fd_sc_hd__o21ai_1
X_09269_ _01248_ VSS VSS VDD VDD _01421_ sky130_fd_sc_hd__buf_4
X_09270_ _07375_ _07377_ _01348_ VSS VSS VDD VDD _01422_ sky130_fd_sc_hd__nor3_1
X_09271_ _01349_ _01422_ VSS VSS VDD VDD _01423_ sky130_fd_sc_hd__nor2_2
X_09272_ _01421_ _01423_ VSS VSS VDD VDD _01424_ sky130_fd_sc_hd__xnor2_1
X_09273_ _01419_ _01424_ VSS VSS VDD VDD _01425_ sky130_fd_sc_hd__nand2_1
X_09274_ _01390_ VSS VSS VDD VDD _01426_ sky130_fd_sc_hd__buf_8
X_09275_ _01420_ _01425_ _01426_ VSS VSS VDD VDD _01427_ sky130_fd_sc_hd__mux2_4
X_09276_ _01339_ _01393_ VSS VSS VDD VDD _01428_ sky130_fd_sc_hd__nand2_1
X_09277_ _01110_ _01223_ _01221_ _01368_ VSS VSS VDD VDD _01429_
+ sky130_fd_sc_hd__o31a_1
X_09278_ net10 _01428_ _01357_ _01429_ VSS VSS VDD VDD _01430_
+ sky130_fd_sc_hd__nor4_1
X_09279_ _01336_ _01430_ _01369_ VSS VSS VDD VDD _01431_ sky130_fd_sc_hd__a21oi_1
X_09280_ _01326_ _01372_ VSS VSS VDD VDD _01432_ sky130_fd_sc_hd__nor2_1
X_09281_ _01432_ _01396_ VSS VSS VDD VDD _01433_ sky130_fd_sc_hd__xnor2_1
X_09282_ _01392_ _01341_ _01389_ _01433_ VSS VSS VDD VDD _01434_
+ sky130_fd_sc_hd__nand4_1
X_09283_ _01431_ _01434_ VSS VSS VDD VDD _01435_ sky130_fd_sc_hd__nand2_4
X_09284_ _01381_ _01382_ _01385_ _01271_ _01357_ VSS VSS VDD
+ VDD _01436_ sky130_fd_sc_hd__a2111oi_1
X_09285_ _01376_ _01380_ _01436_ VSS VSS VDD VDD _01437_ sky130_fd_sc_hd__a21oi_2
X_09286_ _01338_ _01294_ VSS VSS VDD VDD _01438_ sky130_fd_sc_hd__nor2_1
X_09287_ _01356_ _01357_ _01370_ _01374_ VSS VSS VDD VDD _01439_
+ sky130_fd_sc_hd__o31a_2
X_09288_ _01438_ _01439_ VSS VSS VDD VDD _01440_ sky130_fd_sc_hd__nand2_1
X_09289_ _01437_ _01440_ _01433_ VSS VSS VDD VDD _01441_ sky130_fd_sc_hd__o21a_1
X_09290_ _01437_ _01440_ _01433_ VSS VSS VDD VDD _01442_ sky130_fd_sc_hd__nor3_1
X_09291_ _01172_ _01230_ _01237_ _01267_ _01270_ VSS VSS VDD
+ VDD _01443_ sky130_fd_sc_hd__o32a_1
X_09292_ net10 _01287_ _01443_ VSS VSS VDD VDD _01444_ sky130_fd_sc_hd__o21ai_1
X_09293_ _01387_ _01439_ _01444_ VSS VSS VDD VDD _01445_ sky130_fd_sc_hd__nor3_1
X_09294_ _01341_ _01445_ VSS VSS VDD VDD _01446_ sky130_fd_sc_hd__and2_0
X_09295_ _01446_ VSS VSS VDD VDD _01447_ sky130_fd_sc_hd__clkbuf_2
X_09296_ _01381_ _01382_ _01385_ VSS VSS VDD VDD _01448_ sky130_fd_sc_hd__a21oi_1
X_09297_ _01376_ _01380_ _01448_ VSS VSS VDD VDD _01449_ sky130_fd_sc_hd__a21oi_1
X_09298_ _01394_ _01443_ _01377_ _01379_ VSS VSS VDD VDD _01450_
+ sky130_fd_sc_hd__nand4_2
X_09299_ _00594_ _01288_ _01383_ _01350_ VSS VSS VDD VDD _01451_
+ sky130_fd_sc_hd__o22a_1
X_09300_ _01307_ _01311_ _01451_ VSS VSS VDD VDD _01452_ sky130_fd_sc_hd__o21ai_2
X_09301_ _01320_ _01450_ _01452_ _01376_ _01444_ VSS VSS VDD
+ VDD _01453_ sky130_fd_sc_hd__o221ai_4
X_09302_ _01303_ _01269_ _01327_ VSS VSS VDD VDD _01454_ sky130_fd_sc_hd__a21oi_1
X_09303_ net10 _01287_ _01454_ VSS VSS VDD VDD _01455_ sky130_fd_sc_hd__o21ai_1
X_09304_ _01247_ _01266_ _01351_ VSS VSS VDD VDD _01456_ sky130_fd_sc_hd__nand3_1
X_09305_ net21 _01297_ _01298_ VSS VSS VDD VDD _01457_ sky130_fd_sc_hd__a21oi_1
X_09306_ _01455_ _01456_ _01457_ VSS VSS VDD VDD _01458_ sky130_fd_sc_hd__a21boi_1
X_09307_ _01301_ _01336_ _01337_ _01340_ _01294_ VSS VSS VDD
+ VDD _01459_ sky130_fd_sc_hd__a311oi_1
X_09308_ _01271_ _01449_ _01453_ _01458_ _01459_ VSS VSS VDD
+ VDD _01460_ sky130_fd_sc_hd__o2111a_1
X_09309_ _01441_ _01442_ _01447_ _01460_ VSS VSS VDD VDD _01461_
+ sky130_fd_sc_hd__o22a_2
X_09310_ _01399_ _01401_ _01427_ _01435_ _01461_ VSS VSS VDD
+ VDD _01462_ sky130_fd_sc_hd__o2111ai_4
X_09311_ _01247_ _01287_ _01377_ _01379_ VSS VSS VDD VDD _01463_
+ sky130_fd_sc_hd__nand4_1
X_09312_ _01306_ _01451_ VSS VSS VDD VDD _01464_ sky130_fd_sc_hd__xnor2_1
X_09313_ net10 _01266_ _01464_ VSS VSS VDD VDD _01465_ sky130_fd_sc_hd__o21ai_0
X_09314_ _01304_ _01305_ VSS VSS VDD VDD _01466_ sky130_fd_sc_hd__nand2_1
X_09315_ _01463_ _01465_ _01466_ VSS VSS VDD VDD _01467_ sky130_fd_sc_hd__a21oi_1
X_09316_ _01466_ _01463_ _01465_ VSS VSS VDD VDD _01468_ sky130_fd_sc_hd__and3_1
X_09317_ _01248_ _01350_ VSS VSS VDD VDD _01469_ sky130_fd_sc_hd__xnor2_1
X_09318_ _01286_ _01289_ _01469_ VSS VSS VDD VDD _01470_ sky130_fd_sc_hd__nor3_1
X_09319_ _01286_ _01289_ _01469_ VSS VSS VDD VDD _01471_ sky130_fd_sc_hd__o21ai_0
X_09320_ _01467_ _01468_ _01470_ _01471_ VSS VSS VDD VDD _01472_
+ sky130_fd_sc_hd__nor4b_4
X_09321_ _01301_ _01336_ _01337_ _01340_ VSS VSS VDD VDD _01473_
+ sky130_fd_sc_hd__a31o_2
X_09322_ _01376_ _01380_ _01388_ VSS VSS VDD VDD _01474_ sky130_fd_sc_hd__a21oi_4
X_09323_ _01439_ _01473_ _01474_ _01343_ VSS VSS VDD VDD _01475_
+ sky130_fd_sc_hd__nor4_2
X_09324_ _07395_ _07394_ _07393_ VSS VSS VDD VDD _01476_ sky130_fd_sc_hd__o21a_1
X_09325_ _07392_ _01476_ _07410_ VSS VSS VDD VDD _01477_ sky130_fd_sc_hd__o21a_1
X_09326_ _07409_ _01477_ _07407_ VSS VSS VDD VDD _01478_ sky130_fd_sc_hd__o21a_1
X_09327_ _07406_ _01478_ _07404_ VSS VSS VDD VDD _01479_ sky130_fd_sc_hd__o21a_1
X_09328_ _07403_ _01479_ _07401_ VSS VSS VDD VDD _01480_ sky130_fd_sc_hd__o21a_1
X_09329_ _01480_ _07400_ VSS VSS VDD VDD _01481_ sky130_fd_sc_hd__nor2_4
X_09330_ _01481_ VSS VSS VDD VDD _01482_ sky130_fd_sc_hd__inv_2
X_09331_ _01482_ _07398_ _07397_ VSS VSS VDD VDD _01483_ sky130_fd_sc_hd__a21oi_4
X_09332_ _01421_ _01483_ VSS VSS VDD VDD _01484_ sky130_fd_sc_hd__nor2_1
X_09333_ _00567_ _01483_ _00594_ VSS VSS VDD VDD _01485_ sky130_fd_sc_hd__o21ai_4
X_09334_ _01411_ _01414_ VSS VSS VDD VDD _07373_ sky130_fd_sc_hd__nand2_2
X_09335_ _01484_ _01485_ _07373_ VSS VSS VDD VDD _01486_ sky130_fd_sc_hd__mux2i_4
X_09336_ _01421_ _01423_ _01483_ VSS VSS VDD VDD _01487_ sky130_fd_sc_hd__nor3_1
X_09337_ _01423_ _01485_ VSS VSS VDD VDD _01488_ sky130_fd_sc_hd__and2_4
X_09338_ _01439_ _01473_ _01474_ _01487_ _01488_ VSS VSS VDD
+ VDD _01489_ sky130_fd_sc_hd__o32ai_4
X_09339_ _01472_ _01475_ _01486_ _01390_ _01489_ VSS VSS VDD
+ VDD _01490_ sky130_fd_sc_hd__o221a_4
Xclone27 _01472_ _01475_ _01486_ _01390_ _01489_ VSS VSS VDD
+ VDD net27 sky130_fd_sc_hd__o221a_1
X_09341_ _01376_ VSS VSS VDD VDD _01492_ sky130_fd_sc_hd__buf_6
X_09342_ _01320_ _01450_ _01452_ net17 VSS VSS VDD VDD _01493_
+ sky130_fd_sc_hd__o22a_1
X_09343_ _01493_ _01447_ VSS VSS VDD VDD _01494_ sky130_fd_sc_hd__nor2_2
X_09344_ _01272_ _01494_ _01490_ _01453_ VSS VSS VDD VDD _01495_
+ sky130_fd_sc_hd__o2bb2ai_1
X_09345_ _01272_ _01462_ _01490_ _01495_ VSS VSS VDD VDD _01496_
+ sky130_fd_sc_hd__a31oi_4
X_09346_ _01399_ _01401_ _01461_ _01435_ _01490_ VSS VSS VDD
+ VDD _01497_ sky130_fd_sc_hd__o2111ai_4
X_09347_ _01375_ _01341_ _01389_ _01469_ VSS VSS VDD VDD _01498_
+ sky130_fd_sc_hd__a31oi_2
X_09348_ _01290_ _01498_ VSS VSS VDD VDD _01499_ sky130_fd_sc_hd__xnor2_2
X_09349_ _01485_ _01499_ VSS VSS VDD VDD _01500_ sky130_fd_sc_hd__xor2_2
X_09350_ _00568_ _01483_ VSS VSS VDD VDD _01501_ sky130_fd_sc_hd__xnor2_2
X_09351_ _07373_ _01423_ _01426_ VSS VSS VDD VDD _01502_ sky130_fd_sc_hd__mux2i_4
X_09352_ _01497_ _01500_ _01501_ _01502_ VSS VSS VDD VDD _01503_
+ sky130_fd_sc_hd__a31o_1
X_09353_ _01421_ _01483_ VSS VSS VDD VDD _01504_ sky130_fd_sc_hd__and2_0
X_09354_ _01350_ _01343_ VSS VSS VDD VDD _01505_ sky130_fd_sc_hd__xnor2_1
X_09355_ _01484_ _01504_ _01505_ net401 VSS VSS VDD VDD _01506_
+ sky130_fd_sc_hd__o211ai_1
X_09356_ _01343_ _01504_ VSS VSS VDD VDD _01507_ sky130_fd_sc_hd__nand2_1
X_09357_ _01290_ _01484_ VSS VSS VDD VDD _01508_ sky130_fd_sc_hd__nand2_1
X_09358_ _01507_ _01508_ net401 VSS VSS VDD VDD _01509_ sky130_fd_sc_hd__a21o_1
X_09359_ _01502_ _01506_ _01509_ VSS VSS VDD VDD _01510_ sky130_fd_sc_hd__and3_1
X_09360_ _01247_ _01287_ VSS VSS VDD VDD _01511_ sky130_fd_sc_hd__nand2_1
X_09361_ _01307_ _01311_ VSS VSS VDD VDD _01512_ sky130_fd_sc_hd__nor2_1
X_09362_ _01377_ _01379_ _01319_ _01511_ VSS VSS VDD VDD _01513_
+ sky130_fd_sc_hd__a211oi_2
X_09363_ _01511_ _01512_ _01384_ _01494_ _01513_ VSS VSS VDD
+ VDD _01514_ sky130_fd_sc_hd__a311o_2
X_09364_ _01497_ _01510_ _01514_ VSS VSS VDD VDD _01515_ sky130_fd_sc_hd__a21oi_1
X_09365_ _01496_ _01503_ _01515_ VSS VSS VDD VDD _01516_ sky130_fd_sc_hd__and3_1
X_09366_ _07420_ _01421_ VSS VSS VDD VDD _01517_ sky130_fd_sc_hd__nand2_1
X_09367_ _07420_ _00568_ VSS VSS VDD VDD _01518_ sky130_fd_sc_hd__nand2_1
X_09368_ _07359_ _07361_ _00587_ VSS VSS VDD VDD _01519_ sky130_fd_sc_hd__nor3_1
X_09369_ _07342_ _07344_ _01177_ VSS VSS VDD VDD _01520_ sky130_fd_sc_hd__nor3_1
X_09370_ _01073_ _07290_ VSS VSS VDD VDD _07294_ sky130_fd_sc_hd__nor2_2
X_09371_ _07296_ _07304_ _07303_ VSS VSS VDD VDD _01521_ sky130_fd_sc_hd__nor3_1
X_09372_ _01010_ _01521_ VSS VSS VDD VDD _01522_ sky130_fd_sc_hd__nor2_1
X_09373_ _07294_ _01522_ _01108_ VSS VSS VDD VDD _07323_ sky130_fd_sc_hd__mux2_4
X_09374_ _07325_ _07327_ _01077_ VSS VSS VDD VDD _01523_ sky130_fd_sc_hd__nor3_1
X_09375_ _01078_ _01235_ _01523_ VSS VSS VDD VDD _01524_ sky130_fd_sc_hd__nor3_1
X_09376_ _01235_ _07323_ _01524_ VSS VSS VDD VDD _07340_ sky130_fd_sc_hd__a21o_1
X_09377_ _01315_ _07340_ VSS VSS VDD VDD _01525_ sky130_fd_sc_hd__nand2_1
X_09378_ _01178_ _01315_ _01520_ _01525_ VSS VSS VDD VDD _07357_
+ sky130_fd_sc_hd__o31ai_2
X_09379_ net17 _07357_ VSS VSS VDD VDD _01526_ sky130_fd_sc_hd__nand2_1
X_09380_ _00588_ net17 _01519_ _01526_ VSS VSS VDD VDD _07376_
+ sky130_fd_sc_hd__o31ai_2
X_09381_ _07378_ _07380_ _01347_ VSS VSS VDD VDD _01527_ sky130_fd_sc_hd__nor3_1
X_09382_ _01348_ _01527_ VSS VSS VDD VDD _01528_ sky130_fd_sc_hd__nor2_1
X_09383_ _07376_ _01528_ _01390_ VSS VSS VDD VDD _01529_ sky130_fd_sc_hd__mux2i_4
X_09384_ _01427_ _01529_ VSS VSS VDD VDD _01530_ sky130_fd_sc_hd__nand2_2
X_09385_ _07398_ _01481_ VSS VSS VDD VDD _01531_ sky130_fd_sc_hd__xnor2_4
X_09386_ _01530_ _01531_ _01497_ VSS VSS VDD VDD _01532_ sky130_fd_sc_hd__mux2i_4
X_09387_ _01517_ _01518_ _01532_ VSS VSS VDD VDD _01533_ sky130_fd_sc_hd__mux2_1
X_09388_ _00594_ _01532_ VSS VSS VDD VDD _01534_ sky130_fd_sc_hd__or2_1
X_09389_ _01516_ _01533_ _01534_ VSS VSS VDD VDD _01535_ sky130_fd_sc_hd__and3_1
X_09390_ _01535_ VSS VSS VDD VDD _01536_ sky130_fd_sc_hd__buf_4
X_09391_ _01399_ _01401_ _01461_ _01435_ VSS VSS VDD VDD _01537_
+ sky130_fd_sc_hd__o211ai_1
X_09392_ _01472_ _01475_ VSS VSS VDD VDD _01538_ sky130_fd_sc_hd__nor2_1
X_09393_ _01427_ _01538_ VSS VSS VDD VDD _01539_ sky130_fd_sc_hd__nor2_1
X_09394_ _01537_ _01539_ VSS VSS VDD VDD _01540_ sky130_fd_sc_hd__nor2_2
X_09395_ _01271_ _01449_ _01453_ VSS VSS VDD VDD _01541_ sky130_fd_sc_hd__o21a_1
X_09396_ _01541_ _01458_ _01447_ VSS VSS VDD VDD _01542_ sky130_fd_sc_hd__a21o_1
X_09397_ _01386_ _01375_ _01473_ _01437_ VSS VSS VDD VDD _01543_
+ sky130_fd_sc_hd__a211oi_1
X_09398_ _01473_ _01437_ _01543_ VSS VSS VDD VDD _01544_ sky130_fd_sc_hd__a21o_1
X_09399_ net27 _01542_ _01544_ VSS VSS VDD VDD _01545_ sky130_fd_sc_hd__a21o_1
X_09400_ _01490_ _01544_ _01542_ VSS VSS VDD VDD _01546_ sky130_fd_sc_hd__nand3_1
X_09401_ _01336_ _01337_ VSS VSS VDD VDD _01547_ sky130_fd_sc_hd__nand2_1
X_09402_ _01375_ _01437_ _01547_ VSS VSS VDD VDD _01548_ sky130_fd_sc_hd__o21ai_0
X_09403_ _01547_ _01437_ _01338_ VSS VSS VDD VDD _01549_ sky130_fd_sc_hd__a21oi_1
X_09404_ _01386_ _01549_ VSS VSS VDD VDD _01550_ sky130_fd_sc_hd__nor2_1
X_09405_ _01438_ _01548_ _01550_ VSS VSS VDD VDD _01551_ sky130_fd_sc_hd__a21oi_1
X_09406_ _01545_ _01546_ _01551_ VSS VSS VDD VDD _01552_ sky130_fd_sc_hd__a21boi_2
X_09407_ _01455_ _01456_ VSS VSS VDD VDD _01553_ sky130_fd_sc_hd__nand2_1
X_09408_ net27 _01494_ _01272_ VSS VSS VDD VDD _01554_ sky130_fd_sc_hd__o21a_1
X_09409_ _01472_ _01475_ _01486_ net401 _01489_ VSS VSS VDD
+ VDD _01555_ sky130_fd_sc_hd__o221ai_4
X_09410_ _01272_ _01553_ VSS VSS VDD VDD _01556_ sky130_fd_sc_hd__nand2_1
X_09411_ _01493_ _01555_ _01556_ _01447_ VSS VSS VDD VDD _01557_
+ sky130_fd_sc_hd__a211o_1
X_09412_ net10 _01287_ VSS VSS VDD VDD _01558_ sky130_fd_sc_hd__nor2_1
X_09413_ _01341_ _01445_ _01493_ _01271_ VSS VSS VDD VDD _01559_
+ sky130_fd_sc_hd__a211oi_1
X_09414_ _01558_ _01559_ _01454_ VSS VSS VDD VDD _01560_ sky130_fd_sc_hd__o21ai_0
X_09415_ _01457_ _01560_ VSS VSS VDD VDD _01561_ sky130_fd_sc_hd__xnor2_1
X_09416_ _01553_ _01554_ _01557_ _01561_ VSS VSS VDD VDD _01562_
+ sky130_fd_sc_hd__o211a_2
X_09417_ _01540_ _01552_ _01562_ VSS VSS VDD VDD _01563_ sky130_fd_sc_hd__o21ai_4
X_09418_ _01399_ _01401_ VSS VSS VDD VDD _01564_ sky130_fd_sc_hd__or2_1
X_09419_ _01435_ _01427_ _01401_ _01399_ VSS VSS VDD VDD _01565_
+ sky130_fd_sc_hd__o2bb2ai_1
X_09420_ _01441_ _01442_ _01447_ _01460_ VSS VSS VDD VDD _01566_
+ sky130_fd_sc_hd__o22ai_2
X_09421_ _01566_ _01555_ VSS VSS VDD VDD _01567_ sky130_fd_sc_hd__nor2_2
X_09422_ _01564_ _01565_ _01567_ VSS VSS VDD VDD _01568_ sky130_fd_sc_hd__mux2i_2
X_09423_ _07418_ _07417_ _07416_ VSS VSS VDD VDD _01569_ sky130_fd_sc_hd__o21a_1
X_09424_ _07415_ _01569_ _07413_ VSS VSS VDD VDD _01570_ sky130_fd_sc_hd__o21a_1
X_09425_ _07412_ _01570_ _07430_ VSS VSS VDD VDD _01571_ sky130_fd_sc_hd__o21a_1
X_09426_ _07429_ _01571_ _07427_ VSS VSS VDD VDD _01572_ sky130_fd_sc_hd__o21a_1
X_09427_ _07426_ _01572_ _07424_ VSS VSS VDD VDD _01573_ sky130_fd_sc_hd__o21a_2
X_09428_ _01573_ _07423_ _07421_ VSS VSS VDD VDD _01574_ sky130_fd_sc_hd__o21ai_4
X_09429_ _01421_ _01531_ _01574_ VSS VSS VDD VDD _01575_ sky130_fd_sc_hd__nor3_4
X_09430_ _07398_ _01481_ VSS VSS VDD VDD _01576_ sky130_fd_sc_hd__xor2_2
X_09431_ _01574_ _01576_ _00568_ VSS VSS VDD VDD _01577_ sky130_fd_sc_hd__nor3_4
X_09432_ _01577_ _01575_ _01497_ VSS VSS VDD VDD _01578_ sky130_fd_sc_hd__o21ai_4
X_09433_ _01420_ _01425_ net401 VSS VSS VDD VDD _01579_ sky130_fd_sc_hd__mux2i_2
X_09434_ _01529_ VSS VSS VDD VDD _07396_ sky130_fd_sc_hd__inv_1
X_09435_ _01579_ _07396_ _01421_ VSS VSS VDD VDD _01580_ sky130_fd_sc_hd__o21ai_0
X_09436_ _00568_ _01427_ _01529_ VSS VSS VDD VDD _01581_ sky130_fd_sc_hd__nand3_1
X_09437_ _01580_ _01581_ _01497_ _01574_ VSS VSS VDD VDD _01582_
+ sky130_fd_sc_hd__a211o_2
X_09438_ _01399_ _01401_ _01427_ _01435_ VSS VSS VDD VDD _01583_
+ sky130_fd_sc_hd__o211ai_1
X_09439_ _01447_ _01460_ VSS VSS VDD VDD _01584_ sky130_fd_sc_hd__nor2_1
X_09440_ _01441_ _01442_ VSS VSS VDD VDD _01585_ sky130_fd_sc_hd__nor2_1
X_09441_ _01584_ _01555_ _01585_ VSS VSS VDD VDD _01586_ sky130_fd_sc_hd__o21a_1
X_09442_ _01567_ _01583_ _01586_ VSS VSS VDD VDD _01587_ sky130_fd_sc_hd__a21oi_2
X_09443_ _01568_ _01578_ _01582_ _01587_ VSS VSS VDD VDD _01588_
+ sky130_fd_sc_hd__nand4b_2
X_09444_ _01563_ _01588_ VSS VSS VDD VDD _01589_ sky130_fd_sc_hd__nor2_1
X_09445_ _07421_ _07423_ _01573_ VSS VSS VDD VDD _01590_ sky130_fd_sc_hd__or3_1
X_09446_ _01574_ _01590_ VSS VSS VDD VDD _01591_ sky130_fd_sc_hd__nand2_1
X_09447_ _01536_ _01589_ _01591_ VSS VSS VDD VDD _01592_ sky130_fd_sc_hd__a21boi_2
X_09448_ _01564_ _01567_ _01435_ VSS VSS VDD VDD _01593_ sky130_fd_sc_hd__a21oi_4
X_09449_ _01591_ _01593_ VSS VSS VDD VDD _01594_ sky130_fd_sc_hd__and2_0
X_09450_ _01496_ _01503_ _01515_ VSS VSS VDD VDD _01595_ sky130_fd_sc_hd__nand3_1
X_09451_ _01582_ _01578_ VSS VSS VDD VDD _01596_ sky130_fd_sc_hd__nand2_1
X_09452_ _01399_ _01401_ _01435_ VSS VSS VDD VDD _01597_ sky130_fd_sc_hd__o21ai_1
X_09453_ _01597_ _01586_ VSS VSS VDD VDD _01598_ sky130_fd_sc_hd__or2_0
X_09454_ _07418_ _07424_ _07427_ _07430_ VSS VSS VDD VDD _01599_
+ sky130_fd_sc_hd__nand4_1
X_09455_ _07413_ _07416_ _07421_ VSS VSS VDD VDD _01600_ sky130_fd_sc_hd__nand3_1
X_09456_ _01114_ _01599_ _01600_ VSS VSS VDD VDD _01601_ sky130_fd_sc_hd__nor3_2
X_09457_ _07420_ _01601_ VSS VSS VDD VDD _01602_ sky130_fd_sc_hd__nor2_1
X_09458_ _00594_ VSS VSS VDD VDD _01603_ sky130_fd_sc_hd__clkbuf_4
X_09459_ _00568_ _01602_ _01603_ VSS VSS VDD VDD _01604_ sky130_fd_sc_hd__o21ai_1
X_09460_ _01531_ _01604_ VSS VSS VDD VDD _01605_ sky130_fd_sc_hd__nand2_1
X_09461_ _01579_ _07396_ _01604_ VSS VSS VDD VDD _01606_ sky130_fd_sc_hd__o21ai_0
X_09462_ _01399_ _01401_ _01461_ _01435_ _01490_ VSS VSS VDD
+ VDD _01607_ sky130_fd_sc_hd__o2111a_2
X_09463_ _01605_ _01606_ _01607_ VSS VSS VDD VDD _01608_ sky130_fd_sc_hd__mux2i_1
X_09464_ _07362_ _07364_ _00586_ VSS VSS VDD VDD _01609_ sky130_fd_sc_hd__nor3_1
X_09465_ _07345_ _07347_ _01176_ VSS VSS VDD VDD _01610_ sky130_fd_sc_hd__nor3_1
X_09466_ _01057_ _01113_ _07304_ VSS VSS VDD VDD _07326_ sky130_fd_sc_hd__a21oi_2
X_09467_ _07330_ _07328_ _07329_ VSS VSS VDD VDD _01611_ sky130_fd_sc_hd__nor3_1
X_09468_ _01077_ _01611_ VSS VSS VDD VDD _01612_ sky130_fd_sc_hd__nor2_1
X_09469_ _07326_ _01612_ _01173_ VSS VSS VDD VDD _07343_ sky130_fd_sc_hd__mux2_1
X_09470_ _01315_ _07343_ VSS VSS VDD VDD _01613_ sky130_fd_sc_hd__nand2_1
X_09471_ _01177_ _01315_ _01610_ _01613_ VSS VSS VDD VDD _07360_
+ sky130_fd_sc_hd__o31ai_2
X_09472_ net17 _07360_ VSS VSS VDD VDD _01614_ sky130_fd_sc_hd__nand2_1
X_09473_ _00587_ net17 _01609_ _01614_ VSS VSS VDD VDD _07379_
+ sky130_fd_sc_hd__o31ai_1
X_09474_ _07381_ _07383_ _01346_ VSS VSS VDD VDD _01615_ sky130_fd_sc_hd__nor3_1
X_09475_ _01347_ _01615_ VSS VSS VDD VDD _01616_ sky130_fd_sc_hd__nor2_1
X_09476_ _07379_ _01616_ _01426_ VSS VSS VDD VDD _07399_ sky130_fd_sc_hd__mux2_1
X_09477_ _07401_ _07403_ _01479_ VSS VSS VDD VDD _01617_ sky130_fd_sc_hd__nor3_1
X_09478_ _01480_ _01617_ VSS VSS VDD VDD _01618_ sky130_fd_sc_hd__nor2_1
X_09479_ _01497_ VSS VSS VDD VDD _01619_ sky130_fd_sc_hd__buf_6
X_09480_ _07399_ _01618_ _01619_ VSS VSS VDD VDD _07419_ sky130_fd_sc_hd__mux2_1
X_09481_ _01421_ _01602_ VSS VSS VDD VDD _01620_ sky130_fd_sc_hd__nor2_1
X_09482_ _01576_ _01620_ VSS VSS VDD VDD _01621_ sky130_fd_sc_hd__nand2_1
X_09483_ _01427_ _01529_ _01620_ VSS VSS VDD VDD _01622_ sky130_fd_sc_hd__nand3_1
X_09484_ _01621_ _01622_ _01607_ VSS VSS VDD VDD _01623_ sky130_fd_sc_hd__mux2_1
X_09485_ _01598_ _01608_ _07419_ _01623_ VSS VSS VDD VDD _01624_
+ sky130_fd_sc_hd__or4b_1
X_09486_ _01595_ _01563_ _01596_ _01624_ VSS VSS VDD VDD _01625_
+ sky130_fd_sc_hd__nor4_1
X_09487_ _01619_ _01500_ _01501_ _01502_ VSS VSS VDD VDD _01626_
+ sky130_fd_sc_hd__a31oi_4
X_09488_ _01619_ _01510_ _01514_ VSS VSS VDD VDD _01627_ sky130_fd_sc_hd__a21o_1
X_09489_ _01540_ _01552_ _01496_ VSS VSS VDD VDD _01628_ sky130_fd_sc_hd__o21ai_1
X_09490_ _01421_ VSS VSS VDD VDD _01629_ sky130_fd_sc_hd__clkbuf_4
X_09491_ _01629_ _01114_ _01599_ _01600_ VSS VSS VDD VDD _01630_
+ sky130_fd_sc_hd__nor4_1
X_09492_ _01576_ _01630_ VSS VSS VDD VDD _01631_ sky130_fd_sc_hd__nand2_1
X_09493_ _01629_ _01531_ _01601_ VSS VSS VDD VDD _01632_ sky130_fd_sc_hd__nand3_1
X_09494_ _01607_ VSS VSS VDD VDD _01633_ sky130_fd_sc_hd__buf_6
X_09495_ _01631_ _01632_ net20 VSS VSS VDD VDD _01634_ sky130_fd_sc_hd__a21oi_1
X_09496_ _01579_ _07396_ _01601_ _01629_ VSS VSS VDD VDD _01635_
+ sky130_fd_sc_hd__o211ai_1
X_09497_ _01427_ _01529_ _01630_ VSS VSS VDD VDD _01636_ sky130_fd_sc_hd__nand3_1
X_09498_ _01635_ _01636_ net39 VSS VSS VDD VDD _01637_ sky130_fd_sc_hd__a21oi_1
X_09499_ _01634_ _01637_ _01562_ VSS VSS VDD VDD _01638_ sky130_fd_sc_hd__o21ai_0
X_09500_ _01626_ _01627_ _01628_ _01638_ VSS VSS VDD VDD _01639_
+ sky130_fd_sc_hd__nor4_2
X_09501_ _01594_ _01625_ _01639_ VSS VSS VDD VDD _01640_ sky130_fd_sc_hd__or3_2
X_09502_ _07433_ _07441_ _07447_ _07450_ VSS VSS VDD VDD _01641_
+ sky130_fd_sc_hd__nand4_1
X_09503_ _07436_ _07439_ _07444_ VSS VSS VDD VDD _01642_ sky130_fd_sc_hd__nand3_1
X_09504_ _01114_ _01641_ _01642_ VSS VSS VDD VDD _01643_ sky130_fd_sc_hd__nor3_1
X_09505_ _01592_ _01640_ _00569_ _01643_ VSS VSS VDD VDD _01644_
+ sky130_fd_sc_hd__o211a_1
X_09506_ _01516_ _01533_ _01534_ VSS VSS VDD VDD _01645_ sky130_fd_sc_hd__nand3_4
X_09507_ _01563_ _01588_ _01645_ _01591_ VSS VSS VDD VDD _01646_
+ sky130_fd_sc_hd__o31ai_4
X_09508_ _01594_ _01625_ _01639_ VSS VSS VDD VDD _01647_ sky130_fd_sc_hd__nor3_2
X_09509_ _01629_ _01643_ _01646_ _01647_ VSS VSS VDD VDD _01648_
+ sky130_fd_sc_hd__nand4_2
X_09510_ net401 _01486_ _01489_ VSS VSS VDD VDD _01649_ sky130_fd_sc_hd__o21ai_1
X_09511_ _01649_ _01499_ VSS VSS VDD VDD _01650_ sky130_fd_sc_hd__xor2_1
X_09512_ net20 _01650_ VSS VSS VDD VDD _01651_ sky130_fd_sc_hd__nor2_4
X_09513_ _01514_ _01651_ VSS VSS VDD VDD _01652_ sky130_fd_sc_hd__nor2_2
X_09514_ _01644_ _01648_ _01652_ VSS VSS VDD VDD _01653_ sky130_fd_sc_hd__nand3b_4
X_09515_ _01568_ _01593_ VSS VSS VDD VDD _01654_ sky130_fd_sc_hd__nor2_1
X_09516_ _01597_ _01586_ VSS VSS VDD VDD _01655_ sky130_fd_sc_hd__nor2_1
X_09517_ _01540_ _01552_ _01655_ VSS VSS VDD VDD _01656_ sky130_fd_sc_hd__o21a_1
X_09518_ _01578_ _01582_ _01562_ VSS VSS VDD VDD _01657_ sky130_fd_sc_hd__and3_4
X_09519_ _01656_ _01657_ VSS VSS VDD VDD _01658_ sky130_fd_sc_hd__and2_4
Xclone7 _02624_ VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
X_09521_ _01553_ _01554_ _01557_ VSS VSS VDD VDD _01660_ sky130_fd_sc_hd__o21a_1
X_09522_ _01496_ _01660_ VSS VSS VDD VDD _01661_ sky130_fd_sc_hd__and2_0
X_09523_ _01496_ _01660_ VSS VSS VDD VDD _01662_ sky130_fd_sc_hd__nor2b_1
X_09524_ _07420_ _01574_ VSS VSS VDD VDD _01663_ sky130_fd_sc_hd__nor2b_1
X_09525_ _01421_ _01663_ VSS VSS VDD VDD _01664_ sky130_fd_sc_hd__or2_0
X_09526_ _00568_ _01663_ _00594_ VSS VSS VDD VDD _01665_ sky130_fd_sc_hd__o21ai_0
X_09527_ _01579_ _07396_ _01665_ VSS VSS VDD VDD _01666_ sky130_fd_sc_hd__o21ai_0
X_09528_ _01530_ _01664_ _01666_ _01607_ VSS VSS VDD VDD _01667_
+ sky130_fd_sc_hd__o211ai_2
X_09529_ _01531_ _01665_ VSS VSS VDD VDD _01668_ sky130_fd_sc_hd__nand2_1
X_09530_ _01531_ _01664_ _01668_ net39 VSS VSS VDD VDD _01669_
+ sky130_fd_sc_hd__o211ai_2
X_09531_ _01667_ _01669_ _01626_ _01627_ VSS VSS VDD VDD _01670_
+ sky130_fd_sc_hd__a211oi_2
X_09532_ _01661_ _01662_ _01670_ VSS VSS VDD VDD _01671_ sky130_fd_sc_hd__mux2_1
X_09533_ _01589_ _01654_ _01658_ _01671_ VSS VSS VDD VDD _01672_
+ sky130_fd_sc_hd__o22a_1
X_09534_ _01654_ _01671_ _01536_ VSS VSS VDD VDD _01673_ sky130_fd_sc_hd__a21o_1
X_09535_ _01672_ _01673_ VSS VSS VDD VDD _01674_ sky130_fd_sc_hd__nand2_1
X_09536_ _01541_ _01458_ _01447_ VSS VSS VDD VDD _01675_ sky130_fd_sc_hd__a21oi_1
X_09537_ _01555_ _01544_ _01540_ _01675_ VSS VSS VDD VDD _01676_
+ sky130_fd_sc_hd__nor4_1
X_09538_ _01555_ _01675_ _01544_ VSS VSS VDD VDD _01677_ sky130_fd_sc_hd__o21ai_0
X_09539_ _01676_ _01677_ VSS VSS VDD VDD _01678_ sky130_fd_sc_hd__nand2b_1
X_09540_ _01678_ VSS VSS VDD VDD _01679_ sky130_fd_sc_hd__clkbuf_4
X_09541_ _01563_ _01596_ VSS VSS VDD VDD _01680_ sky130_fd_sc_hd__nor2_2
X_09542_ _00569_ _01532_ VSS VSS VDD VDD _01681_ sky130_fd_sc_hd__xnor2_1
X_09543_ _01681_ _01601_ VSS VSS VDD VDD _01682_ sky130_fd_sc_hd__nand2_1
X_09544_ _01682_ _01655_ VSS VSS VDD VDD _01683_ sky130_fd_sc_hd__nand2_1
X_09545_ _01561_ _01660_ VSS VSS VDD VDD _01684_ sky130_fd_sc_hd__nand2_1
X_09546_ net39 _01510_ _01582_ _01578_ _01626_ VSS VSS VDD
+ VDD _01685_ sky130_fd_sc_hd__a221oi_4
X_09547_ _01551_ _01676_ VSS VSS VDD VDD _01686_ sky130_fd_sc_hd__xnor2_1
X_09548_ _01684_ _01645_ _01685_ _01679_ _01686_ VSS VSS VDD
+ VDD _01687_ sky130_fd_sc_hd__o41a_1
X_09549_ _01680_ _01536_ _01683_ _01687_ VSS VSS VDD VDD _01688_
+ sky130_fd_sc_hd__a31o_1
X_09550_ _01582_ _01578_ VSS VSS VDD VDD _01689_ sky130_fd_sc_hd__and2_0
X_09551_ _01689_ _01656_ _01685_ _01684_ VSS VSS VDD VDD _01690_
+ sky130_fd_sc_hd__a211oi_1
X_09552_ _01566_ _01555_ _01576_ VSS VSS VDD VDD _01691_ sky130_fd_sc_hd__o21ai_0
X_09553_ _01461_ _01427_ net27 _01529_ VSS VSS VDD VDD _01692_
+ sky130_fd_sc_hd__nand4_1
X_09554_ _01604_ _01691_ _01692_ _01586_ _01597_ VSS VSS VDD
+ VDD _01693_ sky130_fd_sc_hd__a311oi_1
X_09555_ _01623_ _01582_ _01578_ _01693_ VSS VSS VDD VDD _01694_
+ sky130_fd_sc_hd__nand4_1
X_09556_ _01563_ _01694_ _01670_ _01661_ VSS VSS VDD VDD _01695_
+ sky130_fd_sc_hd__o211ai_1
X_09557_ _01272_ _01553_ _01537_ net27 _01561_ VSS VSS VDD
+ VDD _01696_ sky130_fd_sc_hd__a41oi_1
X_09558_ net27 _01542_ _01696_ VSS VSS VDD VDD _01697_ sky130_fd_sc_hd__a21oi_1
X_09559_ _01540_ _01697_ VSS VSS VDD VDD _01698_ sky130_fd_sc_hd__nor2_1
X_09560_ _01536_ _01690_ _01695_ _01698_ VSS VSS VDD VDD _01699_
+ sky130_fd_sc_hd__a22o_1
X_09561_ _01680_ _01536_ _01587_ VSS VSS VDD VDD _01700_ sky130_fd_sc_hd__a21o_1
X_09562_ _01598_ _01533_ _01534_ _01587_ VSS VSS VDD VDD _01701_
+ sky130_fd_sc_hd__and4_1
X_09563_ _01516_ _01680_ _01701_ VSS VSS VDD VDD _01702_ sky130_fd_sc_hd__nand3_1
X_09564_ _01699_ _01700_ _01702_ VSS VSS VDD VDD _01703_ sky130_fd_sc_hd__nand3b_1
X_09565_ _01674_ _01679_ _01688_ _01703_ VSS VSS VDD VDD _01704_
+ sky130_fd_sc_hd__or4_1
X_09566_ _01704_ VSS VSS VDD VDD _01705_ sky130_fd_sc_hd__buf_2
X_09567_ _01653_ _01705_ VSS VSS VDD VDD _01706_ sky130_fd_sc_hd__or2_0
X_09568_ _01706_ VSS VSS VDD VDD _01707_ sky130_fd_sc_hd__buf_4
X_09569_ _07441_ _07440_ _07439_ VSS VSS VDD VDD _01708_ sky130_fd_sc_hd__o21a_1
X_09570_ _07438_ _01708_ _07436_ VSS VSS VDD VDD _01709_ sky130_fd_sc_hd__o21a_1
X_09571_ _07435_ _01709_ _07433_ VSS VSS VDD VDD _01710_ sky130_fd_sc_hd__o21a_1
X_09572_ _07432_ _01710_ _07450_ VSS VSS VDD VDD _01711_ sky130_fd_sc_hd__o21a_1
X_09573_ _07449_ _01711_ _07447_ VSS VSS VDD VDD _01712_ sky130_fd_sc_hd__o21a_1
X_09574_ _01712_ _07446_ _07444_ VSS VSS VDD VDD _01713_ sky130_fd_sc_hd__o21ai_2
X_09575_ _07443_ _01713_ VSS VSS VDD VDD _01714_ sky130_fd_sc_hd__nand2b_2
X_09576_ _01592_ _01640_ _01714_ _00569_ VSS VSS VDD VDD _01715_
+ sky130_fd_sc_hd__o211ai_4
X_09577_ _07443_ _01713_ VSS VSS VDD VDD _01716_ sky130_fd_sc_hd__nor2b_4
X_09578_ _00569_ _01716_ _01603_ VSS VSS VDD VDD _01717_ sky130_fd_sc_hd__o21ai_2
X_09579_ _01646_ _01647_ _01717_ VSS VSS VDD VDD _01718_ sky130_fd_sc_hd__nand3_2
X_09580_ _00569_ _01663_ VSS VSS VDD VDD _01719_ sky130_fd_sc_hd__xnor2_1
X_09581_ _01536_ _01658_ _01719_ VSS VSS VDD VDD _01720_ sky130_fd_sc_hd__a21boi_1
X_09582_ _01532_ _01720_ VSS VSS VDD VDD _01721_ sky130_fd_sc_hd__xor2_2
X_09583_ _01667_ _01669_ VSS VSS VDD VDD _01722_ sky130_fd_sc_hd__nand2_1
X_09584_ net39 _01501_ VSS VSS VDD VDD _01723_ sky130_fd_sc_hd__nand2_1
X_09585_ _01502_ _01723_ VSS VSS VDD VDD _01724_ sky130_fd_sc_hd__xnor2_2
X_09586_ _01722_ _01724_ VSS VSS VDD VDD _01725_ sky130_fd_sc_hd__nand2_2
X_09587_ _01536_ _01658_ _01725_ VSS VSS VDD VDD _01726_ sky130_fd_sc_hd__a21o_1
X_09588_ _01722_ _01724_ _01726_ VSS VSS VDD VDD _01727_ sky130_fd_sc_hd__o21a_2
X_09589_ _01715_ _01718_ _01721_ _01727_ VSS VSS VDD VDD _01728_
+ sky130_fd_sc_hd__nand4_4
X_09590_ _01651_ _01725_ VSS VSS VDD VDD _01729_ sky130_fd_sc_hd__and2_0
X_09591_ _01536_ VSS VSS VDD VDD _01730_ sky130_fd_sc_hd__buf_4
X_09592_ _01730_ _01658_ _01651_ _01725_ VSS VSS VDD VDD _01731_
+ sky130_fd_sc_hd__a211o_1
X_09593_ _01729_ _01731_ VSS VSS VDD VDD _01732_ sky130_fd_sc_hd__nor2b_2
X_09594_ _01658_ _01730_ VSS VSS VDD VDD _01733_ sky130_fd_sc_hd__nand2_4
X_09595_ _01671_ net33 VSS VSS VDD VDD _01734_ sky130_fd_sc_hd__nand2b_1
X_09596_ _01511_ _01512_ _01384_ _01494_ _01513_ VSS VSS VDD
+ VDD _01735_ sky130_fd_sc_hd__a311oi_4
X_09597_ _01649_ _01499_ VSS VSS VDD VDD _01736_ sky130_fd_sc_hd__nor2_1
X_09598_ _01462_ _01538_ _01736_ VSS VSS VDD VDD _01737_ sky130_fd_sc_hd__o21ai_2
X_09599_ _01735_ _01651_ _01737_ VSS VSS VDD VDD _01738_ sky130_fd_sc_hd__nand3_1
X_09600_ _01735_ _01737_ _01738_ VSS VSS VDD VDD _01739_ sky130_fd_sc_hd__o21ai_0
X_09601_ _01735_ _01725_ _01737_ _01739_ VSS VSS VDD VDD _01740_
+ sky130_fd_sc_hd__a31oi_2
X_09602_ _01735_ _01651_ _01725_ _01740_ net33 VSS VSS VDD
+ VDD _01741_ sky130_fd_sc_hd__o311ai_4
X_09603_ _01732_ _01734_ _01741_ VSS VSS VDD VDD _01742_ sky130_fd_sc_hd__nand3_1
X_09604_ _01699_ _01728_ _01742_ VSS VSS VDD VDD _01743_ sky130_fd_sc_hd__or3_2
X_09605_ _07404_ _07406_ _01478_ VSS VSS VDD VDD _01744_ sky130_fd_sc_hd__nor3_1
X_09606_ _01439_ _01474_ _01473_ VSS VSS VDD VDD _01745_ sky130_fd_sc_hd__nor3_4
X_09607_ _07384_ _07386_ _01345_ VSS VSS VDD VDD _01746_ sky130_fd_sc_hd__nor3_1
X_09608_ _07365_ _07367_ _00585_ VSS VSS VDD VDD _01747_ sky130_fd_sc_hd__nor3_1
X_09609_ _07350_ _07348_ _07349_ VSS VSS VDD VDD _01748_ sky130_fd_sc_hd__nor3_1
X_09610_ _07330_ _01235_ VSS VSS VDD VDD _07346_ sky130_fd_sc_hd__nor2_8
X_09611_ _01315_ _07346_ VSS VSS VDD VDD _01749_ sky130_fd_sc_hd__nand2_2
X_09612_ _01176_ _01315_ _01748_ _01749_ VSS VSS VDD VDD _07363_
+ sky130_fd_sc_hd__o31ai_4
X_09613_ _01492_ _07363_ VSS VSS VDD VDD _01750_ sky130_fd_sc_hd__nand2_1
X_09614_ _00586_ _01492_ _01747_ _01750_ VSS VSS VDD VDD _07382_
+ sky130_fd_sc_hd__o31ai_1
X_09615_ _01745_ _07382_ VSS VSS VDD VDD _01751_ sky130_fd_sc_hd__nand2_1
X_09616_ _01346_ _01745_ _01746_ _01751_ VSS VSS VDD VDD _07402_
+ sky130_fd_sc_hd__o31ai_1
X_09617_ net20 _07402_ VSS VSS VDD VDD _01752_ sky130_fd_sc_hd__nand2_1
X_09618_ _01479_ net20 _01744_ _01752_ VSS VSS VDD VDD _07422_
+ sky130_fd_sc_hd__o31ai_4
X_09619_ _07424_ _07426_ _01572_ VSS VSS VDD VDD _01753_ sky130_fd_sc_hd__nor3_1
X_09620_ _01573_ _01753_ VSS VSS VDD VDD _01754_ sky130_fd_sc_hd__nor2_1
X_09621_ _07422_ _01754_ _01733_ VSS VSS VDD VDD _01755_ sky130_fd_sc_hd__mux2i_4
X_09622_ _01573_ _01753_ _00569_ VSS VSS VDD VDD _01756_ sky130_fd_sc_hd__o21ai_0
X_09623_ _01629_ _01754_ VSS VSS VDD VDD _01757_ sky130_fd_sc_hd__nand2_1
X_09624_ _07464_ _07463_ _07462_ VSS VSS VDD VDD _01758_ sky130_fd_sc_hd__o21a_1
X_09625_ _07461_ _01758_ _07459_ VSS VSS VDD VDD _01759_ sky130_fd_sc_hd__o21a_1
X_09626_ _07458_ _01759_ _07456_ VSS VSS VDD VDD _01760_ sky130_fd_sc_hd__o21a_1
X_09627_ _07455_ _01760_ _07453_ VSS VSS VDD VDD _01761_ sky130_fd_sc_hd__o21a_1
X_09628_ _07452_ _01761_ _07470_ VSS VSS VDD VDD _01762_ sky130_fd_sc_hd__o21a_1
X_09629_ _01762_ _07469_ _07467_ VSS VSS VDD VDD _01763_ sky130_fd_sc_hd__o21ai_1
X_09630_ _07466_ _01763_ VSS VSS VDD VDD _01764_ sky130_fd_sc_hd__nor2b_4
Xclone18 _02749_ VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_2
X_09632_ _01730_ _01658_ _01756_ _01757_ _01764_ VSS VSS VDD
+ VDD _01766_ sky130_fd_sc_hd__a221oi_1
X_09633_ _01764_ _07422_ _01629_ VSS VSS VDD VDD _01767_ sky130_fd_sc_hd__nand3b_4
X_09634_ _01629_ _01764_ _07422_ VSS VSS VDD VDD _01768_ sky130_fd_sc_hd__or3_1
X_09635_ _01656_ _01657_ VSS VSS VDD VDD _01769_ sky130_fd_sc_hd__nand2_1
X_09636_ _01767_ _01768_ _01645_ _01769_ VSS VSS VDD VDD _01770_
+ sky130_fd_sc_hd__a211oi_2
X_09637_ _01770_ _01766_ VSS VSS VDD VDD _01771_ sky130_fd_sc_hd__nor2_2
X_09638_ _01646_ _01647_ VSS VSS VDD VDD _01772_ sky130_fd_sc_hd__nand2_2
X_09639_ _01603_ _01755_ _01771_ _01772_ VSS VSS VDD VDD _01773_
+ sky130_fd_sc_hd__o211ai_4
X_09640_ _01722_ _01724_ _01726_ VSS VSS VDD VDD _01774_ sky130_fd_sc_hd__o21ai_1
X_09641_ _01715_ _01718_ _01721_ VSS VSS VDD VDD _01775_ sky130_fd_sc_hd__and3_1
X_09642_ _01651_ _01774_ _01775_ VSS VSS VDD VDD _01776_ sky130_fd_sc_hd__or3_1
X_09643_ _01592_ _01640_ VSS VSS VDD VDD _01777_ sky130_fd_sc_hd__nor2_1
X_09644_ _01532_ _01716_ _01719_ VSS VSS VDD VDD _01778_ sky130_fd_sc_hd__nand3_1
X_09645_ _01532_ _01714_ VSS VSS VDD VDD _01779_ sky130_fd_sc_hd__nor2_1
X_09646_ _01730_ _01656_ _01657_ _01779_ VSS VSS VDD VDD _01780_
+ sky130_fd_sc_hd__nand4_1
X_09647_ _01657_ _01778_ VSS VSS VDD VDD _01781_ sky130_fd_sc_hd__nor2_1
X_09648_ _01656_ _01778_ VSS VSS VDD VDD _01782_ sky130_fd_sc_hd__nor2_1
X_09649_ _01532_ _01714_ _01719_ VSS VSS VDD VDD _01783_ sky130_fd_sc_hd__nor3_1
X_09650_ _01781_ _01782_ _01783_ VSS VSS VDD VDD _01784_ sky130_fd_sc_hd__nor3_1
X_09651_ _01730_ _01778_ _01780_ _01784_ VSS VSS VDD VDD _01785_
+ sky130_fd_sc_hd__o211ai_1
X_09652_ _01629_ VSS VSS VDD VDD _01786_ sky130_fd_sc_hd__buf_4
X_09653_ _01603_ _01777_ _01785_ _01786_ VSS VSS VDD VDD _01787_
+ sky130_fd_sc_hd__a31oi_1
X_09654_ _01603_ _01592_ _01640_ _01714_ VSS VSS VDD VDD _01788_
+ sky130_fd_sc_hd__nor4_1
X_09655_ _01646_ _01647_ _01716_ VSS VSS VDD VDD _01789_ sky130_fd_sc_hd__a21oi_1
X_09656_ _01788_ _01789_ _01721_ VSS VSS VDD VDD _01790_ sky130_fd_sc_hd__o21ai_0
X_09657_ net20 _01531_ VSS VSS VDD VDD _01791_ sky130_fd_sc_hd__nor2_1
X_09658_ net39 _01530_ VSS VSS VDD VDD _01792_ sky130_fd_sc_hd__nor2_1
X_09659_ _01645_ _01769_ _01719_ _01532_ VSS VSS VDD VDD _01793_
+ sky130_fd_sc_hd__o211ai_1
X_09660_ _01791_ _01792_ _01720_ _01793_ _01714_ VSS VSS VDD
+ VDD _01794_ sky130_fd_sc_hd__o311a_1
X_09661_ _01785_ _01794_ _01777_ VSS VSS VDD VDD _01795_ sky130_fd_sc_hd__mux2i_1
X_09662_ _07446_ _01712_ VSS VSS VDD VDD _01796_ sky130_fd_sc_hd__nor2_2
X_09663_ _07444_ _01796_ VSS VSS VDD VDD _01797_ sky130_fd_sc_hd__xor2_2
X_09664_ _07444_ _01796_ VSS VSS VDD VDD _01798_ sky130_fd_sc_hd__xnor2_4
X_09665_ _00569_ _01798_ VSS VSS VDD VDD _01799_ sky130_fd_sc_hd__xnor2_1
X_09666_ _01603_ _01797_ _01799_ _01764_ VSS VSS VDD VDD _01800_
+ sky130_fd_sc_hd__o22ai_2
X_09667_ _01787_ _01790_ _01795_ _01786_ _01800_ VSS VSS VDD
+ VDD _01801_ sky130_fd_sc_hd__a221o_2
X_09668_ _01707_ _01773_ _01743_ _01776_ _01801_ VSS VSS VDD
+ VDD _01802_ sky130_fd_sc_hd__o32ai_4
X_09669_ _01496_ _01652_ VSS VSS VDD VDD _01803_ sky130_fd_sc_hd__nand2_1
X_09670_ _01496_ _01670_ _01726_ _01803_ VSS VSS VDD VDD _01804_
+ sky130_fd_sc_hd__o22a_1
X_09671_ _01741_ _01804_ VSS VSS VDD VDD _01805_ sky130_fd_sc_hd__nand2_1
X_09672_ _01729_ _01731_ VSS VSS VDD VDD _01806_ sky130_fd_sc_hd__nand2b_2
X_09673_ _01735_ _01737_ VSS VSS VDD VDD _01807_ sky130_fd_sc_hd__xnor2_1
X_09674_ _01496_ _01807_ VSS VSS VDD VDD _01808_ sky130_fd_sc_hd__nand2_1
X_09675_ _01806_ _01808_ _01804_ VSS VSS VDD VDD _01809_ sky130_fd_sc_hd__o21ai_0
X_09676_ _01715_ _01727_ _01721_ _01718_ VSS VSS VDD VDD _01810_
+ sky130_fd_sc_hd__and4_4
X_09677_ _01810_ VSS VSS VDD VDD _01811_ sky130_fd_sc_hd__buf_4
X_09678_ _01805_ _01809_ _01811_ VSS VSS VDD VDD _01812_ sky130_fd_sc_hd__mux2i_1
X_09679_ _01806_ _01808_ VSS VSS VDD VDD _01813_ sky130_fd_sc_hd__nor2_1
X_09680_ _01705_ _01813_ _01653_ _01728_ VSS VSS VDD VDD _01814_
+ sky130_fd_sc_hd__a211oi_1
X_09681_ _01644_ _01648_ _01652_ VSS VSS VDD VDD _01815_ sky130_fd_sc_hd__and3b_1
X_09682_ _01741_ VSS VSS VDD VDD _01816_ sky130_fd_sc_hd__clkinvlp_4
X_09683_ _01815_ _01811_ _01705_ _01806_ _01816_ VSS VSS VDD
+ VDD _01817_ sky130_fd_sc_hd__a32oi_1
X_09684_ _01812_ _01814_ _01817_ VSS VSS VDD VDD _01818_ sky130_fd_sc_hd__o21a_4
X_09685_ _01818_ _01802_ VSS VSS VDD VDD _01819_ sky130_fd_sc_hd__and2_4
X_09686_ _01819_ VSS VSS VDD VDD _01820_ sky130_fd_sc_hd__buf_8
X_09687_ _01645_ _01685_ VSS VSS VDD VDD _01821_ sky130_fd_sc_hd__nor2_1
X_09688_ _01660_ _01821_ _01695_ VSS VSS VDD VDD _01822_ sky130_fd_sc_hd__o21ai_1
X_09689_ _01730_ _01690_ VSS VSS VDD VDD _01823_ sky130_fd_sc_hd__and2_0
X_09690_ _01679_ _01823_ VSS VSS VDD VDD _01824_ sky130_fd_sc_hd__xor2_1
X_09691_ _01822_ _01824_ VSS VSS VDD VDD _01825_ sky130_fd_sc_hd__nor2_1
X_09692_ _01699_ _01728_ _01742_ VSS VSS VDD VDD _01826_ sky130_fd_sc_hd__nor3_2
X_09693_ _01732_ _01734_ _01741_ VSS VSS VDD VDD _01827_ sky130_fd_sc_hd__and3_1
X_09694_ _01811_ _01827_ _01699_ VSS VSS VDD VDD _01828_ sky130_fd_sc_hd__a21boi_2
X_09695_ _01707_ _01826_ _01828_ VSS VSS VDD VDD _01829_ sky130_fd_sc_hd__a21oi_4
X_09696_ _01730_ _01589_ VSS VSS VDD VDD _01830_ sky130_fd_sc_hd__nand2_2
X_09697_ _01593_ _01639_ VSS VSS VDD VDD _01831_ sky130_fd_sc_hd__nor2_1
X_09698_ _01680_ _01587_ _01730_ VSS VSS VDD VDD _01832_ sky130_fd_sc_hd__nand3_1
X_09699_ _01568_ _01832_ VSS VSS VDD VDD _01833_ sky130_fd_sc_hd__nand2_1
X_09700_ _01830_ _01831_ _01833_ VSS VSS VDD VDD _01834_ sky130_fd_sc_hd__o21ai_4
X_09701_ _01672_ _01673_ _01652_ VSS VSS VDD VDD _01835_ sky130_fd_sc_hd__nand3_1
X_09702_ _01835_ _01644_ _01648_ VSS VSS VDD VDD _01836_ sky130_fd_sc_hd__nor3b_1
X_09703_ _01679_ _01688_ _01703_ VSS VSS VDD VDD _01837_ sky130_fd_sc_hd__nor3_2
X_09704_ _01836_ _01837_ _01810_ _01827_ VSS VSS VDD VDD _01838_
+ sky130_fd_sc_hd__nand4b_4
X_09705_ _01834_ _01838_ _01830_ _01593_ VSS VSS VDD VDD _01839_
+ sky130_fd_sc_hd__o211ai_4
X_09706_ _01834_ _01838_ VSS VSS VDD VDD _01840_ sky130_fd_sc_hd__xor2_4
X_09707_ _01680_ _01730_ _01683_ _01687_ VSS VSS VDD VDD _01841_
+ sky130_fd_sc_hd__a31oi_4
X_09708_ _01841_ _01700_ _01702_ _01825_ VSS VSS VDD VDD _01842_
+ sky130_fd_sc_hd__nand4_1
X_09709_ _01707_ _01826_ _01828_ _01842_ VSS VSS VDD VDD _01843_
+ sky130_fd_sc_hd__a211oi_4
X_09710_ _01839_ _01840_ _01843_ VSS VSS VDD VDD _01844_ sky130_fd_sc_hd__and3_1
X_09711_ _01844_ VSS VSS VDD VDD _01845_ sky130_fd_sc_hd__buf_4
X_09712_ _01755_ VSS VSS VDD VDD _07442_ sky130_fd_sc_hd__clkinvlp_4
X_09713_ _00569_ _07442_ VSS VSS VDD VDD _01846_ sky130_fd_sc_hd__xnor2_1
X_09714_ _01653_ _01728_ _01705_ _01846_ VSS VSS VDD VDD _01847_
+ sky130_fd_sc_hd__nor4_1
X_09715_ _01715_ _01718_ _01721_ VSS VSS VDD VDD _01848_ sky130_fd_sc_hd__a21oi_1
X_09716_ _01775_ _01799_ _01848_ VSS VSS VDD VDD _01849_ sky130_fd_sc_hd__nor3_1
X_09717_ _07464_ _07453_ _07456_ _07470_ VSS VSS VDD VDD _01850_
+ sky130_fd_sc_hd__nand4_1
X_09718_ _07459_ _07462_ _07467_ VSS VSS VDD VDD _01851_ sky130_fd_sc_hd__nand3_1
X_09719_ _01114_ _01850_ _01851_ VSS VSS VDD VDD _01852_ sky130_fd_sc_hd__nor3_1
X_09720_ _01847_ _01849_ _01852_ VSS VSS VDD VDD _01853_ sky130_fd_sc_hd__o21ai_2
X_09721_ _01629_ _01716_ VSS VSS VDD VDD _01854_ sky130_fd_sc_hd__xnor2_1
X_09722_ _01836_ _01837_ _01811_ _01854_ VSS VSS VDD VDD _01855_
+ sky130_fd_sc_hd__a31oi_2
X_09723_ _01772_ _01855_ VSS VSS VDD VDD _01856_ sky130_fd_sc_hd__xnor2_2
X_09724_ _01853_ _01856_ VSS VSS VDD VDD _01857_ sky130_fd_sc_hd__or2_2
X_09725_ _01818_ _01845_ _01857_ VSS VSS VDD VDD _01858_ sky130_fd_sc_hd__nand3_1
X_09726_ net25 _01825_ _01829_ _01858_ VSS VSS VDD VDD _01859_
+ sky130_fd_sc_hd__nand4_2
X_09727_ _01653_ _01705_ VSS VSS VDD VDD _01860_ sky130_fd_sc_hd__nor2_2
X_09728_ _01679_ _01688_ _01860_ _01743_ VSS VSS VDD VDD _01861_
+ sky130_fd_sc_hd__nor4_2
X_09729_ _01679_ _01743_ VSS VSS VDD VDD _01862_ sky130_fd_sc_hd__nor2_1
X_09730_ _01841_ _01862_ VSS VSS VDD VDD _01863_ sky130_fd_sc_hd__nor2_1
X_09731_ _01861_ _01863_ VSS VSS VDD VDD _01864_ sky130_fd_sc_hd__nor2_2
X_09732_ _01859_ _01864_ VSS VSS VDD VDD _01865_ sky130_fd_sc_hd__xnor2_4
X_09733_ _01822_ VSS VSS VDD VDD _01866_ sky130_fd_sc_hd__inv_1
X_09734_ _01802_ _01818_ _01866_ VSS VSS VDD VDD _01867_ sky130_fd_sc_hd__and3_1
X_09735_ _01829_ _01867_ VSS VSS VDD VDD _01868_ sky130_fd_sc_hd__or2_0
X_09736_ _01868_ VSS VSS VDD VDD _01869_ sky130_fd_sc_hd__buf_2
X_09737_ _01839_ _01840_ _01843_ VSS VSS VDD VDD _01870_ sky130_fd_sc_hd__nand3_4
X_09738_ _01853_ _01856_ VSS VSS VDD VDD _01871_ sky130_fd_sc_hd__nor2_1
X_09739_ _01870_ _01871_ _01867_ _01829_ VSS VSS VDD VDD _01872_
+ sky130_fd_sc_hd__o211ai_4
X_09740_ _01869_ _01872_ VSS VSS VDD VDD _01873_ sky130_fd_sc_hd__nand2_2
X_09741_ _01834_ _01838_ _01830_ _01593_ VSS VSS VDD VDD _01874_
+ sky130_fd_sc_hd__o211a_1
X_09742_ _01802_ _01818_ _01843_ _01840_ VSS VSS VDD VDD _01875_
+ sky130_fd_sc_hd__a31oi_2
X_09743_ _01707_ _01826_ _01823_ VSS VSS VDD VDD _01876_ sky130_fd_sc_hd__a21o_1
X_09744_ _01836_ _01837_ _01810_ VSS VSS VDD VDD _01877_ sky130_fd_sc_hd__and3_4
X_09745_ _01877_ VSS VSS VDD VDD _01878_ sky130_fd_sc_hd__buf_6
X_09746_ _01841_ _01743_ net29 VSS VSS VDD VDD _01879_ sky130_fd_sc_hd__a21o_1
X_09747_ _01679_ _01823_ VSS VSS VDD VDD _01880_ sky130_fd_sc_hd__nor2_1
X_09748_ _01679_ _01841_ _01876_ _01879_ _01880_ VSS VSS VDD
+ VDD _01881_ sky130_fd_sc_hd__a32oi_4
X_09749_ _01700_ _01702_ VSS VSS VDD VDD _01882_ sky130_fd_sc_hd__nand2_1
X_09750_ _01882_ _01861_ VSS VSS VDD VDD _01883_ sky130_fd_sc_hd__xor2_2
X_09751_ _01874_ _01875_ _01881_ _01883_ VSS VSS VDD VDD _01884_
+ sky130_fd_sc_hd__nor4_2
X_09752_ _01869_ _01872_ _01884_ VSS VSS VDD VDD _01885_ sky130_fd_sc_hd__and3_2
X_09753_ _01802_ _01818_ VSS VSS VDD VDD _01886_ sky130_fd_sc_hd__nand2_8
X_09754_ _07447_ _07449_ _01711_ VSS VSS VDD VDD _01887_ sky130_fd_sc_hd__nor3_1
X_09755_ _01712_ _01887_ VSS VSS VDD VDD _01888_ sky130_fd_sc_hd__nor2_1
X_09756_ _07407_ _07409_ _01477_ VSS VSS VDD VDD _01889_ sky130_fd_sc_hd__nor3_1
X_09757_ _07368_ _07370_ _07369_ VSS VSS VDD VDD _01890_ sky130_fd_sc_hd__nor3_1
X_09758_ _01315_ _07350_ VSS VSS VDD VDD _07366_ sky130_fd_sc_hd__nor2_4
X_09759_ _01492_ _07366_ VSS VSS VDD VDD _01891_ sky130_fd_sc_hd__nand2_2
X_09760_ _00585_ _01492_ _01890_ _01891_ VSS VSS VDD VDD _07385_
+ sky130_fd_sc_hd__o31ai_2
X_09761_ _07387_ _07389_ _01344_ VSS VSS VDD VDD _01892_ sky130_fd_sc_hd__nor3_1
X_09762_ _01345_ _01892_ _01426_ VSS VSS VDD VDD _01893_ sky130_fd_sc_hd__o21ai_2
X_09763_ _01426_ _07385_ _01893_ VSS VSS VDD VDD _07405_ sky130_fd_sc_hd__o21a_1
X_09764_ _01633_ _07405_ VSS VSS VDD VDD _01894_ sky130_fd_sc_hd__nand2_1
X_09765_ _01478_ _01633_ _01889_ _01894_ VSS VSS VDD VDD _07425_
+ sky130_fd_sc_hd__o31ai_1
X_09766_ _07427_ _07429_ _01571_ VSS VSS VDD VDD _01895_ sky130_fd_sc_hd__nor3_1
X_09767_ _01572_ _01895_ VSS VSS VDD VDD _01896_ sky130_fd_sc_hd__nor2_1
X_09768_ _07425_ _01896_ net33 VSS VSS VDD VDD _07445_ sky130_fd_sc_hd__mux2_1
X_09769_ _01888_ _07445_ _01878_ VSS VSS VDD VDD _07465_ sky130_fd_sc_hd__mux2_1
X_09770_ _01886_ _01870_ _07465_ VSS VSS VDD VDD _01897_ sky130_fd_sc_hd__or3_1
X_09771_ _07469_ _01762_ VSS VSS VDD VDD _01898_ sky130_fd_sc_hd__nor2_1
X_09772_ _07467_ _01898_ VSS VSS VDD VDD _01899_ sky130_fd_sc_hd__xor2_1
X_09773_ _01886_ _01870_ _01899_ VSS VSS VDD VDD _01900_ sky130_fd_sc_hd__o21ai_2
X_09774_ _07487_ _07486_ _07485_ VSS VSS VDD VDD _01901_ sky130_fd_sc_hd__o21a_1
X_09775_ _07484_ _01901_ _07482_ VSS VSS VDD VDD _01902_ sky130_fd_sc_hd__o21a_1
X_09776_ _07481_ _01902_ _07479_ VSS VSS VDD VDD _01903_ sky130_fd_sc_hd__o21a_1
X_09777_ _01903_ _07478_ _07476_ VSS VSS VDD VDD _01904_ sky130_fd_sc_hd__o21a_1
X_09778_ _07475_ _01904_ _07473_ VSS VSS VDD VDD _01905_ sky130_fd_sc_hd__o21a_1
X_09779_ _01905_ _07472_ _07490_ VSS VSS VDD VDD _01906_ sky130_fd_sc_hd__o21ai_2
X_09780_ _07489_ _01906_ VSS VSS VDD VDD _01907_ sky130_fd_sc_hd__nor2b_4
X_09781_ _01786_ _01907_ VSS VSS VDD VDD _01908_ sky130_fd_sc_hd__nor2_4
X_09782_ _01897_ _01900_ _01908_ VSS VSS VDD VDD _01909_ sky130_fd_sc_hd__a21boi_4
X_09783_ _01886_ _01870_ _07465_ VSS VSS VDD VDD _01910_ sky130_fd_sc_hd__nor3_4
X_09784_ _07467_ _01898_ VSS VSS VDD VDD _01911_ sky130_fd_sc_hd__xnor2_2
X_09785_ _01820_ _01845_ _01911_ VSS VSS VDD VDD _01912_ sky130_fd_sc_hd__a21oi_4
X_09786_ _07489_ _01906_ VSS VSS VDD VDD _01913_ sky130_fd_sc_hd__nand2b_4
Xclone6 _00670_ VSS VSS VDD VDD net6 sky130_fd_sc_hd__buf_6
X_09788_ _01913_ _01786_ _00746_ VSS VSS VDD VDD _01915_ sky130_fd_sc_hd__a21oi_4
X_09789_ _01910_ _01912_ _01915_ VSS VSS VDD VDD _01916_ sky130_fd_sc_hd__nor3_4
X_09790_ _01777_ _01854_ VSS VSS VDD VDD _01917_ sky130_fd_sc_hd__xnor2_1
X_09791_ _01629_ _01764_ VSS VSS VDD VDD _01918_ sky130_fd_sc_hd__xnor2_2
X_09792_ _01797_ _01918_ VSS VSS VDD VDD _01919_ sky130_fd_sc_hd__xnor2_1
X_09793_ _01800_ _01917_ _01919_ VSS VSS VDD VDD _01920_ sky130_fd_sc_hd__o21ai_0
X_09794_ _01755_ _01918_ VSS VSS VDD VDD _01921_ sky130_fd_sc_hd__nor2_1
X_09795_ _00569_ _01764_ VSS VSS VDD VDD _01922_ sky130_fd_sc_hd__xnor2_1
X_09796_ _07442_ _01922_ VSS VSS VDD VDD _01923_ sky130_fd_sc_hd__nor2_1
X_09797_ _01921_ _01923_ _01773_ VSS VSS VDD VDD _01924_ sky130_fd_sc_hd__o21ai_0
X_09798_ _01920_ _01924_ net29 VSS VSS VDD VDD _01925_ sky130_fd_sc_hd__mux2i_1
X_09799_ _01800_ _01917_ VSS VSS VDD VDD _01926_ sky130_fd_sc_hd__nand2_1
X_09800_ _01603_ _01755_ _01771_ VSS VSS VDD VDD _01927_ sky130_fd_sc_hd__o21ai_0
X_09801_ _01777_ _01927_ VSS VSS VDD VDD _01928_ sky130_fd_sc_hd__nand2_1
X_09802_ _01926_ _01928_ _01878_ VSS VSS VDD VDD _01929_ sky130_fd_sc_hd__mux2_1
X_09803_ _01925_ _01929_ VSS VSS VDD VDD _01930_ sky130_fd_sc_hd__nand2_1
X_09804_ _01727_ _01860_ VSS VSS VDD VDD _01931_ sky130_fd_sc_hd__nand2_1
X_09805_ _01775_ _01931_ _01848_ VSS VSS VDD VDD _01932_ sky130_fd_sc_hd__a21oi_2
X_09806_ _01773_ VSS VSS VDD VDD _01933_ sky130_fd_sc_hd__inv_1
X_09807_ _01707_ _01933_ _01775_ VSS VSS VDD VDD _01934_ sky130_fd_sc_hd__o21ai_0
X_09808_ _01775_ VSS VSS VDD VDD _01935_ sky130_fd_sc_hd__inv_1
X_09809_ _01935_ _01801_ _01727_ VSS VSS VDD VDD _01936_ sky130_fd_sc_hd__a21oi_1
X_09810_ _01727_ _01801_ _01934_ _01936_ VSS VSS VDD VDD _01937_
+ sky130_fd_sc_hd__a31o_1
X_09811_ _01811_ _01707_ VSS VSS VDD VDD _01938_ sky130_fd_sc_hd__nand2_1
X_09812_ _01732_ _01938_ VSS VSS VDD VDD _01939_ sky130_fd_sc_hd__xnor2_1
X_09813_ _01930_ _01932_ _01937_ _01939_ VSS VSS VDD VDD _01940_
+ sky130_fd_sc_hd__and4b_1
X_09814_ _01728_ _01806_ _07442_ VSS VSS VDD VDD _01941_ sky130_fd_sc_hd__nor3_1
X_09815_ _01728_ _01732_ _01798_ VSS VSS VDD VDD _01942_ sky130_fd_sc_hd__nor3_1
X_09816_ _01811_ _01806_ _01798_ VSS VSS VDD VDD _01943_ sky130_fd_sc_hd__nor3_1
X_09817_ _01860_ _01941_ _01942_ _01943_ VSS VSS VDD VDD _01944_
+ sky130_fd_sc_hd__a211oi_2
X_09818_ _01886_ _01870_ _01944_ VSS VSS VDD VDD _01945_ sky130_fd_sc_hd__nor3_4
X_09819_ _01940_ _01945_ VSS VSS VDD VDD _01946_ sky130_fd_sc_hd__nor2_2
X_09820_ _01853_ _01856_ _01840_ _01843_ VSS VSS VDD VDD _01947_
+ sky130_fd_sc_hd__o211ai_2
X_09821_ _01801_ _01776_ _01933_ net29 VSS VSS VDD VDD _01948_
+ sky130_fd_sc_hd__a2bb2oi_2
X_09822_ _01653_ _01728_ VSS VSS VDD VDD _01949_ sky130_fd_sc_hd__nor2_1
X_09823_ _01811_ _01705_ _01813_ VSS VSS VDD VDD _01950_ sky130_fd_sc_hd__nand3_1
X_09824_ _01804_ _01949_ _01950_ VSS VSS VDD VDD _01951_ sky130_fd_sc_hd__o21ai_1
X_09825_ _01653_ _01705_ _01732_ _01811_ VSS VSS VDD VDD _01952_
+ sky130_fd_sc_hd__o211ai_4
X_09826_ _01816_ _01952_ VSS VSS VDD VDD _01953_ sky130_fd_sc_hd__xnor2_4
X_09827_ _01811_ _01705_ _01813_ _01866_ VSS VSS VDD VDD _01954_
+ sky130_fd_sc_hd__a31o_1
X_09828_ _01811_ _01822_ VSS VSS VDD VDD _01955_ sky130_fd_sc_hd__nor2_1
X_09829_ _01742_ _01954_ _01955_ _01860_ VSS VSS VDD VDD _01956_
+ sky130_fd_sc_hd__a211oi_2
X_09830_ _01948_ _01951_ _01953_ _01956_ VSS VSS VDD VDD _01957_
+ sky130_fd_sc_hd__a211o_1
X_09831_ _01948_ _01839_ _01951_ VSS VSS VDD VDD _01958_ sky130_fd_sc_hd__nor3_1
X_09832_ _01820_ _01947_ _01957_ _01958_ VSS VSS VDD VDD _01959_
+ sky130_fd_sc_hd__a211o_1
X_09833_ _01959_ _01916_ _01946_ _01909_ VSS VSS VDD VDD _01960_
+ sky130_fd_sc_hd__nor4_4
X_09834_ _01873_ _01885_ net428 VSS VSS VDD VDD _01961_ sky130_fd_sc_hd__nor3b_1
X_09835_ _01910_ _01912_ _01908_ VSS VSS VDD VDD _01962_ sky130_fd_sc_hd__o21ai_4
X_09836_ _01910_ _01912_ _01915_ VSS VSS VDD VDD _01963_ sky130_fd_sc_hd__or3_4
Xrebuffer46 _07672_ VSS VSS VDD VDD net414 sky130_fd_sc_hd__dlygate4sd1_1
X_09838_ _01940_ _01945_ VSS VSS VDD VDD _01965_ sky130_fd_sc_hd__or2_0
X_09839_ _01965_ VSS VSS VDD VDD _01966_ sky130_fd_sc_hd__clkbuf_4
X_09840_ net25 _01870_ VSS VSS VDD VDD _01967_ sky130_fd_sc_hd__nand2_1
X_09841_ _01956_ _01967_ VSS VSS VDD VDD _01968_ sky130_fd_sc_hd__xor2_1
X_09842_ _01818_ _01962_ _01963_ _01966_ _01968_ VSS VSS VDD
+ VDD _01969_ sky130_fd_sc_hd__a41oi_4
X_09843_ _01820_ _01947_ _01957_ _01958_ VSS VSS VDD VDD _01970_
+ sky130_fd_sc_hd__a211oi_2
X_09844_ _01869_ _01872_ _01884_ _01970_ VSS VSS VDD VDD _01971_
+ sky130_fd_sc_hd__and4_2
X_09845_ _01962_ _01963_ _01966_ _01971_ VSS VSS VDD VDD _01972_
+ sky130_fd_sc_hd__nand4_4
X_09846_ _01873_ net428 _01969_ _01972_ VSS VSS VDD VDD _01973_
+ sky130_fd_sc_hd__o31ai_4
X_09847_ _01873_ _01881_ _01883_ VSS VSS VDD VDD _01974_ sky130_fd_sc_hd__nor3_1
X_09848_ net25 _01840_ _01843_ VSS VSS VDD VDD _01975_ sky130_fd_sc_hd__and3_1
X_09849_ _01839_ _01857_ VSS VSS VDD VDD _01976_ sky130_fd_sc_hd__nand2_1
X_09850_ _01975_ _01976_ _01875_ VSS VSS VDD VDD _01977_ sky130_fd_sc_hd__a21oi_1
X_09851_ net428 _01974_ _01977_ VSS VSS VDD VDD _01978_ sky130_fd_sc_hd__a21o_1
X_09852_ _01975_ _01874_ VSS VSS VDD VDD _01979_ sky130_fd_sc_hd__nand2b_1
X_09853_ _01973_ _01978_ _01979_ VSS VSS VDD VDD _01980_ sky130_fd_sc_hd__nand3_1
X_09854_ _01940_ _01945_ _01869_ _01872_ VSS VSS VDD VDD _01981_
+ sky130_fd_sc_hd__o211ai_1
X_09855_ _01869_ _01872_ _01884_ _01959_ VSS VSS VDD VDD _01982_
+ sky130_fd_sc_hd__a31oi_1
X_09856_ _01909_ _01981_ _01916_ _01982_ VSS VSS VDD VDD _01983_
+ sky130_fd_sc_hd__nor4b_2
X_09857_ _01679_ _01876_ VSS VSS VDD VDD _01984_ sky130_fd_sc_hd__xnor2_1
X_09858_ _01829_ _01867_ _01858_ VSS VSS VDD VDD _01985_ sky130_fd_sc_hd__nand3_1
X_09859_ _01984_ _01985_ VSS VSS VDD VDD _01986_ sky130_fd_sc_hd__xnor2_2
X_09860_ _01983_ _01986_ VSS VSS VDD VDD _01987_ sky130_fd_sc_hd__xnor2_2
X_09861_ _01882_ _01840_ VSS VSS VDD VDD _01988_ sky130_fd_sc_hd__nor2b_1
X_09862_ _01841_ _01825_ _01829_ VSS VSS VDD VDD _01989_ sky130_fd_sc_hd__nand3_1
X_09863_ _01839_ _01988_ _01857_ _01989_ _01886_ VSS VSS VDD
+ VDD _01990_ sky130_fd_sc_hd__a311oi_2
X_09864_ _01883_ _01990_ VSS VSS VDD VDD _01991_ sky130_fd_sc_hd__xnor2_1
X_09865_ _01881_ VSS VSS VDD VDD _01992_ sky130_fd_sc_hd__inv_1
X_09866_ _01869_ _01872_ _01992_ _01970_ VSS VSS VDD VDD _01993_
+ sky130_fd_sc_hd__nand4_1
X_09867_ _01874_ _01875_ _01883_ _01940_ _01945_ VSS VSS VDD
+ VDD _01994_ sky130_fd_sc_hd__o32ai_1
X_09868_ _01909_ _01916_ _01993_ _01994_ VSS VSS VDD VDD _01995_
+ sky130_fd_sc_hd__nor4_1
X_09869_ _01991_ _01995_ VSS VSS VDD VDD _01996_ sky130_fd_sc_hd__xnor2_2
X_09870_ _01987_ _01996_ _01865_ VSS VSS VDD VDD _01997_ sky130_fd_sc_hd__or3b_1
X_09871_ _01980_ _01997_ VSS VSS VDD VDD _01998_ sky130_fd_sc_hd__nor2_2
X_09872_ _01948_ _01953_ _01951_ VSS VSS VDD VDD _01999_ sky130_fd_sc_hd__o21ai_0
X_09873_ _01806_ _01938_ VSS VSS VDD VDD _02000_ sky130_fd_sc_hd__nor2_1
X_09874_ _01818_ _01845_ _01857_ _01948_ VSS VSS VDD VDD _02001_
+ sky130_fd_sc_hd__a31oi_4
X_09875_ _01774_ _01801_ _01938_ _01806_ VSS VSS VDD VDD _02002_
+ sky130_fd_sc_hd__o211a_1
X_09876_ _01816_ _02000_ _02001_ _02002_ VSS VSS VDD VDD _02003_
+ sky130_fd_sc_hd__nor4_1
X_09877_ _01925_ _01937_ VSS VSS VDD VDD _02004_ sky130_fd_sc_hd__and2_0
X_09878_ _01945_ _02004_ _01929_ _01932_ VSS VSS VDD VDD _02005_
+ sky130_fd_sc_hd__o211ai_4
X_09879_ _01966_ _01971_ _02005_ _01916_ _01909_ VSS VSS VDD
+ VDD _02006_ sky130_fd_sc_hd__a2111oi_4
X_09880_ _01967_ _01999_ _02003_ _02006_ VSS VSS VDD VDD _02007_
+ sky130_fd_sc_hd__a22oi_2
X_09881_ _01962_ _01963_ VSS VSS VDD VDD _02008_ sky130_fd_sc_hd__nand2_1
X_09882_ _02008_ _01946_ _01971_ VSS VSS VDD VDD _02009_ sky130_fd_sc_hd__nor3_1
X_09883_ _01953_ _02001_ VSS VSS VDD VDD _02010_ sky130_fd_sc_hd__xor2_4
X_09884_ _02000_ _02001_ _02002_ VSS VSS VDD VDD _02011_ sky130_fd_sc_hd__or3_1
X_09885_ _01909_ _01916_ _02005_ _02011_ VSS VSS VDD VDD _02012_
+ sky130_fd_sc_hd__o31ai_2
X_09886_ _02007_ _02009_ _02010_ _02012_ VSS VSS VDD VDD _02013_
+ sky130_fd_sc_hd__nor4b_4
X_09887_ _01845_ _01820_ VSS VSS VDD VDD _02014_ sky130_fd_sc_hd__nand2_8
X_09888_ _01937_ VSS VSS VDD VDD _02015_ sky130_fd_sc_hd__inv_1
X_09889_ _01932_ VSS VSS VDD VDD _02016_ sky130_fd_sc_hd__inv_1
X_09890_ _01869_ _01872_ _01884_ _01970_ VSS VSS VDD VDD _02017_
+ sky130_fd_sc_hd__nand4_4
X_09891_ _01946_ _02017_ _01962_ _01963_ VSS VSS VDD VDD _02018_
+ sky130_fd_sc_hd__o211ai_1
X_09892_ _01930_ _02016_ _02018_ VSS VSS VDD VDD _02019_ sky130_fd_sc_hd__or3_2
X_09893_ _07450_ _07432_ _01710_ VSS VSS VDD VDD _02020_ sky130_fd_sc_hd__nor3_1
X_09894_ _01711_ _02020_ VSS VSS VDD VDD _02021_ sky130_fd_sc_hd__nor2_1
X_09895_ _07430_ _07412_ _01570_ VSS VSS VDD VDD _02022_ sky130_fd_sc_hd__nor3_1
X_09896_ _01571_ _02022_ VSS VSS VDD VDD _02023_ sky130_fd_sc_hd__or2_0
X_09897_ _07410_ _07392_ _01476_ VSS VSS VDD VDD _02024_ sky130_fd_sc_hd__nor3_1
X_09898_ _07390_ _07372_ _07371_ VSS VSS VDD VDD _02025_ sky130_fd_sc_hd__nor3_1
X_09899_ _07370_ _01492_ VSS VSS VDD VDD _07388_ sky130_fd_sc_hd__nor2_4
X_09900_ _01745_ _07388_ VSS VSS VDD VDD _02026_ sky130_fd_sc_hd__nand2_1
X_09901_ _01344_ _01745_ _02025_ _02026_ VSS VSS VDD VDD _07408_
+ sky130_fd_sc_hd__o31ai_2
X_09902_ _01633_ _07408_ VSS VSS VDD VDD _02027_ sky130_fd_sc_hd__nand2_1
X_09903_ _01477_ _01633_ _02024_ _02027_ VSS VSS VDD VDD _07428_
+ sky130_fd_sc_hd__o31ai_2
X_09904_ _01733_ _07428_ VSS VSS VDD VDD _02028_ sky130_fd_sc_hd__nor2_1
X_09905_ net33 _02023_ _02028_ VSS VSS VDD VDD _07448_ sky130_fd_sc_hd__a21oi_1
X_09906_ _02021_ _07448_ _01878_ VSS VSS VDD VDD _07468_ sky130_fd_sc_hd__mux2_1
X_09907_ _01820_ _01845_ _07468_ VSS VSS VDD VDD _02029_ sky130_fd_sc_hd__nand3_2
X_09908_ _07470_ _07452_ _01761_ VSS VSS VDD VDD _02030_ sky130_fd_sc_hd__nor3_1
X_09909_ _01762_ _02030_ VSS VSS VDD VDD _02031_ sky130_fd_sc_hd__nor2_1
X_09910_ _01886_ _01870_ _02031_ VSS VSS VDD VDD _02032_ sky130_fd_sc_hd__o21ai_2
X_09911_ _02029_ _02032_ _01603_ VSS VSS VDD VDD _02033_ sky130_fd_sc_hd__a21oi_1
X_09912_ _07510_ _07509_ _07508_ VSS VSS VDD VDD _02034_ sky130_fd_sc_hd__o21a_1
X_09913_ _07507_ _02034_ _07505_ VSS VSS VDD VDD _02035_ sky130_fd_sc_hd__o21a_1
X_09914_ _07504_ _02035_ _07502_ VSS VSS VDD VDD _02036_ sky130_fd_sc_hd__o21a_1
X_09915_ _02036_ _07501_ _07499_ VSS VSS VDD VDD _02037_ sky130_fd_sc_hd__o21a_1
X_09916_ _07498_ _02037_ _07496_ VSS VSS VDD VDD _02038_ sky130_fd_sc_hd__o21a_1
X_09917_ _07495_ _02038_ _07493_ VSS VSS VDD VDD _02039_ sky130_fd_sc_hd__o21ai_2
X_09918_ _07492_ _02039_ VSS VSS VDD VDD _02040_ sky130_fd_sc_hd__nand2b_1
X_09919_ _02040_ _01786_ VSS VSS VDD VDD _02041_ sky130_fd_sc_hd__nand2_2
X_09920_ _02029_ _02032_ _02041_ VSS VSS VDD VDD _02042_ sky130_fd_sc_hd__a21oi_4
X_09921_ _07492_ _02039_ VSS VSS VDD VDD _02043_ sky130_fd_sc_hd__nor2b_4
X_09922_ _02043_ _01786_ VSS VSS VDD VDD _02044_ sky130_fd_sc_hd__nor2_2
X_09923_ _02044_ _02032_ _02029_ VSS VSS VDD VDD _02045_ sky130_fd_sc_hd__nand3_1
X_09924_ _02042_ _02033_ _02045_ VSS VSS VDD VDD _02046_ sky130_fd_sc_hd__nor3b_4
X_09925_ _07472_ _01905_ VSS VSS VDD VDD _02047_ sky130_fd_sc_hd__nor2_1
X_09926_ _07490_ _02047_ VSS VSS VDD VDD _02048_ sky130_fd_sc_hd__xnor2_2
X_09927_ _01603_ VSS VSS VDD VDD _02049_ sky130_fd_sc_hd__clkbuf_8
X_09928_ _02049_ _02041_ _02048_ VSS VSS VDD VDD _02050_ sky130_fd_sc_hd__nand3_1
X_09929_ _02044_ _02048_ _02050_ VSS VSS VDD VDD _02051_ sky130_fd_sc_hd__o21ai_2
X_09930_ _02046_ _02051_ _01972_ VSS VSS VDD VDD _02052_ sky130_fd_sc_hd__mux2i_4
X_09931_ _02014_ _02015_ _02019_ _02006_ _02052_ VSS VSS VDD
+ VDD _02053_ sky130_fd_sc_hd__a311oi_4
X_09932_ _01878_ VSS VSS VDD VDD _02054_ sky130_fd_sc_hd__buf_6
X_09933_ net28 _01800_ _01917_ VSS VSS VDD VDD _02055_ sky130_fd_sc_hd__nor3_1
X_09934_ net28 _01933_ _02055_ VSS VSS VDD VDD _02056_ sky130_fd_sc_hd__a21oi_1
X_09935_ _01932_ _02056_ VSS VSS VDD VDD _02057_ sky130_fd_sc_hd__xor2_1
X_09936_ _02008_ _01930_ _02057_ _02014_ VSS VSS VDD VDD _02058_
+ sky130_fd_sc_hd__o211ai_2
X_09937_ _01798_ _07442_ net29 VSS VSS VDD VDD _02059_ sky130_fd_sc_hd__mux2i_4
X_09938_ _01886_ _01870_ _01922_ VSS VSS VDD VDD _02060_ sky130_fd_sc_hd__o21ai_1
X_09939_ _02059_ _02060_ VSS VSS VDD VDD _02061_ sky130_fd_sc_hd__xnor2_2
X_09940_ _01946_ _02017_ _02061_ _01963_ _01962_ VSS VSS VDD
+ VDD _02062_ sky130_fd_sc_hd__o2111ai_1
X_09941_ _01870_ _01886_ VSS VSS VDD VDD _02063_ sky130_fd_sc_hd__nor2_8
X_09942_ net410 _02056_ _01929_ VSS VSS VDD VDD _02064_ sky130_fd_sc_hd__o21ai_1
X_09943_ _02062_ _02064_ VSS VSS VDD VDD _02065_ sky130_fd_sc_hd__xor2_1
X_09944_ _02058_ _02065_ VSS VSS VDD VDD _02066_ sky130_fd_sc_hd__and2_0
X_09945_ _02066_ VSS VSS VDD VDD _02067_ sky130_fd_sc_hd__buf_2
X_09946_ net25 _01845_ _01918_ _02059_ _00746_ VSS VSS VDD
+ VDD _02068_ sky130_fd_sc_hd__a2111oi_2
X_09947_ _01603_ _01918_ _02059_ _01786_ _01913_ VSS VSS VDD
+ VDD _02069_ sky130_fd_sc_hd__a311o_1
X_09948_ _02049_ net410 _02059_ _02068_ _02069_ VSS VSS VDD
+ VDD _02070_ sky130_fd_sc_hd__a311oi_4
X_09949_ _01910_ _01912_ VSS VSS VDD VDD _02071_ sky130_fd_sc_hd__nor2_4
X_09950_ _02049_ _02061_ _02070_ _02071_ VSS VSS VDD VDD _02072_
+ sky130_fd_sc_hd__o211ai_2
X_09951_ _01755_ _01913_ _07445_ VSS VSS VDD VDD _02073_ sky130_fd_sc_hd__or3_1
X_09952_ _01755_ _01913_ _07445_ VSS VSS VDD VDD _02074_ sky130_fd_sc_hd__nand3_1
X_09953_ _01797_ _01913_ _01888_ VSS VSS VDD VDD _02075_ sky130_fd_sc_hd__nor3_1
X_09954_ _01797_ _01913_ _01888_ _02075_ net28 VSS VSS VDD
+ VDD _02076_ sky130_fd_sc_hd__a311oi_1
X_09955_ net28 _02073_ _02074_ _02076_ VSS VSS VDD VDD _02077_
+ sky130_fd_sc_hd__a31oi_1
X_09956_ _01907_ _01899_ VSS VSS VDD VDD _02078_ sky130_fd_sc_hd__nand2_1
X_09957_ _01913_ _01911_ VSS VSS VDD VDD _02079_ sky130_fd_sc_hd__nand2_1
X_09958_ _01918_ _02059_ VSS VSS VDD VDD _02080_ sky130_fd_sc_hd__xnor2_1
X_09959_ _02078_ _02079_ _02080_ VSS VSS VDD VDD _02081_ sky130_fd_sc_hd__mux2i_1
X_09960_ _02077_ _02081_ _02014_ VSS VSS VDD VDD _02082_ sky130_fd_sc_hd__mux2i_1
X_09961_ _07207_ _02082_ _01909_ _02061_ VSS VSS VDD VDD _02083_
+ sky130_fd_sc_hd__a2bb2oi_1
X_09962_ _01786_ _01913_ _01910_ _01912_ _02070_ VSS VSS VDD
+ VDD _02084_ sky130_fd_sc_hd__a2111oi_4
X_09963_ _01972_ _02072_ _02083_ _02084_ VSS VSS VDD VDD _02085_
+ sky130_fd_sc_hd__a31oi_4
X_09964_ _01973_ _02085_ VSS VSS VDD VDD _02086_ sky130_fd_sc_hd__and2_0
X_09965_ _02013_ _02053_ _02067_ _02086_ VSS VSS VDD VDD _02087_
+ sky130_fd_sc_hd__nand4_2
X_09966_ _01998_ _02087_ VSS VSS VDD VDD _02088_ sky130_fd_sc_hd__nor2_2
X_09967_ _01961_ _02088_ _01986_ VSS VSS VDD VDD _02089_ sky130_fd_sc_hd__o21ai_2
X_09968_ _01865_ _02089_ VSS VSS VDD VDD _02090_ sky130_fd_sc_hd__xnor2_4
X_09969_ _02013_ _02053_ _02067_ VSS VSS VDD VDD _02091_ sky130_fd_sc_hd__and3_2
X_09970_ _01973_ _01978_ _01979_ VSS VSS VDD VDD _02092_ sky130_fd_sc_hd__and3_1
X_09971_ _01987_ _01996_ _01865_ VSS VSS VDD VDD _02093_ sky130_fd_sc_hd__nor3b_2
X_09972_ _02092_ _02093_ _02085_ VSS VSS VDD VDD _02094_ sky130_fd_sc_hd__and3_2
X_09973_ _02091_ _02094_ VSS VSS VDD VDD _02095_ sky130_fd_sc_hd__nand2_2
X_09974_ _07453_ _07455_ _01760_ VSS VSS VDD VDD _02096_ sky130_fd_sc_hd__nor3_1
X_09975_ _07372_ _01745_ VSS VSS VDD VDD _07391_ sky130_fd_sc_hd__nor2_4
X_09976_ _07393_ _07395_ _07394_ VSS VSS VDD VDD _02097_ sky130_fd_sc_hd__nor3_1
X_09977_ _01476_ _02097_ _01619_ VSS VSS VDD VDD _02098_ sky130_fd_sc_hd__o21ai_2
X_09978_ _07391_ _01619_ _02098_ VSS VSS VDD VDD _07411_ sky130_fd_sc_hd__o21a_1
X_09979_ _07413_ _07415_ _01569_ VSS VSS VDD VDD _02099_ sky130_fd_sc_hd__nor3_1
X_09980_ _01570_ _02099_ _01733_ VSS VSS VDD VDD _02100_ sky130_fd_sc_hd__o21ai_0
X_09981_ _01733_ _07411_ _02100_ VSS VSS VDD VDD _07431_ sky130_fd_sc_hd__o21a_1
X_09982_ net28 _07431_ VSS VSS VDD VDD _02101_ sky130_fd_sc_hd__nand2_1
X_09983_ _07433_ _07435_ _01709_ VSS VSS VDD VDD _02102_ sky130_fd_sc_hd__nor3_1
X_09984_ _01710_ _02054_ _02102_ VSS VSS VDD VDD _02103_ sky130_fd_sc_hd__or3_1
X_09985_ _02101_ _02103_ VSS VSS VDD VDD _07451_ sky130_fd_sc_hd__nand2_1
X_09986_ net410 _07451_ VSS VSS VDD VDD _02104_ sky130_fd_sc_hd__nand2_1
X_09987_ _01761_ net410 _02096_ _02104_ VSS VSS VDD VDD _07471_
+ sky130_fd_sc_hd__o31ai_2
X_09988_ _07473_ _07475_ _01904_ VSS VSS VDD VDD _02105_ sky130_fd_sc_hd__nor3_1
X_09989_ _01905_ _02105_ VSS VSS VDD VDD _02106_ sky130_fd_sc_hd__nor2_1
X_09990_ _07471_ _02106_ _01972_ VSS VSS VDD VDD _02107_ sky130_fd_sc_hd__mux2i_4
X_09991_ _07530_ _07522_ _07525_ _07528_ VSS VSS VDD VDD _02108_
+ sky130_fd_sc_hd__nand4_1
X_09992_ _07513_ _07516_ _07519_ VSS VSS VDD VDD _02109_ sky130_fd_sc_hd__nand3_1
X_09993_ _01114_ _02108_ _02109_ VSS VSS VDD VDD _02110_ sky130_fd_sc_hd__nor3_2
X_09994_ _07207_ _02107_ _02110_ VSS VSS VDD VDD _02111_ sky130_fd_sc_hd__nand3_1
X_09995_ _01873_ _01881_ VSS VSS VDD VDD _02112_ sky130_fd_sc_hd__nor2_1
X_09996_ _02112_ net428 VSS VSS VDD VDD _02113_ sky130_fd_sc_hd__nand2_1
X_09997_ _01840_ _01991_ VSS VSS VDD VDD _02114_ sky130_fd_sc_hd__nand2_1
X_09998_ _01885_ _02113_ _02114_ _01978_ VSS VSS VDD VDD _02115_
+ sky130_fd_sc_hd__o31a_1
X_09999_ _02013_ _02067_ _02053_ VSS VSS VDD VDD _02116_ sky130_fd_sc_hd__nand3_4
X_10000_ _02093_ _02086_ VSS VSS VDD VDD _02117_ sky130_fd_sc_hd__nand2_1
X_10001_ _01885_ _02113_ _02114_ VSS VSS VDD VDD _02118_ sky130_fd_sc_hd__nor3_1
X_10002_ _01979_ _02118_ VSS VSS VDD VDD _02119_ sky130_fd_sc_hd__nor2_1
X_10003_ _02116_ _02117_ _02119_ VSS VSS VDD VDD _02120_ sky130_fd_sc_hd__o21ai_0
X_10004_ _02095_ _02111_ _02115_ _02120_ VSS VSS VDD VDD _02121_
+ sky130_fd_sc_hd__o211ai_1
X_10005_ _01818_ _02009_ _02007_ VSS VSS VDD VDD _02122_ sky130_fd_sc_hd__a21oi_1
X_10006_ _01962_ _01963_ _01966_ _02017_ VSS VSS VDD VDD _02123_
+ sky130_fd_sc_hd__nand4_2
X_10007_ _02123_ _02012_ VSS VSS VDD VDD _02124_ sky130_fd_sc_hd__nand2_4
X_10008_ _02010_ _02124_ VSS VSS VDD VDD _02125_ sky130_fd_sc_hd__nor2_1
X_10009_ _02125_ _02053_ _02067_ _02085_ VSS VSS VDD VDD _02126_
+ sky130_fd_sc_hd__and4_1
X_10010_ _01980_ _01997_ _02013_ VSS VSS VDD VDD _02127_ sky130_fd_sc_hd__o21ai_1
X_10011_ _02053_ _02067_ _02085_ VSS VSS VDD VDD _02128_ sky130_fd_sc_hd__nand3_4
X_10012_ _02122_ _02126_ _02127_ _02128_ VSS VSS VDD VDD _02129_
+ sky130_fd_sc_hd__o22a_4
X_10013_ _01996_ _02092_ VSS VSS VDD VDD _02130_ sky130_fd_sc_hd__nand2b_1
X_10014_ _01996_ _02087_ VSS VSS VDD VDD _02131_ sky130_fd_sc_hd__xnor2_1
X_10015_ _01987_ _01865_ VSS VSS VDD VDD _02132_ sky130_fd_sc_hd__nor2b_1
X_10016_ _01973_ _02132_ VSS VSS VDD VDD _02133_ sky130_fd_sc_hd__nand2_2
X_10017_ _02130_ _02131_ _02133_ VSS VSS VDD VDD _02134_ sky130_fd_sc_hd__a21oi_1
X_10018_ _02092_ _02093_ _02085_ VSS VSS VDD VDD _02135_ sky130_fd_sc_hd__nand3_2
X_10019_ _02135_ _02116_ VSS VSS VDD VDD _02136_ sky130_fd_sc_hd__nor2_8
X_10020_ _01786_ VSS VSS VDD VDD _02137_ sky130_fd_sc_hd__buf_4
X_10021_ _07495_ _02038_ VSS VSS VDD VDD _02138_ sky130_fd_sc_hd__nor2_1
X_10022_ _07493_ _02138_ VSS VSS VDD VDD _02139_ sky130_fd_sc_hd__xnor2_4
X_10023_ _02137_ _02139_ VSS VSS VDD VDD _02140_ sky130_fd_sc_hd__xnor2_1
X_10024_ _07207_ _02107_ _02094_ _02091_ VSS VSS VDD VDD _02141_
+ sky130_fd_sc_hd__o211ai_2
X_10025_ _02136_ _02140_ _02141_ _02110_ VSS VSS VDD VDD _02142_
+ sky130_fd_sc_hd__o211ai_4
X_10026_ _02121_ _02129_ _02134_ _02142_ VSS VSS VDD VDD _02143_
+ sky130_fd_sc_hd__nand4b_2
X_10027_ _02143_ VSS VSS VDD VDD _02144_ sky130_fd_sc_hd__buf_4
X_10028_ _01972_ VSS VSS VDD VDD _02145_ sky130_fd_sc_hd__buf_6
X_10029_ _02072_ _02083_ VSS VSS VDD VDD _02146_ sky130_fd_sc_hd__nand2_1
X_10030_ net11 _02084_ _02046_ VSS VSS VDD VDD _02147_ sky130_fd_sc_hd__nor3b_1
X_10031_ net11 _02051_ _02146_ _02147_ VSS VSS VDD VDD _02148_
+ sky130_fd_sc_hd__a31o_1
X_10032_ _02065_ _02148_ VSS VSS VDD VDD _02149_ sky130_fd_sc_hd__xnor2_1
X_10033_ _02116_ _02135_ _02149_ VSS VSS VDD VDD _02150_ sky130_fd_sc_hd__o21ai_0
X_10034_ _02058_ _02150_ VSS VSS VDD VDD _02151_ sky130_fd_sc_hd__and2_1
X_10035_ _01786_ _01907_ VSS VSS VDD VDD _02152_ sky130_fd_sc_hd__xnor2_2
X_10036_ _01962_ _01963_ _01966_ _01971_ _02152_ VSS VSS VDD
+ VDD _02153_ sky130_fd_sc_hd__a41oi_4
X_10037_ _02071_ _02153_ VSS VSS VDD VDD _02154_ sky130_fd_sc_hd__xor2_4
X_10038_ _02052_ _02085_ _02154_ VSS VSS VDD VDD _02155_ sky130_fd_sc_hd__or3_1
X_10039_ _02155_ VSS VSS VDD VDD _02156_ sky130_fd_sc_hd__inv_1
X_10040_ _02018_ _02061_ VSS VSS VDD VDD _02157_ sky130_fd_sc_hd__xnor2_1
X_10041_ _02052_ _02154_ _02157_ VSS VSS VDD VDD _02158_ sky130_fd_sc_hd__o21ai_0
X_10042_ _02158_ VSS VSS VDD VDD _02159_ sky130_fd_sc_hd__inv_1
X_10043_ _02029_ _02032_ VSS VSS VDD VDD _07488_ sky130_fd_sc_hd__nand2_1
X_10044_ _02071_ _07488_ VSS VSS VDD VDD _02160_ sky130_fd_sc_hd__nor2_1
X_10045_ _07207_ _01907_ VSS VSS VDD VDD _02161_ sky130_fd_sc_hd__xnor2_1
X_10046_ _01897_ _01900_ _02161_ VSS VSS VDD VDD _02162_ sky130_fd_sc_hd__nand3_1
X_10047_ _01910_ _01912_ _02152_ VSS VSS VDD VDD _02163_ sky130_fd_sc_hd__o21ai_0
X_10048_ _02162_ _02163_ _02048_ VSS VSS VDD VDD _02164_ sky130_fd_sc_hd__a21oi_1
X_10049_ _02160_ _02164_ _01972_ VSS VSS VDD VDD _02165_ sky130_fd_sc_hd__mux2_1
X_10050_ _02092_ _02093_ _02085_ _02165_ VSS VSS VDD VDD _02166_
+ sky130_fd_sc_hd__nand4_1
X_10051_ _02049_ _02071_ VSS VSS VDD VDD _02167_ sky130_fd_sc_hd__xnor2_1
X_10052_ _02153_ _02167_ VSS VSS VDD VDD _02168_ sky130_fd_sc_hd__nor2_1
X_10053_ _07488_ _02048_ net11 VSS VSS VDD VDD _02169_ sky130_fd_sc_hd__mux2i_4
X_10054_ _02049_ _02071_ _02161_ VSS VSS VDD VDD _02170_ sky130_fd_sc_hd__nand3_1
X_10055_ _02049_ _02071_ _02152_ VSS VSS VDD VDD _02171_ sky130_fd_sc_hd__or3_1
X_10056_ _01885_ _01960_ _02170_ _02171_ VSS VSS VDD VDD _02172_
+ sky130_fd_sc_hd__a22oi_1
X_10057_ _02040_ _02168_ _02169_ _02172_ VSS VSS VDD VDD _02173_
+ sky130_fd_sc_hd__nor4_1
X_10058_ _02040_ _02165_ _02137_ VSS VSS VDD VDD _02174_ sky130_fd_sc_hd__a21o_1
X_10059_ _02154_ _02169_ _07207_ _02040_ VSS VSS VDD VDD _02175_
+ sky130_fd_sc_hd__a211o_1
X_10060_ _02154_ _02169_ _02041_ VSS VSS VDD VDD _02176_ sky130_fd_sc_hd__o21bai_1
X_10061_ _02173_ _02174_ _02175_ _02176_ VSS VSS VDD VDD _02177_
+ sky130_fd_sc_hd__o211ai_1
X_10062_ _02116_ _02166_ _02177_ VSS VSS VDD VDD _02178_ sky130_fd_sc_hd__o21ai_1
X_10063_ _02136_ _02156_ _02159_ _02178_ VSS VSS VDD VDD _02179_
+ sky130_fd_sc_hd__o31a_2
X_10064_ _02014_ _02015_ _02019_ _02006_ VSS VSS VDD VDD _02180_
+ sky130_fd_sc_hd__a31oi_2
X_10065_ _02067_ _02148_ _02180_ VSS VSS VDD VDD _02181_ sky130_fd_sc_hd__a21oi_2
X_10066_ _02122_ _01998_ _02128_ VSS VSS VDD VDD _02182_ sky130_fd_sc_hd__a21oi_1
X_10067_ _02010_ _02124_ _02181_ _02182_ VSS VSS VDD VDD _02183_
+ sky130_fd_sc_hd__nor4_2
X_10068_ _02151_ _02179_ _02183_ VSS VSS VDD VDD _02184_ sky130_fd_sc_hd__and3_2
X_10069_ _01987_ _02088_ VSS VSS VDD VDD _02185_ sky130_fd_sc_hd__xnor2_2
X_10070_ _02091_ _02094_ _02107_ VSS VSS VDD VDD _02186_ sky130_fd_sc_hd__nand3_1
X_10071_ _02136_ _02139_ _02186_ _00746_ VSS VSS VDD VDD _02187_
+ sky130_fd_sc_hd__o211a_2
X_10072_ _07530_ _07529_ _07528_ VSS VSS VDD VDD _02188_ sky130_fd_sc_hd__o21a_4
X_10073_ _02188_ _07527_ _07525_ VSS VSS VDD VDD _02189_ sky130_fd_sc_hd__o21a_1
X_10074_ _07524_ _02189_ _07522_ VSS VSS VDD VDD _02190_ sky130_fd_sc_hd__o21a_1
X_10075_ _07521_ _02190_ _07519_ VSS VSS VDD VDD _02191_ sky130_fd_sc_hd__o21a_1
X_10076_ _07518_ _02191_ _07516_ VSS VSS VDD VDD _02192_ sky130_fd_sc_hd__o21a_2
X_10077_ _07515_ _02192_ VSS VSS VDD VDD _02193_ sky130_fd_sc_hd__nor2_4
X_10078_ _02193_ VSS VSS VDD VDD _02194_ sky130_fd_sc_hd__inv_2
X_10079_ _02194_ _07513_ _07512_ VSS VSS VDD VDD _02195_ sky130_fd_sc_hd__a21oi_4
X_10080_ _02137_ _02195_ VSS VSS VDD VDD _02196_ sky130_fd_sc_hd__nor2_1
X_10081_ _02137_ _02195_ _02139_ VSS VSS VDD VDD _02197_ sky130_fd_sc_hd__or3_4
X_10082_ _02195_ _02139_ _02137_ VSS VSS VDD VDD _02198_ sky130_fd_sc_hd__nand3b_4
X_10083_ _02091_ _02094_ _02198_ _02197_ VSS VSS VDD VDD _02199_
+ sky130_fd_sc_hd__a22oi_4
X_10084_ _07207_ _02195_ _02107_ VSS VSS VDD VDD _02200_ sky130_fd_sc_hd__or3_4
X_10085_ _02200_ _02135_ _02116_ VSS VSS VDD VDD _02201_ sky130_fd_sc_hd__nor3_4
X_10086_ _02136_ _02107_ _02196_ _02199_ _02201_ VSS VSS VDD
+ VDD _02202_ sky130_fd_sc_hd__a311o_4
X_10087_ _01973_ _02129_ VSS VSS VDD VDD _02203_ sky130_fd_sc_hd__nand2_1
X_10088_ _02187_ _02202_ _02203_ VSS VSS VDD VDD _02204_ sky130_fd_sc_hd__nor3_2
X_10089_ _02144_ _02184_ _02185_ _02204_ VSS VSS VDD VDD _02205_
+ sky130_fd_sc_hd__nand4_4
X_10090_ _02090_ _02205_ VSS VSS VDD VDD _02206_ sky130_fd_sc_hd__xor2_4
X_10091_ _02187_ _02202_ VSS VSS VDD VDD _02207_ sky130_fd_sc_hd__nor2_8
X_10092_ _02151_ _02179_ VSS VSS VDD VDD _02208_ sky130_fd_sc_hd__and2_2
X_10093_ _02067_ _02148_ _02180_ VSS VSS VDD VDD _02209_ sky130_fd_sc_hd__a21o_1
X_10094_ _01998_ _02128_ _02209_ _02013_ VSS VSS VDD VDD _02210_
+ sky130_fd_sc_hd__o211ai_4
X_10095_ _02130_ _02131_ _02210_ _02133_ VSS VSS VDD VDD _02211_
+ sky130_fd_sc_hd__a211oi_4
X_10096_ _02115_ VSS VSS VDD VDD _02212_ sky130_fd_sc_hd__inv_1
X_10097_ _02116_ _02117_ _02212_ VSS VSS VDD VDD _02213_ sky130_fd_sc_hd__o21ai_0
X_10098_ _02207_ _02208_ _02211_ _02213_ VSS VSS VDD VDD _02214_
+ sky130_fd_sc_hd__a31oi_2
X_10099_ _02136_ _02139_ _02186_ _00746_ VSS VSS VDD VDD _02215_
+ sky130_fd_sc_hd__o211ai_2
X_10100_ _02136_ _02107_ _02196_ _02201_ _02199_ VSS VSS VDD
+ VDD _02216_ sky130_fd_sc_hd__a311oi_4
X_10101_ _02216_ _02215_ VSS VSS VDD VDD _02217_ sky130_fd_sc_hd__nand2_4
X_10102_ _02151_ _02179_ VSS VSS VDD VDD _02218_ sky130_fd_sc_hd__nand2_1
X_10103_ _02136_ VSS VSS VDD VDD _02219_ sky130_fd_sc_hd__buf_6
X_10104_ net16 _02140_ _02141_ _02110_ VSS VSS VDD VDD _02220_
+ sky130_fd_sc_hd__o211a_1
X_10105_ _02220_ _02121_ _02211_ VSS VSS VDD VDD _02221_ sky130_fd_sc_hd__o21ai_1
X_10106_ _02217_ _02212_ _02218_ _02221_ VSS VSS VDD VDD _02222_
+ sky130_fd_sc_hd__nor4_1
X_10107_ _02132_ VSS VSS VDD VDD _02223_ sky130_fd_sc_hd__inv_1
X_10108_ _02223_ _02087_ _01996_ VSS VSS VDD VDD _02224_ sky130_fd_sc_hd__o21ai_1
X_10109_ _02116_ _02092_ _02117_ VSS VSS VDD VDD _02225_ sky130_fd_sc_hd__or3_1
X_10110_ _02119_ _02212_ VSS VSS VDD VDD _02226_ sky130_fd_sc_hd__nand2_1
X_10111_ _02224_ _02225_ _02226_ VSS VSS VDD VDD _02227_ sky130_fd_sc_hd__nand3_1
X_10112_ _02207_ _02208_ _02211_ _02120_ VSS VSS VDD VDD _02228_
+ sky130_fd_sc_hd__a31o_1
X_10113_ _02214_ _02222_ _02227_ _02228_ VSS VSS VDD VDD _02229_
+ sky130_fd_sc_hd__or4b_4
X_10114_ _02095_ _02155_ _02158_ VSS VSS VDD VDD _02230_ sky130_fd_sc_hd__nand3_1
X_10115_ _02215_ _02216_ _02178_ VSS VSS VDD VDD _02231_ sky130_fd_sc_hd__and3_1
X_10116_ _02151_ _02179_ _02183_ VSS VSS VDD VDD _02232_ sky130_fd_sc_hd__nand3_4
X_10117_ _07207_ _02043_ VSS VSS VDD VDD _02233_ sky130_fd_sc_hd__xnor2_1
X_10118_ _02116_ _02135_ _02233_ VSS VSS VDD VDD _02234_ sky130_fd_sc_hd__o21ai_1
X_10119_ _02169_ _02234_ VSS VSS VDD VDD _02235_ sky130_fd_sc_hd__xnor2_2
X_10120_ _02187_ _02202_ _02235_ VSS VSS VDD VDD _02236_ sky130_fd_sc_hd__o21ai_1
X_10121_ _02187_ _02202_ _02235_ VSS VSS VDD VDD _02237_ sky130_fd_sc_hd__or3_1
X_10122_ _02144_ _02232_ _02236_ _02237_ VSS VSS VDD VDD _02238_
+ sky130_fd_sc_hd__o211ai_4
X_10123_ _02144_ _02232_ _02207_ _02179_ VSS VSS VDD VDD _02239_
+ sky130_fd_sc_hd__o211ai_4
X_10124_ _02095_ _02149_ VSS VSS VDD VDD _02240_ sky130_fd_sc_hd__and2_2
X_10125_ _02052_ net16 VSS VSS VDD VDD _02241_ sky130_fd_sc_hd__nor2_1
X_10126_ _02154_ _02241_ VSS VSS VDD VDD _02242_ sky130_fd_sc_hd__xor2_4
X_10127_ _02240_ _02242_ VSS VSS VDD VDD _02243_ sky130_fd_sc_hd__nor2_1
X_10128_ _02230_ _02231_ _02238_ _02239_ _02243_ VSS VSS VDD
+ VDD _02244_ sky130_fd_sc_hd__o2111a_2
X_10129_ _02121_ _02211_ _02142_ VSS VSS VDD VDD _02245_ sky130_fd_sc_hd__nand3b_4
X_10130_ _02215_ _02216_ _02150_ _02179_ VSS VSS VDD VDD _02246_
+ sky130_fd_sc_hd__nand4_1
X_10131_ _02065_ _02095_ _02148_ VSS VSS VDD VDD _02247_ sky130_fd_sc_hd__and3_1
X_10132_ _02019_ _02058_ VSS VSS VDD VDD _02248_ sky130_fd_sc_hd__nand2_1
X_10133_ _02247_ _02248_ VSS VSS VDD VDD _02249_ sky130_fd_sc_hd__xor2_2
X_10134_ _02207_ _02208_ _02245_ _02246_ _02249_ VSS VSS VDD
+ VDD _02250_ sky130_fd_sc_hd__a32oi_4
X_10135_ _02013_ _01998_ _02128_ VSS VSS VDD VDD _02251_ sky130_fd_sc_hd__a21oi_2
X_10136_ _02124_ _02181_ _02251_ VSS VSS VDD VDD _02252_ sky130_fd_sc_hd__nor3_1
X_10137_ _02250_ _02252_ VSS VSS VDD VDD _02253_ sky130_fd_sc_hd__and2_1
X_10138_ net16 _02139_ _02186_ VSS VSS VDD VDD _02254_ sky130_fd_sc_hd__o21ai_2
X_10139_ _02143_ _02217_ _02232_ VSS VSS VDD VDD _02255_ sky130_fd_sc_hd__nor3_4
X_10140_ _07537_ _00584_ _07535_ VSS VSS VDD VDD _02256_ sky130_fd_sc_hd__o21a_1
X_10141_ _02256_ _07534_ VSS VSS VDD VDD _02257_ sky130_fd_sc_hd__nor2_4
X_10142_ _07207_ _02257_ VSS VSS VDD VDD _02258_ sky130_fd_sc_hd__nor2_1
X_10143_ _07476_ _07478_ _01903_ VSS VSS VDD VDD _02259_ sky130_fd_sc_hd__nor3_1
X_10144_ _01904_ _02259_ VSS VSS VDD VDD _02260_ sky130_fd_sc_hd__or2_0
X_10145_ _07456_ _07458_ _01759_ VSS VSS VDD VDD _02261_ sky130_fd_sc_hd__nor3_1
X_10146_ _01633_ _07395_ VSS VSS VDD VDD _07414_ sky130_fd_sc_hd__nor2_4
X_10147_ _07418_ _07416_ _07417_ VSS VSS VDD VDD _02262_ sky130_fd_sc_hd__nor3_1
X_10148_ _01569_ _02262_ VSS VSS VDD VDD _02263_ sky130_fd_sc_hd__nor2_1
X_10149_ _07414_ _02263_ _01733_ VSS VSS VDD VDD _07434_ sky130_fd_sc_hd__mux2_4
X_10150_ _07436_ _07438_ _01708_ VSS VSS VDD VDD _02264_ sky130_fd_sc_hd__nor3_1
X_10151_ _01709_ _02054_ _02264_ VSS VSS VDD VDD _02265_ sky130_fd_sc_hd__nor3_1
X_10152_ _02054_ _07434_ _02265_ VSS VSS VDD VDD _07454_ sky130_fd_sc_hd__a21o_1
X_10153_ _02063_ _07454_ VSS VSS VDD VDD _02266_ sky130_fd_sc_hd__nand2_1
X_10154_ _01760_ _02063_ _02261_ _02266_ VSS VSS VDD VDD _07474_
+ sky130_fd_sc_hd__o31ai_1
X_10155_ net11 _07474_ VSS VSS VDD VDD _02267_ sky130_fd_sc_hd__nor2_1
X_10156_ net11 _02260_ _02267_ VSS VSS VDD VDD _07494_ sky130_fd_sc_hd__a21oi_1
X_10157_ _07496_ _07498_ _02037_ VSS VSS VDD VDD _02268_ sky130_fd_sc_hd__nor3_1
X_10158_ _02038_ _02268_ VSS VSS VDD VDD _02269_ sky130_fd_sc_hd__nor2_1
X_10159_ _07494_ _02269_ _02095_ VSS VSS VDD VDD _07511_ sky130_fd_sc_hd__mux2_2
X_10160_ _00746_ _02258_ _07511_ VSS VSS VDD VDD _02270_ sky130_fd_sc_hd__o21ai_0
X_10161_ _02137_ _07511_ _02257_ VSS VSS VDD VDD _02271_ sky130_fd_sc_hd__or3_1
X_10162_ _02270_ _02271_ VSS VSS VDD VDD _02272_ sky130_fd_sc_hd__and2_0
X_10163_ _02137_ _02195_ VSS VSS VDD VDD _02273_ sky130_fd_sc_hd__xnor2_1
X_10164_ _07513_ _02193_ VSS VSS VDD VDD _02274_ sky130_fd_sc_hd__xor2_2
X_10165_ _02137_ _02274_ VSS VSS VDD VDD _02275_ sky130_fd_sc_hd__xnor2_1
X_10166_ _02049_ _02274_ _02275_ _02257_ VSS VSS VDD VDD _02276_
+ sky130_fd_sc_hd__o22a_1
X_10167_ _02254_ _02273_ _02276_ VSS VSS VDD VDD _02277_ sky130_fd_sc_hd__nor3b_2
X_10168_ _02254_ _02273_ _02276_ VSS VSS VDD VDD _02278_ sky130_fd_sc_hd__and3_1
X_10169_ _02217_ _02144_ _02232_ _02277_ _02278_ VSS VSS VDD
+ VDD _02279_ sky130_fd_sc_hd__o32a_1
X_10170_ _02254_ _02255_ _02272_ _02279_ VSS VSS VDD VDD _02280_
+ sky130_fd_sc_hd__a31o_4
X_10171_ _02244_ _02280_ _02253_ VSS VSS VDD VDD _02281_ sky130_fd_sc_hd__and3_4
Xrebuffer40 _02784_ VSS VSS VDD VDD net407 sky130_fd_sc_hd__dlygate4sd1_1
X_10173_ _02003_ _02006_ VSS VSS VDD VDD _02283_ sky130_fd_sc_hd__nand2_1
X_10174_ _02125_ _02182_ VSS VSS VDD VDD _02284_ sky130_fd_sc_hd__nand2_1
X_10175_ _02124_ _02128_ _02123_ _02010_ VSS VSS VDD VDD _02285_
+ sky130_fd_sc_hd__o211ai_2
X_10176_ _02283_ _02284_ _02285_ VSS VSS VDD VDD _02286_ sky130_fd_sc_hd__nand3_4
X_10177_ _02017_ net428 _01969_ VSS VSS VDD VDD _02287_ sky130_fd_sc_hd__a21oi_4
X_10178_ _02128_ _02127_ VSS VSS VDD VDD _02288_ sky130_fd_sc_hd__nor2_2
X_10179_ _02287_ _02288_ VSS VSS VDD VDD _02289_ sky130_fd_sc_hd__xnor2_4
X_10180_ _02210_ _02289_ VSS VSS VDD VDD _02290_ sky130_fd_sc_hd__xor2_1
X_10181_ _02286_ _02290_ VSS VSS VDD VDD _02291_ sky130_fd_sc_hd__and2_0
X_10182_ _02286_ _02289_ VSS VSS VDD VDD _02292_ sky130_fd_sc_hd__nor2_1
X_10183_ _02207_ _02208_ _02245_ _02252_ VSS VSS VDD VDD _02293_
+ sky130_fd_sc_hd__nand4_4
X_10184_ _02291_ _02292_ _02293_ VSS VSS VDD VDD _02294_ sky130_fd_sc_hd__mux2i_4
X_10185_ _01869_ _01872_ net428 VSS VSS VDD VDD _02295_ sky130_fd_sc_hd__a21oi_1
X_10186_ _02295_ _01961_ VSS VSS VDD VDD _02296_ sky130_fd_sc_hd__nor2_1
X_10187_ _02287_ _02288_ _02296_ VSS VSS VDD VDD _02297_ sky130_fd_sc_hd__a21oi_1
X_10188_ _02088_ _02297_ VSS VSS VDD VDD _02298_ sky130_fd_sc_hd__nor2_1
X_10189_ _02298_ VSS VSS VDD VDD _02299_ sky130_fd_sc_hd__clkinv_2
X_10190_ _02207_ _02144_ _02184_ VSS VSS VDD VDD _02300_ sky130_fd_sc_hd__nand3_2
X_10191_ _02129_ _02300_ VSS VSS VDD VDD _02301_ sky130_fd_sc_hd__xor2_4
X_10192_ _02144_ _02184_ _02204_ VSS VSS VDD VDD _02302_ sky130_fd_sc_hd__nand3_1
X_10193_ _02185_ _02302_ VSS VSS VDD VDD _02303_ sky130_fd_sc_hd__xor2_2
X_10194_ _02294_ _02299_ _02301_ _02303_ VSS VSS VDD VDD _02304_
+ sky130_fd_sc_hd__nor4_4
X_10195_ _02304_ VSS VSS VDD VDD _02305_ sky130_fd_sc_hd__buf_4
X_10196_ _02305_ _02281_ VSS VSS VDD VDD _02306_ sky130_fd_sc_hd__nand2_8
X_10197_ _02206_ _02306_ _02229_ VSS VSS VDD VDD _02307_ sky130_fd_sc_hd__nor3_4
X_10198_ _07538_ _07540_ _00583_ VSS VSS VDD VDD _02308_ sky130_fd_sc_hd__nor3_1
X_10199_ _02255_ VSS VSS VDD VDD _02309_ sky130_fd_sc_hd__buf_6
X_10200_ _07519_ _07521_ _02190_ VSS VSS VDD VDD _02310_ sky130_fd_sc_hd__nor3_1
X_10201_ _07502_ _07504_ _02035_ VSS VSS VDD VDD _02311_ sky130_fd_sc_hd__nor3_1
X_10202_ _07441_ _02054_ VSS VSS VDD VDD _07460_ sky130_fd_sc_hd__nor2_2
X_10203_ _07464_ _07462_ _07463_ VSS VSS VDD VDD _02312_ sky130_fd_sc_hd__nor3_1
X_10204_ _01758_ _02312_ VSS VSS VDD VDD _02313_ sky130_fd_sc_hd__nor2_1
X_10205_ _07460_ _02313_ _02014_ VSS VSS VDD VDD _07480_ sky130_fd_sc_hd__mux2_4
X_10206_ _07482_ _07484_ _01901_ VSS VSS VDD VDD _02314_ sky130_fd_sc_hd__nor3_1
X_10207_ _01902_ _02314_ _02145_ VSS VSS VDD VDD _02315_ sky130_fd_sc_hd__o21ai_0
X_10208_ _07480_ _02145_ _02315_ VSS VSS VDD VDD _07500_ sky130_fd_sc_hd__o21a_1
X_10209_ _07500_ _02219_ VSS VSS VDD VDD _02316_ sky130_fd_sc_hd__nand2_1
X_10210_ _02036_ _02219_ _02311_ _02316_ VSS VSS VDD VDD _07517_
+ sky130_fd_sc_hd__o31ai_1
X_10211_ _07517_ net8 VSS VSS VDD VDD _02317_ sky130_fd_sc_hd__nand2_1
X_10212_ _02191_ net8 _02310_ _02317_ VSS VSS VDD VDD _07536_
+ sky130_fd_sc_hd__o31ai_2
X_10213_ _07536_ net2 VSS VSS VDD VDD _02318_ sky130_fd_sc_hd__nand2_1
X_10214_ _00584_ net2 _02308_ _02318_ VSS VSS VDD VDD _07559_
+ sky130_fd_sc_hd__o31ai_2
X_10215_ _07555_ _07554_ _07553_ VSS VSS VDD VDD _02319_ sky130_fd_sc_hd__o21a_1
X_10216_ _07552_ _02319_ _07573_ VSS VSS VDD VDD _02320_ sky130_fd_sc_hd__o21a_1
X_10217_ _07572_ _02320_ _07570_ VSS VSS VDD VDD _02321_ sky130_fd_sc_hd__o21a_1
X_10218_ _07569_ _02321_ _07567_ VSS VSS VDD VDD _02322_ sky130_fd_sc_hd__o21a_1
X_10219_ _07566_ _02322_ _07564_ VSS VSS VDD VDD _02323_ sky130_fd_sc_hd__o21a_1
X_10220_ _07563_ _02323_ _07561_ VSS VSS VDD VDD _02324_ sky130_fd_sc_hd__o21a_1
X_10221_ _07561_ _07563_ _02323_ VSS VSS VDD VDD _02325_ sky130_fd_sc_hd__nor3_1
X_10222_ _02324_ _02325_ VSS VSS VDD VDD _02326_ sky130_fd_sc_hd__nor2_1
X_10223_ _02228_ _02226_ VSS VSS VDD VDD _02327_ sky130_fd_sc_hd__nand2_2
X_10224_ _02224_ _02225_ VSS VSS VDD VDD _02328_ sky130_fd_sc_hd__nand2_2
X_10225_ _02206_ _02328_ VSS VSS VDD VDD _02329_ sky130_fd_sc_hd__nor2_1
X_10226_ _02217_ _02218_ _02221_ _02225_ VSS VSS VDD VDD _02330_
+ sky130_fd_sc_hd__o31ai_1
X_10227_ _02115_ _02330_ _02214_ VSS VSS VDD VDD _02331_ sky130_fd_sc_hd__a21oi_2
X_10228_ _02329_ _02281_ _02305_ _02331_ VSS VSS VDD VDD _02332_
+ sky130_fd_sc_hd__a31oi_4
X_10229_ _02327_ _02332_ VSS VSS VDD VDD _02333_ sky130_fd_sc_hd__or2_2
X_10230_ _02206_ _02229_ VSS VSS VDD VDD _02334_ sky130_fd_sc_hd__nor2_4
X_10231_ _02334_ VSS VSS VDD VDD _02335_ sky130_fd_sc_hd__clkbuf_8
X_10232_ _02244_ _02253_ _02280_ VSS VSS VDD VDD _02336_ sky130_fd_sc_hd__nand3_4
X_10233_ _02336_ _02294_ _02299_ _02301_ _02303_ VSS VSS VDD
+ VDD _02337_ sky130_fd_sc_hd__o41ai_4
X_10234_ _02090_ _02205_ VSS VSS VDD VDD _02338_ sky130_fd_sc_hd__xnor2_4
X_10235_ _02207_ _02129_ _02144_ _02184_ VSS VSS VDD VDD _02339_
+ sky130_fd_sc_hd__nand4_4
X_10236_ _02133_ _02339_ VSS VSS VDD VDD _02340_ sky130_fd_sc_hd__nor2_1
X_10237_ _02328_ _02340_ VSS VSS VDD VDD _02341_ sky130_fd_sc_hd__xnor2_1
X_10238_ _02289_ _02339_ VSS VSS VDD VDD _02342_ sky130_fd_sc_hd__xnor2_4
X_10239_ _02299_ _02342_ VSS VSS VDD VDD _02343_ sky130_fd_sc_hd__nor2_1
X_10240_ _02338_ _02341_ _02343_ VSS VSS VDD VDD _02344_ sky130_fd_sc_hd__and3_1
X_10241_ _02335_ _02306_ _02337_ _02344_ VSS VSS VDD VDD _02345_
+ sky130_fd_sc_hd__o211ai_4
X_10242_ _02333_ _02345_ VSS VSS VDD VDD _02346_ sky130_fd_sc_hd__nor2_4
X_10243_ _02217_ _02144_ _02232_ _02274_ VSS VSS VDD VDD _02347_
+ sky130_fd_sc_hd__o31ai_1
X_10244_ _02217_ _02144_ _02232_ _07511_ _02347_ VSS VSS VDD
+ VDD _02348_ sky130_fd_sc_hd__o41a_2
X_10245_ _02137_ _02257_ VSS VSS VDD VDD _02349_ sky130_fd_sc_hd__xnor2_2
X_10246_ _02348_ _02349_ VSS VSS VDD VDD _02350_ sky130_fd_sc_hd__xnor2_2
X_10247_ _02144_ _02232_ _02235_ _02207_ VSS VSS VDD VDD _02351_
+ sky130_fd_sc_hd__o211ai_4
X_10248_ _02351_ _02242_ VSS VSS VDD VDD _02352_ sky130_fd_sc_hd__xor2_1
X_10249_ _02238_ _02352_ VSS VSS VDD VDD _02353_ sky130_fd_sc_hd__nand2_1
X_10250_ _02181_ _02251_ VSS VSS VDD VDD _02354_ sky130_fd_sc_hd__nor2_2
X_10251_ _02250_ _02354_ VSS VSS VDD VDD _02355_ sky130_fd_sc_hd__nand2_1
X_10252_ _02280_ _02350_ _02353_ _02355_ VSS VSS VDD VDD _02356_
+ sky130_fd_sc_hd__or4_2
X_10253_ _02255_ _02274_ VSS VSS VDD VDD _02357_ sky130_fd_sc_hd__nor2_1
X_10254_ _02255_ _07511_ _02357_ VSS VSS VDD VDD _02358_ sky130_fd_sc_hd__a21oi_2
X_10255_ _02334_ _02281_ _02304_ _02358_ VSS VSS VDD VDD _02359_
+ sky130_fd_sc_hd__nand4_4
X_10256_ _02240_ _02239_ VSS VSS VDD VDD _02360_ sky130_fd_sc_hd__xnor2_4
X_10257_ _02324_ _07560_ VSS VSS VDD VDD _02361_ sky130_fd_sc_hd__nor2_2
X_10258_ _02361_ VSS VSS VDD VDD _02362_ sky130_fd_sc_hd__inv_2
X_10259_ _02362_ _07558_ _07557_ VSS VSS VDD VDD _02363_ sky130_fd_sc_hd__a21oi_4
X_10260_ _02363_ VSS VSS VDD VDD _02364_ sky130_fd_sc_hd__inv_2
X_10261_ _02254_ _02273_ VSS VSS VDD VDD _02365_ sky130_fd_sc_hd__xnor2_1
X_10262_ _02270_ _02271_ _02254_ VSS VSS VDD VDD _02366_ sky130_fd_sc_hd__a21oi_1
X_10263_ _02255_ _02366_ VSS VSS VDD VDD _02367_ sky130_fd_sc_hd__nand2_1
X_10264_ _02255_ _02276_ _02365_ _02367_ VSS VSS VDD VDD _02368_
+ sky130_fd_sc_hd__o31ai_4
X_10265_ _02230_ _02231_ _02239_ VSS VSS VDD VDD _02369_ sky130_fd_sc_hd__o21a_1
X_10266_ _02238_ _02280_ _02352_ _02369_ VSS VSS VDD VDD _02370_
+ sky130_fd_sc_hd__a31oi_2
X_10267_ _02360_ _02370_ _02368_ _02364_ VSS VSS VDD VDD _02371_
+ sky130_fd_sc_hd__or4_4
X_10268_ _02244_ _02253_ VSS VSS VDD VDD _02372_ sky130_fd_sc_hd__and2_1
X_10269_ _02242_ _02369_ _02280_ _02238_ VSS VSS VDD VDD _02373_
+ sky130_fd_sc_hd__nand4b_2
X_10270_ _02334_ _02372_ _02304_ _02373_ VSS VSS VDD VDD _02374_
+ sky130_fd_sc_hd__a31oi_4
X_10271_ _02356_ _02359_ _02374_ _02371_ VSS VSS VDD VDD _02375_
+ sky130_fd_sc_hd__a211oi_4
X_10272_ _02217_ _02218_ VSS VSS VDD VDD _02376_ sky130_fd_sc_hd__nor2_1
X_10273_ _02376_ _02245_ _02354_ _02251_ VSS VSS VDD VDD _02377_
+ sky130_fd_sc_hd__a31oi_4
X_10274_ _02124_ _02377_ VSS VSS VDD VDD _02378_ sky130_fd_sc_hd__xor2_4
X_10275_ _02335_ _02305_ _02378_ _02336_ VSS VSS VDD VDD _02379_
+ sky130_fd_sc_hd__a31oi_4
X_10276_ _02286_ _02293_ VSS VSS VDD VDD _02380_ sky130_fd_sc_hd__xnor2_4
X_10277_ _02280_ VSS VSS VDD VDD _02381_ sky130_fd_sc_hd__clkbuf_4
X_10278_ _02244_ _02250_ _02354_ _02381_ _02378_ VSS VSS VDD
+ VDD _02382_ sky130_fd_sc_hd__a41oi_4
X_10279_ _02379_ _02380_ _02382_ VSS VSS VDD VDD _02383_ sky130_fd_sc_hd__nor3_4
X_10280_ _02334_ _02304_ _02380_ _02336_ VSS VSS VDD VDD _02384_
+ sky130_fd_sc_hd__a211oi_4
X_10281_ _02301_ _02384_ VSS VSS VDD VDD _02385_ sky130_fd_sc_hd__xnor2_4
X_10282_ _02383_ _02385_ _02375_ VSS VSS VDD VDD _02386_ sky130_fd_sc_hd__and3_4
X_10283_ _02346_ _02386_ VSS VSS VDD VDD _02387_ sky130_fd_sc_hd__nand2_2
X_10284_ _07559_ _02326_ _02387_ VSS VSS VDD VDD _07582_ sky130_fd_sc_hd__mux2_1
X_10285_ _02333_ _02345_ VSS VSS VDD VDD _02388_ sky130_fd_sc_hd__or2_4
X_10286_ _02383_ _02375_ _02385_ VSS VSS VDD VDD _02389_ sky130_fd_sc_hd__nand3_4
X_10287_ _02389_ _02388_ VSS VSS VDD VDD _02390_ sky130_fd_sc_hd__nor2_8
X_10288_ _02364_ _02368_ VSS VSS VDD VDD _02391_ sky130_fd_sc_hd__nor2_2
X_10289_ _02238_ _02381_ VSS VSS VDD VDD _02392_ sky130_fd_sc_hd__nor2_2
X_10290_ _02381_ _02350_ _02392_ _02359_ VSS VSS VDD VDD _02393_
+ sky130_fd_sc_hd__o31ai_2
X_10291_ _02376_ _02245_ _02354_ VSS VSS VDD VDD _02394_ sky130_fd_sc_hd__nand3_1
X_10292_ _02376_ _02354_ _02394_ VSS VSS VDD VDD _02395_ sky130_fd_sc_hd__o21ai_1
X_10293_ _02244_ _02381_ VSS VSS VDD VDD _02396_ sky130_fd_sc_hd__nand2_1
X_10294_ _02250_ _02396_ VSS VSS VDD VDD _02397_ sky130_fd_sc_hd__xor2_1
X_10295_ _02351_ _02242_ VSS VSS VDD VDD _02398_ sky130_fd_sc_hd__xnor2_2
X_10296_ _02238_ _02381_ _02398_ VSS VSS VDD VDD _02399_ sky130_fd_sc_hd__a21oi_1
X_10297_ _02238_ _02280_ _02398_ VSS VSS VDD VDD _02400_ sky130_fd_sc_hd__and3_1
X_10298_ _02399_ _02400_ _02369_ VSS VSS VDD VDD _02401_ sky130_fd_sc_hd__o21ai_1
X_10299_ _02335_ _02281_ _02305_ VSS VSS VDD VDD _02402_ sky130_fd_sc_hd__nand3_4
X_10300_ _02395_ _02397_ _02401_ _02402_ VSS VSS VDD VDD _02403_
+ sky130_fd_sc_hd__o31ai_1
X_10301_ _02360_ _02393_ _02383_ _02403_ VSS VSS VDD VDD _02404_
+ sky130_fd_sc_hd__and4b_1
X_10302_ _02391_ _02343_ _02385_ _02404_ VSS VSS VDD VDD _02405_
+ sky130_fd_sc_hd__nand4_4
X_10303_ _02301_ _02384_ VSS VSS VDD VDD _02406_ sky130_fd_sc_hd__nor2b_2
X_10304_ _02342_ _02406_ VSS VSS VDD VDD _02407_ sky130_fd_sc_hd__xor2_2
X_10305_ _02375_ _02383_ _02385_ VSS VSS VDD VDD _02408_ sky130_fd_sc_hd__a21oi_4
X_10306_ _02388_ _02386_ _02407_ _02408_ VSS VSS VDD VDD _02409_
+ sky130_fd_sc_hd__a211oi_4
X_10307_ _02300_ VSS VSS VDD VDD _02410_ sky130_fd_sc_hd__inv_1
X_10308_ _02289_ _02129_ VSS VSS VDD VDD _02411_ sky130_fd_sc_hd__nor2b_1
X_10309_ _02410_ _02384_ _02411_ VSS VSS VDD VDD _02412_ sky130_fd_sc_hd__o21ai_1
X_10310_ _02299_ _02412_ VSS VSS VDD VDD _02413_ sky130_fd_sc_hd__xnor2_2
X_10311_ _02342_ _02346_ _02389_ _02413_ VSS VSS VDD VDD _02414_
+ sky130_fd_sc_hd__o31ai_4
X_10312_ _02390_ _02405_ _02409_ _02414_ VSS VSS VDD VDD _02415_
+ sky130_fd_sc_hd__o211ai_4
X_10313_ _02379_ _02380_ _02382_ VSS VSS VDD VDD _02416_ sky130_fd_sc_hd__or3_1
X_10314_ _02402_ _02397_ VSS VSS VDD VDD _02417_ sky130_fd_sc_hd__nand2_1
X_10315_ _02381_ _02350_ _02353_ VSS VSS VDD VDD _02418_ sky130_fd_sc_hd__or3_1
X_10316_ _02418_ _02359_ _02371_ VSS VSS VDD VDD _02419_ sky130_fd_sc_hd__a21oi_2
X_10317_ _02244_ _02250_ _02381_ VSS VSS VDD VDD _02420_ sky130_fd_sc_hd__nand3_1
X_10318_ _02335_ _02281_ _02305_ _02420_ VSS VSS VDD VDD _02421_
+ sky130_fd_sc_hd__a31oi_1
X_10319_ _02395_ _02421_ VSS VSS VDD VDD _02422_ sky130_fd_sc_hd__xnor2_1
X_10320_ _02417_ _02419_ _02422_ VSS VSS VDD VDD _02423_ sky130_fd_sc_hd__a21oi_2
X_10321_ _02375_ _02416_ _02423_ _02389_ _02388_ VSS VSS VDD
+ VDD _02424_ sky130_fd_sc_hd__o32ai_4
X_10322_ _02424_ VSS VSS VDD VDD _02425_ sky130_fd_sc_hd__clkinvlp_4
X_10323_ _02335_ _02306_ _02337_ VSS VSS VDD VDD _02426_ sky130_fd_sc_hd__o21ai_4
X_10324_ _02206_ _02426_ _02333_ VSS VSS VDD VDD _02427_ sky130_fd_sc_hd__or3_2
X_10325_ _02206_ _02335_ _02306_ _02339_ _02133_ VSS VSS VDD
+ VDD _02428_ sky130_fd_sc_hd__o32ai_4
X_10326_ _02328_ _02428_ VSS VSS VDD VDD _02429_ sky130_fd_sc_hd__xor2_4
X_10327_ net13 _02405_ _02429_ VSS VSS VDD VDD _02430_ sky130_fd_sc_hd__o21a_1
X_10328_ _02415_ _02425_ _02427_ _02430_ VSS VSS VDD VDD _02431_
+ sky130_fd_sc_hd__nor4_4
X_10329_ _02402_ _02401_ VSS VSS VDD VDD _02432_ sky130_fd_sc_hd__and2_1
X_10330_ _02402_ _02397_ VSS VSS VDD VDD _02433_ sky130_fd_sc_hd__and2_0
X_10331_ _02335_ _02372_ _02305_ _02373_ VSS VSS VDD VDD _02434_
+ sky130_fd_sc_hd__a31o_1
X_10332_ _02402_ _02397_ _02434_ VSS VSS VDD VDD _02435_ sky130_fd_sc_hd__nand3_1
X_10333_ _02433_ _02435_ _02419_ VSS VSS VDD VDD _02436_ sky130_fd_sc_hd__mux2i_2
X_10334_ _02346_ _02386_ _02436_ VSS VSS VDD VDD _02437_ sky130_fd_sc_hd__a21oi_4
X_10335_ _02360_ _02432_ _02437_ VSS VSS VDD VDD _02438_ sky130_fd_sc_hd__nor3_4
X_10336_ _02381_ _02350_ _02359_ VSS VSS VDD VDD _02439_ sky130_fd_sc_hd__o21ai_2
X_10337_ _02392_ _02391_ _02439_ VSS VSS VDD VDD _02440_ sky130_fd_sc_hd__and3_2
X_10338_ _02335_ _02372_ _02305_ VSS VSS VDD VDD _02441_ sky130_fd_sc_hd__nand3_1
X_10339_ _02238_ _02381_ _02441_ VSS VSS VDD VDD _02442_ sky130_fd_sc_hd__and3_2
X_10340_ _02391_ _02439_ _02442_ _02392_ VSS VSS VDD VDD _02443_
+ sky130_fd_sc_hd__a211oi_4
X_10341_ _07575_ _07574_ _07581_ VSS VSS VDD VDD _02444_ sky130_fd_sc_hd__o21a_1
X_10342_ _07580_ _02444_ _07578_ VSS VSS VDD VDD _02445_ sky130_fd_sc_hd__o21a_1
X_10343_ _07577_ _02445_ _07596_ VSS VSS VDD VDD _02446_ sky130_fd_sc_hd__o21a_1
X_10344_ _07595_ _02446_ _07593_ VSS VSS VDD VDD _02447_ sky130_fd_sc_hd__o21a_1
X_10345_ _07592_ _02447_ _07590_ VSS VSS VDD VDD _02448_ sky130_fd_sc_hd__o21a_1
X_10346_ _07589_ _02448_ _07587_ VSS VSS VDD VDD _02449_ sky130_fd_sc_hd__o21a_1
X_10347_ _07586_ _02449_ VSS VSS VDD VDD _02450_ sky130_fd_sc_hd__or2_4
X_10348_ _02450_ _07584_ _07583_ VSS VSS VDD VDD _02451_ sky130_fd_sc_hd__a21oi_4
X_10349_ _07516_ _07518_ _02191_ VSS VSS VDD VDD _02452_ sky130_fd_sc_hd__nor3_1
X_10350_ _07499_ _07501_ _02036_ VSS VSS VDD VDD _02453_ sky130_fd_sc_hd__nor3_1
X_10351_ _07479_ _07481_ _01902_ VSS VSS VDD VDD _02454_ sky130_fd_sc_hd__nor3_1
X_10352_ _01903_ _02454_ VSS VSS VDD VDD _02455_ sky130_fd_sc_hd__or2_0
X_10353_ _07459_ _07461_ _01758_ VSS VSS VDD VDD _02456_ sky130_fd_sc_hd__nor3_1
X_10354_ _07441_ _07439_ _07440_ VSS VSS VDD VDD _02457_ sky130_fd_sc_hd__nor3_1
X_10355_ _01708_ _02457_ VSS VSS VDD VDD _02458_ sky130_fd_sc_hd__nor2_1
X_10356_ _01730_ _01658_ _07418_ VSS VSS VDD VDD _07437_ sky130_fd_sc_hd__a21oi_4
X_10357_ _02458_ _07437_ _02054_ VSS VSS VDD VDD _07457_ sky130_fd_sc_hd__mux2_4
X_10358_ _02063_ _07457_ VSS VSS VDD VDD _02459_ sky130_fd_sc_hd__nand2_1
X_10359_ _01759_ _02063_ _02456_ _02459_ VSS VSS VDD VDD _07477_
+ sky130_fd_sc_hd__o31ai_1
X_10360_ _02145_ _07477_ VSS VSS VDD VDD _02460_ sky130_fd_sc_hd__nor2_1
X_10361_ _02145_ _02455_ _02460_ VSS VSS VDD VDD _07497_ sky130_fd_sc_hd__a21oi_1
X_10362_ net16 _07497_ VSS VSS VDD VDD _02461_ sky130_fd_sc_hd__nand2_1
X_10363_ _02037_ net16 _02453_ _02461_ VSS VSS VDD VDD _07514_
+ sky130_fd_sc_hd__o31ai_2
X_10364_ net8 _07514_ VSS VSS VDD VDD _02462_ sky130_fd_sc_hd__nand2_1
X_10365_ _02192_ _02255_ _02452_ _02462_ VSS VSS VDD VDD _07533_
+ sky130_fd_sc_hd__o31ai_4
X_10366_ _02348_ _07533_ VSS VSS VDD VDD _02463_ sky130_fd_sc_hd__nor2_1
X_10367_ _07535_ _07537_ _00584_ VSS VSS VDD VDD _02464_ sky130_fd_sc_hd__nor3_1
X_10368_ _02256_ _02464_ VSS VSS VDD VDD _02465_ sky130_fd_sc_hd__nor2_1
X_10369_ _02350_ _02465_ VSS VSS VDD VDD _02466_ sky130_fd_sc_hd__nor2_1
X_10370_ _02463_ _02466_ _02402_ VSS VSS VDD VDD _02467_ sky130_fd_sc_hd__mux2_1
X_10371_ _02467_ _02451_ VSS VSS VDD VDD _02468_ sky130_fd_sc_hd__nand2_2
X_10372_ _02381_ _02441_ _02368_ VSS VSS VDD VDD _02469_ sky130_fd_sc_hd__a21oi_1
X_10373_ _07558_ _02361_ VSS VSS VDD VDD _02470_ sky130_fd_sc_hd__xor2_1
X_10374_ _02451_ _02470_ VSS VSS VDD VDD _02471_ sky130_fd_sc_hd__nand2_1
X_10375_ _02471_ VSS VSS VDD VDD _02472_ sky130_fd_sc_hd__inv_1
X_10376_ _02335_ _02281_ _02305_ _02349_ VSS VSS VDD VDD _02473_
+ sky130_fd_sc_hd__a31oi_4
X_10377_ _02348_ _02363_ _02473_ VSS VSS VDD VDD _02474_ sky130_fd_sc_hd__xnor3_1
X_10378_ _02469_ _02472_ _02474_ VSS VSS VDD VDD _02475_ sky130_fd_sc_hd__nand3_1
X_10379_ _02468_ _02389_ _02388_ _02475_ VSS VSS VDD VDD _02476_
+ sky130_fd_sc_hd__o31ai_4
X_10380_ _02390_ _02440_ _02443_ _02476_ VSS VSS VDD VDD _02477_
+ sky130_fd_sc_hd__o31a_4
X_10381_ _02431_ _02438_ _02477_ VSS VSS VDD VDD _02478_ sky130_fd_sc_hd__a21boi_4
X_10382_ _02370_ _02374_ VSS VSS VDD VDD _02479_ sky130_fd_sc_hd__nor2_2
X_10383_ net13 _02440_ _02443_ VSS VSS VDD VDD _02480_ sky130_fd_sc_hd__or3_2
X_10384_ _02480_ _02476_ VSS VSS VDD VDD _02481_ sky130_fd_sc_hd__or2_0
X_10385_ _02398_ _02442_ _02400_ VSS VSS VDD VDD _02482_ sky130_fd_sc_hd__o21bai_4
X_10386_ _02391_ _02439_ VSS VSS VDD VDD _02483_ sky130_fd_sc_hd__nand2_1
X_10387_ _02392_ _02390_ _02483_ VSS VSS VDD VDD _02484_ sky130_fd_sc_hd__nor3_4
X_10388_ _02482_ _02484_ VSS VSS VDD VDD _02485_ sky130_fd_sc_hd__xor2_4
X_10389_ _02479_ _02481_ _02485_ VSS VSS VDD VDD _02486_ sky130_fd_sc_hd__nand3_2
X_10390_ _07607_ _07606_ _07605_ VSS VSS VDD VDD _02487_ sky130_fd_sc_hd__o21a_1
X_10391_ _07604_ _02487_ _07602_ VSS VSS VDD VDD _02488_ sky130_fd_sc_hd__o21a_1
X_10392_ _07601_ _02488_ _07599_ VSS VSS VDD VDD _02489_ sky130_fd_sc_hd__o21a_1
X_10393_ _07598_ _02489_ _07619_ VSS VSS VDD VDD _02490_ sky130_fd_sc_hd__o21a_1
X_10394_ _07618_ _02490_ _07616_ VSS VSS VDD VDD _02491_ sky130_fd_sc_hd__o21a_1
X_10395_ _07615_ _02491_ _07613_ VSS VSS VDD VDD _02492_ sky130_fd_sc_hd__o21ai_2
X_10396_ _07612_ _02492_ VSS VSS VDD VDD _02493_ sky130_fd_sc_hd__nand2b_1
X_10397_ _02493_ _07610_ _07609_ VSS VSS VDD VDD _02494_ sky130_fd_sc_hd__a21oi_2
X_10398_ _07582_ _02438_ _02494_ _02477_ VSS VSS VDD VDD _02495_
+ sky130_fd_sc_hd__and4b_2
X_10399_ _02348_ _02473_ VSS VSS VDD VDD _02496_ sky130_fd_sc_hd__xnor2_2
X_10400_ _02363_ _02496_ VSS VSS VDD VDD _02497_ sky130_fd_sc_hd__xnor2_1
X_10401_ _02451_ _02470_ VSS VSS VDD VDD _02498_ sky130_fd_sc_hd__nor2_1
X_10402_ _07533_ _02465_ _02402_ VSS VSS VDD VDD _07556_ sky130_fd_sc_hd__mux2_1
X_10403_ _02451_ _07556_ VSS VSS VDD VDD _02499_ sky130_fd_sc_hd__xnor2_1
X_10404_ _02496_ _02499_ VSS VSS VDD VDD _02500_ sky130_fd_sc_hd__nand2_1
X_10405_ _02472_ _02497_ _02498_ _02500_ _02387_ VSS VSS VDD
+ VDD _02501_ sky130_fd_sc_hd__o32a_1
X_10406_ _07584_ _02450_ VSS VSS VDD VDD _02502_ sky130_fd_sc_hd__xor2_1
X_10407_ _07610_ _02493_ _07609_ VSS VSS VDD VDD _02503_ sky130_fd_sc_hd__a21o_1
X_10408_ _02501_ _02502_ _02503_ VSS VSS VDD VDD _02504_ sky130_fd_sc_hd__nor3_2
X_10409_ _02495_ _02431_ _02504_ VSS VSS VDD VDD _02505_ sky130_fd_sc_hd__a21oi_4
X_10410_ _02363_ _02496_ _02469_ VSS VSS VDD VDD _02506_ sky130_fd_sc_hd__a21oi_1
X_10411_ _02346_ _02386_ _02483_ VSS VSS VDD VDD _02507_ sky130_fd_sc_hd__a21oi_1
X_10412_ _02472_ _02474_ VSS VSS VDD VDD _02508_ sky130_fd_sc_hd__nand2_1
X_10413_ _02387_ _02468_ _02506_ _02507_ _02508_ VSS VSS VDD
+ VDD _02509_ sky130_fd_sc_hd__o221ai_2
X_10414_ _02480_ _02438_ _02509_ VSS VSS VDD VDD _02510_ sky130_fd_sc_hd__and3_1
X_10415_ _02476_ _02509_ VSS VSS VDD VDD _02511_ sky130_fd_sc_hd__and2b_1
X_10416_ _02431_ _02510_ _02511_ VSS VSS VDD VDD _02512_ sky130_fd_sc_hd__a21oi_2
X_10417_ _02478_ _02486_ _02505_ _02512_ VSS VSS VDD VDD _02513_
+ sky130_fd_sc_hd__or4_1
X_10418_ _02513_ VSS VSS VDD VDD _02514_ sky130_fd_sc_hd__buf_6
X_10419_ _02379_ _02382_ VSS VSS VDD VDD _02515_ sky130_fd_sc_hd__nor2_1
X_10420_ _02346_ _02385_ VSS VSS VDD VDD _02516_ sky130_fd_sc_hd__nand2_1
X_10421_ _02375_ _02515_ VSS VSS VDD VDD _02517_ sky130_fd_sc_hd__and2_0
X_10422_ _02380_ _02516_ _02517_ VSS VSS VDD VDD _02518_ sky130_fd_sc_hd__o21ai_1
X_10423_ net3 _02515_ _02518_ VSS VSS VDD VDD _02519_ sky130_fd_sc_hd__o21a_1
X_10424_ _02390_ VSS VSS VDD VDD _02520_ sky130_fd_sc_hd__buf_6
X_10425_ _02520_ _02405_ _02409_ _02414_ VSS VSS VDD VDD _02521_
+ sky130_fd_sc_hd__o211a_1
X_10426_ _02426_ _02338_ VSS VSS VDD VDD _02522_ sky130_fd_sc_hd__nand2b_1
X_10427_ _02333_ _02522_ VSS VSS VDD VDD _02523_ sky130_fd_sc_hd__nor2_1
X_10428_ _02390_ _02405_ _02429_ VSS VSS VDD VDD _02524_ sky130_fd_sc_hd__o21ai_4
X_10429_ _02521_ _02424_ _02523_ _02524_ VSS VSS VDD VDD _02525_
+ sky130_fd_sc_hd__nand4_4
X_10430_ _02360_ _02432_ VSS VSS VDD VDD _02526_ sky130_fd_sc_hd__nor2_1
X_10431_ _02520_ _02440_ _02443_ _02476_ _02526_ VSS VSS VDD
+ VDD _02527_ sky130_fd_sc_hd__o311a_1
X_10432_ _02525_ _02527_ VSS VSS VDD VDD _02528_ sky130_fd_sc_hd__nand2_1
X_10433_ _02387_ VSS VSS VDD VDD _02529_ sky130_fd_sc_hd__buf_6
X_10434_ net3 net12 _02423_ VSS VSS VDD VDD _02530_ sky130_fd_sc_hd__a21o_2
X_10435_ _02360_ _02374_ VSS VSS VDD VDD _02531_ sky130_fd_sc_hd__nand2b_1
X_10436_ _02391_ _02393_ VSS VSS VDD VDD _02532_ sky130_fd_sc_hd__nand2_1
X_10437_ _02432_ _02532_ _02360_ _02434_ VSS VSS VDD VDD _02533_
+ sky130_fd_sc_hd__o211ai_2
X_10438_ _02419_ _02387_ VSS VSS VDD VDD _02534_ sky130_fd_sc_hd__nand2_1
X_10439_ _02402_ _02401_ VSS VSS VDD VDD _02535_ sky130_fd_sc_hd__nand2_1
X_10440_ _02531_ _02533_ _02534_ _02477_ _02535_ VSS VSS VDD
+ VDD _02536_ sky130_fd_sc_hd__a32oi_4
X_10441_ _02437_ _02530_ _02536_ VSS VSS VDD VDD _02537_ sky130_fd_sc_hd__nor3_1
X_10442_ _02519_ _02528_ _02537_ VSS VSS VDD VDD _02538_ sky130_fd_sc_hd__nand3_2
X_10443_ _02514_ _02538_ VSS VSS VDD VDD _02539_ sky130_fd_sc_hd__nor2_2
X_10444_ _02431_ VSS VSS VDD VDD _02540_ sky130_fd_sc_hd__clkbuf_4
X_10445_ net3 _02423_ VSS VSS VDD VDD _02541_ sky130_fd_sc_hd__nor2_1
X_10446_ _02515_ _02541_ _02520_ VSS VSS VDD VDD _02542_ sky130_fd_sc_hd__a21o_1
X_10447_ _02438_ _02477_ _02542_ VSS VSS VDD VDD _02543_ sky130_fd_sc_hd__nand3_1
X_10448_ _02516_ _02517_ _02379_ VSS VSS VDD VDD _02544_ sky130_fd_sc_hd__a21oi_1
X_10449_ _02379_ _02517_ VSS VSS VDD VDD _02545_ sky130_fd_sc_hd__nor2_1
X_10450_ _02380_ _02545_ VSS VSS VDD VDD _02546_ sky130_fd_sc_hd__nand2_1
X_10451_ _02380_ _02544_ _02546_ VSS VSS VDD VDD _02547_ sky130_fd_sc_hd__o21a_1
X_10452_ _02540_ _02543_ _02547_ VSS VSS VDD VDD _02548_ sky130_fd_sc_hd__o21ai_2
X_10453_ _02438_ _02477_ VSS VSS VDD VDD _02549_ sky130_fd_sc_hd__nand2_8
X_10454_ _02431_ _02549_ _02547_ _02542_ VSS VSS VDD VDD _02550_
+ sky130_fd_sc_hd__or4b_2
X_10455_ net23 _02405_ _02414_ VSS VSS VDD VDD _02551_ sky130_fd_sc_hd__o21ai_4
X_10456_ _02437_ _02424_ VSS VSS VDD VDD _02552_ sky130_fd_sc_hd__nor2b_1
X_10457_ _02427_ _02430_ _02527_ _02552_ VSS VSS VDD VDD _02553_
+ sky130_fd_sc_hd__o211ai_2
X_10458_ net23 _02405_ VSS VSS VDD VDD _02554_ sky130_fd_sc_hd__nor2_1
X_10459_ _02426_ _02554_ VSS VSS VDD VDD _02555_ sky130_fd_sc_hd__xnor2_1
X_10460_ net13 _02440_ _02443_ _02476_ _02526_ VSS VSS VDD
+ VDD _02556_ sky130_fd_sc_hd__o311ai_4
X_10461_ _02425_ _02437_ _02556_ _02551_ VSS VSS VDD VDD _02557_
+ sky130_fd_sc_hd__o31ai_2
X_10462_ _02551_ _02553_ _02555_ _02409_ _02557_ VSS VSS VDD
+ VDD _02558_ sky130_fd_sc_hd__o2111ai_2
X_10463_ _02548_ _02550_ _02558_ VSS VSS VDD VDD _02559_ sky130_fd_sc_hd__a21o_2
X_10464_ _02425_ _02437_ _02556_ VSS VSS VDD VDD _02560_ sky130_fd_sc_hd__nor3_1
X_10465_ _02335_ _02306_ VSS VSS VDD VDD _02561_ sky130_fd_sc_hd__nor2_1
X_10466_ _02281_ _02305_ _02338_ VSS VSS VDD VDD _02562_ sky130_fd_sc_hd__a21oi_1
X_10467_ _02338_ _02561_ _02562_ VSS VSS VDD VDD _02563_ sky130_fd_sc_hd__a21oi_2
X_10468_ _02426_ net13 _02405_ VSS VSS VDD VDD _02564_ sky130_fd_sc_hd__nor3_1
X_10469_ _02563_ _02564_ VSS VSS VDD VDD _02565_ sky130_fd_sc_hd__xnor2_1
X_10470_ _02327_ _02332_ VSS VSS VDD VDD _02566_ sky130_fd_sc_hd__nor2_2
X_10471_ _02360_ _02379_ _02380_ _02382_ VSS VSS VDD VDD _02567_
+ sky130_fd_sc_hd__nor4_1
X_10472_ _07555_ _07558_ _07561_ _07567_ VSS VSS VDD VDD _02568_
+ sky130_fd_sc_hd__nand4_1
X_10473_ _07553_ _07564_ _07570_ _07573_ VSS VSS VDD VDD _02569_
+ sky130_fd_sc_hd__nand4_1
X_10474_ _01114_ _02368_ _02568_ _02569_ VSS VSS VDD VDD _02570_
+ sky130_fd_sc_hd__nor4_1
X_10475_ _02393_ _02403_ _02567_ _02570_ VSS VSS VDD VDD _02571_
+ sky130_fd_sc_hd__nand4_2
X_10476_ _02566_ _02571_ _02389_ _02345_ VSS VSS VDD VDD _02572_
+ sky130_fd_sc_hd__a211oi_4
X_10477_ _02522_ net23 _02405_ _02429_ VSS VSS VDD VDD _02573_
+ sky130_fd_sc_hd__o31a_1
X_10478_ _02572_ _02573_ VSS VSS VDD VDD _02574_ sky130_fd_sc_hd__nor2_4
X_10479_ _02338_ _02566_ _02524_ _02415_ _02426_ VSS VSS VDD
+ VDD _02575_ sky130_fd_sc_hd__a311oi_4
X_10480_ _02565_ _02574_ _02575_ VSS VSS VDD VDD _02576_ sky130_fd_sc_hd__and3_1
X_10481_ _02214_ _02222_ VSS VSS VDD VDD _02577_ sky130_fd_sc_hd__nor2_1
X_10482_ _02577_ _02329_ _02281_ _02305_ VSS VSS VDD VDD _02578_
+ sky130_fd_sc_hd__nand4_2
X_10483_ _02578_ VSS VSS VDD VDD _02579_ sky130_fd_sc_hd__inv_1
X_10484_ _02327_ _02579_ _02332_ VSS VSS VDD VDD _02580_ sky130_fd_sc_hd__a21oi_2
X_10485_ _02572_ _02580_ VSS VSS VDD VDD _02581_ sky130_fd_sc_hd__xor2_4
X_10486_ _02332_ _02345_ _02389_ _02578_ _02327_ VSS VSS VDD
+ VDD _02582_ sky130_fd_sc_hd__o311ai_4
X_10487_ _02581_ _02582_ VSS VSS VDD VDD _02583_ sky130_fd_sc_hd__and2_0
X_10488_ _02563_ _02564_ VSS VSS VDD VDD _02584_ sky130_fd_sc_hd__xor2_1
X_10489_ _02584_ _02574_ _02583_ VSS VSS VDD VDD _02585_ sky130_fd_sc_hd__and3_1
X_10490_ _02560_ _02576_ _02583_ _02585_ VSS VSS VDD VDD _02586_
+ sky130_fd_sc_hd__a31oi_2
X_10491_ _02521_ _02523_ _02524_ _02552_ VSS VSS VDD VDD _02587_
+ sky130_fd_sc_hd__nand4_1
X_10492_ _02527_ _02587_ _02536_ VSS VSS VDD VDD _02588_ sky130_fd_sc_hd__a21o_2
X_10493_ _07582_ _02525_ _02549_ _02501_ _02502_ VSS VSS VDD
+ VDD _02589_ sky130_fd_sc_hd__o32ai_2
X_10494_ _02540_ _02510_ _02511_ VSS VSS VDD VDD _02590_ sky130_fd_sc_hd__a21o_1
X_10495_ _07599_ _07607_ _07610_ _07602_ VSS VSS VDD VDD _02591_
+ sky130_fd_sc_hd__nand4_1
X_10496_ _07605_ _07613_ _07616_ _07619_ VSS VSS VDD VDD _02592_
+ sky130_fd_sc_hd__nand4_1
X_10497_ _01114_ _02591_ _02592_ VSS VSS VDD VDD _02593_ sky130_fd_sc_hd__nor3_2
X_10498_ _02588_ _02589_ _02590_ _02593_ VSS VSS VDD VDD _02594_
+ sky130_fd_sc_hd__and4b_1
X_10499_ _02559_ _02586_ _02594_ VSS VSS VDD VDD _02595_ sky130_fd_sc_hd__nor3_2
X_10500_ _02595_ VSS VSS VDD VDD _02596_ sky130_fd_sc_hd__clkbuf_4
X_10501_ _02539_ _02596_ VSS VSS VDD VDD _02597_ sky130_fd_sc_hd__nand2_4
X_10502_ _07613_ _07615_ _02491_ VSS VSS VDD VDD _02598_ sky130_fd_sc_hd__or3_1
X_10503_ _02492_ _02598_ VSS VSS VDD VDD _02599_ sky130_fd_sc_hd__nand2_1
X_10504_ _02549_ _02525_ VSS VSS VDD VDD _02600_ sky130_fd_sc_hd__nor2_8
X_10505_ _07590_ _07592_ _02447_ VSS VSS VDD VDD _02601_ sky130_fd_sc_hd__nor3_1
X_10506_ _07567_ _07569_ _02321_ VSS VSS VDD VDD _02602_ sky130_fd_sc_hd__nor3_1
X_10507_ _02322_ _02602_ VSS VSS VDD VDD _02603_ sky130_fd_sc_hd__or2_0
X_10508_ _07544_ _07546_ _00581_ VSS VSS VDD VDD _02604_ sky130_fd_sc_hd__nor3_1
X_10509_ _07525_ _07527_ _02188_ VSS VSS VDD VDD _02605_ sky130_fd_sc_hd__nor3_1
X_10510_ _07510_ _07508_ _07509_ VSS VSS VDD VDD _02606_ sky130_fd_sc_hd__nor3_1
X_10511_ _01885_ _01960_ _07487_ VSS VSS VDD VDD _07506_ sky130_fd_sc_hd__a21oi_2
X_10512_ _02219_ _07506_ VSS VSS VDD VDD _02607_ sky130_fd_sc_hd__nand2_1
X_10513_ _02034_ _02219_ _02606_ _02607_ VSS VSS VDD VDD _07523_
+ sky130_fd_sc_hd__o31ai_4
X_10514_ _02309_ _07523_ VSS VSS VDD VDD _02608_ sky130_fd_sc_hd__nand2_1
X_10515_ _02189_ _02309_ _02605_ _02608_ VSS VSS VDD VDD _07542_
+ sky130_fd_sc_hd__o31ai_2
X_10516_ _02307_ _07542_ VSS VSS VDD VDD _02609_ sky130_fd_sc_hd__nand2_1
X_10517_ _00582_ _02307_ _02604_ _02609_ VSS VSS VDD VDD _07565_
+ sky130_fd_sc_hd__o31ai_2
X_10518_ net12 _07565_ VSS VSS VDD VDD _02610_ sky130_fd_sc_hd__nor2_1
X_10519_ net12 _02603_ _02610_ VSS VSS VDD VDD _07588_ sky130_fd_sc_hd__a21oi_1
X_10520_ _02600_ VSS VSS VDD VDD _02611_ sky130_fd_sc_hd__buf_6
X_10521_ _07588_ net19 VSS VSS VDD VDD _02612_ sky130_fd_sc_hd__nand2_1
X_10522_ _02448_ _02600_ _02601_ _02612_ VSS VSS VDD VDD _07611_
+ sky130_fd_sc_hd__o31ai_1
X_10523_ _07611_ _02597_ VSS VSS VDD VDD _02613_ sky130_fd_sc_hd__nor2_1
X_10524_ _02597_ _02599_ _02613_ VSS VSS VDD VDD _07640_ sky130_fd_sc_hd__a21oi_1
X_10525_ butterfly_count\[1\] VSS VSS VDD VDD _07666_ sky130_fd_sc_hd__inv_1
X_10526_ butterfly_count\[0\] VSS VSS VDD VDD _07716_ sky130_fd_sc_hd__inv_2
X_10527_ _07621_ _07620_ _07627_ VSS VSS VDD VDD _02614_ sky130_fd_sc_hd__o21a_1
X_10528_ _07626_ _02614_ _07624_ VSS VSS VDD VDD _02615_ sky130_fd_sc_hd__o21a_1
X_10529_ _07623_ _02615_ _07633_ VSS VSS VDD VDD _02616_ sky130_fd_sc_hd__o21a_1
X_10530_ _07632_ _02616_ _07630_ VSS VSS VDD VDD _02617_ sky130_fd_sc_hd__o21a_1
X_10531_ _02617_ _07629_ _07639_ VSS VSS VDD VDD _02618_ sky130_fd_sc_hd__o21a_1
X_10532_ _07638_ _02618_ VSS VSS VDD VDD _02619_ sky130_fd_sc_hd__nor2_1
X_10533_ _07636_ _02619_ VSS VSS VDD VDD _02620_ sky130_fd_sc_hd__xnor2_1
X_10534_ _02514_ _02538_ VSS VSS VDD VDD _02621_ sky130_fd_sc_hd__or2_4
X_10535_ _02588_ _02589_ _02590_ _02593_ VSS VSS VDD VDD _02622_
+ sky130_fd_sc_hd__nand4b_1
X_10536_ _02586_ _02622_ VSS VSS VDD VDD _02623_ sky130_fd_sc_hd__nand2b_2
X_10537_ _02623_ _02559_ _02621_ VSS VSS VDD VDD _02624_ sky130_fd_sc_hd__nor3_4
X_10538_ _07616_ _07618_ _02490_ VSS VSS VDD VDD _02625_ sky130_fd_sc_hd__nor3_1
X_10539_ _02624_ VSS VSS VDD VDD _02626_ sky130_fd_sc_hd__buf_6
X_10540_ _07593_ _07595_ _02446_ VSS VSS VDD VDD _02627_ sky130_fd_sc_hd__nor3_1
X_10541_ _07570_ _07572_ _02320_ VSS VSS VDD VDD _02628_ sky130_fd_sc_hd__nor3_1
X_10542_ _02321_ _02628_ VSS VSS VDD VDD _02629_ sky130_fd_sc_hd__or2_0
X_10543_ _07547_ _07549_ _00580_ VSS VSS VDD VDD _02630_ sky130_fd_sc_hd__nor3_1
X_10544_ _07530_ _07528_ _07529_ VSS VSS VDD VDD _02631_ sky130_fd_sc_hd__nor3_1
X_10545_ _07510_ _02219_ VSS VSS VDD VDD _07526_ sky130_fd_sc_hd__nor2_4
X_10546_ _02309_ _07526_ VSS VSS VDD VDD _02632_ sky130_fd_sc_hd__nand2_1
X_10547_ _02188_ _02309_ _02631_ _02632_ VSS VSS VDD VDD _07545_
+ sky130_fd_sc_hd__o31ai_4
X_10548_ _02307_ _07545_ VSS VSS VDD VDD _02633_ sky130_fd_sc_hd__nand2_1
X_10549_ _00581_ _02307_ _02630_ _02633_ VSS VSS VDD VDD _07568_
+ sky130_fd_sc_hd__o31ai_2
X_10550_ _02529_ _07568_ VSS VSS VDD VDD _02634_ sky130_fd_sc_hd__nor2_1
X_10551_ _02529_ _02629_ _02634_ VSS VSS VDD VDD _07591_ sky130_fd_sc_hd__a21oi_1
X_10552_ net19 _07591_ VSS VSS VDD VDD _02635_ sky130_fd_sc_hd__nand2_1
X_10553_ _02447_ net19 _02627_ _02635_ VSS VSS VDD VDD _07614_
+ sky130_fd_sc_hd__o31ai_1
X_10554_ net7 _07614_ VSS VSS VDD VDD _02636_ sky130_fd_sc_hd__nand2_1
X_10555_ _02491_ _02624_ _02625_ _02636_ VSS VSS VDD VDD _07634_
+ sky130_fd_sc_hd__o31ai_1
X_10556_ _02437_ _02556_ VSS VSS VDD VDD _02637_ sky130_fd_sc_hd__nand2_1
X_10557_ _02540_ _02549_ _02637_ VSS VSS VDD VDD _02638_ sky130_fd_sc_hd__o21ai_4
X_10558_ _02514_ _02588_ VSS VSS VDD VDD _02639_ sky130_fd_sc_hd__xnor2_1
X_10559_ _02638_ _02639_ VSS VSS VDD VDD _02640_ sky130_fd_sc_hd__nor2_1
X_10560_ _02528_ _02537_ VSS VSS VDD VDD _02641_ sky130_fd_sc_hd__nand2_1
X_10561_ _02540_ _02549_ _02530_ VSS VSS VDD VDD _02642_ sky130_fd_sc_hd__nor3_1
X_10562_ _02519_ _02642_ VSS VSS VDD VDD _02643_ sky130_fd_sc_hd__xnor2_1
X_10563_ _02514_ _02641_ _02643_ VSS VSS VDD VDD _02644_ sky130_fd_sc_hd__o21ai_1
X_10564_ _02478_ _02484_ _02482_ VSS VSS VDD VDD _02645_ sky130_fd_sc_hd__o21a_1
X_10565_ _02478_ _02484_ _02535_ VSS VSS VDD VDD _02646_ sky130_fd_sc_hd__o21ai_1
X_10566_ _02479_ _02645_ _02646_ VSS VSS VDD VDD _02647_ sky130_fd_sc_hd__o21ai_4
X_10567_ _02540_ _02549_ VSS VSS VDD VDD _02648_ sky130_fd_sc_hd__nor2_1
X_10568_ _02530_ _02648_ VSS VSS VDD VDD _02649_ sky130_fd_sc_hd__xor2_1
X_10569_ _02548_ _02550_ _02647_ _02649_ VSS VSS VDD VDD _02650_
+ sky130_fd_sc_hd__a211oi_1
X_10570_ _02624_ _02640_ _02644_ _02650_ VSS VSS VDD VDD _02651_
+ sky130_fd_sc_hd__o211a_1
X_10571_ _02505_ _02512_ _02485_ VSS VSS VDD VDD _02652_ sky130_fd_sc_hd__o21ai_0
X_10572_ net23 _02440_ _02443_ VSS VSS VDD VDD _02653_ sky130_fd_sc_hd__nor3_2
X_10573_ _02653_ _02485_ VSS VSS VDD VDD _02654_ sky130_fd_sc_hd__nand2_1
X_10574_ _02540_ _02495_ _02504_ VSS VSS VDD VDD _02655_ sky130_fd_sc_hd__a21o_1
X_10575_ _02655_ _02590_ _02481_ VSS VSS VDD VDD _02656_ sky130_fd_sc_hd__a21oi_1
X_10576_ _02652_ _02654_ _02478_ _02656_ VSS VSS VDD VDD _02657_
+ sky130_fd_sc_hd__a211oi_1
X_10577_ _02539_ _02596_ _02657_ VSS VSS VDD VDD _02658_ sky130_fd_sc_hd__a21oi_1
X_10578_ _07584_ _02450_ _07583_ VSS VSS VDD VDD _02659_ sky130_fd_sc_hd__a21o_1
X_10579_ _02346_ _02386_ _07556_ VSS VSS VDD VDD _02660_ sky130_fd_sc_hd__nand3_1
X_10580_ net23 _02470_ _02660_ VSS VSS VDD VDD _02661_ sky130_fd_sc_hd__o21ai_0
X_10581_ _02659_ _02661_ VSS VSS VDD VDD _02662_ sky130_fd_sc_hd__or2_1
X_10582_ _02659_ _02661_ VSS VSS VDD VDD _02663_ sky130_fd_sc_hd__nand2_1
X_10583_ _02600_ _02662_ _02663_ VSS VSS VDD VDD _02664_ sky130_fd_sc_hd__o21ai_2
X_10584_ _02438_ _02477_ VSS VSS VDD VDD _02665_ sky130_fd_sc_hd__and2_0
X_10585_ _07582_ _02540_ _02665_ VSS VSS VDD VDD _02666_ sky130_fd_sc_hd__nand3_1
X_10586_ _02525_ _02549_ _02502_ VSS VSS VDD VDD _02667_ sky130_fd_sc_hd__o21ai_0
X_10587_ _02494_ _02666_ _02667_ VSS VSS VDD VDD _02668_ sky130_fd_sc_hd__nand3_1
X_10588_ _02655_ _02664_ _02668_ VSS VSS VDD VDD _02669_ sky130_fd_sc_hd__nor3_1
X_10589_ _02540_ _02665_ _02662_ VSS VSS VDD VDD _02670_ sky130_fd_sc_hd__a21oi_1
X_10590_ _02363_ net12 _02496_ VSS VSS VDD VDD _02671_ sky130_fd_sc_hd__nand3_1
X_10591_ _02363_ _02496_ _02671_ VSS VSS VDD VDD _02672_ sky130_fd_sc_hd__o21ai_1
X_10592_ _02670_ _02672_ VSS VSS VDD VDD _02673_ sky130_fd_sc_hd__xnor2_1
X_10593_ _02505_ _02673_ VSS VSS VDD VDD _02674_ sky130_fd_sc_hd__and2_0
X_10594_ _02539_ _02595_ _02669_ _02674_ VSS VSS VDD VDD _02675_
+ sky130_fd_sc_hd__a211o_2
X_10595_ _07587_ _07589_ _02448_ VSS VSS VDD VDD _02676_ sky130_fd_sc_hd__nor3_1
X_10596_ _02449_ _02676_ _02662_ VSS VSS VDD VDD _02677_ sky130_fd_sc_hd__o21ai_0
X_10597_ _07541_ _07543_ _00582_ VSS VSS VDD VDD _02678_ sky130_fd_sc_hd__nor3_1
X_10598_ _07522_ _07524_ _02189_ VSS VSS VDD VDD _02679_ sky130_fd_sc_hd__nor3_1
X_10599_ _07464_ _02063_ VSS VSS VDD VDD _07483_ sky130_fd_sc_hd__nor2_1
X_10600_ _07487_ _07485_ _07486_ VSS VSS VDD VDD _02680_ sky130_fd_sc_hd__nor3_1
X_10601_ _01901_ _02680_ VSS VSS VDD VDD _02681_ sky130_fd_sc_hd__nor2_1
X_10602_ _07483_ _02681_ _02145_ VSS VSS VDD VDD _07503_ sky130_fd_sc_hd__mux2_4
X_10603_ _07505_ _07507_ _02034_ VSS VSS VDD VDD _02682_ sky130_fd_sc_hd__nor3_1
X_10604_ _02035_ _02682_ _02095_ VSS VSS VDD VDD _02683_ sky130_fd_sc_hd__o21ai_0
X_10605_ _02095_ _07503_ _02683_ VSS VSS VDD VDD _07520_ sky130_fd_sc_hd__o21a_1
X_10606_ net8 _07520_ VSS VSS VDD VDD _02684_ sky130_fd_sc_hd__nand2_1
X_10607_ _02190_ net8 _02679_ _02684_ VSS VSS VDD VDD _07539_
+ sky130_fd_sc_hd__o31ai_2
X_10608_ net2 _07539_ VSS VSS VDD VDD _02685_ sky130_fd_sc_hd__nand2_1
X_10609_ _00583_ net2 _02678_ _02685_ VSS VSS VDD VDD _07562_
+ sky130_fd_sc_hd__o31ai_2
X_10610_ _07564_ _07566_ _02322_ VSS VSS VDD VDD _02686_ sky130_fd_sc_hd__nor3_1
X_10611_ _02323_ _02686_ VSS VSS VDD VDD _02687_ sky130_fd_sc_hd__nor2_1
X_10612_ _07562_ _02687_ net12 VSS VSS VDD VDD _02688_ sky130_fd_sc_hd__mux2i_1
X_10613_ _02600_ _02688_ VSS VSS VDD VDD _02689_ sky130_fd_sc_hd__nand2_1
X_10614_ _02618_ _07638_ _07636_ VSS VSS VDD VDD _02690_ sky130_fd_sc_hd__o21ai_1
X_10615_ _07635_ _02690_ VSS VSS VDD VDD _02691_ sky130_fd_sc_hd__nand2b_1
X_10616_ _02691_ _07642_ _07641_ VSS VSS VDD VDD _02692_ sky130_fd_sc_hd__a21oi_4
X_10617_ _02692_ _02663_ VSS VSS VDD VDD _02693_ sky130_fd_sc_hd__nand2_1
X_10618_ _02677_ _02689_ _02693_ VSS VSS VDD VDD _02694_ sky130_fd_sc_hd__a21oi_2
X_10619_ _07610_ _02493_ VSS VSS VDD VDD _02695_ sky130_fd_sc_hd__xor2_1
X_10620_ _02695_ _02692_ VSS VSS VDD VDD _02696_ sky130_fd_sc_hd__nand2b_1
X_10621_ _02664_ _02696_ VSS VSS VDD VDD _02697_ sky130_fd_sc_hd__nor2_1
X_10622_ _02666_ _02667_ VSS VSS VDD VDD _02698_ sky130_fd_sc_hd__nand2_1
X_10623_ _02494_ _02698_ VSS VSS VDD VDD _02699_ sky130_fd_sc_hd__xnor2_1
X_10624_ _02539_ _02694_ _02595_ _02697_ _02699_ VSS VSS VDD
+ VDD _02700_ sky130_fd_sc_hd__a32o_2
X_10625_ _02512_ _02658_ _02700_ _02675_ VSS VSS VDD VDD _02701_
+ sky130_fd_sc_hd__and4bb_4
X_10626_ _02701_ _02651_ VSS VSS VDD VDD _02702_ sky130_fd_sc_hd__nand2_8
X_10627_ net3 _02515_ _02518_ VSS VSS VDD VDD _02703_ sky130_fd_sc_hd__o21ai_2
X_10628_ _02703_ _02584_ VSS VSS VDD VDD _02704_ sky130_fd_sc_hd__nor2_1
X_10629_ _02703_ _02704_ _02642_ VSS VSS VDD VDD _02705_ sky130_fd_sc_hd__mux2_1
X_10630_ _02514_ _02641_ _02559_ _02705_ VSS VSS VDD VDD _02706_
+ sky130_fd_sc_hd__nor4_2
X_10631_ _02565_ _02706_ VSS VSS VDD VDD _02707_ sky130_fd_sc_hd__nor2_1
X_10632_ _02478_ _02486_ _02505_ _02512_ VSS VSS VDD VDD _02708_
+ sky130_fd_sc_hd__nor4_4
X_10633_ _02519_ _02528_ _02537_ _02547_ VSS VSS VDD VDD _02709_
+ sky130_fd_sc_hd__and4_1
X_10634_ _02521_ _02708_ _02709_ VSS VSS VDD VDD _02710_ sky130_fd_sc_hd__nand3_1
X_10635_ _02415_ _02553_ VSS VSS VDD VDD _02711_ sky130_fd_sc_hd__nor2_1
X_10636_ _02575_ _02560_ VSS VSS VDD VDD _02712_ sky130_fd_sc_hd__nand2_1
X_10637_ _02555_ _02711_ _02712_ VSS VSS VDD VDD _02713_ sky130_fd_sc_hd__o21ai_2
X_10638_ _02710_ _02713_ VSS VSS VDD VDD _02714_ sky130_fd_sc_hd__nand2_1
X_10639_ _02624_ _02707_ _02714_ VSS VSS VDD VDD _02715_ sky130_fd_sc_hd__o21ai_2
X_10640_ _02581_ VSS VSS VDD VDD _02716_ sky130_fd_sc_hd__inv_1
X_10641_ _02530_ _02588_ _02638_ VSS VSS VDD VDD _02717_ sky130_fd_sc_hd__nor3_1
X_10642_ _02548_ _02550_ _02558_ VSS VSS VDD VDD _02718_ sky130_fd_sc_hd__a21oi_1
X_10643_ _02703_ _02565_ VSS VSS VDD VDD _02719_ sky130_fd_sc_hd__nor2_1
X_10644_ _02584_ _02575_ _02560_ VSS VSS VDD VDD _02720_ sky130_fd_sc_hd__and3_1
X_10645_ _02720_ VSS VSS VDD VDD _02721_ sky130_fd_sc_hd__clkbuf_2
X_10646_ _02708_ _02717_ _02718_ _02719_ _02721_ VSS VSS VDD
+ VDD _02722_ sky130_fd_sc_hd__a41oi_1
X_10647_ _02574_ _02722_ VSS VSS VDD VDD _02723_ sky130_fd_sc_hd__xor2_1
X_10648_ _02716_ _02723_ _02597_ VSS VSS VDD VDD _02724_ sky130_fd_sc_hd__o21a_1
X_10649_ _02708_ _02709_ VSS VSS VDD VDD _02725_ sky130_fd_sc_hd__nand2_2
X_10650_ _02415_ _02596_ _02725_ VSS VSS VDD VDD _02726_ sky130_fd_sc_hd__nor3_1
X_10651_ _02708_ _02717_ _02718_ _02719_ VSS VSS VDD VDD _02727_
+ sky130_fd_sc_hd__nand4_2
X_10652_ _02514_ _02538_ _02586_ _02594_ VSS VSS VDD VDD _02728_
+ sky130_fd_sc_hd__nor4_1
X_10653_ _02574_ _02721_ _02581_ VSS VSS VDD VDD _02729_ sky130_fd_sc_hd__o21ai_1
X_10654_ _02574_ _02581_ _02721_ _02582_ VSS VSS VDD VDD _02730_
+ sky130_fd_sc_hd__a31oi_2
X_10655_ _02727_ _02728_ _02729_ _02730_ VSS VSS VDD VDD _02731_
+ sky130_fd_sc_hd__o31ai_4
X_10656_ _02346_ _02389_ VSS VSS VDD VDD _02732_ sky130_fd_sc_hd__nor2_1
X_10657_ _02732_ _02408_ VSS VSS VDD VDD _02733_ sky130_fd_sc_hd__nor2_1
X_10658_ _02425_ _02540_ _02549_ VSS VSS VDD VDD _02734_ sky130_fd_sc_hd__nor3_2
X_10659_ _02733_ _02734_ VSS VSS VDD VDD _02735_ sky130_fd_sc_hd__xnor2_2
X_10660_ _02406_ _02732_ VSS VSS VDD VDD _02736_ sky130_fd_sc_hd__nor2_1
X_10661_ _02342_ _02736_ VSS VSS VDD VDD _02737_ sky130_fd_sc_hd__xnor2_1
X_10662_ _02708_ _02709_ _02735_ _02737_ VSS VSS VDD VDD _02738_
+ sky130_fd_sc_hd__a211o_1
X_10663_ _02342_ _02736_ VSS VSS VDD VDD _02739_ sky130_fd_sc_hd__xor2_1
X_10664_ _02733_ _02708_ _02739_ _02709_ VSS VSS VDD VDD _02740_
+ sky130_fd_sc_hd__nand4b_2
X_10665_ _02596_ _02738_ _02740_ VSS VSS VDD VDD _02741_ sky130_fd_sc_hd__nand3b_4
X_10666_ _02732_ _02407_ _02408_ VSS VSS VDD VDD _02742_ sky130_fd_sc_hd__or3_1
X_10667_ _02427_ _02430_ _02552_ VSS VSS VDD VDD _02743_ sky130_fd_sc_hd__o21ai_0
X_10668_ _02415_ _02556_ _02743_ _02557_ VSS VSS VDD VDD _02744_
+ sky130_fd_sc_hd__o31ai_2
X_10669_ _02551_ _02742_ _02725_ _02744_ VSS VSS VDD VDD _02745_
+ sky130_fd_sc_hd__a22oi_2
X_10670_ _02726_ _02731_ _02741_ _02745_ VSS VSS VDD VDD _02746_
+ sky130_fd_sc_hd__nand4b_1
X_10671_ _02715_ _02724_ _02746_ VSS VSS VDD VDD _02747_ sky130_fd_sc_hd__or3_1
X_10672_ _02747_ VSS VSS VDD VDD _02748_ sky130_fd_sc_hd__buf_4
X_10673_ _02748_ _02702_ VSS VSS VDD VDD _02749_ sky130_fd_sc_hd__nor2_8
X_10674_ _02620_ _07634_ _02749_ VSS VSS VDD VDD _07660_ sky130_fd_sc_hd__mux2_1
X_10675_ _02702_ _02748_ net396 VSS VSS VDD VDD _02750_ sky130_fd_sc_hd__o21ai_2
X_10676_ _02503_ _02698_ _02696_ VSS VSS VDD VDD _02751_ sky130_fd_sc_hd__maj3_1
X_10677_ _02664_ _02751_ VSS VSS VDD VDD _02752_ sky130_fd_sc_hd__nand2_1
X_10678_ _02664_ _02668_ _02752_ VSS VSS VDD VDD _02753_ sky130_fd_sc_hd__o21ai_1
X_10679_ _02655_ _02590_ VSS VSS VDD VDD _02754_ sky130_fd_sc_hd__nand2_1
X_10680_ _02655_ _02597_ _02673_ _02700_ _02590_ VSS VSS VDD
+ VDD _02755_ sky130_fd_sc_hd__a221o_1
X_10681_ _02754_ net1 _02755_ VSS VSS VDD VDD _02756_ sky130_fd_sc_hd__o21ai_2
X_10682_ _02597_ _02753_ _02756_ VSS VSS VDD VDD _02757_ sky130_fd_sc_hd__a21oi_1
X_10683_ _02485_ _02675_ _02750_ _02757_ VSS VSS VDD VDD _02758_
+ sky130_fd_sc_hd__nand4_1
X_10684_ _02540_ _02480_ _02438_ VSS VSS VDD VDD _02759_ sky130_fd_sc_hd__nand3_1
X_10685_ _02590_ _02675_ VSS VSS VDD VDD _02760_ sky130_fd_sc_hd__and2_0
X_10686_ _02754_ net1 VSS VSS VDD VDD _02761_ sky130_fd_sc_hd__nor2_1
X_10687_ _02476_ _02759_ _02700_ _02760_ _02761_ VSS VSS VDD
+ VDD _02762_ sky130_fd_sc_hd__a221o_1
X_10688_ _02759_ _02762_ VSS VSS VDD VDD _02763_ sky130_fd_sc_hd__nand2_1
X_10689_ _02653_ _02763_ VSS VSS VDD VDD _02764_ sky130_fd_sc_hd__xnor2_1
X_10690_ _02449_ _02676_ VSS VSS VDD VDD _02765_ sky130_fd_sc_hd__nor2_1
X_10691_ net19 _02765_ _02689_ VSS VSS VDD VDD _07608_ sky130_fd_sc_hd__o21a_1
X_10692_ _02695_ _07608_ _02624_ VSS VSS VDD VDD _02766_ sky130_fd_sc_hd__mux2i_4
X_10693_ _02692_ _02766_ VSS VSS VDD VDD _02767_ sky130_fd_sc_hd__xnor2_1
X_10694_ _07642_ _02691_ VSS VSS VDD VDD _02768_ sky130_fd_sc_hd__xnor2_1
X_10695_ _02768_ VSS VSS VDD VDD _02769_ sky130_fd_sc_hd__inv_1
X_10696_ _07640_ _02702_ _02748_ _02767_ _02769_ VSS VSS VDD
+ VDD _02770_ sky130_fd_sc_hd__o32a_1
X_10697_ net1 _02668_ VSS VSS VDD VDD _02771_ sky130_fd_sc_hd__nor2_1
X_10698_ _02503_ _02698_ _02771_ VSS VSS VDD VDD _02772_ sky130_fd_sc_hd__a21oi_2
X_10699_ _07647_ _07646_ _07645_ VSS VSS VDD VDD _02773_ sky130_fd_sc_hd__o21a_1
X_10700_ _07644_ _02773_ _07659_ VSS VSS VDD VDD _02774_ sky130_fd_sc_hd__o21a_1
X_10701_ _07658_ _02774_ _07656_ VSS VSS VDD VDD _02775_ sky130_fd_sc_hd__o21a_1
X_10702_ _07655_ _02775_ _07653_ VSS VSS VDD VDD _02776_ sky130_fd_sc_hd__o21a_1
X_10703_ _02776_ _07652_ _07650_ VSS VSS VDD VDD _02777_ sky130_fd_sc_hd__o21a_1
X_10704_ _07649_ _02777_ VSS VSS VDD VDD _02778_ sky130_fd_sc_hd__nor2_2
X_10705_ _02778_ _07665_ VSS VSS VDD VDD _02779_ sky130_fd_sc_hd__nor2b_1
X_10706_ _02779_ _07664_ VSS VSS VDD VDD _02780_ sky130_fd_sc_hd__nor2_2
X_10707_ _02780_ VSS VSS VDD VDD _02781_ sky130_fd_sc_hd__clkinv_2
X_10708_ _02781_ _07662_ _07661_ VSS VSS VDD VDD _02782_ sky130_fd_sc_hd__a21oi_4
X_10709_ _02772_ _02782_ VSS VSS VDD VDD _02783_ sky130_fd_sc_hd__nand2_2
X_10710_ _02783_ _02770_ VSS VSS VDD VDD _02784_ sky130_fd_sc_hd__nor2_4
X_10711_ _02758_ _02764_ _02784_ VSS VSS VDD VDD _02785_ sky130_fd_sc_hd__nor3b_4
X_10712_ _02514_ _02588_ net1 VSS VSS VDD VDD _02786_ sky130_fd_sc_hd__nor3_1
X_10713_ _02514_ _02588_ _02786_ VSS VSS VDD VDD _02787_ sky130_fd_sc_hd__a21oi_1
X_10714_ _02787_ VSS VSS VDD VDD _02788_ sky130_fd_sc_hd__inv_1
X_10715_ _02482_ _02484_ VSS VSS VDD VDD _02789_ sky130_fd_sc_hd__xnor2_2
X_10716_ _02539_ _02596_ _02653_ _02789_ _02754_ VSS VSS VDD
+ VDD _02790_ sky130_fd_sc_hd__a2111oi_4
X_10717_ _02647_ _02790_ VSS VSS VDD VDD _02791_ sky130_fd_sc_hd__xnor2_4
X_10718_ _02702_ _02748_ net390 VSS VSS VDD VDD _02792_ sky130_fd_sc_hd__o21ai_2
X_10719_ _02791_ _02792_ VSS VSS VDD VDD _02793_ sky130_fd_sc_hd__xor2_4
X_10720_ _02621_ _02596_ _02644_ VSS VSS VDD VDD _02794_ sky130_fd_sc_hd__o21ai_1
X_10721_ _02651_ _02701_ VSS VSS VDD VDD _02795_ sky130_fd_sc_hd__and2_0
X_10722_ _02795_ VSS VSS VDD VDD _02796_ sky130_fd_sc_hd__clkbuf_4
X_10723_ _02715_ _02724_ _02746_ VSS VSS VDD VDD _02797_ sky130_fd_sc_hd__nor3_1
X_10724_ _02530_ _02648_ VSS VSS VDD VDD _02798_ sky130_fd_sc_hd__xnor2_2
X_10725_ _02638_ _02639_ _02597_ VSS VSS VDD VDD _02799_ sky130_fd_sc_hd__o21ai_1
X_10726_ _02798_ _02799_ _02701_ _02791_ VSS VSS VDD VDD _02800_
+ sky130_fd_sc_hd__nand4_1
X_10727_ _02796_ _02797_ _02800_ VSS VSS VDD VDD _02801_ sky130_fd_sc_hd__a21oi_1
X_10728_ _02794_ _02801_ VSS VSS VDD VDD _02802_ sky130_fd_sc_hd__xor2_1
X_10729_ _02708_ _02597_ VSS VSS VDD VDD _02803_ sky130_fd_sc_hd__nand2_1
X_10730_ _02588_ _02638_ _02803_ VSS VSS VDD VDD _02804_ sky130_fd_sc_hd__nor3_1
X_10731_ _02649_ _02804_ VSS VSS VDD VDD _02805_ sky130_fd_sc_hd__xnor2_1
X_10732_ _02638_ _02805_ VSS VSS VDD VDD _02806_ sky130_fd_sc_hd__nand2b_1
X_10733_ _02788_ _02793_ _02802_ _02806_ VSS VSS VDD VDD _02807_
+ sky130_fd_sc_hd__nor4_1
X_10734_ _02596_ _02725_ VSS VSS VDD VDD _02808_ sky130_fd_sc_hd__nor2_1
X_10735_ _02735_ _02808_ VSS VSS VDD VDD _02809_ sky130_fd_sc_hd__xnor2_1
X_10736_ _02796_ _02809_ _02747_ VSS VSS VDD VDD _02810_ sky130_fd_sc_hd__and3_1
X_10737_ _02796_ _02809_ _02810_ VSS VSS VDD VDD _02811_ sky130_fd_sc_hd__o21bai_2
X_10738_ _02794_ _02791_ _02798_ _02799_ VSS VSS VDD VDD _02812_
+ sky130_fd_sc_hd__and4b_1
X_10739_ _02702_ _02748_ _02812_ net390 VSS VSS VDD VDD _02813_
+ sky130_fd_sc_hd__o211ai_1
X_10740_ _02621_ _02548_ _02550_ _02808_ VSS VSS VDD VDD _02814_
+ sky130_fd_sc_hd__a31o_1
X_10741_ _02813_ _02814_ VSS VSS VDD VDD _02815_ sky130_fd_sc_hd__xor2_1
X_10742_ _02811_ _02815_ VSS VSS VDD VDD _02816_ sky130_fd_sc_hd__nor2b_1
X_10743_ _02733_ _02734_ VSS VSS VDD VDD _02817_ sky130_fd_sc_hd__nand2_1
X_10744_ _02739_ _02817_ VSS VSS VDD VDD _02818_ sky130_fd_sc_hd__xnor2_1
X_10745_ _02742_ net1 _02725_ _02818_ VSS VSS VDD VDD _02819_
+ sky130_fd_sc_hd__o31ai_1
X_10746_ _02596_ _02725_ VSS VSS VDD VDD _02820_ sky130_fd_sc_hd__or2_0
X_10747_ _02409_ _02596_ _02725_ VSS VSS VDD VDD _02821_ sky130_fd_sc_hd__nor3_1
X_10748_ _02796_ _02820_ _02748_ _02819_ _02821_ VSS VSS VDD
+ VDD _02822_ sky130_fd_sc_hd__a41oi_1
X_10749_ _02810_ _02819_ _02822_ _02735_ VSS VSS VDD VDD _02823_
+ sky130_fd_sc_hd__o22a_2
X_10750_ _02738_ _02740_ VSS VSS VDD VDD _02824_ sky130_fd_sc_hd__nand2_1
X_10751_ _02596_ _02824_ VSS VSS VDD VDD _02825_ sky130_fd_sc_hd__nor2_1
X_10752_ _02551_ _02742_ _02725_ _02744_ VSS VSS VDD VDD _02826_
+ sky130_fd_sc_hd__a22o_1
X_10753_ _02826_ _02726_ VSS VSS VDD VDD _02827_ sky130_fd_sc_hd__nor2_1
X_10754_ _02710_ _02713_ _02706_ _02623_ VSS VSS VDD VDD _02828_
+ sky130_fd_sc_hd__a22oi_4
X_10755_ _02702_ _02825_ _02827_ _02828_ VSS VSS VDD VDD _02829_
+ sky130_fd_sc_hd__o211ai_1
X_10756_ _02415_ _02820_ _02745_ VSS VSS VDD VDD _02830_ sky130_fd_sc_hd__o21ai_2
X_10757_ _02731_ VSS VSS VDD VDD _02831_ sky130_fd_sc_hd__inv_1
X_10758_ _02826_ _02726_ _02828_ VSS VSS VDD VDD _02832_ sky130_fd_sc_hd__o21ai_0
X_10759_ _02830_ _02715_ _02724_ _02831_ _02832_ VSS VSS VDD
+ VDD _02833_ sky130_fd_sc_hd__o41ai_1
X_10760_ _02796_ _02741_ _02833_ VSS VSS VDD VDD _02834_ sky130_fd_sc_hd__nand3_1
X_10761_ _02708_ _02717_ _02719_ VSS VSS VDD VDD _02835_ sky130_fd_sc_hd__and3_1
X_10762_ _02575_ _02560_ _02584_ VSS VSS VDD VDD _02836_ sky130_fd_sc_hd__a21oi_1
X_10763_ _02836_ _02721_ VSS VSS VDD VDD _02837_ sky130_fd_sc_hd__nor2_1
X_10764_ _02706_ _02837_ VSS VSS VDD VDD _02838_ sky130_fd_sc_hd__nor2_1
X_10765_ _02623_ _02706_ _02835_ _02838_ VSS VSS VDD VDD _02839_
+ sky130_fd_sc_hd__a31oi_2
X_10766_ _02839_ VSS VSS VDD VDD _02840_ sky130_fd_sc_hd__inv_1
X_10767_ _02825_ _02830_ _02715_ VSS VSS VDD VDD _02841_ sky130_fd_sc_hd__nor3_2
X_10768_ _02597_ _02723_ VSS VSS VDD VDD _02842_ sky130_fd_sc_hd__nand2_1
X_10769_ _02796_ _02748_ _02841_ _02842_ VSS VSS VDD VDD _02843_
+ sky130_fd_sc_hd__a31oi_2
X_10770_ _02796_ _02842_ _02748_ _02841_ VSS VSS VDD VDD _02844_
+ sky130_fd_sc_hd__and4_1
X_10771_ _02829_ _02834_ _02840_ _02843_ _02844_ VSS VSS VDD
+ VDD _02845_ sky130_fd_sc_hd__a2111oi_1
X_10772_ _02724_ VSS VSS VDD VDD _02846_ sky130_fd_sc_hd__inv_1
X_10773_ _02795_ _02747_ _02841_ VSS VSS VDD VDD _02847_ sky130_fd_sc_hd__and3_1
X_10774_ _02727_ VSS VSS VDD VDD _02848_ sky130_fd_sc_hd__inv_1
X_10775_ _02581_ _02721_ _02848_ VSS VSS VDD VDD _02849_ sky130_fd_sc_hd__nor3_1
X_10776_ _02849_ VSS VSS VDD VDD _02850_ sky130_fd_sc_hd__inv_1
X_10777_ _02795_ _02747_ _02841_ _02850_ VSS VSS VDD VDD _02851_
+ sky130_fd_sc_hd__a31oi_2
X_10778_ _02478_ _02486_ _02622_ _02582_ VSS VSS VDD VDD _02852_
+ sky130_fd_sc_hd__o31ai_1
X_10779_ _02848_ _02852_ _02721_ VSS VSS VDD VDD _02853_ sky130_fd_sc_hd__a21o_1
X_10780_ _02574_ _02581_ _02853_ VSS VSS VDD VDD _02854_ sky130_fd_sc_hd__nand3_1
X_10781_ _02574_ _02581_ _02854_ VSS VSS VDD VDD _02855_ sky130_fd_sc_hd__o21ai_2
X_10782_ _02715_ _02724_ VSS VSS VDD VDD _02856_ sky130_fd_sc_hd__nor2_1
X_10783_ _02796_ _02741_ _02827_ _02856_ _02731_ VSS VSS VDD
+ VDD _02857_ sky130_fd_sc_hd__a41oi_4
X_10784_ _02846_ _02847_ _02851_ _02855_ _02857_ VSS VSS VDD
+ VDD _02858_ sky130_fd_sc_hd__a2111oi_4
X_10785_ _02823_ _02845_ _02858_ VSS VSS VDD VDD _02859_ sky130_fd_sc_hd__and3b_1
X_10786_ _02785_ _02807_ _02816_ _02859_ VSS VSS VDD VDD _02860_
+ sky130_fd_sc_hd__and4_1
X_10787_ _02860_ VSS VSS VDD VDD _02861_ sky130_fd_sc_hd__buf_6
X_10788_ _02861_ VSS VSS VDD VDD _02862_ sky130_fd_sc_hd__inv_8
X_10789_ _02862_ VSS VSS VDD VDD _02863_ sky130_fd_sc_hd__buf_8
X_10790_ _02863_ VSS VSS VDD VDD _00553_ sky130_fd_sc_hd__buf_8
X_10791_ _07650_ _07652_ _02776_ VSS VSS VDD VDD _02864_ sky130_fd_sc_hd__nor3_1
X_10792_ _02777_ _02864_ VSS VSS VDD VDD _02865_ sky130_fd_sc_hd__or2_0
X_10793_ _02749_ VSS VSS VDD VDD _02866_ sky130_fd_sc_hd__buf_6
X_10794_ _07630_ _07632_ _02616_ VSS VSS VDD VDD _02867_ sky130_fd_sc_hd__nor3_1
X_10795_ _07599_ _07601_ _02488_ VSS VSS VDD VDD _02868_ sky130_fd_sc_hd__nor3_1
X_10796_ _07578_ _07580_ _02444_ VSS VSS VDD VDD _02869_ sky130_fd_sc_hd__nor3_1
X_10797_ _07553_ _07555_ _07554_ VSS VSS VDD VDD _02870_ sky130_fd_sc_hd__nor3_1
X_10798_ _02520_ _02319_ _02870_ VSS VSS VDD VDD _02871_ sky130_fd_sc_hd__or3_4
X_10799_ _07532_ net2 _02529_ _02871_ VSS VSS VDD VDD _07576_
+ sky130_fd_sc_hd__o31ai_4
X_10800_ _02611_ _07576_ VSS VSS VDD VDD _02872_ sky130_fd_sc_hd__nand2_1
X_10801_ _02445_ _02611_ _02869_ _02872_ VSS VSS VDD VDD _07597_
+ sky130_fd_sc_hd__o31ai_1
X_10802_ net7 _07597_ VSS VSS VDD VDD _02873_ sky130_fd_sc_hd__nand2_1
X_10803_ _02489_ net7 _02868_ _02873_ VSS VSS VDD VDD _07628_
+ sky130_fd_sc_hd__o31ai_1
X_10804_ net18 _07628_ VSS VSS VDD VDD _02874_ sky130_fd_sc_hd__nand2_1
X_10805_ _02617_ net18 _02867_ _02874_ VSS VSS VDD VDD _07648_
+ sky130_fd_sc_hd__o31ai_1
X_10806_ _07648_ net434 VSS VSS VDD VDD _02875_ sky130_fd_sc_hd__nor2_1
X_10807_ net434 _02865_ _02875_ VSS VSS VDD VDD _07678_ sky130_fd_sc_hd__a21oi_1
X_10808_ _02597_ _02753_ VSS VSS VDD VDD _02876_ sky130_fd_sc_hd__nand2_1
X_10809_ _02750_ VSS VSS VDD VDD _02877_ sky130_fd_sc_hd__inv_1
X_10810_ net393 _02876_ net38 _02877_ VSS VSS VDD VDD _02878_
+ sky130_fd_sc_hd__a31oi_2
X_10811_ _02675_ _02878_ VSS VSS VDD VDD _02879_ sky130_fd_sc_hd__xnor2_2
X_10812_ _02758_ _02764_ net407 VSS VSS VDD VDD _02880_ sky130_fd_sc_hd__or3b_1
X_10813_ _02880_ VSS VSS VDD VDD _02881_ sky130_fd_sc_hd__buf_4
X_10814_ _02788_ _02793_ VSS VSS VDD VDD _02882_ sky130_fd_sc_hd__or2_0
X_10815_ _02881_ _02882_ VSS VSS VDD VDD _02883_ sky130_fd_sc_hd__nor2_1
X_10816_ _02792_ _02791_ VSS VSS VDD VDD _02884_ sky130_fd_sc_hd__nand2b_1
X_10817_ _02884_ _02803_ _02588_ VSS VSS VDD VDD _02885_ sky130_fd_sc_hd__a21oi_1
X_10818_ _02638_ _02885_ VSS VSS VDD VDD _02886_ sky130_fd_sc_hd__xor2_1
X_10819_ net425 _02883_ _02886_ VSS VSS VDD VDD _02887_ sky130_fd_sc_hd__a21o_1
X_10820_ _02863_ _02886_ _02883_ VSS VSS VDD VDD _02888_ sky130_fd_sc_hd__nand3_1
X_10821_ _02480_ _02485_ _02763_ VSS VSS VDD VDD _02889_ sky130_fd_sc_hd__nand3_1
X_10822_ _02480_ _02789_ VSS VSS VDD VDD _02890_ sky130_fd_sc_hd__nor2_1
X_10823_ _02675_ _02750_ VSS VSS VDD VDD _02891_ sky130_fd_sc_hd__and2_0
X_10824_ net392 _02757_ _02891_ VSS VSS VDD VDD _02892_ sky130_fd_sc_hd__and3_1
X_10825_ _02890_ _02763_ _02892_ VSS VSS VDD VDD _02893_ sky130_fd_sc_hd__nand3_1
X_10826_ _02892_ _02889_ VSS VSS VDD VDD _02894_ sky130_fd_sc_hd__or2_0
X_10827_ _02759_ _02890_ _02762_ VSS VSS VDD VDD _02895_ sky130_fd_sc_hd__nand3_1
X_10828_ _02889_ net424 _02893_ _02894_ _02895_ VSS VSS VDD
+ VDD _02896_ sky130_fd_sc_hd__o2111a_1
X_10829_ _02788_ _02884_ VSS VSS VDD VDD _02897_ sky130_fd_sc_hd__xnor2_1
X_10830_ _02887_ _02888_ _02896_ _02897_ VSS VSS VDD VDD _02898_
+ sky130_fd_sc_hd__a211oi_2
X_10831_ _02879_ _02898_ VSS VSS VDD VDD _02899_ sky130_fd_sc_hd__nand2_1
X_10832_ _02137_ VSS VSS VDD VDD _02900_ sky130_fd_sc_hd__clkbuf_4
X_10833_ _02816_ _02859_ VSS VSS VDD VDD _02901_ sky130_fd_sc_hd__and2_0
X_10834_ _02901_ VSS VSS VDD VDD _02902_ sky130_fd_sc_hd__clkbuf_4
X_10835_ _02788_ _02793_ _02802_ _02806_ VSS VSS VDD VDD _02903_
+ sky130_fd_sc_hd__or4_4
X_10836_ _07639_ _07629_ _02617_ VSS VSS VDD VDD _02904_ sky130_fd_sc_hd__nor3_1
X_10837_ _07619_ _07598_ _02489_ VSS VSS VDD VDD _02905_ sky130_fd_sc_hd__nor3_1
X_10838_ _07596_ _07577_ _02445_ VSS VSS VDD VDD _02906_ sky130_fd_sc_hd__nor3_1
X_10839_ _07530_ _02309_ VSS VSS VDD VDD _07548_ sky130_fd_sc_hd__nor2_8
X_10840_ _07532_ _07550_ _07531_ VSS VSS VDD VDD _02907_ sky130_fd_sc_hd__nor3_1
X_10841_ _00580_ _02907_ VSS VSS VDD VDD _02908_ sky130_fd_sc_hd__nor2_1
X_10842_ _07548_ _02908_ _02402_ VSS VSS VDD VDD _07571_ sky130_fd_sc_hd__mux2_1
X_10843_ _07573_ _07552_ _02319_ VSS VSS VDD VDD _02909_ sky130_fd_sc_hd__nor3_1
X_10844_ _02320_ _02909_ _02529_ VSS VSS VDD VDD _02910_ sky130_fd_sc_hd__o21ai_0
X_10845_ _02529_ _07571_ _02910_ VSS VSS VDD VDD _07594_ sky130_fd_sc_hd__o21a_1
X_10846_ _02611_ _07594_ VSS VSS VDD VDD _02911_ sky130_fd_sc_hd__nand2_1
X_10847_ _02446_ net19 _02906_ _02911_ VSS VSS VDD VDD _07617_
+ sky130_fd_sc_hd__o31ai_1
X_10848_ net7 _07617_ VSS VSS VDD VDD _02912_ sky130_fd_sc_hd__nand2_1
X_10849_ _02490_ net7 _02905_ _02912_ VSS VSS VDD VDD _07637_
+ sky130_fd_sc_hd__o31ai_1
X_10850_ _02749_ _07637_ VSS VSS VDD VDD _02913_ sky130_fd_sc_hd__nand2_1
X_10851_ _02618_ _02749_ _02904_ _02913_ VSS VSS VDD VDD _07663_
+ sky130_fd_sc_hd__o31ai_2
X_10852_ _02880_ _02903_ _07663_ VSS VSS VDD VDD _02914_ sky130_fd_sc_hd__nor3_2
X_10853_ _07665_ net400 VSS VSS VDD VDD _02915_ sky130_fd_sc_hd__xor2_2
X_10854_ _02902_ _02914_ _02915_ net426 VSS VSS VDD VDD _02916_
+ sky130_fd_sc_hd__a22oi_4
X_10855_ _02900_ _02916_ VSS VSS VDD VDD _02917_ sky130_fd_sc_hd__xnor2_1
X_10856_ _02702_ _02748_ _02766_ net411 VSS VSS VDD VDD _02918_
+ sky130_fd_sc_hd__o211ai_4
X_10857_ _02772_ _02918_ VSS VSS VDD VDD _02919_ sky130_fd_sc_hd__and2_0
X_10858_ _02919_ VSS VSS VDD VDD _02920_ sky130_fd_sc_hd__inv_1
X_10859_ _02770_ _02782_ VSS VSS VDD VDD _02921_ sky130_fd_sc_hd__nand2b_1
X_10860_ _02772_ _02921_ VSS VSS VDD VDD _02922_ sky130_fd_sc_hd__nor2_1
X_10861_ _02881_ _02903_ _02922_ VSS VSS VDD VDD _02923_ sky130_fd_sc_hd__o21ai_0
X_10862_ _02772_ _02918_ VSS VSS VDD VDD _02924_ sky130_fd_sc_hd__nor2_1
X_10863_ _02921_ _02919_ _02924_ VSS VSS VDD VDD _02925_ sky130_fd_sc_hd__a21oi_1
X_10864_ _02816_ _02859_ _02772_ _02921_ VSS VSS VDD VDD _02926_
+ sky130_fd_sc_hd__a211o_1
X_10865_ net423 _02920_ _02923_ _02925_ _02926_ VSS VSS VDD
+ VDD _02927_ sky130_fd_sc_hd__o2111a_1
X_10866_ _02881_ _02793_ _02861_ VSS VSS VDD VDD _02928_ sky130_fd_sc_hd__nor3_1
X_10867_ _02750_ _02757_ VSS VSS VDD VDD _02929_ sky130_fd_sc_hd__nand2_1
X_10868_ _02881_ _02793_ _02927_ _02928_ _02929_ VSS VSS VDD
+ VDD _02930_ sky130_fd_sc_hd__a2111oi_2
X_10869_ _02823_ _02845_ _02858_ VSS VSS VDD VDD _02931_ sky130_fd_sc_hd__nand3b_1
X_10870_ _02881_ _02903_ VSS VSS VDD VDD _02932_ sky130_fd_sc_hd__nor2_2
X_10871_ _02811_ _02931_ _02932_ VSS VSS VDD VDD _02933_ sky130_fd_sc_hd__o21ai_0
X_10872_ _02881_ _02882_ _02806_ _02802_ VSS VSS VDD VDD _02934_
+ sky130_fd_sc_hd__o31ai_1
X_10873_ _02792_ VSS VSS VDD VDD _02935_ sky130_fd_sc_hd__inv_1
X_10874_ _02799_ _02791_ _02935_ _02804_ VSS VSS VDD VDD _02936_
+ sky130_fd_sc_hd__a31oi_2
X_10875_ _02798_ _02936_ VSS VSS VDD VDD _02937_ sky130_fd_sc_hd__xnor2_2
X_10876_ _02816_ _02933_ _02934_ _02937_ VSS VSS VDD VDD _02938_
+ sky130_fd_sc_hd__and4_1
X_10877_ _07660_ VSS VSS VDD VDD _02939_ sky130_fd_sc_hd__inv_1
X_10878_ _07662_ net389 VSS VSS VDD VDD _02940_ sky130_fd_sc_hd__xor2_2
X_10879_ _02749_ _02768_ VSS VSS VDD VDD _02941_ sky130_fd_sc_hd__nor2_1
X_10880_ _07640_ net18 _02941_ VSS VSS VDD VDD _02942_ sky130_fd_sc_hd__a21oi_1
X_10881_ _02782_ _02942_ VSS VSS VDD VDD _02943_ sky130_fd_sc_hd__xor2_1
X_10882_ _02939_ _02932_ _02902_ _02940_ _02943_ VSS VSS VDD
+ VDD _02944_ sky130_fd_sc_hd__a32oi_4
X_10883_ net388 _02766_ _02918_ VSS VSS VDD VDD _02945_ sky130_fd_sc_hd__o21ai_4
X_10884_ net397 net431 _07680_ _07689_ VSS VSS VDD VDD _02946_
+ sky130_fd_sc_hd__nand4_1
X_10885_ _07669_ _07716_ _07683_ _07686_ VSS VSS VDD VDD _02947_
+ sky130_fd_sc_hd__nand4_1
X_10886_ _02944_ _02945_ _02946_ _02947_ VSS VSS VDD VDD _02948_
+ sky130_fd_sc_hd__nor4_1
X_10887_ _02917_ _02930_ _02938_ _02948_ VSS VSS VDD VDD _02949_
+ sky130_fd_sc_hd__nand4_1
X_10888_ _02899_ _02949_ _02858_ VSS VSS VDD VDD _02950_ sky130_fd_sc_hd__o21ai_2
X_10889_ _02843_ _02844_ VSS VSS VDD VDD _02951_ sky130_fd_sc_hd__nor2_2
X_10890_ _02829_ _02834_ VSS VSS VDD VDD _02952_ sky130_fd_sc_hd__nand2_1
X_10891_ _02952_ _02839_ VSS VSS VDD VDD _02953_ sky130_fd_sc_hd__nand2_1
X_10892_ _02811_ _02931_ _02816_ net402 _02807_ VSS VSS VDD
+ VDD _02954_ sky130_fd_sc_hd__o2111a_1
X_10893_ _02823_ _02954_ VSS VSS VDD VDD _02955_ sky130_fd_sc_hd__xor2_1
X_10894_ _02953_ _02955_ VSS VSS VDD VDD _02956_ sky130_fd_sc_hd__nor2_2
X_10895_ _07669_ _07670_ _07677_ VSS VSS VDD VDD _02957_ sky130_fd_sc_hd__o21a_1
X_10896_ _02957_ _07676_ _07674_ VSS VSS VDD VDD _02958_ sky130_fd_sc_hd__o21a_1
X_10897_ _02958_ _07673_ _07689_ VSS VSS VDD VDD _02959_ sky130_fd_sc_hd__o21ai_1
X_10898_ _07688_ _02959_ VSS VSS VDD VDD _02960_ sky130_fd_sc_hd__nand2b_1
X_10899_ _02960_ _07686_ _07685_ VSS VSS VDD VDD _02961_ sky130_fd_sc_hd__a21o_1
X_10900_ _02961_ _07683_ _07682_ VSS VSS VDD VDD _02962_ sky130_fd_sc_hd__a21o_1
X_10901_ _02962_ _07680_ _07679_ VSS VSS VDD VDD _02963_ sky130_fd_sc_hd__a21oi_4
X_10902_ _07207_ _02916_ VSS VSS VDD VDD _02964_ sky130_fd_sc_hd__xnor2_1
X_10903_ _02902_ _02914_ _02915_ net38 _02049_ VSS VSS VDD
+ VDD _02965_ sky130_fd_sc_hd__a221oi_2
X_10904_ _02944_ _02945_ _02965_ VSS VSS VDD VDD _02966_ sky130_fd_sc_hd__nor3_1
X_10905_ _02919_ _02924_ _02964_ _02963_ _02966_ VSS VSS VDD
+ VDD _02967_ sky130_fd_sc_hd__o221a_4
X_10906_ _02887_ _02888_ _02897_ VSS VSS VDD VDD _02968_ sky130_fd_sc_hd__a21o_1
X_10907_ _02770_ _02783_ _02876_ net403 VSS VSS VDD VDD _02969_
+ sky130_fd_sc_hd__nor4_1
X_10908_ _02784_ net38 _02876_ VSS VSS VDD VDD _02970_ sky130_fd_sc_hd__a21boi_0
X_10909_ _02789_ _02764_ _02756_ _02891_ VSS VSS VDD VDD _02971_
+ sky130_fd_sc_hd__nor4b_1
X_10910_ _02969_ _02970_ _02971_ VSS VSS VDD VDD _02972_ sky130_fd_sc_hd__o21ai_1
X_10911_ _02881_ _02793_ _02928_ VSS VSS VDD VDD _02973_ sky130_fd_sc_hd__a21oi_2
X_10912_ _02932_ _02931_ VSS VSS VDD VDD _02974_ sky130_fd_sc_hd__nand2_1
X_10913_ _02816_ _02934_ _02937_ _02974_ VSS VSS VDD VDD _02975_
+ sky130_fd_sc_hd__and4_1
X_10914_ _02968_ _02972_ _02973_ _02975_ VSS VSS VDD VDD _02976_
+ sky130_fd_sc_hd__and4bb_1
X_10915_ _02951_ _02956_ _02967_ _02976_ VSS VSS VDD VDD _02977_
+ sky130_fd_sc_hd__nand4_4
X_10916_ _02950_ _02977_ VSS VSS VDD VDD _02978_ sky130_fd_sc_hd__or2_4
X_10917_ _02978_ VSS VSS VDD VDD _00552_ sky130_fd_sc_hd__buf_6
X_10918_ _07680_ net408 VSS VSS VDD VDD _02979_ sky130_fd_sc_hd__xnor2_1
X_10919_ _00552_ _02979_ VSS VSS VDD VDD _02980_ sky130_fd_sc_hd__nand2_1
X_10920_ _07678_ net35 _02980_ VSS VSS VDD VDD _07691_ sky130_fd_sc_hd__o21ai_0
X_10921_ _07653_ _07655_ _02775_ VSS VSS VDD VDD _02981_ sky130_fd_sc_hd__nor3_1
X_10922_ _02776_ _02981_ VSS VSS VDD VDD _02982_ sky130_fd_sc_hd__or2_0
X_10923_ _07633_ _07623_ _02615_ VSS VSS VDD VDD _02983_ sky130_fd_sc_hd__nor3_1
X_10924_ _07602_ _07604_ _02487_ VSS VSS VDD VDD _02984_ sky130_fd_sc_hd__nor3_1
X_10925_ _07575_ _07581_ _07574_ VSS VSS VDD VDD _02985_ sky130_fd_sc_hd__nor3_1
X_10926_ _02444_ _02985_ VSS VSS VDD VDD _02986_ sky130_fd_sc_hd__nor2_1
X_10927_ _07555_ _02520_ VSS VSS VDD VDD _07579_ sky130_fd_sc_hd__nor2_4
X_10928_ _02986_ _07579_ _02611_ VSS VSS VDD VDD _07600_ sky130_fd_sc_hd__mux2_4
X_10929_ _02626_ _07600_ VSS VSS VDD VDD _02987_ sky130_fd_sc_hd__nand2_1
X_10930_ _02488_ _02626_ _02984_ _02987_ VSS VSS VDD VDD _07631_
+ sky130_fd_sc_hd__o31ai_1
X_10931_ net18 _07631_ VSS VSS VDD VDD _02988_ sky130_fd_sc_hd__nand2_1
X_10932_ _02616_ net18 _02983_ _02988_ VSS VSS VDD VDD _07651_
+ sky130_fd_sc_hd__o31ai_1
X_10933_ net434 _07651_ VSS VSS VDD VDD _02989_ sky130_fd_sc_hd__nor2_1
X_10934_ net434 _02982_ _02989_ VSS VSS VDD VDD _07681_ sky130_fd_sc_hd__a21oi_1
X_10935_ _07668_ net398 VSS VSS VDD VDD _02990_ sky130_fd_sc_hd__nor2b_2
X_10936_ _07676_ _02990_ net432 VSS VSS VDD VDD _02991_ sky130_fd_sc_hd__o21ai_1
X_10937_ _07673_ _02991_ VSS VSS VDD VDD _02992_ sky130_fd_sc_hd__nand2b_1
X_10938_ _02992_ _07689_ _07688_ VSS VSS VDD VDD _02993_ sky130_fd_sc_hd__a21o_1
X_10939_ _02993_ _07686_ _07685_ VSS VSS VDD VDD _02994_ sky130_fd_sc_hd__a21o_1
X_10940_ _07683_ _02994_ VSS VSS VDD VDD _02995_ sky130_fd_sc_hd__xnor2_1
X_10941_ _00552_ _02995_ VSS VSS VDD VDD _02996_ sky130_fd_sc_hd__nand2_2
X_10942_ net35 _07681_ _02996_ VSS VSS VDD VDD _07695_ sky130_fd_sc_hd__o21ai_1
X_10943_ _07624_ _07626_ _02614_ VSS VSS VDD VDD _02997_ sky130_fd_sc_hd__nor3_1
X_10944_ _07607_ _07605_ _07606_ VSS VSS VDD VDD _02998_ sky130_fd_sc_hd__nor3_1
X_10945_ _07575_ _02611_ VSS VSS VDD VDD _07603_ sky130_fd_sc_hd__nor2_2
X_10946_ _02626_ _07603_ VSS VSS VDD VDD _02999_ sky130_fd_sc_hd__nand2_1
X_10947_ _02487_ _02626_ _02998_ _02999_ VSS VSS VDD VDD _07622_
+ sky130_fd_sc_hd__o31ai_4
X_10948_ _02866_ _07622_ VSS VSS VDD VDD _03000_ sky130_fd_sc_hd__nand2_1
X_10949_ _02615_ _02866_ _02997_ _03000_ VSS VSS VDD VDD _07654_
+ sky130_fd_sc_hd__o31ai_1
X_10950_ _07656_ _07658_ _02774_ VSS VSS VDD VDD _03001_ sky130_fd_sc_hd__nor3_1
X_10951_ _02775_ _03001_ _00553_ VSS VSS VDD VDD _03002_ sky130_fd_sc_hd__o21ai_0
X_10952_ _00553_ _07654_ _03002_ VSS VSS VDD VDD _07684_ sky130_fd_sc_hd__o21a_1
X_10953_ _07686_ net409 VSS VSS VDD VDD _03003_ sky130_fd_sc_hd__xnor2_1
X_10954_ _00552_ _03003_ VSS VSS VDD VDD _03004_ sky130_fd_sc_hd__nand2_2
X_10955_ _00552_ _07684_ _03004_ VSS VSS VDD VDD _07699_ sky130_fd_sc_hd__o21ai_2
X_10956_ _07627_ _07621_ _07620_ VSS VSS VDD VDD _03005_ sky130_fd_sc_hd__nor3_1
X_10957_ _07607_ _02626_ VSS VSS VDD VDD _07625_ sky130_fd_sc_hd__nor2_4
X_10958_ _02866_ _07625_ VSS VSS VDD VDD _03006_ sky130_fd_sc_hd__nand2_1
X_10959_ _02614_ _02866_ _03005_ _03006_ VSS VSS VDD VDD _07657_
+ sky130_fd_sc_hd__o31ai_1
X_10960_ _07659_ _07644_ _02773_ VSS VSS VDD VDD _03007_ sky130_fd_sc_hd__nor3_1
X_10961_ _02774_ _03007_ _02863_ VSS VSS VDD VDD _03008_ sky130_fd_sc_hd__o21ai_0
X_10962_ _00553_ _07657_ _03008_ VSS VSS VDD VDD _07687_ sky130_fd_sc_hd__o21a_1
X_10963_ _07689_ _02992_ VSS VSS VDD VDD _03009_ sky130_fd_sc_hd__xnor2_1
X_10964_ _00552_ _03009_ VSS VSS VDD VDD _03010_ sky130_fd_sc_hd__nand2_1
X_10965_ net35 _07687_ _03010_ VSS VSS VDD VDD _07703_ sky130_fd_sc_hd__o21ai_1
X_10966_ _07621_ _02866_ VSS VSS VDD VDD _07643_ sky130_fd_sc_hd__nor2_8
X_10967_ _07645_ _07647_ _07646_ VSS VSS VDD VDD _03011_ sky130_fd_sc_hd__nor3_1
X_10968_ _02773_ _03011_ _00553_ VSS VSS VDD VDD _03012_ sky130_fd_sc_hd__o21ai_2
X_10969_ _00553_ _07643_ _03012_ VSS VSS VDD VDD _07672_ sky130_fd_sc_hd__o21a_1
X_10970_ net432 _07676_ net422 VSS VSS VDD VDD _03013_ sky130_fd_sc_hd__nor3_1
X_10971_ net416 _03013_ VSS VSS VDD VDD _03014_ sky130_fd_sc_hd__nor2_1
X_10972_ net417 _03014_ net35 VSS VSS VDD VDD _07707_ sky130_fd_sc_hd__mux2i_1
X_10973_ butterfly_count\[2\] _02863_ VSS VSS VDD VDD _03015_
+ sky130_fd_sc_hd__nor2_4
X_10974_ _02863_ _07647_ _03015_ VSS VSS VDD VDD _07675_ sky130_fd_sc_hd__a21oi_4
X_10975_ _02927_ _02950_ _02977_ VSS VSS VDD VDD _03016_ sky130_fd_sc_hd__or3_1
X_10976_ _07662_ _02780_ VSS VSS VDD VDD _03017_ sky130_fd_sc_hd__xnor2_1
X_10977_ _02939_ _02881_ _02903_ VSS VSS VDD VDD _03018_ sky130_fd_sc_hd__nor3_1
X_10978_ _07683_ _02994_ VSS VSS VDD VDD _03019_ sky130_fd_sc_hd__nand2_1
X_10979_ net37 _03017_ _03018_ _02902_ _03019_ VSS VSS VDD
+ VDD _03020_ sky130_fd_sc_hd__a221oi_1
X_10980_ _07682_ _03020_ _07680_ VSS VSS VDD VDD _03021_ sky130_fd_sc_hd__o21a_1
X_10981_ _07679_ _03021_ _02917_ VSS VSS VDD VDD _03022_ sky130_fd_sc_hd__o21ai_1
X_10982_ _02966_ _03022_ VSS VSS VDD VDD _03023_ sky130_fd_sc_hd__and2_0
X_10983_ _02881_ _02903_ _02902_ _02934_ VSS VSS VDD VDD _03024_
+ sky130_fd_sc_hd__o31ai_1
X_10984_ _02881_ _02882_ _02861_ _02886_ VSS VSS VDD VDD _03025_
+ sky130_fd_sc_hd__or4_1
X_10985_ _02937_ _03025_ VSS VSS VDD VDD _03026_ sky130_fd_sc_hd__xor2_1
X_10986_ _02879_ _02898_ _02930_ VSS VSS VDD VDD _03027_ sky130_fd_sc_hd__nand3_1
X_10987_ _02967_ _03024_ _03026_ _03027_ VSS VSS VDD VDD _03028_
+ sky130_fd_sc_hd__nor4_1
X_10988_ _02750_ _02876_ VSS VSS VDD VDD _03029_ sky130_fd_sc_hd__nand2_1
X_10989_ net394 net37 _03029_ VSS VSS VDD VDD _03030_ sky130_fd_sc_hd__a21oi_1
X_10990_ _02969_ _03030_ VSS VSS VDD VDD _03031_ sky130_fd_sc_hd__nor2_1
X_10991_ _03031_ _02967_ VSS VSS VDD VDD _03032_ sky130_fd_sc_hd__nor2b_1
X_10992_ _03023_ _03028_ _03032_ VSS VSS VDD VDD _03033_ sky130_fd_sc_hd__a21oi_1
X_10993_ _02977_ _03033_ VSS VSS VDD VDD _03034_ sky130_fd_sc_hd__nand2_1
X_10994_ net405 _02940_ VSS VSS VDD VDD _03035_ sky130_fd_sc_hd__nor2_1
X_10995_ _02902_ _03018_ VSS VSS VDD VDD _03036_ sky130_fd_sc_hd__and2_0
X_10996_ _02965_ _03035_ _03036_ VSS VSS VDD VDD _03037_ sky130_fd_sc_hd__or3_1
X_10997_ _02782_ _02942_ VSS VSS VDD VDD _03038_ sky130_fd_sc_hd__nor2_1
X_10998_ _02782_ net37 _02942_ VSS VSS VDD VDD _03039_ sky130_fd_sc_hd__and3_1
X_10999_ _03038_ _03039_ _02945_ VSS VSS VDD VDD _03040_ sky130_fd_sc_hd__mux2i_1
X_11000_ _03037_ _03040_ VSS VSS VDD VDD _03041_ sky130_fd_sc_hd__nor2_1
X_11001_ _02945_ _02963_ VSS VSS VDD VDD _03042_ sky130_fd_sc_hd__nand2_1
X_11002_ _02965_ _03035_ _03036_ _03042_ VSS VSS VDD VDD _03043_
+ sky130_fd_sc_hd__nor4_1
X_11003_ _02945_ _02963_ VSS VSS VDD VDD _03044_ sky130_fd_sc_hd__nor2_1
X_11004_ _07679_ _03021_ _03043_ _03044_ _02917_ VSS VSS VDD
+ VDD _03045_ sky130_fd_sc_hd__o221ai_1
X_11005_ _02945_ _03037_ VSS VSS VDD VDD _03046_ sky130_fd_sc_hd__nand2b_1
X_11006_ _03045_ _03046_ _03038_ _03039_ VSS VSS VDD VDD _03047_
+ sky130_fd_sc_hd__a211oi_1
X_11007_ _03022_ _03041_ _03047_ VSS VSS VDD VDD _03048_ sky130_fd_sc_hd__a21oi_1
X_11008_ _02966_ _03022_ VSS VSS VDD VDD _03049_ sky130_fd_sc_hd__nand2_1
X_11009_ _02927_ _03049_ VSS VSS VDD VDD _03050_ sky130_fd_sc_hd__nor2_1
X_11010_ _02902_ _03018_ VSS VSS VDD VDD _03051_ sky130_fd_sc_hd__nand2_1
X_11011_ net406 _02940_ _03051_ VSS VSS VDD VDD _03052_ sky130_fd_sc_hd__o21ai_1
X_11012_ _07682_ _03019_ VSS VSS VDD VDD _03053_ sky130_fd_sc_hd__nand2b_1
X_11013_ _07680_ _03053_ _07679_ VSS VSS VDD VDD _03054_ sky130_fd_sc_hd__a21oi_1
X_11014_ net37 _02940_ VSS VSS VDD VDD _03055_ sky130_fd_sc_hd__nand2_1
X_11015_ _02939_ _02932_ _02902_ net391 VSS VSS VDD VDD _03056_
+ sky130_fd_sc_hd__a31oi_1
X_11016_ net391 _03051_ _03055_ _03056_ VSS VSS VDD VDD _03057_
+ sky130_fd_sc_hd__a22o_1
X_11017_ _02963_ _03035_ VSS VSS VDD VDD _03058_ sky130_fd_sc_hd__nand2_1
X_11018_ _03057_ _03058_ _02900_ _03054_ VSS VSS VDD VDD _03059_
+ sky130_fd_sc_hd__a211oi_1
X_11019_ _02900_ _03052_ _03054_ _03059_ _02916_ VSS VSS VDD
+ VDD _03060_ sky130_fd_sc_hd__a311oi_1
X_11020_ _07680_ _03053_ _07679_ VSS VSS VDD VDD _03061_ sky130_fd_sc_hd__a21o_1
X_11021_ _02900_ _03061_ VSS VSS VDD VDD _03062_ sky130_fd_sc_hd__nand2_1
X_11022_ _02900_ _03054_ VSS VSS VDD VDD _03063_ sky130_fd_sc_hd__xnor2_1
X_11023_ _02963_ _03062_ _03063_ _02049_ VSS VSS VDD VDD _03064_
+ sky130_fd_sc_hd__o22ai_1
X_11024_ _03052_ _03064_ VSS VSS VDD VDD _03065_ sky130_fd_sc_hd__nor2_1
X_11025_ _02900_ _02963_ _03061_ VSS VSS VDD VDD _03066_ sky130_fd_sc_hd__nand3_1
X_11026_ _02900_ _03061_ _03066_ VSS VSS VDD VDD _03067_ sky130_fd_sc_hd__o21ai_0
X_11027_ _02049_ _03067_ _03052_ VSS VSS VDD VDD _03068_ sky130_fd_sc_hd__a21boi_0
X_11028_ _03065_ _03068_ _02916_ VSS VSS VDD VDD _03069_ sky130_fd_sc_hd__o21ai_0
X_11029_ _02968_ _02972_ VSS VSS VDD VDD _03070_ sky130_fd_sc_hd__nor2_1
X_11030_ _02937_ _02967_ _03070_ _02973_ VSS VSS VDD VDD _03071_
+ sky130_fd_sc_hd__nand4_1
X_11031_ _03060_ _03069_ _03071_ _02973_ VSS VSS VDD VDD _03072_
+ sky130_fd_sc_hd__nand4b_1
X_11032_ _02916_ _02944_ _02945_ VSS VSS VDD VDD _03073_ sky130_fd_sc_hd__or3_1
X_11033_ _03048_ _03050_ _03072_ _03073_ _02978_ VSS VSS VDD
+ VDD _03074_ sky130_fd_sc_hd__o32a_1
X_11034_ _02796_ _02741_ _02748_ _02830_ VSS VSS VDD VDD _03075_
+ sky130_fd_sc_hd__a31oi_1
X_11035_ _02796_ _02741_ _02830_ _03075_ VSS VSS VDD VDD _03076_
+ sky130_fd_sc_hd__a31oi_2
X_11036_ _02823_ _03076_ VSS VSS VDD VDD _03077_ sky130_fd_sc_hd__or2_1
X_11037_ _02954_ VSS VSS VDD VDD _03078_ sky130_fd_sc_hd__inv_1
X_11038_ _03078_ _03076_ VSS VSS VDD VDD _03079_ sky130_fd_sc_hd__nand2_1
X_11039_ _02879_ _02898_ _02930_ _02938_ VSS VSS VDD VDD _03080_
+ sky130_fd_sc_hd__and4_1
X_11040_ _02966_ _03022_ _03080_ VSS VSS VDD VDD _03081_ sky130_fd_sc_hd__and3_1
X_11041_ _02950_ _02977_ _03081_ VSS VSS VDD VDD _03082_ sky130_fd_sc_hd__o21ai_0
X_11042_ _03077_ _03079_ _03082_ VSS VSS VDD VDD _03083_ sky130_fd_sc_hd__mux2i_1
X_11043_ _03026_ _03049_ _03027_ _03032_ _03024_ VSS VSS VDD
+ VDD _03084_ sky130_fd_sc_hd__o41ai_1
X_11044_ _02967_ _03070_ _02973_ VSS VSS VDD VDD _03085_ sky130_fd_sc_hd__nand3_1
X_11045_ _02927_ _03049_ _03085_ _03026_ VSS VSS VDD VDD _03086_
+ sky130_fd_sc_hd__a22oi_1
X_11046_ _02932_ _02974_ _02815_ VSS VSS VDD VDD _03087_ sky130_fd_sc_hd__mux2i_1
X_11047_ _02856_ _02731_ VSS VSS VDD VDD _03088_ sky130_fd_sc_hd__nand2_1
X_11048_ _02702_ _02825_ _02830_ VSS VSS VDD VDD _03089_ sky130_fd_sc_hd__nor3_1
X_11049_ _03088_ _03089_ _02828_ VSS VSS VDD VDD _03090_ sky130_fd_sc_hd__nand3_1
X_11050_ _07693_ _07697_ _07701_ _07705_ VSS VSS VDD VDD _03091_
+ sky130_fd_sc_hd__nand4_2
X_11051_ _07701_ _07704_ _07700_ VSS VSS VDD VDD _03092_ sky130_fd_sc_hd__a21oi_2
X_11052_ _03092_ _07697_ VSS VSS VDD VDD _03093_ sky130_fd_sc_hd__nor2b_2
X_11053_ _03093_ _07696_ _07693_ VSS VSS VDD VDD _03094_ sky130_fd_sc_hd__o21ai_1
X_11054_ _07692_ _03094_ VSS VSS VDD VDD _03095_ sky130_fd_sc_hd__nand2b_1
X_11055_ _07709_ _07715_ _07713_ _07718_ _03091_ VSS VSS VDD
+ VDD _03096_ sky130_fd_sc_hd__a41oi_2
X_11056_ _03095_ _03091_ _03096_ VSS VSS VDD VDD _03097_ sky130_fd_sc_hd__a21oi_4
X_11057_ _02840_ _03090_ _03097_ VSS VSS VDD VDD _03098_ sky130_fd_sc_hd__a21oi_2
X_11058_ _02857_ _02847_ _03098_ VSS VSS VDD VDD _03099_ sky130_fd_sc_hd__or3b_1
X_11059_ _02823_ _03076_ VSS VSS VDD VDD _03100_ sky130_fd_sc_hd__nand2_1
X_11060_ _03078_ _03077_ _03100_ VSS VSS VDD VDD _03101_ sky130_fd_sc_hd__o21ai_0
X_11061_ _02811_ _03099_ _03101_ _03087_ VSS VSS VDD VDD _03102_
+ sky130_fd_sc_hd__or4_4
X_11062_ _02675_ net392 _02876_ net37 VSS VSS VDD VDD _03103_
+ sky130_fd_sc_hd__nand4_1
X_11063_ _02756_ _03103_ VSS VSS VDD VDD _03104_ sky130_fd_sc_hd__xor2_1
X_11064_ _02760_ _02750_ _02756_ VSS VSS VDD VDD _03105_ sky130_fd_sc_hd__nor3_1
X_11065_ _02750_ _03104_ _03105_ VSS VSS VDD VDD _03106_ sky130_fd_sc_hd__a21oi_1
X_11066_ _02967_ _03031_ VSS VSS VDD VDD _03107_ sky130_fd_sc_hd__nor2b_1
X_11067_ _02823_ _02953_ _03078_ VSS VSS VDD VDD _03108_ sky130_fd_sc_hd__nor3_1
X_11068_ _02951_ _03108_ VSS VSS VDD VDD _03109_ sky130_fd_sc_hd__xor2_1
X_11069_ _02956_ _03109_ VSS VSS VDD VDD _03110_ sky130_fd_sc_hd__nor2_1
X_11070_ _03110_ _03106_ _03107_ _03102_ VSS VSS VDD VDD _03111_
+ sky130_fd_sc_hd__nor4_4
X_11071_ _02967_ _02976_ VSS VSS VDD VDD _03112_ sky130_fd_sc_hd__nand2_1
X_11072_ _02955_ _02951_ VSS VSS VDD VDD _03113_ sky130_fd_sc_hd__nand2b_1
X_11073_ _03112_ _03113_ _02898_ VSS VSS VDD VDD _03114_ sky130_fd_sc_hd__a21boi_0
X_11074_ _03084_ _03111_ _03086_ _03114_ VSS VSS VDD VDD _03115_
+ sky130_fd_sc_hd__nand4_2
X_11075_ _03016_ _03034_ _03115_ _03083_ _03074_ VSS VSS VDD
+ VDD _03116_ sky130_fd_sc_hd__a2111oi_4
X_11076_ butterfly_count\[1\] _02950_ _02977_ VSS VSS VDD
+ VDD _03117_ sky130_fd_sc_hd__nor3_2
X_11077_ _07669_ net395 _03117_ VSS VSS VDD VDD _05893_ sky130_fd_sc_hd__a21oi_4
X_11078_ _07709_ _07713_ _05907_ VSS VSS VDD VDD _03118_ sky130_fd_sc_hd__nand3_1
X_11079_ _07715_ _07713_ VSS VSS VDD VDD _03119_ sky130_fd_sc_hd__nand2_1
X_11080_ _07719_ _03119_ _07712_ VSS VSS VDD VDD _03120_ sky130_fd_sc_hd__o21bai_1
X_11081_ _07709_ _03120_ _03095_ _07708_ VSS VSS VDD VDD _03121_
+ sky130_fd_sc_hd__a211oi_1
X_11082_ _05893_ _03118_ _03121_ VSS VSS VDD VDD _03122_ sky130_fd_sc_hd__o21ai_4
X_11083_ _02899_ _02949_ _02956_ _02951_ _02858_ VSS VSS VDD
+ VDD _03123_ sky130_fd_sc_hd__o2111ai_1
X_11084_ _02967_ _02976_ _03123_ _02954_ VSS VSS VDD VDD _03124_
+ sky130_fd_sc_hd__a31oi_1
X_11085_ _03089_ _02828_ VSS VSS VDD VDD _03125_ sky130_fd_sc_hd__or2_0
X_11086_ _03077_ _03124_ _03125_ _03090_ VSS VSS VDD VDD _03126_
+ sky130_fd_sc_hd__o211ai_1
X_11087_ _03090_ _03125_ _03124_ _03077_ VSS VSS VDD VDD _03127_
+ sky130_fd_sc_hd__a211o_1
X_11088_ _02927_ _03029_ VSS VSS VDD VDD _03128_ sky130_fd_sc_hd__nor2_1
X_11089_ _02950_ _02977_ _03023_ _03128_ VSS VSS VDD VDD _03129_
+ sky130_fd_sc_hd__o211ai_1
X_11090_ _02879_ _03129_ VSS VSS VDD VDD _03130_ sky130_fd_sc_hd__xor2_1
X_11091_ _03126_ _03127_ _03130_ VSS VSS VDD VDD _03131_ sky130_fd_sc_hd__a21oi_1
X_11092_ _02846_ _02847_ _02851_ _02855_ VSS VSS VDD VDD _03132_
+ sky130_fd_sc_hd__a211oi_1
X_11093_ _02950_ _02977_ _03081_ _02956_ VSS VSS VDD VDD _03133_
+ sky130_fd_sc_hd__o211a_1
X_11094_ _03108_ _03133_ _02951_ VSS VSS VDD VDD _03134_ sky130_fd_sc_hd__o21ai_0
X_11095_ _03132_ _03134_ VSS VSS VDD VDD _03135_ sky130_fd_sc_hd__xnor2_1
X_11096_ _03122_ _03116_ _03131_ _03135_ VSS VSS VDD VDD _00551_
+ sky130_fd_sc_hd__nand4_4
X_11097_ state\[0\] VSS VSS VDD VDD _03136_ sky130_fd_sc_hd__inv_1
X_11098_ state\[2\] VSS VSS VDD VDD _03137_ sky130_fd_sc_hd__buf_4
X_11099_ net91 _07833_ VSS VSS VDD VDD _03138_ sky130_fd_sc_hd__nand2_2
X_11100_ _03137_ _03138_ VSS VSS VDD VDD _03139_ sky130_fd_sc_hd__nand2_1
X_11101_ _03136_ _00557_ _03139_ VSS VSS VDD VDD _00006_ sky130_fd_sc_hd__o21ai_0
X_11102_ state\[2\] VSS VSS VDD VDD _03140_ sky130_fd_sc_hd__inv_1
X_11103_ state\[1\] VSS VSS VDD VDD _03141_ sky130_fd_sc_hd__clkbuf_4
X_11104_ _03141_ VSS VSS VDD VDD _03142_ sky130_fd_sc_hd__clkbuf_8
X_11105_ _03142_ _07819_ VSS VSS VDD VDD _03143_ sky130_fd_sc_hd__nand2_1
X_11106_ _03140_ _03138_ _03143_ VSS VSS VDD VDD _00005_ sky130_fd_sc_hd__o21ai_0
X_11107_ butterfly_count\[2\] state\[1\] VSS VSS VDD VDD _03144_
+ sky130_fd_sc_hd__nor2b_2
X_11108_ _07819_ net354 _03144_ VSS VSS VDD VDD _03145_ sky130_fd_sc_hd__nand3_2
X_11109_ _03145_ VSS VSS VDD VDD _00007_ sky130_fd_sc_hd__inv_8
X_11110_ net519 VSS VSS VDD VDD _03146_ sky130_fd_sc_hd__buf_6
X_11111_ _03146_ VSS VSS VDD VDD _03147_ sky130_fd_sc_hd__buf_6
X_11112_ _03147_ VSS VSS VDD VDD _03148_ sky130_fd_sc_hd__buf_6
X_11113_ net514 VSS VSS VDD VDD _03149_ sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_11115_ net526 VSS VSS VDD VDD _03151_ sky130_fd_sc_hd__inv_4
X_11116_ _03151_ net589 VSS VSS VDD VDD _03152_ sky130_fd_sc_hd__nor2_8
X_11117_ net526 VSS VSS VDD VDD _03153_ sky130_fd_sc_hd__buf_8
X_11118_ net520 net515 VSS VSS VDD VDD _03154_ sky130_fd_sc_hd__nand2b_4
X_11119_ _03154_ VSS VSS VDD VDD _03155_ sky130_fd_sc_hd__buf_6
X_11120_ _03155_ net633 VSS VSS VDD VDD _03156_ sky130_fd_sc_hd__nor2_8
X_11121_ samples_real\[5\]\[0\] _03148_ _03152_ _03156_ samples_real\[2\]\[0\]
+ VSS VSS VDD VDD _03157_ sky130_fd_sc_hd__a32oi_2
X_11122_ _03151_ VSS VSS VDD VDD _03158_ sky130_fd_sc_hd__buf_6
X_11123_ _03158_ _03155_ VSS VSS VDD VDD _03159_ sky130_fd_sc_hd__nor2_1
X_11124_ net590 net572 VSS VSS VDD VDD _03160_ sky130_fd_sc_hd__nor2_8
X_11125_ _03160_ _03146_ VSS VSS VDD VDD _03161_ sky130_fd_sc_hd__and2_4
Xclone64 _05106_ VSS VSS VDD VDD net64 sky130_fd_sc_hd__buf_12
X_11127_ samples_real\[3\]\[0\] _03159_ samples_real\[4\]\[0\]
+ net615 VSS VSS VDD VDD _03163_ sky130_fd_sc_hd__a22oi_4
X_11128_ _03149_ VSS VSS VDD VDD _03164_ sky130_fd_sc_hd__buf_12
X_11129_ _03164_ VSS VSS VDD VDD _03165_ sky130_fd_sc_hd__buf_12
X_11130_ _03165_ VSS VSS VDD VDD _03166_ sky130_fd_sc_hd__buf_6
X_11131_ _03153_ VSS VSS VDD VDD _03167_ sky130_fd_sc_hd__buf_12
X_11132_ samples_real\[6\]\[0\] samples_real\[7\]\[0\] _03167_
+ VSS VSS VDD VDD _03168_ sky130_fd_sc_hd__mux2_4
X_11133_ _03147_ VSS VSS VDD VDD _03169_ sky130_fd_sc_hd__buf_6
X_11134_ _03165_ VSS VSS VDD VDD _03170_ sky130_fd_sc_hd__buf_12
X_11135_ _03158_ samples_real\[1\]\[0\] VSS VSS VDD VDD _03171_
+ sky130_fd_sc_hd__nor2_2
X_11136_ _03169_ _03170_ _03171_ VSS VSS VDD VDD _03172_ sky130_fd_sc_hd__nor3_4
X_11137_ _03168_ _03166_ _03148_ _03172_ VSS VSS VDD VDD _03173_
+ sky130_fd_sc_hd__a31oi_4
X_11138_ net519 net514 idx1\[0\] VSS VSS VDD VDD _03174_ sky130_fd_sc_hd__or3_1
X_11139_ _03174_ VSS VSS VDD VDD _03175_ sky130_fd_sc_hd__buf_6
X_11140_ _03175_ VSS VSS VDD VDD _03176_ sky130_fd_sc_hd__buf_6
X_11141_ _03176_ VSS VSS VDD VDD _03177_ sky130_fd_sc_hd__buf_8
X_11142_ samples_real\[0\]\[0\] _03177_ VSS VSS VDD VDD _03178_
+ sky130_fd_sc_hd__nor2_8
X_11143_ _03157_ _03173_ _03163_ _03178_ VSS VSS VDD VDD _07732_
+ sky130_fd_sc_hd__a31oi_4
X_11144_ net569 VSS VSS VDD VDD _07734_ sky130_fd_sc_hd__inv_2
Xrebuffer230 _03170_ VSS VSS VDD VDD net601 sky130_fd_sc_hd__clkbuf_2
X_11146_ samples_real\[0\]\[1\] samples_real\[2\]\[1\] samples_real\[1\]\[1\]
+ samples_real\[3\]\[1\] net586 net580 VSS VSS VDD VDD _03180_
+ sky130_fd_sc_hd__mux4_2
X_11147_ _03153_ VSS VSS VDD VDD _03181_ sky130_fd_sc_hd__buf_12
X_11148_ _03149_ VSS VSS VDD VDD _03182_ sky130_fd_sc_hd__buf_8
X_11149_ _03182_ VSS VSS VDD VDD _03183_ sky130_fd_sc_hd__buf_6
X_11150_ samples_real\[4\]\[1\] samples_real\[5\]\[1\] samples_real\[6\]\[1\]
+ samples_real\[7\]\[1\] _03181_ _03183_ VSS VSS VDD VDD _03184_
+ sky130_fd_sc_hd__mux4_1
X_11151_ _03169_ VSS VSS VDD VDD _03185_ sky130_fd_sc_hd__clkbuf_8
X_11152_ _03180_ _03184_ _03185_ VSS VSS VDD VDD _05887_ sky130_fd_sc_hd__mux2_4
X_11153_ _05887_ VSS VSS VDD VDD _05883_ sky130_fd_sc_hd__inv_1
X_11154_ net53 VSS VSS VDD VDD _05882_ sky130_fd_sc_hd__clkinv_8
X_11155_ _05891_ VSS VSS VDD VDD _05888_ sky130_fd_sc_hd__inv_2
X_11156_ _07716_ _07718_ _00551_ VSS VSS VDD VDD _00554_ sky130_fd_sc_hd__mux2i_1
X_11157_ _05893_ VSS VSS VDD VDD _03186_ sky130_fd_sc_hd__inv_1
X_11158_ _03186_ _05896_ _00551_ VSS VSS VDD VDD _00555_ sky130_fd_sc_hd__mux2i_1
X_11159_ net399 _07668_ VSS VSS VDD VDD _03187_ sky130_fd_sc_hd__nor2b_1
X_11160_ _02990_ _03187_ net395 VSS VSS VDD VDD _03188_ sky130_fd_sc_hd__o21ai_0
X_11161_ net395 net427 _03188_ VSS VSS VDD VDD _07711_ sky130_fd_sc_hd__o21ai_1
X_11162_ _05895_ _07713_ VSS VSS VDD VDD _03189_ sky130_fd_sc_hd__xnor2_1
X_11163_ _07711_ _03189_ _00551_ VSS VSS VDD VDD _00556_ sky130_fd_sc_hd__mux2i_1
X_11164_ stage\[1\] VSS VSS VDD VDD _07804_ sky130_fd_sc_hd__inv_4
X_11165_ butterfly_in_group\[0\] butterfly_in_group\[1\] stage\[0\]
+ VSS VSS VDD VDD _03190_ sky130_fd_sc_hd__mux2i_2
X_11166_ stage\[0\] VSS VSS VDD VDD _07803_ sky130_fd_sc_hd__inv_8
X_11167_ _00562_ _07803_ butterfly_in_group\[2\] _07804_ VSS
+ VSS VDD VDD _03191_ sky130_fd_sc_hd__nand4_1
X_11168_ _00562_ _07804_ _03190_ _03191_ VSS VSS VDD VDD _05877_
+ sky130_fd_sc_hd__o31ai_4
X_11169_ twiddle_idx\[0\] _05877_ _00007_ VSS VSS VDD VDD
+ _03192_ sky130_fd_sc_hd__mux2i_4
X_11170_ _03192_ VSS VSS VDD VDD _00000_ sky130_fd_sc_hd__inv_1
X_11171_ butterfly_in_group\[1\] butterfly_in_group\[2\] stage\[0\]
+ VSS VSS VDD VDD _03193_ sky130_fd_sc_hd__mux2_1
X_11172_ stage\[1\] _03193_ VSS VSS VDD VDD _03194_ sky130_fd_sc_hd__nand2_1
X_11173_ stage\[0\] butterfly_in_group\[0\] _07804_ VSS VSS
+ VDD VDD _03195_ sky130_fd_sc_hd__nand3_1
X_11174_ _03194_ _03195_ _00562_ VSS VSS VDD VDD _05878_ sky130_fd_sc_hd__a21oi_2
X_11175_ twiddle_idx\[1\] _05878_ _00007_ VSS VSS VDD VDD
+ _00002_ sky130_fd_sc_hd__mux2i_4
X_11176_ _03192_ _00002_ VSS VSS VDD VDD _00023_ sky130_fd_sc_hd__nand2_1
X_11177_ _00023_ VSS VSS VDD VDD _00020_ sky130_fd_sc_hd__inv_1
X_11178_ _03192_ _00002_ VSS VSS VDD VDD _00022_ sky130_fd_sc_hd__nor2_1
X_11179_ _00020_ _00022_ VSS VSS VDD VDD _00001_ sky130_fd_sc_hd__or2_0
X_11180_ _03146_ _03158_ _03164_ VSS VSS VDD VDD _03196_ sky130_fd_sc_hd__nor3_4
X_11181_ net536 samples_imag\[2\]\[0\] _03196_ samples_imag\[1\]\[0\]
+ VSS VSS VDD VDD _03197_ sky130_fd_sc_hd__a22oi_4
X_11182_ _03146_ net516 net65 VSS VSS VDD VDD _03198_ sky130_fd_sc_hd__and3_2
X_11183_ samples_imag\[4\]\[0\] net553 _03198_ samples_imag\[7\]\[0\]
+ VSS VSS VDD VDD _03199_ sky130_fd_sc_hd__a22oi_4
X_11184_ net516 net65 samples_imag\[3\]\[0\] VSS VSS VDD VDD
+ _03200_ sky130_fd_sc_hd__and3_4
X_11185_ _03149_ VSS VSS VDD VDD _03201_ sky130_fd_sc_hd__inv_4
X_11186_ _03201_ net575 VSS VSS VDD VDD _03202_ sky130_fd_sc_hd__nor2_4
X_11187_ samples_imag\[5\]\[0\] _03152_ _03202_ samples_imag\[6\]\[0\]
+ VSS VSS VDD VDD _03203_ sky130_fd_sc_hd__a22oi_1
X_11188_ _03147_ _03203_ VSS VSS VDD VDD _03204_ sky130_fd_sc_hd__nand2_1
X_11189_ _03146_ _03200_ net555 _03204_ VSS VSS VDD VDD _03205_
+ sky130_fd_sc_hd__o31ai_4
X_11190_ samples_imag\[0\]\[0\] _03175_ VSS VSS VDD VDD _03206_
+ sky130_fd_sc_hd__nor2_1
X_11191_ _03199_ _03197_ _03205_ _03206_ VSS VSS VDD VDD _07846_
+ sky130_fd_sc_hd__a31oi_4
X_11192_ net529 VSS VSS VDD VDD _07848_ sky130_fd_sc_hd__inv_2
X_11193_ _03176_ VSS VSS VDD VDD _03207_ sky130_fd_sc_hd__buf_6
X_11194_ _03146_ _03151_ VSS VSS VDD VDD _03208_ sky130_fd_sc_hd__nor2_2
X_11195_ net591 VSS VSS VDD VDD _03209_ sky130_fd_sc_hd__buf_8
X_11196_ _03209_ _03147_ VSS VSS VDD VDD _03210_ sky130_fd_sc_hd__nor2b_4
X_11197_ samples_imag\[3\]\[1\] _03208_ _03210_ samples_imag\[6\]\[1\]
+ VSS VSS VDD VDD _03211_ sky130_fd_sc_hd__a22oi_1
X_11198_ _03201_ _03211_ VSS VSS VDD VDD _03212_ sky130_fd_sc_hd__nor2_1
X_11199_ _03209_ VSS VSS VDD VDD _03213_ sky130_fd_sc_hd__buf_12
X_11200_ samples_imag\[1\]\[1\] VSS VSS VDD VDD _03214_ sky130_fd_sc_hd__inv_1
X_11201_ _03213_ _03214_ _03169_ VSS VSS VDD VDD _03215_ sky130_fd_sc_hd__a21oi_4
X_11202_ _03158_ samples_imag\[4\]\[1\] _03215_ VSS VSS VDD
+ VDD _03216_ sky130_fd_sc_hd__a21oi_1
X_11203_ samples_imag\[5\]\[1\] samples_imag\[7\]\[1\] _03165_
+ VSS VSS VDD VDD _03217_ sky130_fd_sc_hd__mux2_4
X_11204_ _03185_ _03213_ _03217_ net534 samples_imag\[2\]\[1\]
+ VSS VSS VDD VDD _03218_ sky130_fd_sc_hd__a32oi_2
X_11205_ _03166_ _03216_ _03218_ VSS VSS VDD VDD _03219_ sky130_fd_sc_hd__o21ai_1
X_11206_ samples_imag\[0\]\[1\] _03207_ _03212_ _03219_ VSS
+ VSS VDD VDD _05902_ sky130_fd_sc_hd__o22a_2
X_11207_ _05902_ VSS VSS VDD VDD _05898_ sky130_fd_sc_hd__inv_2
X_11208_ temp_imag\[0\] VSS VSS VDD VDD _05897_ sky130_fd_sc_hd__inv_6
X_11209_ _05906_ VSS VSS VDD VDD _05903_ sky130_fd_sc_hd__inv_2
X_11210_ _00562_ stage\[0\] stage\[1\] VSS VSS VDD VDD _03220_
+ sky130_fd_sc_hd__nand3_1
X_11211_ group\[0\] _02900_ _03220_ VSS VSS VDD VDD _07913_
+ sky130_fd_sc_hd__and3_1
X_11212_ group\[1\] _02900_ _03220_ VSS VSS VDD VDD _07915_
+ sky130_fd_sc_hd__and3_1
X_11213_ _07820_ _03220_ group\[0\] _07807_ VSS VSS VDD VDD
+ _07918_ sky130_fd_sc_hd__and4b_1
X_11214_ group\[0\] _07813_ VSS VSS VDD VDD _03221_ sky130_fd_sc_hd__nand2_1
X_11215_ group\[1\] _07807_ VSS VSS VDD VDD _03222_ sky130_fd_sc_hd__nand2_1
X_11216_ _03221_ _03222_ VSS VSS VDD VDD _03223_ sky130_fd_sc_hd__xnor2_1
X_11217_ _07820_ _03223_ VSS VSS VDD VDD _03224_ sky130_fd_sc_hd__nor2_1
X_11218_ group\[2\] _02900_ VSS VSS VDD VDD _03225_ sky130_fd_sc_hd__nand2_1
X_11219_ _03224_ _03225_ VSS VSS VDD VDD _03226_ sky130_fd_sc_hd__xnor2_1
X_11220_ _03220_ _03226_ VSS VSS VDD VDD _03227_ sky130_fd_sc_hd__nand2_1
X_11221_ _07919_ _07921_ VSS VSS VDD VDD _03228_ sky130_fd_sc_hd__xor2_1
X_11222_ butterfly_in_group\[2\] _07916_ VSS VSS VDD VDD _03229_
+ sky130_fd_sc_hd__xnor2_1
X_11223_ _03228_ _03229_ VSS VSS VDD VDD _03230_ sky130_fd_sc_hd__xnor2_1
X_11224_ _03227_ _03230_ VSS VSS VDD VDD _00013_ sky130_fd_sc_hd__xnor2_1
X_11225_ _05909_ _07710_ VSS VSS VDD VDD _03231_ sky130_fd_sc_hd__xnor2_1
X_11226_ _00013_ _03231_ VSS VSS VDD VDD _00015_ sky130_fd_sc_hd__xnor2_1
Xclone41 net474 VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_2
X_11228_ net443 VSS VSS VDD VDD _03233_ sky130_fd_sc_hd__buf_6
X_11229_ _03233_ VSS VSS VDD VDD _03234_ sky130_fd_sc_hd__buf_6
X_11230_ idx2\[0\] VSS VSS VDD VDD _03235_ sky130_fd_sc_hd__buf_6
X_11231_ _03235_ VSS VSS VDD VDD _03236_ sky130_fd_sc_hd__buf_12
X_11232_ _03236_ VSS VSS VDD VDD _03237_ sky130_fd_sc_hd__buf_8
X_11233_ _03237_ VSS VSS VDD VDD _03238_ sky130_fd_sc_hd__buf_12
X_11234_ samples_real\[0\]\[12\] samples_real\[4\]\[12\] samples_real\[1\]\[12\]
+ samples_real\[5\]\[12\] _03234_ net451 VSS VSS VDD VDD _03239_
+ sky130_fd_sc_hd__mux4_1
X_11235_ _03234_ VSS VSS VDD VDD _03240_ sky130_fd_sc_hd__buf_6
X_11236_ samples_real\[2\]\[12\] samples_real\[3\]\[12\] samples_real\[6\]\[12\]
+ samples_real\[7\]\[12\] net452 net50 VSS VSS VDD VDD _03241_
+ sky130_fd_sc_hd__mux4_1
X_11237_ idx2\[1\] VSS VSS VDD VDD _03242_ sky130_fd_sc_hd__buf_6
X_11238_ _03242_ VSS VSS VDD VDD _03243_ sky130_fd_sc_hd__buf_8
X_11239_ _03243_ VSS VSS VDD VDD _03244_ sky130_fd_sc_hd__buf_4
X_11240_ _03244_ VSS VSS VDD VDD _03245_ sky130_fd_sc_hd__buf_6
X_11241_ _03239_ _03241_ _03245_ VSS VSS VDD VDD _03246_ sky130_fd_sc_hd__mux2i_4
X_11242_ _00010_ VSS VSS VDD VDD _03247_ sky130_fd_sc_hd__buf_4
X_11243_ _03246_ _03247_ VSS VSS VDD VDD _05947_ sky130_fd_sc_hd__nand2b_1
X_11244_ _00008_ VSS VSS VDD VDD _03248_ sky130_fd_sc_hd__clkinv_8
X_11245_ net444 VSS VSS VDD VDD _03249_ sky130_fd_sc_hd__clkinv_4
X_11246_ _03243_ _03249_ VSS VSS VDD VDD _03250_ sky130_fd_sc_hd__nor2_2
X_11247_ net42 net46 VSS VSS VDD VDD _03251_ sky130_fd_sc_hd__nor2b_4
X_11248_ samples_imag\[5\]\[12\] _03250_ _03251_ samples_imag\[3\]\[12\]
+ VSS VSS VDD VDD _03252_ sky130_fd_sc_hd__a22o_1
X_11249_ samples_imag\[4\]\[12\] VSS VSS VDD VDD _03253_ sky130_fd_sc_hd__inv_1
X_11250_ net42 _03253_ net452 VSS VSS VDD VDD _03254_ sky130_fd_sc_hd__a21oi_1
X_11251_ _03249_ samples_imag\[1\]\[12\] _03254_ VSS VSS VDD
+ VDD _03255_ sky130_fd_sc_hd__a21oi_1
X_11252_ _03243_ net51 VSS VSS VDD VDD _03256_ sky130_fd_sc_hd__nand2_4
X_11253_ samples_imag\[6\]\[12\] samples_imag\[7\]\[12\] net452
+ VSS VSS VDD VDD _03257_ sky130_fd_sc_hd__mux2i_2
X_11254_ _03235_ _03233_ VSS VSS VDD VDD _03258_ sky130_fd_sc_hd__nor2_4
X_11255_ samples_imag\[2\]\[12\] _03258_ VSS VSS VDD VDD _03259_
+ sky130_fd_sc_hd__nand2_1
X_11256_ _03243_ _03255_ _03256_ _03257_ _03259_ VSS VSS VDD
+ VDD _03260_ sky130_fd_sc_hd__o221ai_4
X_11257_ net451 _03252_ _03260_ VSS VSS VDD VDD _03261_ sky130_fd_sc_hd__a21oi_4
X_11258_ net493 _03235_ net443 VSS VSS VDD VDD _03262_ sky130_fd_sc_hd__or3_4
X_11259_ _03262_ VSS VSS VDD VDD _03263_ sky130_fd_sc_hd__buf_6
X_11260_ samples_imag\[0\]\[12\] net49 VSS VSS VDD VDD _03264_
+ sky130_fd_sc_hd__nor2_2
X_11261_ _03248_ _03261_ _03264_ VSS VSS VDD VDD _07938_ sky130_fd_sc_hd__nor3_2
X_11262_ _03263_ VSS VSS VDD VDD _03265_ sky130_fd_sc_hd__buf_8
X_11263_ _03242_ _03235_ _03233_ VSS VSS VDD VDD _03266_ sky130_fd_sc_hd__and3_4
Xclone49 _03262_ VSS VSS VDD VDD net49 sky130_fd_sc_hd__buf_4
X_11265_ _03266_ VSS VSS VDD VDD _03268_ sky130_fd_sc_hd__buf_8
X_11266_ net507 net443 VSS VSS VDD VDD _03269_ sky130_fd_sc_hd__nand2b_4
Xclone51 _03233_ VSS VSS VDD VDD net51 sky130_fd_sc_hd__buf_6
X_11268_ net441 net509 VSS VSS VDD VDD _03271_ sky130_fd_sc_hd__nor2_8
X_11269_ _03271_ VSS VSS VDD VDD _03272_ sky130_fd_sc_hd__buf_8
X_11270_ samples_real\[7\]\[11\] _03268_ _03272_ samples_real\[4\]\[11\]
+ VSS VSS VDD VDD _03273_ sky130_fd_sc_hd__a22oi_1
X_11271_ _03242_ _03258_ VSS VSS VDD VDD _03274_ sky130_fd_sc_hd__and2_4
X_11272_ _03274_ VSS VSS VDD VDD _03275_ sky130_fd_sc_hd__buf_4
X_11273_ _03242_ _03233_ VSS VSS VDD VDD _03276_ sky130_fd_sc_hd__nor2_4
X_11274_ _03276_ _03236_ VSS VSS VDD VDD _03277_ sky130_fd_sc_hd__and2_4
Xclone43 _03236_ VSS VSS VDD VDD net43 sky130_fd_sc_hd__buf_2
X_11276_ _03277_ VSS VSS VDD VDD _03279_ sky130_fd_sc_hd__buf_12
X_11277_ samples_real\[2\]\[11\] _03275_ _03279_ samples_real\[1\]\[11\]
+ VSS VSS VDD VDD _03280_ sky130_fd_sc_hd__a22oi_1
X_11278_ _03273_ _03280_ VSS VSS VDD VDD _03281_ sky130_fd_sc_hd__nand2_1
X_11279_ _03243_ VSS VSS VDD VDD _03282_ sky130_fd_sc_hd__buf_8
X_11280_ _03282_ VSS VSS VDD VDD _03283_ sky130_fd_sc_hd__buf_12
X_11281_ net41 _03249_ VSS VSS VDD VDD _03284_ sky130_fd_sc_hd__nor2_2
X_11282_ _03284_ VSS VSS VDD VDD _03285_ sky130_fd_sc_hd__buf_6
X_11283_ net42 net41 VSS VSS VDD VDD _03286_ sky130_fd_sc_hd__nor2b_4
X_11284_ net510 VSS VSS VDD VDD _03287_ sky130_fd_sc_hd__clkbuf_8
X_11285_ samples_real\[6\]\[11\] _03285_ _03287_ samples_real\[3\]\[11\]
+ VSS VSS VDD VDD _03288_ sky130_fd_sc_hd__a22oi_1
X_11286_ _03235_ _03233_ VSS VSS VDD VDD _03289_ sky130_fd_sc_hd__and2_2
Xclone50 net51 VSS VSS VDD VDD net50 sky130_fd_sc_hd__buf_6
X_11288_ _03289_ VSS VSS VDD VDD _03291_ sky130_fd_sc_hd__buf_4
X_11289_ _03258_ VSS VSS VDD VDD _03292_ sky130_fd_sc_hd__buf_4
X_11290_ samples_real\[5\]\[11\] _03291_ _03292_ _03283_ VSS
+ VSS VDD VDD _03293_ sky130_fd_sc_hd__a211oi_1
X_11291_ _03283_ _03288_ _03293_ VSS VSS VDD VDD _03294_ sky130_fd_sc_hd__a21oi_1
X_11292_ samples_real\[0\]\[11\] _03265_ _03281_ _03294_ VSS
+ VSS VDD VDD _03295_ sky130_fd_sc_hd__o22a_4
X_11293_ _03247_ _03295_ VSS VSS VDD VDD _05911_ sky130_fd_sc_hd__nand2_2
X_11294_ _03283_ VSS VSS VDD VDD _03296_ sky130_fd_sc_hd__buf_12
X_11295_ _03296_ VSS VSS VDD VDD _03297_ sky130_fd_sc_hd__buf_12
X_11296_ samples_imag\[6\]\[11\] _03285_ _03287_ samples_imag\[3\]\[11\]
+ VSS VSS VDD VDD _03298_ sky130_fd_sc_hd__a22o_1
X_11297_ _03238_ VSS VSS VDD VDD _03299_ sky130_fd_sc_hd__buf_12
X_11298_ _03299_ VSS VSS VDD VDD _03300_ sky130_fd_sc_hd__buf_12
X_11299_ samples_imag\[4\]\[11\] samples_imag\[5\]\[11\] _03300_
+ VSS VSS VDD VDD _03301_ sky130_fd_sc_hd__mux2i_1
X_11300_ _03296_ net44 samples_imag\[7\]\[11\] VSS VSS VDD
+ VDD _03302_ sky130_fd_sc_hd__nand3_1
X_11301_ _03296_ _03301_ _03302_ VSS VSS VDD VDD _03303_ sky130_fd_sc_hd__o21ai_1
X_11302_ _03240_ VSS VSS VDD VDD _03304_ sky130_fd_sc_hd__buf_6
X_11303_ samples_imag\[1\]\[11\] VSS VSS VDD VDD _03305_ sky130_fd_sc_hd__inv_1
X_11304_ _03300_ samples_imag\[2\]\[11\] VSS VSS VDD VDD _03306_
+ sky130_fd_sc_hd__nand2b_1
X_11305_ _03300_ _03305_ _03296_ _03306_ _03304_ VSS VSS VDD
+ VDD _03307_ sky130_fd_sc_hd__a221oi_2
X_11306_ _03297_ _03298_ _03304_ _03303_ _03307_ VSS VSS VDD
+ VDD _03308_ sky130_fd_sc_hd__a221oi_4
X_11307_ _03265_ VSS VSS VDD VDD _03309_ sky130_fd_sc_hd__buf_6
X_11308_ _03309_ VSS VSS VDD VDD _03310_ sky130_fd_sc_hd__buf_6
X_11309_ samples_imag\[0\]\[11\] _03310_ VSS VSS VDD VDD _03311_
+ sky130_fd_sc_hd__nor2_2
X_11310_ _03248_ net497 _03311_ VSS VSS VDD VDD _05912_ sky130_fd_sc_hd__nor3_4
X_11311_ _00008_ VSS VSS VDD VDD _03312_ sky130_fd_sc_hd__clkbuf_4
X_11312_ _03312_ VSS VSS VDD VDD _03313_ sky130_fd_sc_hd__buf_6
X_11313_ _03309_ VSS VSS VDD VDD _03314_ sky130_fd_sc_hd__buf_6
X_11314_ _03249_ VSS VSS VDD VDD _03315_ sky130_fd_sc_hd__buf_4
X_11315_ _03243_ net42 VSS VSS VDD VDD _03316_ sky130_fd_sc_hd__and2_2
X_11316_ _03315_ samples_imag\[2\]\[10\] _03316_ samples_imag\[6\]\[10\]
+ VSS VSS VDD VDD _03317_ sky130_fd_sc_hd__a22oi_2
X_11317_ samples_imag\[5\]\[10\] _03291_ _03292_ VSS VSS VDD
+ VDD _03318_ sky130_fd_sc_hd__a21oi_1
X_11318_ _03286_ net46 VSS VSS VDD VDD _03319_ sky130_fd_sc_hd__and2_4
Xclone46 net493 VSS VSS VDD VDD net46 sky130_fd_sc_hd__buf_2
X_11320_ samples_imag\[1\]\[10\] _03279_ _03319_ samples_imag\[3\]\[10\]
+ VSS VSS VDD VDD _03321_ sky130_fd_sc_hd__a22o_4
X_11321_ samples_imag\[7\]\[10\] _03268_ _03272_ samples_imag\[4\]\[10\]
+ _03321_ VSS VSS VDD VDD _03322_ sky130_fd_sc_hd__a221oi_4
X_11322_ net44 _03317_ _03318_ _03297_ _03322_ VSS VSS VDD
+ VDD _03323_ sky130_fd_sc_hd__o221ai_4
X_11323_ _03314_ samples_imag\[0\]\[10\] _03323_ VSS VSS VDD
+ VDD _03324_ sky130_fd_sc_hd__o21ai_4
X_11324_ _03324_ VSS VSS VDD VDD _03325_ sky130_fd_sc_hd__inv_2
X_11325_ _03313_ net508 VSS VSS VDD VDD _05921_ sky130_fd_sc_hd__nand2_1
X_11326_ _05921_ VSS VSS VDD VDD _05913_ sky130_fd_sc_hd__inv_1
X_11327_ samples_imag\[7\]\[9\] _03266_ _03272_ samples_imag\[4\]\[9\]
+ VSS VSS VDD VDD _03326_ sky130_fd_sc_hd__a22oi_2
X_11328_ samples_imag\[2\]\[9\] _03275_ _03277_ samples_imag\[1\]\[9\]
+ VSS VSS VDD VDD _03327_ sky130_fd_sc_hd__a22oi_1
X_11329_ _03326_ _03327_ VSS VSS VDD VDD _03328_ sky130_fd_sc_hd__nand2_1
X_11330_ samples_imag\[6\]\[9\] _03285_ _03287_ samples_imag\[3\]\[9\]
+ VSS VSS VDD VDD _03329_ sky130_fd_sc_hd__a22oi_1
X_11331_ samples_imag\[5\]\[9\] _03289_ _03292_ _03282_ VSS
+ VSS VDD VDD _03330_ sky130_fd_sc_hd__a211oi_1
X_11332_ _03245_ _03329_ _03330_ VSS VSS VDD VDD _03331_ sky130_fd_sc_hd__a21oi_1
X_11333_ samples_imag\[0\]\[9\] net49 _03328_ _03331_ VSS
+ VSS VDD VDD _03332_ sky130_fd_sc_hd__o22a_4
X_11334_ _00008_ _03332_ VSS VSS VDD VDD _05922_ sky130_fd_sc_hd__nand2_2
X_11335_ _05922_ VSS VSS VDD VDD _05937_ sky130_fd_sc_hd__inv_1
X_11336_ _03247_ VSS VSS VDD VDD _03333_ sky130_fd_sc_hd__clkbuf_8
X_11337_ samples_real\[0\]\[10\] _03265_ VSS VSS VDD VDD _03334_
+ sky130_fd_sc_hd__nor2_2
X_11338_ _03237_ VSS VSS VDD VDD _03335_ sky130_fd_sc_hd__buf_4
X_11339_ samples_real\[2\]\[10\] samples_real\[6\]\[10\] _03240_
+ VSS VSS VDD VDD _03336_ sky130_fd_sc_hd__mux2i_1
X_11340_ samples_real\[7\]\[10\] _03289_ VSS VSS VDD VDD _03337_
+ sky130_fd_sc_hd__nand2_1
X_11341_ _03335_ _03336_ _03337_ VSS VSS VDD VDD _03338_ sky130_fd_sc_hd__o21ai_1
X_11342_ samples_real\[1\]\[10\] samples_real\[5\]\[10\] _03240_
+ VSS VSS VDD VDD _03339_ sky130_fd_sc_hd__mux2i_1
X_11343_ samples_real\[4\]\[10\] net476 VSS VSS VDD VDD _03340_
+ sky130_fd_sc_hd__nor2_1
X_11344_ net45 _03339_ _03340_ _03245_ VSS VSS VDD VDD _03341_
+ sky130_fd_sc_hd__a211oi_2
X_11345_ samples_real\[3\]\[10\] net465 _03245_ _03338_ _03341_
+ VSS VSS VDD VDD _03342_ sky130_fd_sc_hd__a221oi_4
X_11346_ _03334_ net462 VSS VSS VDD VDD _03343_ sky130_fd_sc_hd__nor2_1
X_11347_ _03333_ _03343_ VSS VSS VDD VDD _05994_ sky130_fd_sc_hd__nand2_1
X_11348_ _05994_ VSS VSS VDD VDD _05923_ sky130_fd_sc_hd__inv_1
X_11349_ samples_imag\[0\]\[8\] _03265_ VSS VSS VDD VDD _03344_
+ sky130_fd_sc_hd__nor2_2
X_11350_ _03243_ _03289_ VSS VSS VDD VDD _03345_ sky130_fd_sc_hd__nor2b_2
X_11351_ _03345_ VSS VSS VDD VDD _03346_ sky130_fd_sc_hd__clkbuf_4
X_11352_ samples_imag\[2\]\[8\] VSS VSS VDD VDD _03347_ sky130_fd_sc_hd__inv_1
X_11353_ _03282_ _03347_ _03335_ VSS VSS VDD VDD _03348_ sky130_fd_sc_hd__a21oi_1
X_11354_ _03282_ _03335_ samples_imag\[3\]\[8\] _03348_ VSS
+ VSS VDD VDD _03349_ sky130_fd_sc_hd__a31oi_1
X_11355_ samples_imag\[6\]\[8\] samples_imag\[7\]\[8\] _03236_
+ VSS VSS VDD VDD _03350_ sky130_fd_sc_hd__mux2_1
X_11356_ _03243_ _03237_ VSS VSS VDD VDD _03351_ sky130_fd_sc_hd__nor2_2
X_11357_ _03282_ _03350_ _03351_ samples_imag\[4\]\[8\] _03315_
+ VSS VSS VDD VDD _03352_ sky130_fd_sc_hd__a221oi_1
X_11358_ _03315_ _03349_ _03352_ VSS VSS VDD VDD _03353_ sky130_fd_sc_hd__a21oi_2
X_11359_ samples_imag\[1\]\[8\] _03279_ _03346_ samples_imag\[5\]\[8\]
+ _03353_ VSS VSS VDD VDD _03354_ sky130_fd_sc_hd__a221oi_4
X_11360_ _03248_ _03344_ net481 VSS VSS VDD VDD _05938_ sky130_fd_sc_hd__nor3_4
X_11361_ samples_imag\[6\]\[7\] _03285_ net510 samples_imag\[3\]\[7\]
+ VSS VSS VDD VDD _03355_ sky130_fd_sc_hd__a22o_1
X_11362_ samples_imag\[4\]\[7\] samples_imag\[5\]\[7\] _03237_
+ VSS VSS VDD VDD _03356_ sky130_fd_sc_hd__mux2i_1
X_11363_ _03244_ net469 samples_imag\[7\]\[7\] VSS VSS VDD
+ VDD _03357_ sky130_fd_sc_hd__nand3_1
X_11364_ _03244_ _03356_ _03357_ VSS VSS VDD VDD _03358_ sky130_fd_sc_hd__o21ai_2
X_11365_ samples_imag\[1\]\[7\] VSS VSS VDD VDD _03359_ sky130_fd_sc_hd__inv_1
X_11366_ net452 samples_imag\[2\]\[7\] VSS VSS VDD VDD _03360_
+ sky130_fd_sc_hd__nand2b_1
X_11367_ net469 _03359_ _03360_ _03244_ net50 VSS VSS VDD
+ VDD _03361_ sky130_fd_sc_hd__a221oi_2
X_11368_ _03355_ _03282_ _03358_ net50 _03361_ VSS VSS VDD
+ VDD _03362_ sky130_fd_sc_hd__a221oi_4
X_11369_ samples_imag\[0\]\[7\] _03263_ VSS VSS VDD VDD _03363_
+ sky130_fd_sc_hd__nor2_1
X_11370_ net438 _03363_ VSS VSS VDD VDD _03364_ sky130_fd_sc_hd__nor2_4
X_11371_ _03312_ _03364_ VSS VSS VDD VDD _06069_ sky130_fd_sc_hd__nand2_2
X_11372_ _06069_ VSS VSS VDD VDD _05980_ sky130_fd_sc_hd__inv_1
X_11373_ samples_imag\[7\]\[6\] _03268_ _03272_ samples_imag\[4\]\[6\]
+ VSS VSS VDD VDD _03365_ sky130_fd_sc_hd__a22oi_2
X_11374_ samples_imag\[2\]\[6\] _03275_ _03279_ samples_imag\[1\]\[6\]
+ VSS VSS VDD VDD _03366_ sky130_fd_sc_hd__a22oi_1
X_11375_ _03365_ _03366_ VSS VSS VDD VDD _03367_ sky130_fd_sc_hd__nand2_1
X_11376_ samples_imag\[6\]\[6\] _03285_ _03287_ samples_imag\[3\]\[6\]
+ VSS VSS VDD VDD _03368_ sky130_fd_sc_hd__a22oi_1
X_11377_ samples_imag\[5\]\[6\] _03291_ _03292_ _03296_ VSS
+ VSS VDD VDD _03369_ sky130_fd_sc_hd__a211oi_2
X_11378_ _03297_ _03368_ _03369_ VSS VSS VDD VDD _03370_ sky130_fd_sc_hd__a21oi_2
X_11379_ _03309_ samples_imag\[0\]\[6\] _03367_ _03370_ VSS
+ VSS VDD VDD _03371_ sky130_fd_sc_hd__o22a_4
X_11380_ _03313_ _03371_ VSS VSS VDD VDD _06070_ sky130_fd_sc_hd__nand2_2
X_11381_ _06070_ VSS VSS VDD VDD _06123_ sky130_fd_sc_hd__clkinvlp_4
X_11382_ samples_imag\[7\]\[4\] _03266_ _03272_ samples_imag\[4\]\[4\]
+ VSS VSS VDD VDD _03372_ sky130_fd_sc_hd__a22oi_2
X_11383_ samples_imag\[2\]\[4\] _03275_ _03277_ samples_imag\[1\]\[4\]
+ VSS VSS VDD VDD _03373_ sky130_fd_sc_hd__a22oi_1
X_11384_ _03372_ _03373_ VSS VSS VDD VDD _03374_ sky130_fd_sc_hd__nand2_1
X_11385_ samples_imag\[6\]\[4\] _03285_ _03287_ samples_imag\[3\]\[4\]
+ VSS VSS VDD VDD _03375_ sky130_fd_sc_hd__a22oi_1
X_11386_ samples_imag\[5\]\[4\] _03289_ _03292_ _03282_ VSS
+ VSS VDD VDD _03376_ sky130_fd_sc_hd__a211oi_1
X_11387_ _03245_ _03375_ _03376_ VSS VSS VDD VDD _03377_ sky130_fd_sc_hd__a21oi_1
X_11388_ samples_imag\[0\]\[4\] _03265_ _03374_ _03377_ VSS
+ VSS VDD VDD _03378_ sky130_fd_sc_hd__o22a_4
X_11389_ _03312_ net483 VSS VSS VDD VDD _07955_ sky130_fd_sc_hd__nand2_2
X_11390_ _07955_ VSS VSS VDD VDD _06175_ sky130_fd_sc_hd__inv_4
X_11391_ samples_real\[0\]\[9\] _03263_ VSS VSS VDD VDD _03379_
+ sky130_fd_sc_hd__nor2_1
X_11392_ samples_real\[2\]\[9\] VSS VSS VDD VDD _03380_ sky130_fd_sc_hd__inv_1
X_11393_ _03243_ _03380_ net43 VSS VSS VDD VDD _03381_ sky130_fd_sc_hd__a21oi_1
X_11394_ _03244_ net43 samples_real\[3\]\[9\] _03381_ VSS
+ VSS VDD VDD _03382_ sky130_fd_sc_hd__a31oi_1
X_11395_ samples_real\[6\]\[9\] samples_real\[7\]\[9\] _03236_
+ VSS VSS VDD VDD _03383_ sky130_fd_sc_hd__mux2_1
X_11396_ samples_real\[4\]\[9\] _03351_ _03383_ _03243_ _03315_
+ VSS VSS VDD VDD _03384_ sky130_fd_sc_hd__a221oi_1
X_11397_ _03315_ _03382_ _03384_ VSS VSS VDD VDD _03385_ sky130_fd_sc_hd__a21oi_1
X_11398_ samples_real\[1\]\[9\] net506 _03345_ samples_real\[5\]\[9\]
+ _03385_ VSS VSS VDD VDD _03386_ sky130_fd_sc_hd__a221oi_4
X_11399_ _03379_ net504 VSS VSS VDD VDD _03387_ sky130_fd_sc_hd__nor2_2
X_11400_ _00010_ _03387_ VSS VSS VDD VDD _05939_ sky130_fd_sc_hd__nand2_2
X_11401_ _03249_ samples_imag\[1\]\[5\] _03289_ samples_imag\[5\]\[5\]
+ VSS VSS VDD VDD _03388_ sky130_fd_sc_hd__a22oi_2
X_11402_ samples_imag\[6\]\[5\] _03316_ _03276_ VSS VSS VDD
+ VDD _03389_ sky130_fd_sc_hd__a21oi_1
X_11403_ _03271_ samples_imag\[4\]\[5\] _03274_ samples_imag\[2\]\[5\]
+ VSS VSS VDD VDD _03390_ sky130_fd_sc_hd__a22o_1
X_11404_ samples_imag\[7\]\[5\] _03266_ _03319_ samples_imag\[3\]\[5\]
+ _03390_ VSS VSS VDD VDD _03391_ sky130_fd_sc_hd__a221oi_4
X_11405_ _03244_ _03388_ _03389_ net451 _03391_ VSS VSS VDD
+ VDD _03392_ sky130_fd_sc_hd__o221ai_4
X_11406_ samples_imag\[0\]\[5\] _03263_ _03392_ VSS VSS VDD
+ VDD _03393_ sky130_fd_sc_hd__o21ai_4
X_11407_ _03248_ net502 VSS VSS VDD VDD _06124_ sky130_fd_sc_hd__nor2_4
X_11408_ samples_imag\[6\]\[3\] samples_imag\[7\]\[3\] _03335_
+ VSS VSS VDD VDD _03394_ sky130_fd_sc_hd__mux2i_1
X_11409_ samples_imag\[1\]\[3\] _03277_ VSS VSS VDD VDD _03395_
+ sky130_fd_sc_hd__nand2_1
X_11410_ _03256_ _03394_ _03395_ VSS VSS VDD VDD _03396_ sky130_fd_sc_hd__o21ai_1
X_11411_ samples_imag\[5\]\[3\] _03250_ _03251_ samples_imag\[3\]\[3\]
+ VSS VSS VDD VDD _03397_ sky130_fd_sc_hd__a22oi_1
X_11412_ samples_imag\[4\]\[3\] VSS VSS VDD VDD _03398_ sky130_fd_sc_hd__inv_1
X_11413_ _03240_ _03398_ _03244_ VSS VSS VDD VDD _03399_ sky130_fd_sc_hd__a21oi_1
X_11414_ _03315_ samples_imag\[2\]\[3\] _03399_ _03335_ VSS
+ VSS VDD VDD _03400_ sky130_fd_sc_hd__a211oi_1
X_11415_ _03299_ _03397_ _03400_ VSS VSS VDD VDD _03401_ sky130_fd_sc_hd__a21oi_1
X_11416_ samples_imag\[0\]\[3\] _03265_ _03396_ _03401_ VSS
+ VSS VDD VDD _03402_ sky130_fd_sc_hd__o22a_4
X_11417_ _03313_ _03402_ VSS VSS VDD VDD _06285_ sky130_fd_sc_hd__nand2_2
X_11418_ _06285_ VSS VSS VDD VDD _06235_ sky130_fd_sc_hd__clkinv_4
X_11419_ samples_imag\[2\]\[2\] samples_imag\[3\]\[2\] samples_imag\[6\]\[2\]
+ samples_imag\[7\]\[2\] _03236_ _03234_ VSS VSS VDD VDD _03403_
+ sky130_fd_sc_hd__mux4_1
X_11420_ samples_imag\[1\]\[2\] samples_imag\[5\]\[2\] _03234_
+ VSS VSS VDD VDD _03404_ sky130_fd_sc_hd__mux2i_1
X_11421_ samples_imag\[4\]\[2\] net458 VSS VSS VDD VDD _03405_
+ sky130_fd_sc_hd__nor2_1
X_11422_ _03237_ _03404_ _03405_ _03244_ VSS VSS VDD VDD _03406_
+ sky130_fd_sc_hd__a211oi_2
X_11423_ _03282_ _03403_ _03406_ VSS VSS VDD VDD _03407_ sky130_fd_sc_hd__a21oi_4
X_11424_ samples_imag\[0\]\[2\] _03263_ VSS VSS VDD VDD _03408_
+ sky130_fd_sc_hd__nor2_2
X_11425_ _03407_ _03408_ VSS VSS VDD VDD _03409_ sky130_fd_sc_hd__nor2_1
X_11426_ _00008_ _03409_ VSS VSS VDD VDD _06286_ sky130_fd_sc_hd__nand2_4
X_11427_ _06286_ VSS VSS VDD VDD _06501_ sky130_fd_sc_hd__inv_2
X_11428_ samples_real\[0\]\[8\] samples_real\[4\]\[8\] samples_real\[1\]\[8\]
+ samples_real\[5\]\[8\] _03234_ _03299_ VSS VSS VDD VDD _03410_
+ sky130_fd_sc_hd__mux4_1
X_11429_ samples_real\[2\]\[8\] samples_real\[3\]\[8\] samples_real\[6\]\[8\]
+ samples_real\[7\]\[8\] _03238_ _03304_ VSS VSS VDD VDD _03411_
+ sky130_fd_sc_hd__mux4_1
X_11430_ _03410_ _03411_ _03283_ VSS VSS VDD VDD _03412_ sky130_fd_sc_hd__mux2_4
X_11431_ _03247_ _03412_ VSS VSS VDD VDD _05958_ sky130_fd_sc_hd__and2_2
X_11432_ _05958_ VSS VSS VDD VDD _05981_ sky130_fd_sc_hd__inv_1
X_11433_ samples_imag\[0\]\[1\] samples_imag\[4\]\[1\] samples_imag\[1\]\[1\]
+ samples_imag\[5\]\[1\] _03240_ _03299_ VSS VSS VDD VDD _03413_
+ sky130_fd_sc_hd__mux4_1
X_11434_ samples_imag\[2\]\[1\] samples_imag\[3\]\[1\] samples_imag\[6\]\[1\]
+ samples_imag\[7\]\[1\] net469 _03304_ VSS VSS VDD VDD _03414_
+ sky130_fd_sc_hd__mux4_2
X_11435_ _03413_ _03414_ _03283_ VSS VSS VDD VDD _03415_ sky130_fd_sc_hd__mux2i_4
X_11436_ net499 _03312_ VSS VSS VDD VDD _06333_ sky130_fd_sc_hd__nand2b_4
X_11437_ _06333_ VSS VSS VDD VDD _07928_ sky130_fd_sc_hd__inv_4
X_11438_ _00009_ VSS VSS VDD VDD _03416_ sky130_fd_sc_hd__buf_2
X_11439_ samples_real\[7\]\[13\] _03266_ _03271_ samples_real\[4\]\[13\]
+ VSS VSS VDD VDD _03417_ sky130_fd_sc_hd__a22oi_2
X_11440_ samples_real\[2\]\[13\] _03274_ net482 samples_real\[1\]\[13\]
+ VSS VSS VDD VDD _03418_ sky130_fd_sc_hd__a22oi_1
X_11441_ _03417_ _03418_ VSS VSS VDD VDD _03419_ sky130_fd_sc_hd__nand2_1
X_11442_ samples_real\[6\]\[13\] _03285_ _03287_ samples_real\[3\]\[13\]
+ VSS VSS VDD VDD _03420_ sky130_fd_sc_hd__a22oi_1
X_11443_ samples_real\[5\]\[13\] _03289_ _03258_ _03244_ VSS
+ VSS VDD VDD _03421_ sky130_fd_sc_hd__a211oi_1
X_11444_ _03282_ _03420_ _03421_ VSS VSS VDD VDD _03422_ sky130_fd_sc_hd__a21oi_1
X_11445_ samples_real\[0\]\[13\] net49 _03419_ _03422_ VSS
+ VSS VDD VDD _03423_ sky130_fd_sc_hd__o22a_4
X_11446_ _03416_ _03423_ VSS VSS VDD VDD _05954_ sky130_fd_sc_hd__and2_0
X_11447_ samples_real\[7\]\[7\] _03266_ _03272_ samples_real\[4\]\[7\]
+ VSS VSS VDD VDD _03424_ sky130_fd_sc_hd__a22oi_2
X_11448_ samples_real\[2\]\[7\] _03275_ net482 samples_real\[1\]\[7\]
+ VSS VSS VDD VDD _03425_ sky130_fd_sc_hd__a22oi_1
X_11449_ _03424_ _03425_ VSS VSS VDD VDD _03426_ sky130_fd_sc_hd__nand2_1
X_11450_ samples_real\[6\]\[7\] _03285_ _03287_ samples_real\[3\]\[7\]
+ VSS VSS VDD VDD _03427_ sky130_fd_sc_hd__a22oi_1
X_11451_ samples_real\[5\]\[7\] _03291_ _03292_ _03245_ VSS
+ VSS VDD VDD _03428_ sky130_fd_sc_hd__a211oi_1
X_11452_ _03283_ _03427_ _03428_ VSS VSS VDD VDD _03429_ sky130_fd_sc_hd__a21oi_1
X_11453_ samples_real\[0\]\[7\] _03265_ _03426_ _03429_ VSS
+ VSS VDD VDD _03430_ sky130_fd_sc_hd__o22a_4
X_11454_ _00010_ _03430_ VSS VSS VDD VDD _05999_ sky130_fd_sc_hd__nand2_4
X_11455_ _05999_ VSS VSS VDD VDD _06002_ sky130_fd_sc_hd__clkinvlp_4
X_11456_ _00012_ VSS VSS VDD VDD _03431_ sky130_fd_sc_hd__clkbuf_4
X_11457_ _03431_ _03295_ VSS VSS VDD VDD _05995_ sky130_fd_sc_hd__nand2_1
X_11458_ _00010_ VSS VSS VDD VDD _03432_ sky130_fd_sc_hd__inv_6
X_11459_ _03315_ samples_real\[1\]\[6\] _03291_ samples_real\[5\]\[6\]
+ VSS VSS VDD VDD _03433_ sky130_fd_sc_hd__a22oi_1
X_11460_ _03297_ _03433_ VSS VSS VDD VDD _03434_ sky130_fd_sc_hd__nor2_1
X_11461_ samples_real\[6\]\[6\] _03316_ _03276_ VSS VSS VDD
+ VDD _03435_ sky130_fd_sc_hd__a21oi_1
X_11462_ net44 _03435_ VSS VSS VDD VDD _03436_ sky130_fd_sc_hd__nor2_1
X_11463_ _03275_ VSS VSS VDD VDD _03437_ sky130_fd_sc_hd__buf_4
X_11464_ samples_real\[4\]\[6\] _03272_ _03437_ samples_real\[2\]\[6\]
+ VSS VSS VDD VDD _03438_ sky130_fd_sc_hd__a22oi_1
X_11465_ _03319_ VSS VSS VDD VDD _03439_ sky130_fd_sc_hd__buf_6
X_11466_ samples_real\[7\]\[6\] _03268_ _03439_ samples_real\[3\]\[6\]
+ VSS VSS VDD VDD _03440_ sky130_fd_sc_hd__a22oi_1
X_11467_ _03438_ _03440_ VSS VSS VDD VDD _03441_ sky130_fd_sc_hd__nand2_1
X_11468_ _03441_ _03436_ _03434_ _03310_ samples_real\[0\]\[6\]
+ VSS VSS VDD VDD _03442_ sky130_fd_sc_hd__o32ai_4
X_11469_ _03432_ net455 VSS VSS VDD VDD _05962_ sky130_fd_sc_hd__nor2_4
X_11470_ _05962_ VSS VSS VDD VDD _06125_ sky130_fd_sc_hd__inv_1
X_11471_ _00011_ VSS VSS VDD VDD _03443_ sky130_fd_sc_hd__buf_2
X_11472_ samples_real\[2\]\[5\] samples_real\[3\]\[5\] samples_real\[6\]\[5\]
+ samples_real\[7\]\[5\] _03299_ _03304_ VSS VSS VDD VDD _03444_
+ sky130_fd_sc_hd__mux4_2
X_11473_ samples_real\[1\]\[5\] samples_real\[5\]\[5\] _03304_
+ VSS VSS VDD VDD _03445_ sky130_fd_sc_hd__mux2i_1
X_11474_ samples_real\[4\]\[5\] net477 VSS VSS VDD VDD _03446_
+ sky130_fd_sc_hd__nor2_1
X_11475_ net44 _03445_ _03446_ _03297_ VSS VSS VDD VDD _03447_
+ sky130_fd_sc_hd__a211oi_2
X_11476_ _03444_ _03297_ _03447_ VSS VSS VDD VDD _03448_ sky130_fd_sc_hd__a21oi_4
X_11477_ _03309_ VSS VSS VDD VDD _03449_ sky130_fd_sc_hd__buf_4
X_11478_ _03449_ samples_real\[0\]\[5\] VSS VSS VDD VDD _03450_
+ sky130_fd_sc_hd__nor2_8
X_11479_ _03450_ _03448_ VSS VSS VDD VDD _03451_ sky130_fd_sc_hd__nor2_4
X_11480_ _03443_ _03451_ VSS VSS VDD VDD _05963_ sky130_fd_sc_hd__and2_4
X_11481_ samples_imag\[2\]\[0\] samples_imag\[3\]\[0\] samples_imag\[6\]\[0\]
+ samples_imag\[7\]\[0\] net475 net446 VSS VSS VDD VDD _03452_
+ sky130_fd_sc_hd__mux4_1
X_11482_ net46 _03452_ VSS VSS VDD VDD _03453_ sky130_fd_sc_hd__nand2_1
X_11483_ samples_imag\[1\]\[0\] samples_imag\[5\]\[0\] net447
+ VSS VSS VDD VDD _03454_ sky130_fd_sc_hd__mux2i_1
X_11484_ samples_imag\[4\]\[0\] _03269_ VSS VSS VDD VDD _03455_
+ sky130_fd_sc_hd__nor2_1
X_11485_ net41 _03454_ _03455_ net494 VSS VSS VDD VDD _03456_
+ sky130_fd_sc_hd__a211o_1
X_11486_ samples_imag\[0\]\[0\] _03262_ VSS VSS VDD VDD _03457_
+ sky130_fd_sc_hd__nor2_1
X_11487_ _03453_ _03456_ _03457_ VSS VSS VDD VDD _03458_ sky130_fd_sc_hd__a21oi_4
X_11488_ _00008_ _03458_ VSS VSS VDD VDD _06367_ sky130_fd_sc_hd__nand2_4
X_11489_ _06367_ VSS VSS VDD VDD _06371_ sky130_fd_sc_hd__inv_2
X_11490_ _03416_ _03295_ VSS VSS VDD VDD _06081_ sky130_fd_sc_hd__and2_0
X_11491_ _03432_ _03450_ _03448_ VSS VSS VDD VDD _06095_ sky130_fd_sc_hd__nor3_4
X_11492_ _06095_ VSS VSS VDD VDD _06004_ sky130_fd_sc_hd__clkinv_2
X_11493_ samples_real\[2\]\[4\] samples_real\[3\]\[4\] samples_real\[6\]\[4\]
+ samples_real\[7\]\[4\] _03300_ _03304_ VSS VSS VDD VDD _03459_
+ sky130_fd_sc_hd__mux4_2
X_11494_ samples_real\[1\]\[4\] samples_real\[5\]\[4\] _03304_
+ VSS VSS VDD VDD _03460_ sky130_fd_sc_hd__mux2i_1
X_11495_ samples_real\[4\]\[4\] net477 VSS VSS VDD VDD _03461_
+ sky130_fd_sc_hd__nor2_1
X_11496_ _03300_ _03460_ _03297_ _03461_ VSS VSS VDD VDD _03462_
+ sky130_fd_sc_hd__a211oi_2
X_11497_ _03459_ _03297_ _03462_ VSS VSS VDD VDD _03463_ sky130_fd_sc_hd__a21oi_4
X_11498_ samples_real\[0\]\[4\] _03310_ VSS VSS VDD VDD _03464_
+ sky130_fd_sc_hd__nor2_2
X_11499_ _03432_ net442 _03464_ VSS VSS VDD VDD _06041_ sky130_fd_sc_hd__nor3_4
X_11500_ _06041_ VSS VSS VDD VDD _06017_ sky130_fd_sc_hd__inv_2
X_11501_ _03443_ VSS VSS VDD VDD _03465_ sky130_fd_sc_hd__clkbuf_4
X_11502_ _03309_ VSS VSS VDD VDD _03466_ sky130_fd_sc_hd__clkbuf_4
X_11503_ _03272_ VSS VSS VDD VDD _03467_ sky130_fd_sc_hd__buf_4
X_11504_ samples_real\[7\]\[3\] _03268_ _03467_ samples_real\[4\]\[3\]
+ VSS VSS VDD VDD _03468_ sky130_fd_sc_hd__a22oi_4
X_11505_ _03279_ VSS VSS VDD VDD _03469_ sky130_fd_sc_hd__clkbuf_4
X_11506_ samples_real\[2\]\[3\] _03437_ _03469_ samples_real\[1\]\[3\]
+ VSS VSS VDD VDD _03470_ sky130_fd_sc_hd__a22oi_1
X_11507_ _03468_ _03470_ VSS VSS VDD VDD _03471_ sky130_fd_sc_hd__nand2_1
X_11508_ samples_real\[6\]\[3\] _03285_ _03287_ samples_real\[3\]\[3\]
+ VSS VSS VDD VDD _03472_ sky130_fd_sc_hd__a22oi_1
X_11509_ samples_real\[5\]\[3\] _03291_ _03292_ _03296_ VSS
+ VSS VDD VDD _03473_ sky130_fd_sc_hd__a211oi_1
X_11510_ _03297_ _03472_ _03473_ VSS VSS VDD VDD _03474_ sky130_fd_sc_hd__a21oi_1
X_11511_ _03466_ samples_real\[0\]\[3\] _03471_ _03474_ VSS
+ VSS VDD VDD _03475_ sky130_fd_sc_hd__o22a_4
X_11512_ _03465_ _03475_ VSS VSS VDD VDD _06018_ sky130_fd_sc_hd__nand2_1
X_11513_ _06018_ VSS VSS VDD VDD _06031_ sky130_fd_sc_hd__inv_1
X_11514_ samples_real\[2\]\[2\] samples_real\[3\]\[2\] samples_real\[6\]\[2\]
+ samples_real\[7\]\[2\] net452 net51 VSS VSS VDD VDD _03476_
+ sky130_fd_sc_hd__mux4_2
X_11515_ samples_real\[1\]\[2\] samples_real\[5\]\[2\] _03234_
+ VSS VSS VDD VDD _03477_ sky130_fd_sc_hd__mux2i_1
X_11516_ samples_real\[4\]\[2\] net476 VSS VSS VDD VDD _03478_
+ sky130_fd_sc_hd__nor2_1
X_11517_ _03335_ _03477_ _03478_ _03282_ VSS VSS VDD VDD _03479_
+ sky130_fd_sc_hd__a211oi_1
X_11518_ _03245_ _03476_ _03479_ VSS VSS VDD VDD _03480_ sky130_fd_sc_hd__a21oi_4
X_11519_ samples_real\[0\]\[2\] net49 VSS VSS VDD VDD _03481_
+ sky130_fd_sc_hd__nor2_1
X_11520_ _03480_ _03481_ VSS VSS VDD VDD _03482_ sky130_fd_sc_hd__nor2_2
X_11521_ _03465_ _03482_ VSS VSS VDD VDD _06019_ sky130_fd_sc_hd__nand2_2
X_11522_ _06019_ VSS VSS VDD VDD _06200_ sky130_fd_sc_hd__inv_1
X_11523_ _03333_ _03475_ VSS VSS VDD VDD _06027_ sky130_fd_sc_hd__nand2_4
X_11524_ _06027_ VSS VSS VDD VDD _06199_ sky130_fd_sc_hd__clkinv_2
X_11525_ samples_real\[7\]\[1\] _03268_ _03467_ samples_real\[4\]\[1\]
+ VSS VSS VDD VDD _03483_ sky130_fd_sc_hd__a22oi_4
X_11526_ samples_real\[2\]\[1\] _03275_ _03279_ samples_real\[1\]\[1\]
+ VSS VSS VDD VDD _03484_ sky130_fd_sc_hd__a22oi_1
X_11527_ _03483_ _03484_ VSS VSS VDD VDD _03485_ sky130_fd_sc_hd__nand2_1
X_11528_ samples_real\[6\]\[1\] _03285_ _03287_ samples_real\[3\]\[1\]
+ VSS VSS VDD VDD _03486_ sky130_fd_sc_hd__a22oi_1
X_11529_ samples_real\[5\]\[1\] _03291_ _03292_ _03296_ VSS
+ VSS VDD VDD _03487_ sky130_fd_sc_hd__a211oi_2
X_11530_ _03297_ _03486_ _03487_ VSS VSS VDD VDD _03488_ sky130_fd_sc_hd__a21oi_1
X_11531_ samples_real\[0\]\[1\] _03449_ _03485_ _03488_ VSS
+ VSS VDD VDD _03489_ sky130_fd_sc_hd__o22a_4
X_11532_ _03465_ _03489_ VSS VSS VDD VDD _06028_ sky130_fd_sc_hd__nand2_1
X_11533_ _06028_ VSS VSS VDD VDD _06032_ sky130_fd_sc_hd__inv_1
X_11534_ _03333_ _03482_ VSS VSS VDD VDD _06046_ sky130_fd_sc_hd__nand2_1
X_11535_ _06046_ VSS VSS VDD VDD _06033_ sky130_fd_sc_hd__inv_2
X_11536_ samples_real\[2\]\[0\] samples_real\[3\]\[0\] samples_real\[6\]\[0\]
+ samples_real\[7\]\[0\] net41 net42 VSS VSS VDD VDD _03490_
+ sky130_fd_sc_hd__mux4_1
X_11537_ samples_real\[4\]\[0\] VSS VSS VDD VDD _03491_ sky130_fd_sc_hd__inv_1
X_11538_ samples_real\[1\]\[0\] samples_real\[5\]\[0\] net445
+ VSS VSS VDD VDD _03492_ sky130_fd_sc_hd__mux2i_1
X_11539_ _03491_ _03284_ _03492_ net41 net46 VSS VSS VDD VDD
+ _03493_ sky130_fd_sc_hd__a221oi_2
X_11540_ net46 _03490_ _03493_ VSS VSS VDD VDD _03494_ sky130_fd_sc_hd__a21oi_4
X_11541_ samples_real\[0\]\[0\] _03262_ VSS VSS VDD VDD _03495_
+ sky130_fd_sc_hd__nor2_4
X_11542_ _03494_ _03495_ VSS VSS VDD VDD _03496_ sky130_fd_sc_hd__nor2_1
X_11543_ _03465_ _03496_ VSS VSS VDD VDD _06047_ sky130_fd_sc_hd__nand2_1
X_11544_ _06047_ VSS VSS VDD VDD _06201_ sky130_fd_sc_hd__inv_1
X_11545_ _03333_ _03489_ VSS VSS VDD VDD _06434_ sky130_fd_sc_hd__nand2_2
X_11546_ _06434_ VSS VSS VDD VDD _06202_ sky130_fd_sc_hd__clkinv_2
X_11547_ samples_imag\[0\]\[13\] samples_imag\[4\]\[13\] samples_imag\[1\]\[13\]
+ samples_imag\[5\]\[13\] net51 net45 VSS VSS VDD VDD _03497_
+ sky130_fd_sc_hd__mux4_1
X_11548_ samples_imag\[2\]\[13\] samples_imag\[3\]\[13\] samples_imag\[6\]\[13\]
+ samples_imag\[7\]\[13\] net451 _03304_ VSS VSS VDD VDD _03498_
+ sky130_fd_sc_hd__mux4_1
X_11549_ _03497_ _03498_ _03283_ VSS VSS VDD VDD _03499_ sky130_fd_sc_hd__mux2i_4
X_11550_ _03248_ _03499_ VSS VSS VDD VDD _07939_ sky130_fd_sc_hd__nor2_1
X_11551_ _03333_ _03496_ VSS VSS VDD VDD _06465_ sky130_fd_sc_hd__nand2_2
X_11552_ _06465_ VSS VSS VDD VDD _06382_ sky130_fd_sc_hd__inv_2
X_11553_ _00009_ VSS VSS VDD VDD _03500_ sky130_fd_sc_hd__clkinvlp_4
X_11554_ _03500_ VSS VSS VDD VDD _03501_ sky130_fd_sc_hd__buf_4
X_11555_ _03501_ _03334_ net464 VSS VSS VDD VDD _06134_ sky130_fd_sc_hd__nor3_1
X_11556_ _03431_ _03412_ VSS VSS VDD VDD _06183_ sky130_fd_sc_hd__nand2_1
X_11557_ _03416_ _03412_ VSS VSS VDD VDD _06244_ sky130_fd_sc_hd__and2_0
X_11558_ _03416_ _03430_ VSS VSS VDD VDD _06294_ sky130_fd_sc_hd__and2_0
X_11559_ _03501_ net456 VSS VSS VDD VDD _06341_ sky130_fd_sc_hd__nor2_1
X_11560_ _03463_ _03464_ VSS VSS VDD VDD _03502_ sky130_fd_sc_hd__nor2_2
X_11561_ _03431_ _03502_ VSS VSS VDD VDD _06378_ sky130_fd_sc_hd__nand2_1
X_11562_ _03431_ _03482_ VSS VSS VDD VDD _06435_ sky130_fd_sc_hd__nand2_1
X_11563_ _03501_ net468 _03464_ VSS VSS VDD VDD _08051_ sky130_fd_sc_hd__nor3_1
X_11564_ _03431_ _03489_ VSS VSS VDD VDD _06466_ sky130_fd_sc_hd__nand2_1
X_11565_ _03416_ _03489_ VSS VSS VDD VDD _08082_ sky130_fd_sc_hd__and2_0
X_11566_ _00012_ VSS VSS VDD VDD _03503_ sky130_fd_sc_hd__inv_2
X_11567_ _03503_ VSS VSS VDD VDD _03504_ sky130_fd_sc_hd__buf_4
X_11568_ _03504_ _03494_ _03495_ VSS VSS VDD VDD _08083_ sky130_fd_sc_hd__nor3_1
X_11569_ _08069_ _07956_ VSS VSS VDD VDD _06471_ sky130_fd_sc_hd__and2_0
X_11570_ _03500_ _03494_ _03495_ VSS VSS VDD VDD _08120_ sky130_fd_sc_hd__nor3_4
X_11571_ _08108_ VSS VSS VDD VDD _06331_ sky130_fd_sc_hd__inv_1
X_11572_ _08108_ _08112_ VSS VSS VDD VDD _06518_ sky130_fd_sc_hd__nor2b_1
X_11573_ _08106_ _08124_ VSS VSS VDD VDD _03505_ sky130_fd_sc_hd__nand2_2
X_11574_ _08126_ _08130_ _08116_ VSS VSS VDD VDD _03506_ sky130_fd_sc_hd__nand3_1
X_11575_ _08129_ _06367_ VSS VSS VDD VDD _03507_ sky130_fd_sc_hd__xnor2_1
X_11576_ _08116_ _08123_ _08115_ VSS VSS VDD VDD _03508_ sky130_fd_sc_hd__a21o_1
X_11577_ _03508_ _08106_ _08105_ VSS VSS VDD VDD _03509_ sky130_fd_sc_hd__a21oi_4
X_11578_ _08120_ _03506_ _03505_ _03507_ _03509_ VSS VSS VDD
+ VDD _03510_ sky130_fd_sc_hd__o41ai_4
X_11579_ _08096_ _03510_ _08095_ VSS VSS VDD VDD _03511_ sky130_fd_sc_hd__a21o_1
X_11580_ _08071_ _03511_ _08070_ VSS VSS VDD VDD _03512_ sky130_fd_sc_hd__a21oi_2
X_11581_ _03512_ _08060_ VSS VSS VDD VDD _03513_ sky130_fd_sc_hd__nor2b_1
X_11582_ _03513_ _08059_ _08047_ VSS VSS VDD VDD _03514_ sky130_fd_sc_hd__o21ai_1
X_11583_ _08046_ _03514_ VSS VSS VDD VDD _03515_ sky130_fd_sc_hd__nand2b_1
X_11584_ _03515_ _08028_ _08027_ VSS VSS VDD VDD _03516_ sky130_fd_sc_hd__a21oi_2
X_11585_ _03516_ _08013_ VSS VSS VDD VDD _03517_ sky130_fd_sc_hd__nor2b_1
X_11586_ _03517_ _08012_ _08003_ VSS VSS VDD VDD _03518_ sky130_fd_sc_hd__o21ai_1
X_11587_ _08002_ _03518_ VSS VSS VDD VDD _03519_ sky130_fd_sc_hd__nand2b_1
X_11588_ _03519_ _07994_ _07993_ VSS VSS VDD VDD _03520_ sky130_fd_sc_hd__a21oi_4
X_11589_ _03494_ _03495_ _00016_ VSS VSS VDD VDD _03521_ sky130_fd_sc_hd__o21ai_0
X_11590_ _03458_ _00017_ VSS VSS VDD VDD _03522_ sky130_fd_sc_hd__nor2b_1
X_11591_ _03521_ _03522_ VSS VSS VDD VDD _03523_ sky130_fd_sc_hd__xnor2_1
X_11592_ samples_real\[6\]\[14\] samples_real\[7\]\[14\] net43
+ VSS VSS VDD VDD _03524_ sky130_fd_sc_hd__mux2i_1
X_11593_ _03256_ _03524_ VSS VSS VDD VDD _03525_ sky130_fd_sc_hd__nor2_1
X_11594_ samples_real\[1\]\[14\] net482 _03525_ VSS VSS VDD
+ VDD _03526_ sky130_fd_sc_hd__a21oi_1
X_11595_ samples_real\[2\]\[14\] VSS VSS VDD VDD _03527_ sky130_fd_sc_hd__inv_1
X_11596_ _03315_ samples_real\[4\]\[14\] VSS VSS VDD VDD _03528_
+ sky130_fd_sc_hd__nor2_1
X_11597_ net51 _03527_ _03528_ _03244_ VSS VSS VDD VDD _03529_
+ sky130_fd_sc_hd__o22ai_1
X_11598_ samples_real\[5\]\[14\] _03250_ _03251_ samples_real\[3\]\[14\]
+ VSS VSS VDD VDD _03530_ sky130_fd_sc_hd__a22oi_1
X_11599_ _03335_ _03530_ VSS VSS VDD VDD _03531_ sky130_fd_sc_hd__nand2_1
X_11600_ _03335_ _03529_ _03531_ VSS VSS VDD VDD _03532_ sky130_fd_sc_hd__o21ai_1
X_11601_ samples_real\[0\]\[14\] net49 VSS VSS VDD VDD _03533_
+ sky130_fd_sc_hd__nor2_1
X_11602_ _03526_ _03532_ _03533_ VSS VSS VDD VDD _03534_ sky130_fd_sc_hd__a21oi_4
X_11603_ _00012_ _03534_ VSS VSS VDD VDD _03535_ sky130_fd_sc_hd__nand2_1
X_11604_ _07938_ _03535_ VSS VSS VDD VDD _03536_ sky130_fd_sc_hd__xor2_1
X_11605_ _03523_ _03536_ VSS VSS VDD VDD _03537_ sky130_fd_sc_hd__xnor2_1
X_11606_ _06124_ _06286_ VSS VSS VDD VDD _03538_ sky130_fd_sc_hd__xor2_1
X_11607_ _05939_ _03538_ VSS VSS VDD VDD _03539_ sky130_fd_sc_hd__xnor2_1
X_11608_ _03537_ _03539_ VSS VSS VDD VDD _03540_ sky130_fd_sc_hd__xnor2_1
X_11609_ _05911_ _03540_ VSS VSS VDD VDD _03541_ sky130_fd_sc_hd__xnor2_1
X_11610_ _03246_ _03423_ VSS VSS VDD VDD _03542_ sky130_fd_sc_hd__xor2_1
X_11611_ _03343_ _03542_ VSS VSS VDD VDD _03543_ sky130_fd_sc_hd__xnor2_1
X_11612_ _03247_ _03543_ VSS VSS VDD VDD _03544_ sky130_fd_sc_hd__nand2_1
X_11613_ _03335_ samples_real\[5\]\[15\] VSS VSS VDD VDD _03545_
+ sky130_fd_sc_hd__nand2_1
X_11614_ samples_real\[6\]\[15\] samples_real\[7\]\[15\] net43
+ VSS VSS VDD VDD _03546_ sky130_fd_sc_hd__mux2_1
X_11615_ _03245_ _03546_ VSS VSS VDD VDD _03547_ sky130_fd_sc_hd__nand2_1
X_11616_ _03245_ _03545_ _03547_ VSS VSS VDD VDD _03548_ sky130_fd_sc_hd__o21ai_1
X_11617_ samples_real\[2\]\[15\] samples_real\[3\]\[15\] net451
+ VSS VSS VDD VDD _03549_ sky130_fd_sc_hd__mux2_1
X_11618_ samples_real\[4\]\[15\] VSS VSS VDD VDD _03550_ sky130_fd_sc_hd__inv_1
X_11619_ net50 _03550_ _03335_ VSS VSS VDD VDD _03551_ sky130_fd_sc_hd__a21oi_1
X_11620_ _03315_ samples_real\[1\]\[15\] _03551_ VSS VSS VDD
+ VDD _03552_ sky130_fd_sc_hd__a21oi_1
X_11621_ _03245_ _03552_ VSS VSS VDD VDD _03553_ sky130_fd_sc_hd__nor2_1
X_11622_ _03304_ _03548_ _03549_ _03251_ _03553_ VSS VSS VDD
+ VDD _03554_ sky130_fd_sc_hd__a221oi_4
X_11623_ samples_real\[0\]\[15\] _03265_ _00009_ VSS VSS VDD
+ VDD _03555_ sky130_fd_sc_hd__o21ai_0
X_11624_ _03554_ _03555_ VSS VSS VDD VDD _03556_ sky130_fd_sc_hd__nor2_1
X_11625_ _00016_ _00017_ VSS VSS VDD VDD _03557_ sky130_fd_sc_hd__xor2_2
X_11626_ _06212_ _05992_ VSS VSS VDD VDD _03558_ sky130_fd_sc_hd__xnor2_2
X_11627_ _06109_ _06155_ VSS VSS VDD VDD _03559_ sky130_fd_sc_hd__xnor2_1
X_11628_ _03559_ _03558_ VSS VSS VDD VDD _03560_ sky130_fd_sc_hd__xnor2_2
X_11629_ _03557_ _03560_ VSS VSS VDD VDD _03561_ sky130_fd_sc_hd__xnor2_2
X_11630_ _03556_ _03561_ VSS VSS VDD VDD _03562_ sky130_fd_sc_hd__xnor2_1
X_11631_ _05922_ _06069_ VSS VSS VDD VDD _03563_ sky130_fd_sc_hd__xnor2_1
X_11632_ _03562_ _03563_ VSS VSS VDD VDD _03564_ sky130_fd_sc_hd__xnor2_1
X_11633_ _03544_ _03564_ VSS VSS VDD VDD _03565_ sky130_fd_sc_hd__xnor2_1
X_11634_ _03565_ _03541_ VSS VSS VDD VDD _03566_ sky130_fd_sc_hd__xnor2_1
X_11635_ _05928_ _05950_ VSS VSS VDD VDD _03567_ sky130_fd_sc_hd__xnor2_1
X_11636_ _07987_ _07924_ VSS VSS VDD VDD _03568_ sky130_fd_sc_hd__xnor2_1
X_11637_ _03567_ _03568_ VSS VSS VDD VDD _03569_ sky130_fd_sc_hd__xnor2_1
X_11638_ _06020_ _06053_ VSS VSS VDD VDD _03570_ sky130_fd_sc_hd__xnor2_1
X_11639_ _07929_ _06007_ VSS VSS VDD VDD _03571_ sky130_fd_sc_hd__xnor2_1
X_11640_ _03570_ _03571_ VSS VSS VDD VDD _03572_ sky130_fd_sc_hd__xnor2_1
X_11641_ _03569_ _03572_ VSS VSS VDD VDD _03573_ sky130_fd_sc_hd__xnor2_1
X_11642_ _07940_ _06015_ VSS VSS VDD VDD _03574_ sky130_fd_sc_hd__xnor2_1
X_11643_ _07942_ _07945_ VSS VSS VDD VDD _03575_ sky130_fd_sc_hd__xnor2_1
X_11644_ _03574_ _03575_ VSS VSS VDD VDD _03576_ sky130_fd_sc_hd__xnor2_1
X_11645_ _03573_ _03576_ VSS VSS VDD VDD _03577_ sky130_fd_sc_hd__xnor2_1
X_11646_ _05999_ _03577_ VSS VSS VDD VDD _03578_ sky130_fd_sc_hd__xnor2_1
X_11647_ _05932_ _05959_ VSS VSS VDD VDD _03579_ sky130_fd_sc_hd__xnor2_1
X_11648_ _06035_ _05919_ VSS VSS VDD VDD _03580_ sky130_fd_sc_hd__xnor2_1
X_11649_ _03579_ _03580_ VSS VSS VDD VDD _03581_ sky130_fd_sc_hd__xnor2_1
X_11650_ _07932_ _07968_ VSS VSS VDD VDD _03582_ sky130_fd_sc_hd__xnor2_1
X_11651_ _05914_ _07923_ VSS VSS VDD VDD _03583_ sky130_fd_sc_hd__xnor2_1
X_11652_ _03582_ _03583_ VSS VSS VDD VDD _03584_ sky130_fd_sc_hd__xnor2_1
X_11653_ _03581_ _03584_ VSS VSS VDD VDD _03585_ sky130_fd_sc_hd__xnor2_1
X_11654_ _06057_ _06089_ VSS VSS VDD VDD _03586_ sky130_fd_sc_hd__xor2_1
X_11655_ _06025_ _06038_ VSS VSS VDD VDD _03587_ sky130_fd_sc_hd__xnor2_1
X_11656_ _03586_ _03587_ VSS VSS VDD VDD _03588_ sky130_fd_sc_hd__xnor2_1
X_11657_ _05967_ _05971_ VSS VSS VDD VDD _03589_ sky130_fd_sc_hd__xnor2_1
X_11658_ _06104_ _05964_ VSS VSS VDD VDD _03590_ sky130_fd_sc_hd__xnor2_1
X_11659_ _03589_ _03590_ VSS VSS VDD VDD _03591_ sky130_fd_sc_hd__xnor2_1
X_11660_ _03588_ _03591_ VSS VSS VDD VDD _03592_ sky130_fd_sc_hd__xnor2_1
X_11661_ _03585_ _03592_ VSS VSS VDD VDD _03593_ sky130_fd_sc_hd__xnor2_1
X_11662_ _03443_ _03412_ VSS VSS VDD VDD _03594_ sky130_fd_sc_hd__nand2_1
X_11663_ _03593_ _03594_ VSS VSS VDD VDD _03595_ sky130_fd_sc_hd__xnor2_1
X_11664_ _03578_ _03595_ VSS VSS VDD VDD _03596_ sky130_fd_sc_hd__xnor2_1
X_11665_ _03315_ samples_imag\[2\]\[14\] _03316_ samples_imag\[6\]\[14\]
+ VSS VSS VDD VDD _03597_ sky130_fd_sc_hd__a22oi_2
X_11666_ samples_imag\[5\]\[14\] _03291_ _03292_ VSS VSS VDD
+ VDD _03598_ sky130_fd_sc_hd__a21oi_1
X_11667_ samples_imag\[4\]\[14\] _03271_ _03319_ samples_imag\[3\]\[14\]
+ VSS VSS VDD VDD _03599_ sky130_fd_sc_hd__a22o_1
X_11668_ samples_imag\[7\]\[14\] _03266_ _03279_ samples_imag\[1\]\[14\]
+ _03599_ VSS VSS VDD VDD _03600_ sky130_fd_sc_hd__a221oi_2
X_11669_ net45 _03597_ _03598_ _03283_ _03600_ VSS VSS VDD
+ VDD _03601_ sky130_fd_sc_hd__o221ai_4
X_11670_ samples_imag\[0\]\[14\] _03265_ _03601_ VSS VSS VDD
+ VDD _03602_ sky130_fd_sc_hd__o21ai_2
X_11671_ _03499_ _03602_ VSS VSS VDD VDD _03603_ sky130_fd_sc_hd__xor2_1
X_11672_ _03312_ _03603_ VSS VSS VDD VDD _03604_ sky130_fd_sc_hd__nand2_1
X_11673_ _03596_ _03604_ VSS VSS VDD VDD _03605_ sky130_fd_sc_hd__xnor2_1
X_11674_ _03605_ _03566_ VSS VSS VDD VDD _03606_ sky130_fd_sc_hd__xnor2_1
X_11675_ _03520_ _03606_ VSS VSS VDD VDD _00018_ sky130_fd_sc_hd__xnor2_1
X_11676_ _03465_ _03458_ VSS VSS VDD VDD _06886_ sky130_fd_sc_hd__nand2_2
X_11677_ _06886_ VSS VSS VDD VDD _08131_ sky130_fd_sc_hd__clkinvlp_4
X_11678_ _00008_ _03423_ VSS VSS VDD VDD _08132_ sky130_fd_sc_hd__and2_1
X_11679_ net498 _03443_ VSS VSS VDD VDD _06531_ sky130_fd_sc_hd__nor2b_2
X_11680_ _06531_ VSS VSS VDD VDD _06829_ sky130_fd_sc_hd__inv_1
X_11681_ _03407_ _03408_ _03432_ VSS VSS VDD VDD _06713_ sky130_fd_sc_hd__nor3_4
X_11682_ net440 _03432_ VSS VSS VDD VDD _06526_ sky130_fd_sc_hd__nor2_8
X_11683_ _06526_ VSS VSS VDD VDD _06661_ sky130_fd_sc_hd__clkinv_2
X_11684_ _03465_ _03409_ VSS VSS VDD VDD _06662_ sky130_fd_sc_hd__nand2_2
X_11685_ _06662_ VSS VSS VDD VDD _06527_ sky130_fd_sc_hd__inv_1
X_11686_ _03443_ _03402_ VSS VSS VDD VDD _06598_ sky130_fd_sc_hd__nand2_2
X_11687_ _06598_ VSS VSS VDD VDD _06528_ sky130_fd_sc_hd__inv_1
X_11688_ _03465_ _03378_ VSS VSS VDD VDD _06563_ sky130_fd_sc_hd__nand2_1
X_11689_ _03393_ VSS VSS VDD VDD _03607_ sky130_fd_sc_hd__inv_2
X_11690_ _03247_ net461 VSS VSS VDD VDD _06564_ sky130_fd_sc_hd__nand2_8
X_11691_ _06564_ VSS VSS VDD VDD _06775_ sky130_fd_sc_hd__inv_1
X_11692_ _03247_ _03378_ VSS VSS VDD VDD _06535_ sky130_fd_sc_hd__and2_1
X_11693_ _06535_ VSS VSS VDD VDD _06599_ sky130_fd_sc_hd__inv_2
X_11694_ _03443_ _03607_ VSS VSS VDD VDD _06536_ sky130_fd_sc_hd__and2_4
X_11695_ _06536_ VSS VSS VDD VDD _06607_ sky130_fd_sc_hd__inv_1
X_11696_ _03333_ _03371_ VSS VSS VDD VDD _06608_ sky130_fd_sc_hd__nand2_4
X_11697_ _06608_ VSS VSS VDD VDD _06537_ sky130_fd_sc_hd__inv_4
X_11698_ _03246_ _03312_ VSS VSS VDD VDD _06643_ sky130_fd_sc_hd__nand2b_2
X_11699_ _06643_ VSS VSS VDD VDD _06646_ sky130_fd_sc_hd__inv_1
X_11700_ _03443_ _03371_ VSS VSS VDD VDD _08137_ sky130_fd_sc_hd__and2_0
X_11701_ _08137_ VSS VSS VDD VDD _06576_ sky130_fd_sc_hd__inv_1
X_11702_ _03333_ _03364_ VSS VSS VDD VDD _06577_ sky130_fd_sc_hd__nand2_2
X_11703_ _06577_ VSS VSS VDD VDD _06721_ sky130_fd_sc_hd__inv_1
X_11704_ _03465_ _03364_ VSS VSS VDD VDD _06550_ sky130_fd_sc_hd__nand2_1
X_11705_ _03344_ net479 VSS VSS VDD VDD _03608_ sky130_fd_sc_hd__nor2_1
X_11706_ _03333_ _03608_ VSS VSS VDD VDD _06551_ sky130_fd_sc_hd__nand2_2
X_11707_ _06551_ VSS VSS VDD VDD _06722_ sky130_fd_sc_hd__inv_1
X_11708_ _03333_ _03332_ VSS VSS VDD VDD _06552_ sky130_fd_sc_hd__nand2_2
X_11709_ _06552_ VSS VSS VDD VDD _06545_ sky130_fd_sc_hd__inv_1
X_11710_ _03247_ _03325_ VSS VSS VDD VDD _06610_ sky130_fd_sc_hd__nand2_2
X_11711_ _06610_ VSS VSS VDD VDD _06546_ sky130_fd_sc_hd__inv_2
X_11712_ _03432_ _03311_ net495 VSS VSS VDD VDD _06547_ sky130_fd_sc_hd__nor3_4
X_11713_ _03432_ _03261_ _03264_ VSS VSS VDD VDD _06555_ sky130_fd_sc_hd__nor3_1
X_11714_ _03313_ _03295_ VSS VSS VDD VDD _06630_ sky130_fd_sc_hd__nand2_2
X_11715_ _06630_ VSS VSS VDD VDD _06693_ sky130_fd_sc_hd__inv_1
X_11716_ _03504_ _03499_ VSS VSS VDD VDD _08141_ sky130_fd_sc_hd__nor2_1
X_11717_ _03501_ _03602_ VSS VSS VDD VDD _08142_ sky130_fd_sc_hd__nor2_1
X_11718_ _03480_ _03248_ _03481_ VSS VSS VDD VDD _06729_ sky130_fd_sc_hd__nor3_4
X_11719_ _03312_ _03489_ VSS VSS VDD VDD _06778_ sky130_fd_sc_hd__and2_4
X_11720_ net467 _03464_ _03248_ VSS VSS VDD VDD _08146_ sky130_fd_sc_hd__nor3_4
X_11721_ net471 VSS VSS VDD VDD _06853_ sky130_fd_sc_hd__inv_4
X_11722_ net463 _03334_ _03248_ VSS VSS VDD VDD _06631_ sky130_fd_sc_hd__nor3_4
X_11723_ _03248_ _03494_ _03495_ VSS VSS VDD VDD _06833_ sky130_fd_sc_hd__nor3_4
X_11724_ _03313_ _03475_ VSS VSS VDD VDD _06903_ sky130_fd_sc_hd__nand2_4
X_11725_ _06903_ VSS VSS VDD VDD _06991_ sky130_fd_sc_hd__clkinv_4
X_11726_ _03313_ _03451_ VSS VSS VDD VDD _06797_ sky130_fd_sc_hd__nand2_4
X_11727_ _06797_ VSS VSS VDD VDD _06986_ sky130_fd_sc_hd__inv_2
X_11728_ _03312_ _03430_ VSS VSS VDD VDD _08156_ sky130_fd_sc_hd__and2_2
X_11729_ _08156_ VSS VSS VDD VDD _06697_ sky130_fd_sc_hd__inv_2
X_11730_ _03313_ _03412_ VSS VSS VDD VDD _06698_ sky130_fd_sc_hd__nand2_4
X_11731_ _06698_ VSS VSS VDD VDD _06648_ sky130_fd_sc_hd__inv_2
X_11732_ _03434_ _03436_ _03441_ _03310_ samples_real\[0\]\[6\]
+ VSS VSS VDD VDD _03609_ sky130_fd_sc_hd__o32a_4
X_11733_ _03313_ _03609_ VSS VSS VDD VDD _06749_ sky130_fd_sc_hd__nand2_4
X_11734_ _06749_ VSS VSS VDD VDD _06943_ sky130_fd_sc_hd__clkinv_2
X_11735_ _03313_ _03387_ VSS VSS VDD VDD _06635_ sky130_fd_sc_hd__nand2_2
X_11736_ _06635_ VSS VSS VDD VDD _06632_ sky130_fd_sc_hd__inv_2
X_11737_ _08335_ _06833_ VSS VSS VDD VDD _08336_ sky130_fd_sc_hd__and2_0
X_11738_ _07103_ _08327_ _08329_ _08331_ VSS VSS VDD VDD _03610_
+ sky130_fd_sc_hd__nand4b_1
X_11739_ _08338_ _06833_ _08337_ VSS VSS VDD VDD _03611_ sky130_fd_sc_hd__a21oi_1
X_11740_ _03610_ _03611_ VSS VSS VDD VDD _03612_ sky130_fd_sc_hd__nor2_1
X_11741_ _08320_ _08266_ _08296_ VSS VSS VDD VDD _03613_ sky130_fd_sc_hd__and3_1
X_11742_ _08326_ _03612_ _03613_ _08284_ _08313_ VSS VSS VDD
+ VDD _03614_ sky130_fd_sc_hd__o2111ai_4
X_11743_ _08319_ _08313_ _08312_ VSS VSS VDD VDD _03615_ sky130_fd_sc_hd__a21oi_1
X_11744_ _03615_ _08296_ VSS VSS VDD VDD _03616_ sky130_fd_sc_hd__nor2b_1
X_11745_ _08295_ _03616_ _08284_ VSS VSS VDD VDD _03617_ sky130_fd_sc_hd__o21ai_1
X_11746_ _08283_ _03617_ VSS VSS VDD VDD _03618_ sky130_fd_sc_hd__nand2b_1
X_11747_ _08266_ _03618_ _08265_ VSS VSS VDD VDD _03619_ sky130_fd_sc_hd__a21oi_2
X_11748_ _03614_ _03619_ _08252_ VSS VSS VDD VDD _03620_ sky130_fd_sc_hd__a21boi_0
X_11749_ _08251_ _03620_ _08238_ VSS VSS VDD VDD _03621_ sky130_fd_sc_hd__o21ai_1
X_11750_ _08237_ _03621_ VSS VSS VDD VDD _03622_ sky130_fd_sc_hd__nand2b_1
X_11751_ _03622_ _08223_ _08222_ VSS VSS VDD VDD _03623_ sky130_fd_sc_hd__a21oi_2
X_11752_ _03312_ _03534_ VSS VSS VDD VDD _03624_ sky130_fd_sc_hd__nand2_1
X_11753_ _03458_ _00016_ VSS VSS VDD VDD _03625_ sky130_fd_sc_hd__nor2b_1
X_11754_ _03624_ _03625_ VSS VSS VDD VDD _03626_ sky130_fd_sc_hd__xnor2_1
X_11755_ _03503_ _03602_ VSS VSS VDD VDD _03627_ sky130_fd_sc_hd__nor2_1
X_11756_ _03443_ _03608_ VSS VSS VDD VDD _03628_ sky130_fd_sc_hd__nand2_1
X_11757_ _03627_ _03628_ VSS VSS VDD VDD _03629_ sky130_fd_sc_hd__xnor2_1
X_11758_ _03626_ _03629_ VSS VSS VDD VDD _03630_ sky130_fd_sc_hd__xnor2_1
X_11759_ _08168_ _06702_ VSS VSS VDD VDD _03631_ sky130_fd_sc_hd__xor2_1
X_11760_ _06691_ _06705_ VSS VSS VDD VDD _03632_ sky130_fd_sc_hd__xnor2_1
X_11761_ _03631_ _03632_ VSS VSS VDD VDD _03633_ sky130_fd_sc_hd__xnor2_1
X_11762_ _08143_ _06628_ VSS VSS VDD VDD _03634_ sky130_fd_sc_hd__xnor2_1
X_11763_ _08133_ _08136_ VSS VSS VDD VDD _03635_ sky130_fd_sc_hd__xnor2_1
X_11764_ _03634_ _03635_ VSS VSS VDD VDD _03636_ sky130_fd_sc_hd__xnor2_1
X_11765_ _03633_ _03636_ VSS VSS VDD VDD _03637_ sky130_fd_sc_hd__xnor2_1
X_11766_ _06587_ _06619_ VSS VSS VDD VDD _03638_ sky130_fd_sc_hd__xor2_1
X_11767_ _06561_ _06574_ VSS VSS VDD VDD _03639_ sky130_fd_sc_hd__xnor2_1
X_11768_ _03638_ _03639_ VSS VSS VDD VDD _03640_ sky130_fd_sc_hd__xnor2_1
X_11769_ _06529_ _08139_ VSS VSS VDD VDD _03641_ sky130_fd_sc_hd__xnor2_1
X_11770_ _08197_ _06549_ VSS VSS VDD VDD _03642_ sky130_fd_sc_hd__xnor2_1
X_11771_ _03641_ _03642_ VSS VSS VDD VDD _03643_ sky130_fd_sc_hd__xnor2_1
X_11772_ _03640_ _03643_ VSS VSS VDD VDD _03644_ sky130_fd_sc_hd__xnor2_1
X_11773_ _03637_ _03644_ VSS VSS VDD VDD _03645_ sky130_fd_sc_hd__xnor2_1
X_11774_ _06591_ _06556_ VSS VSS VDD VDD _03646_ sky130_fd_sc_hd__xor2_1
X_11775_ _06553_ _06543_ VSS VSS VDD VDD _03647_ sky130_fd_sc_hd__xnor2_1
X_11776_ _03646_ _03647_ VSS VSS VDD VDD _03648_ sky130_fd_sc_hd__xnor2_1
X_11777_ _08159_ _08158_ VSS VSS VDD VDD _03649_ sky130_fd_sc_hd__xnor2_1
X_11778_ _06583_ _06651_ VSS VSS VDD VDD _03650_ sky130_fd_sc_hd__xnor2_1
X_11779_ _03649_ _03650_ VSS VSS VDD VDD _03651_ sky130_fd_sc_hd__xnor2_1
X_11780_ _03648_ _03651_ VSS VSS VDD VDD _03652_ sky130_fd_sc_hd__xnor2_1
X_11781_ _06639_ _06644_ VSS VSS VDD VDD _03653_ sky130_fd_sc_hd__xnor2_1
X_11782_ _08147_ _08161_ VSS VSS VDD VDD _03654_ sky130_fd_sc_hd__xnor2_1
X_11783_ _03653_ _03654_ VSS VSS VDD VDD _03655_ sky130_fd_sc_hd__xnor2_1
X_11784_ _03652_ _03655_ VSS VSS VDD VDD _03656_ sky130_fd_sc_hd__xnor2_1
X_11785_ _03645_ _03656_ VSS VSS VDD VDD _03657_ sky130_fd_sc_hd__xnor2_1
X_11786_ _03261_ _03264_ VSS VSS VDD VDD _03658_ sky130_fd_sc_hd__nor2_1
X_11787_ _03658_ _03499_ VSS VSS VDD VDD _03659_ sky130_fd_sc_hd__xnor2_1
X_11788_ _03247_ _03659_ VSS VSS VDD VDD _03660_ sky130_fd_sc_hd__nand2_1
X_11789_ _03657_ _03660_ VSS VSS VDD VDD _03661_ sky130_fd_sc_hd__xnor2_1
X_11790_ _03630_ _03661_ VSS VSS VDD VDD _03662_ sky130_fd_sc_hd__xnor2_1
X_11791_ _06713_ net487 VSS VSS VDD VDD _03663_ sky130_fd_sc_hd__xor2_1
X_11792_ _03494_ _03495_ _00017_ VSS VSS VDD VDD _03664_ sky130_fd_sc_hd__o21ai_0
X_11793_ _08132_ _03664_ VSS VSS VDD VDD _03665_ sky130_fd_sc_hd__xnor2_1
X_11794_ _03663_ _03665_ VSS VSS VDD VDD _03666_ sky130_fd_sc_hd__xnor2_1
X_11795_ net485 _03402_ VSS VSS VDD VDD _03667_ sky130_fd_sc_hd__xor2_1
X_11796_ net500 _03667_ VSS VSS VDD VDD _03668_ sky130_fd_sc_hd__xnor2_1
X_11797_ _03443_ _03668_ VSS VSS VDD VDD _03669_ sky130_fd_sc_hd__nand2_1
X_11798_ _03666_ _03669_ VSS VSS VDD VDD _03670_ sky130_fd_sc_hd__xnor2_1
X_11799_ _03246_ _03295_ VSS VSS VDD VDD _03671_ sky130_fd_sc_hd__xnor2_1
X_11800_ _03312_ _03671_ VSS VSS VDD VDD _03672_ sky130_fd_sc_hd__nand2_1
X_11801_ samples_imag\[1\]\[15\] samples_imag\[5\]\[15\] net50
+ VSS VSS VDD VDD _03673_ sky130_fd_sc_hd__mux2i_1
X_11802_ net45 _03673_ VSS VSS VDD VDD _03674_ sky130_fd_sc_hd__nand2_1
X_11803_ samples_imag\[4\]\[15\] _03269_ _03674_ VSS VSS VDD
+ VDD _03675_ sky130_fd_sc_hd__o21ai_1
X_11804_ net43 _03256_ VSS VSS VDD VDD _03676_ sky130_fd_sc_hd__nor2_8
X_11805_ samples_imag\[7\]\[15\] _03266_ _03676_ samples_imag\[6\]\[15\]
+ VSS VSS VDD VDD _03677_ sky130_fd_sc_hd__a22o_1
X_11806_ samples_imag\[2\]\[15\] _03275_ net465 samples_imag\[3\]\[15\]
+ _03677_ VSS VSS VDD VDD _03678_ sky130_fd_sc_hd__a221oi_2
X_11807_ _03283_ _03675_ _03678_ VSS VSS VDD VDD _03679_ sky130_fd_sc_hd__o21ai_4
X_11808_ samples_imag\[0\]\[15\] _03265_ _03679_ _00009_ VSS
+ VSS VDD VDD _03680_ sky130_fd_sc_hd__o211ai_2
X_11809_ _06538_ _06806_ VSS VSS VDD VDD _03681_ sky130_fd_sc_hd__xor2_2
X_11810_ _06633_ _06758_ VSS VSS VDD VDD _03682_ sky130_fd_sc_hd__xnor2_1
X_11811_ _03682_ _03681_ VSS VSS VDD VDD _03683_ sky130_fd_sc_hd__xnor2_2
X_11812_ _03683_ _03557_ VSS VSS VDD VDD _03684_ sky130_fd_sc_hd__xnor2_1
X_11813_ _03684_ _03680_ VSS VSS VDD VDD _03685_ sky130_fd_sc_hd__xnor2_1
X_11814_ _03685_ _06564_ VSS VSS VDD VDD _03686_ sky130_fd_sc_hd__xnor2_1
X_11815_ _03686_ _03672_ VSS VSS VDD VDD _03687_ sky130_fd_sc_hd__xnor2_1
X_11816_ _03687_ _03670_ VSS VSS VDD VDD _03688_ sky130_fd_sc_hd__xnor2_1
X_11817_ _03688_ _03662_ VSS VSS VDD VDD _03689_ sky130_fd_sc_hd__xnor2_2
X_11818_ _03689_ _03623_ VSS VSS VDD VDD _00019_ sky130_fd_sc_hd__xor2_1
X_11819_ _07819_ state\[1\] VSS VSS VDD VDD _00003_ sky130_fd_sc_hd__nor2b_1
X_11820_ _03465_ _03609_ VSS VSS VDD VDD _06003_ sky130_fd_sc_hd__nand2_1
X_11821_ _03465_ _03502_ VSS VSS VDD VDD _06005_ sky130_fd_sc_hd__nand2_1
X_11822_ _07942_ VSS VSS VDD VDD _06099_ sky130_fd_sc_hd__inv_1
X_11823_ _08155_ VSS VSS VDD VDD _06636_ sky130_fd_sc_hd__inv_1
X_11824_ _06706_ VSS VSS VDD VDD _06755_ sky130_fd_sc_hd__inv_2
X_11825_ _08211_ VSS VSS VDD VDD _06840_ sky130_fd_sc_hd__inv_1
X_11826_ _08225_ VSS VSS VDD VDD _06895_ sky130_fd_sc_hd__inv_1
X_11827_ _06898_ VSS VSS VDD VDD _06905_ sky130_fd_sc_hd__inv_1
X_11828_ _06872_ VSS VSS VDD VDD _06914_ sky130_fd_sc_hd__inv_1
X_11829_ _06879_ VSS VSS VDD VDD _06922_ sky130_fd_sc_hd__inv_1
X_11830_ _06931_ VSS VSS VDD VDD _06933_ sky130_fd_sc_hd__inv_1
X_11831_ _08242_ VSS VSS VDD VDD _06938_ sky130_fd_sc_hd__inv_1
X_11832_ net488 VSS VSS VDD VDD _06948_ sky130_fd_sc_hd__inv_1
X_11833_ _06713_ VSS VSS VDD VDD _06597_ sky130_fd_sc_hd__inv_2
X_11834_ _08256_ VSS VSS VDD VDD _06981_ sky130_fd_sc_hd__inv_1
X_11835_ _08274_ VSS VSS VDD VDD _07027_ sky130_fd_sc_hd__inv_1
X_11836_ _06930_ VSS VSS VDD VDD _06927_ sky130_fd_sc_hd__inv_1
X_11837_ _08276_ VSS VSS VDD VDD _07069_ sky130_fd_sc_hd__inv_1
X_11838_ _03431_ _03423_ VSS VSS VDD VDD _05948_ sky130_fd_sc_hd__nand2_1
X_11839_ _07948_ VSS VSS VDD VDD _06051_ sky130_fd_sc_hd__inv_1
X_11840_ _07980_ VSS VSS VDD VDD _06252_ sky130_fd_sc_hd__inv_1
X_11841_ _07991_ VSS VSS VDD VDD _06302_ sky130_fd_sc_hd__inv_1
X_11842_ _06496_ VSS VSS VDD VDD _06493_ sky130_fd_sc_hd__inv_1
X_11843_ _06506_ VSS VSS VDD VDD _06502_ sky130_fd_sc_hd__inv_1
X_11844_ _08114_ VSS VSS VDD VDD _06522_ sky130_fd_sc_hd__inv_1
X_11845_ _08152_ VSS VSS VDD VDD _06658_ sky130_fd_sc_hd__inv_1
X_11846_ _08170_ VSS VSS VDD VDD _06689_ sky130_fd_sc_hd__inv_1
X_11847_ _08183_ VSS VSS VDD VDD _06742_ sky130_fd_sc_hd__inv_1
X_11848_ _08195_ VSS VSS VDD VDD _06790_ sky130_fd_sc_hd__inv_1
X_11849_ _08208_ VSS VSS VDD VDD _06846_ sky130_fd_sc_hd__inv_1
X_11850_ _08213_ VSS VSS VDD VDD _06877_ sky130_fd_sc_hd__inv_1
X_11851_ _06904_ VSS VSS VDD VDD _06944_ sky130_fd_sc_hd__inv_1
X_11852_ _06964_ VSS VSS VDD VDD _06961_ sky130_fd_sc_hd__inv_1
X_11853_ _08306_ VSS VSS VDD VDD _07070_ sky130_fd_sc_hd__inv_1
X_11854_ _07095_ VSS VSS VDD VDD _07092_ sky130_fd_sc_hd__inv_1
X_11855_ _08317_ VSS VSS VDD VDD _07097_ sky130_fd_sc_hd__inv_1
X_11856_ _07105_ VSS VSS VDD VDD _07100_ sky130_fd_sc_hd__inv_1
X_11857_ _07731_ VSS VSS VDD VDD _05884_ sky130_fd_sc_hd__inv_2
X_11858_ _07845_ VSS VSS VDD VDD _05899_ sky130_fd_sc_hd__inv_2
X_11859_ _03416_ _03534_ VSS VSS VDD VDD _05949_ sky130_fd_sc_hd__nand2_1
X_11860_ _03246_ _00009_ VSS VSS VDD VDD _05996_ sky130_fd_sc_hd__nand2b_1
X_11861_ _03416_ _03387_ VSS VSS VDD VDD _06184_ sky130_fd_sc_hd__nand2_1
X_11862_ _07979_ VSS VSS VDD VDD _06253_ sky130_fd_sc_hd__inv_1
X_11863_ _07990_ VSS VSS VDD VDD _06303_ sky130_fd_sc_hd__inv_1
X_11864_ _03416_ _03451_ VSS VSS VDD VDD _06379_ sky130_fd_sc_hd__nand2_1
X_11865_ _03416_ _03475_ VSS VSS VDD VDD _06436_ sky130_fd_sc_hd__nand2_1
X_11866_ _03416_ _03482_ VSS VSS VDD VDD _06467_ sky130_fd_sc_hd__nand2_1
X_11867_ _06484_ VSS VSS VDD VDD _06494_ sky130_fd_sc_hd__inv_1
X_11868_ _06507_ VSS VSS VDD VDD _06503_ sky130_fd_sc_hd__inv_1
X_11869_ _08163_ VSS VSS VDD VDD _06638_ sky130_fd_sc_hd__inv_1
X_11870_ _08151_ VSS VSS VDD VDD _06659_ sky130_fd_sc_hd__inv_1
X_11871_ _08169_ VSS VSS VDD VDD _06690_ sky130_fd_sc_hd__inv_1
X_11872_ _08182_ VSS VSS VDD VDD _06743_ sky130_fd_sc_hd__inv_1
X_11873_ _08194_ VSS VSS VDD VDD _06791_ sky130_fd_sc_hd__inv_1
X_11874_ _08216_ VSS VSS VDD VDD _06842_ sky130_fd_sc_hd__inv_1
X_11875_ _08207_ VSS VSS VDD VDD _06847_ sky130_fd_sc_hd__inv_1
X_11876_ _08212_ VSS VSS VDD VDD _06878_ sky130_fd_sc_hd__inv_1
X_11877_ _08231_ VSS VSS VDD VDD _06897_ sky130_fd_sc_hd__inv_1
X_11878_ _06899_ VSS VSS VDD VDD _06924_ sky130_fd_sc_hd__inv_1
X_11879_ _08247_ VSS VSS VDD VDD _06940_ sky130_fd_sc_hd__inv_1
X_11880_ _06949_ VSS VSS VDD VDD _06945_ sky130_fd_sc_hd__inv_1
X_11881_ _03333_ _03402_ VSS VSS VDD VDD _06565_ sky130_fd_sc_hd__nand2_4
X_11882_ _08261_ VSS VSS VDD VDD _06983_ sky130_fd_sc_hd__inv_1
X_11883_ _08281_ VSS VSS VDD VDD _07029_ sky130_fd_sc_hd__inv_1
X_11884_ _08287_ VSS VSS VDD VDD _07049_ sky130_fd_sc_hd__inv_1
X_11885_ _08316_ VSS VSS VDD VDD _07098_ sky130_fd_sc_hd__inv_1
X_11886_ _05910_ VSS VSS VDD VDD _00014_ sky130_fd_sc_hd__inv_1
X_11887_ _05956_ VSS VSS VDD VDD _07936_ sky130_fd_sc_hd__inv_1
X_11888_ _05968_ VSS VSS VDD VDD _05991_ sky130_fd_sc_hd__inv_1
X_11889_ _05993_ VSS VSS VDD VDD _06013_ sky130_fd_sc_hd__inv_1
X_11890_ _06049_ VSS VSS VDD VDD _06100_ sky130_fd_sc_hd__inv_1
X_11891_ _06083_ VSS VSS VDD VDD _07963_ sky130_fd_sc_hd__inv_1
X_11892_ _06087_ VSS VSS VDD VDD _06130_ sky130_fd_sc_hd__inv_1
X_11893_ _06136_ VSS VSS VDD VDD _07972_ sky130_fd_sc_hd__inv_1
X_11894_ _06139_ VSS VSS VDD VDD _06180_ sky130_fd_sc_hd__inv_1
X_11895_ _06190_ VSS VSS VDD VDD _06240_ sky130_fd_sc_hd__inv_1
X_11896_ _06194_ VSS VSS VDD VDD _06206_ sky130_fd_sc_hd__inv_1
X_11897_ _06197_ VSS VSS VDD VDD _06251_ sky130_fd_sc_hd__inv_1
X_11898_ _06246_ VSS VSS VDD VDD _07995_ sky130_fd_sc_hd__inv_1
X_11899_ _06250_ VSS VSS VDD VDD _06290_ sky130_fd_sc_hd__inv_1
X_11900_ _06280_ VSS VSS VDD VDD _08004_ sky130_fd_sc_hd__inv_1
X_11901_ _06296_ VSS VSS VDD VDD _08006_ sky130_fd_sc_hd__inv_1
X_11902_ _06300_ VSS VSS VDD VDD _06337_ sky130_fd_sc_hd__inv_1
X_11903_ _06328_ VSS VSS VDD VDD _08014_ sky130_fd_sc_hd__inv_1
X_11904_ _06332_ VSS VSS VDD VDD _08016_ sky130_fd_sc_hd__inv_1
X_11905_ _06343_ VSS VSS VDD VDD _08019_ sky130_fd_sc_hd__inv_2
X_11906_ _06347_ VSS VSS VDD VDD _06375_ sky130_fd_sc_hd__inv_1
X_11907_ _06370_ VSS VSS VDD VDD _08048_ sky130_fd_sc_hd__inv_1
X_11908_ _06408_ VSS VSS VDD VDD _08037_ sky130_fd_sc_hd__inv_2
X_11909_ _06431_ VSS VSS VDD VDD _08052_ sky130_fd_sc_hd__inv_1
X_11910_ _06455_ VSS VSS VDD VDD _08072_ sky130_fd_sc_hd__inv_1
X_11911_ _06462_ VSS VSS VDD VDD _08063_ sky130_fd_sc_hd__inv_1
X_11912_ _06530_ VSS VSS VDD VDD _08135_ sky130_fd_sc_hd__inv_1
X_11913_ _06539_ VSS VSS VDD VDD _06541_ sky130_fd_sc_hd__inv_2
X_11914_ _06562_ VSS VSS VDD VDD _06589_ sky130_fd_sc_hd__inv_2
X_11915_ _06575_ VSS VSS VDD VDD _06581_ sky130_fd_sc_hd__inv_1
X_11916_ _06596_ VSS VSS VDD VDD _06653_ sky130_fd_sc_hd__inv_1
X_11917_ _06616_ VSS VSS VDD VDD _06655_ sky130_fd_sc_hd__inv_1
X_11918_ _06620_ VSS VSS VDD VDD _06626_ sky130_fd_sc_hd__inv_1
X_11919_ _06634_ VSS VSS VDD VDD _06641_ sky130_fd_sc_hd__inv_1
X_11920_ _06679_ VSS VSS VDD VDD _06685_ sky130_fd_sc_hd__inv_1
X_11921_ _06712_ VSS VSS VDD VDD _06763_ sky130_fd_sc_hd__inv_1
X_11922_ _06732_ VSS VSS VDD VDD _06737_ sky130_fd_sc_hd__inv_1
X_11923_ _06769_ VSS VSS VDD VDD _06815_ sky130_fd_sc_hd__inv_1
X_11924_ _06788_ VSS VSS VDD VDD _06817_ sky130_fd_sc_hd__inv_1
X_11925_ _06823_ VSS VSS VDD VDD _06873_ sky130_fd_sc_hd__inv_1
X_11926_ _06835_ VSS VSS VDD VDD _06841_ sky130_fd_sc_hd__inv_1
X_11927_ _06860_ VSS VSS VDD VDD _06871_ sky130_fd_sc_hd__inv_1
X_11928_ _06909_ VSS VSS VDD VDD _06920_ sky130_fd_sc_hd__inv_1
X_11929_ _06926_ VSS VSS VDD VDD _06965_ sky130_fd_sc_hd__inv_1
X_11930_ _06955_ VSS VSS VDD VDD _06967_ sky130_fd_sc_hd__inv_1
X_11931_ _06973_ VSS VSS VDD VDD _07007_ sky130_fd_sc_hd__inv_1
X_11932_ _06992_ VSS VSS VDD VDD _07021_ sky130_fd_sc_hd__inv_1
X_11933_ _06997_ VSS VSS VDD VDD _07009_ sky130_fd_sc_hd__inv_1
X_11934_ _07068_ VSS VSS VDD VDD _07071_ sky130_fd_sc_hd__inv_1
X_11935_ _05955_ VSS VSS VDD VDD _07931_ sky130_fd_sc_hd__inv_1
X_11936_ _06029_ VSS VSS VDD VDD _06024_ sky130_fd_sc_hd__inv_1
X_11937_ _06011_ VSS VSS VDD VDD _06008_ sky130_fd_sc_hd__inv_1
X_11938_ _06048_ VSS VSS VDD VDD _06044_ sky130_fd_sc_hd__inv_1
X_11939_ _06082_ VSS VSS VDD VDD _07950_ sky130_fd_sc_hd__inv_1
X_11940_ _06135_ VSS VSS VDD VDD _07964_ sky130_fd_sc_hd__inv_1
X_11941_ _06245_ VSS VSS VDD VDD _07984_ sky130_fd_sc_hd__inv_1
X_11942_ _06295_ VSS VSS VDD VDD _07996_ sky130_fd_sc_hd__inv_1
X_11943_ _06327_ VSS VSS VDD VDD _08005_ sky130_fd_sc_hd__inv_1
X_11944_ _06342_ VSS VSS VDD VDD _08007_ sky130_fd_sc_hd__inv_1
X_11945_ _06369_ VSS VSS VDD VDD _08017_ sky130_fd_sc_hd__inv_1
X_11946_ _06407_ VSS VSS VDD VDD _08022_ sky130_fd_sc_hd__inv_1
X_11947_ _06430_ VSS VSS VDD VDD _08038_ sky130_fd_sc_hd__inv_1
X_11948_ _06454_ VSS VSS VDD VDD _08049_ sky130_fd_sc_hd__inv_1
X_11949_ _06461_ VSS VSS VDD VDD _08053_ sky130_fd_sc_hd__inv_1
X_11950_ _06533_ VSS VSS VDD VDD _06540_ sky130_fd_sc_hd__inv_1
X_11951_ _06570_ VSS VSS VDD VDD _06580_ sky130_fd_sc_hd__inv_1
X_11952_ _06595_ VSS VSS VDD VDD _06590_ sky130_fd_sc_hd__inv_1
X_11953_ _06604_ VSS VSS VDD VDD _06582_ sky130_fd_sc_hd__inv_1
X_11954_ _06615_ VSS VSS VDD VDD _06625_ sky130_fd_sc_hd__inv_1
X_11955_ _06647_ VSS VSS VDD VDD _06642_ sky130_fd_sc_hd__inv_1
X_11956_ _06674_ VSS VSS VDD VDD _06684_ sky130_fd_sc_hd__inv_1
X_11957_ _06678_ VSS VSS VDD VDD _06627_ sky130_fd_sc_hd__inv_1
X_11958_ _06711_ VSS VSS VDD VDD _06707_ sky130_fd_sc_hd__inv_1
X_11959_ _06727_ VSS VSS VDD VDD _06736_ sky130_fd_sc_hd__inv_1
X_11960_ _06731_ VSS VSS VDD VDD _06686_ sky130_fd_sc_hd__inv_1
X_11961_ _06768_ VSS VSS VDD VDD _06764_ sky130_fd_sc_hd__inv_1
X_11962_ _06780_ VSS VSS VDD VDD _06738_ sky130_fd_sc_hd__inv_1
X_11963_ _06787_ VSS VSS VDD VDD _06800_ sky130_fd_sc_hd__inv_1
X_11964_ _06822_ VSS VSS VDD VDD _06816_ sky130_fd_sc_hd__inv_1
X_11965_ _06925_ VSS VSS VDD VDD _06919_ sky130_fd_sc_hd__inv_1
X_11966_ _06972_ VSS VSS VDD VDD _06966_ sky130_fd_sc_hd__inv_1
X_11967_ _07014_ VSS VSS VDD VDD _07008_ sky130_fd_sc_hd__inv_1
X_11968_ _07025_ VSS VSS VDD VDD _07022_ sky130_fd_sc_hd__inv_1
X_11969_ samples_real\[6\]\[14\] samples_real\[7\]\[14\] _03181_
+ VSS VSS VDD VDD _03690_ sky130_fd_sc_hd__mux2_1
X_11970_ samples_real\[3\]\[14\] _03208_ _03690_ _03169_ VSS
+ VSS VDD VDD _03691_ sky130_fd_sc_hd__a22o_1
X_11971_ samples_real\[1\]\[14\] VSS VSS VDD VDD _03692_ sky130_fd_sc_hd__inv_1
X_11972_ net580 _03692_ _03183_ VSS VSS VDD VDD _03693_ sky130_fd_sc_hd__a21oi_1
X_11973_ _03158_ samples_real\[2\]\[14\] _03693_ VSS VSS VDD
+ VDD _03694_ sky130_fd_sc_hd__a21oi_1
X_11974_ _03209_ VSS VSS VDD VDD _03695_ sky130_fd_sc_hd__buf_12
X_11975_ samples_real\[4\]\[14\] samples_real\[5\]\[14\] _03695_
+ VSS VSS VDD VDD _03696_ sky130_fd_sc_hd__mux2i_1
X_11976_ _03147_ _03201_ VSS VSS VDD VDD _03697_ sky130_fd_sc_hd__nand2_1
X_11977_ _03148_ _03694_ _03696_ _03697_ VSS VSS VDD VDD _03698_
+ sky130_fd_sc_hd__o22ai_1
X_11978_ _03166_ _03691_ _03698_ VSS VSS VDD VDD _03699_ sky130_fd_sc_hd__a21oi_1
X_11979_ samples_real\[0\]\[14\] _03207_ VSS VSS VDD VDD _03700_
+ sky130_fd_sc_hd__nor2_1
X_11980_ _03699_ _03700_ VSS VSS VDD VDD _07721_ sky130_fd_sc_hd__nor2_1
X_11981_ samples_real\[0\]\[13\] samples_real\[2\]\[13\] samples_real\[1\]\[13\]
+ samples_real\[3\]\[13\] net56 net580 VSS VSS VDD VDD _03701_
+ sky130_fd_sc_hd__mux4_1
X_11982_ samples_real\[4\]\[13\] samples_real\[5\]\[13\] samples_real\[6\]\[13\]
+ samples_real\[7\]\[13\] net582 _03183_ VSS VSS VDD VDD _03702_
+ sky130_fd_sc_hd__mux4_1
X_11983_ _03701_ _03702_ _03185_ VSS VSS VDD VDD _07726_ sky130_fd_sc_hd__mux2_1
X_11984_ samples_real\[0\]\[15\] samples_real\[2\]\[15\] samples_real\[1\]\[15\]
+ samples_real\[3\]\[15\] net517 net67 VSS VSS VDD VDD _03703_
+ sky130_fd_sc_hd__mux4_1
X_11985_ samples_real\[4\]\[15\] samples_real\[5\]\[15\] samples_real\[6\]\[15\]
+ samples_real\[7\]\[15\] net67 net636 VSS VSS VDD VDD _03704_
+ sky130_fd_sc_hd__mux4_1
X_11986_ _03703_ _03704_ net522 VSS VSS VDD VDD _07736_ sky130_fd_sc_hd__mux2_2
X_11987_ samples_real\[0\]\[12\] samples_real\[2\]\[12\] samples_real\[1\]\[12\]
+ samples_real\[3\]\[12\] net56 net580 VSS VSS VDD VDD _03705_
+ sky130_fd_sc_hd__mux4_1
X_11988_ samples_real\[4\]\[12\] samples_real\[5\]\[12\] samples_real\[6\]\[12\]
+ samples_real\[7\]\[12\] _03181_ _03183_ VSS VSS VDD VDD _03706_
+ sky130_fd_sc_hd__mux4_1
X_11989_ _03705_ _03706_ _03148_ VSS VSS VDD VDD _07740_ sky130_fd_sc_hd__mux2_1
X_11990_ samples_real\[0\]\[11\] samples_real\[2\]\[11\] samples_real\[1\]\[11\]
+ samples_real\[3\]\[11\] net56 net580 VSS VSS VDD VDD _03707_
+ sky130_fd_sc_hd__mux4_1
X_11991_ samples_real\[4\]\[11\] samples_real\[5\]\[11\] samples_real\[6\]\[11\]
+ samples_real\[7\]\[11\] _03181_ _03183_ VSS VSS VDD VDD _03708_
+ sky130_fd_sc_hd__mux4_1
X_11992_ _03707_ _03708_ _03185_ VSS VSS VDD VDD _07745_ sky130_fd_sc_hd__mux2_1
X_11993_ samples_real\[2\]\[10\] net535 _03198_ samples_real\[7\]\[10\]
+ VSS VSS VDD VDD _03709_ sky130_fd_sc_hd__a22oi_2
X_11994_ samples_real\[4\]\[10\] net552 net547 samples_real\[1\]\[10\]
+ VSS VSS VDD VDD _03710_ sky130_fd_sc_hd__a22oi_2
X_11995_ _03183_ net643 samples_real\[3\]\[10\] VSS VSS VDD
+ VDD _03711_ sky130_fd_sc_hd__and3_1
X_11996_ samples_real\[5\]\[10\] net562 net613 samples_real\[6\]\[10\]
+ VSS VSS VDD VDD _03712_ sky130_fd_sc_hd__a22oi_1
X_11997_ _03185_ _03712_ VSS VSS VDD VDD _03713_ sky130_fd_sc_hd__nand2_1
X_11998_ _03148_ net556 _03711_ _03713_ VSS VSS VDD VDD _03714_
+ sky130_fd_sc_hd__o31ai_2
X_11999_ _03176_ VSS VSS VDD VDD _03715_ sky130_fd_sc_hd__clkbuf_4
X_12000_ samples_real\[0\]\[10\] _03715_ VSS VSS VDD VDD _03716_
+ sky130_fd_sc_hd__nor2_1
X_12001_ _03709_ _03710_ _03714_ _03716_ VSS VSS VDD VDD _07750_
+ sky130_fd_sc_hd__a31oi_4
X_12002_ samples_real\[3\]\[9\] _03208_ _03210_ samples_real\[6\]\[9\]
+ VSS VSS VDD VDD _03717_ sky130_fd_sc_hd__a22o_1
X_12003_ _03166_ _03717_ VSS VSS VDD VDD _03718_ sky130_fd_sc_hd__nand2_1
X_12004_ _03158_ samples_real\[1\]\[9\] _03201_ VSS VSS VDD
+ VDD _03719_ sky130_fd_sc_hd__o21ai_0
X_12005_ _03213_ _03380_ _03719_ VSS VSS VDD VDD _03720_ sky130_fd_sc_hd__o21ai_0
X_12006_ samples_real\[4\]\[9\] samples_real\[5\]\[9\] net643
+ VSS VSS VDD VDD _03721_ sky130_fd_sc_hd__mux2i_1
X_12007_ _03166_ _03213_ samples_real\[7\]\[9\] VSS VSS VDD
+ VDD _03722_ sky130_fd_sc_hd__nand3_1
X_12008_ _03166_ _03721_ _03722_ _03148_ VSS VSS VDD VDD _03723_
+ sky130_fd_sc_hd__o211ai_1
X_12009_ _03185_ _03720_ _03723_ VSS VSS VDD VDD _03724_ sky130_fd_sc_hd__o21ai_0
X_12010_ samples_real\[0\]\[9\] _03715_ VSS VSS VDD VDD _03725_
+ sky130_fd_sc_hd__nor2_1
X_12011_ _03718_ _03724_ _03725_ VSS VSS VDD VDD _07755_ sky130_fd_sc_hd__a21oi_2
X_12012_ samples_real\[0\]\[8\] samples_real\[2\]\[8\] samples_real\[1\]\[8\]
+ samples_real\[3\]\[8\] net606 _03213_ VSS VSS VDD VDD _03726_
+ sky130_fd_sc_hd__mux4_1
X_12013_ samples_real\[4\]\[8\] samples_real\[5\]\[8\] samples_real\[6\]\[8\]
+ samples_real\[7\]\[8\] _03209_ _03166_ VSS VSS VDD VDD _03727_
+ sky130_fd_sc_hd__mux4_1
X_12014_ _03169_ VSS VSS VDD VDD _03728_ sky130_fd_sc_hd__buf_6
X_12015_ _03726_ _03727_ _03728_ VSS VSS VDD VDD _07760_ sky130_fd_sc_hd__mux2_1
X_12016_ samples_real\[0\]\[7\] samples_real\[2\]\[7\] samples_real\[1\]\[7\]
+ samples_real\[3\]\[7\] net587 net580 VSS VSS VDD VDD _03729_
+ sky130_fd_sc_hd__mux4_1
X_12017_ samples_real\[4\]\[7\] samples_real\[5\]\[7\] samples_real\[6\]\[7\]
+ samples_real\[7\]\[7\] _03181_ _03183_ VSS VSS VDD VDD _03730_
+ sky130_fd_sc_hd__mux4_1
X_12018_ _03729_ _03730_ _03148_ VSS VSS VDD VDD _07765_ sky130_fd_sc_hd__mux2_1
X_12019_ samples_real\[6\]\[6\] samples_real\[7\]\[6\] _03695_
+ VSS VSS VDD VDD _03731_ sky130_fd_sc_hd__mux2i_1
X_12020_ samples_real\[5\]\[6\] net561 VSS VSS VDD VDD _03732_
+ sky130_fd_sc_hd__nand2_1
X_12021_ _03201_ _03731_ _03732_ VSS VSS VDD VDD _03733_ sky130_fd_sc_hd__o21ai_0
X_12022_ samples_real\[2\]\[6\] VSS VSS VDD VDD _03734_ sky130_fd_sc_hd__inv_1
X_12023_ net66 _03734_ _03169_ VSS VSS VDD VDD _03735_ sky130_fd_sc_hd__a21oi_1
X_12024_ _03201_ samples_real\[4\]\[6\] _03735_ VSS VSS VDD
+ VDD _03736_ sky130_fd_sc_hd__a21oi_1
X_12025_ samples_real\[1\]\[6\] samples_real\[3\]\[6\] _03166_
+ VSS VSS VDD VDD _03737_ sky130_fd_sc_hd__mux2i_1
X_12026_ _03169_ net643 VSS VSS VDD VDD _03738_ sky130_fd_sc_hd__nand2b_1
X_12027_ _03213_ _03736_ _03737_ _03738_ VSS VSS VDD VDD _03739_
+ sky130_fd_sc_hd__o22ai_1
X_12028_ _03728_ _03733_ _03739_ VSS VSS VDD VDD _03740_ sky130_fd_sc_hd__a21oi_1
X_12029_ samples_real\[0\]\[6\] _03207_ VSS VSS VDD VDD _03741_
+ sky130_fd_sc_hd__nor2_1
X_12030_ _03740_ _03741_ VSS VSS VDD VDD _07770_ sky130_fd_sc_hd__nor2_2
X_12031_ samples_real\[0\]\[5\] samples_real\[2\]\[5\] samples_real\[1\]\[5\]
+ samples_real\[3\]\[5\] _03182_ _03695_ VSS VSS VDD VDD _03742_
+ sky130_fd_sc_hd__mux4_1
X_12032_ samples_real\[4\]\[5\] samples_real\[5\]\[5\] samples_real\[6\]\[5\]
+ samples_real\[7\]\[5\] net583 net66 VSS VSS VDD VDD _03743_
+ sky130_fd_sc_hd__mux4_1
X_12033_ _03742_ _03743_ _03185_ VSS VSS VDD VDD _07775_ sky130_fd_sc_hd__mux2_1
X_12034_ samples_real\[0\]\[4\] samples_real\[2\]\[4\] samples_real\[1\]\[4\]
+ samples_real\[3\]\[4\] net586 net580 VSS VSS VDD VDD _03744_
+ sky130_fd_sc_hd__mux4_1
X_12035_ samples_real\[4\]\[4\] samples_real\[5\]\[4\] samples_real\[6\]\[4\]
+ samples_real\[7\]\[4\] _03181_ _03183_ VSS VSS VDD VDD _03745_
+ sky130_fd_sc_hd__mux4_1
X_12036_ _03744_ _03745_ _03185_ VSS VSS VDD VDD _07780_ sky130_fd_sc_hd__mux2_1
X_12037_ samples_real\[0\]\[3\] samples_real\[2\]\[3\] samples_real\[1\]\[3\]
+ samples_real\[3\]\[3\] _03182_ _03695_ VSS VSS VDD VDD _03746_
+ sky130_fd_sc_hd__mux4_2
X_12038_ samples_real\[4\]\[3\] samples_real\[5\]\[3\] samples_real\[6\]\[3\]
+ samples_real\[7\]\[3\] net582 net601 VSS VSS VDD VDD _03747_
+ sky130_fd_sc_hd__mux4_1
X_12039_ _03746_ _03747_ _03728_ VSS VSS VDD VDD _07785_ sky130_fd_sc_hd__mux2_2
X_12040_ samples_real\[0\]\[2\] samples_real\[2\]\[2\] samples_real\[1\]\[2\]
+ samples_real\[3\]\[2\] _03182_ _03695_ VSS VSS VDD VDD _03748_
+ sky130_fd_sc_hd__mux4_1
X_12041_ samples_real\[4\]\[2\] samples_real\[5\]\[2\] samples_real\[6\]\[2\]
+ samples_real\[7\]\[2\] net582 net600 VSS VSS VDD VDD _03749_
+ sky130_fd_sc_hd__mux4_1
X_12042_ _03748_ _03749_ _03728_ VSS VSS VDD VDD _07790_ sky130_fd_sc_hd__mux2_4
X_12043_ sample_count\[0\] VSS VSS VDD VDD _07827_ sky130_fd_sc_hd__inv_1
X_12044_ samples_imag\[1\]\[14\] samples_imag\[3\]\[14\] samples_imag\[5\]\[14\]
+ samples_imag\[7\]\[14\] net55 _03169_ VSS VSS VDD VDD _03750_
+ sky130_fd_sc_hd__mux4_1
X_12045_ samples_imag\[4\]\[14\] samples_imag\[6\]\[14\] net66
+ VSS VSS VDD VDD _03751_ sky130_fd_sc_hd__mux2i_1
X_12046_ samples_imag\[2\]\[14\] _03155_ VSS VSS VDD VDD _03752_
+ sky130_fd_sc_hd__nor2_1
X_12047_ _03728_ _03751_ _03752_ _03213_ VSS VSS VDD VDD _03753_
+ sky130_fd_sc_hd__a211oi_1
X_12048_ _03213_ _03750_ _03753_ VSS VSS VDD VDD _03754_ sky130_fd_sc_hd__a21oi_1
X_12049_ samples_imag\[0\]\[14\] _03207_ VSS VSS VDD VDD _03755_
+ sky130_fd_sc_hd__nor2_1
X_12050_ _03754_ _03755_ VSS VSS VDD VDD _07835_ sky130_fd_sc_hd__nor2_1
X_12051_ samples_imag\[0\]\[13\] net584 VSS VSS VDD VDD _03756_
+ sky130_fd_sc_hd__nor2_1
X_12052_ samples_imag\[6\]\[13\] samples_imag\[7\]\[13\] net546
+ VSS VSS VDD VDD _03757_ sky130_fd_sc_hd__mux2i_1
X_12053_ samples_imag\[5\]\[13\] net559 VSS VSS VDD VDD _03758_
+ sky130_fd_sc_hd__nand2_1
X_12054_ _03201_ _03757_ _03758_ VSS VSS VDD VDD _03759_ sky130_fd_sc_hd__o21ai_0
X_12055_ samples_imag\[2\]\[13\] samples_imag\[3\]\[13\] _03181_
+ VSS VSS VDD VDD _03760_ sky130_fd_sc_hd__mux2i_1
X_12056_ samples_imag\[1\]\[13\] VSS VSS VDD VDD _03761_ sky130_fd_sc_hd__inv_1
X_12057_ net546 _03761_ _03146_ VSS VSS VDD VDD _03762_ sky130_fd_sc_hd__a21oi_1
X_12058_ _03158_ samples_imag\[4\]\[13\] _03762_ VSS VSS VDD
+ VDD _03763_ sky130_fd_sc_hd__a21oi_1
X_12059_ net539 _03760_ _03763_ net55 VSS VSS VDD VDD _03764_
+ sky130_fd_sc_hd__o22ai_1
X_12060_ _03147_ _03759_ _03764_ VSS VSS VDD VDD _03765_ sky130_fd_sc_hd__a21oi_1
X_12061_ _03756_ _03765_ VSS VSS VDD VDD _07840_ sky130_fd_sc_hd__nor2_2
X_12062_ samples_imag\[1\]\[15\] samples_imag\[3\]\[15\] samples_imag\[5\]\[15\]
+ samples_imag\[7\]\[15\] net634 net521 VSS VSS VDD VDD _03766_
+ sky130_fd_sc_hd__mux4_1
X_12063_ samples_imag\[4\]\[15\] samples_imag\[6\]\[15\] net635
+ VSS VSS VDD VDD _03767_ sky130_fd_sc_hd__mux2i_1
X_12064_ samples_imag\[2\]\[15\] net539 VSS VSS VDD VDD _03768_
+ sky130_fd_sc_hd__nor2_1
X_12065_ net521 _03767_ _03768_ net67 VSS VSS VDD VDD _03769_
+ sky130_fd_sc_hd__a211oi_1
X_12066_ net67 _03766_ _03769_ VSS VSS VDD VDD _03770_ sky130_fd_sc_hd__a21oi_1
X_12067_ samples_imag\[0\]\[15\] net584 VSS VSS VDD VDD _03771_
+ sky130_fd_sc_hd__nor2_1
X_12068_ _03770_ _03771_ VSS VSS VDD VDD _07850_ sky130_fd_sc_hd__nor2_4
X_12069_ samples_imag\[5\]\[12\] VSS VSS VDD VDD _03772_ sky130_fd_sc_hd__inv_1
X_12070_ _03147_ net560 VSS VSS VDD VDD _03773_ sky130_fd_sc_hd__nand2_4
X_12071_ _03772_ _03773_ net548 samples_imag\[1\]\[12\] VSS
+ VSS VDD VDD _03774_ sky130_fd_sc_hd__a2bb2oi_1
X_12072_ samples_imag\[4\]\[12\] samples_imag\[6\]\[12\] net55
+ VSS VSS VDD VDD _03775_ sky130_fd_sc_hd__mux2i_1
X_12073_ samples_imag\[2\]\[12\] net538 _03158_ VSS VSS VDD
+ VDD _03776_ sky130_fd_sc_hd__o21ai_0
X_12074_ _03148_ _03775_ _03776_ VSS VSS VDD VDD _03777_ sky130_fd_sc_hd__a21oi_1
X_12075_ samples_imag\[3\]\[12\] _03159_ _03198_ samples_imag\[7\]\[12\]
+ _03777_ VSS VSS VDD VDD _03778_ sky130_fd_sc_hd__a221oi_1
X_12076_ samples_imag\[0\]\[12\] _03207_ VSS VSS VDD VDD _03779_
+ sky130_fd_sc_hd__nor2_2
X_12077_ _03774_ _03778_ _03779_ VSS VSS VDD VDD _07854_ sky130_fd_sc_hd__a21oi_2
X_12078_ samples_imag\[1\]\[11\] samples_imag\[3\]\[11\] samples_imag\[5\]\[11\]
+ samples_imag\[7\]\[11\] _03182_ _03169_ VSS VSS VDD VDD _03780_
+ sky130_fd_sc_hd__mux4_1
X_12079_ samples_imag\[4\]\[11\] samples_imag\[6\]\[11\] net55
+ VSS VSS VDD VDD _03781_ sky130_fd_sc_hd__mux2i_1
X_12080_ samples_imag\[2\]\[11\] _03155_ VSS VSS VDD VDD _03782_
+ sky130_fd_sc_hd__nor2_1
X_12081_ _03148_ _03781_ _03782_ _03213_ VSS VSS VDD VDD _03783_
+ sky130_fd_sc_hd__a211oi_1
X_12082_ _03213_ _03780_ _03783_ VSS VSS VDD VDD _03784_ sky130_fd_sc_hd__a21oi_1
X_12083_ samples_imag\[0\]\[11\] _03207_ VSS VSS VDD VDD _03785_
+ sky130_fd_sc_hd__nor2_1
X_12084_ _03784_ _03785_ VSS VSS VDD VDD _07859_ sky130_fd_sc_hd__nor2_1
X_12085_ samples_imag\[0\]\[10\] samples_imag\[2\]\[10\] samples_imag\[1\]\[10\]
+ samples_imag\[3\]\[10\] net56 net580 VSS VSS VDD VDD _03786_
+ sky130_fd_sc_hd__mux4_1
X_12086_ samples_imag\[4\]\[10\] samples_imag\[5\]\[10\] samples_imag\[6\]\[10\]
+ samples_imag\[7\]\[10\] _03181_ net604 VSS VSS VDD VDD _03787_
+ sky130_fd_sc_hd__mux4_1
X_12087_ _03786_ _03787_ _03148_ VSS VSS VDD VDD _07864_ sky130_fd_sc_hd__mux2_1
X_12088_ samples_imag\[2\]\[9\] samples_imag\[3\]\[9\] samples_imag\[6\]\[9\]
+ samples_imag\[7\]\[9\] net640 _03169_ VSS VSS VDD VDD _03788_
+ sky130_fd_sc_hd__mux4_1
X_12089_ _03166_ _03788_ VSS VSS VDD VDD _03789_ sky130_fd_sc_hd__nand2_1
X_12090_ samples_imag\[4\]\[9\] samples_imag\[5\]\[9\] _03695_
+ VSS VSS VDD VDD _03790_ sky130_fd_sc_hd__mux2i_1
X_12091_ _03728_ _03790_ VSS VSS VDD VDD _03791_ sky130_fd_sc_hd__nand2_1
X_12092_ samples_imag\[1\]\[9\] _03738_ _03791_ _03201_ VSS
+ VSS VDD VDD _03792_ sky130_fd_sc_hd__o211ai_1
X_12093_ samples_imag\[0\]\[9\] _03207_ VSS VSS VDD VDD _03793_
+ sky130_fd_sc_hd__nor2_1
X_12094_ _03789_ _03792_ _03793_ VSS VSS VDD VDD _07869_ sky130_fd_sc_hd__a21oi_2
X_12095_ samples_imag\[0\]\[8\] samples_imag\[2\]\[8\] samples_imag\[1\]\[8\]
+ samples_imag\[3\]\[8\] _03182_ _03695_ VSS VSS VDD VDD _03794_
+ sky130_fd_sc_hd__mux4_1
X_12096_ samples_imag\[4\]\[8\] samples_imag\[5\]\[8\] samples_imag\[6\]\[8\]
+ samples_imag\[7\]\[8\] net574 net66 VSS VSS VDD VDD _03795_
+ sky130_fd_sc_hd__mux4_1
X_12097_ _03794_ _03795_ _03728_ VSS VSS VDD VDD _07874_ sky130_fd_sc_hd__mux2_2
X_12098_ samples_imag\[0\]\[7\] samples_imag\[2\]\[7\] samples_imag\[1\]\[7\]
+ samples_imag\[3\]\[7\] _03182_ _03695_ VSS VSS VDD VDD _03796_
+ sky130_fd_sc_hd__mux4_1
X_12099_ samples_imag\[4\]\[7\] samples_imag\[5\]\[7\] samples_imag\[6\]\[7\]
+ samples_imag\[7\]\[7\] net574 net66 VSS VSS VDD VDD _03797_
+ sky130_fd_sc_hd__mux4_1
X_12100_ _03796_ _03797_ _03728_ VSS VSS VDD VDD _07879_ sky130_fd_sc_hd__mux2_2
X_12101_ samples_imag\[0\]\[6\] samples_imag\[2\]\[6\] samples_imag\[1\]\[6\]
+ samples_imag\[3\]\[6\] _03182_ _03695_ VSS VSS VDD VDD _03798_
+ sky130_fd_sc_hd__mux4_1
X_12102_ samples_imag\[4\]\[6\] samples_imag\[5\]\[6\] samples_imag\[6\]\[6\]
+ samples_imag\[7\]\[6\] net640 _03166_ VSS VSS VDD VDD _03799_
+ sky130_fd_sc_hd__mux4_1
X_12103_ _03798_ _03799_ _03728_ VSS VSS VDD VDD _07884_ sky130_fd_sc_hd__mux2_1
X_12104_ samples_imag\[0\]\[5\] samples_imag\[2\]\[5\] samples_imag\[1\]\[5\]
+ samples_imag\[3\]\[5\] net607 net580 VSS VSS VDD VDD _03800_
+ sky130_fd_sc_hd__mux4_1
X_12105_ samples_imag\[4\]\[5\] samples_imag\[5\]\[5\] samples_imag\[6\]\[5\]
+ samples_imag\[7\]\[5\] _03181_ _03183_ VSS VSS VDD VDD _03801_
+ sky130_fd_sc_hd__mux4_1
X_12106_ _03800_ _03801_ _03185_ VSS VSS VDD VDD _07889_ sky130_fd_sc_hd__mux2_1
X_12107_ samples_imag\[0\]\[4\] samples_imag\[2\]\[4\] samples_imag\[1\]\[4\]
+ samples_imag\[3\]\[4\] _03182_ net580 VSS VSS VDD VDD _03802_
+ sky130_fd_sc_hd__mux4_1
X_12108_ samples_imag\[4\]\[4\] samples_imag\[5\]\[4\] samples_imag\[6\]\[4\]
+ samples_imag\[7\]\[4\] net574 net603 VSS VSS VDD VDD _03803_
+ sky130_fd_sc_hd__mux4_1
X_12109_ _03802_ _03803_ _03185_ VSS VSS VDD VDD _07894_ sky130_fd_sc_hd__mux2_2
X_12110_ samples_imag\[0\]\[3\] samples_imag\[2\]\[3\] samples_imag\[1\]\[3\]
+ samples_imag\[3\]\[3\] _03182_ _03695_ VSS VSS VDD VDD _03804_
+ sky130_fd_sc_hd__mux4_1
X_12111_ samples_imag\[4\]\[3\] samples_imag\[5\]\[3\] samples_imag\[6\]\[3\]
+ samples_imag\[7\]\[3\] net574 net601 VSS VSS VDD VDD _03805_
+ sky130_fd_sc_hd__mux4_2
X_12112_ _03804_ _03805_ _03728_ VSS VSS VDD VDD _07899_ sky130_fd_sc_hd__mux2_4
X_12113_ samples_imag\[6\]\[2\] samples_imag\[7\]\[2\] net576
+ VSS VSS VDD VDD _03806_ sky130_fd_sc_hd__mux2_1
X_12114_ samples_imag\[3\]\[2\] _03208_ _03806_ _03146_ VSS
+ VSS VDD VDD _03807_ sky130_fd_sc_hd__a22o_1
X_12115_ _03151_ samples_imag\[1\]\[2\] _03201_ VSS VSS VDD
+ VDD _03808_ sky130_fd_sc_hd__o21ai_0
X_12116_ _03158_ samples_imag\[2\]\[2\] _03808_ VSS VSS VDD
+ VDD _03809_ sky130_fd_sc_hd__a21boi_0
X_12117_ samples_imag\[4\]\[2\] samples_imag\[5\]\[2\] _03181_
+ VSS VSS VDD VDD _03810_ sky130_fd_sc_hd__mux2i_2
X_12118_ _03147_ _03809_ _03810_ _03697_ VSS VSS VDD VDD _03811_
+ sky130_fd_sc_hd__o22ai_1
X_12119_ _03807_ _03183_ _03811_ VSS VSS VDD VDD _03812_ sky130_fd_sc_hd__a21oi_2
X_12120_ samples_imag\[0\]\[2\] _03175_ VSS VSS VDD VDD _03813_
+ sky130_fd_sc_hd__nor2_1
X_12121_ _03813_ _03812_ VSS VSS VDD VDD _07904_ sky130_fd_sc_hd__nor2_4
X_12122_ _05915_ VSS VSS VDD VDD _05916_ sky130_fd_sc_hd__inv_1
X_12123_ _05929_ VSS VSS VDD VDD _05931_ sky130_fd_sc_hd__inv_1
X_12124_ _05941_ VSS VSS VDD VDD _05976_ sky130_fd_sc_hd__inv_1
X_12125_ _05911_ VSS VSS VDD VDD _05952_ sky130_fd_sc_hd__inv_1
X_12126_ _03443_ _03430_ VSS VSS VDD VDD _05961_ sky130_fd_sc_hd__and2_0
X_12127_ _07933_ VSS VSS VDD VDD _05989_ sky130_fd_sc_hd__inv_1
X_12128_ _05946_ VSS VSS VDD VDD _05974_ sky130_fd_sc_hd__inv_1
X_12129_ _05983_ VSS VSS VDD VDD _06065_ sky130_fd_sc_hd__inv_1
X_12130_ _05939_ VSS VSS VDD VDD _05957_ sky130_fd_sc_hd__inv_1
X_12131_ _06006_ VSS VSS VDD VDD _06022_ sky130_fd_sc_hd__inv_1
X_12132_ _06009_ VSS VSS VDD VDD _06036_ sky130_fd_sc_hd__inv_1
X_12133_ _07941_ VSS VSS VDD VDD _07944_ sky130_fd_sc_hd__inv_1
X_12134_ _06016_ VSS VSS VDD VDD _06056_ sky130_fd_sc_hd__inv_1
X_12135_ _05988_ VSS VSS VDD VDD _06063_ sky130_fd_sc_hd__inv_1
X_12136_ _06043_ VSS VSS VDD VDD _06085_ sky130_fd_sc_hd__inv_1
X_12137_ _06106_ VSS VSS VDD VDD _06102_ sky130_fd_sc_hd__inv_1
X_12138_ _06094_ VSS VSS VDD VDD _06092_ sky130_fd_sc_hd__inv_1
X_12139_ _07947_ VSS VSS VDD VDD _07951_ sky130_fd_sc_hd__inv_1
X_12140_ _06105_ VSS VSS VDD VDD _06108_ sky130_fd_sc_hd__inv_1
X_12141_ _06114_ VSS VSS VDD VDD _06112_ sky130_fd_sc_hd__inv_1
X_12142_ _06076_ VSS VSS VDD VDD _06118_ sky130_fd_sc_hd__inv_1
X_12143_ _06127_ VSS VSS VDD VDD _06171_ sky130_fd_sc_hd__inv_1
X_12144_ _06152_ VSS VSS VDD VDD _06148_ sky130_fd_sc_hd__inv_1
X_12145_ _06147_ VSS VSS VDD VDD _06187_ sky130_fd_sc_hd__inv_1
X_12146_ _07923_ VSS VSS VDD VDD _07965_ sky130_fd_sc_hd__inv_1
X_12147_ _06151_ VSS VSS VDD VDD _06158_ sky130_fd_sc_hd__inv_1
X_12148_ _06163_ VSS VSS VDD VDD _06161_ sky130_fd_sc_hd__inv_1
X_12149_ _06167_ VSS VSS VDD VDD _06165_ sky130_fd_sc_hd__inv_1
X_12150_ _06177_ VSS VSS VDD VDD _06231_ sky130_fd_sc_hd__inv_1
X_12151_ _06198_ VSS VSS VDD VDD _06247_ sky130_fd_sc_hd__inv_1
X_12152_ _07987_ VSS VSS VDD VDD _07976_ sky130_fd_sc_hd__inv_1
X_12153_ _06208_ VSS VSS VDD VDD _07981_ sky130_fd_sc_hd__inv_1
X_12154_ _06209_ VSS VSS VDD VDD _06218_ sky130_fd_sc_hd__inv_1
X_12155_ _06223_ VSS VSS VDD VDD _06221_ sky130_fd_sc_hd__inv_1
X_12156_ _06227_ VSS VSS VDD VDD _06225_ sky130_fd_sc_hd__inv_1
X_12157_ _06237_ VSS VSS VDD VDD _06281_ sky130_fd_sc_hd__inv_1
X_12158_ _07997_ VSS VSS VDD VDD _05925_ sky130_fd_sc_hd__inv_1
X_12159_ _06258_ VSS VSS VDD VDD _07992_ sky130_fd_sc_hd__inv_1
X_12160_ _06259_ VSS VSS VDD VDD _06268_ sky130_fd_sc_hd__inv_1
X_12161_ _06273_ VSS VSS VDD VDD _06271_ sky130_fd_sc_hd__inv_1
X_12162_ _06277_ VSS VSS VDD VDD _06275_ sky130_fd_sc_hd__inv_1
X_12163_ _06310_ VSS VSS VDD VDD _06305_ sky130_fd_sc_hd__inv_1
X_12164_ _05942_ VSS VSS VDD VDD _07927_ sky130_fd_sc_hd__inv_1
X_12165_ _06324_ VSS VSS VDD VDD _06321_ sky130_fd_sc_hd__inv_1
X_12166_ _08008_ VSS VSS VDD VDD _06348_ sky130_fd_sc_hd__inv_1
X_12167_ _05984_ VSS VSS VDD VDD _07934_ sky130_fd_sc_hd__inv_1
X_12168_ _06456_ VSS VSS VDD VDD _06452_ sky130_fd_sc_hd__inv_1
X_12169_ _06409_ VSS VSS VDD VDD _06404_ sky130_fd_sc_hd__inv_2
X_12170_ _08023_ VSS VSS VDD VDD _06384_ sky130_fd_sc_hd__inv_1
X_12171_ _08041_ VSS VSS VDD VDD _06072_ sky130_fd_sc_hd__inv_1
X_12172_ _06366_ VSS VSS VDD VDD _06396_ sky130_fd_sc_hd__inv_1
X_12173_ _06432_ VSS VSS VDD VDD _06427_ sky130_fd_sc_hd__inv_1
X_12174_ _08039_ VSS VSS VDD VDD _06411_ sky130_fd_sc_hd__inv_1
X_12175_ _07958_ VSS VSS VDD VDD _08043_ sky130_fd_sc_hd__inv_1
X_12176_ _06403_ VSS VSS VDD VDD _06423_ sky130_fd_sc_hd__inv_1
X_12177_ _06463_ VSS VSS VDD VDD _06458_ sky130_fd_sc_hd__inv_1
X_12178_ _08054_ VSS VSS VDD VDD _08057_ sky130_fd_sc_hd__inv_1
X_12179_ _06450_ VSS VSS VDD VDD _06447_ sky130_fd_sc_hd__inv_2
X_12180_ _08065_ VSS VSS VDD VDD _08067_ sky130_fd_sc_hd__inv_1
X_12181_ _08061_ VSS VSS VDD VDD _06477_ sky130_fd_sc_hd__inv_1
X_12182_ _03402_ _08065_ net484 VSS VSS VDD VDD _03814_ sky130_fd_sc_hd__mux2_1
X_12183_ _03313_ _03814_ VSS VSS VDD VDD _06475_ sky130_fd_sc_hd__nand2_1
X_12184_ _08062_ VSS VSS VDD VDD _08075_ sky130_fd_sc_hd__inv_1
X_12185_ _08088_ VSS VSS VDD VDD _06482_ sky130_fd_sc_hd__inv_1
X_12186_ _08081_ VSS VSS VDD VDD _08100_ sky130_fd_sc_hd__inv_1
X_12187_ _06329_ VSS VSS VDD VDD _06326_ sky130_fd_sc_hd__inv_1
X_12188_ _06495_ VSS VSS VDD VDD _06512_ sky130_fd_sc_hd__inv_1
X_12189_ _06504_ VSS VSS VDD VDD _06509_ sky130_fd_sc_hd__inv_1
X_12190_ _06505_ VSS VSS VDD VDD _06514_ sky130_fd_sc_hd__inv_1
X_12191_ _08111_ VSS VSS VDD VDD _08109_ sky130_fd_sc_hd__inv_1
X_12192_ _06554_ VSS VSS VDD VDD _06572_ sky130_fd_sc_hd__inv_1
X_12193_ _06544_ VSS VSS VDD VDD _06560_ sky130_fd_sc_hd__inv_2
X_12194_ _06579_ VSS VSS VDD VDD _06602_ sky130_fd_sc_hd__inv_1
X_12195_ _03504_ _03261_ _03264_ VSS VSS VDD VDD _08144_ sky130_fd_sc_hd__nor3_1
X_12196_ _06611_ VSS VSS VDD VDD _06621_ sky130_fd_sc_hd__inv_1
X_12197_ _06601_ VSS VSS VDD VDD _08149_ sky130_fd_sc_hd__inv_1
X_12198_ _06609_ VSS VSS VDD VDD _06665_ sky130_fd_sc_hd__inv_1
X_12199_ _03504_ net495 _03311_ VSS VSS VDD VDD _08153_ sky130_fd_sc_hd__nor3_1
X_12200_ _06670_ VSS VSS VDD VDD _06680_ sky130_fd_sc_hd__inv_1
X_12201_ _06645_ VSS VSS VDD VDD _08167_ sky130_fd_sc_hd__inv_1
X_12202_ _06664_ VSS VSS VDD VDD _08171_ sky130_fd_sc_hd__inv_1
X_12203_ _06669_ VSS VSS VDD VDD _06716_ sky130_fd_sc_hd__inv_1
X_12204_ _06660_ VSS VSS VDD VDD _06709_ sky130_fd_sc_hd__inv_1
X_12205_ _03504_ _03324_ VSS VSS VDD VDD _08174_ sky130_fd_sc_hd__nor2_1
X_12206_ _06700_ VSS VSS VDD VDD _06745_ sky130_fd_sc_hd__inv_1
X_12207_ _06720_ VSS VSS VDD VDD _06770_ sky130_fd_sc_hd__inv_1
X_12208_ _03431_ _03332_ VSS VSS VDD VDD _08186_ sky130_fd_sc_hd__and2_0
X_12209_ _06751_ VSS VSS VDD VDD _06793_ sky130_fd_sc_hd__inv_1
X_12210_ _06753_ VSS VSS VDD VDD _08196_ sky130_fd_sc_hd__inv_1
X_12211_ _06774_ VSS VSS VDD VDD _06824_ sky130_fd_sc_hd__inv_1
X_12212_ _03504_ _03344_ net480 VSS VSS VDD VDD _08199_ sky130_fd_sc_hd__nor3_1
X_12213_ _06831_ VSS VSS VDD VDD _06836_ sky130_fd_sc_hd__inv_1
X_12214_ _06799_ VSS VSS VDD VDD _06849_ sky130_fd_sc_hd__inv_1
X_12215_ _06802_ VSS VSS VDD VDD _08209_ sky130_fd_sc_hd__inv_1
X_12216_ _06762_ VSS VSS VDD VDD _06808_ sky130_fd_sc_hd__inv_1
X_12217_ _06830_ VSS VSS VDD VDD _06880_ sky130_fd_sc_hd__inv_1
X_12218_ _03503_ net438 _03363_ VSS VSS VDD VDD _08214_ sky130_fd_sc_hd__nor3_1
X_12219_ _06888_ VSS VSS VDD VDD _06890_ sky130_fd_sc_hd__inv_1
X_12220_ _06843_ VSS VSS VDD VDD _06856_ sky130_fd_sc_hd__inv_1
X_12221_ _06814_ VSS VSS VDD VDD _06865_ sky130_fd_sc_hd__inv_1
X_12222_ _06832_ VSS VSS VDD VDD _06882_ sky130_fd_sc_hd__inv_1
X_12223_ _03431_ _03371_ VSS VSS VDD VDD _08229_ sky130_fd_sc_hd__and2_0
X_12224_ _06902_ VSS VSS VDD VDD _08232_ sky130_fd_sc_hd__inv_1
X_12225_ _06929_ VSS VSS VDD VDD _08240_ sky130_fd_sc_hd__inv_1
X_12226_ _03504_ net503 VSS VSS VDD VDD _08245_ sky130_fd_sc_hd__nor2_1
X_12227_ _06974_ VSS VSS VDD VDD _06976_ sky130_fd_sc_hd__inv_1
X_12228_ _06941_ VSS VSS VDD VDD _06951_ sky130_fd_sc_hd__inv_1
X_12229_ _06950_ VSS VSS VDD VDD _06987_ sky130_fd_sc_hd__inv_1
X_12230_ _06921_ VSS VSS VDD VDD _06960_ sky130_fd_sc_hd__inv_1
X_12231_ _06942_ VSS VSS VDD VDD _06971_ sky130_fd_sc_hd__inv_1
X_12232_ _06932_ VSS VSS VDD VDD _08253_ sky130_fd_sc_hd__inv_1
X_12233_ _03431_ net483 VSS VSS VDD VDD _08259_ sky130_fd_sc_hd__and2_0
X_12234_ _06984_ VSS VSS VDD VDD _06993_ sky130_fd_sc_hd__inv_1
X_12235_ _06968_ VSS VSS VDD VDD _07002_ sky130_fd_sc_hd__inv_1
X_12236_ _06985_ VSS VSS VDD VDD _07013_ sky130_fd_sc_hd__inv_1
X_12237_ _00012_ _03402_ VSS VSS VDD VDD _08270_ sky130_fd_sc_hd__and2_0
X_12238_ _07024_ VSS VSS VDD VDD _08278_ sky130_fd_sc_hd__inv_1
X_12239_ _07030_ VSS VSS VDD VDD _08282_ sky130_fd_sc_hd__inv_1
X_12240_ _07010_ VSS VSS VDD VDD _07036_ sky130_fd_sc_hd__inv_1
X_12241_ _07031_ VSS VSS VDD VDD _07041_ sky130_fd_sc_hd__inv_1
X_12242_ _03503_ _03407_ _03408_ VSS VSS VDD VDD _08288_ sky130_fd_sc_hd__nor3_1
X_12243_ _07051_ VSS VSS VDD VDD _08297_ sky130_fd_sc_hd__inv_1
X_12244_ _03504_ net501 VSS VSS VDD VDD _08302_ sky130_fd_sc_hd__nor2_1
X_12245_ _07072_ VSS VSS VDD VDD _07079_ sky130_fd_sc_hd__inv_1
X_12246_ _07073_ VSS VSS VDD VDD _07082_ sky130_fd_sc_hd__inv_1
X_12247_ _00012_ _03458_ VSS VSS VDD VDD _08333_ sky130_fd_sc_hd__and2_0
X_12248_ _07113_ _00640_ _00644_ VSS VSS VDD VDD _07122_ sky130_fd_sc_hd__o21a_1
X_12249_ _00686_ _00689_ VSS VSS VDD VDD _07125_ sky130_fd_sc_hd__nand2_1
X_12250_ _00627_ _00649_ VSS VSS VDD VDD _07134_ sky130_fd_sc_hd__nand2_1
X_12251_ _00648_ _07125_ _00693_ VSS VSS VDD VDD _07137_ sky130_fd_sc_hd__a21bo_1
X_12252_ _00767_ VSS VSS VDD VDD _07140_ sky130_fd_sc_hd__clkinv_2
X_12253_ _00870_ VSS VSS VDD VDD _07143_ sky130_fd_sc_hd__inv_1
X_12254_ _07134_ VSS VSS VDD VDD _03815_ sky130_fd_sc_hd__inv_1
X_12255_ _00674_ net6 VSS VSS VDD VDD _03816_ sky130_fd_sc_hd__nand2_1
X_12256_ net6 _03815_ _03816_ VSS VSS VDD VDD _07154_ sky130_fd_sc_hd__o21ai_2
X_12257_ _00690_ _00697_ VSS VSS VDD VDD _03817_ sky130_fd_sc_hd__nor2_4
X_12258_ _03817_ VSS VSS VDD VDD _07157_ sky130_fd_sc_hd__inv_2
X_12259_ _00675_ _00772_ VSS VSS VDD VDD _03818_ sky130_fd_sc_hd__nand2_1
X_12260_ _00675_ _00767_ _03818_ VSS VSS VDD VDD _07160_ sky130_fd_sc_hd__o21ai_0
X_12261_ _03815_ _00739_ _00676_ _00681_ VSS VSS VDD VDD _07167_
+ sky130_fd_sc_hd__o211ai_1
X_12262_ _00660_ _00717_ VSS VSS VDD VDD _03819_ sky130_fd_sc_hd__nand2_1
X_12263_ _00660_ _03817_ _03819_ VSS VSS VDD VDD _07170_ sky130_fd_sc_hd__o21ai_2
X_12264_ _00660_ _07163_ VSS VSS VDD VDD _03820_ sky130_fd_sc_hd__nor2_1
X_12265_ net36 _00876_ _03820_ VSS VSS VDD VDD _07176_ sky130_fd_sc_hd__a21oi_1
X_12266_ _00710_ _07170_ _00716_ VSS VSS VDD VDD _07187_ sky130_fd_sc_hd__a21o_1
X_12267_ _00698_ _07173_ VSS VSS VDD VDD _03821_ sky130_fd_sc_hd__nor2_1
X_12268_ _00775_ _03821_ VSS VSS VDD VDD _07190_ sky130_fd_sc_hd__nor2_1
X_12269_ _00709_ _00726_ VSS VSS VDD VDD _03822_ sky130_fd_sc_hd__nand2_1
X_12270_ _00683_ _03822_ _00842_ _00752_ VSS VSS VDD VDD _07208_
+ sky130_fd_sc_hd__a22o_1
X_12271_ _00797_ _00788_ _00824_ _00786_ VSS VSS VDD VDD _07211_
+ sky130_fd_sc_hd__o22ai_1
X_12272_ _00869_ _00825_ VSS VSS VDD VDD _03823_ sky130_fd_sc_hd__nand2_1
X_12273_ _03823_ _00912_ VSS VSS VDD VDD _07214_ sky130_fd_sc_hd__nand2_1
X_12274_ _01227_ VSS VSS VDD VDD _07311_ sky130_fd_sc_hd__inv_1
X_12275_ _02107_ VSS VSS VDD VDD _07491_ sky130_fd_sc_hd__inv_1
X_12276_ _07532_ _02307_ VSS VSS VDD VDD _07551_ sky130_fd_sc_hd__nor2_1
X_12277_ _02688_ VSS VSS VDD VDD _07585_ sky130_fd_sc_hd__inv_1
X_12278_ _05887_ _07726_ _07736_ _07760_ VSS VSS VDD VDD _03824_
+ sky130_fd_sc_hd__nor4_1
X_12279_ _07740_ _07745_ _07775_ _07790_ VSS VSS VDD VDD _03825_
+ sky130_fd_sc_hd__nor4_1
X_12280_ _07755_ _07765_ _07780_ _07785_ VSS VSS VDD VDD _03826_
+ sky130_fd_sc_hd__nor4_1
X_12281_ _07732_ _07721_ _07750_ _07770_ VSS VSS VDD VDD _03827_
+ sky130_fd_sc_hd__nor4_1
X_12282_ _03824_ _03825_ _03826_ _03827_ VSS VSS VDD VDD _07737_
+ sky130_fd_sc_hd__nand4_1
X_12283_ _07815_ VSS VSS VDD VDD _07818_ sky130_fd_sc_hd__inv_1
X_12284_ sample_count\[1\] VSS VSS VDD VDD _07828_ sky130_fd_sc_hd__inv_1
X_12285_ _07717_ VSS VSS VDD VDD _05894_ sky130_fd_sc_hd__inv_1
X_12286_ net637 _07840_ _07850_ _07904_ VSS VSS VDD VDD _03828_
+ sky130_fd_sc_hd__or4_1
X_12287_ _07854_ _07859_ _07869_ _03828_ VSS VSS VDD VDD _03829_
+ sky130_fd_sc_hd__nor4_1
X_12288_ _07864_ _07889_ _07894_ _07899_ VSS VSS VDD VDD _03830_
+ sky130_fd_sc_hd__nor4_1
X_12289_ _05902_ _07835_ VSS VSS VDD VDD _03831_ sky130_fd_sc_hd__nor2_1
X_12290_ _07874_ _07879_ _07884_ VSS VSS VDD VDD _03832_ sky130_fd_sc_hd__nor3_1
X_12291_ _03829_ _03830_ _03831_ _03832_ VSS VSS VDD VDD _07851_
+ sky130_fd_sc_hd__nand4_1
X_12292_ _05940_ VSS VSS VDD VDD _05934_ sky130_fd_sc_hd__inv_1
X_12293_ _07925_ VSS VSS VDD VDD _05926_ sky130_fd_sc_hd__inv_1
X_12294_ _07926_ VSS VSS VDD VDD _05927_ sky130_fd_sc_hd__inv_1
X_12295_ _05982_ VSS VSS VDD VDD _05977_ sky130_fd_sc_hd__inv_1
X_12296_ _03504_ _03246_ VSS VSS VDD VDD _05953_ sky130_fd_sc_hd__nor2_1
X_12297_ _06000_ VSS VSS VDD VDD _05966_ sky130_fd_sc_hd__inv_1
X_12298_ _07937_ VSS VSS VDD VDD _05990_ sky130_fd_sc_hd__inv_1
X_12299_ _03503_ _03334_ net464 VSS VSS VDD VDD _06080_ sky130_fd_sc_hd__nor3_1
X_12300_ _06021_ VSS VSS VDD VDD _06023_ sky130_fd_sc_hd__inv_1
X_12301_ _06045_ VSS VSS VDD VDD _06091_ sky130_fd_sc_hd__inv_1
X_12302_ _06126_ VSS VSS VDD VDD _06120_ sky130_fd_sc_hd__inv_1
X_12303_ _07949_ VSS VSS VDD VDD _06073_ sky130_fd_sc_hd__inv_1
X_12304_ _07960_ VSS VSS VDD VDD _06074_ sky130_fd_sc_hd__inv_1
X_12305_ _03503_ _03379_ net505 VSS VSS VDD VDD _06133_ sky130_fd_sc_hd__nor3_1
X_12306_ _06140_ VSS VSS VDD VDD _06137_ sky130_fd_sc_hd__inv_1
X_12307_ _06101_ VSS VSS VDD VDD _06144_ sky130_fd_sc_hd__inv_1
X_12308_ _07922_ VSS VSS VDD VDD _07953_ sky130_fd_sc_hd__inv_1
X_12309_ _06176_ VSS VSS VDD VDD _06172_ sky130_fd_sc_hd__inv_1
X_12310_ _06191_ VSS VSS VDD VDD _06188_ sky130_fd_sc_hd__inv_1
X_12311_ _07974_ VSS VSS VDD VDD _07966_ sky130_fd_sc_hd__inv_1
X_12312_ _06236_ VSS VSS VDD VDD _06232_ sky130_fd_sc_hd__inv_1
X_12313_ _00012_ _03430_ VSS VSS VDD VDD _06243_ sky130_fd_sc_hd__and2_0
X_12314_ _07975_ VSS VSS VDD VDD _07977_ sky130_fd_sc_hd__inv_1
X_12315_ _03504_ net456 VSS VSS VDD VDD _06293_ sky130_fd_sc_hd__nor2_1
X_12316_ _07988_ VSS VSS VDD VDD _05918_ sky130_fd_sc_hd__inv_1
X_12317_ _03503_ _03448_ _03450_ VSS VSS VDD VDD _06340_ sky130_fd_sc_hd__nor3_1
X_12318_ _06323_ VSS VSS VDD VDD _06320_ sky130_fd_sc_hd__inv_1
X_12319_ _06304_ VSS VSS VDD VDD _06306_ sky130_fd_sc_hd__inv_1
X_12320_ _07998_ VSS VSS VDD VDD _05935_ sky130_fd_sc_hd__inv_1
X_12321_ _06372_ VSS VSS VDD VDD _06368_ sky130_fd_sc_hd__inv_1
X_12322_ _08009_ VSS VSS VDD VDD _05978_ sky130_fd_sc_hd__inv_1
X_12323_ _06362_ VSS VSS VDD VDD _06360_ sky130_fd_sc_hd__inv_1
X_12324_ _06457_ VSS VSS VDD VDD _06453_ sky130_fd_sc_hd__inv_1
X_12325_ _06410_ VSS VSS VDD VDD _06405_ sky130_fd_sc_hd__inv_1
X_12326_ _08024_ VSS VSS VDD VDD _06067_ sky130_fd_sc_hd__inv_1
X_12327_ _06399_ VSS VSS VDD VDD _06397_ sky130_fd_sc_hd__inv_1
X_12328_ _03431_ _03475_ VSS VSS VDD VDD _08032_ sky130_fd_sc_hd__nand2_1
X_12329_ _06433_ VSS VSS VDD VDD _06428_ sky130_fd_sc_hd__inv_1
X_12330_ _08042_ VSS VSS VDD VDD _06121_ sky130_fd_sc_hd__inv_1
X_12331_ _06426_ VSS VSS VDD VDD _06424_ sky130_fd_sc_hd__inv_1
X_12332_ _06464_ VSS VSS VDD VDD _06459_ sky130_fd_sc_hd__inv_1
X_12333_ _06451_ VSS VSS VDD VDD _06448_ sky130_fd_sc_hd__inv_1
X_12334_ _08077_ VSS VSS VDD VDD _08064_ sky130_fd_sc_hd__inv_1
X_12335_ _07955_ VSS VSS VDD VDD _08068_ sky130_fd_sc_hd__inv_1
X_12336_ _08073_ VSS VSS VDD VDD _06478_ sky130_fd_sc_hd__inv_1
X_12337_ _08080_ VSS VSS VDD VDD _08076_ sky130_fd_sc_hd__inv_1
X_12338_ _08084_ VSS VSS VDD VDD _08079_ sky130_fd_sc_hd__inv_1
X_12339_ _08101_ VSS VSS VDD VDD _08087_ sky130_fd_sc_hd__inv_1
X_12340_ _07982_ VSS VSS VDD VDD _06481_ sky130_fd_sc_hd__inv_1
X_12341_ _06491_ VSS VSS VDD VDD _06489_ sky130_fd_sc_hd__inv_1
X_12342_ _08089_ VSS VSS VDD VDD _08098_ sky130_fd_sc_hd__inv_1
X_12343_ _06498_ VSS VSS VDD VDD _06283_ sky130_fd_sc_hd__inv_1
X_12344_ _06516_ VSS VSS VDD VDD _06513_ sky130_fd_sc_hd__inv_1
X_12345_ _06524_ VSS VSS VDD VDD _06517_ sky130_fd_sc_hd__inv_1
X_12346_ _08110_ VSS VSS VDD VDD _08117_ sky130_fd_sc_hd__inv_1
X_12347_ _08118_ _06367_ _08128_ VSS VSS VDD VDD _08125_ sky130_fd_sc_hd__a21o_1
X_12348_ _03247_ _03458_ VSS VSS VDD VDD _06532_ sky130_fd_sc_hd__and2_4
X_12349_ _06578_ VSS VSS VDD VDD _06573_ sky130_fd_sc_hd__inv_1
X_12350_ _06566_ VSS VSS VDD VDD _06568_ sky130_fd_sc_hd__inv_1
X_12351_ _06600_ VSS VSS VDD VDD _06569_ sky130_fd_sc_hd__inv_1
X_12352_ _06606_ VSS VSS VDD VDD _06603_ sky130_fd_sc_hd__inv_1
X_12353_ _03501_ _03499_ VSS VSS VDD VDD _08145_ sky130_fd_sc_hd__nor2_1
X_12354_ _06663_ VSS VSS VDD VDD _08150_ sky130_fd_sc_hd__inv_1
X_12355_ _06668_ VSS VSS VDD VDD _06666_ sky130_fd_sc_hd__inv_1
X_12356_ _03501_ _03261_ _03264_ VSS VSS VDD VDD _08154_ sky130_fd_sc_hd__nor3_1
X_12357_ _06699_ VSS VSS VDD VDD _06694_ sky130_fd_sc_hd__inv_1
X_12358_ _06719_ VSS VSS VDD VDD _06717_ sky130_fd_sc_hd__inv_1
X_12359_ _03501_ net496 _03311_ VSS VSS VDD VDD _08175_ sky130_fd_sc_hd__nor3_1
X_12360_ _06750_ VSS VSS VDD VDD _06746_ sky130_fd_sc_hd__inv_1
X_12361_ _06773_ VSS VSS VDD VDD _06771_ sky130_fd_sc_hd__inv_1
X_12362_ _03501_ net478 VSS VSS VDD VDD _08187_ sky130_fd_sc_hd__nor2_1
X_12363_ _06798_ VSS VSS VDD VDD _06794_ sky130_fd_sc_hd__inv_1
X_12364_ _06760_ VSS VSS VDD VDD _06756_ sky130_fd_sc_hd__inv_1
X_12365_ _06828_ VSS VSS VDD VDD _06825_ sky130_fd_sc_hd__inv_1
X_12366_ _00009_ _03332_ VSS VSS VDD VDD _08200_ sky130_fd_sc_hd__and2_0
X_12367_ _06854_ VSS VSS VDD VDD _06850_ sky130_fd_sc_hd__inv_1
X_12368_ _06812_ VSS VSS VDD VDD _06809_ sky130_fd_sc_hd__inv_1
X_12369_ _06885_ VSS VSS VDD VDD _06881_ sky130_fd_sc_hd__inv_1
X_12370_ _03500_ _03344_ net480 VSS VSS VDD VDD _08215_ sky130_fd_sc_hd__nor3_1
X_12371_ _06848_ VSS VSS VDD VDD _06857_ sky130_fd_sc_hd__inv_1
X_12372_ _06901_ VSS VSS VDD VDD _08217_ sky130_fd_sc_hd__inv_1
X_12373_ _06869_ VSS VSS VDD VDD _06866_ sky130_fd_sc_hd__inv_1
X_12374_ _06928_ VSS VSS VDD VDD _08224_ sky130_fd_sc_hd__inv_1
X_12375_ _03500_ net439 _03363_ VSS VSS VDD VDD _08230_ sky130_fd_sc_hd__nor3_1
X_12376_ _06918_ VSS VSS VDD VDD _06915_ sky130_fd_sc_hd__inv_1
X_12377_ _00009_ _03371_ VSS VSS VDD VDD _08246_ sky130_fd_sc_hd__and2_0
X_12378_ _03501_ net502 VSS VSS VDD VDD _08260_ sky130_fd_sc_hd__nor2_1
X_12379_ _07023_ VSS VSS VDD VDD _08262_ sky130_fd_sc_hd__inv_1
X_12380_ _07006_ VSS VSS VDD VDD _07003_ sky130_fd_sc_hd__inv_1
X_12381_ _06975_ VSS VSS VDD VDD _08267_ sky130_fd_sc_hd__inv_1
X_12382_ _00009_ net483 VSS VSS VDD VDD _08271_ sky130_fd_sc_hd__and2_0
X_12383_ _07050_ VSS VSS VDD VDD _08285_ sky130_fd_sc_hd__inv_1
X_12384_ _00009_ _03402_ VSS VSS VDD VDD _08289_ sky130_fd_sc_hd__and2_0
X_12385_ _03500_ _03407_ _03408_ VSS VSS VDD VDD _08303_ sky130_fd_sc_hd__nor3_1
X_12386_ _07102_ VSS VSS VDD VDD _08330_ sky130_fd_sc_hd__inv_1
X_12387_ _03501_ net499 VSS VSS VDD VDD _08334_ sky130_fd_sc_hd__nor2_1
X_12388_ _08074_ VSS VSS VDD VDD _08097_ sky130_fd_sc_hd__inv_1
X_12389_ _08099_ VSS VSS VDD VDD _08107_ sky130_fd_sc_hd__inv_1
X_12390_ _08148_ VSS VSS VDD VDD _06657_ sky130_fd_sc_hd__inv_1
X_12391_ _08162_ VSS VSS VDD VDD _06637_ sky130_fd_sc_hd__inv_1
X_12392_ _08177_ VSS VSS VDD VDD _06741_ sky130_fd_sc_hd__inv_1
X_12393_ _08189_ VSS VSS VDD VDD _06789_ sky130_fd_sc_hd__inv_1
X_12394_ _08202_ VSS VSS VDD VDD _06845_ sky130_fd_sc_hd__inv_1
X_12395_ _08210_ VSS VSS VDD VDD _06876_ sky130_fd_sc_hd__inv_1
X_12396_ _08275_ VSS VSS VDD VDD _07028_ sky130_fd_sc_hd__inv_1
X_12397_ _08314_ VSS VSS VDD VDD _07096_ sky130_fd_sc_hd__inv_1
X_12398_ _07930_ VSS VSS VDD VDD _05970_ sky130_fd_sc_hd__inv_1
X_12399_ _07935_ VSS VSS VDD VDD _06060_ sky130_fd_sc_hd__inv_1
X_12400_ _07946_ VSS VSS VDD VDD _06050_ sky130_fd_sc_hd__inv_1
X_12401_ _07957_ VSS VSS VDD VDD _06173_ sky130_fd_sc_hd__inv_1
X_12402_ _07962_ VSS VSS VDD VDD _06169_ sky130_fd_sc_hd__inv_1
X_12403_ _07970_ VSS VSS VDD VDD _06233_ sky130_fd_sc_hd__inv_1
X_12404_ _07971_ VSS VSS VDD VDD _06229_ sky130_fd_sc_hd__inv_1
X_12405_ _07983_ VSS VSS VDD VDD _06279_ sky130_fd_sc_hd__inv_1
X_12406_ _07985_ VSS VSS VDD VDD _06301_ sky130_fd_sc_hd__inv_1
X_12407_ _08078_ VSS VSS VDD VDD _08086_ sky130_fd_sc_hd__inv_1
X_12408_ _08085_ VSS VSS VDD VDD _08119_ sky130_fd_sc_hd__inv_1
X_12409_ _08102_ VSS VSS VDD VDD _06497_ sky130_fd_sc_hd__inv_1
X_12410_ _08228_ VSS VSS VDD VDD _06896_ sky130_fd_sc_hd__inv_1
X_12411_ _08244_ VSS VSS VDD VDD _06939_ sky130_fd_sc_hd__inv_1
X_12412_ _08258_ VSS VSS VDD VDD _06982_ sky130_fd_sc_hd__inv_1
X_12413_ _07104_ VSS VSS VDD VDD _07101_ sky130_fd_sc_hd__inv_1
X_12414_ _08272_ VSS VSS VDD VDD _07048_ sky130_fd_sc_hd__inv_1
X_12415_ sample_count\[2\] VSS VSS VDD VDD _03833_ sky130_fd_sc_hd__inv_1
X_12416_ _03137_ net91 VSS VSS VDD VDD _03834_ sky130_fd_sc_hd__nand2_1
X_12417_ bit_rev_idx\[0\] VSS VSS VDD VDD _03835_ sky130_fd_sc_hd__clkbuf_2
X_12418_ _03835_ _03834_ VSS VSS VDD VDD _03836_ sky130_fd_sc_hd__nand2_1
X_12419_ _03833_ _03834_ _03836_ VSS VSS VDD VDD _00024_ sky130_fd_sc_hd__o21ai_0
X_12420_ bit_rev_idx\[1\] VSS VSS VDD VDD _03837_ sky130_fd_sc_hd__clkbuf_2
X_12421_ _03837_ _03834_ VSS VSS VDD VDD _03838_ sky130_fd_sc_hd__nand2_1
X_12422_ _07828_ _03834_ _03838_ VSS VSS VDD VDD _00025_ sky130_fd_sc_hd__o21ai_0
X_12423_ bit_rev_idx\[2\] VSS VSS VDD VDD _03839_ sky130_fd_sc_hd__clkbuf_2
X_12424_ _03839_ _03834_ VSS VSS VDD VDD _03840_ sky130_fd_sc_hd__nand2_1
X_12425_ _07827_ _03834_ _03840_ VSS VSS VDD VDD _00026_ sky130_fd_sc_hd__o21ai_0
X_12426_ net94 VSS VSS VDD VDD _03841_ sky130_fd_sc_hd__inv_1
X_12427_ _00557_ _00559_ VSS VSS VDD VDD _03842_ sky130_fd_sc_hd__nor2_1
X_12428_ net93 _03841_ VSS VSS VDD VDD _03843_ sky130_fd_sc_hd__nor2_1
X_12429_ _03842_ _03843_ state\[0\] VSS VSS VDD VDD _03844_
+ sky130_fd_sc_hd__o21ai_0
X_12430_ _00560_ _03841_ _03844_ VSS VSS VDD VDD _00027_ sky130_fd_sc_hd__o21ai_0
X_12431_ _03137_ state\[1\] VSS VSS VDD VDD _03845_ sky130_fd_sc_hd__nor2_2
X_12432_ _03137_ _03138_ _00003_ _03845_ VSS VSS VDD VDD _03846_
+ sky130_fd_sc_hd__a211oi_4
X_12433_ _07716_ _03144_ _03846_ VSS VSS VDD VDD _03847_ sky130_fd_sc_hd__nand3_1
X_12434_ _07716_ _03846_ _03847_ VSS VSS VDD VDD _00028_ sky130_fd_sc_hd__o21ai_0
X_12435_ _07800_ _03144_ _03846_ VSS VSS VDD VDD _03848_ sky130_fd_sc_hd__nand3_1
X_12436_ _07666_ _03846_ _03848_ VSS VSS VDD VDD _00029_ sky130_fd_sc_hd__o21ai_0
X_12437_ _07801_ _03144_ _03846_ VSS VSS VDD VDD _03849_ sky130_fd_sc_hd__nand3_1
X_12438_ _00811_ _03846_ _03849_ VSS VSS VDD VDD _00030_ sky130_fd_sc_hd__o21ai_0
X_12439_ net95 samples_imag\[0\]\[0\] _00560_ VSS VSS VDD
+ VDD _00031_ sky130_fd_sc_hd__mux2_1
X_12440_ net96 samples_imag\[6\]\[4\] _00560_ VSS VSS VDD
+ VDD _00032_ sky130_fd_sc_hd__mux2_1
X_12441_ net97 samples_imag\[6\]\[5\] _00560_ VSS VSS VDD
+ VDD _00033_ sky130_fd_sc_hd__mux2_1
X_12442_ net98 samples_imag\[6\]\[6\] _00560_ VSS VSS VDD
+ VDD _00034_ sky130_fd_sc_hd__mux2_1
X_12443_ net99 samples_imag\[6\]\[7\] _00560_ VSS VSS VDD
+ VDD _00035_ sky130_fd_sc_hd__mux2_1
X_12444_ net100 samples_imag\[6\]\[8\] _00560_ VSS VSS VDD
+ VDD _00036_ sky130_fd_sc_hd__mux2_1
X_12445_ _00559_ VSS VSS VDD VDD _03850_ sky130_fd_sc_hd__buf_6
X_12446_ net101 samples_imag\[6\]\[9\] _03850_ VSS VSS VDD
+ VDD _00037_ sky130_fd_sc_hd__mux2_1
X_12447_ net102 samples_imag\[6\]\[10\] _03850_ VSS VSS VDD
+ VDD _00038_ sky130_fd_sc_hd__mux2_1
X_12448_ net103 samples_imag\[6\]\[11\] _03850_ VSS VSS VDD
+ VDD _00039_ sky130_fd_sc_hd__mux2_1
X_12449_ net104 samples_imag\[6\]\[12\] _03850_ VSS VSS VDD
+ VDD _00040_ sky130_fd_sc_hd__mux2_1
X_12450_ net105 samples_imag\[6\]\[13\] _03850_ VSS VSS VDD
+ VDD _00041_ sky130_fd_sc_hd__mux2_1
X_12451_ net106 samples_imag\[0\]\[10\] _03850_ VSS VSS VDD
+ VDD _00042_ sky130_fd_sc_hd__mux2_1
X_12452_ net107 samples_imag\[6\]\[14\] _03850_ VSS VSS VDD
+ VDD _00043_ sky130_fd_sc_hd__mux2_1
X_12453_ net108 samples_imag\[6\]\[15\] _03850_ VSS VSS VDD
+ VDD _00044_ sky130_fd_sc_hd__mux2_1
X_12454_ net109 samples_imag\[7\]\[0\] _03850_ VSS VSS VDD
+ VDD _00045_ sky130_fd_sc_hd__mux2_1
X_12455_ net110 samples_imag\[7\]\[1\] _03850_ VSS VSS VDD
+ VDD _00046_ sky130_fd_sc_hd__mux2_1
X_12456_ _00559_ VSS VSS VDD VDD _03851_ sky130_fd_sc_hd__clkbuf_4
X_12457_ net111 samples_imag\[7\]\[2\] _03851_ VSS VSS VDD
+ VDD _00047_ sky130_fd_sc_hd__mux2_1
X_12458_ net112 samples_imag\[7\]\[3\] _03851_ VSS VSS VDD
+ VDD _00048_ sky130_fd_sc_hd__mux2_1
X_12459_ net113 samples_imag\[7\]\[4\] _03851_ VSS VSS VDD
+ VDD _00049_ sky130_fd_sc_hd__mux2_1
X_12460_ net114 samples_imag\[7\]\[5\] _03851_ VSS VSS VDD
+ VDD _00050_ sky130_fd_sc_hd__mux2_1
X_12461_ net115 samples_imag\[7\]\[6\] _03851_ VSS VSS VDD
+ VDD _00051_ sky130_fd_sc_hd__mux2_1
X_12462_ net116 samples_imag\[7\]\[7\] _03851_ VSS VSS VDD
+ VDD _00052_ sky130_fd_sc_hd__mux2_1
X_12463_ net117 samples_imag\[0\]\[11\] _03851_ VSS VSS VDD
+ VDD _00053_ sky130_fd_sc_hd__mux2_1
X_12464_ net118 samples_imag\[7\]\[8\] _03851_ VSS VSS VDD
+ VDD _00054_ sky130_fd_sc_hd__mux2_1
X_12465_ net119 samples_imag\[7\]\[9\] _03851_ VSS VSS VDD
+ VDD _00055_ sky130_fd_sc_hd__mux2_1
X_12466_ net120 samples_imag\[7\]\[10\] _03851_ VSS VSS VDD
+ VDD _00056_ sky130_fd_sc_hd__mux2_1
X_12467_ _00559_ VSS VSS VDD VDD _03852_ sky130_fd_sc_hd__buf_4
X_12468_ net121 samples_imag\[7\]\[11\] _03852_ VSS VSS VDD
+ VDD _00057_ sky130_fd_sc_hd__mux2_1
X_12469_ net122 samples_imag\[7\]\[12\] _03852_ VSS VSS VDD
+ VDD _00058_ sky130_fd_sc_hd__mux2_1
X_12470_ net123 samples_imag\[7\]\[13\] _03852_ VSS VSS VDD
+ VDD _00059_ sky130_fd_sc_hd__mux2_1
X_12471_ net124 samples_imag\[7\]\[14\] _03852_ VSS VSS VDD
+ VDD _00060_ sky130_fd_sc_hd__mux2_1
X_12472_ net125 samples_imag\[7\]\[15\] _03852_ VSS VSS VDD
+ VDD _00061_ sky130_fd_sc_hd__mux2_1
X_12473_ net126 samples_imag\[0\]\[12\] _03852_ VSS VSS VDD
+ VDD _00062_ sky130_fd_sc_hd__mux2_1
X_12474_ net127 samples_imag\[0\]\[13\] _03852_ VSS VSS VDD
+ VDD _00063_ sky130_fd_sc_hd__mux2_1
X_12475_ net128 samples_imag\[0\]\[14\] _03852_ VSS VSS VDD
+ VDD _00064_ sky130_fd_sc_hd__mux2_1
X_12476_ net129 samples_imag\[0\]\[15\] _03852_ VSS VSS VDD
+ VDD _00065_ sky130_fd_sc_hd__mux2_1
X_12477_ net130 samples_imag\[1\]\[0\] _03852_ VSS VSS VDD
+ VDD _00066_ sky130_fd_sc_hd__mux2_1
X_12478_ _00559_ VSS VSS VDD VDD _03853_ sky130_fd_sc_hd__buf_6
X_12479_ net131 samples_imag\[1\]\[1\] _03853_ VSS VSS VDD
+ VDD _00067_ sky130_fd_sc_hd__mux2_1
X_12480_ net132 samples_imag\[1\]\[2\] _03853_ VSS VSS VDD
+ VDD _00068_ sky130_fd_sc_hd__mux2_1
X_12481_ net133 samples_imag\[1\]\[3\] _03853_ VSS VSS VDD
+ VDD _00069_ sky130_fd_sc_hd__mux2_1
X_12482_ net134 samples_imag\[0\]\[1\] _03853_ VSS VSS VDD
+ VDD _00070_ sky130_fd_sc_hd__mux2_1
X_12483_ net135 samples_imag\[1\]\[4\] _03853_ VSS VSS VDD
+ VDD _00071_ sky130_fd_sc_hd__mux2_1
X_12484_ net136 samples_imag\[1\]\[5\] _03853_ VSS VSS VDD
+ VDD _00072_ sky130_fd_sc_hd__mux2_1
X_12485_ net137 samples_imag\[1\]\[6\] _03853_ VSS VSS VDD
+ VDD _00073_ sky130_fd_sc_hd__mux2_1
X_12486_ net138 samples_imag\[1\]\[7\] _03853_ VSS VSS VDD
+ VDD _00074_ sky130_fd_sc_hd__mux2_1
X_12487_ net139 samples_imag\[1\]\[8\] _03853_ VSS VSS VDD
+ VDD _00075_ sky130_fd_sc_hd__mux2_1
X_12488_ net140 samples_imag\[1\]\[9\] _03853_ VSS VSS VDD
+ VDD _00076_ sky130_fd_sc_hd__mux2_1
X_12489_ _00559_ VSS VSS VDD VDD _03854_ sky130_fd_sc_hd__clkbuf_8
X_12490_ net141 samples_imag\[1\]\[10\] _03854_ VSS VSS VDD
+ VDD _00077_ sky130_fd_sc_hd__mux2_1
X_12491_ net142 samples_imag\[1\]\[11\] _03854_ VSS VSS VDD
+ VDD _00078_ sky130_fd_sc_hd__mux2_1
X_12492_ net143 samples_imag\[1\]\[12\] _03854_ VSS VSS VDD
+ VDD _00079_ sky130_fd_sc_hd__mux2_1
X_12493_ net144 samples_imag\[1\]\[13\] _03854_ VSS VSS VDD
+ VDD _00080_ sky130_fd_sc_hd__mux2_1
X_12494_ net145 samples_imag\[0\]\[2\] _03854_ VSS VSS VDD
+ VDD _00081_ sky130_fd_sc_hd__mux2_1
X_12495_ net146 samples_imag\[1\]\[14\] _03854_ VSS VSS VDD
+ VDD _00082_ sky130_fd_sc_hd__mux2_1
X_12496_ net147 samples_imag\[1\]\[15\] _03854_ VSS VSS VDD
+ VDD _00083_ sky130_fd_sc_hd__mux2_1
X_12497_ net148 samples_imag\[2\]\[0\] _03854_ VSS VSS VDD
+ VDD _00084_ sky130_fd_sc_hd__mux2_1
X_12498_ net149 samples_imag\[2\]\[1\] _03854_ VSS VSS VDD
+ VDD _00085_ sky130_fd_sc_hd__mux2_1
X_12499_ net150 samples_imag\[2\]\[2\] _03854_ VSS VSS VDD
+ VDD _00086_ sky130_fd_sc_hd__mux2_1
X_12500_ _00559_ VSS VSS VDD VDD _03855_ sky130_fd_sc_hd__buf_6
X_12501_ net151 samples_imag\[2\]\[3\] _03855_ VSS VSS VDD
+ VDD _00087_ sky130_fd_sc_hd__mux2_1
X_12502_ net152 samples_imag\[2\]\[4\] _03855_ VSS VSS VDD
+ VDD _00088_ sky130_fd_sc_hd__mux2_1
X_12503_ net153 samples_imag\[2\]\[5\] _03855_ VSS VSS VDD
+ VDD _00089_ sky130_fd_sc_hd__mux2_1
X_12504_ net154 samples_imag\[2\]\[6\] _03855_ VSS VSS VDD
+ VDD _00090_ sky130_fd_sc_hd__mux2_1
X_12505_ net155 samples_imag\[2\]\[7\] _03855_ VSS VSS VDD
+ VDD _00091_ sky130_fd_sc_hd__mux2_1
X_12506_ net156 samples_imag\[0\]\[3\] _03855_ VSS VSS VDD
+ VDD _00092_ sky130_fd_sc_hd__mux2_1
X_12507_ net157 samples_imag\[2\]\[8\] _03855_ VSS VSS VDD
+ VDD _00093_ sky130_fd_sc_hd__mux2_1
X_12508_ net158 samples_imag\[2\]\[9\] _03855_ VSS VSS VDD
+ VDD _00094_ sky130_fd_sc_hd__mux2_1
X_12509_ net159 samples_imag\[2\]\[10\] _03855_ VSS VSS VDD
+ VDD _00095_ sky130_fd_sc_hd__mux2_1
X_12510_ net160 samples_imag\[2\]\[11\] _03855_ VSS VSS VDD
+ VDD _00096_ sky130_fd_sc_hd__mux2_1
X_12511_ _00559_ VSS VSS VDD VDD _03856_ sky130_fd_sc_hd__buf_4
X_12512_ net161 samples_imag\[2\]\[12\] _03856_ VSS VSS VDD
+ VDD _00097_ sky130_fd_sc_hd__mux2_1
X_12513_ net162 samples_imag\[2\]\[13\] _03856_ VSS VSS VDD
+ VDD _00098_ sky130_fd_sc_hd__mux2_1
X_12514_ net163 samples_imag\[2\]\[14\] _03856_ VSS VSS VDD
+ VDD _00099_ sky130_fd_sc_hd__mux2_1
X_12515_ net164 samples_imag\[2\]\[15\] _03856_ VSS VSS VDD
+ VDD _00100_ sky130_fd_sc_hd__mux2_1
X_12516_ net165 samples_imag\[3\]\[0\] _03856_ VSS VSS VDD
+ VDD _00101_ sky130_fd_sc_hd__mux2_1
X_12517_ net166 samples_imag\[3\]\[1\] _03856_ VSS VSS VDD
+ VDD _00102_ sky130_fd_sc_hd__mux2_1
X_12518_ net167 samples_imag\[0\]\[4\] _03856_ VSS VSS VDD
+ VDD _00103_ sky130_fd_sc_hd__mux2_1
X_12519_ net168 samples_imag\[3\]\[2\] _03856_ VSS VSS VDD
+ VDD _00104_ sky130_fd_sc_hd__mux2_1
X_12520_ net169 samples_imag\[3\]\[3\] _03856_ VSS VSS VDD
+ VDD _00105_ sky130_fd_sc_hd__mux2_1
X_12521_ net170 samples_imag\[3\]\[4\] _03856_ VSS VSS VDD
+ VDD _00106_ sky130_fd_sc_hd__mux2_1
X_12522_ _00559_ VSS VSS VDD VDD _03857_ sky130_fd_sc_hd__buf_6
X_12523_ net171 samples_imag\[3\]\[5\] _03857_ VSS VSS VDD
+ VDD _00107_ sky130_fd_sc_hd__mux2_1
X_12524_ net172 samples_imag\[3\]\[6\] _03857_ VSS VSS VDD
+ VDD _00108_ sky130_fd_sc_hd__mux2_1
X_12525_ net173 samples_imag\[3\]\[7\] _03857_ VSS VSS VDD
+ VDD _00109_ sky130_fd_sc_hd__mux2_1
X_12526_ net174 samples_imag\[3\]\[8\] _03857_ VSS VSS VDD
+ VDD _00110_ sky130_fd_sc_hd__mux2_1
X_12527_ net175 samples_imag\[3\]\[9\] _03857_ VSS VSS VDD
+ VDD _00111_ sky130_fd_sc_hd__mux2_1
X_12528_ net176 samples_imag\[3\]\[10\] _03857_ VSS VSS VDD
+ VDD _00112_ sky130_fd_sc_hd__mux2_1
X_12529_ net177 samples_imag\[3\]\[11\] _03857_ VSS VSS VDD
+ VDD _00113_ sky130_fd_sc_hd__mux2_1
X_12530_ net178 samples_imag\[0\]\[5\] _03857_ VSS VSS VDD
+ VDD _00114_ sky130_fd_sc_hd__mux2_1
X_12531_ net179 samples_imag\[3\]\[12\] _03857_ VSS VSS VDD
+ VDD _00115_ sky130_fd_sc_hd__mux2_1
X_12532_ net180 samples_imag\[3\]\[13\] _03857_ VSS VSS VDD
+ VDD _00116_ sky130_fd_sc_hd__mux2_1
X_12533_ _00558_ VSS VSS VDD VDD _03858_ sky130_fd_sc_hd__buf_6
X_12534_ _03858_ VSS VSS VDD VDD _03859_ sky130_fd_sc_hd__clkbuf_4
X_12535_ net181 samples_imag\[3\]\[14\] _03859_ VSS VSS VDD
+ VDD _00117_ sky130_fd_sc_hd__mux2_1
X_12536_ net182 samples_imag\[3\]\[15\] _03859_ VSS VSS VDD
+ VDD _00118_ sky130_fd_sc_hd__mux2_1
X_12537_ net183 samples_imag\[4\]\[0\] _03859_ VSS VSS VDD
+ VDD _00119_ sky130_fd_sc_hd__mux2_1
X_12538_ net184 samples_imag\[4\]\[1\] _03859_ VSS VSS VDD
+ VDD _00120_ sky130_fd_sc_hd__mux2_1
X_12539_ net185 samples_imag\[4\]\[2\] _03859_ VSS VSS VDD
+ VDD _00121_ sky130_fd_sc_hd__mux2_1
X_12540_ net186 samples_imag\[4\]\[3\] _03859_ VSS VSS VDD
+ VDD _00122_ sky130_fd_sc_hd__mux2_1
X_12541_ net187 samples_imag\[4\]\[4\] _03859_ VSS VSS VDD
+ VDD _00123_ sky130_fd_sc_hd__mux2_1
X_12542_ net188 samples_imag\[4\]\[5\] _03859_ VSS VSS VDD
+ VDD _00124_ sky130_fd_sc_hd__mux2_1
X_12543_ net189 samples_imag\[0\]\[6\] _03859_ VSS VSS VDD
+ VDD _00125_ sky130_fd_sc_hd__mux2_1
X_12544_ net190 samples_imag\[4\]\[6\] _03859_ VSS VSS VDD
+ VDD _00126_ sky130_fd_sc_hd__mux2_1
X_12545_ _03858_ VSS VSS VDD VDD _03860_ sky130_fd_sc_hd__clkbuf_4
X_12546_ net191 samples_imag\[4\]\[7\] _03860_ VSS VSS VDD
+ VDD _00127_ sky130_fd_sc_hd__mux2_1
X_12547_ net192 samples_imag\[4\]\[8\] _03860_ VSS VSS VDD
+ VDD _00128_ sky130_fd_sc_hd__mux2_1
X_12548_ net193 samples_imag\[4\]\[9\] _03860_ VSS VSS VDD
+ VDD _00129_ sky130_fd_sc_hd__mux2_1
X_12549_ net194 samples_imag\[4\]\[10\] _03860_ VSS VSS VDD
+ VDD _00130_ sky130_fd_sc_hd__mux2_1
X_12550_ net195 samples_imag\[4\]\[11\] _03860_ VSS VSS VDD
+ VDD _00131_ sky130_fd_sc_hd__mux2_1
X_12551_ net196 samples_imag\[4\]\[12\] _03860_ VSS VSS VDD
+ VDD _00132_ sky130_fd_sc_hd__mux2_1
X_12552_ net197 samples_imag\[4\]\[13\] _03860_ VSS VSS VDD
+ VDD _00133_ sky130_fd_sc_hd__mux2_1
X_12553_ net198 samples_imag\[4\]\[14\] _03860_ VSS VSS VDD
+ VDD _00134_ sky130_fd_sc_hd__mux2_1
X_12554_ net199 samples_imag\[4\]\[15\] _03860_ VSS VSS VDD
+ VDD _00135_ sky130_fd_sc_hd__mux2_1
X_12555_ net200 samples_imag\[0\]\[7\] _03860_ VSS VSS VDD
+ VDD _00136_ sky130_fd_sc_hd__mux2_1
X_12556_ _03858_ VSS VSS VDD VDD _03861_ sky130_fd_sc_hd__clkbuf_4
X_12557_ net201 samples_imag\[5\]\[0\] _03861_ VSS VSS VDD
+ VDD _00137_ sky130_fd_sc_hd__mux2_1
X_12558_ net202 samples_imag\[5\]\[1\] _03861_ VSS VSS VDD
+ VDD _00138_ sky130_fd_sc_hd__mux2_1
X_12559_ net203 samples_imag\[5\]\[2\] _03861_ VSS VSS VDD
+ VDD _00139_ sky130_fd_sc_hd__mux2_1
X_12560_ net204 samples_imag\[5\]\[3\] _03861_ VSS VSS VDD
+ VDD _00140_ sky130_fd_sc_hd__mux2_1
X_12561_ net205 samples_imag\[5\]\[4\] _03861_ VSS VSS VDD
+ VDD _00141_ sky130_fd_sc_hd__mux2_1
X_12562_ net206 samples_imag\[5\]\[5\] _03861_ VSS VSS VDD
+ VDD _00142_ sky130_fd_sc_hd__mux2_1
X_12563_ net207 samples_imag\[5\]\[6\] _03861_ VSS VSS VDD
+ VDD _00143_ sky130_fd_sc_hd__mux2_1
X_12564_ net208 samples_imag\[5\]\[7\] _03861_ VSS VSS VDD
+ VDD _00144_ sky130_fd_sc_hd__mux2_1
X_12565_ net209 samples_imag\[5\]\[8\] _03861_ VSS VSS VDD
+ VDD _00145_ sky130_fd_sc_hd__mux2_1
X_12566_ net210 samples_imag\[5\]\[9\] _03861_ VSS VSS VDD
+ VDD _00146_ sky130_fd_sc_hd__mux2_1
X_12567_ _03858_ VSS VSS VDD VDD _03862_ sky130_fd_sc_hd__buf_4
X_12568_ net211 samples_imag\[0\]\[8\] _03862_ VSS VSS VDD
+ VDD _00147_ sky130_fd_sc_hd__mux2_1
X_12569_ net212 samples_imag\[5\]\[10\] _03862_ VSS VSS VDD
+ VDD _00148_ sky130_fd_sc_hd__mux2_1
X_12570_ net213 samples_imag\[5\]\[11\] _03862_ VSS VSS VDD
+ VDD _00149_ sky130_fd_sc_hd__mux2_1
X_12571_ net214 samples_imag\[5\]\[12\] _03862_ VSS VSS VDD
+ VDD _00150_ sky130_fd_sc_hd__mux2_1
X_12572_ net215 samples_imag\[5\]\[13\] _03862_ VSS VSS VDD
+ VDD _00151_ sky130_fd_sc_hd__mux2_1
X_12573_ net216 samples_imag\[5\]\[14\] _03862_ VSS VSS VDD
+ VDD _00152_ sky130_fd_sc_hd__mux2_1
X_12574_ net217 samples_imag\[5\]\[15\] _03862_ VSS VSS VDD
+ VDD _00153_ sky130_fd_sc_hd__mux2_1
X_12575_ net218 samples_imag\[6\]\[0\] _03862_ VSS VSS VDD
+ VDD _00154_ sky130_fd_sc_hd__mux2_1
X_12576_ net219 samples_imag\[6\]\[1\] _03862_ VSS VSS VDD
+ VDD _00155_ sky130_fd_sc_hd__mux2_1
X_12577_ net220 samples_imag\[6\]\[2\] _03862_ VSS VSS VDD
+ VDD _00156_ sky130_fd_sc_hd__mux2_1
X_12578_ _03858_ VSS VSS VDD VDD _03863_ sky130_fd_sc_hd__buf_4
X_12579_ net221 samples_imag\[6\]\[3\] _03863_ VSS VSS VDD
+ VDD _00157_ sky130_fd_sc_hd__mux2_1
X_12580_ net222 samples_imag\[0\]\[9\] _03863_ VSS VSS VDD
+ VDD _00158_ sky130_fd_sc_hd__mux2_1
X_12581_ net223 samples_real\[0\]\[0\] _03863_ VSS VSS VDD
+ VDD _00159_ sky130_fd_sc_hd__mux2_1
X_12582_ net224 samples_real\[6\]\[4\] _03863_ VSS VSS VDD
+ VDD _00160_ sky130_fd_sc_hd__mux2_1
X_12583_ net225 samples_real\[6\]\[5\] _03863_ VSS VSS VDD
+ VDD _00161_ sky130_fd_sc_hd__mux2_1
X_12584_ net226 samples_real\[6\]\[6\] _03863_ VSS VSS VDD
+ VDD _00162_ sky130_fd_sc_hd__mux2_1
X_12585_ net227 samples_real\[6\]\[7\] _03863_ VSS VSS VDD
+ VDD _00163_ sky130_fd_sc_hd__mux2_1
X_12586_ net228 samples_real\[6\]\[8\] _03863_ VSS VSS VDD
+ VDD _00164_ sky130_fd_sc_hd__mux2_1
X_12587_ net229 samples_real\[6\]\[9\] _03863_ VSS VSS VDD
+ VDD _00165_ sky130_fd_sc_hd__mux2_1
X_12588_ net230 samples_real\[6\]\[10\] _03863_ VSS VSS VDD
+ VDD _00166_ sky130_fd_sc_hd__mux2_1
X_12589_ _03858_ VSS VSS VDD VDD _03864_ sky130_fd_sc_hd__buf_4
X_12590_ net231 samples_real\[6\]\[11\] _03864_ VSS VSS VDD
+ VDD _00167_ sky130_fd_sc_hd__mux2_1
X_12591_ net232 samples_real\[6\]\[12\] _03864_ VSS VSS VDD
+ VDD _00168_ sky130_fd_sc_hd__mux2_1
X_12592_ net233 samples_real\[6\]\[13\] _03864_ VSS VSS VDD
+ VDD _00169_ sky130_fd_sc_hd__mux2_1
X_12593_ net234 samples_real\[0\]\[10\] _03864_ VSS VSS VDD
+ VDD _00170_ sky130_fd_sc_hd__mux2_1
X_12594_ net235 samples_real\[6\]\[14\] _03864_ VSS VSS VDD
+ VDD _00171_ sky130_fd_sc_hd__mux2_1
X_12595_ net236 samples_real\[6\]\[15\] _03864_ VSS VSS VDD
+ VDD _00172_ sky130_fd_sc_hd__mux2_1
X_12596_ net237 samples_real\[7\]\[0\] _03864_ VSS VSS VDD
+ VDD _00173_ sky130_fd_sc_hd__mux2_1
X_12597_ net238 samples_real\[7\]\[1\] _03864_ VSS VSS VDD
+ VDD _00174_ sky130_fd_sc_hd__mux2_1
X_12598_ net239 samples_real\[7\]\[2\] _03864_ VSS VSS VDD
+ VDD _00175_ sky130_fd_sc_hd__mux2_1
X_12599_ net240 samples_real\[7\]\[3\] _03864_ VSS VSS VDD
+ VDD _00176_ sky130_fd_sc_hd__mux2_1
X_12600_ _03858_ VSS VSS VDD VDD _03865_ sky130_fd_sc_hd__buf_4
X_12601_ net241 samples_real\[7\]\[4\] _03865_ VSS VSS VDD
+ VDD _00177_ sky130_fd_sc_hd__mux2_1
X_12602_ net242 samples_real\[7\]\[5\] _03865_ VSS VSS VDD
+ VDD _00178_ sky130_fd_sc_hd__mux2_1
X_12603_ net243 samples_real\[7\]\[6\] _03865_ VSS VSS VDD
+ VDD _00179_ sky130_fd_sc_hd__mux2_1
X_12604_ net244 samples_real\[7\]\[7\] _03865_ VSS VSS VDD
+ VDD _00180_ sky130_fd_sc_hd__mux2_1
X_12605_ net245 samples_real\[0\]\[11\] _03865_ VSS VSS VDD
+ VDD _00181_ sky130_fd_sc_hd__mux2_1
X_12606_ net246 samples_real\[7\]\[8\] _03865_ VSS VSS VDD
+ VDD _00182_ sky130_fd_sc_hd__mux2_1
X_12607_ net247 samples_real\[7\]\[9\] _03865_ VSS VSS VDD
+ VDD _00183_ sky130_fd_sc_hd__mux2_1
X_12608_ net248 samples_real\[7\]\[10\] _03865_ VSS VSS VDD
+ VDD _00184_ sky130_fd_sc_hd__mux2_1
X_12609_ net249 samples_real\[7\]\[11\] _03865_ VSS VSS VDD
+ VDD _00185_ sky130_fd_sc_hd__mux2_1
X_12610_ net250 samples_real\[7\]\[12\] _03865_ VSS VSS VDD
+ VDD _00186_ sky130_fd_sc_hd__mux2_1
X_12611_ _03858_ VSS VSS VDD VDD _03866_ sky130_fd_sc_hd__buf_6
X_12612_ net251 samples_real\[7\]\[13\] _03866_ VSS VSS VDD
+ VDD _00187_ sky130_fd_sc_hd__mux2_1
X_12613_ net252 samples_real\[7\]\[14\] _03866_ VSS VSS VDD
+ VDD _00188_ sky130_fd_sc_hd__mux2_1
X_12614_ net253 samples_real\[7\]\[15\] _03866_ VSS VSS VDD
+ VDD _00189_ sky130_fd_sc_hd__mux2_1
X_12615_ net254 samples_real\[0\]\[12\] _03866_ VSS VSS VDD
+ VDD _00190_ sky130_fd_sc_hd__mux2_1
X_12616_ net255 samples_real\[0\]\[13\] _03866_ VSS VSS VDD
+ VDD _00191_ sky130_fd_sc_hd__mux2_1
X_12617_ net256 samples_real\[0\]\[14\] _03866_ VSS VSS VDD
+ VDD _00192_ sky130_fd_sc_hd__mux2_1
X_12618_ net257 samples_real\[0\]\[15\] _03866_ VSS VSS VDD
+ VDD _00193_ sky130_fd_sc_hd__mux2_1
X_12619_ net258 samples_real\[1\]\[0\] _03866_ VSS VSS VDD
+ VDD _00194_ sky130_fd_sc_hd__mux2_1
X_12620_ net259 samples_real\[1\]\[1\] _03866_ VSS VSS VDD
+ VDD _00195_ sky130_fd_sc_hd__mux2_1
X_12621_ net260 samples_real\[1\]\[2\] _03866_ VSS VSS VDD
+ VDD _00196_ sky130_fd_sc_hd__mux2_1
X_12622_ _03858_ VSS VSS VDD VDD _03867_ sky130_fd_sc_hd__clkbuf_4
X_12623_ net261 samples_real\[1\]\[3\] _03867_ VSS VSS VDD
+ VDD _00197_ sky130_fd_sc_hd__mux2_1
X_12624_ net262 samples_real\[0\]\[1\] _03867_ VSS VSS VDD
+ VDD _00198_ sky130_fd_sc_hd__mux2_1
X_12625_ net263 samples_real\[1\]\[4\] _03867_ VSS VSS VDD
+ VDD _00199_ sky130_fd_sc_hd__mux2_1
X_12626_ net264 samples_real\[1\]\[5\] _03867_ VSS VSS VDD
+ VDD _00200_ sky130_fd_sc_hd__mux2_1
X_12627_ net265 samples_real\[1\]\[6\] _03867_ VSS VSS VDD
+ VDD _00201_ sky130_fd_sc_hd__mux2_1
X_12628_ net266 samples_real\[1\]\[7\] _03867_ VSS VSS VDD
+ VDD _00202_ sky130_fd_sc_hd__mux2_1
X_12629_ net267 samples_real\[1\]\[8\] _03867_ VSS VSS VDD
+ VDD _00203_ sky130_fd_sc_hd__mux2_1
X_12630_ net268 samples_real\[1\]\[9\] _03867_ VSS VSS VDD
+ VDD _00204_ sky130_fd_sc_hd__mux2_1
X_12631_ net269 samples_real\[1\]\[10\] _03867_ VSS VSS VDD
+ VDD _00205_ sky130_fd_sc_hd__mux2_1
X_12632_ net270 samples_real\[1\]\[11\] _03867_ VSS VSS VDD
+ VDD _00206_ sky130_fd_sc_hd__mux2_1
X_12633_ _03858_ VSS VSS VDD VDD _03868_ sky130_fd_sc_hd__buf_4
X_12634_ net271 samples_real\[1\]\[12\] _03868_ VSS VSS VDD
+ VDD _00207_ sky130_fd_sc_hd__mux2_1
X_12635_ net272 samples_real\[1\]\[13\] _03868_ VSS VSS VDD
+ VDD _00208_ sky130_fd_sc_hd__mux2_1
X_12636_ net273 samples_real\[0\]\[2\] _03868_ VSS VSS VDD
+ VDD _00209_ sky130_fd_sc_hd__mux2_1
X_12637_ net274 samples_real\[1\]\[14\] _03868_ VSS VSS VDD
+ VDD _00210_ sky130_fd_sc_hd__mux2_1
X_12638_ net275 samples_real\[1\]\[15\] _03868_ VSS VSS VDD
+ VDD _00211_ sky130_fd_sc_hd__mux2_1
X_12639_ net276 samples_real\[2\]\[0\] _03868_ VSS VSS VDD
+ VDD _00212_ sky130_fd_sc_hd__mux2_1
X_12640_ net277 samples_real\[2\]\[1\] _03868_ VSS VSS VDD
+ VDD _00213_ sky130_fd_sc_hd__mux2_1
X_12641_ net278 samples_real\[2\]\[2\] _03868_ VSS VSS VDD
+ VDD _00214_ sky130_fd_sc_hd__mux2_1
X_12642_ net279 samples_real\[2\]\[3\] _03868_ VSS VSS VDD
+ VDD _00215_ sky130_fd_sc_hd__mux2_1
X_12643_ net280 samples_real\[2\]\[4\] _03868_ VSS VSS VDD
+ VDD _00216_ sky130_fd_sc_hd__mux2_1
X_12644_ _00558_ VSS VSS VDD VDD _03869_ sky130_fd_sc_hd__clkbuf_4
X_12645_ net281 samples_real\[2\]\[5\] _03869_ VSS VSS VDD
+ VDD _00217_ sky130_fd_sc_hd__mux2_1
X_12646_ net282 samples_real\[2\]\[6\] _03869_ VSS VSS VDD
+ VDD _00218_ sky130_fd_sc_hd__mux2_1
X_12647_ net283 samples_real\[2\]\[7\] _03869_ VSS VSS VDD
+ VDD _00219_ sky130_fd_sc_hd__mux2_1
X_12648_ net284 samples_real\[0\]\[3\] _03869_ VSS VSS VDD
+ VDD _00220_ sky130_fd_sc_hd__mux2_1
X_12649_ net285 samples_real\[2\]\[8\] _03869_ VSS VSS VDD
+ VDD _00221_ sky130_fd_sc_hd__mux2_1
X_12650_ net286 samples_real\[2\]\[9\] _03869_ VSS VSS VDD
+ VDD _00222_ sky130_fd_sc_hd__mux2_1
X_12651_ net287 samples_real\[2\]\[10\] _03869_ VSS VSS VDD
+ VDD _00223_ sky130_fd_sc_hd__mux2_1
X_12652_ net288 samples_real\[2\]\[11\] _03869_ VSS VSS VDD
+ VDD _00224_ sky130_fd_sc_hd__mux2_1
X_12653_ net289 samples_real\[2\]\[12\] _03869_ VSS VSS VDD
+ VDD _00225_ sky130_fd_sc_hd__mux2_1
X_12654_ net290 samples_real\[2\]\[13\] _03869_ VSS VSS VDD
+ VDD _00226_ sky130_fd_sc_hd__mux2_1
X_12655_ _00558_ VSS VSS VDD VDD _03870_ sky130_fd_sc_hd__buf_4
X_12656_ net291 samples_real\[2\]\[14\] _03870_ VSS VSS VDD
+ VDD _00227_ sky130_fd_sc_hd__mux2_1
X_12657_ net292 samples_real\[2\]\[15\] _03870_ VSS VSS VDD
+ VDD _00228_ sky130_fd_sc_hd__mux2_1
X_12658_ net293 samples_real\[3\]\[0\] _03870_ VSS VSS VDD
+ VDD _00229_ sky130_fd_sc_hd__mux2_1
X_12659_ net294 samples_real\[3\]\[1\] _03870_ VSS VSS VDD
+ VDD _00230_ sky130_fd_sc_hd__mux2_1
X_12660_ net295 samples_real\[0\]\[4\] _03870_ VSS VSS VDD
+ VDD _00231_ sky130_fd_sc_hd__mux2_1
X_12661_ net296 samples_real\[3\]\[2\] _03870_ VSS VSS VDD
+ VDD _00232_ sky130_fd_sc_hd__mux2_1
X_12662_ net297 samples_real\[3\]\[3\] _03870_ VSS VSS VDD
+ VDD _00233_ sky130_fd_sc_hd__mux2_1
X_12663_ net298 samples_real\[3\]\[4\] _03870_ VSS VSS VDD
+ VDD _00234_ sky130_fd_sc_hd__mux2_1
X_12664_ net299 samples_real\[3\]\[5\] _03870_ VSS VSS VDD
+ VDD _00235_ sky130_fd_sc_hd__mux2_1
X_12665_ net300 samples_real\[3\]\[6\] _03870_ VSS VSS VDD
+ VDD _00236_ sky130_fd_sc_hd__mux2_1
X_12666_ _00558_ VSS VSS VDD VDD _03871_ sky130_fd_sc_hd__clkbuf_4
X_12667_ net301 samples_real\[3\]\[7\] _03871_ VSS VSS VDD
+ VDD _00237_ sky130_fd_sc_hd__mux2_1
X_12668_ net302 samples_real\[3\]\[8\] _03871_ VSS VSS VDD
+ VDD _00238_ sky130_fd_sc_hd__mux2_1
X_12669_ net303 samples_real\[3\]\[9\] _03871_ VSS VSS VDD
+ VDD _00239_ sky130_fd_sc_hd__mux2_1
X_12670_ net304 samples_real\[3\]\[10\] _03871_ VSS VSS VDD
+ VDD _00240_ sky130_fd_sc_hd__mux2_1
X_12671_ net305 samples_real\[3\]\[11\] _03871_ VSS VSS VDD
+ VDD _00241_ sky130_fd_sc_hd__mux2_1
X_12672_ net306 samples_real\[0\]\[5\] _03871_ VSS VSS VDD
+ VDD _00242_ sky130_fd_sc_hd__mux2_1
X_12673_ net307 samples_real\[3\]\[12\] _03871_ VSS VSS VDD
+ VDD _00243_ sky130_fd_sc_hd__mux2_1
X_12674_ net308 samples_real\[3\]\[13\] _03871_ VSS VSS VDD
+ VDD _00244_ sky130_fd_sc_hd__mux2_1
X_12675_ net309 samples_real\[3\]\[14\] _03871_ VSS VSS VDD
+ VDD _00245_ sky130_fd_sc_hd__mux2_1
X_12676_ net310 samples_real\[3\]\[15\] _03871_ VSS VSS VDD
+ VDD _00246_ sky130_fd_sc_hd__mux2_1
X_12677_ _00558_ VSS VSS VDD VDD _03872_ sky130_fd_sc_hd__buf_4
X_12678_ net311 samples_real\[4\]\[0\] _03872_ VSS VSS VDD
+ VDD _00247_ sky130_fd_sc_hd__mux2_1
X_12679_ net312 samples_real\[4\]\[1\] _03872_ VSS VSS VDD
+ VDD _00248_ sky130_fd_sc_hd__mux2_1
X_12680_ net313 samples_real\[4\]\[2\] _03872_ VSS VSS VDD
+ VDD _00249_ sky130_fd_sc_hd__mux2_1
X_12681_ net314 samples_real\[4\]\[3\] _03872_ VSS VSS VDD
+ VDD _00250_ sky130_fd_sc_hd__mux2_1
X_12682_ net315 samples_real\[4\]\[4\] _03872_ VSS VSS VDD
+ VDD _00251_ sky130_fd_sc_hd__mux2_1
X_12683_ net316 samples_real\[4\]\[5\] _03872_ VSS VSS VDD
+ VDD _00252_ sky130_fd_sc_hd__mux2_1
X_12684_ net317 samples_real\[0\]\[6\] _03872_ VSS VSS VDD
+ VDD _00253_ sky130_fd_sc_hd__mux2_1
X_12685_ net318 samples_real\[4\]\[6\] _03872_ VSS VSS VDD
+ VDD _00254_ sky130_fd_sc_hd__mux2_1
X_12686_ net319 samples_real\[4\]\[7\] _03872_ VSS VSS VDD
+ VDD _00255_ sky130_fd_sc_hd__mux2_1
X_12687_ net320 samples_real\[4\]\[8\] _03872_ VSS VSS VDD
+ VDD _00256_ sky130_fd_sc_hd__mux2_1
X_12688_ _00558_ VSS VSS VDD VDD _03873_ sky130_fd_sc_hd__clkbuf_4
X_12689_ net321 samples_real\[4\]\[9\] _03873_ VSS VSS VDD
+ VDD _00257_ sky130_fd_sc_hd__mux2_1
X_12690_ net322 samples_real\[4\]\[10\] _03873_ VSS VSS VDD
+ VDD _00258_ sky130_fd_sc_hd__mux2_1
X_12691_ net323 samples_real\[4\]\[11\] _03873_ VSS VSS VDD
+ VDD _00259_ sky130_fd_sc_hd__mux2_1
X_12692_ net324 samples_real\[4\]\[12\] _03873_ VSS VSS VDD
+ VDD _00260_ sky130_fd_sc_hd__mux2_1
X_12693_ net325 samples_real\[4\]\[13\] _03873_ VSS VSS VDD
+ VDD _00261_ sky130_fd_sc_hd__mux2_1
X_12694_ net326 samples_real\[4\]\[14\] _03873_ VSS VSS VDD
+ VDD _00262_ sky130_fd_sc_hd__mux2_1
X_12695_ net327 samples_real\[4\]\[15\] _03873_ VSS VSS VDD
+ VDD _00263_ sky130_fd_sc_hd__mux2_1
X_12696_ net328 samples_real\[0\]\[7\] _03873_ VSS VSS VDD
+ VDD _00264_ sky130_fd_sc_hd__mux2_1
X_12697_ net329 samples_real\[5\]\[0\] _03873_ VSS VSS VDD
+ VDD _00265_ sky130_fd_sc_hd__mux2_1
X_12698_ net330 samples_real\[5\]\[1\] _03873_ VSS VSS VDD
+ VDD _00266_ sky130_fd_sc_hd__mux2_1
X_12699_ _00558_ VSS VSS VDD VDD _03874_ sky130_fd_sc_hd__clkbuf_4
X_12700_ net331 samples_real\[5\]\[2\] _03874_ VSS VSS VDD
+ VDD _00267_ sky130_fd_sc_hd__mux2_1
X_12701_ net332 samples_real\[5\]\[3\] _03874_ VSS VSS VDD
+ VDD _00268_ sky130_fd_sc_hd__mux2_1
X_12702_ net333 samples_real\[5\]\[4\] _03874_ VSS VSS VDD
+ VDD _00269_ sky130_fd_sc_hd__mux2_1
X_12703_ net334 samples_real\[5\]\[5\] _03874_ VSS VSS VDD
+ VDD _00270_ sky130_fd_sc_hd__mux2_1
X_12704_ net335 samples_real\[5\]\[6\] _03874_ VSS VSS VDD
+ VDD _00271_ sky130_fd_sc_hd__mux2_1
X_12705_ net336 samples_real\[5\]\[7\] _03874_ VSS VSS VDD
+ VDD _00272_ sky130_fd_sc_hd__mux2_1
X_12706_ net337 samples_real\[5\]\[8\] _03874_ VSS VSS VDD
+ VDD _00273_ sky130_fd_sc_hd__mux2_1
X_12707_ net338 samples_real\[5\]\[9\] _03874_ VSS VSS VDD
+ VDD _00274_ sky130_fd_sc_hd__mux2_1
X_12708_ net339 samples_real\[0\]\[8\] _03874_ VSS VSS VDD
+ VDD _00275_ sky130_fd_sc_hd__mux2_1
X_12709_ net340 samples_real\[5\]\[10\] _03874_ VSS VSS VDD
+ VDD _00276_ sky130_fd_sc_hd__mux2_1
X_12710_ _00558_ VSS VSS VDD VDD _03875_ sky130_fd_sc_hd__buf_4
X_12711_ net341 samples_real\[5\]\[11\] _03875_ VSS VSS VDD
+ VDD _00277_ sky130_fd_sc_hd__mux2_1
X_12712_ net342 samples_real\[5\]\[12\] _03875_ VSS VSS VDD
+ VDD _00278_ sky130_fd_sc_hd__mux2_1
X_12713_ net343 samples_real\[5\]\[13\] _03875_ VSS VSS VDD
+ VDD _00279_ sky130_fd_sc_hd__mux2_1
X_12714_ net344 samples_real\[5\]\[14\] _03875_ VSS VSS VDD
+ VDD _00280_ sky130_fd_sc_hd__mux2_1
X_12715_ net345 samples_real\[5\]\[15\] _03875_ VSS VSS VDD
+ VDD _00281_ sky130_fd_sc_hd__mux2_1
X_12716_ net346 samples_real\[6\]\[0\] _03875_ VSS VSS VDD
+ VDD _00282_ sky130_fd_sc_hd__mux2_1
X_12717_ net347 samples_real\[6\]\[1\] _03875_ VSS VSS VDD
+ VDD _00283_ sky130_fd_sc_hd__mux2_1
X_12718_ net348 samples_real\[6\]\[2\] _03875_ VSS VSS VDD
+ VDD _00284_ sky130_fd_sc_hd__mux2_1
X_12719_ net349 samples_real\[6\]\[3\] _03875_ VSS VSS VDD
+ VDD _00285_ sky130_fd_sc_hd__mux2_1
X_12720_ net350 samples_real\[0\]\[9\] _03875_ VSS VSS VDD
+ VDD _00286_ sky130_fd_sc_hd__mux2_1
X_12721_ _03140_ net351 _00557_ VSS VSS VDD VDD _03876_ sky130_fd_sc_hd__mux2i_1
X_12722_ _03136_ _00560_ net351 VSS VSS VDD VDD _03877_ sky130_fd_sc_hd__a21oi_1
X_12723_ net351 _03138_ VSS VSS VDD VDD _03878_ sky130_fd_sc_hd__nand2_1
X_12724_ _03136_ _03876_ _03877_ _03137_ _03878_ VSS VSS VDD
+ VDD _00287_ sky130_fd_sc_hd__o221ai_1
X_12725_ net93 net352 _03842_ VSS VSS VDD VDD _03879_ sky130_fd_sc_hd__o21bai_1
X_12726_ _00560_ net352 VSS VSS VDD VDD _03880_ sky130_fd_sc_hd__nor2_1
X_12727_ state\[0\] _03879_ _03880_ VSS VSS VDD VDD _00288_
+ sky130_fd_sc_hd__a21oi_1
X_12728_ _03140_ net91 VSS VSS VDD VDD _03881_ sky130_fd_sc_hd__nor2_1
X_12729_ _03136_ net93 _03143_ VSS VSS VDD VDD _03882_ sky130_fd_sc_hd__o21ai_0
X_12730_ _03136_ _03845_ _03881_ _03882_ VSS VSS VDD VDD _03883_
+ sky130_fd_sc_hd__a211oi_2
X_12731_ _07833_ _07827_ _03883_ _03137_ VSS VSS VDD VDD _03884_
+ sky130_fd_sc_hd__nand4b_1
X_12732_ _07827_ _03883_ _03884_ VSS VSS VDD VDD _00289_ sky130_fd_sc_hd__o21ai_0
X_12733_ _07833_ _07830_ _03883_ _03137_ VSS VSS VDD VDD _03885_
+ sky130_fd_sc_hd__nand4b_1
X_12734_ _07828_ _03883_ _03885_ VSS VSS VDD VDD _00290_ sky130_fd_sc_hd__o21ai_0
X_12735_ _03137_ _07834_ _03883_ VSS VSS VDD VDD _03886_ sky130_fd_sc_hd__nand3_1
X_12736_ _03833_ _03883_ _03886_ VSS VSS VDD VDD _00291_ sky130_fd_sc_hd__o21ai_0
X_12737_ sample_count\[2\] _07829_ VSS VSS VDD VDD _03887_
+ sky130_fd_sc_hd__nor2b_2
X_12738_ _03887_ _03137_ VSS VSS VDD VDD _03888_ sky130_fd_sc_hd__nand2b_4
X_12739_ _03837_ _03835_ _03839_ VSS VSS VDD VDD _03889_ sky130_fd_sc_hd__nor3_1
X_12740_ butterfly_count\[2\] _07819_ VSS VSS VDD VDD _03890_
+ sky130_fd_sc_hd__nand2b_1
X_12741_ state\[1\] _03890_ _03881_ _03845_ VSS VSS VDD VDD
+ _03891_ sky130_fd_sc_hd__a211oi_4
X_12742_ _03888_ _03889_ _03891_ VSS VSS VDD VDD _03892_ sky130_fd_sc_hd__o21ai_4
X_12743_ _03892_ VSS VSS VDD VDD _03893_ sky130_fd_sc_hd__buf_2
X_12744_ _03309_ VSS VSS VDD VDD _03894_ sky130_fd_sc_hd__clkbuf_4
X_12745_ temp_imag\[0\] _07850_ VSS VSS VDD VDD _03895_ sky130_fd_sc_hd__xnor2_4
X_12746_ _07842_ VSS VSS VDD VDD _03896_ sky130_fd_sc_hd__clkbuf_2
X_12747_ _07856_ VSS VSS VDD VDD _03897_ sky130_fd_sc_hd__inv_1
X_12748_ _07861_ VSS VSS VDD VDD _03898_ sky130_fd_sc_hd__clkbuf_2
X_12749_ _07866_ VSS VSS VDD VDD _03899_ sky130_fd_sc_hd__inv_1
X_12750_ _07871_ VSS VSS VDD VDD _03900_ sky130_fd_sc_hd__clkbuf_2
X_12751_ _07876_ VSS VSS VDD VDD _03901_ sky130_fd_sc_hd__inv_1
X_12752_ _07881_ VSS VSS VDD VDD _03902_ sky130_fd_sc_hd__clkbuf_2
X_12753_ _07886_ VSS VSS VDD VDD _03903_ sky130_fd_sc_hd__inv_1
X_12754_ _07891_ VSS VSS VDD VDD _03904_ sky130_fd_sc_hd__clkbuf_2
X_12755_ _07896_ VSS VSS VDD VDD _03905_ sky130_fd_sc_hd__clkbuf_2
Xrebuffer167 _03156_ VSS VSS VDD VDD net534 sky130_fd_sc_hd__dlygate4sd1_1
X_12757_ _07906_ VSS VSS VDD VDD _03907_ sky130_fd_sc_hd__buf_6
X_12758_ _05903_ _07910_ _07909_ VSS VSS VDD VDD _03908_ sky130_fd_sc_hd__a21o_1
X_12759_ _03908_ _03907_ _07905_ VSS VSS VDD VDD _03909_ sky130_fd_sc_hd__a21o_1
X_12760_ _03909_ _07901_ _07900_ VSS VSS VDD VDD _03910_ sky130_fd_sc_hd__a21o_1
X_12761_ _03910_ _03905_ _07895_ VSS VSS VDD VDD _03911_ sky130_fd_sc_hd__a21o_1
X_12762_ _03911_ _03904_ _07890_ VSS VSS VDD VDD _03912_ sky130_fd_sc_hd__a21oi_2
X_12763_ _03912_ _03903_ _07885_ VSS VSS VDD VDD _03913_ sky130_fd_sc_hd__o21bai_2
X_12764_ _03913_ _03902_ _07880_ VSS VSS VDD VDD _03914_ sky130_fd_sc_hd__a21oi_2
X_12765_ _03914_ _03901_ _07875_ VSS VSS VDD VDD _03915_ sky130_fd_sc_hd__o21bai_2
X_12766_ _03915_ _03900_ _07870_ VSS VSS VDD VDD _03916_ sky130_fd_sc_hd__a21oi_2
X_12767_ _03916_ _03899_ _07865_ VSS VSS VDD VDD _03917_ sky130_fd_sc_hd__o21bai_2
X_12768_ _03917_ _03898_ _07860_ VSS VSS VDD VDD _03918_ sky130_fd_sc_hd__a21oi_2
X_12769_ _03918_ _03897_ _07855_ VSS VSS VDD VDD _03919_ sky130_fd_sc_hd__o21bai_2
X_12770_ _03919_ _03896_ _07841_ VSS VSS VDD VDD _03920_ sky130_fd_sc_hd__a21o_1
X_12771_ _07837_ _03920_ _07836_ VSS VSS VDD VDD _03921_ sky130_fd_sc_hd__a21oi_4
X_12772_ _03895_ _03921_ VSS VSS VDD VDD _03922_ sky130_fd_sc_hd__xnor2_4
X_12773_ temp_imag\[0\] _07853_ _03922_ VSS VSS VDD VDD _03923_
+ sky130_fd_sc_hd__and3_4
Xclone54 net523 _03895_ VSS VSS VDD VDD net54 sky130_fd_sc_hd__xnor2_4
X_12775_ _03923_ _07847_ VSS VSS VDD VDD _03925_ sky130_fd_sc_hd__nand2b_4
Xrebuffer164 _03921_ VSS VSS VDD VDD net531 sky130_fd_sc_hd__buf_1
X_12777_ _07910_ VSS VSS VDD VDD _03927_ sky130_fd_sc_hd__inv_1
X_12778_ _03927_ _07845_ _07911_ VSS VSS VDD VDD _03928_ sky130_fd_sc_hd__a21oi_1
X_12779_ _03907_ _03928_ VSS VSS VDD VDD _03929_ sky130_fd_sc_hd__nor2_1
X_12780_ _07907_ _03929_ VSS VSS VDD VDD _03930_ sky130_fd_sc_hd__nor2_1
X_12781_ _07901_ _03930_ VSS VSS VDD VDD _03931_ sky130_fd_sc_hd__nor2_1
X_12782_ _07902_ _03931_ VSS VSS VDD VDD _03932_ sky130_fd_sc_hd__nor2_1
X_12783_ _03905_ _03932_ VSS VSS VDD VDD _03933_ sky130_fd_sc_hd__nor2_1
X_12784_ _07897_ _03933_ VSS VSS VDD VDD _03934_ sky130_fd_sc_hd__nor2_1
X_12785_ _03904_ _03934_ _07892_ VSS VSS VDD VDD _03935_ sky130_fd_sc_hd__o21bai_1
X_12786_ _03903_ _03935_ _07887_ VSS VSS VDD VDD _03936_ sky130_fd_sc_hd__a21oi_2
X_12787_ _03902_ _03936_ _07882_ VSS VSS VDD VDD _03937_ sky130_fd_sc_hd__o21bai_1
X_12788_ _03937_ _03901_ _07877_ VSS VSS VDD VDD _03938_ sky130_fd_sc_hd__a21oi_2
X_12789_ _03900_ _03938_ _07872_ VSS VSS VDD VDD _03939_ sky130_fd_sc_hd__o21bai_1
X_12790_ _03939_ _03899_ _07867_ VSS VSS VDD VDD _03940_ sky130_fd_sc_hd__a21oi_2
X_12791_ _03898_ _03940_ _07862_ VSS VSS VDD VDD _03941_ sky130_fd_sc_hd__o21bai_1
X_12792_ _03897_ _03941_ _07857_ VSS VSS VDD VDD _03942_ sky130_fd_sc_hd__a21oi_2
X_12793_ _03896_ _03942_ VSS VSS VDD VDD _03943_ sky130_fd_sc_hd__nor2_1
X_12794_ _07843_ _03943_ VSS VSS VDD VDD _03944_ sky130_fd_sc_hd__nor2_1
X_12795_ _07837_ _03944_ VSS VSS VDD VDD _03945_ sky130_fd_sc_hd__nor2_1
X_12796_ _03945_ _07838_ VSS VSS VDD VDD _03946_ sky130_fd_sc_hd__nor2_1
X_12797_ _03895_ _03946_ VSS VSS VDD VDD _03947_ sky130_fd_sc_hd__xor2_2
X_12798_ _03907_ _05900_ VSS VSS VDD VDD _03948_ sky130_fd_sc_hd__nor2_1
X_12799_ _07907_ _03948_ VSS VSS VDD VDD _03949_ sky130_fd_sc_hd__nor2_1
X_12800_ _07901_ _03949_ VSS VSS VDD VDD _03950_ sky130_fd_sc_hd__nor2_1
X_12801_ _03950_ _07902_ VSS VSS VDD VDD _03951_ sky130_fd_sc_hd__nor2_1
X_12802_ _03905_ _03951_ VSS VSS VDD VDD _03952_ sky130_fd_sc_hd__nor2_1
X_12803_ _07897_ _03952_ VSS VSS VDD VDD _03953_ sky130_fd_sc_hd__nor2_1
X_12804_ _03904_ _03953_ VSS VSS VDD VDD _03954_ sky130_fd_sc_hd__nor2_1
X_12805_ _03954_ _07892_ VSS VSS VDD VDD _03955_ sky130_fd_sc_hd__nor2_1
X_12806_ _07886_ _03955_ VSS VSS VDD VDD _03956_ sky130_fd_sc_hd__nor2_1
X_12807_ _07887_ _03956_ VSS VSS VDD VDD _03957_ sky130_fd_sc_hd__nor2_1
X_12808_ _03957_ _03902_ VSS VSS VDD VDD _03958_ sky130_fd_sc_hd__nor2_2
X_12809_ _07882_ _03958_ VSS VSS VDD VDD _03959_ sky130_fd_sc_hd__nor2_2
X_12810_ _07876_ _03959_ VSS VSS VDD VDD _03960_ sky130_fd_sc_hd__nor2_1
X_12811_ _07877_ _03960_ VSS VSS VDD VDD _03961_ sky130_fd_sc_hd__nor2_1
X_12812_ _03900_ _03961_ VSS VSS VDD VDD _03962_ sky130_fd_sc_hd__nor2_1
X_12813_ _03962_ _07872_ VSS VSS VDD VDD _03963_ sky130_fd_sc_hd__nor2_1
X_12814_ _07866_ _03963_ VSS VSS VDD VDD _03964_ sky130_fd_sc_hd__nor2_1
X_12815_ _07867_ _03964_ VSS VSS VDD VDD _03965_ sky130_fd_sc_hd__nor2_1
X_12816_ _03898_ _03965_ VSS VSS VDD VDD _03966_ sky130_fd_sc_hd__nor2_1
X_12817_ _07862_ _03966_ VSS VSS VDD VDD _03967_ sky130_fd_sc_hd__nor2_1
X_12818_ _07856_ _03967_ VSS VSS VDD VDD _03968_ sky130_fd_sc_hd__nor2_1
X_12819_ _07857_ _03968_ VSS VSS VDD VDD _03969_ sky130_fd_sc_hd__nor2_1
X_12820_ _03896_ _03969_ VSS VSS VDD VDD _03970_ sky130_fd_sc_hd__nor2_1
X_12821_ _07843_ _03970_ VSS VSS VDD VDD _03971_ sky130_fd_sc_hd__nor2_1
X_12822_ _03971_ _07837_ VSS VSS VDD VDD _03972_ sky130_fd_sc_hd__xnor2_1
X_12823_ _03896_ _03942_ VSS VSS VDD VDD _03973_ sky130_fd_sc_hd__xnor2_1
X_12824_ _07856_ net616 VSS VSS VDD VDD _03974_ sky130_fd_sc_hd__xnor2_1
X_12825_ _07886_ net557 VSS VSS VDD VDD _03975_ sky130_fd_sc_hd__xnor2_1
X_12826_ _03904_ net638 VSS VSS VDD VDD _03976_ sky130_fd_sc_hd__xnor2_1
X_12827_ _07901_ net644 VSS VSS VDD VDD _03977_ sky130_fd_sc_hd__xnor2_1
X_12828_ _03907_ _05900_ VSS VSS VDD VDD _03978_ sky130_fd_sc_hd__xnor2_1
X_12829_ _03905_ net554 VSS VSS VDD VDD _03979_ sky130_fd_sc_hd__xnor2_1
X_12830_ _07847_ _03978_ _03979_ _05901_ VSS VSS VDD VDD _03980_
+ sky130_fd_sc_hd__and4b_1
X_12831_ _03975_ _03976_ _03977_ _03980_ VSS VSS VDD VDD _03981_
+ sky130_fd_sc_hd__nand4_1
X_12832_ _07876_ net641 VSS VSS VDD VDD _03982_ sky130_fd_sc_hd__xnor2_1
X_12833_ _03902_ _03936_ VSS VSS VDD VDD _03983_ sky130_fd_sc_hd__xnor2_1
X_12834_ _03982_ _03983_ VSS VSS VDD VDD _03984_ sky130_fd_sc_hd__nand2_1
X_12835_ _03981_ _03984_ VSS VSS VDD VDD _03985_ sky130_fd_sc_hd__nor2_1
X_12836_ _03900_ _03938_ VSS VSS VDD VDD _03986_ sky130_fd_sc_hd__xnor2_1
X_12837_ _07866_ net563 VSS VSS VDD VDD _03987_ sky130_fd_sc_hd__xnor2_1
X_12838_ _03898_ _03940_ VSS VSS VDD VDD _03988_ sky130_fd_sc_hd__xnor2_1
X_12839_ _03985_ _03986_ _03987_ _03988_ VSS VSS VDD VDD _03989_
+ sky130_fd_sc_hd__and4_1
X_12840_ _03989_ _03973_ _03974_ _03972_ VSS VSS VDD VDD _03990_
+ sky130_fd_sc_hd__nand4_2
X_12841_ temp_imag\[0\] _03990_ _07852_ VSS VSS VDD VDD _03991_
+ sky130_fd_sc_hd__nand3_4
X_12842_ _03947_ _03991_ VSS VSS VDD VDD _03992_ sky130_fd_sc_hd__nor2_8
X_12843_ _03992_ _07847_ VSS VSS VDD VDD _03993_ sky130_fd_sc_hd__nor2b_4
X_12844_ _03993_ VSS VSS VDD VDD _03994_ sky130_fd_sc_hd__buf_6
X_12845_ _03176_ _03892_ VSS VSS VDD VDD _03995_ sky130_fd_sc_hd__nor2_1
X_12846_ samples_imag\[0\]\[0\] _03176_ _03994_ _03995_ VSS
+ VSS VDD VDD _03996_ sky130_fd_sc_hd__a22o_1
X_12847_ _03449_ _03996_ VSS VSS VDD VDD _03997_ sky130_fd_sc_hd__nand2_1
X_12848_ _03894_ _03893_ _03925_ _03997_ VSS VSS VDD VDD _03998_
+ sky130_fd_sc_hd__o31ai_2
X_12849_ _03142_ VSS VSS VDD VDD _03999_ sky130_fd_sc_hd__buf_6
X_12850_ _03141_ net34 VSS VSS VDD VDD _04000_ sky130_fd_sc_hd__nand2b_1
X_12851_ _04000_ VSS VSS VDD VDD _04001_ sky130_fd_sc_hd__buf_4
X_12852_ _03893_ _04001_ VSS VSS VDD VDD _04002_ sky130_fd_sc_hd__nor2_1
X_12853_ samples_imag\[0\]\[0\] _03893_ _03998_ _03999_ _04002_
+ VSS VSS VDD VDD _00292_ sky130_fd_sc_hd__a221o_1
X_12854_ _03893_ VSS VSS VDD VDD _04003_ sky130_fd_sc_hd__clkbuf_4
X_12855_ _03142_ VSS VSS VDD VDD _04004_ sky130_fd_sc_hd__buf_6
X_12856_ _03992_ VSS VSS VDD VDD _04005_ sky130_fd_sc_hd__buf_6
X_12857_ _04005_ _03987_ VSS VSS VDD VDD _04006_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12859_ _03177_ _04006_ VSS VSS VDD VDD _04008_ sky130_fd_sc_hd__nor2_1
X_12860_ samples_imag\[0\]\[10\] _03207_ _04008_ VSS VSS VDD
+ VDD _04009_ sky130_fd_sc_hd__a21oi_1
X_12861_ _03923_ VSS VSS VDD VDD _04010_ sky130_fd_sc_hd__buf_12
X_12862_ _03907_ _05904_ _07905_ VSS VSS VDD VDD _04011_ sky130_fd_sc_hd__a21o_1
X_12863_ _07901_ _04011_ _07900_ VSS VSS VDD VDD _04012_ sky130_fd_sc_hd__a21o_1
X_12864_ _03905_ _04012_ _07895_ VSS VSS VDD VDD _04013_ sky130_fd_sc_hd__a21o_1
X_12865_ _03904_ _04013_ _07890_ VSS VSS VDD VDD _04014_ sky130_fd_sc_hd__a21oi_2
X_12866_ _03903_ _04014_ _07885_ VSS VSS VDD VDD _04015_ sky130_fd_sc_hd__o21bai_1
X_12867_ _04015_ _03902_ _07880_ VSS VSS VDD VDD _04016_ sky130_fd_sc_hd__a21oi_2
X_12868_ _03901_ _04016_ _07875_ VSS VSS VDD VDD _04017_ sky130_fd_sc_hd__o21bai_1
X_12869_ _03900_ _04017_ _07870_ VSS VSS VDD VDD _04018_ sky130_fd_sc_hd__a21oi_2
X_12870_ _03899_ _04018_ VSS VSS VDD VDD _04019_ sky130_fd_sc_hd__xnor2_2
X_12871_ net62 _04019_ VSS VSS VDD VDD _04020_ sky130_fd_sc_hd__nor2_8
X_12872_ _03314_ _04020_ VSS VSS VDD VDD _04021_ sky130_fd_sc_hd__nor2_1
X_12873_ _04009_ _03310_ _04021_ VSS VSS VDD VDD _04022_ sky130_fd_sc_hd__a21oi_1
X_12874_ state\[1\] VSS VSS VDD VDD _04023_ sky130_fd_sc_hd__buf_2
X_12875_ _04023_ net40 VSS VSS VDD VDD _04024_ sky130_fd_sc_hd__nor2b_1
X_12876_ _04024_ VSS VSS VDD VDD _04025_ sky130_fd_sc_hd__buf_4
X_12877_ _04004_ _04022_ _04025_ VSS VSS VDD VDD _04026_ sky130_fd_sc_hd__a21oi_1
X_12878_ _03893_ VSS VSS VDD VDD _04027_ sky130_fd_sc_hd__buf_2
X_12879_ samples_imag\[0\]\[10\] _04027_ VSS VSS VDD VDD _04028_
+ sky130_fd_sc_hd__nand2_1
X_12880_ _04003_ _04026_ _04028_ VSS VSS VDD VDD _00293_ sky130_fd_sc_hd__o21ai_1
X_12881_ _03142_ VSS VSS VDD VDD _04029_ sky130_fd_sc_hd__buf_4
X_12882_ _04029_ VSS VSS VDD VDD _04030_ sky130_fd_sc_hd__clkbuf_4
X_12883_ _04005_ _03988_ VSS VSS VDD VDD _04031_ sky130_fd_sc_hd__or2_4
Xclone66 net605 VSS VSS VDD VDD net66 sky130_fd_sc_hd__clkbuf_4
X_12885_ _03177_ _04031_ VSS VSS VDD VDD _04033_ sky130_fd_sc_hd__nor2_2
X_12886_ samples_imag\[0\]\[11\] _03207_ _04033_ VSS VSS VDD
+ VDD _04034_ sky130_fd_sc_hd__a21oi_1
X_12887_ _03898_ net543 VSS VSS VDD VDD _04035_ sky130_fd_sc_hd__xnor2_2
X_12888_ _04035_ _04010_ VSS VSS VDD VDD _04036_ sky130_fd_sc_hd__nor2_8
X_12889_ _03314_ _04036_ VSS VSS VDD VDD _04037_ sky130_fd_sc_hd__nor2_1
X_12890_ _04034_ _03310_ _04037_ VSS VSS VDD VDD _04038_ sky130_fd_sc_hd__a21oi_1
X_12891_ _04023_ net47 VSS VSS VDD VDD _04039_ sky130_fd_sc_hd__nor2b_1
X_12892_ _04039_ VSS VSS VDD VDD _04040_ sky130_fd_sc_hd__buf_4
X_12893_ _04030_ _04038_ _04040_ VSS VSS VDD VDD _04041_ sky130_fd_sc_hd__a21oi_1
X_12894_ samples_imag\[0\]\[11\] _04027_ VSS VSS VDD VDD _04042_
+ sky130_fd_sc_hd__nand2_1
X_12895_ _04003_ _04041_ _04042_ VSS VSS VDD VDD _00294_ sky130_fd_sc_hd__o21ai_1
X_12896_ _03892_ VSS VSS VDD VDD _04043_ sky130_fd_sc_hd__buf_2
X_12897_ _03176_ VSS VSS VDD VDD _04044_ sky130_fd_sc_hd__clkbuf_4
X_12898_ net77 _03974_ VSS VSS VDD VDD _04045_ sky130_fd_sc_hd__or2_4
Xclone55 net56 VSS VSS VDD VDD net55 sky130_fd_sc_hd__buf_6
X_12900_ _04044_ _04045_ VSS VSS VDD VDD _04047_ sky130_fd_sc_hd__nor2_1
X_12901_ samples_imag\[0\]\[12\] _03207_ _04047_ VSS VSS VDD
+ VDD _04048_ sky130_fd_sc_hd__a21oi_1
X_12902_ _03899_ _04018_ _07865_ VSS VSS VDD VDD _04049_ sky130_fd_sc_hd__o21bai_1
X_12903_ _03898_ _04049_ _07860_ VSS VSS VDD VDD _04050_ sky130_fd_sc_hd__a21oi_2
X_12904_ _03897_ _04050_ VSS VSS VDD VDD _04051_ sky130_fd_sc_hd__xnor2_2
X_12905_ _04051_ _04010_ VSS VSS VDD VDD _04052_ sky130_fd_sc_hd__nor2_8
X_12906_ _03314_ _04052_ VSS VSS VDD VDD _04053_ sky130_fd_sc_hd__nor2_1
X_12907_ _04048_ _03310_ _04053_ VSS VSS VDD VDD _04054_ sky130_fd_sc_hd__a21oi_1
X_12908_ state\[1\] VSS VSS VDD VDD _04055_ sky130_fd_sc_hd__clkbuf_4
X_12909_ _04055_ net48 VSS VSS VDD VDD _04056_ sky130_fd_sc_hd__nor2b_1
X_12910_ _04056_ VSS VSS VDD VDD _04057_ sky130_fd_sc_hd__buf_6
X_12911_ _04054_ _04030_ _04057_ VSS VSS VDD VDD _04058_ sky130_fd_sc_hd__a21oi_1
X_12912_ samples_imag\[0\]\[12\] _04027_ VSS VSS VDD VDD _04059_
+ sky130_fd_sc_hd__nand2_1
X_12913_ _04043_ _04058_ _04059_ VSS VSS VDD VDD _00295_ sky130_fd_sc_hd__o21ai_1
X_12914_ _03176_ VSS VSS VDD VDD _04060_ sky130_fd_sc_hd__clkbuf_4
X_12915_ net77 _03973_ VSS VSS VDD VDD _04061_ sky130_fd_sc_hd__or2_4
Xclone65 net526 VSS VSS VDD VDD net65 sky130_fd_sc_hd__buf_8
X_12917_ _04044_ _04061_ VSS VSS VDD VDD _04063_ sky130_fd_sc_hd__nor2_1
X_12918_ samples_imag\[0\]\[13\] _04060_ _04063_ VSS VSS VDD
+ VDD _04064_ sky130_fd_sc_hd__a21oi_1
X_12919_ _03896_ _03919_ VSS VSS VDD VDD _04065_ sky130_fd_sc_hd__xnor2_2
X_12920_ _04065_ _04010_ VSS VSS VDD VDD _04066_ sky130_fd_sc_hd__nor2_8
X_12921_ _03314_ _04066_ VSS VSS VDD VDD _04067_ sky130_fd_sc_hd__nor2_1
X_12922_ _04064_ _03310_ _04067_ VSS VSS VDD VDD _04068_ sky130_fd_sc_hd__a21oi_1
X_12923_ _04023_ net57 VSS VSS VDD VDD _04069_ sky130_fd_sc_hd__nor2b_1
X_12924_ _04069_ VSS VSS VDD VDD _04070_ sky130_fd_sc_hd__buf_6
X_12925_ _04030_ _04068_ _04070_ VSS VSS VDD VDD _04071_ sky130_fd_sc_hd__a21oi_1
X_12926_ samples_imag\[0\]\[13\] _04027_ VSS VSS VDD VDD _04072_
+ sky130_fd_sc_hd__nand2_1
X_12927_ _04043_ _04071_ _04072_ VSS VSS VDD VDD _00296_ sky130_fd_sc_hd__o21ai_1
X_12928_ net77 _03972_ VSS VSS VDD VDD _04073_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12930_ _04073_ _04044_ VSS VSS VDD VDD _04075_ sky130_fd_sc_hd__nor2_2
X_12931_ samples_imag\[0\]\[14\] _04060_ _04075_ VSS VSS VDD
+ VDD _04076_ sky130_fd_sc_hd__a21oi_1
X_12932_ _03897_ _04050_ _07855_ VSS VSS VDD VDD _04077_ sky130_fd_sc_hd__o21bai_1
X_12933_ _03896_ _04077_ _07841_ VSS VSS VDD VDD _04078_ sky130_fd_sc_hd__a21oi_2
X_12934_ _04078_ _07837_ VSS VSS VDD VDD _04079_ sky130_fd_sc_hd__xor2_2
X_12935_ net62 _04079_ VSS VSS VDD VDD _04080_ sky130_fd_sc_hd__nor2_8
X_12936_ _03314_ _04080_ VSS VSS VDD VDD _04081_ sky130_fd_sc_hd__nor2_1
X_12937_ _04076_ _03310_ _04081_ VSS VSS VDD VDD _04082_ sky130_fd_sc_hd__a21oi_1
X_12938_ _04023_ net58 VSS VSS VDD VDD _04083_ sky130_fd_sc_hd__nor2b_1
X_12939_ _04083_ VSS VSS VDD VDD _04084_ sky130_fd_sc_hd__buf_4
X_12940_ _04082_ _04030_ _04084_ VSS VSS VDD VDD _04085_ sky130_fd_sc_hd__a21oi_1
X_12941_ samples_imag\[0\]\[14\] _04027_ VSS VSS VDD VDD _04086_
+ sky130_fd_sc_hd__nand2_1
X_12942_ _04085_ _04043_ _04086_ VSS VSS VDD VDD _00297_ sky130_fd_sc_hd__o21ai_1
X_12943_ _03893_ VSS VSS VDD VDD _04087_ sky130_fd_sc_hd__clkbuf_4
X_12944_ _03142_ VSS VSS VDD VDD _04088_ sky130_fd_sc_hd__buf_4
X_12945_ _03176_ VSS VSS VDD VDD _04089_ sky130_fd_sc_hd__clkbuf_4
X_12946_ temp_imag\[0\] _07852_ net542 net545 VSS VSS VDD
+ VDD _04090_ sky130_fd_sc_hd__a31oi_4
X_12947_ _03176_ VSS VSS VDD VDD _04091_ sky130_fd_sc_hd__clkbuf_4
X_12948_ samples_imag\[0\]\[15\] _04091_ VSS VSS VDD VDD _04092_
+ sky130_fd_sc_hd__nand2_1
X_12949_ _04089_ _04090_ _04092_ _03309_ VSS VSS VDD VDD _04093_
+ sky130_fd_sc_hd__o211ai_1
X_12950_ _03894_ net524 _04093_ VSS VSS VDD VDD _04094_ sky130_fd_sc_hd__o21ai_0
X_12951_ _03142_ net59 VSS VSS VDD VDD _04095_ sky130_fd_sc_hd__nor2_4
X_12952_ _04088_ _04094_ _04095_ _04087_ VSS VSS VDD VDD _04096_
+ sky130_fd_sc_hd__a211oi_1
X_12953_ samples_imag\[0\]\[15\] _04087_ _04096_ VSS VSS VDD
+ VDD _00298_ sky130_fd_sc_hd__a21o_1
X_12954_ net77 _05901_ VSS VSS VDD VDD _04097_ sky130_fd_sc_hd__or2_4
Xclone62 _03923_ VSS VSS VDD VDD net62 sky130_fd_sc_hd__buf_12
X_12956_ _04044_ net647 VSS VSS VDD VDD _04099_ sky130_fd_sc_hd__nor2_2
X_12957_ samples_imag\[0\]\[1\] _04060_ _04099_ VSS VSS VDD
+ VDD _04100_ sky130_fd_sc_hd__a21oi_1
X_12958_ _04010_ _05905_ VSS VSS VDD VDD _04101_ sky130_fd_sc_hd__nor2_8
X_12959_ _03314_ _04101_ VSS VSS VDD VDD _04102_ sky130_fd_sc_hd__nor2_1
X_12960_ _04100_ _03310_ _04102_ VSS VSS VDD VDD _04103_ sky130_fd_sc_hd__a21oi_1
X_12961_ _04055_ net60 VSS VSS VDD VDD _04104_ sky130_fd_sc_hd__nor2b_1
X_12962_ _04104_ VSS VSS VDD VDD _04105_ sky130_fd_sc_hd__clkbuf_8
X_12963_ _04030_ _04103_ _04105_ VSS VSS VDD VDD _04106_ sky130_fd_sc_hd__a21oi_1
X_12964_ samples_imag\[0\]\[1\] _04027_ VSS VSS VDD VDD _04107_
+ sky130_fd_sc_hd__nand2_1
X_12965_ _04043_ _04106_ _04107_ VSS VSS VDD VDD _00299_ sky130_fd_sc_hd__o21ai_1
X_12966_ _03309_ VSS VSS VDD VDD _04108_ sky130_fd_sc_hd__clkbuf_4
X_12967_ _03978_ _04005_ VSS VSS VDD VDD _04109_ sky130_fd_sc_hd__or2_4
Xclone77 _03992_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__buf_6
X_12969_ _04044_ _04109_ VSS VSS VDD VDD _04111_ sky130_fd_sc_hd__nor2_1
X_12970_ samples_imag\[0\]\[2\] _04060_ _04111_ VSS VSS VDD
+ VDD _04112_ sky130_fd_sc_hd__a21oi_1
X_12971_ _03907_ _05904_ VSS VSS VDD VDD _04113_ sky130_fd_sc_hd__xnor2_2
X_12972_ _04113_ net62 VSS VSS VDD VDD _04114_ sky130_fd_sc_hd__nor2_8
X_12973_ _03314_ _04114_ VSS VSS VDD VDD _04115_ sky130_fd_sc_hd__nor2_1
X_12974_ _04112_ _04108_ _04115_ VSS VSS VDD VDD _04116_ sky130_fd_sc_hd__a21oi_1
X_12975_ _04023_ net61 VSS VSS VDD VDD _04117_ sky130_fd_sc_hd__nor2b_1
X_12976_ _04117_ VSS VSS VDD VDD _04118_ sky130_fd_sc_hd__buf_6
X_12977_ _04116_ _04030_ _04118_ VSS VSS VDD VDD _04119_ sky130_fd_sc_hd__a21oi_1
X_12978_ samples_imag\[0\]\[2\] _04027_ VSS VSS VDD VDD _04120_
+ sky130_fd_sc_hd__nand2_1
X_12979_ _04043_ _04119_ _04120_ VSS VSS VDD VDD _00300_ sky130_fd_sc_hd__o21ai_1
X_12980_ net77 _03977_ VSS VSS VDD VDD _04121_ sky130_fd_sc_hd__or2_4
Xsplit67 net528 VSS VSS VDD VDD net67 sky130_fd_sc_hd__dlymetal6s2s_1
X_12982_ _04044_ _04121_ VSS VSS VDD VDD _04123_ sky130_fd_sc_hd__nor2_1
X_12983_ samples_imag\[0\]\[3\] _04060_ _04123_ VSS VSS VDD
+ VDD _04124_ sky130_fd_sc_hd__a21oi_1
X_12984_ _07901_ net544 VSS VSS VDD VDD _04125_ sky130_fd_sc_hd__xnor2_2
X_12985_ _04125_ _04010_ VSS VSS VDD VDD _04126_ sky130_fd_sc_hd__nor2_8
X_12986_ _03314_ _04126_ VSS VSS VDD VDD _04127_ sky130_fd_sc_hd__nor2_1
X_12987_ _04124_ _04108_ _04127_ VSS VSS VDD VDD _04128_ sky130_fd_sc_hd__a21oi_1
X_12988_ _04055_ net63 VSS VSS VDD VDD _04129_ sky130_fd_sc_hd__nor2b_1
X_12989_ _04129_ VSS VSS VDD VDD _04130_ sky130_fd_sc_hd__buf_6
X_12990_ _04030_ _04128_ _04130_ VSS VSS VDD VDD _04131_ sky130_fd_sc_hd__a21oi_1
X_12991_ samples_imag\[0\]\[3\] _04027_ VSS VSS VDD VDD _04132_
+ sky130_fd_sc_hd__nand2_1
X_12992_ _04043_ _04131_ _04132_ VSS VSS VDD VDD _00301_ sky130_fd_sc_hd__o21ai_1
X_12993_ _04005_ _03979_ VSS VSS VDD VDD _04133_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_12995_ _04044_ _04133_ VSS VSS VDD VDD _04135_ sky130_fd_sc_hd__nor2_1
X_12996_ samples_imag\[0\]\[4\] _04060_ _04135_ VSS VSS VDD
+ VDD _04136_ sky130_fd_sc_hd__a21oi_1
X_12997_ _03905_ _04012_ VSS VSS VDD VDD _04137_ sky130_fd_sc_hd__xnor2_2
X_12998_ net62 _04137_ VSS VSS VDD VDD _04138_ sky130_fd_sc_hd__nor2_8
X_12999_ _03314_ _04138_ VSS VSS VDD VDD _04139_ sky130_fd_sc_hd__nor2_1
X_13000_ _04136_ _04108_ _04139_ VSS VSS VDD VDD _04140_ sky130_fd_sc_hd__a21oi_1
X_13001_ _04023_ net68 VSS VSS VDD VDD _04141_ sky130_fd_sc_hd__nor2b_1
X_13002_ _04141_ VSS VSS VDD VDD _04142_ sky130_fd_sc_hd__buf_4
X_13003_ _04030_ _04140_ _04142_ VSS VSS VDD VDD _04143_ sky130_fd_sc_hd__a21oi_1
X_13004_ samples_imag\[0\]\[4\] _04027_ VSS VSS VDD VDD _04144_
+ sky130_fd_sc_hd__nand2_1
X_13005_ _04043_ _04143_ _04144_ VSS VSS VDD VDD _00302_ sky130_fd_sc_hd__o21ai_1
X_13006_ _04005_ _03976_ VSS VSS VDD VDD _04145_ sky130_fd_sc_hd__or2_4
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_13008_ _04145_ _04044_ VSS VSS VDD VDD _04147_ sky130_fd_sc_hd__nor2_1
X_13009_ samples_imag\[0\]\[5\] _04060_ _04147_ VSS VSS VDD
+ VDD _04148_ sky130_fd_sc_hd__a21oi_1
X_13010_ _03904_ _03911_ VSS VSS VDD VDD _04149_ sky130_fd_sc_hd__xnor2_2
X_13011_ net62 _04149_ VSS VSS VDD VDD _04150_ sky130_fd_sc_hd__nor2_8
X_13012_ _03894_ _04150_ VSS VSS VDD VDD _04151_ sky130_fd_sc_hd__nor2_1
X_13013_ _04108_ _04148_ _04151_ VSS VSS VDD VDD _04152_ sky130_fd_sc_hd__a21oi_1
X_13014_ _04023_ net69 VSS VSS VDD VDD _04153_ sky130_fd_sc_hd__nor2b_1
X_13015_ _04153_ VSS VSS VDD VDD _04154_ sky130_fd_sc_hd__clkbuf_8
X_13016_ _04152_ _04030_ _04154_ VSS VSS VDD VDD _04155_ sky130_fd_sc_hd__a21oi_2
X_13017_ samples_imag\[0\]\[5\] _04027_ VSS VSS VDD VDD _04156_
+ sky130_fd_sc_hd__nand2_1
X_13018_ _04043_ _04155_ _04156_ VSS VSS VDD VDD _00303_ sky130_fd_sc_hd__o21ai_1
X_13019_ _03975_ _03992_ VSS VSS VDD VDD _04157_ sky130_fd_sc_hd__or2_1
X_13020_ _04157_ VSS VSS VDD VDD _04158_ sky130_fd_sc_hd__buf_6
X_13021_ _04044_ _04158_ VSS VSS VDD VDD _04159_ sky130_fd_sc_hd__nor2_1
X_13022_ samples_imag\[0\]\[6\] _04060_ _04159_ VSS VSS VDD
+ VDD _04160_ sky130_fd_sc_hd__a21oi_1
X_13023_ _03903_ _04014_ VSS VSS VDD VDD _04161_ sky130_fd_sc_hd__xnor2_2
X_13024_ net518 _04161_ VSS VSS VDD VDD _04162_ sky130_fd_sc_hd__nor2_8
X_13025_ _03894_ _04162_ VSS VSS VDD VDD _04163_ sky130_fd_sc_hd__nor2_1
X_13026_ _04108_ _04160_ _04163_ VSS VSS VDD VDD _04164_ sky130_fd_sc_hd__a21oi_1
X_13027_ _04023_ net70 VSS VSS VDD VDD _04165_ sky130_fd_sc_hd__nor2b_1
X_13028_ _04165_ VSS VSS VDD VDD _04166_ sky130_fd_sc_hd__clkbuf_8
X_13029_ _04030_ _04164_ _04166_ VSS VSS VDD VDD _04167_ sky130_fd_sc_hd__a21oi_1
X_13030_ _03893_ VSS VSS VDD VDD _04168_ sky130_fd_sc_hd__buf_4
X_13031_ samples_imag\[0\]\[6\] _04168_ VSS VSS VDD VDD _04169_
+ sky130_fd_sc_hd__nand2_1
X_13032_ _04043_ _04167_ _04169_ VSS VSS VDD VDD _00304_ sky130_fd_sc_hd__o21ai_1
X_13033_ _03142_ VSS VSS VDD VDD _04170_ sky130_fd_sc_hd__buf_4
X_13034_ _04170_ VSS VSS VDD VDD _04171_ sky130_fd_sc_hd__buf_4
X_13035_ _03983_ _03992_ VSS VSS VDD VDD _04172_ sky130_fd_sc_hd__or2_1
X_13036_ _04172_ VSS VSS VDD VDD _04173_ sky130_fd_sc_hd__buf_6
X_13037_ _04044_ _04173_ VSS VSS VDD VDD _04174_ sky130_fd_sc_hd__nor2_2
X_13038_ samples_imag\[0\]\[7\] _04060_ _04174_ VSS VSS VDD
+ VDD _04175_ sky130_fd_sc_hd__a21oi_1
X_13039_ _03902_ net541 VSS VSS VDD VDD _04176_ sky130_fd_sc_hd__xnor2_2
X_13040_ net518 _04176_ VSS VSS VDD VDD _04177_ sky130_fd_sc_hd__nor2_8
X_13041_ _03894_ _04177_ VSS VSS VDD VDD _04178_ sky130_fd_sc_hd__nor2_2
X_13042_ _04108_ _04175_ _04178_ VSS VSS VDD VDD _04179_ sky130_fd_sc_hd__a21oi_1
X_13043_ _04055_ net71 VSS VSS VDD VDD _04180_ sky130_fd_sc_hd__nor2b_1
X_13044_ _04180_ VSS VSS VDD VDD _04181_ sky130_fd_sc_hd__buf_4
X_13045_ _04171_ _04179_ _04181_ VSS VSS VDD VDD _04182_ sky130_fd_sc_hd__a21oi_1
X_13046_ samples_imag\[0\]\[7\] _04168_ VSS VSS VDD VDD _04183_
+ sky130_fd_sc_hd__nand2_1
X_13047_ _04043_ _04182_ _04183_ VSS VSS VDD VDD _00305_ sky130_fd_sc_hd__o21ai_1
X_13048_ _03892_ VSS VSS VDD VDD _04184_ sky130_fd_sc_hd__buf_4
X_13049_ _03982_ _03992_ VSS VSS VDD VDD _04185_ sky130_fd_sc_hd__or2_1
X_13050_ _04185_ VSS VSS VDD VDD _04186_ sky130_fd_sc_hd__buf_6
X_13051_ _04089_ _04186_ VSS VSS VDD VDD _04187_ sky130_fd_sc_hd__nor2_1
X_13052_ samples_imag\[0\]\[8\] _04060_ _04187_ VSS VSS VDD
+ VDD _04188_ sky130_fd_sc_hd__a21oi_1
X_13053_ _03901_ net639 VSS VSS VDD VDD _04189_ sky130_fd_sc_hd__xnor2_2
X_13054_ net518 _04189_ VSS VSS VDD VDD _04190_ sky130_fd_sc_hd__nor2_8
X_13055_ _03894_ _04190_ VSS VSS VDD VDD _04191_ sky130_fd_sc_hd__nor2_1
X_13056_ _04108_ _04188_ _04191_ VSS VSS VDD VDD _04192_ sky130_fd_sc_hd__a21oi_1
X_13057_ _04055_ net72 VSS VSS VDD VDD _04193_ sky130_fd_sc_hd__nor2b_1
X_13058_ _04193_ VSS VSS VDD VDD _04194_ sky130_fd_sc_hd__buf_6
X_13059_ _04171_ _04192_ _04194_ VSS VSS VDD VDD _04195_ sky130_fd_sc_hd__a21oi_1
X_13060_ samples_imag\[0\]\[8\] _04168_ VSS VSS VDD VDD _04196_
+ sky130_fd_sc_hd__nand2_1
X_13061_ _04184_ _04195_ _04196_ VSS VSS VDD VDD _00306_ sky130_fd_sc_hd__o21ai_1
X_13062_ _03986_ _03992_ VSS VSS VDD VDD _04197_ sky130_fd_sc_hd__or2_1
X_13063_ _04197_ VSS VSS VDD VDD _04198_ sky130_fd_sc_hd__buf_6
X_13064_ _04089_ _04198_ VSS VSS VDD VDD _04199_ sky130_fd_sc_hd__nor2_1
X_13065_ samples_imag\[0\]\[9\] _03715_ _04199_ VSS VSS VDD
+ VDD _04200_ sky130_fd_sc_hd__a21oi_1
X_13066_ _03900_ _03915_ VSS VSS VDD VDD _04201_ sky130_fd_sc_hd__xnor2_2
X_13067_ net518 _04201_ VSS VSS VDD VDD _04202_ sky130_fd_sc_hd__nor2_8
X_13068_ _03894_ _04202_ VSS VSS VDD VDD _04203_ sky130_fd_sc_hd__nor2_1
X_13069_ _04108_ _04200_ _04203_ VSS VSS VDD VDD _04204_ sky130_fd_sc_hd__a21oi_1
X_13070_ _04023_ net73 VSS VSS VDD VDD _04205_ sky130_fd_sc_hd__nor2b_1
X_13071_ _04205_ VSS VSS VDD VDD _04206_ sky130_fd_sc_hd__buf_6
X_13072_ _04171_ _04204_ _04206_ VSS VSS VDD VDD _04207_ sky130_fd_sc_hd__a21oi_1
X_13073_ samples_imag\[0\]\[9\] _04168_ VSS VSS VDD VDD _04208_
+ sky130_fd_sc_hd__nand2_1
X_13074_ _04184_ _04207_ _04208_ VSS VSS VDD VDD _00307_ sky130_fd_sc_hd__o21ai_0
X_13075_ _03837_ _03839_ _03835_ VSS VSS VDD VDD _04209_ sky130_fd_sc_hd__nor3b_1
X_13076_ _03137_ _03887_ _03891_ VSS VSS VDD VDD _04210_ sky130_fd_sc_hd__a21boi_4
X_13077_ _03888_ _04209_ _04210_ VSS VSS VDD VDD _04211_ sky130_fd_sc_hd__o21ai_4
X_13078_ _04211_ VSS VSS VDD VDD _04212_ sky130_fd_sc_hd__buf_4
X_13079_ _04212_ VSS VSS VDD VDD _04213_ sky130_fd_sc_hd__buf_4
X_13080_ _03469_ VSS VSS VDD VDD _04214_ sky130_fd_sc_hd__clkbuf_4
X_13081_ _03146_ net516 _03151_ VSS VSS VDD VDD _04215_ sky130_fd_sc_hd__or3_1
X_13082_ _04215_ VSS VSS VDD VDD _04216_ sky130_fd_sc_hd__clkbuf_4
X_13083_ _04216_ VSS VSS VDD VDD _04217_ sky130_fd_sc_hd__buf_4
X_13084_ _04216_ VSS VSS VDD VDD _04218_ sky130_fd_sc_hd__buf_4
X_13085_ _04218_ _04211_ VSS VSS VDD VDD _04219_ sky130_fd_sc_hd__nor2_1
X_13086_ samples_imag\[1\]\[0\] _04217_ _03994_ _04219_ VSS
+ VSS VDD VDD _04220_ sky130_fd_sc_hd__a22oi_1
X_13087_ _04214_ _04220_ VSS VSS VDD VDD _04221_ sky130_fd_sc_hd__nor2_1
X_13088_ net44 _03276_ VSS VSS VDD VDD _04222_ sky130_fd_sc_hd__nand2_4
X_13089_ _04222_ _04212_ _03925_ VSS VSS VDD VDD _04223_ sky130_fd_sc_hd__nor3_2
X_13090_ _04223_ _04221_ _04004_ VSS VSS VDD VDD _04224_ sky130_fd_sc_hd__o21ai_1
X_13091_ _04212_ VSS VSS VDD VDD _04225_ sky130_fd_sc_hd__clkbuf_4
X_13092_ samples_imag\[1\]\[0\] _04225_ VSS VSS VDD VDD _04226_
+ sky130_fd_sc_hd__nand2_1
X_13093_ _04001_ _04213_ _04226_ _04224_ VSS VSS VDD VDD _00308_
+ sky130_fd_sc_hd__o211ai_2
X_13094_ _04211_ VSS VSS VDD VDD _04227_ sky130_fd_sc_hd__buf_4
X_13095_ _03469_ VSS VSS VDD VDD _04228_ sky130_fd_sc_hd__buf_4
X_13096_ _04006_ _04218_ VSS VSS VDD VDD _04229_ sky130_fd_sc_hd__nor2_1
X_13097_ samples_imag\[1\]\[10\] _04217_ _04229_ VSS VSS VDD
+ VDD _04230_ sky130_fd_sc_hd__a21oi_1
X_13098_ _03279_ VSS VSS VDD VDD _04231_ sky130_fd_sc_hd__clkbuf_4
X_13099_ _04231_ _04020_ VSS VSS VDD VDD _04232_ sky130_fd_sc_hd__nand2_1
X_13100_ _04228_ _04230_ _04232_ VSS VSS VDD VDD _04233_ sky130_fd_sc_hd__o21ai_1
X_13101_ _04171_ _04233_ _04025_ VSS VSS VDD VDD _04234_ sky130_fd_sc_hd__a21oi_1
X_13102_ samples_imag\[1\]\[10\] _04213_ VSS VSS VDD VDD _04235_
+ sky130_fd_sc_hd__nand2_1
X_13103_ _04227_ _04234_ _04235_ VSS VSS VDD VDD _00309_ sky130_fd_sc_hd__o21ai_1
X_13104_ _03142_ VSS VSS VDD VDD _04236_ sky130_fd_sc_hd__buf_4
X_13105_ _04236_ VSS VSS VDD VDD _04237_ sky130_fd_sc_hd__clkbuf_8
X_13106_ _03279_ VSS VSS VDD VDD _04238_ sky130_fd_sc_hd__clkbuf_4
X_13107_ _04216_ VSS VSS VDD VDD _04239_ sky130_fd_sc_hd__clkbuf_4
X_13108_ _04216_ VSS VSS VDD VDD _04240_ sky130_fd_sc_hd__buf_4
X_13109_ _04031_ _04240_ VSS VSS VDD VDD _04241_ sky130_fd_sc_hd__nor2_1
X_13110_ samples_imag\[1\]\[11\] _04239_ _04241_ VSS VSS VDD
+ VDD _04242_ sky130_fd_sc_hd__a21oi_1
X_13111_ _03279_ VSS VSS VDD VDD _04243_ sky130_fd_sc_hd__clkbuf_4
X_13112_ _04243_ _04036_ VSS VSS VDD VDD _04244_ sky130_fd_sc_hd__nand2_1
X_13113_ _04238_ _04242_ _04244_ VSS VSS VDD VDD _04245_ sky130_fd_sc_hd__o21ai_1
X_13114_ _04212_ VSS VSS VDD VDD _04246_ sky130_fd_sc_hd__buf_4
X_13115_ _04245_ _04237_ _04246_ _04040_ VSS VSS VDD VDD _04247_
+ sky130_fd_sc_hd__a211oi_1
X_13116_ _03305_ _04213_ _04247_ VSS VSS VDD VDD _00310_ sky130_fd_sc_hd__a21oi_1
X_13117_ _04045_ _04218_ VSS VSS VDD VDD _04248_ sky130_fd_sc_hd__nor2_1
X_13118_ samples_imag\[1\]\[12\] _04217_ _04248_ VSS VSS VDD
+ VDD _04249_ sky130_fd_sc_hd__a21oi_1
X_13119_ _04231_ _04052_ VSS VSS VDD VDD _04250_ sky130_fd_sc_hd__nand2_1
X_13120_ _04228_ _04249_ _04250_ VSS VSS VDD VDD _04251_ sky130_fd_sc_hd__o21ai_1
X_13121_ _04171_ _04251_ _04057_ VSS VSS VDD VDD _04252_ sky130_fd_sc_hd__a21oi_1
X_13122_ samples_imag\[1\]\[12\] _04213_ VSS VSS VDD VDD _04253_
+ sky130_fd_sc_hd__nand2_1
X_13123_ _04227_ _04252_ _04253_ VSS VSS VDD VDD _00311_ sky130_fd_sc_hd__o21ai_1
X_13124_ _04061_ _04240_ VSS VSS VDD VDD _04254_ sky130_fd_sc_hd__nor2_1
X_13125_ samples_imag\[1\]\[13\] _04239_ _04254_ VSS VSS VDD
+ VDD _04255_ sky130_fd_sc_hd__a21oi_1
X_13126_ _04243_ _04066_ VSS VSS VDD VDD _04256_ sky130_fd_sc_hd__nand2_1
X_13127_ _04238_ _04255_ _04256_ VSS VSS VDD VDD _04257_ sky130_fd_sc_hd__o21ai_1
X_13128_ _04257_ _04237_ _04246_ _04070_ VSS VSS VDD VDD _04258_
+ sky130_fd_sc_hd__a211oi_1
X_13129_ _03761_ _04213_ _04258_ VSS VSS VDD VDD _00312_ sky130_fd_sc_hd__a21oi_1
X_13130_ _04218_ _04073_ VSS VSS VDD VDD _04259_ sky130_fd_sc_hd__nor2_1
X_13131_ samples_imag\[1\]\[14\] _04217_ _04259_ VSS VSS VDD
+ VDD _04260_ sky130_fd_sc_hd__a21oi_1
X_13132_ _04231_ _04080_ VSS VSS VDD VDD _04261_ sky130_fd_sc_hd__nand2_1
X_13133_ _04228_ _04260_ _04261_ VSS VSS VDD VDD _04262_ sky130_fd_sc_hd__o21ai_1
X_13134_ _04171_ _04262_ _04084_ VSS VSS VDD VDD _04263_ sky130_fd_sc_hd__a21oi_1
X_13135_ samples_imag\[1\]\[14\] _04213_ VSS VSS VDD VDD _04264_
+ sky130_fd_sc_hd__nand2_1
X_13136_ _04227_ _04263_ _04264_ VSS VSS VDD VDD _00313_ sky130_fd_sc_hd__o21ai_1
X_13137_ _04216_ VSS VSS VDD VDD _04265_ sky130_fd_sc_hd__clkbuf_4
X_13138_ samples_imag\[1\]\[15\] _04216_ VSS VSS VDD VDD _04266_
+ sky130_fd_sc_hd__nand2_1
X_13139_ _04265_ _04090_ _04266_ _04222_ VSS VSS VDD VDD _04267_
+ sky130_fd_sc_hd__o211ai_1
X_13140_ _04222_ net524 _04267_ VSS VSS VDD VDD _04268_ sky130_fd_sc_hd__o21ai_0
X_13141_ _04088_ _04268_ _04212_ _04095_ VSS VSS VDD VDD _04269_
+ sky130_fd_sc_hd__a211oi_1
X_13142_ samples_imag\[1\]\[15\] _04246_ _04269_ VSS VSS VDD
+ VDD _00314_ sky130_fd_sc_hd__a21o_1
X_13143_ _04240_ net647 VSS VSS VDD VDD _04270_ sky130_fd_sc_hd__nor2_1
X_13144_ samples_imag\[1\]\[1\] _04239_ _04270_ VSS VSS VDD
+ VDD _04271_ sky130_fd_sc_hd__a21oi_1
X_13145_ _04101_ _04243_ VSS VSS VDD VDD _04272_ sky130_fd_sc_hd__nand2_1
X_13146_ _04238_ _04271_ _04272_ VSS VSS VDD VDD _04273_ sky130_fd_sc_hd__o21ai_1
X_13147_ _04273_ _04237_ _04246_ _04105_ VSS VSS VDD VDD _04274_
+ sky130_fd_sc_hd__a211oi_1
X_13148_ _03214_ _04213_ _04274_ VSS VSS VDD VDD _00315_ sky130_fd_sc_hd__a21oi_1
X_13149_ _04109_ _04218_ VSS VSS VDD VDD _04275_ sky130_fd_sc_hd__nor2_1
X_13150_ samples_imag\[1\]\[2\] _04217_ _04275_ VSS VSS VDD
+ VDD _04276_ sky130_fd_sc_hd__a21oi_1
X_13151_ _04231_ _04114_ VSS VSS VDD VDD _04277_ sky130_fd_sc_hd__nand2_1
X_13152_ _04228_ _04276_ _04277_ VSS VSS VDD VDD _04278_ sky130_fd_sc_hd__o21ai_1
X_13153_ _04171_ _04278_ _04118_ VSS VSS VDD VDD _04279_ sky130_fd_sc_hd__a21oi_1
X_13154_ samples_imag\[1\]\[2\] _04213_ VSS VSS VDD VDD _04280_
+ sky130_fd_sc_hd__nand2_1
X_13155_ _04279_ _04227_ _04280_ VSS VSS VDD VDD _00316_ sky130_fd_sc_hd__o21ai_1
X_13156_ _04218_ _04121_ VSS VSS VDD VDD _04281_ sky130_fd_sc_hd__nor2_1
X_13157_ samples_imag\[1\]\[3\] _04217_ _04281_ VSS VSS VDD
+ VDD _04282_ sky130_fd_sc_hd__a21oi_1
X_13158_ _04238_ _04126_ VSS VSS VDD VDD _04283_ sky130_fd_sc_hd__nand2_1
X_13159_ _04228_ _04282_ _04283_ VSS VSS VDD VDD _04284_ sky130_fd_sc_hd__o21ai_1
X_13160_ _04284_ _04171_ _04130_ VSS VSS VDD VDD _04285_ sky130_fd_sc_hd__a21oi_1
X_13161_ _04212_ VSS VSS VDD VDD _04286_ sky130_fd_sc_hd__buf_4
X_13162_ samples_imag\[1\]\[3\] _04286_ VSS VSS VDD VDD _04287_
+ sky130_fd_sc_hd__nand2_1
X_13163_ _04227_ _04285_ _04287_ VSS VSS VDD VDD _00317_ sky130_fd_sc_hd__o21ai_1
X_13164_ _04133_ _04218_ VSS VSS VDD VDD _04288_ sky130_fd_sc_hd__nor2_1
X_13165_ samples_imag\[1\]\[4\] _04217_ _04288_ VSS VSS VDD
+ VDD _04289_ sky130_fd_sc_hd__a21oi_1
X_13166_ _04238_ _04138_ VSS VSS VDD VDD _04290_ sky130_fd_sc_hd__nand2_1
X_13167_ _04231_ _04289_ _04290_ VSS VSS VDD VDD _04291_ sky130_fd_sc_hd__o21ai_1
X_13168_ _04171_ _04291_ _04142_ VSS VSS VDD VDD _04292_ sky130_fd_sc_hd__a21oi_1
X_13169_ samples_imag\[1\]\[4\] _04286_ VSS VSS VDD VDD _04293_
+ sky130_fd_sc_hd__nand2_1
X_13170_ _04227_ _04292_ _04293_ VSS VSS VDD VDD _00318_ sky130_fd_sc_hd__o21ai_1
X_13171_ _04145_ _04218_ VSS VSS VDD VDD _04294_ sky130_fd_sc_hd__nor2_1
X_13172_ samples_imag\[1\]\[5\] _04239_ _04294_ VSS VSS VDD
+ VDD _04295_ sky130_fd_sc_hd__a21oi_1
X_13173_ _04238_ _04150_ VSS VSS VDD VDD _04296_ sky130_fd_sc_hd__nand2_1
X_13174_ _04231_ _04295_ _04296_ VSS VSS VDD VDD _04297_ sky130_fd_sc_hd__o21ai_1
X_13175_ _04171_ _04297_ _04154_ VSS VSS VDD VDD _04298_ sky130_fd_sc_hd__a21oi_1
X_13176_ samples_imag\[1\]\[5\] _04286_ VSS VSS VDD VDD _04299_
+ sky130_fd_sc_hd__nand2_1
X_13177_ _04227_ _04298_ _04299_ VSS VSS VDD VDD _00319_ sky130_fd_sc_hd__o21ai_1
X_13178_ _04170_ VSS VSS VDD VDD _04300_ sky130_fd_sc_hd__clkbuf_4
X_13179_ _04218_ _04158_ VSS VSS VDD VDD _04301_ sky130_fd_sc_hd__nor2_2
X_13180_ samples_imag\[1\]\[6\] _04239_ _04301_ VSS VSS VDD
+ VDD _04302_ sky130_fd_sc_hd__a21oi_1
X_13181_ _04238_ _04162_ VSS VSS VDD VDD _04303_ sky130_fd_sc_hd__nand2_1
X_13182_ _04231_ _04302_ _04303_ VSS VSS VDD VDD _04304_ sky130_fd_sc_hd__o21ai_1
X_13183_ _04300_ _04304_ _04166_ VSS VSS VDD VDD _04305_ sky130_fd_sc_hd__a21oi_1
X_13184_ samples_imag\[1\]\[6\] _04286_ VSS VSS VDD VDD _04306_
+ sky130_fd_sc_hd__nand2_1
X_13185_ _04227_ _04305_ _04306_ VSS VSS VDD VDD _00320_ sky130_fd_sc_hd__o21ai_1
X_13186_ _04216_ _04173_ VSS VSS VDD VDD _04307_ sky130_fd_sc_hd__nor2_1
X_13187_ samples_imag\[1\]\[7\] _04239_ _04307_ VSS VSS VDD
+ VDD _04308_ sky130_fd_sc_hd__a21oi_1
X_13188_ _04243_ _04177_ VSS VSS VDD VDD _04309_ sky130_fd_sc_hd__nand2_1
X_13189_ _04243_ _04308_ _04309_ VSS VSS VDD VDD _04310_ sky130_fd_sc_hd__o21ai_1
X_13190_ _04237_ _04310_ _04212_ _04181_ VSS VSS VDD VDD _04311_
+ sky130_fd_sc_hd__a211oi_2
X_13191_ _03359_ _04213_ _04311_ VSS VSS VDD VDD _00321_ sky130_fd_sc_hd__a21oi_1
X_13192_ _04265_ _04186_ VSS VSS VDD VDD _04312_ sky130_fd_sc_hd__nor2_2
X_13193_ samples_imag\[1\]\[8\] _04239_ _04312_ VSS VSS VDD
+ VDD _04313_ sky130_fd_sc_hd__a21oi_1
X_13194_ _04238_ _04190_ VSS VSS VDD VDD _04314_ sky130_fd_sc_hd__nand2_1
X_13195_ _04231_ _04313_ _04314_ VSS VSS VDD VDD _04315_ sky130_fd_sc_hd__o21ai_1
X_13196_ _04300_ _04315_ _04194_ VSS VSS VDD VDD _04316_ sky130_fd_sc_hd__a21oi_1
X_13197_ samples_imag\[1\]\[8\] _04286_ VSS VSS VDD VDD _04317_
+ sky130_fd_sc_hd__nand2_1
X_13198_ _04227_ _04316_ _04317_ VSS VSS VDD VDD _00322_ sky130_fd_sc_hd__o21ai_1
X_13199_ _04211_ VSS VSS VDD VDD _04318_ sky130_fd_sc_hd__buf_4
X_13200_ _04265_ _04198_ VSS VSS VDD VDD _04319_ sky130_fd_sc_hd__nor2_1
X_13201_ samples_imag\[1\]\[9\] _04239_ _04319_ VSS VSS VDD
+ VDD _04320_ sky130_fd_sc_hd__a21oi_1
X_13202_ _04238_ _04202_ VSS VSS VDD VDD _04321_ sky130_fd_sc_hd__nand2_1
X_13203_ _04231_ _04320_ _04321_ VSS VSS VDD VDD _04322_ sky130_fd_sc_hd__o21ai_1
X_13204_ _04300_ _04322_ _04206_ VSS VSS VDD VDD _04323_ sky130_fd_sc_hd__a21oi_1
X_13205_ samples_imag\[1\]\[9\] _04286_ VSS VSS VDD VDD _04324_
+ sky130_fd_sc_hd__nand2_1
X_13206_ _04318_ _04323_ _04324_ VSS VSS VDD VDD _00323_ sky130_fd_sc_hd__o21ai_1
X_13207_ _03835_ _03839_ _03837_ VSS VSS VDD VDD _04325_ sky130_fd_sc_hd__nor3b_1
X_13208_ _03888_ _04325_ _04210_ VSS VSS VDD VDD _04326_ sky130_fd_sc_hd__o21ai_4
X_13209_ _04326_ VSS VSS VDD VDD _04327_ sky130_fd_sc_hd__clkbuf_4
X_13210_ _04327_ VSS VSS VDD VDD _04328_ sky130_fd_sc_hd__buf_4
X_13211_ _03437_ VSS VSS VDD VDD _04329_ sky130_fd_sc_hd__clkbuf_4
X_13212_ net539 _03151_ VSS VSS VDD VDD _04330_ sky130_fd_sc_hd__nand2b_1
X_13213_ _04330_ VSS VSS VDD VDD _04331_ sky130_fd_sc_hd__clkbuf_4
X_13214_ _04331_ VSS VSS VDD VDD _04332_ sky130_fd_sc_hd__clkbuf_4
X_13215_ _04331_ VSS VSS VDD VDD _04333_ sky130_fd_sc_hd__buf_4
X_13216_ _04333_ _04326_ VSS VSS VDD VDD _04334_ sky130_fd_sc_hd__nor2_1
X_13217_ samples_imag\[2\]\[0\] _04332_ _03994_ _04334_ VSS
+ VSS VDD VDD _04335_ sky130_fd_sc_hd__a22oi_1
X_13218_ _04329_ _04335_ VSS VSS VDD VDD _04336_ sky130_fd_sc_hd__nor2_1
X_13219_ _03296_ _03292_ VSS VSS VDD VDD _04337_ sky130_fd_sc_hd__nand2_4
X_13220_ _04337_ _04327_ _03925_ VSS VSS VDD VDD _04338_ sky130_fd_sc_hd__nor3_2
X_13221_ _04336_ _04338_ _04004_ VSS VSS VDD VDD _04339_ sky130_fd_sc_hd__o21ai_1
X_13222_ _04327_ VSS VSS VDD VDD _04340_ sky130_fd_sc_hd__clkbuf_4
X_13223_ samples_imag\[2\]\[0\] _04340_ VSS VSS VDD VDD _04341_
+ sky130_fd_sc_hd__nand2_1
X_13224_ _04001_ _04328_ _04341_ _04339_ VSS VSS VDD VDD _00324_
+ sky130_fd_sc_hd__o211ai_1
X_13225_ _04326_ VSS VSS VDD VDD _04342_ sky130_fd_sc_hd__clkbuf_4
X_13226_ _03437_ VSS VSS VDD VDD _04343_ sky130_fd_sc_hd__buf_4
X_13227_ _04333_ _04006_ VSS VSS VDD VDD _04344_ sky130_fd_sc_hd__nor2_1
X_13228_ samples_imag\[2\]\[10\] _04332_ _04344_ VSS VSS VDD
+ VDD _04345_ sky130_fd_sc_hd__a21oi_1
X_13229_ _03275_ VSS VSS VDD VDD _04346_ sky130_fd_sc_hd__clkbuf_4
X_13230_ _04346_ _04020_ VSS VSS VDD VDD _04347_ sky130_fd_sc_hd__nand2_1
X_13231_ _04343_ _04345_ _04347_ VSS VSS VDD VDD _04348_ sky130_fd_sc_hd__o21ai_1
X_13232_ _04300_ _04348_ _04025_ VSS VSS VDD VDD _04349_ sky130_fd_sc_hd__a21oi_1
X_13233_ samples_imag\[2\]\[10\] _04328_ VSS VSS VDD VDD _04350_
+ sky130_fd_sc_hd__nand2_1
X_13234_ _04342_ _04349_ _04350_ VSS VSS VDD VDD _00325_ sky130_fd_sc_hd__o21ai_1
X_13235_ _04031_ _04333_ VSS VSS VDD VDD _04351_ sky130_fd_sc_hd__nor2_1
X_13236_ samples_imag\[2\]\[11\] _04332_ _04351_ VSS VSS VDD
+ VDD _04352_ sky130_fd_sc_hd__a21oi_1
X_13237_ _03437_ VSS VSS VDD VDD _04353_ sky130_fd_sc_hd__clkbuf_4
X_13238_ _04353_ _04036_ VSS VSS VDD VDD _04354_ sky130_fd_sc_hd__nand2_1
X_13239_ _04343_ _04352_ _04354_ VSS VSS VDD VDD _04355_ sky130_fd_sc_hd__o21ai_1
X_13240_ _04300_ _04355_ _04040_ VSS VSS VDD VDD _04356_ sky130_fd_sc_hd__a21oi_1
X_13241_ samples_imag\[2\]\[11\] _04328_ VSS VSS VDD VDD _04357_
+ sky130_fd_sc_hd__nand2_1
X_13242_ _04342_ _04356_ _04357_ VSS VSS VDD VDD _00326_ sky130_fd_sc_hd__o21ai_1
X_13243_ _04331_ VSS VSS VDD VDD _04358_ sky130_fd_sc_hd__clkbuf_4
X_13244_ _04333_ _04045_ VSS VSS VDD VDD _04359_ sky130_fd_sc_hd__nor2_2
X_13245_ samples_imag\[2\]\[12\] _04358_ _04359_ VSS VSS VDD
+ VDD _04360_ sky130_fd_sc_hd__a21oi_1
X_13246_ _04353_ _04052_ VSS VSS VDD VDD _04361_ sky130_fd_sc_hd__nand2_1
X_13247_ _04343_ _04360_ _04361_ VSS VSS VDD VDD _04362_ sky130_fd_sc_hd__o21ai_1
X_13248_ _04300_ _04362_ _04057_ VSS VSS VDD VDD _04363_ sky130_fd_sc_hd__a21oi_1
X_13249_ samples_imag\[2\]\[12\] _04328_ VSS VSS VDD VDD _04364_
+ sky130_fd_sc_hd__nand2_1
X_13250_ _04342_ _04363_ _04364_ VSS VSS VDD VDD _00327_ sky130_fd_sc_hd__o21ai_1
X_13251_ _04061_ _04333_ VSS VSS VDD VDD _04365_ sky130_fd_sc_hd__nor2_1
X_13252_ samples_imag\[2\]\[13\] _04358_ _04365_ VSS VSS VDD
+ VDD _04366_ sky130_fd_sc_hd__a21oi_1
X_13253_ _04353_ _04066_ VSS VSS VDD VDD _04367_ sky130_fd_sc_hd__nand2_1
X_13254_ _04343_ _04366_ _04367_ VSS VSS VDD VDD _04368_ sky130_fd_sc_hd__o21ai_1
X_13255_ _04300_ _04368_ _04070_ VSS VSS VDD VDD _04369_ sky130_fd_sc_hd__a21oi_1
X_13256_ samples_imag\[2\]\[13\] _04328_ VSS VSS VDD VDD _04370_
+ sky130_fd_sc_hd__nand2_1
X_13257_ _04342_ _04369_ _04370_ VSS VSS VDD VDD _00328_ sky130_fd_sc_hd__o21ai_1
X_13258_ _04333_ _04073_ VSS VSS VDD VDD _04371_ sky130_fd_sc_hd__nor2_1
X_13259_ samples_imag\[2\]\[14\] _04358_ _04371_ VSS VSS VDD
+ VDD _04372_ sky130_fd_sc_hd__a21oi_1
X_13260_ _04353_ _04080_ VSS VSS VDD VDD _04373_ sky130_fd_sc_hd__nand2_1
X_13261_ _04343_ _04372_ _04373_ VSS VSS VDD VDD _04374_ sky130_fd_sc_hd__o21ai_1
X_13262_ _04300_ _04374_ _04084_ VSS VSS VDD VDD _04375_ sky130_fd_sc_hd__a21oi_1
X_13263_ samples_imag\[2\]\[14\] _04328_ VSS VSS VDD VDD _04376_
+ sky130_fd_sc_hd__nand2_1
X_13264_ _04375_ _04342_ _04376_ VSS VSS VDD VDD _00329_ sky130_fd_sc_hd__o21ai_1
X_13265_ _04327_ VSS VSS VDD VDD _04377_ sky130_fd_sc_hd__buf_4
X_13266_ _04331_ VSS VSS VDD VDD _04378_ sky130_fd_sc_hd__clkbuf_4
X_13267_ samples_imag\[2\]\[15\] _04331_ VSS VSS VDD VDD _04379_
+ sky130_fd_sc_hd__nand2_1
X_13268_ _04378_ _04090_ _04379_ _04337_ VSS VSS VDD VDD _04380_
+ sky130_fd_sc_hd__o211ai_1
X_13269_ _04337_ net54 _04380_ VSS VSS VDD VDD _04381_ sky130_fd_sc_hd__o21ai_1
X_13270_ _04088_ _04381_ _04327_ _04095_ VSS VSS VDD VDD _04382_
+ sky130_fd_sc_hd__a211oi_2
X_13271_ samples_imag\[2\]\[15\] _04377_ _04382_ VSS VSS VDD
+ VDD _00330_ sky130_fd_sc_hd__a21o_1
X_13272_ _04333_ _04097_ VSS VSS VDD VDD _04383_ sky130_fd_sc_hd__nor2_2
X_13273_ samples_imag\[2\]\[1\] _04358_ _04383_ VSS VSS VDD
+ VDD _04384_ sky130_fd_sc_hd__a21oi_1
X_13274_ _04353_ _04101_ VSS VSS VDD VDD _04385_ sky130_fd_sc_hd__nand2_1
X_13275_ _04346_ _04384_ _04385_ VSS VSS VDD VDD _04386_ sky130_fd_sc_hd__o21ai_1
X_13276_ _04300_ _04386_ _04105_ VSS VSS VDD VDD _04387_ sky130_fd_sc_hd__a21oi_1
X_13277_ _04327_ VSS VSS VDD VDD _04388_ sky130_fd_sc_hd__buf_4
X_13278_ samples_imag\[2\]\[1\] _04388_ VSS VSS VDD VDD _04389_
+ sky130_fd_sc_hd__nand2_1
X_13279_ _04387_ _04342_ _04389_ VSS VSS VDD VDD _00331_ sky130_fd_sc_hd__o21ai_1
X_13280_ _04109_ _04378_ VSS VSS VDD VDD _04390_ sky130_fd_sc_hd__nor2_1
X_13281_ samples_imag\[2\]\[2\] _04358_ _04390_ VSS VSS VDD
+ VDD _04391_ sky130_fd_sc_hd__a21oi_1
X_13282_ _04353_ _04114_ VSS VSS VDD VDD _04392_ sky130_fd_sc_hd__nand2_1
X_13283_ _04346_ _04391_ _04392_ VSS VSS VDD VDD _04393_ sky130_fd_sc_hd__o21ai_1
X_13284_ _04300_ _04393_ _04118_ VSS VSS VDD VDD _04394_ sky130_fd_sc_hd__a21oi_1
X_13285_ samples_imag\[2\]\[2\] _04388_ VSS VSS VDD VDD _04395_
+ sky130_fd_sc_hd__nand2_1
X_13286_ _04342_ _04394_ _04395_ VSS VSS VDD VDD _00332_ sky130_fd_sc_hd__o21ai_1
X_13287_ _04170_ VSS VSS VDD VDD _04396_ sky130_fd_sc_hd__buf_2
X_13288_ _04378_ _04121_ VSS VSS VDD VDD _04397_ sky130_fd_sc_hd__nor2_2
X_13289_ samples_imag\[2\]\[3\] _04358_ _04397_ VSS VSS VDD
+ VDD _04398_ sky130_fd_sc_hd__a21oi_1
X_13290_ _04353_ _04126_ VSS VSS VDD VDD _04399_ sky130_fd_sc_hd__nand2_1
X_13291_ _04346_ _04398_ _04399_ VSS VSS VDD VDD _04400_ sky130_fd_sc_hd__o21ai_1
X_13292_ _04396_ _04400_ _04130_ VSS VSS VDD VDD _04401_ sky130_fd_sc_hd__a21oi_1
X_13293_ samples_imag\[2\]\[3\] _04388_ VSS VSS VDD VDD _04402_
+ sky130_fd_sc_hd__nand2_1
X_13294_ _04342_ _04401_ _04402_ VSS VSS VDD VDD _00333_ sky130_fd_sc_hd__o21ai_1
X_13295_ _04133_ _04378_ VSS VSS VDD VDD _04403_ sky130_fd_sc_hd__nor2_1
X_13296_ samples_imag\[2\]\[4\] _04358_ _04403_ VSS VSS VDD
+ VDD _04404_ sky130_fd_sc_hd__a21oi_1
X_13297_ _04353_ _04138_ VSS VSS VDD VDD _04405_ sky130_fd_sc_hd__nand2_1
X_13298_ _04346_ _04404_ _04405_ VSS VSS VDD VDD _04406_ sky130_fd_sc_hd__o21ai_1
X_13299_ _04396_ _04406_ _04142_ VSS VSS VDD VDD _04407_ sky130_fd_sc_hd__a21oi_1
X_13300_ samples_imag\[2\]\[4\] _04388_ VSS VSS VDD VDD _04408_
+ sky130_fd_sc_hd__nand2_1
X_13301_ _04342_ _04407_ _04408_ VSS VSS VDD VDD _00334_ sky130_fd_sc_hd__o21ai_1
X_13302_ _04326_ VSS VSS VDD VDD _04409_ sky130_fd_sc_hd__buf_4
X_13303_ _04378_ _04145_ VSS VSS VDD VDD _04410_ sky130_fd_sc_hd__nor2_2
X_13304_ samples_imag\[2\]\[5\] _04358_ _04410_ VSS VSS VDD
+ VDD _04411_ sky130_fd_sc_hd__a21oi_1
X_13305_ _04353_ _04150_ VSS VSS VDD VDD _04412_ sky130_fd_sc_hd__nand2_1
X_13306_ _04346_ _04411_ _04412_ VSS VSS VDD VDD _04413_ sky130_fd_sc_hd__o21ai_1
X_13307_ _04396_ _04413_ _04154_ VSS VSS VDD VDD _04414_ sky130_fd_sc_hd__a21oi_1
X_13308_ samples_imag\[2\]\[5\] _04388_ VSS VSS VDD VDD _04415_
+ sky130_fd_sc_hd__nand2_1
X_13309_ _04409_ _04414_ _04415_ VSS VSS VDD VDD _00335_ sky130_fd_sc_hd__o21ai_1
X_13310_ _04378_ _04158_ VSS VSS VDD VDD _04416_ sky130_fd_sc_hd__nor2_1
X_13311_ samples_imag\[2\]\[6\] _04358_ _04416_ VSS VSS VDD
+ VDD _04417_ sky130_fd_sc_hd__a21oi_1
X_13312_ _04353_ _04162_ VSS VSS VDD VDD _04418_ sky130_fd_sc_hd__nand2_1
X_13313_ _04346_ _04417_ _04418_ VSS VSS VDD VDD _04419_ sky130_fd_sc_hd__o21ai_1
X_13314_ _04396_ _04419_ _04166_ VSS VSS VDD VDD _04420_ sky130_fd_sc_hd__a21oi_1
X_13315_ samples_imag\[2\]\[6\] _04388_ VSS VSS VDD VDD _04421_
+ sky130_fd_sc_hd__nand2_1
X_13316_ _04409_ _04420_ _04421_ VSS VSS VDD VDD _00336_ sky130_fd_sc_hd__o21ai_1
X_13317_ _04378_ _04173_ VSS VSS VDD VDD _04422_ sky130_fd_sc_hd__nor2_1
X_13318_ samples_imag\[2\]\[7\] _04358_ _04422_ VSS VSS VDD
+ VDD _04423_ sky130_fd_sc_hd__a21oi_1
X_13319_ _03275_ VSS VSS VDD VDD _04424_ sky130_fd_sc_hd__clkbuf_4
X_13320_ _04424_ _04177_ VSS VSS VDD VDD _04425_ sky130_fd_sc_hd__nand2_1
X_13321_ _04346_ _04423_ _04425_ VSS VSS VDD VDD _04426_ sky130_fd_sc_hd__o21ai_1
X_13322_ _04396_ _04426_ _04181_ VSS VSS VDD VDD _04427_ sky130_fd_sc_hd__a21oi_1
X_13323_ samples_imag\[2\]\[7\] _04388_ VSS VSS VDD VDD _04428_
+ sky130_fd_sc_hd__nand2_1
X_13324_ _04409_ _04427_ _04428_ VSS VSS VDD VDD _00337_ sky130_fd_sc_hd__o21ai_1
X_13325_ _04331_ VSS VSS VDD VDD _04429_ sky130_fd_sc_hd__buf_4
X_13326_ _04331_ _04186_ VSS VSS VDD VDD _04430_ sky130_fd_sc_hd__nor2_1
X_13327_ samples_imag\[2\]\[8\] _04429_ _04430_ VSS VSS VDD
+ VDD _04431_ sky130_fd_sc_hd__a21oi_1
X_13328_ _04424_ _04190_ VSS VSS VDD VDD _04432_ sky130_fd_sc_hd__nand2_1
X_13329_ _04424_ _04431_ _04432_ VSS VSS VDD VDD _04433_ sky130_fd_sc_hd__o21ai_1
X_13330_ _04237_ _04433_ _04377_ _04194_ VSS VSS VDD VDD _04434_
+ sky130_fd_sc_hd__a211oi_2
X_13331_ _03347_ _04328_ _04434_ VSS VSS VDD VDD _00338_ sky130_fd_sc_hd__a21oi_1
X_13332_ _04378_ _04198_ VSS VSS VDD VDD _04435_ sky130_fd_sc_hd__nor2_1
X_13333_ samples_imag\[2\]\[9\] _04429_ _04435_ VSS VSS VDD
+ VDD _04436_ sky130_fd_sc_hd__a21oi_1
X_13334_ _04424_ _04202_ VSS VSS VDD VDD _04437_ sky130_fd_sc_hd__nand2_1
X_13335_ _04346_ _04436_ _04437_ VSS VSS VDD VDD _04438_ sky130_fd_sc_hd__o21ai_1
X_13336_ _04396_ _04438_ _04206_ VSS VSS VDD VDD _04439_ sky130_fd_sc_hd__a21oi_1
X_13337_ samples_imag\[2\]\[9\] _04388_ VSS VSS VDD VDD _04440_
+ sky130_fd_sc_hd__nand2_1
X_13338_ _04409_ _04439_ _04440_ VSS VSS VDD VDD _00339_ sky130_fd_sc_hd__o21ai_1
X_13339_ _03837_ _03835_ VSS VSS VDD VDD _04441_ sky130_fd_sc_hd__nand2_1
X_13340_ _03839_ _04441_ VSS VSS VDD VDD _04442_ sky130_fd_sc_hd__nor2_1
X_13341_ _03888_ _04442_ _04210_ VSS VSS VDD VDD _04443_ sky130_fd_sc_hd__o21ai_4
X_13342_ _04443_ VSS VSS VDD VDD _04444_ sky130_fd_sc_hd__buf_4
X_13343_ _03158_ net539 VSS VSS VDD VDD _04445_ sky130_fd_sc_hd__or2_0
X_13344_ _04445_ VSS VSS VDD VDD _04446_ sky130_fd_sc_hd__buf_4
X_13345_ _04446_ VSS VSS VDD VDD _04447_ sky130_fd_sc_hd__buf_4
X_13346_ _04446_ _04444_ VSS VSS VDD VDD _04448_ sky130_fd_sc_hd__nor2_1
X_13347_ samples_imag\[3\]\[0\] _04447_ _03994_ _04448_ VSS
+ VSS VDD VDD _04449_ sky130_fd_sc_hd__a22oi_1
X_13348_ _03296_ _03287_ VSS VSS VDD VDD _04450_ sky130_fd_sc_hd__nand2_4
X_13349_ _04450_ _04444_ VSS VSS VDD VDD _04451_ sky130_fd_sc_hd__or2_1
X_13350_ _03439_ _04449_ _04451_ _03925_ VSS VSS VDD VDD _04452_
+ sky130_fd_sc_hd__o22ai_2
X_13351_ _04001_ _04444_ VSS VSS VDD VDD _04453_ sky130_fd_sc_hd__nor2_1
X_13352_ samples_imag\[3\]\[0\] _04444_ _04452_ _03999_ _04453_
+ VSS VSS VDD VDD _00340_ sky130_fd_sc_hd__a221o_1
X_13353_ _04444_ VSS VSS VDD VDD _04454_ sky130_fd_sc_hd__buf_4
X_13354_ _03439_ VSS VSS VDD VDD _04455_ sky130_fd_sc_hd__buf_4
X_13355_ _04446_ VSS VSS VDD VDD _04456_ sky130_fd_sc_hd__buf_4
X_13356_ _04447_ _04006_ VSS VSS VDD VDD _04457_ sky130_fd_sc_hd__nor2_2
X_13357_ samples_imag\[3\]\[10\] _04456_ _04457_ VSS VSS VDD
+ VDD _04458_ sky130_fd_sc_hd__a21oi_1
X_13358_ _03439_ VSS VSS VDD VDD _04459_ sky130_fd_sc_hd__clkbuf_4
X_13359_ _04459_ _04020_ VSS VSS VDD VDD _04460_ sky130_fd_sc_hd__nand2_1
X_13360_ _04455_ _04458_ _04460_ VSS VSS VDD VDD _04461_ sky130_fd_sc_hd__o21ai_1
X_13361_ _04396_ _04461_ _04025_ VSS VSS VDD VDD _04462_ sky130_fd_sc_hd__a21oi_1
X_13362_ _04444_ VSS VSS VDD VDD _04463_ sky130_fd_sc_hd__buf_2
X_13363_ samples_imag\[3\]\[10\] _04463_ VSS VSS VDD VDD _04464_
+ sky130_fd_sc_hd__nand2_1
X_13364_ _04462_ _04454_ _04464_ VSS VSS VDD VDD _00341_ sky130_fd_sc_hd__o21ai_1
X_13365_ _04031_ _04447_ VSS VSS VDD VDD _04465_ sky130_fd_sc_hd__nor2_2
X_13366_ samples_imag\[3\]\[11\] _04456_ _04465_ VSS VSS VDD
+ VDD _04466_ sky130_fd_sc_hd__a21oi_1
X_13367_ _03439_ VSS VSS VDD VDD _04467_ sky130_fd_sc_hd__buf_2
X_13368_ _04467_ _04036_ VSS VSS VDD VDD _04468_ sky130_fd_sc_hd__nand2_1
X_13369_ _04455_ _04466_ _04468_ VSS VSS VDD VDD _04469_ sky130_fd_sc_hd__o21ai_1
X_13370_ _04396_ _04469_ _04040_ VSS VSS VDD VDD _04470_ sky130_fd_sc_hd__a21oi_1
X_13371_ samples_imag\[3\]\[11\] _04463_ VSS VSS VDD VDD _04471_
+ sky130_fd_sc_hd__nand2_1
X_13372_ _04470_ _04454_ _04471_ VSS VSS VDD VDD _00342_ sky130_fd_sc_hd__o21ai_1
X_13373_ _04443_ VSS VSS VDD VDD _04472_ sky130_fd_sc_hd__clkbuf_2
X_13374_ _04447_ _04045_ VSS VSS VDD VDD _04473_ sky130_fd_sc_hd__nor2_2
X_13375_ samples_imag\[3\]\[12\] _04456_ _04473_ VSS VSS VDD
+ VDD _04474_ sky130_fd_sc_hd__a21oi_1
X_13376_ _04052_ _04467_ VSS VSS VDD VDD _04475_ sky130_fd_sc_hd__nand2_1
X_13377_ _04455_ _04474_ _04475_ VSS VSS VDD VDD _04476_ sky130_fd_sc_hd__o21ai_1
X_13378_ _04476_ _04396_ _04057_ VSS VSS VDD VDD _04477_ sky130_fd_sc_hd__a21oi_1
X_13379_ samples_imag\[3\]\[12\] _04463_ VSS VSS VDD VDD _04478_
+ sky130_fd_sc_hd__nand2_1
X_13380_ _04472_ _04477_ _04478_ VSS VSS VDD VDD _00343_ sky130_fd_sc_hd__o21ai_1
X_13381_ _04061_ _04447_ VSS VSS VDD VDD _04479_ sky130_fd_sc_hd__nor2_2
X_13382_ samples_imag\[3\]\[13\] _04456_ _04479_ VSS VSS VDD
+ VDD _04480_ sky130_fd_sc_hd__a21oi_1
X_13383_ _04467_ _04066_ VSS VSS VDD VDD _04481_ sky130_fd_sc_hd__nand2_1
X_13384_ _04455_ _04480_ _04481_ VSS VSS VDD VDD _04482_ sky130_fd_sc_hd__o21ai_1
X_13385_ _04396_ _04482_ _04070_ VSS VSS VDD VDD _04483_ sky130_fd_sc_hd__a21oi_1
X_13386_ samples_imag\[3\]\[13\] _04463_ VSS VSS VDD VDD _04484_
+ sky130_fd_sc_hd__nand2_1
X_13387_ _04472_ _04483_ _04484_ VSS VSS VDD VDD _00344_ sky130_fd_sc_hd__o21ai_1
X_13388_ _04170_ VSS VSS VDD VDD _04485_ sky130_fd_sc_hd__buf_2
X_13389_ _04446_ VSS VSS VDD VDD _04486_ sky130_fd_sc_hd__buf_2
X_13390_ _04073_ _04447_ VSS VSS VDD VDD _04487_ sky130_fd_sc_hd__nor2_1
X_13391_ samples_imag\[3\]\[14\] _04486_ _04487_ VSS VSS VDD
+ VDD _04488_ sky130_fd_sc_hd__a21oi_1
X_13392_ _04467_ _04080_ VSS VSS VDD VDD _04489_ sky130_fd_sc_hd__nand2_1
X_13393_ _04455_ _04488_ _04489_ VSS VSS VDD VDD _04490_ sky130_fd_sc_hd__o21ai_1
X_13394_ _04485_ _04490_ _04084_ VSS VSS VDD VDD _04491_ sky130_fd_sc_hd__a21oi_1
X_13395_ samples_imag\[3\]\[14\] _04463_ VSS VSS VDD VDD _04492_
+ sky130_fd_sc_hd__nand2_1
X_13396_ _04472_ _04491_ _04492_ VSS VSS VDD VDD _00345_ sky130_fd_sc_hd__o21ai_1
X_13397_ _04444_ VSS VSS VDD VDD _04493_ sky130_fd_sc_hd__buf_2
X_13398_ _04446_ VSS VSS VDD VDD _04494_ sky130_fd_sc_hd__buf_4
X_13399_ samples_imag\[3\]\[15\] _04446_ VSS VSS VDD VDD _04495_
+ sky130_fd_sc_hd__nand2_1
X_13400_ _04494_ _04090_ _04495_ _04450_ VSS VSS VDD VDD _04496_
+ sky130_fd_sc_hd__o211ai_1
X_13401_ _04450_ net54 _04496_ VSS VSS VDD VDD _04497_ sky130_fd_sc_hd__o21ai_0
X_13402_ _04088_ _04497_ _04493_ _04095_ VSS VSS VDD VDD _04498_
+ sky130_fd_sc_hd__a211oi_1
X_13403_ samples_imag\[3\]\[15\] _04493_ _04498_ VSS VSS VDD
+ VDD _00346_ sky130_fd_sc_hd__a21o_1
X_13404_ _04447_ _04097_ VSS VSS VDD VDD _04499_ sky130_fd_sc_hd__nor2_1
X_13405_ samples_imag\[3\]\[1\] _04486_ _04499_ VSS VSS VDD
+ VDD _04500_ sky130_fd_sc_hd__a21oi_1
X_13406_ _04467_ _04101_ VSS VSS VDD VDD _04501_ sky130_fd_sc_hd__nand2_1
X_13407_ _04455_ _04500_ _04501_ VSS VSS VDD VDD _04502_ sky130_fd_sc_hd__o21ai_1
X_13408_ _04485_ _04502_ _04105_ VSS VSS VDD VDD _04503_ sky130_fd_sc_hd__a21oi_1
X_13409_ samples_imag\[3\]\[1\] _04463_ VSS VSS VDD VDD _04504_
+ sky130_fd_sc_hd__nand2_1
X_13410_ _04472_ _04503_ _04504_ VSS VSS VDD VDD _00347_ sky130_fd_sc_hd__o21ai_1
X_13411_ _04447_ _04109_ VSS VSS VDD VDD _04505_ sky130_fd_sc_hd__nor2_2
X_13412_ samples_imag\[3\]\[2\] _04486_ _04505_ VSS VSS VDD
+ VDD _04506_ sky130_fd_sc_hd__a21oi_1
X_13413_ _04467_ _04114_ VSS VSS VDD VDD _04507_ sky130_fd_sc_hd__nand2_1
X_13414_ _04459_ _04506_ _04507_ VSS VSS VDD VDD _04508_ sky130_fd_sc_hd__o21ai_1
X_13415_ _04485_ _04508_ _04118_ VSS VSS VDD VDD _04509_ sky130_fd_sc_hd__a21oi_1
X_13416_ samples_imag\[3\]\[2\] _04463_ VSS VSS VDD VDD _04510_
+ sky130_fd_sc_hd__nand2_1
X_13417_ _04472_ _04509_ _04510_ VSS VSS VDD VDD _00348_ sky130_fd_sc_hd__o21ai_1
X_13418_ _04494_ _04121_ VSS VSS VDD VDD _04511_ sky130_fd_sc_hd__nor2_2
X_13419_ samples_imag\[3\]\[3\] _04486_ _04511_ VSS VSS VDD
+ VDD _04512_ sky130_fd_sc_hd__a21oi_1
X_13420_ _04467_ _04126_ VSS VSS VDD VDD _04513_ sky130_fd_sc_hd__nand2_1
X_13421_ _04459_ _04512_ _04513_ VSS VSS VDD VDD _04514_ sky130_fd_sc_hd__o21ai_1
X_13422_ _04485_ _04514_ _04130_ VSS VSS VDD VDD _04515_ sky130_fd_sc_hd__a21oi_1
X_13423_ samples_imag\[3\]\[3\] _04463_ VSS VSS VDD VDD _04516_
+ sky130_fd_sc_hd__nand2_1
X_13424_ _04472_ _04515_ _04516_ VSS VSS VDD VDD _00349_ sky130_fd_sc_hd__o21ai_1
X_13425_ _04133_ _04494_ VSS VSS VDD VDD _04517_ sky130_fd_sc_hd__nor2_1
X_13426_ samples_imag\[3\]\[4\] _04486_ _04517_ VSS VSS VDD
+ VDD _04518_ sky130_fd_sc_hd__a21oi_1
X_13427_ _04467_ _04138_ VSS VSS VDD VDD _04519_ sky130_fd_sc_hd__nand2_1
X_13428_ _04459_ _04518_ _04519_ VSS VSS VDD VDD _04520_ sky130_fd_sc_hd__o21ai_1
X_13429_ _04485_ _04520_ _04142_ VSS VSS VDD VDD _04521_ sky130_fd_sc_hd__a21oi_1
X_13430_ samples_imag\[3\]\[4\] _04463_ VSS VSS VDD VDD _04522_
+ sky130_fd_sc_hd__nand2_1
X_13431_ _04472_ _04521_ _04522_ VSS VSS VDD VDD _00350_ sky130_fd_sc_hd__o21ai_1
X_13432_ _04145_ _04494_ VSS VSS VDD VDD _04523_ sky130_fd_sc_hd__nor2_1
X_13433_ samples_imag\[3\]\[5\] _04486_ _04523_ VSS VSS VDD
+ VDD _04524_ sky130_fd_sc_hd__a21oi_1
X_13434_ _04467_ _04150_ VSS VSS VDD VDD _04525_ sky130_fd_sc_hd__nand2_1
X_13435_ _04459_ _04524_ _04525_ VSS VSS VDD VDD _04526_ sky130_fd_sc_hd__o21ai_1
X_13436_ _04485_ _04526_ _04154_ VSS VSS VDD VDD _04527_ sky130_fd_sc_hd__a21oi_1
X_13437_ samples_imag\[3\]\[5\] _04463_ VSS VSS VDD VDD _04528_
+ sky130_fd_sc_hd__nand2_1
X_13438_ _04472_ _04527_ _04528_ VSS VSS VDD VDD _00351_ sky130_fd_sc_hd__o21ai_1
X_13439_ _04494_ _04158_ VSS VSS VDD VDD _04529_ sky130_fd_sc_hd__nor2_1
X_13440_ samples_imag\[3\]\[6\] _04486_ _04529_ VSS VSS VDD
+ VDD _04530_ sky130_fd_sc_hd__a21oi_1
X_13441_ _04467_ _04162_ VSS VSS VDD VDD _04531_ sky130_fd_sc_hd__nand2_1
X_13442_ _04459_ _04530_ _04531_ VSS VSS VDD VDD _04532_ sky130_fd_sc_hd__o21ai_1
X_13443_ _04485_ _04532_ _04166_ VSS VSS VDD VDD _04533_ sky130_fd_sc_hd__a21oi_1
X_13444_ _04444_ VSS VSS VDD VDD _04534_ sky130_fd_sc_hd__buf_4
X_13445_ samples_imag\[3\]\[6\] _04534_ VSS VSS VDD VDD _04535_
+ sky130_fd_sc_hd__nand2_1
X_13446_ _04472_ _04533_ _04535_ VSS VSS VDD VDD _00352_ sky130_fd_sc_hd__o21ai_1
X_13447_ _04494_ _04173_ VSS VSS VDD VDD _04536_ sky130_fd_sc_hd__nor2_1
X_13448_ samples_imag\[3\]\[7\] _04486_ _04536_ VSS VSS VDD
+ VDD _04537_ sky130_fd_sc_hd__a21oi_1
X_13449_ _03439_ _04177_ VSS VSS VDD VDD _04538_ sky130_fd_sc_hd__nand2_1
X_13450_ _04459_ _04537_ _04538_ VSS VSS VDD VDD _04539_ sky130_fd_sc_hd__o21ai_1
X_13451_ _04485_ _04539_ _04181_ VSS VSS VDD VDD _04540_ sky130_fd_sc_hd__a21oi_1
X_13452_ samples_imag\[3\]\[7\] _04534_ VSS VSS VDD VDD _04541_
+ sky130_fd_sc_hd__nand2_1
X_13453_ _04472_ _04540_ _04541_ VSS VSS VDD VDD _00353_ sky130_fd_sc_hd__o21ai_1
X_13454_ _04443_ VSS VSS VDD VDD _04542_ sky130_fd_sc_hd__buf_4
X_13455_ _04494_ _04186_ VSS VSS VDD VDD _04543_ sky130_fd_sc_hd__nor2_1
X_13456_ samples_imag\[3\]\[8\] _04486_ _04543_ VSS VSS VDD
+ VDD _04544_ sky130_fd_sc_hd__a21oi_1
X_13457_ _03439_ _04190_ VSS VSS VDD VDD _04545_ sky130_fd_sc_hd__nand2_1
X_13458_ _04459_ _04544_ _04545_ VSS VSS VDD VDD _04546_ sky130_fd_sc_hd__o21ai_1
X_13459_ _04485_ _04546_ _04194_ VSS VSS VDD VDD _04547_ sky130_fd_sc_hd__a21oi_1
X_13460_ samples_imag\[3\]\[8\] _04534_ VSS VSS VDD VDD _04548_
+ sky130_fd_sc_hd__nand2_1
X_13461_ _04542_ _04547_ _04548_ VSS VSS VDD VDD _00354_ sky130_fd_sc_hd__o21ai_1
X_13462_ _04494_ _04198_ VSS VSS VDD VDD _04549_ sky130_fd_sc_hd__nor2_2
X_13463_ samples_imag\[3\]\[9\] _04486_ _04549_ VSS VSS VDD
+ VDD _04550_ sky130_fd_sc_hd__a21oi_1
X_13464_ _03439_ _04202_ VSS VSS VDD VDD _04551_ sky130_fd_sc_hd__nand2_2
X_13465_ _04459_ _04550_ _04551_ VSS VSS VDD VDD _04552_ sky130_fd_sc_hd__o21ai_1
X_13466_ _04485_ _04552_ _04206_ VSS VSS VDD VDD _04553_ sky130_fd_sc_hd__a21oi_1
X_13467_ samples_imag\[3\]\[9\] _04534_ VSS VSS VDD VDD _04554_
+ sky130_fd_sc_hd__nand2_1
X_13468_ _04542_ _04553_ _04554_ VSS VSS VDD VDD _00355_ sky130_fd_sc_hd__o21ai_1
X_13469_ _03837_ _03835_ _03839_ VSS VSS VDD VDD _04555_ sky130_fd_sc_hd__nor3b_1
X_13470_ _03888_ _04555_ _04210_ VSS VSS VDD VDD _04556_ sky130_fd_sc_hd__o21ai_4
X_13471_ _04556_ VSS VSS VDD VDD _04557_ sky130_fd_sc_hd__buf_2
X_13472_ _03467_ VSS VSS VDD VDD _04558_ sky130_fd_sc_hd__buf_2
X_13473_ _03146_ _03160_ VSS VSS VDD VDD _04559_ sky130_fd_sc_hd__nand2_2
X_13474_ _04559_ VSS VSS VDD VDD _04560_ sky130_fd_sc_hd__clkbuf_4
X_13475_ _04559_ VSS VSS VDD VDD _04561_ sky130_fd_sc_hd__clkbuf_4
X_13476_ _04561_ _04556_ VSS VSS VDD VDD _04562_ sky130_fd_sc_hd__nor2_1
X_13477_ samples_imag\[4\]\[0\] _04560_ _03994_ _04562_ VSS
+ VSS VDD VDD _04563_ sky130_fd_sc_hd__a22oi_1
X_13478_ _03272_ VSS VSS VDD VDD _04564_ sky130_fd_sc_hd__clkbuf_4
X_13479_ _04557_ _03925_ VSS VSS VDD VDD _04565_ sky130_fd_sc_hd__nor2_1
X_13480_ _04564_ _04565_ VSS VSS VDD VDD _04566_ sky130_fd_sc_hd__nand2_1
X_13481_ _04558_ _04563_ _04566_ VSS VSS VDD VDD _04567_ sky130_fd_sc_hd__o21ai_1
X_13482_ _04001_ _04557_ VSS VSS VDD VDD _04568_ sky130_fd_sc_hd__nor2_1
X_13483_ samples_imag\[4\]\[0\] _04557_ _03999_ _04567_ _04568_
+ VSS VSS VDD VDD _00356_ sky130_fd_sc_hd__a221o_1
X_13484_ _04557_ VSS VSS VDD VDD _04569_ sky130_fd_sc_hd__clkbuf_4
X_13485_ _04170_ VSS VSS VDD VDD _04570_ sky130_fd_sc_hd__buf_2
X_13486_ _03467_ VSS VSS VDD VDD _04571_ sky130_fd_sc_hd__clkbuf_4
X_13487_ _04561_ VSS VSS VDD VDD _04572_ sky130_fd_sc_hd__buf_2
X_13488_ _04559_ VSS VSS VDD VDD _04573_ sky130_fd_sc_hd__clkbuf_4
X_13489_ _04573_ _04006_ VSS VSS VDD VDD _04574_ sky130_fd_sc_hd__nor2_2
X_13490_ samples_imag\[4\]\[10\] _04572_ _04574_ VSS VSS VDD
+ VDD _04575_ sky130_fd_sc_hd__a21oi_1
X_13491_ _03467_ VSS VSS VDD VDD _04576_ sky130_fd_sc_hd__buf_2
X_13492_ _04576_ _04020_ VSS VSS VDD VDD _04577_ sky130_fd_sc_hd__nand2_1
X_13493_ _04575_ _04571_ _04577_ VSS VSS VDD VDD _04578_ sky130_fd_sc_hd__o21ai_1
X_13494_ _04570_ _04578_ _04025_ VSS VSS VDD VDD _04579_ sky130_fd_sc_hd__a21oi_1
X_13495_ _04557_ VSS VSS VDD VDD _04580_ sky130_fd_sc_hd__clkbuf_4
X_13496_ samples_imag\[4\]\[10\] _04580_ VSS VSS VDD VDD _04581_
+ sky130_fd_sc_hd__nand2_1
X_13497_ _04569_ _04579_ _04581_ VSS VSS VDD VDD _00357_ sky130_fd_sc_hd__o21ai_1
X_13498_ _04031_ _04573_ VSS VSS VDD VDD _04582_ sky130_fd_sc_hd__nor2_2
X_13499_ samples_imag\[4\]\[11\] _04572_ _04582_ VSS VSS VDD
+ VDD _04583_ sky130_fd_sc_hd__a21oi_1
X_13500_ _04576_ _04036_ VSS VSS VDD VDD _04584_ sky130_fd_sc_hd__nand2_1
X_13501_ _04571_ _04583_ _04584_ VSS VSS VDD VDD _04585_ sky130_fd_sc_hd__o21ai_1
X_13502_ _04570_ _04585_ _04040_ VSS VSS VDD VDD _04586_ sky130_fd_sc_hd__a21oi_1
X_13503_ samples_imag\[4\]\[11\] _04580_ VSS VSS VDD VDD _04587_
+ sky130_fd_sc_hd__nand2_1
X_13504_ _04569_ _04586_ _04587_ VSS VSS VDD VDD _00358_ sky130_fd_sc_hd__o21ai_1
X_13505_ _04559_ VSS VSS VDD VDD _04588_ sky130_fd_sc_hd__clkbuf_4
X_13506_ _04561_ net646 VSS VSS VDD VDD _04589_ sky130_fd_sc_hd__nor2_2
X_13507_ samples_imag\[4\]\[12\] _04588_ _04589_ VSS VSS VDD
+ VDD _04590_ sky130_fd_sc_hd__a21oi_1
X_13508_ _04564_ _04052_ VSS VSS VDD VDD _04591_ sky130_fd_sc_hd__nand2_1
X_13509_ _04564_ _04590_ _04591_ VSS VSS VDD VDD _04592_ sky130_fd_sc_hd__o21ai_1
X_13510_ _04557_ VSS VSS VDD VDD _04593_ sky130_fd_sc_hd__clkbuf_4
X_13511_ _04592_ _04237_ _04593_ _04057_ VSS VSS VDD VDD _04594_
+ sky130_fd_sc_hd__a211oi_1
X_13512_ _03253_ _04580_ _04594_ VSS VSS VDD VDD _00359_ sky130_fd_sc_hd__a21oi_1
X_13513_ _04556_ VSS VSS VDD VDD _04595_ sky130_fd_sc_hd__clkbuf_2
X_13514_ _04061_ _04573_ VSS VSS VDD VDD _04596_ sky130_fd_sc_hd__nor2_1
X_13515_ samples_imag\[4\]\[13\] _04572_ _04596_ VSS VSS VDD
+ VDD _04597_ sky130_fd_sc_hd__a21oi_1
X_13516_ _04576_ _04066_ VSS VSS VDD VDD _04598_ sky130_fd_sc_hd__nand2_1
X_13517_ _04597_ _04571_ _04598_ VSS VSS VDD VDD _04599_ sky130_fd_sc_hd__o21ai_1
X_13518_ _04599_ _04570_ _04070_ VSS VSS VDD VDD _04600_ sky130_fd_sc_hd__a21oi_1
X_13519_ samples_imag\[4\]\[13\] _04580_ VSS VSS VDD VDD _04601_
+ sky130_fd_sc_hd__nand2_1
X_13520_ _04595_ _04600_ _04601_ VSS VSS VDD VDD _00360_ sky130_fd_sc_hd__o21ai_1
X_13521_ _04573_ _04073_ VSS VSS VDD VDD _04602_ sky130_fd_sc_hd__nor2_2
X_13522_ samples_imag\[4\]\[14\] _04572_ _04602_ VSS VSS VDD
+ VDD _04603_ sky130_fd_sc_hd__a21oi_1
X_13523_ _04576_ _04080_ VSS VSS VDD VDD _04604_ sky130_fd_sc_hd__nand2_1
X_13524_ _04571_ _04603_ _04604_ VSS VSS VDD VDD _04605_ sky130_fd_sc_hd__o21ai_1
X_13525_ _04570_ _04605_ _04084_ VSS VSS VDD VDD _04606_ sky130_fd_sc_hd__a21oi_1
X_13526_ samples_imag\[4\]\[14\] _04580_ VSS VSS VDD VDD _04607_
+ sky130_fd_sc_hd__nand2_1
X_13527_ _04595_ _04606_ _04607_ VSS VSS VDD VDD _00361_ sky130_fd_sc_hd__o21ai_1
X_13528_ samples_imag\[4\]\[15\] net549 VSS VSS VDD VDD _04608_
+ sky130_fd_sc_hd__nor2_1
X_13529_ net550 _04090_ _04608_ _03467_ VSS VSS VDD VDD _04609_
+ sky130_fd_sc_hd__a211oi_1
X_13530_ _04564_ net54 _04609_ VSS VSS VDD VDD _04610_ sky130_fd_sc_hd__a21oi_1
X_13531_ _04088_ _04610_ _04593_ _04095_ VSS VSS VDD VDD _04611_
+ sky130_fd_sc_hd__a211oi_1
X_13532_ samples_imag\[4\]\[15\] _04593_ _04611_ VSS VSS VDD
+ VDD _00362_ sky130_fd_sc_hd__a21o_1
X_13533_ _04573_ _04097_ VSS VSS VDD VDD _04612_ sky130_fd_sc_hd__nor2_1
X_13534_ samples_imag\[4\]\[1\] _04572_ _04612_ VSS VSS VDD
+ VDD _04613_ sky130_fd_sc_hd__a21oi_1
X_13535_ _04558_ _04101_ VSS VSS VDD VDD _04614_ sky130_fd_sc_hd__nand2_1
X_13536_ _04613_ _04571_ _04614_ VSS VSS VDD VDD _04615_ sky130_fd_sc_hd__o21ai_1
X_13537_ _04570_ _04615_ _04105_ VSS VSS VDD VDD _04616_ sky130_fd_sc_hd__a21oi_1
X_13538_ samples_imag\[4\]\[1\] _04580_ VSS VSS VDD VDD _04617_
+ sky130_fd_sc_hd__nand2_1
X_13539_ _04595_ _04616_ _04617_ VSS VSS VDD VDD _00363_ sky130_fd_sc_hd__o21ai_1
X_13540_ _04109_ _04573_ VSS VSS VDD VDD _04618_ sky130_fd_sc_hd__nor2_2
X_13541_ samples_imag\[4\]\[2\] _04572_ _04618_ VSS VSS VDD
+ VDD _04619_ sky130_fd_sc_hd__a21oi_1
X_13542_ _04558_ _04114_ VSS VSS VDD VDD _04620_ sky130_fd_sc_hd__nand2_1
X_13543_ _04619_ _04571_ _04620_ VSS VSS VDD VDD _04621_ sky130_fd_sc_hd__o21ai_1
X_13544_ _04621_ _04570_ _04118_ VSS VSS VDD VDD _04622_ sky130_fd_sc_hd__a21oi_1
X_13545_ samples_imag\[4\]\[2\] _04580_ VSS VSS VDD VDD _04623_
+ sky130_fd_sc_hd__nand2_1
X_13546_ _04595_ _04622_ _04623_ VSS VSS VDD VDD _00364_ sky130_fd_sc_hd__o21ai_1
X_13547_ _04121_ _04561_ VSS VSS VDD VDD _04624_ sky130_fd_sc_hd__nor2_1
X_13548_ samples_imag\[4\]\[3\] _04588_ _04624_ VSS VSS VDD
+ VDD _04625_ sky130_fd_sc_hd__a21oi_1
X_13549_ _04564_ _04126_ VSS VSS VDD VDD _04626_ sky130_fd_sc_hd__nand2_1
X_13550_ _04625_ _04564_ _04626_ VSS VSS VDD VDD _04627_ sky130_fd_sc_hd__o21ai_1
X_13551_ _04627_ _04237_ _04593_ _04130_ VSS VSS VDD VDD _04628_
+ sky130_fd_sc_hd__a211oi_1
X_13552_ _03398_ _04580_ _04628_ VSS VSS VDD VDD _00365_ sky130_fd_sc_hd__a21oi_1
X_13553_ _04133_ _04573_ VSS VSS VDD VDD _04629_ sky130_fd_sc_hd__nor2_1
X_13554_ samples_imag\[4\]\[4\] _04572_ _04629_ VSS VSS VDD
+ VDD _04630_ sky130_fd_sc_hd__a21oi_1
X_13555_ _04558_ _04138_ VSS VSS VDD VDD _04631_ sky130_fd_sc_hd__nand2_1
X_13556_ _04630_ _04571_ _04631_ VSS VSS VDD VDD _04632_ sky130_fd_sc_hd__o21ai_1
X_13557_ _04632_ _04570_ _04142_ VSS VSS VDD VDD _04633_ sky130_fd_sc_hd__a21oi_1
X_13558_ samples_imag\[4\]\[4\] _04580_ VSS VSS VDD VDD _04634_
+ sky130_fd_sc_hd__nand2_1
X_13559_ _04595_ _04633_ _04634_ VSS VSS VDD VDD _00366_ sky130_fd_sc_hd__o21ai_1
X_13560_ _04573_ _04145_ VSS VSS VDD VDD _04635_ sky130_fd_sc_hd__nor2_2
X_13561_ samples_imag\[4\]\[5\] _04572_ _04635_ VSS VSS VDD
+ VDD _04636_ sky130_fd_sc_hd__a21oi_1
X_13562_ _04558_ _04150_ VSS VSS VDD VDD _04637_ sky130_fd_sc_hd__nand2_1
X_13563_ _04576_ _04636_ _04637_ VSS VSS VDD VDD _04638_ sky130_fd_sc_hd__o21ai_1
X_13564_ _04570_ _04638_ _04154_ VSS VSS VDD VDD _04639_ sky130_fd_sc_hd__a21oi_1
X_13565_ samples_imag\[4\]\[5\] _04580_ VSS VSS VDD VDD _04640_
+ sky130_fd_sc_hd__nand2_1
X_13566_ _04639_ _04595_ _04640_ VSS VSS VDD VDD _00367_ sky130_fd_sc_hd__o21ai_1
X_13567_ _04573_ _04158_ VSS VSS VDD VDD _04641_ sky130_fd_sc_hd__nor2_1
X_13568_ samples_imag\[4\]\[6\] _04572_ _04641_ VSS VSS VDD
+ VDD _04642_ sky130_fd_sc_hd__a21oi_1
X_13569_ _04558_ _04162_ VSS VSS VDD VDD _04643_ sky130_fd_sc_hd__nand2_1
X_13570_ _04576_ _04642_ _04643_ VSS VSS VDD VDD _04644_ sky130_fd_sc_hd__o21ai_1
X_13571_ _04570_ _04644_ _04166_ VSS VSS VDD VDD _04645_ sky130_fd_sc_hd__a21oi_1
X_13572_ _04557_ VSS VSS VDD VDD _04646_ sky130_fd_sc_hd__clkbuf_4
X_13573_ samples_imag\[4\]\[6\] _04646_ VSS VSS VDD VDD _04647_
+ sky130_fd_sc_hd__nand2_1
X_13574_ _04595_ _04645_ _04647_ VSS VSS VDD VDD _00368_ sky130_fd_sc_hd__o21ai_1
X_13575_ _04573_ _04173_ VSS VSS VDD VDD _04648_ sky130_fd_sc_hd__nor2_2
X_13576_ samples_imag\[4\]\[7\] _04572_ _04648_ VSS VSS VDD
+ VDD _04649_ sky130_fd_sc_hd__a21oi_1
X_13577_ _04558_ _04177_ VSS VSS VDD VDD _04650_ sky130_fd_sc_hd__nand2_1
X_13578_ _04576_ _04649_ _04650_ VSS VSS VDD VDD _04651_ sky130_fd_sc_hd__o21ai_1
X_13579_ _04570_ _04651_ _04181_ VSS VSS VDD VDD _04652_ sky130_fd_sc_hd__a21oi_1
X_13580_ samples_imag\[4\]\[7\] _04646_ VSS VSS VDD VDD _04653_
+ sky130_fd_sc_hd__nand2_1
X_13581_ _04595_ _04652_ _04653_ VSS VSS VDD VDD _00369_ sky130_fd_sc_hd__o21ai_1
X_13582_ _04170_ VSS VSS VDD VDD _04654_ sky130_fd_sc_hd__clkbuf_4
X_13583_ _04559_ VSS VSS VDD VDD _04655_ sky130_fd_sc_hd__clkbuf_4
X_13584_ _04655_ _04186_ VSS VSS VDD VDD _04656_ sky130_fd_sc_hd__nor2_1
X_13585_ samples_imag\[4\]\[8\] _04588_ _04656_ VSS VSS VDD
+ VDD _04657_ sky130_fd_sc_hd__a21oi_1
X_13586_ _04558_ _04190_ VSS VSS VDD VDD _04658_ sky130_fd_sc_hd__nand2_1
X_13587_ _04576_ _04657_ _04658_ VSS VSS VDD VDD _04659_ sky130_fd_sc_hd__o21ai_1
X_13588_ _04654_ _04659_ _04194_ VSS VSS VDD VDD _04660_ sky130_fd_sc_hd__a21oi_1
X_13589_ samples_imag\[4\]\[8\] _04646_ VSS VSS VDD VDD _04661_
+ sky130_fd_sc_hd__nand2_1
X_13590_ _04595_ _04660_ _04661_ VSS VSS VDD VDD _00370_ sky130_fd_sc_hd__o21ai_1
X_13591_ _04655_ _04198_ VSS VSS VDD VDD _04662_ sky130_fd_sc_hd__nor2_1
X_13592_ samples_imag\[4\]\[9\] _04588_ _04662_ VSS VSS VDD
+ VDD _04663_ sky130_fd_sc_hd__a21oi_1
X_13593_ _04558_ _04202_ VSS VSS VDD VDD _04664_ sky130_fd_sc_hd__nand2_1
X_13594_ _04576_ _04663_ _04664_ VSS VSS VDD VDD _04665_ sky130_fd_sc_hd__o21ai_1
X_13595_ _04654_ _04665_ _04206_ VSS VSS VDD VDD _04666_ sky130_fd_sc_hd__a21oi_1
X_13596_ samples_imag\[4\]\[9\] _04646_ VSS VSS VDD VDD _04667_
+ sky130_fd_sc_hd__nand2_1
X_13597_ _04595_ _04666_ _04667_ VSS VSS VDD VDD _00371_ sky130_fd_sc_hd__o21ai_1
X_13598_ _03837_ _03835_ _03839_ VSS VSS VDD VDD _04668_ sky130_fd_sc_hd__and3b_1
X_13599_ _03888_ _04668_ _04210_ VSS VSS VDD VDD _04669_ sky130_fd_sc_hd__o21ai_4
X_13600_ _04669_ VSS VSS VDD VDD _04670_ sky130_fd_sc_hd__buf_2
X_13601_ _04670_ VSS VSS VDD VDD _04671_ sky130_fd_sc_hd__clkbuf_4
X_13602_ _03346_ VSS VSS VDD VDD _04672_ sky130_fd_sc_hd__clkbuf_4
X_13603_ _03773_ VSS VSS VDD VDD _04673_ sky130_fd_sc_hd__buf_4
X_13604_ _03773_ VSS VSS VDD VDD _04674_ sky130_fd_sc_hd__buf_2
X_13605_ _04674_ _04669_ VSS VSS VDD VDD _04675_ sky130_fd_sc_hd__nor2_1
X_13606_ samples_imag\[5\]\[0\] _04673_ _03994_ _04675_ VSS
+ VSS VDD VDD _04676_ sky130_fd_sc_hd__a22oi_1
X_13607_ _04672_ _04676_ VSS VSS VDD VDD _04677_ sky130_fd_sc_hd__nor2_1
X_13608_ _03283_ _03291_ VSS VSS VDD VDD _04678_ sky130_fd_sc_hd__nand2b_1
X_13609_ _04678_ VSS VSS VDD VDD _04679_ sky130_fd_sc_hd__clkbuf_4
X_13610_ _04679_ VSS VSS VDD VDD _04680_ sky130_fd_sc_hd__clkbuf_4
X_13611_ _04680_ _04670_ _03925_ VSS VSS VDD VDD _04681_ sky130_fd_sc_hd__nor3_2
X_13612_ _04681_ _04677_ _04004_ VSS VSS VDD VDD _04682_ sky130_fd_sc_hd__o21ai_1
X_13613_ _04670_ VSS VSS VDD VDD _04683_ sky130_fd_sc_hd__clkbuf_4
X_13614_ samples_imag\[5\]\[0\] _04683_ VSS VSS VDD VDD _04684_
+ sky130_fd_sc_hd__nand2_1
X_13615_ _04001_ _04671_ _04684_ _04682_ VSS VSS VDD VDD _00372_
+ sky130_fd_sc_hd__o211ai_1
X_13616_ _04669_ VSS VSS VDD VDD _04685_ sky130_fd_sc_hd__clkbuf_4
X_13617_ _03346_ VSS VSS VDD VDD _04686_ sky130_fd_sc_hd__clkbuf_4
X_13618_ _04674_ _04006_ VSS VSS VDD VDD _04687_ sky130_fd_sc_hd__nor2_2
X_13619_ samples_imag\[5\]\[10\] _04673_ _04687_ VSS VSS VDD
+ VDD _04688_ sky130_fd_sc_hd__a21oi_1
X_13620_ _03346_ VSS VSS VDD VDD _04689_ sky130_fd_sc_hd__buf_2
X_13621_ _04689_ _04020_ VSS VSS VDD VDD _04690_ sky130_fd_sc_hd__nand2_1
X_13622_ _04686_ _04688_ _04690_ VSS VSS VDD VDD _04691_ sky130_fd_sc_hd__o21ai_1
X_13623_ _04654_ _04691_ _04025_ VSS VSS VDD VDD _04692_ sky130_fd_sc_hd__a21oi_1
X_13624_ samples_imag\[5\]\[10\] _04671_ VSS VSS VDD VDD _04693_
+ sky130_fd_sc_hd__nand2_1
X_13625_ _04685_ _04692_ _04693_ VSS VSS VDD VDD _00373_ sky130_fd_sc_hd__o21ai_1
X_13626_ _04674_ _04031_ VSS VSS VDD VDD _04694_ sky130_fd_sc_hd__nor2_1
X_13627_ samples_imag\[5\]\[11\] _04673_ _04694_ VSS VSS VDD
+ VDD _04695_ sky130_fd_sc_hd__a21oi_1
X_13628_ _03346_ VSS VSS VDD VDD _04696_ sky130_fd_sc_hd__buf_2
X_13629_ _04696_ _04036_ VSS VSS VDD VDD _04697_ sky130_fd_sc_hd__nand2_1
X_13630_ _04686_ _04695_ _04697_ VSS VSS VDD VDD _04698_ sky130_fd_sc_hd__o21ai_1
X_13631_ _04654_ _04698_ _04040_ VSS VSS VDD VDD _04699_ sky130_fd_sc_hd__a21oi_1
X_13632_ samples_imag\[5\]\[11\] _04671_ VSS VSS VDD VDD _04700_
+ sky130_fd_sc_hd__nand2_1
X_13633_ _04685_ _04699_ _04700_ VSS VSS VDD VDD _00374_ sky130_fd_sc_hd__o21ai_1
X_13634_ _03773_ net646 VSS VSS VDD VDD _04701_ sky130_fd_sc_hd__nor2_1
X_13635_ samples_imag\[5\]\[12\] _04674_ _04701_ VSS VSS VDD
+ VDD _04702_ sky130_fd_sc_hd__a21oi_1
X_13636_ _03346_ _04052_ VSS VSS VDD VDD _04703_ sky130_fd_sc_hd__nand2_1
X_13637_ _03346_ _04702_ _04703_ VSS VSS VDD VDD _04704_ sky130_fd_sc_hd__o21ai_1
X_13638_ _04704_ _04237_ _04670_ _04057_ VSS VSS VDD VDD _04705_
+ sky130_fd_sc_hd__a211oi_1
X_13639_ _03772_ _04671_ _04705_ VSS VSS VDD VDD _00375_ sky130_fd_sc_hd__a21oi_1
X_13640_ _03773_ VSS VSS VDD VDD _04706_ sky130_fd_sc_hd__buf_2
X_13641_ _04061_ _04674_ VSS VSS VDD VDD _04707_ sky130_fd_sc_hd__nor2_1
X_13642_ samples_imag\[5\]\[13\] _04706_ _04707_ VSS VSS VDD
+ VDD _04708_ sky130_fd_sc_hd__a21oi_1
X_13643_ _04696_ _04066_ VSS VSS VDD VDD _04709_ sky130_fd_sc_hd__nand2_1
X_13644_ _04686_ _04708_ _04709_ VSS VSS VDD VDD _04710_ sky130_fd_sc_hd__o21ai_1
X_13645_ _04654_ _04710_ _04070_ VSS VSS VDD VDD _04711_ sky130_fd_sc_hd__a21oi_1
X_13646_ samples_imag\[5\]\[13\] _04671_ VSS VSS VDD VDD _04712_
+ sky130_fd_sc_hd__nand2_1
X_13647_ _04685_ _04711_ _04712_ VSS VSS VDD VDD _00376_ sky130_fd_sc_hd__o21ai_1
X_13648_ _04073_ _04674_ VSS VSS VDD VDD _04713_ sky130_fd_sc_hd__nor2_1
X_13649_ samples_imag\[5\]\[14\] _04706_ _04713_ VSS VSS VDD
+ VDD _04714_ sky130_fd_sc_hd__a21oi_1
X_13650_ _04696_ _04080_ VSS VSS VDD VDD _04715_ sky130_fd_sc_hd__nand2_1
X_13651_ _04686_ _04714_ _04715_ VSS VSS VDD VDD _04716_ sky130_fd_sc_hd__o21ai_1
X_13652_ _04654_ _04716_ _04084_ VSS VSS VDD VDD _04717_ sky130_fd_sc_hd__a21oi_1
X_13653_ samples_imag\[5\]\[14\] _04671_ VSS VSS VDD VDD _04718_
+ sky130_fd_sc_hd__nand2_1
X_13654_ _04685_ _04717_ _04718_ VSS VSS VDD VDD _00377_ sky130_fd_sc_hd__o21ai_1
X_13655_ _04670_ VSS VSS VDD VDD _04719_ sky130_fd_sc_hd__clkbuf_4
X_13656_ _03773_ VSS VSS VDD VDD _04720_ sky130_fd_sc_hd__clkbuf_4
X_13657_ samples_imag\[5\]\[15\] _03773_ VSS VSS VDD VDD _04721_
+ sky130_fd_sc_hd__nand2_1
X_13658_ _04720_ _04090_ _04721_ _04679_ VSS VSS VDD VDD _04722_
+ sky130_fd_sc_hd__o211ai_1
X_13659_ _04679_ net525 _04722_ VSS VSS VDD VDD _04723_ sky130_fd_sc_hd__o21ai_0
X_13660_ _04088_ _04723_ _04670_ _04095_ VSS VSS VDD VDD _04724_
+ sky130_fd_sc_hd__a211oi_1
X_13661_ samples_imag\[5\]\[15\] _04719_ _04724_ VSS VSS VDD
+ VDD _00378_ sky130_fd_sc_hd__a21o_1
X_13662_ _04674_ _04097_ VSS VSS VDD VDD _04725_ sky130_fd_sc_hd__nor2_1
X_13663_ samples_imag\[5\]\[1\] _04706_ _04725_ VSS VSS VDD
+ VDD _04726_ sky130_fd_sc_hd__a21oi_1
X_13664_ _04101_ _04696_ VSS VSS VDD VDD _04727_ sky130_fd_sc_hd__nand2_1
X_13665_ _04686_ _04726_ _04727_ VSS VSS VDD VDD _04728_ sky130_fd_sc_hd__o21ai_1
X_13666_ _04654_ _04728_ _04105_ VSS VSS VDD VDD _04729_ sky130_fd_sc_hd__a21oi_1
X_13667_ samples_imag\[5\]\[1\] _04671_ VSS VSS VDD VDD _04730_
+ sky130_fd_sc_hd__nand2_1
X_13668_ _04685_ _04729_ _04730_ VSS VSS VDD VDD _00379_ sky130_fd_sc_hd__o21ai_1
X_13669_ _04109_ _04674_ VSS VSS VDD VDD _04731_ sky130_fd_sc_hd__nor2_1
X_13670_ samples_imag\[5\]\[2\] _04706_ _04731_ VSS VSS VDD
+ VDD _04732_ sky130_fd_sc_hd__a21oi_1
X_13671_ _04696_ _04114_ VSS VSS VDD VDD _04733_ sky130_fd_sc_hd__nand2_1
X_13672_ _04689_ _04732_ _04733_ VSS VSS VDD VDD _04734_ sky130_fd_sc_hd__o21ai_1
X_13673_ _04654_ _04734_ _04118_ VSS VSS VDD VDD _04735_ sky130_fd_sc_hd__a21oi_1
X_13674_ samples_imag\[5\]\[2\] _04671_ VSS VSS VDD VDD _04736_
+ sky130_fd_sc_hd__nand2_1
X_13675_ _04685_ _04735_ _04736_ VSS VSS VDD VDD _00380_ sky130_fd_sc_hd__o21ai_1
X_13676_ _04121_ _04720_ VSS VSS VDD VDD _04737_ sky130_fd_sc_hd__nor2_1
X_13677_ samples_imag\[5\]\[3\] _04706_ _04737_ VSS VSS VDD
+ VDD _04738_ sky130_fd_sc_hd__a21oi_1
X_13678_ _04696_ _04126_ VSS VSS VDD VDD _04739_ sky130_fd_sc_hd__nand2_1
X_13679_ _04689_ _04738_ _04739_ VSS VSS VDD VDD _04740_ sky130_fd_sc_hd__o21ai_1
X_13680_ _04654_ _04740_ _04130_ VSS VSS VDD VDD _04741_ sky130_fd_sc_hd__a21oi_1
X_13681_ samples_imag\[5\]\[3\] _04671_ VSS VSS VDD VDD _04742_
+ sky130_fd_sc_hd__nand2_1
X_13682_ _04685_ _04741_ _04742_ VSS VSS VDD VDD _00381_ sky130_fd_sc_hd__o21ai_1
X_13683_ _04133_ _04720_ VSS VSS VDD VDD _04743_ sky130_fd_sc_hd__nor2_1
X_13684_ samples_imag\[5\]\[4\] _04706_ _04743_ VSS VSS VDD
+ VDD _04744_ sky130_fd_sc_hd__a21oi_1
X_13685_ _04696_ _04138_ VSS VSS VDD VDD _04745_ sky130_fd_sc_hd__nand2_1
X_13686_ _04689_ _04744_ _04745_ VSS VSS VDD VDD _04746_ sky130_fd_sc_hd__o21ai_1
X_13687_ _04654_ _04746_ _04142_ VSS VSS VDD VDD _04747_ sky130_fd_sc_hd__a21oi_1
X_13688_ samples_imag\[5\]\[4\] _04671_ VSS VSS VDD VDD _04748_
+ sky130_fd_sc_hd__nand2_1
X_13689_ _04685_ _04747_ _04748_ VSS VSS VDD VDD _00382_ sky130_fd_sc_hd__o21ai_1
X_13690_ _04170_ VSS VSS VDD VDD _04749_ sky130_fd_sc_hd__clkbuf_4
X_13691_ _04145_ _04720_ VSS VSS VDD VDD _04750_ sky130_fd_sc_hd__nor2_1
X_13692_ samples_imag\[5\]\[5\] _04706_ _04750_ VSS VSS VDD
+ VDD _04751_ sky130_fd_sc_hd__a21oi_1
X_13693_ _04696_ _04150_ VSS VSS VDD VDD _04752_ sky130_fd_sc_hd__nand2_1
X_13694_ _04689_ _04751_ _04752_ VSS VSS VDD VDD _04753_ sky130_fd_sc_hd__o21ai_1
X_13695_ _04749_ _04753_ _04154_ VSS VSS VDD VDD _04754_ sky130_fd_sc_hd__a21oi_1
X_13696_ _04670_ VSS VSS VDD VDD _04755_ sky130_fd_sc_hd__clkbuf_4
X_13697_ samples_imag\[5\]\[5\] _04755_ VSS VSS VDD VDD _04756_
+ sky130_fd_sc_hd__nand2_1
X_13698_ _04685_ _04754_ _04756_ VSS VSS VDD VDD _00383_ sky130_fd_sc_hd__o21ai_1
X_13699_ _04669_ VSS VSS VDD VDD _04757_ sky130_fd_sc_hd__buf_2
X_13700_ _04720_ _04158_ VSS VSS VDD VDD _04758_ sky130_fd_sc_hd__nor2_1
X_13701_ samples_imag\[5\]\[6\] _04706_ _04758_ VSS VSS VDD
+ VDD _04759_ sky130_fd_sc_hd__a21oi_1
X_13702_ _04696_ _04162_ VSS VSS VDD VDD _04760_ sky130_fd_sc_hd__nand2_1
X_13703_ _04689_ _04759_ _04760_ VSS VSS VDD VDD _04761_ sky130_fd_sc_hd__o21ai_1
X_13704_ _04749_ _04761_ _04166_ VSS VSS VDD VDD _04762_ sky130_fd_sc_hd__a21oi_1
X_13705_ samples_imag\[5\]\[6\] _04755_ VSS VSS VDD VDD _04763_
+ sky130_fd_sc_hd__nand2_1
X_13706_ _04757_ _04762_ _04763_ VSS VSS VDD VDD _00384_ sky130_fd_sc_hd__o21ai_1
X_13707_ _04720_ _04173_ VSS VSS VDD VDD _04764_ sky130_fd_sc_hd__nor2_1
X_13708_ samples_imag\[5\]\[7\] _04706_ _04764_ VSS VSS VDD
+ VDD _04765_ sky130_fd_sc_hd__a21oi_1
X_13709_ _04696_ _04177_ VSS VSS VDD VDD _04766_ sky130_fd_sc_hd__nand2_1
X_13710_ _04689_ _04765_ _04766_ VSS VSS VDD VDD _04767_ sky130_fd_sc_hd__o21ai_1
X_13711_ _04749_ _04767_ _04181_ VSS VSS VDD VDD _04768_ sky130_fd_sc_hd__a21oi_1
X_13712_ samples_imag\[5\]\[7\] _04755_ VSS VSS VDD VDD _04769_
+ sky130_fd_sc_hd__nand2_1
X_13713_ _04757_ _04768_ _04769_ VSS VSS VDD VDD _00385_ sky130_fd_sc_hd__o21ai_1
X_13714_ _04720_ _04186_ VSS VSS VDD VDD _04770_ sky130_fd_sc_hd__nor2_1
X_13715_ samples_imag\[5\]\[8\] _04706_ _04770_ VSS VSS VDD
+ VDD _04771_ sky130_fd_sc_hd__a21oi_1
X_13716_ _03346_ _04190_ VSS VSS VDD VDD _04772_ sky130_fd_sc_hd__nand2_1
X_13717_ _04689_ _04771_ _04772_ VSS VSS VDD VDD _04773_ sky130_fd_sc_hd__o21ai_1
X_13718_ _04749_ _04773_ _04194_ VSS VSS VDD VDD _04774_ sky130_fd_sc_hd__a21oi_1
X_13719_ samples_imag\[5\]\[8\] _04755_ VSS VSS VDD VDD _04775_
+ sky130_fd_sc_hd__nand2_1
X_13720_ _04757_ _04774_ _04775_ VSS VSS VDD VDD _00386_ sky130_fd_sc_hd__o21ai_1
X_13721_ _04720_ _04198_ VSS VSS VDD VDD _04776_ sky130_fd_sc_hd__nor2_2
X_13722_ samples_imag\[5\]\[9\] _04674_ _04776_ VSS VSS VDD
+ VDD _04777_ sky130_fd_sc_hd__a21oi_1
X_13723_ _03346_ _04202_ VSS VSS VDD VDD _04778_ sky130_fd_sc_hd__nand2_1
X_13724_ _04689_ _04777_ _04778_ VSS VSS VDD VDD _04779_ sky130_fd_sc_hd__o21ai_1
X_13725_ _04749_ _04779_ _04206_ VSS VSS VDD VDD _04780_ sky130_fd_sc_hd__a21oi_1
X_13726_ samples_imag\[5\]\[9\] _04755_ VSS VSS VDD VDD _04781_
+ sky130_fd_sc_hd__nand2_1
X_13727_ _04757_ _04780_ _04781_ VSS VSS VDD VDD _00387_ sky130_fd_sc_hd__o21ai_1
X_13728_ _03835_ _03839_ _03837_ VSS VSS VDD VDD _04782_ sky130_fd_sc_hd__and3b_1
X_13729_ _03888_ _04782_ _04210_ VSS VSS VDD VDD _04783_ sky130_fd_sc_hd__o21ai_1
X_13730_ _04783_ VSS VSS VDD VDD _04784_ sky130_fd_sc_hd__clkbuf_4
X_13731_ _03147_ net614 VSS VSS VDD VDD _04785_ sky130_fd_sc_hd__nand2_4
X_13732_ _04785_ VSS VSS VDD VDD _04786_ sky130_fd_sc_hd__clkbuf_4
X_13733_ _04785_ _04784_ VSS VSS VDD VDD _04787_ sky130_fd_sc_hd__nor2_1
X_13734_ samples_imag\[6\]\[0\] _04786_ _04787_ _03994_ VSS
+ VSS VDD VDD _04788_ sky130_fd_sc_hd__a22oi_2
X_13735_ net45 _03316_ VSS VSS VDD VDD _04789_ sky130_fd_sc_hd__nand2b_1
X_13736_ _04789_ VSS VSS VDD VDD _04790_ sky130_fd_sc_hd__buf_2
X_13737_ _04790_ _04784_ VSS VSS VDD VDD _04791_ sky130_fd_sc_hd__or2_0
X_13738_ _03676_ _04788_ _04791_ _03925_ VSS VSS VDD VDD _04792_
+ sky130_fd_sc_hd__o22ai_2
X_13739_ _04001_ _04784_ VSS VSS VDD VDD _04793_ sky130_fd_sc_hd__nor2_1
X_13740_ samples_imag\[6\]\[0\] _04784_ _04792_ _03999_ _04793_
+ VSS VSS VDD VDD _00388_ sky130_fd_sc_hd__a221o_1
X_13741_ _04784_ VSS VSS VDD VDD _04794_ sky130_fd_sc_hd__buf_4
X_13742_ _03676_ VSS VSS VDD VDD _04795_ sky130_fd_sc_hd__clkbuf_4
X_13743_ _04785_ VSS VSS VDD VDD _04796_ sky130_fd_sc_hd__buf_4
X_13744_ _04785_ VSS VSS VDD VDD _04797_ sky130_fd_sc_hd__clkbuf_4
X_13745_ _04006_ _04797_ VSS VSS VDD VDD _04798_ sky130_fd_sc_hd__nor2_2
X_13746_ samples_imag\[6\]\[10\] _04796_ _04798_ VSS VSS VDD
+ VDD _04799_ sky130_fd_sc_hd__a21oi_1
X_13747_ _03676_ VSS VSS VDD VDD _04800_ sky130_fd_sc_hd__clkbuf_4
X_13748_ _04800_ _04020_ VSS VSS VDD VDD _04801_ sky130_fd_sc_hd__nand2_1
X_13749_ _04795_ _04799_ _04801_ VSS VSS VDD VDD _04802_ sky130_fd_sc_hd__o21ai_1
X_13750_ _04749_ _04802_ _04025_ VSS VSS VDD VDD _04803_ sky130_fd_sc_hd__a21oi_1
X_13751_ _04784_ VSS VSS VDD VDD _04804_ sky130_fd_sc_hd__buf_2
X_13752_ samples_imag\[6\]\[10\] _04804_ VSS VSS VDD VDD _04805_
+ sky130_fd_sc_hd__nand2_1
X_13753_ _04794_ _04803_ _04805_ VSS VSS VDD VDD _00389_ sky130_fd_sc_hd__o21ai_1
X_13754_ _04031_ _04797_ VSS VSS VDD VDD _04806_ sky130_fd_sc_hd__nor2_1
X_13755_ samples_imag\[6\]\[11\] _04796_ _04806_ VSS VSS VDD
+ VDD _04807_ sky130_fd_sc_hd__a21oi_1
X_13756_ _03676_ VSS VSS VDD VDD _04808_ sky130_fd_sc_hd__buf_2
X_13757_ _04808_ _04036_ VSS VSS VDD VDD _04809_ sky130_fd_sc_hd__nand2_1
X_13758_ _04795_ _04807_ _04809_ VSS VSS VDD VDD _04810_ sky130_fd_sc_hd__o21ai_1
X_13759_ _04749_ _04810_ _04040_ VSS VSS VDD VDD _04811_ sky130_fd_sc_hd__a21oi_1
X_13760_ samples_imag\[6\]\[11\] _04804_ VSS VSS VDD VDD _04812_
+ sky130_fd_sc_hd__nand2_1
X_13761_ _04794_ _04811_ _04812_ VSS VSS VDD VDD _00390_ sky130_fd_sc_hd__o21ai_1
X_13762_ _04783_ VSS VSS VDD VDD _04813_ sky130_fd_sc_hd__clkbuf_2
X_13763_ _04045_ _04797_ VSS VSS VDD VDD _04814_ sky130_fd_sc_hd__nor2_1
X_13764_ samples_imag\[6\]\[12\] _04796_ _04814_ VSS VSS VDD
+ VDD _04815_ sky130_fd_sc_hd__a21oi_1
X_13765_ _04808_ _04052_ VSS VSS VDD VDD _04816_ sky130_fd_sc_hd__nand2_1
X_13766_ _04795_ _04815_ _04816_ VSS VSS VDD VDD _04817_ sky130_fd_sc_hd__o21ai_1
X_13767_ _04749_ _04817_ _04057_ VSS VSS VDD VDD _04818_ sky130_fd_sc_hd__a21oi_1
X_13768_ samples_imag\[6\]\[12\] _04804_ VSS VSS VDD VDD _04819_
+ sky130_fd_sc_hd__nand2_1
X_13769_ _04818_ _04813_ _04819_ VSS VSS VDD VDD _00391_ sky130_fd_sc_hd__o21ai_1
X_13770_ _04061_ _04797_ VSS VSS VDD VDD _04820_ sky130_fd_sc_hd__nor2_1
X_13771_ samples_imag\[6\]\[13\] _04796_ _04820_ VSS VSS VDD
+ VDD _04821_ sky130_fd_sc_hd__a21oi_1
X_13772_ _04808_ _04066_ VSS VSS VDD VDD _04822_ sky130_fd_sc_hd__nand2_1
X_13773_ _04795_ _04821_ _04822_ VSS VSS VDD VDD _04823_ sky130_fd_sc_hd__o21ai_1
X_13774_ _04749_ _04823_ _04070_ VSS VSS VDD VDD _04824_ sky130_fd_sc_hd__a21oi_1
X_13775_ samples_imag\[6\]\[13\] _04804_ VSS VSS VDD VDD _04825_
+ sky130_fd_sc_hd__nand2_1
X_13776_ _04813_ _04824_ _04825_ VSS VSS VDD VDD _00392_ sky130_fd_sc_hd__o21ai_1
X_13777_ _04785_ VSS VSS VDD VDD _04826_ sky130_fd_sc_hd__buf_2
X_13778_ _04073_ _04797_ VSS VSS VDD VDD _04827_ sky130_fd_sc_hd__nor2_1
X_13779_ samples_imag\[6\]\[14\] _04826_ _04827_ VSS VSS VDD
+ VDD _04828_ sky130_fd_sc_hd__a21oi_1
X_13780_ _04808_ _04080_ VSS VSS VDD VDD _04829_ sky130_fd_sc_hd__nand2_1
X_13781_ _04795_ _04828_ _04829_ VSS VSS VDD VDD _04830_ sky130_fd_sc_hd__o21ai_1
X_13782_ _04749_ _04830_ _04084_ VSS VSS VDD VDD _04831_ sky130_fd_sc_hd__a21oi_1
X_13783_ samples_imag\[6\]\[14\] _04804_ VSS VSS VDD VDD _04832_
+ sky130_fd_sc_hd__nand2_1
X_13784_ _04813_ _04831_ _04832_ VSS VSS VDD VDD _00393_ sky130_fd_sc_hd__o21ai_1
X_13785_ _04784_ VSS VSS VDD VDD _04833_ sky130_fd_sc_hd__clkbuf_4
X_13786_ samples_imag\[6\]\[15\] _04785_ VSS VSS VDD VDD _04834_
+ sky130_fd_sc_hd__nand2_1
X_13787_ _04090_ _04797_ _04834_ _04790_ VSS VSS VDD VDD _04835_
+ sky130_fd_sc_hd__o211ai_1
X_13788_ _04790_ net525 _04835_ VSS VSS VDD VDD _04836_ sky130_fd_sc_hd__o21ai_0
X_13789_ _04088_ _04836_ _04833_ _04095_ VSS VSS VDD VDD _04837_
+ sky130_fd_sc_hd__a211oi_1
X_13790_ samples_imag\[6\]\[15\] _04833_ _04837_ VSS VSS VDD
+ VDD _00394_ sky130_fd_sc_hd__a21o_1
X_13791_ _04170_ VSS VSS VDD VDD _04838_ sky130_fd_sc_hd__buf_2
X_13792_ _04097_ _04797_ VSS VSS VDD VDD _04839_ sky130_fd_sc_hd__nor2_1
X_13793_ samples_imag\[6\]\[1\] _04826_ _04839_ VSS VSS VDD
+ VDD _04840_ sky130_fd_sc_hd__a21oi_1
X_13794_ _04808_ _04101_ VSS VSS VDD VDD _04841_ sky130_fd_sc_hd__nand2_1
X_13795_ _04795_ _04840_ _04841_ VSS VSS VDD VDD _04842_ sky130_fd_sc_hd__o21ai_1
X_13796_ _04838_ _04842_ _04105_ VSS VSS VDD VDD _04843_ sky130_fd_sc_hd__a21oi_1
X_13797_ samples_imag\[6\]\[1\] _04804_ VSS VSS VDD VDD _04844_
+ sky130_fd_sc_hd__nand2_1
X_13798_ _04813_ _04843_ _04844_ VSS VSS VDD VDD _00395_ sky130_fd_sc_hd__o21ai_1
X_13799_ _04797_ _04109_ VSS VSS VDD VDD _04845_ sky130_fd_sc_hd__nor2_1
X_13800_ samples_imag\[6\]\[2\] _04826_ _04845_ VSS VSS VDD
+ VDD _04846_ sky130_fd_sc_hd__a21oi_1
X_13801_ _04808_ _04114_ VSS VSS VDD VDD _04847_ sky130_fd_sc_hd__nand2_1
X_13802_ _04800_ _04846_ _04847_ VSS VSS VDD VDD _04848_ sky130_fd_sc_hd__o21ai_1
X_13803_ _04838_ _04848_ _04118_ VSS VSS VDD VDD _04849_ sky130_fd_sc_hd__a21oi_1
X_13804_ samples_imag\[6\]\[2\] _04804_ VSS VSS VDD VDD _04850_
+ sky130_fd_sc_hd__nand2_1
X_13805_ _04813_ _04849_ _04850_ VSS VSS VDD VDD _00396_ sky130_fd_sc_hd__o21ai_1
X_13806_ _04121_ _04786_ VSS VSS VDD VDD _04851_ sky130_fd_sc_hd__nor2_2
X_13807_ samples_imag\[6\]\[3\] _04826_ _04851_ VSS VSS VDD
+ VDD _04852_ sky130_fd_sc_hd__a21oi_1
X_13808_ _04808_ _04126_ VSS VSS VDD VDD _04853_ sky130_fd_sc_hd__nand2_1
X_13809_ _04800_ _04852_ _04853_ VSS VSS VDD VDD _04854_ sky130_fd_sc_hd__o21ai_1
X_13810_ _04838_ _04854_ _04130_ VSS VSS VDD VDD _04855_ sky130_fd_sc_hd__a21oi_1
X_13811_ samples_imag\[6\]\[3\] _04804_ VSS VSS VDD VDD _04856_
+ sky130_fd_sc_hd__nand2_1
X_13812_ _04813_ _04855_ _04856_ VSS VSS VDD VDD _00397_ sky130_fd_sc_hd__o21ai_1
X_13813_ _04786_ _04133_ VSS VSS VDD VDD _04857_ sky130_fd_sc_hd__nor2_1
X_13814_ samples_imag\[6\]\[4\] _04826_ _04857_ VSS VSS VDD
+ VDD _04858_ sky130_fd_sc_hd__a21oi_1
X_13815_ _04808_ _04138_ VSS VSS VDD VDD _04859_ sky130_fd_sc_hd__nand2_1
X_13816_ _04800_ _04858_ _04859_ VSS VSS VDD VDD _04860_ sky130_fd_sc_hd__o21ai_1
X_13817_ _04838_ _04860_ _04142_ VSS VSS VDD VDD _04861_ sky130_fd_sc_hd__a21oi_1
X_13818_ samples_imag\[6\]\[4\] _04804_ VSS VSS VDD VDD _04862_
+ sky130_fd_sc_hd__nand2_1
X_13819_ _04813_ _04861_ _04862_ VSS VSS VDD VDD _00398_ sky130_fd_sc_hd__o21ai_1
X_13820_ _04786_ _04145_ VSS VSS VDD VDD _04863_ sky130_fd_sc_hd__nor2_1
X_13821_ samples_imag\[6\]\[5\] _04826_ _04863_ VSS VSS VDD
+ VDD _04864_ sky130_fd_sc_hd__a21oi_1
X_13822_ _04808_ _04150_ VSS VSS VDD VDD _04865_ sky130_fd_sc_hd__nand2_1
X_13823_ _04800_ _04864_ _04865_ VSS VSS VDD VDD _04866_ sky130_fd_sc_hd__o21ai_1
X_13824_ _04838_ _04866_ _04154_ VSS VSS VDD VDD _04867_ sky130_fd_sc_hd__a21oi_1
X_13825_ samples_imag\[6\]\[5\] _04804_ VSS VSS VDD VDD _04868_
+ sky130_fd_sc_hd__nand2_1
X_13826_ _04813_ _04867_ _04868_ VSS VSS VDD VDD _00399_ sky130_fd_sc_hd__o21ai_1
X_13827_ _04158_ _04786_ VSS VSS VDD VDD _04869_ sky130_fd_sc_hd__nor2_1
X_13828_ samples_imag\[6\]\[6\] _04826_ _04869_ VSS VSS VDD
+ VDD _04870_ sky130_fd_sc_hd__a21oi_1
X_13829_ _04808_ _04162_ VSS VSS VDD VDD _04871_ sky130_fd_sc_hd__nand2_1
X_13830_ _04800_ _04870_ _04871_ VSS VSS VDD VDD _04872_ sky130_fd_sc_hd__o21ai_1
X_13831_ _04838_ _04872_ _04166_ VSS VSS VDD VDD _04873_ sky130_fd_sc_hd__a21oi_1
X_13832_ _04784_ VSS VSS VDD VDD _04874_ sky130_fd_sc_hd__buf_4
X_13833_ samples_imag\[6\]\[6\] _04874_ VSS VSS VDD VDD _04875_
+ sky130_fd_sc_hd__nand2_1
X_13834_ _04813_ _04873_ _04875_ VSS VSS VDD VDD _00400_ sky130_fd_sc_hd__o21ai_1
X_13835_ _04173_ _04786_ VSS VSS VDD VDD _04876_ sky130_fd_sc_hd__nor2_2
X_13836_ samples_imag\[6\]\[7\] _04826_ _04876_ VSS VSS VDD
+ VDD _04877_ sky130_fd_sc_hd__a21oi_1
X_13837_ _03676_ _04177_ VSS VSS VDD VDD _04878_ sky130_fd_sc_hd__nand2_1
X_13838_ _04800_ _04877_ _04878_ VSS VSS VDD VDD _04879_ sky130_fd_sc_hd__o21ai_1
X_13839_ _04838_ _04879_ _04181_ VSS VSS VDD VDD _04880_ sky130_fd_sc_hd__a21oi_1
X_13840_ samples_imag\[6\]\[7\] _04874_ VSS VSS VDD VDD _04881_
+ sky130_fd_sc_hd__nand2_1
X_13841_ _04813_ _04880_ _04881_ VSS VSS VDD VDD _00401_ sky130_fd_sc_hd__o21ai_1
X_13842_ _04783_ VSS VSS VDD VDD _04882_ sky130_fd_sc_hd__buf_4
X_13843_ _04186_ _04786_ VSS VSS VDD VDD _04883_ sky130_fd_sc_hd__nor2_1
X_13844_ samples_imag\[6\]\[8\] _04826_ _04883_ VSS VSS VDD
+ VDD _04884_ sky130_fd_sc_hd__a21oi_1
X_13845_ _03676_ _04190_ VSS VSS VDD VDD _04885_ sky130_fd_sc_hd__nand2_1
X_13846_ _04800_ _04884_ _04885_ VSS VSS VDD VDD _04886_ sky130_fd_sc_hd__o21ai_1
X_13847_ _04838_ _04886_ _04194_ VSS VSS VDD VDD _04887_ sky130_fd_sc_hd__a21oi_1
X_13848_ samples_imag\[6\]\[8\] _04874_ VSS VSS VDD VDD _04888_
+ sky130_fd_sc_hd__nand2_1
X_13849_ _04882_ _04887_ _04888_ VSS VSS VDD VDD _00402_ sky130_fd_sc_hd__o21ai_1
X_13850_ _04198_ _04786_ VSS VSS VDD VDD _04889_ sky130_fd_sc_hd__nor2_2
X_13851_ samples_imag\[6\]\[9\] _04826_ _04889_ VSS VSS VDD
+ VDD _04890_ sky130_fd_sc_hd__a21oi_1
X_13852_ _03676_ _04202_ VSS VSS VDD VDD _04891_ sky130_fd_sc_hd__nand2_1
X_13853_ _04800_ _04890_ _04891_ VSS VSS VDD VDD _04892_ sky130_fd_sc_hd__o21ai_1
X_13854_ _04838_ _04892_ _04206_ VSS VSS VDD VDD _04893_ sky130_fd_sc_hd__a21oi_1
X_13855_ samples_imag\[6\]\[9\] _04874_ VSS VSS VDD VDD _04894_
+ sky130_fd_sc_hd__nand2_1
X_13856_ _04882_ _04893_ _04894_ VSS VSS VDD VDD _00403_ sky130_fd_sc_hd__o21ai_1
X_13857_ _03837_ _03835_ _03839_ VSS VSS VDD VDD _04895_ sky130_fd_sc_hd__nand3_1
X_13858_ net91 _04895_ _03887_ VSS VSS VDD VDD _04896_ sky130_fd_sc_hd__a21oi_1
X_13859_ _03140_ _04896_ _03891_ VSS VSS VDD VDD _04897_ sky130_fd_sc_hd__o21ai_2
X_13860_ _04897_ VSS VSS VDD VDD _04898_ sky130_fd_sc_hd__clkbuf_4
X_13861_ _03268_ VSS VSS VDD VDD _04899_ sky130_fd_sc_hd__clkbuf_4
X_13862_ _03147_ net55 net642 VSS VSS VDD VDD _04900_ sky130_fd_sc_hd__nand3_4
X_13863_ _04900_ VSS VSS VDD VDD _04901_ sky130_fd_sc_hd__clkbuf_4
X_13864_ _04900_ _04898_ VSS VSS VDD VDD _04902_ sky130_fd_sc_hd__nor2_1
X_13865_ samples_imag\[7\]\[0\] _04901_ _03994_ _04902_ VSS
+ VSS VDD VDD _04903_ sky130_fd_sc_hd__a22oi_1
X_13866_ _03296_ _03291_ VSS VSS VDD VDD _04904_ sky130_fd_sc_hd__nand2_2
X_13867_ _04904_ _04898_ VSS VSS VDD VDD _04905_ sky130_fd_sc_hd__or2_0
X_13868_ _04899_ _04903_ _04905_ _03925_ VSS VSS VDD VDD _04906_
+ sky130_fd_sc_hd__o22ai_2
X_13869_ _04001_ _04898_ VSS VSS VDD VDD _04907_ sky130_fd_sc_hd__nor2_1
X_13870_ samples_imag\[7\]\[0\] _04898_ _04906_ _03999_ _04907_
+ VSS VSS VDD VDD _00404_ sky130_fd_sc_hd__a221o_1
X_13871_ _04898_ VSS VSS VDD VDD _04908_ sky130_fd_sc_hd__buf_4
X_13872_ _03268_ VSS VSS VDD VDD _04909_ sky130_fd_sc_hd__buf_2
X_13873_ _04909_ VSS VSS VDD VDD _04910_ sky130_fd_sc_hd__buf_4
X_13874_ _04900_ VSS VSS VDD VDD _04911_ sky130_fd_sc_hd__buf_2
X_13875_ _04900_ VSS VSS VDD VDD _04912_ sky130_fd_sc_hd__buf_2
X_13876_ _04006_ _04912_ VSS VSS VDD VDD _04913_ sky130_fd_sc_hd__nor2_1
X_13877_ samples_imag\[7\]\[10\] _04911_ _04913_ VSS VSS VDD
+ VDD _04914_ sky130_fd_sc_hd__a21oi_1
X_13878_ _03268_ VSS VSS VDD VDD _04915_ sky130_fd_sc_hd__buf_2
X_13879_ _04915_ _04020_ VSS VSS VDD VDD _04916_ sky130_fd_sc_hd__nand2_1
X_13880_ _04910_ _04914_ _04916_ VSS VSS VDD VDD _04917_ sky130_fd_sc_hd__o21ai_1
X_13881_ _04838_ _04917_ _04025_ VSS VSS VDD VDD _04918_ sky130_fd_sc_hd__a21oi_1
X_13882_ _04898_ VSS VSS VDD VDD _04919_ sky130_fd_sc_hd__buf_2
X_13883_ samples_imag\[7\]\[10\] _04919_ VSS VSS VDD VDD _04920_
+ sky130_fd_sc_hd__nand2_1
X_13884_ _04908_ _04918_ _04920_ VSS VSS VDD VDD _00405_ sky130_fd_sc_hd__o21ai_1
X_13885_ _04170_ VSS VSS VDD VDD _04921_ sky130_fd_sc_hd__buf_2
X_13886_ _04031_ _04912_ VSS VSS VDD VDD _04922_ sky130_fd_sc_hd__nor2_2
X_13887_ samples_imag\[7\]\[11\] _04911_ _04922_ VSS VSS VDD
+ VDD _04923_ sky130_fd_sc_hd__a21oi_1
X_13888_ _03268_ VSS VSS VDD VDD _04924_ sky130_fd_sc_hd__buf_2
X_13889_ _04924_ _04036_ VSS VSS VDD VDD _04925_ sky130_fd_sc_hd__nand2_1
X_13890_ _04910_ _04923_ _04925_ VSS VSS VDD VDD _04926_ sky130_fd_sc_hd__o21ai_1
X_13891_ _04921_ _04926_ _04040_ VSS VSS VDD VDD _04927_ sky130_fd_sc_hd__a21oi_1
X_13892_ samples_imag\[7\]\[11\] _04919_ VSS VSS VDD VDD _04928_
+ sky130_fd_sc_hd__nand2_1
X_13893_ _04908_ _04927_ _04928_ VSS VSS VDD VDD _00406_ sky130_fd_sc_hd__o21ai_1
X_13894_ _04897_ VSS VSS VDD VDD _04929_ sky130_fd_sc_hd__buf_2
X_13895_ _04912_ net646 VSS VSS VDD VDD _04930_ sky130_fd_sc_hd__nor2_2
X_13896_ samples_imag\[7\]\[12\] _04911_ _04930_ VSS VSS VDD
+ VDD _04931_ sky130_fd_sc_hd__a21oi_1
X_13897_ _04924_ _04052_ VSS VSS VDD VDD _04932_ sky130_fd_sc_hd__nand2_1
X_13898_ _04910_ _04931_ _04932_ VSS VSS VDD VDD _04933_ sky130_fd_sc_hd__o21ai_1
X_13899_ _04921_ _04933_ _04057_ VSS VSS VDD VDD _04934_ sky130_fd_sc_hd__a21oi_1
X_13900_ samples_imag\[7\]\[12\] _04919_ VSS VSS VDD VDD _04935_
+ sky130_fd_sc_hd__nand2_1
X_13901_ _04929_ _04934_ _04935_ VSS VSS VDD VDD _00407_ sky130_fd_sc_hd__o21ai_1
X_13902_ _04912_ _04061_ VSS VSS VDD VDD _04936_ sky130_fd_sc_hd__nor2_1
X_13903_ samples_imag\[7\]\[13\] _04911_ _04936_ VSS VSS VDD
+ VDD _04937_ sky130_fd_sc_hd__a21oi_1
X_13904_ _04924_ _04066_ VSS VSS VDD VDD _04938_ sky130_fd_sc_hd__nand2_1
X_13905_ _04910_ _04937_ _04938_ VSS VSS VDD VDD _04939_ sky130_fd_sc_hd__o21ai_1
X_13906_ _04921_ _04939_ _04070_ VSS VSS VDD VDD _04940_ sky130_fd_sc_hd__a21oi_1
X_13907_ samples_imag\[7\]\[13\] _04919_ VSS VSS VDD VDD _04941_
+ sky130_fd_sc_hd__nand2_1
X_13908_ _04929_ _04940_ _04941_ VSS VSS VDD VDD _00408_ sky130_fd_sc_hd__o21ai_1
X_13909_ _04912_ _04073_ VSS VSS VDD VDD _04942_ sky130_fd_sc_hd__nor2_1
X_13910_ samples_imag\[7\]\[14\] _04911_ _04942_ VSS VSS VDD
+ VDD _04943_ sky130_fd_sc_hd__a21oi_1
X_13911_ _04924_ _04080_ VSS VSS VDD VDD _04944_ sky130_fd_sc_hd__nand2_1
X_13912_ _04910_ _04943_ _04944_ VSS VSS VDD VDD _04945_ sky130_fd_sc_hd__o21ai_1
X_13913_ _04921_ _04945_ _04084_ VSS VSS VDD VDD _04946_ sky130_fd_sc_hd__a21oi_1
X_13914_ samples_imag\[7\]\[14\] _04919_ VSS VSS VDD VDD _04947_
+ sky130_fd_sc_hd__nand2_1
X_13915_ _04929_ _04946_ _04947_ VSS VSS VDD VDD _00409_ sky130_fd_sc_hd__o21ai_1
X_13916_ _04898_ VSS VSS VDD VDD _04948_ sky130_fd_sc_hd__clkbuf_4
X_13917_ _04900_ VSS VSS VDD VDD _04949_ sky130_fd_sc_hd__buf_4
X_13918_ samples_imag\[7\]\[15\] _04900_ VSS VSS VDD VDD _04950_
+ sky130_fd_sc_hd__nand2_1
X_13919_ _04949_ _04090_ _04950_ _04904_ VSS VSS VDD VDD _04951_
+ sky130_fd_sc_hd__o211ai_1
X_13920_ _04904_ net54 _04951_ VSS VSS VDD VDD _04952_ sky130_fd_sc_hd__o21ai_0
X_13921_ _04029_ _04952_ _04948_ _04095_ VSS VSS VDD VDD _04953_
+ sky130_fd_sc_hd__a211oi_1
X_13922_ samples_imag\[7\]\[15\] _04948_ _04953_ VSS VSS VDD
+ VDD _00410_ sky130_fd_sc_hd__a21o_1
X_13923_ _04912_ _04097_ VSS VSS VDD VDD _04954_ sky130_fd_sc_hd__nor2_1
X_13924_ samples_imag\[7\]\[1\] _04911_ _04954_ VSS VSS VDD
+ VDD _04955_ sky130_fd_sc_hd__a21oi_1
X_13925_ _04101_ _04924_ VSS VSS VDD VDD _04956_ sky130_fd_sc_hd__nand2_1
X_13926_ _04910_ _04955_ _04956_ VSS VSS VDD VDD _04957_ sky130_fd_sc_hd__o21ai_1
X_13927_ _04921_ _04957_ _04105_ VSS VSS VDD VDD _04958_ sky130_fd_sc_hd__a21oi_1
X_13928_ samples_imag\[7\]\[1\] _04919_ VSS VSS VDD VDD _04959_
+ sky130_fd_sc_hd__nand2_1
X_13929_ _04929_ _04958_ _04959_ VSS VSS VDD VDD _00411_ sky130_fd_sc_hd__o21ai_1
X_13930_ _04109_ _04912_ VSS VSS VDD VDD _04960_ sky130_fd_sc_hd__nor2_2
X_13931_ samples_imag\[7\]\[2\] _04911_ _04960_ VSS VSS VDD
+ VDD _04961_ sky130_fd_sc_hd__a21oi_1
X_13932_ _04924_ _04114_ VSS VSS VDD VDD _04962_ sky130_fd_sc_hd__nand2_1
X_13933_ _04915_ _04961_ _04962_ VSS VSS VDD VDD _04963_ sky130_fd_sc_hd__o21ai_1
X_13934_ _04921_ _04963_ _04118_ VSS VSS VDD VDD _04964_ sky130_fd_sc_hd__a21oi_1
X_13935_ samples_imag\[7\]\[2\] _04919_ VSS VSS VDD VDD _04965_
+ sky130_fd_sc_hd__nand2_1
X_13936_ _04929_ _04964_ _04965_ VSS VSS VDD VDD _00412_ sky130_fd_sc_hd__o21ai_1
X_13937_ _04121_ _04912_ VSS VSS VDD VDD _04966_ sky130_fd_sc_hd__nor2_1
X_13938_ samples_imag\[7\]\[3\] _04911_ _04966_ VSS VSS VDD
+ VDD _04967_ sky130_fd_sc_hd__a21oi_1
X_13939_ _04924_ _04126_ VSS VSS VDD VDD _04968_ sky130_fd_sc_hd__nand2_1
X_13940_ _04915_ _04967_ _04968_ VSS VSS VDD VDD _04969_ sky130_fd_sc_hd__o21ai_1
X_13941_ _04921_ _04969_ _04130_ VSS VSS VDD VDD _04970_ sky130_fd_sc_hd__a21oi_1
X_13942_ samples_imag\[7\]\[3\] _04919_ VSS VSS VDD VDD _04971_
+ sky130_fd_sc_hd__nand2_1
X_13943_ _04929_ _04970_ _04971_ VSS VSS VDD VDD _00413_ sky130_fd_sc_hd__o21ai_1
X_13944_ _04133_ _04912_ VSS VSS VDD VDD _04972_ sky130_fd_sc_hd__nor2_1
X_13945_ samples_imag\[7\]\[4\] _04911_ _04972_ VSS VSS VDD
+ VDD _04973_ sky130_fd_sc_hd__a21oi_1
X_13946_ _04924_ _04138_ VSS VSS VDD VDD _04974_ sky130_fd_sc_hd__nand2_1
X_13947_ _04915_ _04973_ _04974_ VSS VSS VDD VDD _04975_ sky130_fd_sc_hd__o21ai_1
X_13948_ _04921_ _04975_ _04142_ VSS VSS VDD VDD _04976_ sky130_fd_sc_hd__a21oi_1
X_13949_ samples_imag\[7\]\[4\] _04919_ VSS VSS VDD VDD _04977_
+ sky130_fd_sc_hd__nand2_1
X_13950_ _04929_ _04976_ _04977_ VSS VSS VDD VDD _00414_ sky130_fd_sc_hd__o21ai_1
X_13951_ _04145_ _04912_ VSS VSS VDD VDD _04978_ sky130_fd_sc_hd__nor2_1
X_13952_ samples_imag\[7\]\[5\] _04911_ _04978_ VSS VSS VDD
+ VDD _04979_ sky130_fd_sc_hd__a21oi_1
X_13953_ _04924_ _04150_ VSS VSS VDD VDD _04980_ sky130_fd_sc_hd__nand2_1
X_13954_ _04915_ _04979_ _04980_ VSS VSS VDD VDD _04981_ sky130_fd_sc_hd__o21ai_1
X_13955_ _04921_ _04981_ _04154_ VSS VSS VDD VDD _04982_ sky130_fd_sc_hd__a21oi_1
X_13956_ samples_imag\[7\]\[5\] _04919_ VSS VSS VDD VDD _04983_
+ sky130_fd_sc_hd__nand2_1
X_13957_ _04929_ _04982_ _04983_ VSS VSS VDD VDD _00415_ sky130_fd_sc_hd__o21ai_1
X_13958_ _04900_ VSS VSS VDD VDD _04984_ sky130_fd_sc_hd__clkbuf_4
X_13959_ _04949_ _04158_ VSS VSS VDD VDD _04985_ sky130_fd_sc_hd__nor2_2
X_13960_ samples_imag\[7\]\[6\] _04984_ _04985_ VSS VSS VDD
+ VDD _04986_ sky130_fd_sc_hd__a21oi_1
X_13961_ _04924_ _04162_ VSS VSS VDD VDD _04987_ sky130_fd_sc_hd__nand2_1
X_13962_ _04915_ _04986_ _04987_ VSS VSS VDD VDD _04988_ sky130_fd_sc_hd__o21ai_1
X_13963_ _04921_ _04988_ _04166_ VSS VSS VDD VDD _04989_ sky130_fd_sc_hd__a21oi_1
X_13964_ _04898_ VSS VSS VDD VDD _04990_ sky130_fd_sc_hd__clkbuf_4
X_13965_ samples_imag\[7\]\[6\] _04990_ VSS VSS VDD VDD _04991_
+ sky130_fd_sc_hd__nand2_1
X_13966_ _04929_ _04989_ _04991_ VSS VSS VDD VDD _00416_ sky130_fd_sc_hd__o21ai_1
X_13967_ _04170_ VSS VSS VDD VDD _04992_ sky130_fd_sc_hd__buf_4
X_13968_ _04949_ _04173_ VSS VSS VDD VDD _04993_ sky130_fd_sc_hd__nor2_2
X_13969_ samples_imag\[7\]\[7\] _04984_ _04993_ VSS VSS VDD
+ VDD _04994_ sky130_fd_sc_hd__a21oi_1
X_13970_ _04899_ _04177_ VSS VSS VDD VDD _04995_ sky130_fd_sc_hd__nand2_1
X_13971_ _04915_ _04994_ _04995_ VSS VSS VDD VDD _04996_ sky130_fd_sc_hd__o21ai_1
X_13972_ _04992_ _04996_ _04181_ VSS VSS VDD VDD _04997_ sky130_fd_sc_hd__a21oi_1
X_13973_ samples_imag\[7\]\[7\] _04990_ VSS VSS VDD VDD _04998_
+ sky130_fd_sc_hd__nand2_1
X_13974_ _04929_ _04997_ _04998_ VSS VSS VDD VDD _00417_ sky130_fd_sc_hd__o21ai_1
X_13975_ _04897_ VSS VSS VDD VDD _04999_ sky130_fd_sc_hd__buf_2
X_13976_ _04949_ _04186_ VSS VSS VDD VDD _05000_ sky130_fd_sc_hd__nor2_2
X_13977_ samples_imag\[7\]\[8\] _04984_ _05000_ VSS VSS VDD
+ VDD _05001_ sky130_fd_sc_hd__a21oi_1
X_13978_ _04899_ _04190_ VSS VSS VDD VDD _05002_ sky130_fd_sc_hd__nand2_1
X_13979_ _04915_ _05001_ _05002_ VSS VSS VDD VDD _05003_ sky130_fd_sc_hd__o21ai_1
X_13980_ _04992_ _05003_ _04194_ VSS VSS VDD VDD _05004_ sky130_fd_sc_hd__a21oi_1
X_13981_ samples_imag\[7\]\[8\] _04990_ VSS VSS VDD VDD _05005_
+ sky130_fd_sc_hd__nand2_1
X_13982_ _04999_ _05004_ _05005_ VSS VSS VDD VDD _00418_ sky130_fd_sc_hd__o21ai_1
X_13983_ _04949_ _04198_ VSS VSS VDD VDD _05006_ sky130_fd_sc_hd__nor2_2
X_13984_ samples_imag\[7\]\[9\] _04984_ _05006_ VSS VSS VDD
+ VDD _05007_ sky130_fd_sc_hd__a21oi_1
X_13985_ _04899_ _04202_ VSS VSS VDD VDD _05008_ sky130_fd_sc_hd__nand2_1
X_13986_ _04915_ _05007_ _05008_ VSS VSS VDD VDD _05009_ sky130_fd_sc_hd__o21ai_1
X_13987_ _04992_ _05009_ _04206_ VSS VSS VDD VDD _05010_ sky130_fd_sc_hd__a21oi_1
X_13988_ samples_imag\[7\]\[9\] _04990_ VSS VSS VDD VDD _05011_
+ sky130_fd_sc_hd__nand2_1
X_13989_ _04999_ _05010_ _05011_ VSS VSS VDD VDD _00419_ sky130_fd_sc_hd__o21ai_1
X_13990_ _05882_ _07736_ VSS VSS VDD VDD _05012_ sky130_fd_sc_hd__xnor2_4
X_13991_ _07728_ VSS VSS VDD VDD _05013_ sky130_fd_sc_hd__clkbuf_2
X_13992_ _07742_ VSS VSS VDD VDD _05014_ sky130_fd_sc_hd__inv_1
X_13993_ _07747_ VSS VSS VDD VDD _05015_ sky130_fd_sc_hd__clkbuf_2
X_13994_ _07752_ VSS VSS VDD VDD _05016_ sky130_fd_sc_hd__inv_1
X_13995_ _07757_ VSS VSS VDD VDD _05017_ sky130_fd_sc_hd__buf_2
X_13996_ _07762_ VSS VSS VDD VDD _05018_ sky130_fd_sc_hd__inv_1
X_13997_ _07767_ VSS VSS VDD VDD _05019_ sky130_fd_sc_hd__clkbuf_2
X_13998_ _07772_ VSS VSS VDD VDD _05020_ sky130_fd_sc_hd__inv_1
X_13999_ _07777_ VSS VSS VDD VDD _05021_ sky130_fd_sc_hd__clkbuf_2
X_14000_ _07782_ VSS VSS VDD VDD _05022_ sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xclone52 _05012_ _05038_ VSS VSS VDD VDD net52 sky130_fd_sc_hd__xor2_4
X_14003_ _05888_ _07796_ _07795_ VSS VSS VDD VDD _05025_ sky130_fd_sc_hd__a21o_1
X_14004_ _05025_ _07792_ _07791_ VSS VSS VDD VDD _05026_ sky130_fd_sc_hd__a21o_1
X_14005_ _05026_ _07787_ _07786_ VSS VSS VDD VDD _05027_ sky130_fd_sc_hd__a21o_1
X_14006_ _05027_ _05022_ _07781_ VSS VSS VDD VDD _05028_ sky130_fd_sc_hd__a21o_1
X_14007_ _05028_ _05021_ _07776_ VSS VSS VDD VDD _05029_ sky130_fd_sc_hd__a21oi_2
X_14008_ _05029_ _05020_ _07771_ VSS VSS VDD VDD _05030_ sky130_fd_sc_hd__o21bai_2
X_14009_ _05030_ _05019_ _07766_ VSS VSS VDD VDD _05031_ sky130_fd_sc_hd__a21oi_2
X_14010_ _05031_ _05018_ _07761_ VSS VSS VDD VDD _05032_ sky130_fd_sc_hd__o21bai_1
X_14011_ _05017_ _05032_ _07756_ VSS VSS VDD VDD _05033_ sky130_fd_sc_hd__a21oi_1
X_14012_ _05016_ _05033_ _07751_ VSS VSS VDD VDD _05034_ sky130_fd_sc_hd__o21bai_1
X_14013_ _05015_ _05034_ _07746_ VSS VSS VDD VDD _05035_ sky130_fd_sc_hd__a21oi_1
X_14014_ _05014_ _05035_ _07741_ VSS VSS VDD VDD _05036_ sky130_fd_sc_hd__o21bai_1
X_14015_ _05036_ _05013_ _07727_ VSS VSS VDD VDD _05037_ sky130_fd_sc_hd__a21o_1
X_14016_ _07723_ _05037_ _07722_ VSS VSS VDD VDD _05038_ sky130_fd_sc_hd__a21oi_4
X_14017_ _05012_ _05038_ VSS VSS VDD VDD _05039_ sky130_fd_sc_hd__xor2_4
X_14018_ temp_real\[0\] _07739_ _05039_ VSS VSS VDD VDD _05040_
+ sky130_fd_sc_hd__nand3_4
X_14019_ _05040_ _07733_ VSS VSS VDD VDD _05041_ sky130_fd_sc_hd__nand2_8
X_14020_ _07796_ VSS VSS VDD VDD _05042_ sky130_fd_sc_hd__inv_2
X_14021_ _07731_ _05042_ _07797_ VSS VSS VDD VDD _05043_ sky130_fd_sc_hd__a21oi_4
X_14022_ _05043_ _07792_ VSS VSS VDD VDD _05044_ sky130_fd_sc_hd__nor2_4
X_14023_ _05044_ _07793_ VSS VSS VDD VDD _05045_ sky130_fd_sc_hd__nor2_4
X_14024_ _07787_ _05045_ VSS VSS VDD VDD _05046_ sky130_fd_sc_hd__nor2_2
X_14025_ _05046_ _07788_ VSS VSS VDD VDD _05047_ sky130_fd_sc_hd__nor2_2
X_14026_ _05047_ _05022_ VSS VSS VDD VDD _05048_ sky130_fd_sc_hd__nor2_1
X_14027_ _05048_ _07783_ VSS VSS VDD VDD _05049_ sky130_fd_sc_hd__nor2_2
X_14028_ _05049_ _05021_ _07778_ VSS VSS VDD VDD _05050_ sky130_fd_sc_hd__o21bai_1
X_14029_ _05020_ _05050_ _07773_ VSS VSS VDD VDD _05051_ sky130_fd_sc_hd__a21oi_2
X_14030_ _05051_ _05019_ _07768_ VSS VSS VDD VDD _05052_ sky130_fd_sc_hd__o21bai_1
X_14031_ _05052_ _05018_ _07763_ VSS VSS VDD VDD _05053_ sky130_fd_sc_hd__a21oi_2
X_14032_ _05053_ _05017_ _07758_ VSS VSS VDD VDD _05054_ sky130_fd_sc_hd__o21bai_1
X_14033_ _05016_ _05054_ _07753_ VSS VSS VDD VDD _05055_ sky130_fd_sc_hd__a21oi_2
X_14034_ _05055_ _05015_ _07748_ VSS VSS VDD VDD _05056_ sky130_fd_sc_hd__o21bai_1
X_14035_ _05014_ _05056_ _07743_ VSS VSS VDD VDD _05057_ sky130_fd_sc_hd__a21oi_2
X_14036_ _05057_ _05013_ VSS VSS VDD VDD _05058_ sky130_fd_sc_hd__nor2_1
X_14037_ _05058_ _07729_ VSS VSS VDD VDD _05059_ sky130_fd_sc_hd__nor2_1
X_14038_ _07723_ _05059_ VSS VSS VDD VDD _05060_ sky130_fd_sc_hd__nor2_1
X_14039_ _05060_ _07724_ VSS VSS VDD VDD _05061_ sky130_fd_sc_hd__nor2_1
X_14040_ _05061_ _05012_ VSS VSS VDD VDD _05062_ sky130_fd_sc_hd__xnor2_2
X_14041_ _07792_ _05885_ VSS VSS VDD VDD _05063_ sky130_fd_sc_hd__nor2_1
X_14042_ _07793_ _05063_ VSS VSS VDD VDD _05064_ sky130_fd_sc_hd__nor2_1
X_14043_ _07787_ _05064_ VSS VSS VDD VDD _05065_ sky130_fd_sc_hd__nor2_1
X_14044_ _05065_ _07788_ VSS VSS VDD VDD _05066_ sky130_fd_sc_hd__nor2_2
X_14045_ _05022_ _05066_ VSS VSS VDD VDD _05067_ sky130_fd_sc_hd__nor2_2
X_14046_ _07783_ _05067_ VSS VSS VDD VDD _05068_ sky130_fd_sc_hd__nor2_1
X_14047_ _05068_ _05021_ VSS VSS VDD VDD _05069_ sky130_fd_sc_hd__nor2_1
X_14048_ _05069_ _07778_ VSS VSS VDD VDD _05070_ sky130_fd_sc_hd__nor2_2
X_14049_ _07772_ _05070_ VSS VSS VDD VDD _05071_ sky130_fd_sc_hd__nor2_1
X_14050_ _07773_ _05071_ VSS VSS VDD VDD _05072_ sky130_fd_sc_hd__nor2_1
X_14051_ _05072_ _05019_ VSS VSS VDD VDD _05073_ sky130_fd_sc_hd__nor2_1
X_14052_ _05073_ _07768_ VSS VSS VDD VDD _05074_ sky130_fd_sc_hd__nor2_2
X_14053_ _05074_ _07762_ VSS VSS VDD VDD _05075_ sky130_fd_sc_hd__nor2_2
X_14054_ _07763_ _05075_ VSS VSS VDD VDD _05076_ sky130_fd_sc_hd__nor2_1
X_14055_ _05017_ _05076_ VSS VSS VDD VDD _05077_ sky130_fd_sc_hd__nor2_1
X_14056_ _05077_ _07758_ VSS VSS VDD VDD _05078_ sky130_fd_sc_hd__nor2_2
X_14057_ _07752_ _05078_ VSS VSS VDD VDD _05079_ sky130_fd_sc_hd__nor2_1
X_14058_ _05079_ _07753_ VSS VSS VDD VDD _05080_ sky130_fd_sc_hd__nor2_1
X_14059_ _05080_ _05015_ VSS VSS VDD VDD _05081_ sky130_fd_sc_hd__nor2_1
X_14060_ _05081_ _07748_ VSS VSS VDD VDD _05082_ sky130_fd_sc_hd__nor2_1
X_14061_ _07742_ _05082_ VSS VSS VDD VDD _05083_ sky130_fd_sc_hd__nor2_1
X_14062_ _05083_ _07743_ VSS VSS VDD VDD _05084_ sky130_fd_sc_hd__nor2_1
X_14063_ _05084_ _05013_ VSS VSS VDD VDD _05085_ sky130_fd_sc_hd__nor2_1
X_14064_ _07729_ _05085_ VSS VSS VDD VDD _05086_ sky130_fd_sc_hd__nor2_2
X_14065_ _05086_ _07723_ VSS VSS VDD VDD _05087_ sky130_fd_sc_hd__xnor2_2
X_14066_ _05013_ net564 VSS VSS VDD VDD _05088_ sky130_fd_sc_hd__xnor2_1
X_14067_ net581 _07742_ VSS VSS VDD VDD _05089_ sky130_fd_sc_hd__xnor2_2
X_14068_ _05017_ _05053_ VSS VSS VDD VDD _05090_ sky130_fd_sc_hd__xor2_2
X_14069_ _05015_ _05055_ VSS VSS VDD VDD _05091_ sky130_fd_sc_hd__xor2_2
X_14070_ _05016_ net599 VSS VSS VDD VDD _05092_ sky130_fd_sc_hd__xnor2_2
X_14071_ _07772_ net592 VSS VSS VDD VDD _05093_ sky130_fd_sc_hd__xnor2_1
X_14072_ _05021_ _05049_ VSS VSS VDD VDD _05094_ sky130_fd_sc_hd__xnor2_1
X_14073_ _07787_ net513 VSS VSS VDD VDD _05095_ sky130_fd_sc_hd__xnor2_1
X_14074_ net617 net578 VSS VSS VDD VDD _05096_ sky130_fd_sc_hd__xor2_2
X_14075_ _05022_ _05066_ VSS VSS VDD VDD _05097_ sky130_fd_sc_hd__xor2_2
X_14076_ _07733_ _05096_ _05097_ _05886_ VSS VSS VDD VDD _05098_
+ sky130_fd_sc_hd__nor4b_1
X_14077_ _05093_ _05094_ _05095_ _05098_ VSS VSS VDD VDD _05099_
+ sky130_fd_sc_hd__nand4_1
X_14078_ _05018_ net597 VSS VSS VDD VDD _05100_ sky130_fd_sc_hd__xnor2_4
X_14079_ _05019_ _05051_ VSS VSS VDD VDD _05101_ sky130_fd_sc_hd__xor2_1
X_14080_ _05092_ _05099_ _05100_ _05101_ VSS VSS VDD VDD _05102_
+ sky130_fd_sc_hd__or4_4
X_14081_ _05090_ _05091_ _05102_ VSS VSS VDD VDD _05103_ sky130_fd_sc_hd__nor3_4
X_14082_ net53 _07738_ VSS VSS VDD VDD _05104_ sky130_fd_sc_hd__nand2_1
X_14083_ _05103_ _05088_ _05089_ _05087_ _05104_ VSS VSS VDD
+ VDD _05105_ sky130_fd_sc_hd__a41oi_4
X_14084_ _05062_ _05105_ VSS VSS VDD VDD _05106_ sky130_fd_sc_hd__nand2b_4
X_14085_ _05106_ _07733_ VSS VSS VDD VDD _05107_ sky130_fd_sc_hd__and2_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14087_ samples_real\[0\]\[0\] _03176_ _03995_ _05107_ VSS
+ VSS VDD VDD _05109_ sky130_fd_sc_hd__a22o_1
X_14088_ _03449_ _05109_ VSS VSS VDD VDD _05110_ sky130_fd_sc_hd__nand2_1
X_14089_ _03894_ _03893_ _05041_ _05110_ VSS VSS VDD VDD _05111_
+ sky130_fd_sc_hd__o31ai_1
X_14090_ _03141_ net74 VSS VSS VDD VDD _05112_ sky130_fd_sc_hd__nand2b_1
X_14091_ _05112_ VSS VSS VDD VDD _05113_ sky130_fd_sc_hd__buf_4
X_14092_ _03893_ _05113_ VSS VSS VDD VDD _05114_ sky130_fd_sc_hd__nor2_1
X_14093_ samples_real\[0\]\[0\] _03893_ _05111_ _03999_ _05114_
+ VSS VSS VDD VDD _00420_ sky130_fd_sc_hd__a221o_1
X_14094_ _05040_ VSS VSS VDD VDD _05115_ sky130_fd_sc_hd__buf_12
X_14095_ net612 _05889_ _07791_ VSS VSS VDD VDD _05116_ sky130_fd_sc_hd__a21o_1
X_14096_ _07787_ _05116_ _07786_ VSS VSS VDD VDD _05117_ sky130_fd_sc_hd__a21o_1
X_14097_ _05022_ _05117_ _07781_ VSS VSS VDD VDD _05118_ sky130_fd_sc_hd__a21o_1
X_14098_ _05021_ _05118_ _07776_ VSS VSS VDD VDD _05119_ sky130_fd_sc_hd__a21oi_1
X_14099_ _05020_ _05119_ _07771_ VSS VSS VDD VDD _05120_ sky130_fd_sc_hd__o21bai_1
X_14100_ _05019_ _05120_ _07766_ VSS VSS VDD VDD _05121_ sky130_fd_sc_hd__a21oi_1
X_14101_ _05018_ _05121_ _07761_ VSS VSS VDD VDD _05122_ sky130_fd_sc_hd__o21bai_1
X_14102_ _05017_ _05122_ _07756_ VSS VSS VDD VDD _05123_ sky130_fd_sc_hd__a21oi_2
X_14103_ _07752_ _05123_ VSS VSS VDD VDD _05124_ sky130_fd_sc_hd__xnor2_2
X_14104_ net568 _05124_ VSS VSS VDD VDD _05125_ sky130_fd_sc_hd__nand2_8
X_14105_ _05106_ VSS VSS VDD VDD _05126_ sky130_fd_sc_hd__buf_12
X_14106_ net577 _05126_ VSS VSS VDD VDD _05127_ sky130_fd_sc_hd__nand2_8
X_14107_ samples_real\[0\]\[10\] _04089_ VSS VSS VDD VDD _05128_
+ sky130_fd_sc_hd__nand2_1
X_14108_ _03715_ _05127_ _05128_ VSS VSS VDD VDD _05129_ sky130_fd_sc_hd__o21ai_2
X_14109_ _03466_ _05129_ VSS VSS VDD VDD _05130_ sky130_fd_sc_hd__nand2_1
X_14110_ _04108_ _05125_ _05130_ VSS VSS VDD VDD _05131_ sky130_fd_sc_hd__o21ai_2
X_14111_ _04055_ net75 VSS VSS VDD VDD _05132_ sky130_fd_sc_hd__nor2b_1
X_14112_ _05132_ VSS VSS VDD VDD _05133_ sky130_fd_sc_hd__buf_4
X_14113_ _04992_ _05131_ _05133_ VSS VSS VDD VDD _05134_ sky130_fd_sc_hd__a21oi_2
X_14114_ samples_real\[0\]\[10\] _04168_ VSS VSS VDD VDD _05135_
+ sky130_fd_sc_hd__nand2_1
X_14115_ _04184_ _05134_ _05135_ VSS VSS VDD VDD _00421_ sky130_fd_sc_hd__o21ai_2
X_14116_ _03309_ VSS VSS VDD VDD _05136_ sky130_fd_sc_hd__buf_2
X_14117_ _05015_ _05034_ VSS VSS VDD VDD _05137_ sky130_fd_sc_hd__xor2_1
X_14118_ net568 _05137_ VSS VSS VDD VDD _05138_ sky130_fd_sc_hd__nand2_8
X_14119_ _05091_ _05126_ VSS VSS VDD VDD _05139_ sky130_fd_sc_hd__nand2_8
X_14120_ samples_real\[0\]\[11\] _04089_ VSS VSS VDD VDD _05140_
+ sky130_fd_sc_hd__nand2_1
X_14121_ _03715_ _05139_ _05140_ VSS VSS VDD VDD _05141_ sky130_fd_sc_hd__o21ai_2
X_14122_ _03466_ _05141_ VSS VSS VDD VDD _05142_ sky130_fd_sc_hd__nand2_1
X_14123_ _05136_ _05138_ _05142_ VSS VSS VDD VDD _05143_ sky130_fd_sc_hd__o21ai_2
X_14124_ _04055_ net76 VSS VSS VDD VDD _05144_ sky130_fd_sc_hd__nor2b_1
X_14125_ _05144_ VSS VSS VDD VDD _05145_ sky130_fd_sc_hd__clkbuf_4
X_14126_ _05143_ _04992_ _05145_ VSS VSS VDD VDD _05146_ sky130_fd_sc_hd__a21oi_2
X_14127_ samples_real\[0\]\[11\] _04168_ VSS VSS VDD VDD _05147_
+ sky130_fd_sc_hd__nand2_1
X_14128_ _04184_ _05146_ _05147_ VSS VSS VDD VDD _00422_ sky130_fd_sc_hd__o21ai_1
X_14129_ _05016_ _05123_ _07751_ VSS VSS VDD VDD _05148_ sky130_fd_sc_hd__o21bai_1
X_14130_ _05015_ _05148_ _07746_ VSS VSS VDD VDD _05149_ sky130_fd_sc_hd__a21oi_1
X_14131_ _07742_ _05149_ VSS VSS VDD VDD _05150_ sky130_fd_sc_hd__xnor2_1
X_14132_ _05115_ _05150_ VSS VSS VDD VDD _05151_ sky130_fd_sc_hd__nand2_8
X_14133_ _05089_ net64 VSS VSS VDD VDD _05152_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14135_ samples_real\[0\]\[12\] _04089_ VSS VSS VDD VDD _05154_
+ sky130_fd_sc_hd__nand2_1
X_14136_ _03715_ _05152_ _05154_ VSS VSS VDD VDD _05155_ sky130_fd_sc_hd__o21ai_2
X_14137_ _03466_ _05155_ VSS VSS VDD VDD _05156_ sky130_fd_sc_hd__nand2_1
X_14138_ _05136_ _05151_ _05156_ VSS VSS VDD VDD _05157_ sky130_fd_sc_hd__o21ai_1
X_14139_ _04055_ net78 VSS VSS VDD VDD _05158_ sky130_fd_sc_hd__nor2b_1
X_14140_ _05158_ VSS VSS VDD VDD _05159_ sky130_fd_sc_hd__clkbuf_4
X_14141_ _04992_ _05157_ _05159_ VSS VSS VDD VDD _05160_ sky130_fd_sc_hd__a21oi_1
X_14142_ samples_real\[0\]\[12\] _04168_ VSS VSS VDD VDD _05161_
+ sky130_fd_sc_hd__nand2_1
X_14143_ _04184_ _05160_ _05161_ VSS VSS VDD VDD _00423_ sky130_fd_sc_hd__o21ai_1
X_14144_ _05013_ _05036_ VSS VSS VDD VDD _05162_ sky130_fd_sc_hd__xor2_1
X_14145_ _05115_ _05162_ VSS VSS VDD VDD _05163_ sky130_fd_sc_hd__nand2_8
X_14146_ _05088_ net64 VSS VSS VDD VDD _05164_ sky130_fd_sc_hd__nand2b_4
Xclone56 _03149_ VSS VSS VDD VDD net56 sky130_fd_sc_hd__buf_6
X_14148_ samples_real\[0\]\[13\] _04089_ VSS VSS VDD VDD _05166_
+ sky130_fd_sc_hd__nand2_1
X_14149_ _03715_ _05164_ _05166_ VSS VSS VDD VDD _05167_ sky130_fd_sc_hd__o21ai_2
X_14150_ _03466_ _05167_ VSS VSS VDD VDD _05168_ sky130_fd_sc_hd__nand2_1
X_14151_ _05136_ _05163_ _05168_ VSS VSS VDD VDD _05169_ sky130_fd_sc_hd__o21ai_1
X_14152_ _04055_ net79 VSS VSS VDD VDD _05170_ sky130_fd_sc_hd__nor2b_1
X_14153_ _05170_ VSS VSS VDD VDD _05171_ sky130_fd_sc_hd__clkbuf_4
X_14154_ _04992_ _05169_ _05171_ VSS VSS VDD VDD _05172_ sky130_fd_sc_hd__a21oi_1
X_14155_ samples_real\[0\]\[13\] _04168_ VSS VSS VDD VDD _05173_
+ sky130_fd_sc_hd__nand2_1
X_14156_ _04184_ _05172_ _05173_ VSS VSS VDD VDD _00424_ sky130_fd_sc_hd__o21ai_1
X_14157_ _05014_ _05149_ _07741_ VSS VSS VDD VDD _05174_ sky130_fd_sc_hd__o21bai_1
X_14158_ _05013_ _05174_ _07727_ VSS VSS VDD VDD _05175_ sky130_fd_sc_hd__a21oi_1
X_14159_ _07723_ _05175_ VSS VSS VDD VDD _05176_ sky130_fd_sc_hd__xnor2_1
X_14160_ _05040_ _05176_ VSS VSS VDD VDD _05177_ sky130_fd_sc_hd__nand2_4
X_14161_ _05087_ _05106_ VSS VSS VDD VDD _05178_ sky130_fd_sc_hd__nand2b_4
XANTENNA_1 net601 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
X_14163_ samples_real\[0\]\[14\] _04089_ VSS VSS VDD VDD _05180_
+ sky130_fd_sc_hd__nand2_1
X_14164_ _03715_ _05178_ _05180_ VSS VSS VDD VDD _05181_ sky130_fd_sc_hd__o21ai_2
X_14165_ _03466_ _05181_ VSS VSS VDD VDD _05182_ sky130_fd_sc_hd__nand2_1
X_14166_ _05136_ _05177_ _05182_ VSS VSS VDD VDD _05183_ sky130_fd_sc_hd__o21ai_1
X_14167_ _04055_ net80 VSS VSS VDD VDD _05184_ sky130_fd_sc_hd__nor2b_1
X_14168_ _05184_ VSS VSS VDD VDD _05185_ sky130_fd_sc_hd__buf_4
X_14169_ _04992_ _05183_ _05185_ VSS VSS VDD VDD _05186_ sky130_fd_sc_hd__a21oi_1
X_14170_ samples_real\[0\]\[14\] _04168_ VSS VSS VDD VDD _05187_
+ sky130_fd_sc_hd__nand2_1
X_14171_ _04184_ _05186_ _05187_ VSS VSS VDD VDD _00425_ sky130_fd_sc_hd__o21ai_1
X_14172_ _05062_ net567 VSS VSS VDD VDD _05188_ sky130_fd_sc_hd__nor2_4
X_14173_ samples_real\[0\]\[15\] _04091_ VSS VSS VDD VDD _05189_
+ sky130_fd_sc_hd__nand2_1
X_14174_ _04089_ _05188_ _05189_ _03309_ VSS VSS VDD VDD _05190_
+ sky130_fd_sc_hd__o211ai_1
X_14175_ _03894_ net566 _05190_ VSS VSS VDD VDD _05191_ sky130_fd_sc_hd__o21ai_0
X_14176_ _03142_ net81 VSS VSS VDD VDD _05192_ sky130_fd_sc_hd__nor2_4
X_14177_ _04029_ _05191_ _05192_ _04087_ VSS VSS VDD VDD _05193_
+ sky130_fd_sc_hd__a211oi_1
X_14178_ samples_real\[0\]\[15\] _04087_ _05193_ VSS VSS VDD
+ VDD _00426_ sky130_fd_sc_hd__a21o_1
X_14179_ _05886_ _05106_ VSS VSS VDD VDD _05194_ sky130_fd_sc_hd__nand2b_4
Xrebuffer244 _05219_ VSS VSS VDD VDD net619 sky130_fd_sc_hd__buf_6
X_14181_ _04089_ _05194_ VSS VSS VDD VDD _05196_ sky130_fd_sc_hd__nor2_4
X_14182_ samples_real\[0\]\[1\] _03715_ _05196_ VSS VSS VDD
+ VDD _05197_ sky130_fd_sc_hd__a21oi_2
X_14183_ net53 net565 _07739_ _05890_ VSS VSS VDD VDD _05198_
+ sky130_fd_sc_hd__a31oi_4
X_14184_ _03894_ _05198_ VSS VSS VDD VDD _05199_ sky130_fd_sc_hd__nor2_1
X_14185_ _05197_ _04108_ _05199_ VSS VSS VDD VDD _05200_ sky130_fd_sc_hd__a21oi_1
X_14186_ _04023_ net82 VSS VSS VDD VDD _05201_ sky130_fd_sc_hd__nor2b_2
X_14187_ _05201_ VSS VSS VDD VDD _05202_ sky130_fd_sc_hd__buf_4
X_14188_ _05200_ _04992_ _05202_ VSS VSS VDD VDD _05203_ sky130_fd_sc_hd__a21oi_1
X_14189_ samples_real\[0\]\[1\] _04168_ VSS VSS VDD VDD _05204_
+ sky130_fd_sc_hd__nand2_1
X_14190_ _05203_ _04184_ _05204_ VSS VSS VDD VDD _00427_ sky130_fd_sc_hd__o21ai_1
X_14191_ net612 _05889_ VSS VSS VDD VDD _05205_ sky130_fd_sc_hd__xor2_1
X_14192_ _05115_ _05205_ VSS VSS VDD VDD _05206_ sky130_fd_sc_hd__nand2_8
X_14193_ _05096_ _05126_ VSS VSS VDD VDD _05207_ sky130_fd_sc_hd__nand2_8
X_14194_ samples_real\[0\]\[2\] _04091_ VSS VSS VDD VDD _05208_
+ sky130_fd_sc_hd__nand2_1
X_14195_ _03715_ _05207_ _05208_ VSS VSS VDD VDD _05209_ sky130_fd_sc_hd__o21ai_2
X_14196_ _03466_ _05209_ VSS VSS VDD VDD _05210_ sky130_fd_sc_hd__nand2_1
X_14197_ _05136_ _05206_ _05210_ VSS VSS VDD VDD _05211_ sky130_fd_sc_hd__o21ai_2
X_14198_ _03141_ net83 VSS VSS VDD VDD _05212_ sky130_fd_sc_hd__nor2b_1
X_14199_ _05212_ VSS VSS VDD VDD _05213_ sky130_fd_sc_hd__buf_4
X_14200_ _05211_ _04992_ _05213_ VSS VSS VDD VDD _05214_ sky130_fd_sc_hd__a21oi_2
X_14201_ samples_real\[0\]\[2\] _04003_ VSS VSS VDD VDD _05215_
+ sky130_fd_sc_hd__nand2_1
X_14202_ _04184_ _05214_ _05215_ VSS VSS VDD VDD _00428_ sky130_fd_sc_hd__o21ai_2
X_14203_ _04236_ VSS VSS VDD VDD _05216_ sky130_fd_sc_hd__clkbuf_4
X_14204_ _07787_ _05026_ VSS VSS VDD VDD _05217_ sky130_fd_sc_hd__xor2_1
X_14205_ net568 _05217_ VSS VSS VDD VDD _05218_ sky130_fd_sc_hd__nand2_8
X_14206_ _05095_ net64 VSS VSS VDD VDD _05219_ sky130_fd_sc_hd__nand2b_4
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
X_14208_ samples_real\[0\]\[3\] _04091_ VSS VSS VDD VDD _05221_
+ sky130_fd_sc_hd__nand2_1
X_14209_ _03177_ _05219_ _05221_ VSS VSS VDD VDD _05222_ sky130_fd_sc_hd__o21ai_2
X_14210_ _03466_ _05222_ VSS VSS VDD VDD _05223_ sky130_fd_sc_hd__nand2_1
X_14211_ _05218_ _05136_ _05223_ VSS VSS VDD VDD _05224_ sky130_fd_sc_hd__o21ai_2
X_14212_ _03141_ net84 VSS VSS VDD VDD _05225_ sky130_fd_sc_hd__nor2b_1
X_14213_ _05225_ VSS VSS VDD VDD _05226_ sky130_fd_sc_hd__buf_4
X_14214_ _05224_ _05216_ _05226_ VSS VSS VDD VDD _05227_ sky130_fd_sc_hd__a21oi_2
X_14215_ samples_real\[0\]\[3\] _04003_ VSS VSS VDD VDD _05228_
+ sky130_fd_sc_hd__nand2_1
X_14216_ _04184_ _05227_ _05228_ VSS VSS VDD VDD _00429_ sky130_fd_sc_hd__o21ai_2
X_14217_ _05022_ _05117_ VSS VSS VDD VDD _05229_ sky130_fd_sc_hd__xor2_1
X_14218_ _05115_ _05229_ VSS VSS VDD VDD _05230_ sky130_fd_sc_hd__nand2_4
X_14219_ _05097_ _05126_ VSS VSS VDD VDD _05231_ sky130_fd_sc_hd__nand2_8
X_14220_ samples_real\[0\]\[4\] _04091_ VSS VSS VDD VDD _05232_
+ sky130_fd_sc_hd__nand2_1
X_14221_ _05231_ _03177_ _05232_ VSS VSS VDD VDD _05233_ sky130_fd_sc_hd__o21ai_2
X_14222_ _03449_ _05233_ VSS VSS VDD VDD _05234_ sky130_fd_sc_hd__nand2_1
X_14223_ _05136_ _05230_ _05234_ VSS VSS VDD VDD _05235_ sky130_fd_sc_hd__o21ai_2
X_14224_ _03141_ net85 VSS VSS VDD VDD _05236_ sky130_fd_sc_hd__nor2b_1
X_14225_ _05236_ VSS VSS VDD VDD _05237_ sky130_fd_sc_hd__buf_4
X_14226_ _05216_ _05235_ _05237_ VSS VSS VDD VDD _05238_ sky130_fd_sc_hd__a21oi_2
X_14227_ samples_real\[0\]\[4\] _04003_ VSS VSS VDD VDD _05239_
+ sky130_fd_sc_hd__nand2_1
X_14228_ _05238_ _04087_ _05239_ VSS VSS VDD VDD _00430_ sky130_fd_sc_hd__o21ai_1
X_14229_ _05021_ _05028_ VSS VSS VDD VDD _05240_ sky130_fd_sc_hd__xor2_1
X_14230_ net568 _05240_ VSS VSS VDD VDD _05241_ sky130_fd_sc_hd__nand2_8
X_14231_ _05094_ _05106_ VSS VSS VDD VDD _05242_ sky130_fd_sc_hd__nand2b_4
Xhold282 data_valid_in VSS VSS VDD VDD net649 sky130_fd_sc_hd__dlygate4sd3_1
X_14233_ samples_real\[0\]\[5\] _04091_ VSS VSS VDD VDD _05244_
+ sky130_fd_sc_hd__nand2_1
X_14234_ _03177_ _05242_ _05244_ VSS VSS VDD VDD _05245_ sky130_fd_sc_hd__o21ai_1
X_14235_ _03449_ _05245_ VSS VSS VDD VDD _05246_ sky130_fd_sc_hd__nand2_1
X_14236_ _05136_ _05241_ _05246_ VSS VSS VDD VDD _05247_ sky130_fd_sc_hd__o21ai_2
X_14237_ _03141_ net86 VSS VSS VDD VDD _05248_ sky130_fd_sc_hd__nor2b_1
X_14238_ _05248_ VSS VSS VDD VDD _05249_ sky130_fd_sc_hd__buf_4
X_14239_ _05247_ _05216_ _05249_ VSS VSS VDD VDD _05250_ sky130_fd_sc_hd__a21oi_2
X_14240_ samples_real\[0\]\[5\] _04003_ VSS VSS VDD VDD _05251_
+ sky130_fd_sc_hd__nand2_1
X_14241_ _05250_ _04087_ _05251_ VSS VSS VDD VDD _00431_ sky130_fd_sc_hd__o21ai_1
X_14242_ _07772_ _05119_ VSS VSS VDD VDD _05252_ sky130_fd_sc_hd__xnor2_2
X_14243_ _05040_ _05252_ VSS VSS VDD VDD _05253_ sky130_fd_sc_hd__nand2_8
X_14244_ _05093_ _05106_ VSS VSS VDD VDD _05254_ sky130_fd_sc_hd__nand2b_4
Xhold281 rst_n VSS VSS VDD VDD net648 sky130_fd_sc_hd__dlygate4sd3_1
X_14246_ samples_real\[0\]\[6\] _04091_ VSS VSS VDD VDD _05256_
+ sky130_fd_sc_hd__nand2_1
X_14247_ _05254_ _03177_ _05256_ VSS VSS VDD VDD _05257_ sky130_fd_sc_hd__o21ai_2
X_14248_ _03449_ _05257_ VSS VSS VDD VDD _05258_ sky130_fd_sc_hd__nand2_1
X_14249_ _05136_ _05253_ _05258_ VSS VSS VDD VDD _05259_ sky130_fd_sc_hd__o21ai_1
X_14250_ _03141_ net87 VSS VSS VDD VDD _05260_ sky130_fd_sc_hd__nor2b_1
X_14251_ _05260_ VSS VSS VDD VDD _05261_ sky130_fd_sc_hd__clkbuf_8
X_14252_ _05259_ _05216_ _05261_ VSS VSS VDD VDD _05262_ sky130_fd_sc_hd__a21oi_1
X_14253_ samples_real\[0\]\[6\] _04003_ VSS VSS VDD VDD _05263_
+ sky130_fd_sc_hd__nand2_1
X_14254_ _04087_ _05262_ _05263_ VSS VSS VDD VDD _00432_ sky130_fd_sc_hd__o21ai_1
X_14255_ _05019_ _05030_ VSS VSS VDD VDD _05264_ sky130_fd_sc_hd__xor2_2
X_14256_ net568 _05264_ VSS VSS VDD VDD _05265_ sky130_fd_sc_hd__nand2_8
X_14257_ _05101_ net64 VSS VSS VDD VDD _05266_ sky130_fd_sc_hd__nand2_8
X_14258_ samples_real\[0\]\[7\] _04091_ VSS VSS VDD VDD _05267_
+ sky130_fd_sc_hd__nand2_1
X_14259_ _03177_ _05266_ _05267_ VSS VSS VDD VDD _05268_ sky130_fd_sc_hd__o21ai_2
X_14260_ _03449_ _05268_ VSS VSS VDD VDD _05269_ sky130_fd_sc_hd__nand2_1
X_14261_ _05136_ _05265_ _05269_ VSS VSS VDD VDD _05270_ sky130_fd_sc_hd__o21ai_1
X_14262_ _03141_ net88 VSS VSS VDD VDD _05271_ sky130_fd_sc_hd__nor2b_1
X_14263_ _05271_ VSS VSS VDD VDD _05272_ sky130_fd_sc_hd__buf_4
X_14264_ _05270_ _05216_ _05272_ VSS VSS VDD VDD _05273_ sky130_fd_sc_hd__a21oi_1
X_14265_ samples_real\[0\]\[7\] _04003_ VSS VSS VDD VDD _05274_
+ sky130_fd_sc_hd__nand2_1
X_14266_ _04087_ _05273_ _05274_ VSS VSS VDD VDD _00433_ sky130_fd_sc_hd__o21ai_1
X_14267_ _07762_ _05121_ VSS VSS VDD VDD _05275_ sky130_fd_sc_hd__xnor2_1
X_14268_ _05115_ _05275_ VSS VSS VDD VDD _05276_ sky130_fd_sc_hd__nand2_8
X_14269_ _05100_ net64 VSS VSS VDD VDD _05277_ sky130_fd_sc_hd__nand2_8
X_14270_ samples_real\[0\]\[8\] _04091_ VSS VSS VDD VDD _05278_
+ sky130_fd_sc_hd__nand2_1
X_14271_ _03177_ _05277_ _05278_ VSS VSS VDD VDD _05279_ sky130_fd_sc_hd__o21ai_2
X_14272_ _03449_ _05279_ VSS VSS VDD VDD _05280_ sky130_fd_sc_hd__nand2_1
X_14273_ _03466_ _05276_ _05280_ VSS VSS VDD VDD _05281_ sky130_fd_sc_hd__o21ai_1
X_14274_ _03141_ net89 VSS VSS VDD VDD _05282_ sky130_fd_sc_hd__nor2b_1
X_14275_ _05282_ VSS VSS VDD VDD _05283_ sky130_fd_sc_hd__buf_4
X_14276_ _05216_ _05281_ _05283_ VSS VSS VDD VDD _05284_ sky130_fd_sc_hd__a21oi_1
X_14277_ samples_real\[0\]\[8\] _04003_ VSS VSS VDD VDD _05285_
+ sky130_fd_sc_hd__nand2_1
X_14278_ _04087_ _05284_ _05285_ VSS VSS VDD VDD _00434_ sky130_fd_sc_hd__o21ai_1
X_14279_ _05017_ net573 VSS VSS VDD VDD _05286_ sky130_fd_sc_hd__xor2_2
X_14280_ _05040_ _05286_ VSS VSS VDD VDD _05287_ sky130_fd_sc_hd__nand2_4
X_14281_ _05090_ _05126_ VSS VSS VDD VDD _05288_ sky130_fd_sc_hd__nand2_8
X_14282_ samples_real\[0\]\[9\] _04091_ VSS VSS VDD VDD _05289_
+ sky130_fd_sc_hd__nand2_1
X_14283_ _03177_ _05288_ _05289_ VSS VSS VDD VDD _05290_ sky130_fd_sc_hd__o21ai_2
X_14284_ _03449_ _05290_ VSS VSS VDD VDD _05291_ sky130_fd_sc_hd__nand2_1
X_14285_ _03466_ _05287_ _05291_ VSS VSS VDD VDD _05292_ sky130_fd_sc_hd__o21ai_1
X_14286_ state\[1\] net90 VSS VSS VDD VDD _05293_ sky130_fd_sc_hd__nor2b_1
X_14287_ _05293_ VSS VSS VDD VDD _05294_ sky130_fd_sc_hd__buf_4
X_14288_ _05216_ _05292_ _05294_ VSS VSS VDD VDD _05295_ sky130_fd_sc_hd__a21oi_1
X_14289_ samples_real\[0\]\[9\] _04003_ VSS VSS VDD VDD _05296_
+ sky130_fd_sc_hd__nand2_1
X_14290_ _04087_ _05295_ _05296_ VSS VSS VDD VDD _00435_ sky130_fd_sc_hd__o21ai_1
X_14291_ samples_real\[1\]\[0\] _04217_ _05107_ _04219_ VSS
+ VSS VDD VDD _05297_ sky130_fd_sc_hd__a22oi_2
X_14292_ _05297_ _04214_ VSS VSS VDD VDD _05298_ sky130_fd_sc_hd__nor2_1
X_14293_ _04222_ _04212_ _05041_ VSS VSS VDD VDD _05299_ sky130_fd_sc_hd__nor3_1
X_14294_ _05299_ _05298_ _04004_ VSS VSS VDD VDD _05300_ sky130_fd_sc_hd__o21ai_1
X_14295_ samples_real\[1\]\[0\] _04227_ VSS VSS VDD VDD _05301_
+ sky130_fd_sc_hd__nand2_1
X_14296_ _04246_ _05113_ _05301_ _05300_ VSS VSS VDD VDD _00436_
+ sky130_fd_sc_hd__o211ai_1
X_14297_ _04265_ _05127_ VSS VSS VDD VDD _05302_ sky130_fd_sc_hd__nor2_4
X_14298_ samples_real\[1\]\[10\] _04239_ _04243_ _05302_ VSS
+ VSS VDD VDD _05303_ sky130_fd_sc_hd__a211oi_2
X_14299_ _04214_ _05125_ _05303_ VSS VSS VDD VDD _05304_ sky130_fd_sc_hd__a21oi_1
X_14300_ _05216_ _05304_ _05133_ VSS VSS VDD VDD _05305_ sky130_fd_sc_hd__a21oi_1
X_14301_ samples_real\[1\]\[10\] _04286_ VSS VSS VDD VDD _05306_
+ sky130_fd_sc_hd__nand2_1
X_14302_ _04318_ _05305_ _05306_ VSS VSS VDD VDD _00437_ sky130_fd_sc_hd__o21ai_1
X_14303_ _04216_ VSS VSS VDD VDD _05307_ sky130_fd_sc_hd__clkbuf_4
X_14304_ _04265_ _05139_ VSS VSS VDD VDD _05308_ sky130_fd_sc_hd__nor2_4
X_14305_ samples_real\[1\]\[11\] _05307_ _04243_ _05308_ VSS
+ VSS VDD VDD _05309_ sky130_fd_sc_hd__a211oi_2
X_14306_ _04214_ _05138_ _05309_ VSS VSS VDD VDD _05310_ sky130_fd_sc_hd__a21oi_1
X_14307_ _05310_ _05216_ _05145_ VSS VSS VDD VDD _05311_ sky130_fd_sc_hd__a21oi_2
X_14308_ samples_real\[1\]\[11\] _04286_ VSS VSS VDD VDD _05312_
+ sky130_fd_sc_hd__nand2_1
X_14309_ _04318_ _05311_ _05312_ VSS VSS VDD VDD _00438_ sky130_fd_sc_hd__o21ai_1
X_14310_ _04265_ _05152_ VSS VSS VDD VDD _05313_ sky130_fd_sc_hd__nor2_2
X_14311_ samples_real\[1\]\[12\] _05307_ _04243_ _05313_ VSS
+ VSS VDD VDD _05314_ sky130_fd_sc_hd__a211oi_2
X_14312_ _04214_ _05151_ _05314_ VSS VSS VDD VDD _05315_ sky130_fd_sc_hd__a21oi_2
X_14313_ _05315_ _05216_ _05159_ VSS VSS VDD VDD _05316_ sky130_fd_sc_hd__a21oi_2
X_14314_ samples_real\[1\]\[12\] _04286_ VSS VSS VDD VDD _05317_
+ sky130_fd_sc_hd__nand2_1
X_14315_ _04318_ _05316_ _05317_ VSS VSS VDD VDD _00439_ sky130_fd_sc_hd__o21ai_2
X_14316_ _04236_ VSS VSS VDD VDD _05318_ sky130_fd_sc_hd__clkbuf_4
X_14317_ _04265_ _05164_ VSS VSS VDD VDD _05319_ sky130_fd_sc_hd__nor2_4
X_14318_ samples_real\[1\]\[13\] _05307_ _04243_ _05319_ VSS
+ VSS VDD VDD _05320_ sky130_fd_sc_hd__a211oi_2
X_14319_ _04214_ _05163_ _05320_ VSS VSS VDD VDD _05321_ sky130_fd_sc_hd__a21oi_2
X_14320_ _05321_ _05318_ _05171_ VSS VSS VDD VDD _05322_ sky130_fd_sc_hd__a21oi_2
X_14321_ samples_real\[1\]\[13\] _04286_ VSS VSS VDD VDD _05323_
+ sky130_fd_sc_hd__nand2_1
X_14322_ _04318_ _05322_ _05323_ VSS VSS VDD VDD _00440_ sky130_fd_sc_hd__o21ai_1
X_14323_ _03142_ VSS VSS VDD VDD _05324_ sky130_fd_sc_hd__buf_4
X_14324_ _04214_ _05177_ VSS VSS VDD VDD _05325_ sky130_fd_sc_hd__nand2_1
X_14325_ samples_real\[1\]\[14\] _04217_ VSS VSS VDD VDD _05326_
+ sky130_fd_sc_hd__nand2_1
X_14326_ _04217_ _05178_ _05326_ _04222_ VSS VSS VDD VDD _05327_
+ sky130_fd_sc_hd__o211ai_1
X_14327_ _05324_ _05325_ _05327_ _04212_ _05185_ VSS VSS VDD
+ VDD _05328_ sky130_fd_sc_hd__a311oi_1
X_14328_ _03692_ _04213_ _05328_ VSS VSS VDD VDD _00441_ sky130_fd_sc_hd__a21oi_1
X_14329_ samples_real\[1\]\[15\] _04216_ VSS VSS VDD VDD _05329_
+ sky130_fd_sc_hd__nand2_1
X_14330_ _04265_ _05188_ _05329_ _04222_ VSS VSS VDD VDD _05330_
+ sky130_fd_sc_hd__o211ai_1
X_14331_ _04222_ net52 _05330_ VSS VSS VDD VDD _05331_ sky130_fd_sc_hd__o21ai_0
X_14332_ _04029_ _05331_ _05192_ _04212_ VSS VSS VDD VDD _05332_
+ sky130_fd_sc_hd__a211oi_2
X_14333_ samples_real\[1\]\[15\] _04246_ _05332_ VSS VSS VDD
+ VDD _00442_ sky130_fd_sc_hd__a21o_1
X_14334_ _04265_ _05194_ VSS VSS VDD VDD _05333_ sky130_fd_sc_hd__nor2_2
X_14335_ samples_real\[1\]\[1\] _04239_ _05333_ VSS VSS VDD
+ VDD _05334_ sky130_fd_sc_hd__a21oi_1
X_14336_ _04238_ _05198_ VSS VSS VDD VDD _05335_ sky130_fd_sc_hd__nand2_1
X_14337_ _04231_ _05334_ _05335_ VSS VSS VDD VDD _05336_ sky130_fd_sc_hd__o21ai_2
X_14338_ _05336_ _05318_ _05202_ VSS VSS VDD VDD _05337_ sky130_fd_sc_hd__a21oi_2
X_14339_ samples_real\[1\]\[1\] _04225_ VSS VSS VDD VDD _05338_
+ sky130_fd_sc_hd__nand2_1
X_14340_ _04318_ _05337_ _05338_ VSS VSS VDD VDD _00443_ sky130_fd_sc_hd__o21ai_1
X_14341_ _04265_ _05207_ VSS VSS VDD VDD _05339_ sky130_fd_sc_hd__nor2_4
X_14342_ samples_real\[1\]\[2\] _05307_ _04243_ _05339_ VSS
+ VSS VDD VDD _05340_ sky130_fd_sc_hd__a211oi_1
X_14343_ _04214_ _05206_ _05340_ VSS VSS VDD VDD _05341_ sky130_fd_sc_hd__a21oi_1
X_14344_ _05318_ _05341_ _05213_ VSS VSS VDD VDD _05342_ sky130_fd_sc_hd__a21oi_1
X_14345_ samples_real\[1\]\[2\] _04225_ VSS VSS VDD VDD _05343_
+ sky130_fd_sc_hd__nand2_1
X_14346_ _04318_ _05342_ _05343_ VSS VSS VDD VDD _00444_ sky130_fd_sc_hd__o21ai_1
X_14347_ _04240_ _05219_ VSS VSS VDD VDD _05344_ sky130_fd_sc_hd__nor2_1
X_14348_ samples_real\[1\]\[3\] _05307_ _03469_ _05344_ VSS
+ VSS VDD VDD _05345_ sky130_fd_sc_hd__a211oi_1
X_14349_ _04214_ _05218_ _05345_ VSS VSS VDD VDD _05346_ sky130_fd_sc_hd__a21oi_1
X_14350_ _05346_ _05318_ _05226_ VSS VSS VDD VDD _05347_ sky130_fd_sc_hd__a21oi_1
X_14351_ samples_real\[1\]\[3\] _04225_ VSS VSS VDD VDD _05348_
+ sky130_fd_sc_hd__nand2_1
X_14352_ _04318_ _05347_ _05348_ VSS VSS VDD VDD _00445_ sky130_fd_sc_hd__o21ai_1
X_14353_ _04240_ _05231_ VSS VSS VDD VDD _05349_ sky130_fd_sc_hd__nor2_2
X_14354_ samples_real\[1\]\[4\] _05307_ _03469_ _05349_ VSS
+ VSS VDD VDD _05350_ sky130_fd_sc_hd__a211oi_1
X_14355_ _04214_ _05230_ _05350_ VSS VSS VDD VDD _05351_ sky130_fd_sc_hd__a21oi_1
X_14356_ _05351_ _05318_ _05237_ VSS VSS VDD VDD _05352_ sky130_fd_sc_hd__a21oi_1
X_14357_ samples_real\[1\]\[4\] _04225_ VSS VSS VDD VDD _05353_
+ sky130_fd_sc_hd__nand2_1
X_14358_ _05352_ _04318_ _05353_ VSS VSS VDD VDD _00446_ sky130_fd_sc_hd__o21ai_1
X_14359_ _04240_ _05242_ VSS VSS VDD VDD _05354_ sky130_fd_sc_hd__nor2_1
X_14360_ samples_real\[1\]\[5\] _05307_ _03469_ _05354_ VSS
+ VSS VDD VDD _05355_ sky130_fd_sc_hd__a211oi_1
X_14361_ _04228_ _05241_ _05355_ VSS VSS VDD VDD _05356_ sky130_fd_sc_hd__a21oi_1
X_14362_ _05318_ _05356_ _05249_ VSS VSS VDD VDD _05357_ sky130_fd_sc_hd__a21oi_1
X_14363_ samples_real\[1\]\[5\] _04225_ VSS VSS VDD VDD _05358_
+ sky130_fd_sc_hd__nand2_1
X_14364_ _04318_ _05357_ _05358_ VSS VSS VDD VDD _00447_ sky130_fd_sc_hd__o21ai_0
X_14365_ _04240_ _05254_ VSS VSS VDD VDD _05359_ sky130_fd_sc_hd__nor2_1
X_14366_ samples_real\[1\]\[6\] _05307_ _03469_ _05359_ VSS
+ VSS VDD VDD _05360_ sky130_fd_sc_hd__a211oi_1
X_14367_ _04228_ _05253_ _05360_ VSS VSS VDD VDD _05361_ sky130_fd_sc_hd__a21oi_1
X_14368_ _05318_ _05361_ _05261_ VSS VSS VDD VDD _05362_ sky130_fd_sc_hd__a21oi_1
X_14369_ samples_real\[1\]\[6\] _04225_ VSS VSS VDD VDD _05363_
+ sky130_fd_sc_hd__nand2_1
X_14370_ _04246_ _05362_ _05363_ VSS VSS VDD VDD _00448_ sky130_fd_sc_hd__o21ai_1
X_14371_ _04240_ _05266_ VSS VSS VDD VDD _05364_ sky130_fd_sc_hd__nor2_2
X_14372_ samples_real\[1\]\[7\] _05307_ _03469_ _05364_ VSS
+ VSS VDD VDD _05365_ sky130_fd_sc_hd__a211oi_1
X_14373_ _04228_ _05265_ _05365_ VSS VSS VDD VDD _05366_ sky130_fd_sc_hd__a21oi_1
X_14374_ _05318_ _05366_ _05272_ VSS VSS VDD VDD _05367_ sky130_fd_sc_hd__a21oi_1
X_14375_ samples_real\[1\]\[7\] _04225_ VSS VSS VDD VDD _05368_
+ sky130_fd_sc_hd__nand2_1
X_14376_ _04246_ _05367_ _05368_ VSS VSS VDD VDD _00449_ sky130_fd_sc_hd__o21ai_1
X_14377_ _04240_ _05277_ VSS VSS VDD VDD _05369_ sky130_fd_sc_hd__nor2_4
X_14378_ samples_real\[1\]\[8\] _05307_ _03469_ _05369_ VSS
+ VSS VDD VDD _05370_ sky130_fd_sc_hd__a211oi_2
X_14379_ _04228_ _05276_ _05370_ VSS VSS VDD VDD _05371_ sky130_fd_sc_hd__a21oi_1
X_14380_ _05371_ _05318_ _05283_ VSS VSS VDD VDD _05372_ sky130_fd_sc_hd__a21oi_1
X_14381_ samples_real\[1\]\[8\] _04225_ VSS VSS VDD VDD _05373_
+ sky130_fd_sc_hd__nand2_1
X_14382_ _05372_ _04246_ _05373_ VSS VSS VDD VDD _00450_ sky130_fd_sc_hd__o21ai_1
X_14383_ _04240_ _05288_ VSS VSS VDD VDD _05374_ sky130_fd_sc_hd__nor2_4
X_14384_ samples_real\[1\]\[9\] _04218_ _03469_ _05374_ VSS
+ VSS VDD VDD _05375_ sky130_fd_sc_hd__a211oi_2
X_14385_ _04228_ _05287_ _05375_ VSS VSS VDD VDD _05376_ sky130_fd_sc_hd__a21oi_1
X_14386_ _05376_ _05318_ _05294_ VSS VSS VDD VDD _05377_ sky130_fd_sc_hd__a21oi_1
X_14387_ samples_real\[1\]\[9\] _04225_ VSS VSS VDD VDD _05378_
+ sky130_fd_sc_hd__nand2_1
X_14388_ _04246_ _05377_ _05378_ VSS VSS VDD VDD _00451_ sky130_fd_sc_hd__o21ai_1
X_14389_ samples_real\[2\]\[0\] _04332_ _04334_ _05107_ VSS
+ VSS VDD VDD _05379_ sky130_fd_sc_hd__a22oi_2
X_14390_ _04329_ _05379_ VSS VSS VDD VDD _05380_ sky130_fd_sc_hd__nor2_1
X_14391_ _04337_ _04327_ _05041_ VSS VSS VDD VDD _05381_ sky130_fd_sc_hd__nor3_1
X_14392_ _05381_ _05380_ _04004_ VSS VSS VDD VDD _05382_ sky130_fd_sc_hd__o21ai_1
X_14393_ samples_real\[2\]\[0\] _04342_ VSS VSS VDD VDD _05383_
+ sky130_fd_sc_hd__nand2_1
X_14394_ _04377_ _05113_ _05383_ _05382_ VSS VSS VDD VDD _00452_
+ sky130_fd_sc_hd__o211ai_2
X_14395_ _04236_ VSS VSS VDD VDD _05384_ sky130_fd_sc_hd__buf_2
X_14396_ _04331_ VSS VSS VDD VDD _05385_ sky130_fd_sc_hd__buf_2
X_14397_ _05385_ _05127_ VSS VSS VDD VDD _05386_ sky130_fd_sc_hd__nor2_4
X_14398_ samples_real\[2\]\[10\] _04429_ _04424_ _05386_ VSS
+ VSS VDD VDD _05387_ sky130_fd_sc_hd__a211oi_2
X_14399_ _04329_ _05125_ _05387_ VSS VSS VDD VDD _05388_ sky130_fd_sc_hd__a21oi_2
X_14400_ _05388_ _05384_ _05133_ VSS VSS VDD VDD _05389_ sky130_fd_sc_hd__a21oi_2
X_14401_ samples_real\[2\]\[10\] _04388_ VSS VSS VDD VDD _05390_
+ sky130_fd_sc_hd__nand2_1
X_14402_ _04409_ _05389_ _05390_ VSS VSS VDD VDD _00453_ sky130_fd_sc_hd__o21ai_1
X_14403_ _05139_ _05385_ VSS VSS VDD VDD _05391_ sky130_fd_sc_hd__nor2_4
X_14404_ samples_real\[2\]\[11\] _04429_ _04424_ _05391_ VSS
+ VSS VDD VDD _05392_ sky130_fd_sc_hd__a211oi_2
X_14405_ _04329_ _05138_ _05392_ VSS VSS VDD VDD _05393_ sky130_fd_sc_hd__a21oi_2
X_14406_ _05384_ _05393_ _05145_ VSS VSS VDD VDD _05394_ sky130_fd_sc_hd__a21oi_2
X_14407_ samples_real\[2\]\[11\] _04388_ VSS VSS VDD VDD _05395_
+ sky130_fd_sc_hd__nand2_1
X_14408_ _05394_ _04409_ _05395_ VSS VSS VDD VDD _00454_ sky130_fd_sc_hd__o21ai_1
X_14409_ _05152_ _05385_ VSS VSS VDD VDD _05396_ sky130_fd_sc_hd__nor2_4
X_14410_ samples_real\[2\]\[12\] _04429_ _04424_ _05396_ VSS
+ VSS VDD VDD _05397_ sky130_fd_sc_hd__a211oi_2
X_14411_ _04329_ _05151_ _05397_ VSS VSS VDD VDD _05398_ sky130_fd_sc_hd__a21oi_2
X_14412_ _05398_ _05384_ _05159_ VSS VSS VDD VDD _05399_ sky130_fd_sc_hd__a21oi_2
X_14413_ samples_real\[2\]\[12\] _04340_ VSS VSS VDD VDD _05400_
+ sky130_fd_sc_hd__nand2_1
X_14414_ _05399_ _04409_ _05400_ VSS VSS VDD VDD _00455_ sky130_fd_sc_hd__o21ai_1
X_14415_ _05385_ _05164_ VSS VSS VDD VDD _05401_ sky130_fd_sc_hd__nor2_4
X_14416_ samples_real\[2\]\[13\] _04429_ _04424_ _05401_ VSS
+ VSS VDD VDD _05402_ sky130_fd_sc_hd__a211oi_2
X_14417_ _04329_ _05163_ _05402_ VSS VSS VDD VDD _05403_ sky130_fd_sc_hd__a21oi_2
X_14418_ _05384_ _05403_ _05171_ VSS VSS VDD VDD _05404_ sky130_fd_sc_hd__a21oi_2
X_14419_ samples_real\[2\]\[13\] _04340_ VSS VSS VDD VDD _05405_
+ sky130_fd_sc_hd__nand2_1
X_14420_ _04409_ _05404_ _05405_ VSS VSS VDD VDD _00456_ sky130_fd_sc_hd__o21ai_1
X_14421_ _04329_ _05177_ VSS VSS VDD VDD _05406_ sky130_fd_sc_hd__nand2_1
X_14422_ samples_real\[2\]\[14\] _04332_ VSS VSS VDD VDD _05407_
+ sky130_fd_sc_hd__nand2_1
X_14423_ _04332_ _05178_ _05407_ _04337_ VSS VSS VDD VDD _05408_
+ sky130_fd_sc_hd__o211ai_1
X_14424_ _03999_ _05406_ _05408_ _04377_ _05185_ VSS VSS VDD
+ VDD _05409_ sky130_fd_sc_hd__a311oi_1
X_14425_ _03527_ _04328_ _05409_ VSS VSS VDD VDD _00457_ sky130_fd_sc_hd__a21oi_1
X_14426_ samples_real\[2\]\[15\] _04331_ VSS VSS VDD VDD _05410_
+ sky130_fd_sc_hd__nand2_1
X_14427_ _04378_ _05188_ _05410_ _04337_ VSS VSS VDD VDD _05411_
+ sky130_fd_sc_hd__o211ai_1
X_14428_ _04337_ net52 _05411_ VSS VSS VDD VDD _05412_ sky130_fd_sc_hd__o21ai_0
X_14429_ _04029_ _05412_ _05192_ _04327_ VSS VSS VDD VDD _05413_
+ sky130_fd_sc_hd__a211oi_2
X_14430_ samples_real\[2\]\[15\] _04377_ _05413_ VSS VSS VDD
+ VDD _00458_ sky130_fd_sc_hd__a21o_1
X_14431_ _05194_ _04378_ VSS VSS VDD VDD _05414_ sky130_fd_sc_hd__nor2_4
X_14432_ samples_real\[2\]\[1\] _04429_ _05414_ VSS VSS VDD
+ VDD _05415_ sky130_fd_sc_hd__a21oi_2
X_14433_ _04424_ _05198_ VSS VSS VDD VDD _05416_ sky130_fd_sc_hd__nand2_1
X_14434_ _04346_ _05415_ _05416_ VSS VSS VDD VDD _05417_ sky130_fd_sc_hd__o21ai_2
X_14435_ _05384_ _05417_ _05202_ VSS VSS VDD VDD _05418_ sky130_fd_sc_hd__a21oi_2
X_14436_ samples_real\[2\]\[1\] _04340_ VSS VSS VDD VDD _05419_
+ sky130_fd_sc_hd__nand2_1
X_14437_ _05418_ _04409_ _05419_ VSS VSS VDD VDD _00459_ sky130_fd_sc_hd__o21ai_1
X_14438_ _05207_ _05385_ VSS VSS VDD VDD _05420_ sky130_fd_sc_hd__nor2_4
X_14439_ samples_real\[2\]\[2\] _04429_ _04424_ _05420_ VSS
+ VSS VDD VDD _05421_ sky130_fd_sc_hd__a211oi_2
X_14440_ _04329_ _05206_ _05421_ VSS VSS VDD VDD _05422_ sky130_fd_sc_hd__a21oi_2
X_14441_ _05422_ _05384_ _05213_ VSS VSS VDD VDD _05423_ sky130_fd_sc_hd__a21oi_2
X_14442_ samples_real\[2\]\[2\] _04340_ VSS VSS VDD VDD _05424_
+ sky130_fd_sc_hd__nand2_1
X_14443_ _05423_ _04409_ _05424_ VSS VSS VDD VDD _00460_ sky130_fd_sc_hd__o21ai_1
X_14444_ _05385_ _05219_ VSS VSS VDD VDD _05425_ sky130_fd_sc_hd__nor2_2
X_14445_ samples_real\[2\]\[3\] _04429_ _05425_ _03437_ VSS
+ VSS VDD VDD _05426_ sky130_fd_sc_hd__a211oi_2
X_14446_ _04343_ _05218_ _05426_ VSS VSS VDD VDD _05427_ sky130_fd_sc_hd__a21oi_2
X_14447_ _05384_ _05427_ _05226_ VSS VSS VDD VDD _05428_ sky130_fd_sc_hd__a21oi_2
X_14448_ samples_real\[2\]\[3\] _04340_ VSS VSS VDD VDD _05429_
+ sky130_fd_sc_hd__nand2_1
X_14449_ _04377_ _05428_ _05429_ VSS VSS VDD VDD _00461_ sky130_fd_sc_hd__o21ai_1
X_14450_ _05231_ _05385_ VSS VSS VDD VDD _05430_ sky130_fd_sc_hd__nor2_4
X_14451_ samples_real\[2\]\[4\] _04429_ _03437_ _05430_ VSS
+ VSS VDD VDD _05431_ sky130_fd_sc_hd__a211oi_2
X_14452_ _04343_ _05230_ _05431_ VSS VSS VDD VDD _05432_ sky130_fd_sc_hd__a21oi_2
X_14453_ _05432_ _05384_ _05237_ VSS VSS VDD VDD _05433_ sky130_fd_sc_hd__a21oi_2
X_14454_ samples_real\[2\]\[4\] _04340_ VSS VSS VDD VDD _05434_
+ sky130_fd_sc_hd__nand2_1
X_14455_ _05433_ _04377_ _05434_ VSS VSS VDD VDD _00462_ sky130_fd_sc_hd__o21ai_1
X_14456_ _05385_ _05242_ VSS VSS VDD VDD _05435_ sky130_fd_sc_hd__nor2_1
X_14457_ samples_real\[2\]\[5\] _04333_ _03437_ _05435_ VSS
+ VSS VDD VDD _05436_ sky130_fd_sc_hd__a211oi_1
X_14458_ _04343_ _05241_ _05436_ VSS VSS VDD VDD _05437_ sky130_fd_sc_hd__a21oi_1
X_14459_ _05384_ _05437_ _05249_ VSS VSS VDD VDD _05438_ sky130_fd_sc_hd__a21oi_1
X_14460_ samples_real\[2\]\[5\] _04340_ VSS VSS VDD VDD _05439_
+ sky130_fd_sc_hd__nand2_1
X_14461_ _04377_ _05438_ _05439_ VSS VSS VDD VDD _00463_ sky130_fd_sc_hd__o21ai_0
X_14462_ _04329_ _05253_ VSS VSS VDD VDD _05440_ sky130_fd_sc_hd__nand2_1
X_14463_ samples_real\[2\]\[6\] _04332_ VSS VSS VDD VDD _05441_
+ sky130_fd_sc_hd__nand2_1
X_14464_ _04332_ _05254_ _05441_ _04337_ VSS VSS VDD VDD _05442_
+ sky130_fd_sc_hd__o211ai_1
X_14465_ _03999_ _05440_ _05442_ _04327_ _05261_ VSS VSS VDD
+ VDD _05443_ sky130_fd_sc_hd__a311oi_1
X_14466_ _03734_ _04328_ _05443_ VSS VSS VDD VDD _00464_ sky130_fd_sc_hd__a21oi_1
X_14467_ _05385_ _05266_ VSS VSS VDD VDD _05444_ sky130_fd_sc_hd__nor2_4
X_14468_ samples_real\[2\]\[7\] _04333_ _03437_ _05444_ VSS
+ VSS VDD VDD _05445_ sky130_fd_sc_hd__a211oi_2
X_14469_ _04343_ _05265_ _05445_ VSS VSS VDD VDD _05446_ sky130_fd_sc_hd__a21oi_1
X_14470_ _05384_ _05446_ _05272_ VSS VSS VDD VDD _05447_ sky130_fd_sc_hd__a21oi_1
X_14471_ samples_real\[2\]\[7\] _04340_ VSS VSS VDD VDD _05448_
+ sky130_fd_sc_hd__nand2_1
X_14472_ _04377_ _05447_ _05448_ VSS VSS VDD VDD _00465_ sky130_fd_sc_hd__o21ai_1
X_14473_ _04236_ VSS VSS VDD VDD _05449_ sky130_fd_sc_hd__buf_6
X_14474_ _05277_ _05385_ VSS VSS VDD VDD _05450_ sky130_fd_sc_hd__nor2_2
X_14475_ samples_real\[2\]\[8\] _04333_ _03437_ _05450_ VSS
+ VSS VDD VDD _05451_ sky130_fd_sc_hd__a211oi_2
X_14476_ _04343_ _05276_ _05451_ VSS VSS VDD VDD _05452_ sky130_fd_sc_hd__a21oi_1
X_14477_ _05449_ _05452_ _05283_ VSS VSS VDD VDD _05453_ sky130_fd_sc_hd__a21oi_1
X_14478_ samples_real\[2\]\[8\] _04340_ VSS VSS VDD VDD _05454_
+ sky130_fd_sc_hd__nand2_1
X_14479_ _04377_ _05453_ _05454_ VSS VSS VDD VDD _00466_ sky130_fd_sc_hd__o21ai_1
X_14480_ _04329_ _05287_ VSS VSS VDD VDD _05455_ sky130_fd_sc_hd__nand2_1
X_14481_ samples_real\[2\]\[9\] _04332_ VSS VSS VDD VDD _05456_
+ sky130_fd_sc_hd__nand2_1
X_14482_ _05288_ _04332_ _05456_ _04337_ VSS VSS VDD VDD _05457_
+ sky130_fd_sc_hd__o211ai_2
X_14483_ _03999_ _05455_ _05457_ _04327_ _05294_ VSS VSS VDD
+ VDD _05458_ sky130_fd_sc_hd__a311oi_1
X_14484_ _03380_ _04328_ _05458_ VSS VSS VDD VDD _00467_ sky130_fd_sc_hd__a21oi_1
X_14485_ samples_real\[3\]\[0\] _04447_ _05107_ _04448_ VSS
+ VSS VDD VDD _05459_ sky130_fd_sc_hd__a22oi_2
X_14486_ _04451_ _05041_ _04455_ _05459_ VSS VSS VDD VDD _05460_
+ sky130_fd_sc_hd__o22ai_1
X_14487_ _04444_ _05113_ VSS VSS VDD VDD _05461_ sky130_fd_sc_hd__nor2_1
X_14488_ samples_real\[3\]\[0\] _04444_ _05460_ _03999_ _05461_
+ VSS VSS VDD VDD _00468_ sky130_fd_sc_hd__a221o_1
X_14489_ _04236_ VSS VSS VDD VDD _05462_ sky130_fd_sc_hd__clkbuf_4
X_14490_ _03439_ VSS VSS VDD VDD _05463_ sky130_fd_sc_hd__buf_2
X_14491_ _05463_ _05125_ VSS VSS VDD VDD _05464_ sky130_fd_sc_hd__nand2_1
X_14492_ _04446_ VSS VSS VDD VDD _05465_ sky130_fd_sc_hd__buf_2
X_14493_ _04446_ VSS VSS VDD VDD _05466_ sky130_fd_sc_hd__buf_2
X_14494_ samples_real\[3\]\[10\] _05466_ VSS VSS VDD VDD _05467_
+ sky130_fd_sc_hd__nand2_1
X_14495_ _04450_ VSS VSS VDD VDD _05468_ sky130_fd_sc_hd__buf_2
X_14496_ _05465_ _05127_ _05467_ _05468_ VSS VSS VDD VDD _05469_
+ sky130_fd_sc_hd__o211ai_2
X_14497_ _05464_ _05469_ _05462_ _05133_ VSS VSS VDD VDD _05470_
+ sky130_fd_sc_hd__a31oi_1
X_14498_ samples_real\[3\]\[10\] _04534_ VSS VSS VDD VDD _05471_
+ sky130_fd_sc_hd__nand2_1
X_14499_ _05470_ _04542_ _05471_ VSS VSS VDD VDD _00469_ sky130_fd_sc_hd__o21ai_1
X_14500_ _05463_ _05138_ VSS VSS VDD VDD _05472_ sky130_fd_sc_hd__nand2_1
X_14501_ samples_real\[3\]\[11\] _05466_ VSS VSS VDD VDD _05473_
+ sky130_fd_sc_hd__nand2_1
X_14502_ _05465_ _05139_ _05473_ _05468_ VSS VSS VDD VDD _05474_
+ sky130_fd_sc_hd__o211ai_2
X_14503_ _05472_ _05474_ _05462_ _05145_ VSS VSS VDD VDD _05475_
+ sky130_fd_sc_hd__a31oi_2
X_14504_ samples_real\[3\]\[11\] _04534_ VSS VSS VDD VDD _05476_
+ sky130_fd_sc_hd__nand2_1
X_14505_ _04542_ _05475_ _05476_ VSS VSS VDD VDD _00470_ sky130_fd_sc_hd__o21ai_1
X_14506_ _05463_ _05151_ VSS VSS VDD VDD _05477_ sky130_fd_sc_hd__nand2_1
X_14507_ samples_real\[3\]\[12\] _05466_ VSS VSS VDD VDD _05478_
+ sky130_fd_sc_hd__nand2_1
X_14508_ _05465_ _05152_ _05478_ _05468_ VSS VSS VDD VDD _05479_
+ sky130_fd_sc_hd__o211ai_2
X_14509_ _05477_ _05479_ _05462_ _05159_ VSS VSS VDD VDD _05480_
+ sky130_fd_sc_hd__a31oi_2
X_14510_ samples_real\[3\]\[12\] _04534_ VSS VSS VDD VDD _05481_
+ sky130_fd_sc_hd__nand2_1
X_14511_ _04542_ _05480_ _05481_ VSS VSS VDD VDD _00471_ sky130_fd_sc_hd__o21ai_1
X_14512_ _05463_ _05163_ VSS VSS VDD VDD _05482_ sky130_fd_sc_hd__nand2_1
X_14513_ samples_real\[3\]\[13\] _05466_ VSS VSS VDD VDD _05483_
+ sky130_fd_sc_hd__nand2_1
X_14514_ _05465_ _05164_ _05483_ _05468_ VSS VSS VDD VDD _05484_
+ sky130_fd_sc_hd__o211ai_2
X_14515_ _05482_ _05484_ _05462_ _05171_ VSS VSS VDD VDD _05485_
+ sky130_fd_sc_hd__a31oi_2
X_14516_ samples_real\[3\]\[13\] _04534_ VSS VSS VDD VDD _05486_
+ sky130_fd_sc_hd__nand2_1
X_14517_ _04542_ _05485_ _05486_ VSS VSS VDD VDD _00472_ sky130_fd_sc_hd__o21ai_1
X_14518_ _05463_ _05177_ VSS VSS VDD VDD _05487_ sky130_fd_sc_hd__nand2_1
X_14519_ samples_real\[3\]\[14\] _05466_ VSS VSS VDD VDD _05488_
+ sky130_fd_sc_hd__nand2_1
X_14520_ _05465_ _05178_ _05488_ _05468_ VSS VSS VDD VDD _05489_
+ sky130_fd_sc_hd__o211ai_2
X_14521_ _05462_ _05487_ _05489_ _05185_ VSS VSS VDD VDD _05490_
+ sky130_fd_sc_hd__a31oi_2
X_14522_ samples_real\[3\]\[14\] _04534_ VSS VSS VDD VDD _05491_
+ sky130_fd_sc_hd__nand2_1
X_14523_ _04542_ _05490_ _05491_ VSS VSS VDD VDD _00473_ sky130_fd_sc_hd__o21ai_1
X_14524_ samples_real\[3\]\[15\] _04446_ VSS VSS VDD VDD _05492_
+ sky130_fd_sc_hd__nand2_1
X_14525_ _04494_ _05188_ _05492_ _04450_ VSS VSS VDD VDD _05493_
+ sky130_fd_sc_hd__o211ai_1
X_14526_ _04450_ net52 _05493_ VSS VSS VDD VDD _05494_ sky130_fd_sc_hd__o21ai_0
X_14527_ _04029_ _05494_ _05192_ _04493_ VSS VSS VDD VDD _05495_
+ sky130_fd_sc_hd__a211oi_1
X_14528_ samples_real\[3\]\[15\] _04493_ _05495_ VSS VSS VDD
+ VDD _00474_ sky130_fd_sc_hd__a21o_1
X_14529_ _04494_ _05194_ VSS VSS VDD VDD _05496_ sky130_fd_sc_hd__nor2_2
X_14530_ samples_real\[3\]\[1\] _04447_ _05496_ VSS VSS VDD
+ VDD _05497_ sky130_fd_sc_hd__a21oi_1
X_14531_ _03439_ _05198_ VSS VSS VDD VDD _05498_ sky130_fd_sc_hd__nand2_1
X_14532_ _04459_ _05497_ _05498_ VSS VSS VDD VDD _05499_ sky130_fd_sc_hd__o21ai_1
X_14533_ _05449_ _05499_ _05202_ VSS VSS VDD VDD _05500_ sky130_fd_sc_hd__a21oi_1
X_14534_ samples_real\[3\]\[1\] _04534_ VSS VSS VDD VDD _05501_
+ sky130_fd_sc_hd__nand2_1
X_14535_ _04542_ _05500_ _05501_ VSS VSS VDD VDD _00475_ sky130_fd_sc_hd__o21ai_1
X_14536_ _05463_ _05206_ VSS VSS VDD VDD _05502_ sky130_fd_sc_hd__nand2_1
X_14537_ samples_real\[3\]\[2\] _05466_ VSS VSS VDD VDD _05503_
+ sky130_fd_sc_hd__nand2_1
X_14538_ _05465_ _05207_ _05503_ _05468_ VSS VSS VDD VDD _05504_
+ sky130_fd_sc_hd__o211ai_2
X_14539_ _05462_ _05504_ _05502_ _05213_ VSS VSS VDD VDD _05505_
+ sky130_fd_sc_hd__a31oi_1
X_14540_ samples_real\[3\]\[2\] _04454_ VSS VSS VDD VDD _05506_
+ sky130_fd_sc_hd__nand2_1
X_14541_ _04542_ _05505_ _05506_ VSS VSS VDD VDD _00476_ sky130_fd_sc_hd__o21ai_1
X_14542_ _05463_ _05218_ VSS VSS VDD VDD _05507_ sky130_fd_sc_hd__nand2_1
X_14543_ samples_real\[3\]\[3\] _05466_ VSS VSS VDD VDD _05508_
+ sky130_fd_sc_hd__nand2_1
X_14544_ _05465_ _05219_ _05508_ _05468_ VSS VSS VDD VDD _05509_
+ sky130_fd_sc_hd__o211ai_2
X_14545_ _05507_ _05509_ _05462_ _05226_ VSS VSS VDD VDD _05510_
+ sky130_fd_sc_hd__a31oi_1
X_14546_ samples_real\[3\]\[3\] _04454_ VSS VSS VDD VDD _05511_
+ sky130_fd_sc_hd__nand2_1
X_14547_ _05510_ _04542_ _05511_ VSS VSS VDD VDD _00477_ sky130_fd_sc_hd__o21ai_1
X_14548_ _05463_ _05230_ VSS VSS VDD VDD _05512_ sky130_fd_sc_hd__nand2_1
X_14549_ samples_real\[3\]\[4\] _04456_ VSS VSS VDD VDD _05513_
+ sky130_fd_sc_hd__nand2_1
X_14550_ _05465_ _05231_ _05513_ _05468_ VSS VSS VDD VDD _05514_
+ sky130_fd_sc_hd__o211ai_2
X_14551_ _05462_ _05514_ _05512_ _05237_ VSS VSS VDD VDD _05515_
+ sky130_fd_sc_hd__a31oi_1
X_14552_ samples_real\[3\]\[4\] _04454_ VSS VSS VDD VDD _05516_
+ sky130_fd_sc_hd__nand2_1
X_14553_ _04493_ _05515_ _05516_ VSS VSS VDD VDD _00478_ sky130_fd_sc_hd__o21ai_1
X_14554_ _05463_ _05241_ VSS VSS VDD VDD _05517_ sky130_fd_sc_hd__nand2_1
X_14555_ samples_real\[3\]\[5\] _04456_ VSS VSS VDD VDD _05518_
+ sky130_fd_sc_hd__nand2_1
X_14556_ _05465_ _05242_ _05518_ _05468_ VSS VSS VDD VDD _05519_
+ sky130_fd_sc_hd__o211ai_1
X_14557_ _05462_ _05517_ _05519_ _05249_ VSS VSS VDD VDD _05520_
+ sky130_fd_sc_hd__a31oi_1
X_14558_ samples_real\[3\]\[5\] _04454_ VSS VSS VDD VDD _05521_
+ sky130_fd_sc_hd__nand2_1
X_14559_ _04493_ _05520_ _05521_ VSS VSS VDD VDD _00479_ sky130_fd_sc_hd__o21ai_0
X_14560_ _05463_ _05253_ VSS VSS VDD VDD _05522_ sky130_fd_sc_hd__nand2_1
X_14561_ samples_real\[3\]\[6\] _04456_ VSS VSS VDD VDD _05523_
+ sky130_fd_sc_hd__nand2_1
X_14562_ _05465_ _05254_ _05523_ _05468_ VSS VSS VDD VDD _05524_
+ sky130_fd_sc_hd__o211ai_1
X_14563_ _05462_ _05522_ _05524_ _05261_ VSS VSS VDD VDD _05525_
+ sky130_fd_sc_hd__a31oi_1
X_14564_ samples_real\[3\]\[6\] _04454_ VSS VSS VDD VDD _05526_
+ sky130_fd_sc_hd__nand2_1
X_14565_ _04493_ _05525_ _05526_ VSS VSS VDD VDD _00480_ sky130_fd_sc_hd__o21ai_0
X_14566_ _04236_ VSS VSS VDD VDD _05527_ sky130_fd_sc_hd__buf_4
X_14567_ _05265_ _04455_ VSS VSS VDD VDD _05528_ sky130_fd_sc_hd__nand2_2
X_14568_ samples_real\[3\]\[7\] _04456_ VSS VSS VDD VDD _05529_
+ sky130_fd_sc_hd__nand2_1
X_14569_ _05466_ _05266_ _05529_ _04450_ VSS VSS VDD VDD _05530_
+ sky130_fd_sc_hd__o211ai_2
X_14570_ _05527_ _05528_ _05530_ _05272_ VSS VSS VDD VDD _05531_
+ sky130_fd_sc_hd__a31oi_1
X_14571_ samples_real\[3\]\[7\] _04454_ VSS VSS VDD VDD _05532_
+ sky130_fd_sc_hd__nand2_1
X_14572_ _05531_ _04493_ _05532_ VSS VSS VDD VDD _00481_ sky130_fd_sc_hd__o21ai_1
X_14573_ _04455_ _05276_ VSS VSS VDD VDD _05533_ sky130_fd_sc_hd__nand2_1
X_14574_ samples_real\[3\]\[8\] _04456_ VSS VSS VDD VDD _05534_
+ sky130_fd_sc_hd__nand2_1
X_14575_ _05277_ _05466_ _05534_ _04450_ VSS VSS VDD VDD _05535_
+ sky130_fd_sc_hd__o211ai_2
X_14576_ _05527_ _05533_ _05535_ _05283_ VSS VSS VDD VDD _05536_
+ sky130_fd_sc_hd__a31oi_1
X_14577_ samples_real\[3\]\[8\] _04454_ VSS VSS VDD VDD _05537_
+ sky130_fd_sc_hd__nand2_1
X_14578_ _04493_ _05536_ _05537_ VSS VSS VDD VDD _00482_ sky130_fd_sc_hd__o21ai_1
X_14579_ _04455_ _05287_ VSS VSS VDD VDD _05538_ sky130_fd_sc_hd__nand2_1
X_14580_ samples_real\[3\]\[9\] _04456_ VSS VSS VDD VDD _05539_
+ sky130_fd_sc_hd__nand2_1
X_14581_ _05466_ _05288_ _05539_ _04450_ VSS VSS VDD VDD _05540_
+ sky130_fd_sc_hd__o211ai_2
X_14582_ _05527_ _05540_ _05538_ _05294_ VSS VSS VDD VDD _05541_
+ sky130_fd_sc_hd__a31oi_1
X_14583_ samples_real\[3\]\[9\] _04454_ VSS VSS VDD VDD _05542_
+ sky130_fd_sc_hd__nand2_1
X_14584_ _04493_ _05541_ _05542_ VSS VSS VDD VDD _00483_ sky130_fd_sc_hd__o21ai_1
X_14585_ samples_real\[4\]\[0\] _04560_ _04562_ _05107_ VSS
+ VSS VDD VDD _05543_ sky130_fd_sc_hd__a22oi_1
X_14586_ _04557_ _05041_ VSS VSS VDD VDD _05544_ sky130_fd_sc_hd__nor2_1
X_14587_ _04564_ _05544_ VSS VSS VDD VDD _05545_ sky130_fd_sc_hd__nand2_1
X_14588_ _04564_ _05543_ _05545_ VSS VSS VDD VDD _05546_ sky130_fd_sc_hd__o21ai_0
X_14589_ _04557_ _05113_ VSS VSS VDD VDD _05547_ sky130_fd_sc_hd__nor2_1
X_14590_ samples_real\[4\]\[0\] _04557_ _05546_ _04088_ _05547_
+ VSS VSS VDD VDD _00484_ sky130_fd_sc_hd__a221o_1
X_14591_ _04556_ VSS VSS VDD VDD _05548_ sky130_fd_sc_hd__buf_2
X_14592_ _03467_ VSS VSS VDD VDD _05549_ sky130_fd_sc_hd__buf_2
X_14593_ _05127_ _04655_ VSS VSS VDD VDD _05550_ sky130_fd_sc_hd__nor2_4
X_14594_ samples_real\[4\]\[10\] _04588_ _04564_ _05550_ VSS
+ VSS VDD VDD _05551_ sky130_fd_sc_hd__a211oi_2
X_14595_ _05549_ _05125_ _05551_ VSS VSS VDD VDD _05552_ sky130_fd_sc_hd__a21oi_2
X_14596_ _05552_ _05449_ _05133_ VSS VSS VDD VDD _05553_ sky130_fd_sc_hd__a21oi_1
X_14597_ samples_real\[4\]\[10\] _04646_ VSS VSS VDD VDD _05554_
+ sky130_fd_sc_hd__nand2_1
X_14598_ _05553_ _05548_ _05554_ VSS VSS VDD VDD _00485_ sky130_fd_sc_hd__o21ai_1
X_14599_ _03272_ VSS VSS VDD VDD _05555_ sky130_fd_sc_hd__buf_2
X_14600_ _04655_ _05139_ VSS VSS VDD VDD _05556_ sky130_fd_sc_hd__nor2_4
X_14601_ samples_real\[4\]\[11\] _04588_ _05555_ _05556_ VSS
+ VSS VDD VDD _05557_ sky130_fd_sc_hd__a211oi_2
X_14602_ _05549_ _05138_ _05557_ VSS VSS VDD VDD _05558_ sky130_fd_sc_hd__a21oi_2
X_14603_ _05449_ _05558_ _05145_ VSS VSS VDD VDD _05559_ sky130_fd_sc_hd__a21oi_1
X_14604_ samples_real\[4\]\[11\] _04646_ VSS VSS VDD VDD _05560_
+ sky130_fd_sc_hd__nand2_1
X_14605_ _05559_ _05548_ _05560_ VSS VSS VDD VDD _00486_ sky130_fd_sc_hd__o21ai_1
X_14606_ _04655_ _05152_ VSS VSS VDD VDD _05561_ sky130_fd_sc_hd__nor2_4
X_14607_ samples_real\[4\]\[12\] _04588_ _05555_ _05561_ VSS
+ VSS VDD VDD _05562_ sky130_fd_sc_hd__a211oi_1
X_14608_ _05549_ _05151_ _05562_ VSS VSS VDD VDD _05563_ sky130_fd_sc_hd__a21oi_1
X_14609_ _05563_ _05449_ _05159_ VSS VSS VDD VDD _05564_ sky130_fd_sc_hd__a21oi_1
X_14610_ samples_real\[4\]\[12\] _04646_ VSS VSS VDD VDD _05565_
+ sky130_fd_sc_hd__nand2_1
X_14611_ _05548_ _05564_ _05565_ VSS VSS VDD VDD _00487_ sky130_fd_sc_hd__o21ai_1
X_14612_ _04655_ _05164_ VSS VSS VDD VDD _05566_ sky130_fd_sc_hd__nor2_4
X_14613_ samples_real\[4\]\[13\] _04588_ _05555_ _05566_ VSS
+ VSS VDD VDD _05567_ sky130_fd_sc_hd__a211oi_2
X_14614_ _05549_ _05163_ _05567_ VSS VSS VDD VDD _05568_ sky130_fd_sc_hd__a21oi_1
X_14615_ _05449_ _05568_ _05171_ VSS VSS VDD VDD _05569_ sky130_fd_sc_hd__a21oi_1
X_14616_ samples_real\[4\]\[13\] _04646_ VSS VSS VDD VDD _05570_
+ sky130_fd_sc_hd__nand2_1
X_14617_ _05548_ _05569_ _05570_ VSS VSS VDD VDD _00488_ sky130_fd_sc_hd__o21ai_1
X_14618_ _04655_ _05178_ VSS VSS VDD VDD _05571_ sky130_fd_sc_hd__nor2_2
X_14619_ samples_real\[4\]\[14\] _04588_ _05555_ _05571_ VSS
+ VSS VDD VDD _05572_ sky130_fd_sc_hd__a211oi_1
X_14620_ _05549_ _05177_ _05572_ VSS VSS VDD VDD _05573_ sky130_fd_sc_hd__a21oi_1
X_14621_ _05573_ _05449_ _05185_ VSS VSS VDD VDD _05574_ sky130_fd_sc_hd__a21oi_1
X_14622_ samples_real\[4\]\[14\] _04646_ VSS VSS VDD VDD _05575_
+ sky130_fd_sc_hd__nand2_1
X_14623_ _05548_ _05574_ _05575_ VSS VSS VDD VDD _00489_ sky130_fd_sc_hd__o21ai_1
X_14624_ samples_real\[4\]\[15\] net549 VSS VSS VDD VDD _05576_
+ sky130_fd_sc_hd__nor2_1
X_14625_ net551 _05188_ _05576_ _03467_ VSS VSS VDD VDD _05577_
+ sky130_fd_sc_hd__a211oi_1
X_14626_ _04564_ net52 _05577_ VSS VSS VDD VDD _05578_ sky130_fd_sc_hd__a21oi_1
X_14627_ _04029_ _05578_ _05192_ _04593_ VSS VSS VDD VDD _05579_
+ sky130_fd_sc_hd__a211oi_1
X_14628_ samples_real\[4\]\[15\] _04593_ _05579_ VSS VSS VDD
+ VDD _00490_ sky130_fd_sc_hd__a21o_1
X_14629_ _04655_ _05194_ VSS VSS VDD VDD _05580_ sky130_fd_sc_hd__nor2_2
X_14630_ samples_real\[4\]\[1\] _04588_ _05580_ VSS VSS VDD
+ VDD _05581_ sky130_fd_sc_hd__a21oi_1
X_14631_ _04558_ _05198_ VSS VSS VDD VDD _05582_ sky130_fd_sc_hd__nand2_1
X_14632_ _04576_ _05581_ _05582_ VSS VSS VDD VDD _05583_ sky130_fd_sc_hd__o21ai_1
X_14633_ _05449_ _05583_ _05202_ VSS VSS VDD VDD _05584_ sky130_fd_sc_hd__a21oi_1
X_14634_ samples_real\[4\]\[1\] _04646_ VSS VSS VDD VDD _05585_
+ sky130_fd_sc_hd__nand2_1
X_14635_ _05548_ _05584_ _05585_ VSS VSS VDD VDD _00491_ sky130_fd_sc_hd__o21ai_1
X_14636_ _04655_ _05207_ VSS VSS VDD VDD _05586_ sky130_fd_sc_hd__nor2_4
X_14637_ samples_real\[4\]\[2\] _04560_ _05555_ _05586_ VSS
+ VSS VDD VDD _05587_ sky130_fd_sc_hd__a211oi_2
X_14638_ _05549_ _05206_ _05587_ VSS VSS VDD VDD _05588_ sky130_fd_sc_hd__a21oi_1
X_14639_ _05449_ _05588_ _05213_ VSS VSS VDD VDD _05589_ sky130_fd_sc_hd__a21oi_1
X_14640_ samples_real\[4\]\[2\] _04569_ VSS VSS VDD VDD _05590_
+ sky130_fd_sc_hd__nand2_1
X_14641_ _05548_ _05589_ _05590_ VSS VSS VDD VDD _00492_ sky130_fd_sc_hd__o21ai_1
X_14642_ _04655_ net619 VSS VSS VDD VDD _05591_ sky130_fd_sc_hd__nor2_4
X_14643_ samples_real\[4\]\[3\] _04560_ _05555_ _05591_ VSS
+ VSS VDD VDD _05592_ sky130_fd_sc_hd__a211oi_2
X_14644_ _05549_ _05218_ _05592_ VSS VSS VDD VDD _05593_ sky130_fd_sc_hd__a21oi_2
X_14645_ _05593_ _05449_ _05226_ VSS VSS VDD VDD _05594_ sky130_fd_sc_hd__a21oi_2
X_14646_ samples_real\[4\]\[3\] _04569_ VSS VSS VDD VDD _05595_
+ sky130_fd_sc_hd__nand2_1
X_14647_ _05548_ _05594_ _05595_ VSS VSS VDD VDD _00493_ sky130_fd_sc_hd__o21ai_1
X_14648_ _04236_ VSS VSS VDD VDD _05596_ sky130_fd_sc_hd__clkbuf_4
X_14649_ _04561_ _05231_ VSS VSS VDD VDD _05597_ sky130_fd_sc_hd__nor2_4
X_14650_ samples_real\[4\]\[4\] _04560_ _05555_ _05597_ VSS
+ VSS VDD VDD _05598_ sky130_fd_sc_hd__a211oi_2
X_14651_ _05549_ _05230_ _05598_ VSS VSS VDD VDD _05599_ sky130_fd_sc_hd__a21oi_1
X_14652_ _05599_ _05596_ _05237_ VSS VSS VDD VDD _05600_ sky130_fd_sc_hd__a21oi_1
X_14653_ samples_real\[4\]\[4\] _04569_ VSS VSS VDD VDD _05601_
+ sky130_fd_sc_hd__nand2_1
X_14654_ _05548_ _05600_ _05601_ VSS VSS VDD VDD _00494_ sky130_fd_sc_hd__o21ai_1
X_14655_ _04561_ _05242_ VSS VSS VDD VDD _05602_ sky130_fd_sc_hd__nor2_1
X_14656_ samples_real\[4\]\[5\] _04560_ _05555_ _05602_ VSS
+ VSS VDD VDD _05603_ sky130_fd_sc_hd__a211oi_1
X_14657_ _05549_ _05241_ _05603_ VSS VSS VDD VDD _05604_ sky130_fd_sc_hd__a21oi_2
X_14658_ _05604_ _05596_ _05249_ VSS VSS VDD VDD _05605_ sky130_fd_sc_hd__a21oi_2
X_14659_ samples_real\[4\]\[5\] _04569_ VSS VSS VDD VDD _05606_
+ sky130_fd_sc_hd__nand2_1
X_14660_ _05605_ _05548_ _05606_ VSS VSS VDD VDD _00495_ sky130_fd_sc_hd__o21ai_1
X_14661_ _04561_ _05254_ VSS VSS VDD VDD _05607_ sky130_fd_sc_hd__nor2_4
X_14662_ samples_real\[4\]\[6\] _04560_ _05555_ _05607_ VSS
+ VSS VDD VDD _05608_ sky130_fd_sc_hd__a211oi_2
X_14663_ _05549_ _05253_ _05608_ VSS VSS VDD VDD _05609_ sky130_fd_sc_hd__a21oi_1
X_14664_ _05596_ _05609_ _05261_ VSS VSS VDD VDD _05610_ sky130_fd_sc_hd__a21oi_1
X_14665_ samples_real\[4\]\[6\] _04569_ VSS VSS VDD VDD _05611_
+ sky130_fd_sc_hd__nand2_1
X_14666_ _04593_ _05610_ _05611_ VSS VSS VDD VDD _00496_ sky130_fd_sc_hd__o21ai_1
X_14667_ _04561_ _05266_ VSS VSS VDD VDD _05612_ sky130_fd_sc_hd__nor2_2
X_14668_ samples_real\[4\]\[7\] _04560_ _05612_ _05555_ VSS
+ VSS VDD VDD _05613_ sky130_fd_sc_hd__a211oi_1
X_14669_ _04571_ _05265_ _05613_ VSS VSS VDD VDD _05614_ sky130_fd_sc_hd__a21oi_1
X_14670_ _05614_ _05596_ _05272_ VSS VSS VDD VDD _05615_ sky130_fd_sc_hd__a21oi_1
X_14671_ samples_real\[4\]\[7\] _04569_ VSS VSS VDD VDD _05616_
+ sky130_fd_sc_hd__nand2_1
X_14672_ _04593_ _05615_ _05616_ VSS VSS VDD VDD _00497_ sky130_fd_sc_hd__o21ai_1
X_14673_ _04561_ _05277_ VSS VSS VDD VDD _05617_ sky130_fd_sc_hd__nor2_4
X_14674_ samples_real\[4\]\[8\] _04560_ _05617_ _03467_ VSS
+ VSS VDD VDD _05618_ sky130_fd_sc_hd__a211oi_2
X_14675_ _04571_ _05276_ _05618_ VSS VSS VDD VDD _05619_ sky130_fd_sc_hd__a21oi_1
X_14676_ _05619_ _05596_ _05283_ VSS VSS VDD VDD _05620_ sky130_fd_sc_hd__a21oi_1
X_14677_ samples_real\[4\]\[8\] _04569_ VSS VSS VDD VDD _05621_
+ sky130_fd_sc_hd__nand2_1
X_14678_ _05620_ _04593_ _05621_ VSS VSS VDD VDD _00498_ sky130_fd_sc_hd__o21ai_1
X_14679_ _05288_ _04561_ VSS VSS VDD VDD _05622_ sky130_fd_sc_hd__nor2_4
X_14680_ samples_real\[4\]\[9\] _04560_ _03467_ _05622_ VSS
+ VSS VDD VDD _05623_ sky130_fd_sc_hd__a211oi_2
X_14681_ _04571_ _05287_ _05623_ VSS VSS VDD VDD _05624_ sky130_fd_sc_hd__a21oi_2
X_14682_ _05624_ _05596_ _05294_ VSS VSS VDD VDD _05625_ sky130_fd_sc_hd__a21oi_1
X_14683_ samples_real\[4\]\[9\] _04569_ VSS VSS VDD VDD _05626_
+ sky130_fd_sc_hd__nand2_1
X_14684_ _05625_ _04593_ _05626_ VSS VSS VDD VDD _00499_ sky130_fd_sc_hd__o21ai_1
X_14685_ samples_real\[5\]\[0\] _04673_ _04675_ _05107_ VSS
+ VSS VDD VDD _05627_ sky130_fd_sc_hd__a22oi_1
X_14686_ _04672_ _05627_ VSS VSS VDD VDD _05628_ sky130_fd_sc_hd__nor2_1
X_14687_ _04680_ _04670_ _05041_ VSS VSS VDD VDD _05629_ sky130_fd_sc_hd__nor3_1
X_14688_ _05628_ _05629_ _04004_ VSS VSS VDD VDD _05630_ sky130_fd_sc_hd__o21ai_0
X_14689_ samples_real\[5\]\[0\] _04685_ VSS VSS VDD VDD _05631_
+ sky130_fd_sc_hd__nand2_1
X_14690_ _04719_ _05113_ _05630_ _05631_ VSS VSS VDD VDD _00500_
+ sky130_fd_sc_hd__o211ai_1
X_14691_ _04672_ _05125_ VSS VSS VDD VDD _05632_ sky130_fd_sc_hd__nand2_1
X_14692_ _03773_ VSS VSS VDD VDD _05633_ sky130_fd_sc_hd__buf_2
X_14693_ _03773_ VSS VSS VDD VDD _05634_ sky130_fd_sc_hd__clkbuf_4
X_14694_ samples_real\[5\]\[10\] _05634_ VSS VSS VDD VDD _05635_
+ sky130_fd_sc_hd__nand2_1
X_14695_ _05633_ _05127_ _05635_ _04680_ VSS VSS VDD VDD _05636_
+ sky130_fd_sc_hd__o211ai_2
X_14696_ _05527_ _05636_ _05632_ _05133_ VSS VSS VDD VDD _05637_
+ sky130_fd_sc_hd__a31oi_1
X_14697_ samples_real\[5\]\[10\] _04755_ VSS VSS VDD VDD _05638_
+ sky130_fd_sc_hd__nand2_1
X_14698_ _04757_ _05637_ _05638_ VSS VSS VDD VDD _00501_ sky130_fd_sc_hd__o21ai_1
X_14699_ _04672_ _05138_ VSS VSS VDD VDD _05639_ sky130_fd_sc_hd__nand2_1
X_14700_ samples_real\[5\]\[11\] _05634_ VSS VSS VDD VDD _05640_
+ sky130_fd_sc_hd__nand2_1
X_14701_ _05633_ _05139_ _05640_ _04680_ VSS VSS VDD VDD _05641_
+ sky130_fd_sc_hd__o211ai_2
X_14702_ _05527_ _05639_ _05641_ _05145_ VSS VSS VDD VDD _05642_
+ sky130_fd_sc_hd__a31oi_1
X_14703_ samples_real\[5\]\[11\] _04755_ VSS VSS VDD VDD _05643_
+ sky130_fd_sc_hd__nand2_1
X_14704_ _04757_ _05642_ _05643_ VSS VSS VDD VDD _00502_ sky130_fd_sc_hd__o21ai_1
X_14705_ _04672_ _05151_ VSS VSS VDD VDD _05644_ sky130_fd_sc_hd__nand2_1
X_14706_ samples_real\[5\]\[12\] _05634_ VSS VSS VDD VDD _05645_
+ sky130_fd_sc_hd__nand2_1
X_14707_ _05633_ _05152_ _05645_ _04680_ VSS VSS VDD VDD _05646_
+ sky130_fd_sc_hd__o211ai_2
X_14708_ _05527_ _05646_ _05644_ _05159_ VSS VSS VDD VDD _05647_
+ sky130_fd_sc_hd__a31oi_1
X_14709_ samples_real\[5\]\[12\] _04755_ VSS VSS VDD VDD _05648_
+ sky130_fd_sc_hd__nand2_1
X_14710_ _05647_ _04757_ _05648_ VSS VSS VDD VDD _00503_ sky130_fd_sc_hd__o21ai_1
X_14711_ _04672_ _05163_ VSS VSS VDD VDD _05649_ sky130_fd_sc_hd__nand2_1
X_14712_ samples_real\[5\]\[13\] _05634_ VSS VSS VDD VDD _05650_
+ sky130_fd_sc_hd__nand2_1
X_14713_ _05633_ _05164_ _05650_ _04680_ VSS VSS VDD VDD _05651_
+ sky130_fd_sc_hd__o211ai_2
X_14714_ _05527_ _05651_ _05649_ _05171_ VSS VSS VDD VDD _05652_
+ sky130_fd_sc_hd__a31oi_1
X_14715_ samples_real\[5\]\[13\] _04755_ VSS VSS VDD VDD _05653_
+ sky130_fd_sc_hd__nand2_1
X_14716_ _04757_ _05652_ _05653_ VSS VSS VDD VDD _00504_ sky130_fd_sc_hd__o21ai_1
X_14717_ _04672_ _05177_ VSS VSS VDD VDD _05654_ sky130_fd_sc_hd__nand2_1
X_14718_ samples_real\[5\]\[14\] _05634_ VSS VSS VDD VDD _05655_
+ sky130_fd_sc_hd__nand2_1
X_14719_ _05633_ _05178_ _05655_ _04680_ VSS VSS VDD VDD _05656_
+ sky130_fd_sc_hd__o211ai_2
X_14720_ _05527_ _05654_ _05656_ _05185_ VSS VSS VDD VDD _05657_
+ sky130_fd_sc_hd__a31oi_1
X_14721_ samples_real\[5\]\[14\] _04755_ VSS VSS VDD VDD _05658_
+ sky130_fd_sc_hd__nand2_1
X_14722_ _04757_ _05657_ _05658_ VSS VSS VDD VDD _00505_ sky130_fd_sc_hd__o21ai_1
X_14723_ samples_real\[5\]\[15\] _03773_ VSS VSS VDD VDD _05659_
+ sky130_fd_sc_hd__nand2_1
X_14724_ _04720_ _05188_ _05659_ _04679_ VSS VSS VDD VDD _05660_
+ sky130_fd_sc_hd__o211ai_1
X_14725_ _04679_ net593 _05660_ VSS VSS VDD VDD _05661_ sky130_fd_sc_hd__o21ai_0
X_14726_ _04029_ _05661_ _05192_ _04670_ VSS VSS VDD VDD _05662_
+ sky130_fd_sc_hd__a211oi_1
X_14727_ samples_real\[5\]\[15\] _04670_ _05662_ VSS VSS VDD
+ VDD _00506_ sky130_fd_sc_hd__a21o_1
X_14728_ _04720_ _05194_ VSS VSS VDD VDD _05663_ sky130_fd_sc_hd__nor2_2
X_14729_ samples_real\[5\]\[1\] _04674_ _05663_ VSS VSS VDD
+ VDD _05664_ sky130_fd_sc_hd__a21oi_1
X_14730_ _03346_ _05198_ VSS VSS VDD VDD _05665_ sky130_fd_sc_hd__nand2_1
X_14731_ _05664_ _04689_ _05665_ VSS VSS VDD VDD _05666_ sky130_fd_sc_hd__o21ai_1
X_14732_ _05666_ _05596_ _05202_ VSS VSS VDD VDD _05667_ sky130_fd_sc_hd__a21oi_1
X_14733_ samples_real\[5\]\[1\] _04683_ VSS VSS VDD VDD _05668_
+ sky130_fd_sc_hd__nand2_1
X_14734_ _04757_ _05667_ _05668_ VSS VSS VDD VDD _00507_ sky130_fd_sc_hd__o21ai_1
X_14735_ _04672_ _05206_ VSS VSS VDD VDD _05669_ sky130_fd_sc_hd__nand2_1
X_14736_ samples_real\[5\]\[2\] _05634_ VSS VSS VDD VDD _05670_
+ sky130_fd_sc_hd__nand2_1
X_14737_ _05633_ _05207_ _05670_ _04680_ VSS VSS VDD VDD _05671_
+ sky130_fd_sc_hd__o211ai_2
X_14738_ _05527_ _05671_ _05669_ _05213_ VSS VSS VDD VDD _05672_
+ sky130_fd_sc_hd__a31oi_1
X_14739_ samples_real\[5\]\[2\] _04683_ VSS VSS VDD VDD _05673_
+ sky130_fd_sc_hd__nand2_1
X_14740_ _04719_ _05672_ _05673_ VSS VSS VDD VDD _00508_ sky130_fd_sc_hd__o21ai_1
X_14741_ _04672_ _05218_ VSS VSS VDD VDD _05674_ sky130_fd_sc_hd__nand2_2
X_14742_ samples_real\[5\]\[3\] _05634_ VSS VSS VDD VDD _05675_
+ sky130_fd_sc_hd__nand2_1
X_14743_ _05633_ net619 _05675_ _04680_ VSS VSS VDD VDD _05676_
+ sky130_fd_sc_hd__o211ai_2
X_14744_ _05527_ _05674_ _05676_ _05226_ VSS VSS VDD VDD _05677_
+ sky130_fd_sc_hd__a31oi_1
X_14745_ samples_real\[5\]\[3\] _04683_ VSS VSS VDD VDD _05678_
+ sky130_fd_sc_hd__nand2_1
X_14746_ _04719_ _05677_ _05678_ VSS VSS VDD VDD _00509_ sky130_fd_sc_hd__o21ai_1
X_14747_ _04236_ VSS VSS VDD VDD _05679_ sky130_fd_sc_hd__clkbuf_4
X_14748_ _04672_ _05230_ VSS VSS VDD VDD _05680_ sky130_fd_sc_hd__nand2_1
X_14749_ samples_real\[5\]\[4\] _04673_ VSS VSS VDD VDD _05681_
+ sky130_fd_sc_hd__nand2_1
X_14750_ _05633_ _05231_ _05681_ _04680_ VSS VSS VDD VDD _05682_
+ sky130_fd_sc_hd__o211ai_1
X_14751_ _05679_ _05682_ _05680_ _05237_ VSS VSS VDD VDD _05683_
+ sky130_fd_sc_hd__a31oi_1
X_14752_ samples_real\[5\]\[4\] _04683_ VSS VSS VDD VDD _05684_
+ sky130_fd_sc_hd__nand2_1
X_14753_ _04719_ _05683_ _05684_ VSS VSS VDD VDD _00510_ sky130_fd_sc_hd__o21ai_0
X_14754_ _04686_ _05241_ VSS VSS VDD VDD _05685_ sky130_fd_sc_hd__nand2_1
X_14755_ samples_real\[5\]\[5\] _04673_ VSS VSS VDD VDD _05686_
+ sky130_fd_sc_hd__nand2_1
X_14756_ _05633_ _05242_ _05686_ _04679_ VSS VSS VDD VDD _05687_
+ sky130_fd_sc_hd__o211ai_1
X_14757_ _05679_ _05685_ _05687_ _05249_ VSS VSS VDD VDD _05688_
+ sky130_fd_sc_hd__a31oi_1
X_14758_ samples_real\[5\]\[5\] _04683_ VSS VSS VDD VDD _05689_
+ sky130_fd_sc_hd__nand2_1
X_14759_ _04719_ _05688_ _05689_ VSS VSS VDD VDD _00511_ sky130_fd_sc_hd__o21ai_0
X_14760_ _04686_ _05253_ VSS VSS VDD VDD _05690_ sky130_fd_sc_hd__nand2_1
X_14761_ samples_real\[5\]\[6\] _04673_ VSS VSS VDD VDD _05691_
+ sky130_fd_sc_hd__nand2_1
X_14762_ _05633_ _05254_ _05691_ _04679_ VSS VSS VDD VDD _05692_
+ sky130_fd_sc_hd__o211ai_1
X_14763_ _05679_ _05690_ _05692_ _05261_ VSS VSS VDD VDD _05693_
+ sky130_fd_sc_hd__a31oi_1
X_14764_ samples_real\[5\]\[6\] _04683_ VSS VSS VDD VDD _05694_
+ sky130_fd_sc_hd__nand2_1
X_14765_ _04719_ _05693_ _05694_ VSS VSS VDD VDD _00512_ sky130_fd_sc_hd__o21ai_0
X_14766_ _04686_ _05265_ VSS VSS VDD VDD _05695_ sky130_fd_sc_hd__nand2_1
X_14767_ samples_real\[5\]\[7\] _04673_ VSS VSS VDD VDD _05696_
+ sky130_fd_sc_hd__nand2_1
X_14768_ _05634_ _05266_ _05696_ _04679_ VSS VSS VDD VDD _05697_
+ sky130_fd_sc_hd__o211ai_2
X_14769_ _05695_ _05697_ _05679_ _05272_ VSS VSS VDD VDD _05698_
+ sky130_fd_sc_hd__a31oi_1
X_14770_ samples_real\[5\]\[7\] _04683_ VSS VSS VDD VDD _05699_
+ sky130_fd_sc_hd__nand2_1
X_14771_ _04719_ _05698_ _05699_ VSS VSS VDD VDD _00513_ sky130_fd_sc_hd__o21ai_1
X_14772_ _04686_ _05276_ VSS VSS VDD VDD _05700_ sky130_fd_sc_hd__nand2_1
X_14773_ samples_real\[5\]\[8\] _04673_ VSS VSS VDD VDD _05701_
+ sky130_fd_sc_hd__nand2_1
X_14774_ _05277_ _05634_ _05701_ _04679_ VSS VSS VDD VDD _05702_
+ sky130_fd_sc_hd__o211ai_2
X_14775_ _05679_ _05700_ _05702_ _05283_ VSS VSS VDD VDD _05703_
+ sky130_fd_sc_hd__a31oi_1
X_14776_ samples_real\[5\]\[8\] _04683_ VSS VSS VDD VDD _05704_
+ sky130_fd_sc_hd__nand2_1
X_14777_ _04719_ _05703_ _05704_ VSS VSS VDD VDD _00514_ sky130_fd_sc_hd__o21ai_1
X_14778_ _04686_ _05287_ VSS VSS VDD VDD _05705_ sky130_fd_sc_hd__nand2_1
X_14779_ samples_real\[5\]\[9\] _04673_ VSS VSS VDD VDD _05706_
+ sky130_fd_sc_hd__nand2_1
X_14780_ _05634_ _05288_ _05706_ _04679_ VSS VSS VDD VDD _05707_
+ sky130_fd_sc_hd__o211ai_2
X_14781_ _05679_ _05707_ _05705_ _05294_ VSS VSS VDD VDD _05708_
+ sky130_fd_sc_hd__a31oi_1
X_14782_ samples_real\[5\]\[9\] _04683_ VSS VSS VDD VDD _05709_
+ sky130_fd_sc_hd__nand2_1
X_14783_ _04719_ _05708_ _05709_ VSS VSS VDD VDD _00515_ sky130_fd_sc_hd__o21ai_1
X_14784_ samples_real\[6\]\[0\] _04797_ _05107_ _04787_ VSS
+ VSS VDD VDD _05710_ sky130_fd_sc_hd__a22oi_2
X_14785_ _04791_ _05041_ _04795_ _05710_ VSS VSS VDD VDD _05711_
+ sky130_fd_sc_hd__o22ai_1
X_14786_ _04784_ _05113_ VSS VSS VDD VDD _05712_ sky130_fd_sc_hd__nor2_1
X_14787_ samples_real\[6\]\[0\] _04784_ _05711_ _04088_ _05712_
+ VSS VSS VDD VDD _00516_ sky130_fd_sc_hd__a221o_1
X_14788_ _03676_ VSS VSS VDD VDD _05713_ sky130_fd_sc_hd__clkbuf_4
X_14789_ _05713_ _05125_ VSS VSS VDD VDD _05714_ sky130_fd_sc_hd__nand2_2
X_14790_ _04785_ VSS VSS VDD VDD _05715_ sky130_fd_sc_hd__buf_2
X_14791_ _04785_ VSS VSS VDD VDD _05716_ sky130_fd_sc_hd__clkbuf_4
X_14792_ samples_real\[6\]\[10\] _05716_ VSS VSS VDD VDD _05717_
+ sky130_fd_sc_hd__nand2_1
X_14793_ _04790_ VSS VSS VDD VDD _05718_ sky130_fd_sc_hd__clkbuf_4
X_14794_ _05715_ _05127_ _05717_ _05718_ VSS VSS VDD VDD _05719_
+ sky130_fd_sc_hd__o211ai_2
X_14795_ _05714_ _05719_ _05679_ _05133_ VSS VSS VDD VDD _05720_
+ sky130_fd_sc_hd__a31oi_1
X_14796_ samples_real\[6\]\[10\] _04874_ VSS VSS VDD VDD _05721_
+ sky130_fd_sc_hd__nand2_1
X_14797_ _04882_ _05720_ _05721_ VSS VSS VDD VDD _00517_ sky130_fd_sc_hd__o21ai_1
X_14798_ _05713_ _05138_ VSS VSS VDD VDD _05722_ sky130_fd_sc_hd__nand2_1
X_14799_ samples_real\[6\]\[11\] _05716_ VSS VSS VDD VDD _05723_
+ sky130_fd_sc_hd__nand2_1
X_14800_ _05715_ _05139_ _05723_ _05718_ VSS VSS VDD VDD _05724_
+ sky130_fd_sc_hd__o211ai_2
X_14801_ _05679_ _05724_ _05722_ _05145_ VSS VSS VDD VDD _05725_
+ sky130_fd_sc_hd__a31oi_1
X_14802_ samples_real\[6\]\[11\] _04874_ VSS VSS VDD VDD _05726_
+ sky130_fd_sc_hd__nand2_1
X_14803_ _04882_ _05725_ _05726_ VSS VSS VDD VDD _00518_ sky130_fd_sc_hd__o21ai_1
X_14804_ _05713_ _05151_ VSS VSS VDD VDD _05727_ sky130_fd_sc_hd__nand2_1
X_14805_ samples_real\[6\]\[12\] _05716_ VSS VSS VDD VDD _05728_
+ sky130_fd_sc_hd__nand2_1
X_14806_ _05715_ _05152_ _05728_ _05718_ VSS VSS VDD VDD _05729_
+ sky130_fd_sc_hd__o211ai_2
X_14807_ _05679_ _05729_ _05727_ _05159_ VSS VSS VDD VDD _05730_
+ sky130_fd_sc_hd__a31oi_1
X_14808_ samples_real\[6\]\[12\] _04874_ VSS VSS VDD VDD _05731_
+ sky130_fd_sc_hd__nand2_1
X_14809_ _04882_ _05730_ _05731_ VSS VSS VDD VDD _00519_ sky130_fd_sc_hd__o21ai_1
X_14810_ _05713_ _05163_ VSS VSS VDD VDD _05732_ sky130_fd_sc_hd__nand2_1
X_14811_ samples_real\[6\]\[13\] _05716_ VSS VSS VDD VDD _05733_
+ sky130_fd_sc_hd__nand2_1
X_14812_ _05715_ _05164_ _05733_ _05718_ VSS VSS VDD VDD _05734_
+ sky130_fd_sc_hd__o211ai_2
X_14813_ _05679_ _05734_ _05732_ _05171_ VSS VSS VDD VDD _05735_
+ sky130_fd_sc_hd__a31oi_1
X_14814_ samples_real\[6\]\[13\] _04874_ VSS VSS VDD VDD _05736_
+ sky130_fd_sc_hd__nand2_1
X_14815_ _04882_ _05735_ _05736_ VSS VSS VDD VDD _00520_ sky130_fd_sc_hd__o21ai_1
X_14816_ _05713_ _05177_ VSS VSS VDD VDD _05737_ sky130_fd_sc_hd__nand2_1
X_14817_ samples_real\[6\]\[14\] _05716_ VSS VSS VDD VDD _05738_
+ sky130_fd_sc_hd__nand2_1
X_14818_ _05715_ _05178_ _05738_ _05718_ VSS VSS VDD VDD _05739_
+ sky130_fd_sc_hd__o211ai_1
X_14819_ _05324_ _05737_ _05739_ _05185_ VSS VSS VDD VDD _05740_
+ sky130_fd_sc_hd__a31oi_1
X_14820_ samples_real\[6\]\[14\] _04874_ VSS VSS VDD VDD _05741_
+ sky130_fd_sc_hd__nand2_1
X_14821_ _04882_ _05740_ _05741_ VSS VSS VDD VDD _00521_ sky130_fd_sc_hd__o21ai_0
X_14822_ samples_real\[6\]\[15\] _04785_ VSS VSS VDD VDD _05742_
+ sky130_fd_sc_hd__nand2_1
X_14823_ _04786_ _05188_ _05742_ _04790_ VSS VSS VDD VDD _05743_
+ sky130_fd_sc_hd__o211ai_1
X_14824_ _04790_ net593 _05743_ VSS VSS VDD VDD _05744_ sky130_fd_sc_hd__o21ai_0
X_14825_ _04029_ _05744_ _05192_ _04833_ VSS VSS VDD VDD _05745_
+ sky130_fd_sc_hd__a211oi_1
X_14826_ samples_real\[6\]\[15\] _04833_ _05745_ VSS VSS VDD
+ VDD _00522_ sky130_fd_sc_hd__a21o_1
X_14827_ _05194_ _04786_ VSS VSS VDD VDD _05746_ sky130_fd_sc_hd__nor2_4
X_14828_ samples_real\[6\]\[1\] _04797_ _05746_ VSS VSS VDD
+ VDD _05747_ sky130_fd_sc_hd__a21oi_2
X_14829_ _03676_ _05198_ VSS VSS VDD VDD _05748_ sky130_fd_sc_hd__nand2_1
X_14830_ _04800_ _05747_ _05748_ VSS VSS VDD VDD _05749_ sky130_fd_sc_hd__o21ai_2
X_14831_ _05596_ _05749_ _05202_ VSS VSS VDD VDD _05750_ sky130_fd_sc_hd__a21oi_1
X_14832_ samples_real\[6\]\[1\] _04874_ VSS VSS VDD VDD _05751_
+ sky130_fd_sc_hd__nand2_1
X_14833_ _04882_ _05750_ _05751_ VSS VSS VDD VDD _00523_ sky130_fd_sc_hd__o21ai_1
X_14834_ _05713_ _05206_ VSS VSS VDD VDD _05752_ sky130_fd_sc_hd__nand2_1
X_14835_ samples_real\[6\]\[2\] _05716_ VSS VSS VDD VDD _05753_
+ sky130_fd_sc_hd__nand2_1
X_14836_ _05715_ _05207_ _05753_ _05718_ VSS VSS VDD VDD _05754_
+ sky130_fd_sc_hd__o211ai_2
X_14837_ _05324_ _05754_ _05752_ _05213_ VSS VSS VDD VDD _05755_
+ sky130_fd_sc_hd__a31oi_1
X_14838_ samples_real\[6\]\[2\] _04794_ VSS VSS VDD VDD _05756_
+ sky130_fd_sc_hd__nand2_1
X_14839_ _05755_ _04882_ _05756_ VSS VSS VDD VDD _00524_ sky130_fd_sc_hd__o21ai_1
X_14840_ _05713_ _05218_ VSS VSS VDD VDD _05757_ sky130_fd_sc_hd__nand2_1
X_14841_ samples_real\[6\]\[3\] _05716_ VSS VSS VDD VDD _05758_
+ sky130_fd_sc_hd__nand2_1
X_14842_ _05715_ net619 _05758_ _05718_ VSS VSS VDD VDD _05759_
+ sky130_fd_sc_hd__o211ai_2
X_14843_ _05324_ _05759_ _05757_ _05226_ VSS VSS VDD VDD _05760_
+ sky130_fd_sc_hd__a31oi_1
X_14844_ samples_real\[6\]\[3\] _04794_ VSS VSS VDD VDD _05761_
+ sky130_fd_sc_hd__nand2_1
X_14845_ _05760_ _04882_ _05761_ VSS VSS VDD VDD _00525_ sky130_fd_sc_hd__o21ai_1
X_14846_ _05713_ _05230_ VSS VSS VDD VDD _05762_ sky130_fd_sc_hd__nand2_1
X_14847_ samples_real\[6\]\[4\] _04796_ VSS VSS VDD VDD _05763_
+ sky130_fd_sc_hd__nand2_1
X_14848_ _05715_ _05231_ _05763_ _05718_ VSS VSS VDD VDD _05764_
+ sky130_fd_sc_hd__o211ai_1
X_14849_ _05324_ _05764_ _05762_ _05237_ VSS VSS VDD VDD _05765_
+ sky130_fd_sc_hd__a31oi_1
X_14850_ samples_real\[6\]\[4\] _04794_ VSS VSS VDD VDD _05766_
+ sky130_fd_sc_hd__nand2_1
X_14851_ _05765_ _04833_ _05766_ VSS VSS VDD VDD _00526_ sky130_fd_sc_hd__o21ai_0
X_14852_ _05713_ _05241_ VSS VSS VDD VDD _05767_ sky130_fd_sc_hd__nand2_1
X_14853_ samples_real\[6\]\[5\] _04796_ VSS VSS VDD VDD _05768_
+ sky130_fd_sc_hd__nand2_1
X_14854_ _05715_ _05242_ _05768_ _05718_ VSS VSS VDD VDD _05769_
+ sky130_fd_sc_hd__o211ai_1
X_14855_ _05324_ _05767_ _05769_ _05249_ VSS VSS VDD VDD _05770_
+ sky130_fd_sc_hd__a31oi_1
X_14856_ samples_real\[6\]\[5\] _04794_ VSS VSS VDD VDD _05771_
+ sky130_fd_sc_hd__nand2_1
X_14857_ _04833_ _05770_ _05771_ VSS VSS VDD VDD _00527_ sky130_fd_sc_hd__o21ai_0
X_14858_ _05713_ _05253_ VSS VSS VDD VDD _05772_ sky130_fd_sc_hd__nand2_1
X_14859_ samples_real\[6\]\[6\] _04796_ VSS VSS VDD VDD _05773_
+ sky130_fd_sc_hd__nand2_1
X_14860_ _05715_ _05254_ _05773_ _05718_ VSS VSS VDD VDD _05774_
+ sky130_fd_sc_hd__o211ai_1
X_14861_ _05324_ _05772_ _05774_ _05261_ VSS VSS VDD VDD _05775_
+ sky130_fd_sc_hd__a31oi_1
X_14862_ samples_real\[6\]\[6\] _04794_ VSS VSS VDD VDD _05776_
+ sky130_fd_sc_hd__nand2_1
X_14863_ _04833_ _05775_ _05776_ VSS VSS VDD VDD _00528_ sky130_fd_sc_hd__o21ai_0
X_14864_ _05265_ _04795_ VSS VSS VDD VDD _05777_ sky130_fd_sc_hd__nand2_2
X_14865_ samples_real\[6\]\[7\] _04796_ VSS VSS VDD VDD _05778_
+ sky130_fd_sc_hd__nand2_1
X_14866_ _05716_ _05266_ _05778_ _04790_ VSS VSS VDD VDD _05779_
+ sky130_fd_sc_hd__o211ai_2
X_14867_ _05777_ _05779_ _05324_ _05272_ VSS VSS VDD VDD _05780_
+ sky130_fd_sc_hd__a31oi_1
X_14868_ samples_real\[6\]\[7\] _04794_ VSS VSS VDD VDD _05781_
+ sky130_fd_sc_hd__nand2_1
X_14869_ _04833_ _05780_ _05781_ VSS VSS VDD VDD _00529_ sky130_fd_sc_hd__o21ai_2
X_14870_ _04795_ _05276_ VSS VSS VDD VDD _05782_ sky130_fd_sc_hd__nand2_1
X_14871_ samples_real\[6\]\[8\] _04796_ VSS VSS VDD VDD _05783_
+ sky130_fd_sc_hd__nand2_1
X_14872_ _05277_ _05716_ _05783_ _04790_ VSS VSS VDD VDD _05784_
+ sky130_fd_sc_hd__o211ai_2
X_14873_ _05324_ _05782_ _05784_ _05283_ VSS VSS VDD VDD _05785_
+ sky130_fd_sc_hd__a31oi_1
X_14874_ samples_real\[6\]\[8\] _04794_ VSS VSS VDD VDD _05786_
+ sky130_fd_sc_hd__nand2_1
X_14875_ _04833_ _05785_ _05786_ VSS VSS VDD VDD _00530_ sky130_fd_sc_hd__o21ai_1
X_14876_ _04795_ _05287_ VSS VSS VDD VDD _05787_ sky130_fd_sc_hd__nand2_1
X_14877_ samples_real\[6\]\[9\] _04796_ VSS VSS VDD VDD _05788_
+ sky130_fd_sc_hd__nand2_1
X_14878_ _05716_ _05288_ _05788_ _04790_ VSS VSS VDD VDD _05789_
+ sky130_fd_sc_hd__o211ai_2
X_14879_ _05324_ _05789_ _05787_ _05294_ VSS VSS VDD VDD _05790_
+ sky130_fd_sc_hd__a31oi_1
X_14880_ samples_real\[6\]\[9\] _04794_ VSS VSS VDD VDD _05791_
+ sky130_fd_sc_hd__nand2_1
X_14881_ _04833_ _05790_ _05791_ VSS VSS VDD VDD _00531_ sky130_fd_sc_hd__o21ai_1
X_14882_ samples_real\[7\]\[0\] _04901_ _05107_ _04902_ VSS
+ VSS VDD VDD _05792_ sky130_fd_sc_hd__a22oi_1
X_14883_ _04909_ VSS VSS VDD VDD _05793_ sky130_fd_sc_hd__buf_2
X_14884_ _04905_ _05041_ _05793_ _05792_ VSS VSS VDD VDD _05794_
+ sky130_fd_sc_hd__o22ai_1
X_14885_ _04898_ _05113_ VSS VSS VDD VDD _05795_ sky130_fd_sc_hd__nor2_1
X_14886_ samples_real\[7\]\[0\] _04898_ _05794_ _04088_ _05795_
+ VSS VSS VDD VDD _00532_ sky130_fd_sc_hd__a221o_1
X_14887_ _04949_ _05127_ VSS VSS VDD VDD _05796_ sky130_fd_sc_hd__nor2_4
X_14888_ samples_real\[7\]\[10\] _04984_ _04899_ _05796_ VSS
+ VSS VDD VDD _05797_ sky130_fd_sc_hd__a211oi_1
X_14889_ _05793_ _05125_ _05797_ VSS VSS VDD VDD _05798_ sky130_fd_sc_hd__a21oi_1
X_14890_ _05798_ _05596_ _05133_ VSS VSS VDD VDD _05799_ sky130_fd_sc_hd__a21oi_1
X_14891_ samples_real\[7\]\[10\] _04990_ VSS VSS VDD VDD _05800_
+ sky130_fd_sc_hd__nand2_1
X_14892_ _04999_ _05799_ _05800_ VSS VSS VDD VDD _00533_ sky130_fd_sc_hd__o21ai_1
X_14893_ _04949_ _05139_ VSS VSS VDD VDD _05801_ sky130_fd_sc_hd__nor2_4
X_14894_ samples_real\[7\]\[11\] _04984_ _04899_ _05801_ VSS
+ VSS VDD VDD _05802_ sky130_fd_sc_hd__a211oi_2
X_14895_ _05793_ _05138_ _05802_ VSS VSS VDD VDD _05803_ sky130_fd_sc_hd__a21oi_1
X_14896_ _05803_ _05596_ _05145_ VSS VSS VDD VDD _05804_ sky130_fd_sc_hd__a21oi_1
X_14897_ samples_real\[7\]\[11\] _04990_ VSS VSS VDD VDD _05805_
+ sky130_fd_sc_hd__nand2_1
X_14898_ _04999_ _05804_ _05805_ VSS VSS VDD VDD _00534_ sky130_fd_sc_hd__o21ai_1
X_14899_ _04236_ VSS VSS VDD VDD _05806_ sky130_fd_sc_hd__clkbuf_4
X_14900_ _04949_ _05152_ VSS VSS VDD VDD _05807_ sky130_fd_sc_hd__nor2_2
X_14901_ samples_real\[7\]\[12\] _04984_ _04899_ _05807_ VSS
+ VSS VDD VDD _05808_ sky130_fd_sc_hd__a211oi_1
X_14902_ _05793_ _05151_ _05808_ VSS VSS VDD VDD _05809_ sky130_fd_sc_hd__a21oi_1
X_14903_ _05806_ _05809_ _05159_ VSS VSS VDD VDD _05810_ sky130_fd_sc_hd__a21oi_1
X_14904_ samples_real\[7\]\[12\] _04990_ VSS VSS VDD VDD _05811_
+ sky130_fd_sc_hd__nand2_1
X_14905_ _04999_ _05810_ _05811_ VSS VSS VDD VDD _00535_ sky130_fd_sc_hd__o21ai_1
X_14906_ _04900_ VSS VSS VDD VDD _05812_ sky130_fd_sc_hd__clkbuf_4
X_14907_ _05164_ _05812_ VSS VSS VDD VDD _05813_ sky130_fd_sc_hd__nor2_4
X_14908_ samples_real\[7\]\[13\] _04984_ _04899_ _05813_ VSS
+ VSS VDD VDD _05814_ sky130_fd_sc_hd__a211oi_2
X_14909_ _05793_ _05163_ _05814_ VSS VSS VDD VDD _05815_ sky130_fd_sc_hd__a21oi_2
X_14910_ _05815_ _05806_ _05171_ VSS VSS VDD VDD _05816_ sky130_fd_sc_hd__a21oi_1
X_14911_ samples_real\[7\]\[13\] _04990_ VSS VSS VDD VDD _05817_
+ sky130_fd_sc_hd__nand2_1
X_14912_ _04999_ _05816_ _05817_ VSS VSS VDD VDD _00536_ sky130_fd_sc_hd__o21ai_1
X_14913_ _05812_ _05178_ VSS VSS VDD VDD _05818_ sky130_fd_sc_hd__nor2_4
X_14914_ samples_real\[7\]\[14\] _04984_ _04899_ _05818_ VSS
+ VSS VDD VDD _05819_ sky130_fd_sc_hd__a211oi_2
X_14915_ _05793_ _05177_ _05819_ VSS VSS VDD VDD _05820_ sky130_fd_sc_hd__a21oi_1
X_14916_ _05806_ _05820_ _05185_ VSS VSS VDD VDD _05821_ sky130_fd_sc_hd__a21oi_1
X_14917_ samples_real\[7\]\[14\] _04990_ VSS VSS VDD VDD _05822_
+ sky130_fd_sc_hd__nand2_1
X_14918_ _04999_ _05821_ _05822_ VSS VSS VDD VDD _00537_ sky130_fd_sc_hd__o21ai_1
X_14919_ samples_real\[7\]\[15\] _04900_ VSS VSS VDD VDD _05823_
+ sky130_fd_sc_hd__nand2_1
X_14920_ _04949_ _05188_ _05823_ _04904_ VSS VSS VDD VDD _05824_
+ sky130_fd_sc_hd__o211ai_1
X_14921_ _04904_ net52 _05824_ VSS VSS VDD VDD _05825_ sky130_fd_sc_hd__o21ai_0
X_14922_ _04029_ _05825_ _05192_ _04948_ VSS VSS VDD VDD _05826_
+ sky130_fd_sc_hd__a211oi_1
X_14923_ samples_real\[7\]\[15\] _04948_ _05826_ VSS VSS VDD
+ VDD _00538_ sky130_fd_sc_hd__a21o_1
X_14924_ _05194_ _04949_ VSS VSS VDD VDD _05827_ sky130_fd_sc_hd__nor2_4
X_14925_ samples_real\[7\]\[1\] _04984_ _05827_ VSS VSS VDD
+ VDD _05828_ sky130_fd_sc_hd__a21oi_1
X_14926_ _04899_ _05198_ VSS VSS VDD VDD _05829_ sky130_fd_sc_hd__nand2_1
X_14927_ _04915_ _05828_ _05829_ VSS VSS VDD VDD _05830_ sky130_fd_sc_hd__o21ai_1
X_14928_ _05830_ _05806_ _05202_ VSS VSS VDD VDD _05831_ sky130_fd_sc_hd__a21oi_1
X_14929_ samples_real\[7\]\[1\] _04990_ VSS VSS VDD VDD _05832_
+ sky130_fd_sc_hd__nand2_1
X_14930_ _04999_ _05831_ _05832_ VSS VSS VDD VDD _00539_ sky130_fd_sc_hd__o21ai_1
X_14931_ _05812_ _05207_ VSS VSS VDD VDD _05833_ sky130_fd_sc_hd__nor2_2
X_14932_ samples_real\[7\]\[2\] _04901_ _04909_ _05833_ VSS
+ VSS VDD VDD _05834_ sky130_fd_sc_hd__a211oi_1
X_14933_ _05793_ _05206_ _05834_ VSS VSS VDD VDD _05835_ sky130_fd_sc_hd__a21oi_1
X_14934_ _05806_ _05835_ _05213_ VSS VSS VDD VDD _05836_ sky130_fd_sc_hd__a21oi_1
X_14935_ samples_real\[7\]\[2\] _04908_ VSS VSS VDD VDD _05837_
+ sky130_fd_sc_hd__nand2_1
X_14936_ _04999_ _05836_ _05837_ VSS VSS VDD VDD _00540_ sky130_fd_sc_hd__o21ai_1
X_14937_ _05812_ net619 VSS VSS VDD VDD _05838_ sky130_fd_sc_hd__nor2_4
X_14938_ samples_real\[7\]\[3\] _04901_ _04909_ _05838_ VSS
+ VSS VDD VDD _05839_ sky130_fd_sc_hd__a211oi_2
X_14939_ _05793_ _05218_ _05839_ VSS VSS VDD VDD _05840_ sky130_fd_sc_hd__a21oi_1
X_14940_ _05806_ _05840_ _05226_ VSS VSS VDD VDD _05841_ sky130_fd_sc_hd__a21oi_1
X_14941_ samples_real\[7\]\[3\] _04908_ VSS VSS VDD VDD _05842_
+ sky130_fd_sc_hd__nand2_1
X_14942_ _04999_ _05841_ _05842_ VSS VSS VDD VDD _00541_ sky130_fd_sc_hd__o21ai_1
X_14943_ _05812_ _05231_ VSS VSS VDD VDD _05843_ sky130_fd_sc_hd__nor2_2
X_14944_ samples_real\[7\]\[4\] _04901_ _04909_ _05843_ VSS
+ VSS VDD VDD _05844_ sky130_fd_sc_hd__a211oi_1
X_14945_ _05793_ _05230_ _05844_ VSS VSS VDD VDD _05845_ sky130_fd_sc_hd__a21oi_1
X_14946_ _05806_ _05845_ _05237_ VSS VSS VDD VDD _05846_ sky130_fd_sc_hd__a21oi_1
X_14947_ samples_real\[7\]\[4\] _04908_ VSS VSS VDD VDD _05847_
+ sky130_fd_sc_hd__nand2_1
X_14948_ _04948_ _05846_ _05847_ VSS VSS VDD VDD _00542_ sky130_fd_sc_hd__o21ai_1
X_14949_ _05812_ _05242_ VSS VSS VDD VDD _05848_ sky130_fd_sc_hd__nor2_4
X_14950_ samples_real\[7\]\[5\] _04901_ _04909_ _05848_ VSS
+ VSS VDD VDD _05849_ sky130_fd_sc_hd__a211oi_2
X_14951_ _05793_ _05241_ _05849_ VSS VSS VDD VDD _05850_ sky130_fd_sc_hd__a21oi_1
X_14952_ _05806_ _05850_ _05249_ VSS VSS VDD VDD _05851_ sky130_fd_sc_hd__a21oi_1
X_14953_ samples_real\[7\]\[5\] _04908_ VSS VSS VDD VDD _05852_
+ sky130_fd_sc_hd__nand2_1
X_14954_ _04948_ _05851_ _05852_ VSS VSS VDD VDD _00543_ sky130_fd_sc_hd__o21ai_1
X_14955_ _05812_ _05254_ VSS VSS VDD VDD _05853_ sky130_fd_sc_hd__nor2_2
X_14956_ samples_real\[7\]\[6\] _04901_ _04909_ _05853_ VSS
+ VSS VDD VDD _05854_ sky130_fd_sc_hd__a211oi_1
X_14957_ _04910_ _05253_ _05854_ VSS VSS VDD VDD _05855_ sky130_fd_sc_hd__a21oi_1
X_14958_ _05806_ _05855_ _05261_ VSS VSS VDD VDD _05856_ sky130_fd_sc_hd__a21oi_1
X_14959_ samples_real\[7\]\[6\] _04908_ VSS VSS VDD VDD _05857_
+ sky130_fd_sc_hd__nand2_1
X_14960_ _04948_ _05856_ _05857_ VSS VSS VDD VDD _00544_ sky130_fd_sc_hd__o21ai_1
X_14961_ _05266_ _05812_ VSS VSS VDD VDD _05858_ sky130_fd_sc_hd__nor2_4
X_14962_ samples_real\[7\]\[7\] _04901_ _04909_ _05858_ VSS
+ VSS VDD VDD _05859_ sky130_fd_sc_hd__a211oi_1
X_14963_ _04910_ _05265_ _05859_ VSS VSS VDD VDD _05860_ sky130_fd_sc_hd__a21oi_1
X_14964_ _05860_ _05806_ _05272_ VSS VSS VDD VDD _05861_ sky130_fd_sc_hd__a21oi_1
X_14965_ samples_real\[7\]\[7\] _04908_ VSS VSS VDD VDD _05862_
+ sky130_fd_sc_hd__nand2_1
X_14966_ _04948_ _05861_ _05862_ VSS VSS VDD VDD _00545_ sky130_fd_sc_hd__o21ai_1
X_14967_ _05812_ _05277_ VSS VSS VDD VDD _05863_ sky130_fd_sc_hd__nor2_4
X_14968_ samples_real\[7\]\[8\] _04901_ _04909_ _05863_ VSS
+ VSS VDD VDD _05864_ sky130_fd_sc_hd__a211oi_2
X_14969_ _04910_ _05276_ _05864_ VSS VSS VDD VDD _05865_ sky130_fd_sc_hd__a21oi_1
X_14970_ _04237_ _05865_ _05283_ VSS VSS VDD VDD _05866_ sky130_fd_sc_hd__a21oi_1
X_14971_ samples_real\[7\]\[8\] _04908_ VSS VSS VDD VDD _05867_
+ sky130_fd_sc_hd__nand2_1
X_14972_ _04948_ _05866_ _05867_ VSS VSS VDD VDD _00546_ sky130_fd_sc_hd__o21ai_1
X_14973_ _05812_ _05288_ VSS VSS VDD VDD _05868_ sky130_fd_sc_hd__nor2_4
X_14974_ samples_real\[7\]\[9\] _04901_ _04909_ _05868_ VSS
+ VSS VDD VDD _05869_ sky130_fd_sc_hd__a211oi_2
X_14975_ _04910_ _05287_ _05869_ VSS VSS VDD VDD _05870_ sky130_fd_sc_hd__a21oi_1
X_14976_ _04237_ _05870_ _05294_ VSS VSS VDD VDD _05871_ sky130_fd_sc_hd__a21oi_1
X_14977_ samples_real\[7\]\[9\] _04908_ VSS VSS VDD VDD _05872_
+ sky130_fd_sc_hd__nand2_1
X_14978_ _04948_ _05871_ _05872_ VSS VSS VDD VDD _00547_ sky130_fd_sc_hd__o21ai_1
X_14979_ _07819_ _03144_ _03846_ VSS VSS VDD VDD _05873_ sky130_fd_sc_hd__a21boi_2
X_14980_ _04004_ _07803_ _05873_ VSS VSS VDD VDD _05874_ sky130_fd_sc_hd__nand3_1
X_14981_ _07803_ _05873_ _05874_ VSS VSS VDD VDD _00548_ sky130_fd_sc_hd__o21ai_0
X_14982_ _04004_ _07806_ _05873_ VSS VSS VDD VDD _05875_ sky130_fd_sc_hd__nand3_1
X_14983_ _07804_ _05873_ _05875_ VSS VSS VDD VDD _00549_ sky130_fd_sc_hd__o21ai_0
X_14984_ _04004_ _07820_ _05873_ VSS VSS VDD VDD _05876_ sky130_fd_sc_hd__nand3_1
X_14985_ _07817_ _05873_ _05876_ VSS VSS VDD VDD _00550_ sky130_fd_sc_hd__o21ai_0
X_14986_ _00002_ _03192_ VSS VSS VDD VDD _00021_ sky130_fd_sc_hd__nand2b_1
X_14987_ _05882_ _05883_ _05884_ VSS VSS VDD VDD _05885_ _05886_
+ sky130_fd_sc_hd__fa_2
X_14988_ _05882_ net588 _05888_ VSS VSS VDD VDD _05889_ _05890_
+ sky130_fd_sc_hd__fa_2
X_14989_ _05892_ _05893_ _05894_ VSS VSS VDD VDD _05895_ _05896_
+ sky130_fd_sc_hd__fa_1
X_14990_ _05897_ _05898_ _05899_ VSS VSS VDD VDD _05900_ _05901_
+ sky130_fd_sc_hd__fa_2
X_14991_ _05897_ _05902_ _05903_ VSS VSS VDD VDD _05904_ _05905_
+ sky130_fd_sc_hd__fa_2
X_14992_ _05907_ _05880_ _05908_ VSS VSS VDD VDD _05909_ _05910_
+ sky130_fd_sc_hd__fa_1
X_14993_ _05911_ _05912_ _05913_ VSS VSS VDD VDD _05914_ _05915_
+ sky130_fd_sc_hd__fa_1
X_14994_ _05916_ _05917_ _05918_ VSS VSS VDD VDD _05919_ _05920_
+ sky130_fd_sc_hd__fa_1
X_14995_ _05921_ _05922_ _05923_ VSS VSS VDD VDD _05917_ _05924_
+ sky130_fd_sc_hd__fa_1
X_14996_ _05925_ _05926_ _05927_ VSS VSS VDD VDD _05928_ _05929_
+ sky130_fd_sc_hd__fa_1
X_14997_ _05920_ _05930_ _05931_ VSS VSS VDD VDD _05932_ _05933_
+ sky130_fd_sc_hd__fa_1
X_14998_ _05924_ _05934_ _05935_ VSS VSS VDD VDD _05930_ _05936_
+ sky130_fd_sc_hd__fa_1
X_14999_ _05937_ _05938_ _05939_ VSS VSS VDD VDD _05940_ _05941_
+ sky130_fd_sc_hd__fa_1
X_15000_ _05942_ _05943_ _05944_ VSS VSS VDD VDD _05945_ _05946_
+ sky130_fd_sc_hd__fa_1
X_15001_ _05947_ _05948_ _05949_ VSS VSS VDD VDD _05950_ _05951_
+ sky130_fd_sc_hd__fa_1
X_15002_ _05952_ _05953_ _05954_ VSS VSS VDD VDD _05955_ _05956_
+ sky130_fd_sc_hd__fa_1
X_15003_ _05923_ _05957_ _05958_ VSS VSS VDD VDD _05959_ _05960_
+ sky130_fd_sc_hd__fa_1
X_15004_ _05961_ net454 _05963_ VSS VSS VDD VDD _05964_ _05965_
+ sky130_fd_sc_hd__fa_1
X_15005_ _05960_ _05966_ _05965_ VSS VSS VDD VDD _05967_ _05968_
+ sky130_fd_sc_hd__fa_1
X_15006_ _05970_ _05969_ _05933_ VSS VSS VDD VDD _05971_ _05972_
+ sky130_fd_sc_hd__fa_1
X_15007_ _05936_ _05973_ _05974_ VSS VSS VDD VDD _05969_ _05975_
+ sky130_fd_sc_hd__fa_1
X_15008_ _05976_ _05977_ _05978_ VSS VSS VDD VDD _05973_ _05979_
+ sky130_fd_sc_hd__fa_1
X_15009_ _05938_ _05980_ _05981_ VSS VSS VDD VDD _05982_ _05983_
+ sky130_fd_sc_hd__fa_1
X_15010_ _05984_ _05985_ _05986_ VSS VSS VDD VDD _05987_ _05988_
+ sky130_fd_sc_hd__fa_1
X_15011_ _05989_ _05990_ _05991_ VSS VSS VDD VDD _05992_ _05993_
+ sky130_fd_sc_hd__fa_1
X_15012_ _05994_ _05995_ _05996_ VSS VSS VDD VDD _05997_ _05998_
+ sky130_fd_sc_hd__fa_1
X_15013_ _05939_ _05981_ _05999_ VSS VSS VDD VDD _06000_ _06001_
+ sky130_fd_sc_hd__fa_1
X_15014_ _06003_ _06004_ _06005_ VSS VSS VDD VDD _06006_ _06007_
+ sky130_fd_sc_hd__fa_1
X_15015_ _06001_ _06008_ _06007_ VSS VSS VDD VDD _06009_ _06010_
+ sky130_fd_sc_hd__fa_1
X_15016_ _06012_ _06013_ _06014_ VSS VSS VDD VDD _06015_ _06016_
+ sky130_fd_sc_hd__fa_1
X_15017_ _06018_ _06017_ _06019_ VSS VSS VDD VDD _06020_ _06021_
+ sky130_fd_sc_hd__fa_1
X_15018_ _06022_ _06024_ _06023_ VSS VSS VDD VDD _06025_ _06026_
+ sky130_fd_sc_hd__fa_1
X_15019_ _06019_ _06027_ _06028_ VSS VSS VDD VDD _06029_ _06030_
+ sky130_fd_sc_hd__fa_1
X_15020_ _06031_ _06032_ _06033_ VSS VSS VDD VDD _06034_ _06035_
+ sky130_fd_sc_hd__fa_2
X_15021_ _06036_ _06037_ _06026_ VSS VSS VDD VDD _06038_ _06039_
+ sky130_fd_sc_hd__fa_1
X_15022_ _05958_ _06002_ net454 VSS VSS VDD VDD _06011_ _06040_
+ sky130_fd_sc_hd__fa_1
X_15023_ _05963_ net449 _06031_ VSS VSS VDD VDD _06042_ _06043_
+ sky130_fd_sc_hd__fa_1
X_15024_ _06042_ _06030_ _06044_ VSS VSS VDD VDD _06037_ _06045_
+ sky130_fd_sc_hd__fa_1
X_15025_ _06028_ _06046_ _06047_ VSS VSS VDD VDD _06048_ _06049_
+ sky130_fd_sc_hd__fa_1
X_15026_ _06050_ _06051_ _06052_ VSS VSS VDD VDD _06053_ _06054_
+ sky130_fd_sc_hd__fa_1
X_15027_ _06056_ _06055_ _05972_ VSS VSS VDD VDD _06057_ _06058_
+ sky130_fd_sc_hd__fa_1
X_15028_ _05975_ _06059_ _06060_ VSS VSS VDD VDD _06055_ _06061_
+ sky130_fd_sc_hd__fa_1
X_15029_ _05979_ _06062_ _06063_ VSS VSS VDD VDD _06059_ _06064_
+ sky130_fd_sc_hd__fa_1
X_15030_ _06065_ _06066_ _06067_ VSS VSS VDD VDD _06062_ _06068_
+ sky130_fd_sc_hd__fa_1
X_15031_ _06069_ _06070_ _06002_ VSS VSS VDD VDD _06066_ _06071_
+ sky130_fd_sc_hd__fa_1
X_15032_ _06072_ _06073_ _06074_ VSS VSS VDD VDD _06075_ _06076_
+ sky130_fd_sc_hd__fa_1
X_15033_ _06077_ _06078_ _06010_ VSS VSS VDD VDD _06014_ _06079_
+ sky130_fd_sc_hd__fa_1
X_15034_ _05957_ _06080_ _06081_ VSS VSS VDD VDD _06082_ _06083_
+ sky130_fd_sc_hd__fa_1
X_15035_ _06040_ _06084_ _06085_ VSS VSS VDD VDD _06086_ _06087_
+ sky130_fd_sc_hd__fa_1
X_15036_ _06054_ _06088_ _06039_ VSS VSS VDD VDD _06089_ _06090_
+ sky130_fd_sc_hd__fa_1
X_15037_ _06086_ _06092_ _06091_ VSS VSS VDD VDD _06088_ _06093_
+ sky130_fd_sc_hd__fa_1
X_15038_ _06002_ net454 _06095_ VSS VSS VDD VDD _06084_ _06096_
+ sky130_fd_sc_hd__fa_1
X_15039_ _06005_ _06019_ _06027_ VSS VSS VDD VDD _06097_ _06098_
+ sky130_fd_sc_hd__fa_1
X_15040_ _06099_ _06097_ _06100_ VSS VSS VDD VDD _06094_ _06101_
+ sky130_fd_sc_hd__fa_1
X_15041_ _06102_ _06103_ _06090_ VSS VSS VDD VDD _06104_ _06105_
+ sky130_fd_sc_hd__fa_1
X_15042_ _06058_ _06107_ _06108_ VSS VSS VDD VDD _06109_ _06110_
+ sky130_fd_sc_hd__fa_1
X_15043_ _06061_ _06111_ _06112_ VSS VSS VDD VDD _06107_ _06113_
+ sky130_fd_sc_hd__fa_1
X_15044_ _06064_ _06115_ _06075_ VSS VSS VDD VDD _06111_ _06116_
+ sky130_fd_sc_hd__fa_1
X_15045_ _06068_ _06117_ _06118_ VSS VSS VDD VDD _06115_ _06119_
+ sky130_fd_sc_hd__fa_1
X_15046_ _06071_ _06120_ _06121_ VSS VSS VDD VDD _06117_ _06122_
+ sky130_fd_sc_hd__fa_1
X_15047_ _06123_ _06124_ _06125_ VSS VSS VDD VDD _06126_ _06127_
+ sky130_fd_sc_hd__fa_1
X_15048_ _06128_ _06129_ _06130_ VSS VSS VDD VDD _06131_ _06132_
+ sky130_fd_sc_hd__fa_1
X_15049_ _05958_ _06133_ _06134_ VSS VSS VDD VDD _06135_ _06136_
+ sky130_fd_sc_hd__fa_1
X_15050_ _06096_ _06137_ _06098_ VSS VSS VDD VDD _06138_ _06139_
+ sky130_fd_sc_hd__fa_1
X_15051_ _06142_ _06141_ _06093_ VSS VSS VDD VDD _06103_ _06143_
+ sky130_fd_sc_hd__fa_1
X_15052_ _06138_ _06144_ _06145_ VSS VSS VDD VDD _06141_ _06146_
+ sky130_fd_sc_hd__fa_1
X_15053_ _06125_ _06004_ _06017_ VSS VSS VDD VDD _06140_ _06147_
+ sky130_fd_sc_hd__fa_1
X_15054_ _06148_ _06143_ _06149_ VSS VSS VDD VDD _06150_ _06151_
+ sky130_fd_sc_hd__fa_1
X_15055_ _06154_ _06153_ _06110_ VSS VSS VDD VDD _06155_ _06156_
+ sky130_fd_sc_hd__fa_1
X_15056_ _06113_ _06157_ _06158_ VSS VSS VDD VDD _06153_ _06159_
+ sky130_fd_sc_hd__fa_1
X_15057_ _06116_ _06160_ _06161_ VSS VSS VDD VDD _06157_ _06162_
+ sky130_fd_sc_hd__fa_1
X_15058_ _06119_ _06164_ _06165_ VSS VSS VDD VDD _06160_ _06166_
+ sky130_fd_sc_hd__fa_1
X_15059_ _06122_ _06168_ _06169_ VSS VSS VDD VDD _06164_ _06170_
+ sky130_fd_sc_hd__fa_1
X_15060_ _06171_ _06172_ _06173_ VSS VSS VDD VDD _06168_ _06174_
+ sky130_fd_sc_hd__fa_1
X_15061_ _06175_ _06124_ _06004_ VSS VSS VDD VDD _06176_ _06177_
+ sky130_fd_sc_hd__fa_1
X_15062_ _06178_ _06179_ _06180_ VSS VSS VDD VDD _06181_ _06182_
+ sky130_fd_sc_hd__fa_1
X_15063_ _05999_ _06183_ _06184_ VSS VSS VDD VDD _06185_ _06186_
+ sky130_fd_sc_hd__fa_1
X_15064_ _06187_ _06188_ _06035_ VSS VSS VDD VDD _06189_ _06190_
+ sky130_fd_sc_hd__fa_1
X_15065_ _06146_ _06192_ _06193_ VSS VSS VDD VDD _06149_ _06194_
+ sky130_fd_sc_hd__fa_1
X_15066_ _06189_ _06195_ _06196_ VSS VSS VDD VDD _06192_ _06197_
+ sky130_fd_sc_hd__fa_1
X_15067_ _06004_ _06017_ _06027_ VSS VSS VDD VDD _06191_ _06198_
+ sky130_fd_sc_hd__fa_1
X_15068_ _06200_ _06201_ _06202_ VSS VSS VDD VDD _06203_ _06204_
+ sky130_fd_sc_hd__fa_1
X_15069_ _06205_ _06206_ _06207_ VSS VSS VDD VDD _06208_ _06209_
+ sky130_fd_sc_hd__fa_1
X_15070_ _06211_ _06210_ _06156_ VSS VSS VDD VDD _06212_ _06213_
+ sky130_fd_sc_hd__fa_2
X_15071_ _06159_ _06214_ _06215_ VSS VSS VDD VDD _06210_ _06216_
+ sky130_fd_sc_hd__fa_2
X_15072_ _06162_ _06217_ _06218_ VSS VSS VDD VDD _06214_ _06219_
+ sky130_fd_sc_hd__fa_1
X_15073_ _06166_ _06220_ _06221_ VSS VSS VDD VDD _06217_ _06222_
+ sky130_fd_sc_hd__fa_1
X_15074_ _06170_ _06224_ _06225_ VSS VSS VDD VDD _06220_ _06226_
+ sky130_fd_sc_hd__fa_1
X_15075_ _06174_ _06228_ _06229_ VSS VSS VDD VDD _06224_ _06230_
+ sky130_fd_sc_hd__fa_1
X_15076_ _06231_ _06232_ _06233_ VSS VSS VDD VDD _06228_ _06234_
+ sky130_fd_sc_hd__fa_1
X_15077_ _06017_ _06235_ _06175_ VSS VSS VDD VDD _06236_ _06237_
+ sky130_fd_sc_hd__fa_1
X_15078_ _06238_ _06239_ _06240_ VSS VSS VDD VDD _06241_ _06242_
+ sky130_fd_sc_hd__fa_1
X_15079_ net453 _06243_ _06244_ VSS VSS VDD VDD _06245_ _06246_
+ sky130_fd_sc_hd__fa_1
X_15080_ _06247_ _06248_ _06204_ VSS VSS VDD VDD _06249_ _06250_
+ sky130_fd_sc_hd__fa_1
X_15081_ _06251_ _06252_ _06253_ VSS VSS VDD VDD _06207_ _06254_
+ sky130_fd_sc_hd__fa_1
X_15082_ _06199_ net450 _06033_ VSS VSS VDD VDD _06248_ _06255_
+ sky130_fd_sc_hd__fa_1
X_15083_ _06256_ _06254_ _06257_ VSS VSS VDD VDD _06258_ _06259_
+ sky130_fd_sc_hd__fa_1
X_15084_ _06216_ _06260_ _06261_ VSS VSS VDD VDD _06262_ _06263_
+ sky130_fd_sc_hd__fa_1
X_15085_ _06219_ _06264_ _06265_ VSS VSS VDD VDD _06260_ _06266_
+ sky130_fd_sc_hd__fa_1
X_15086_ _06222_ _06267_ _06268_ VSS VSS VDD VDD _06264_ _06269_
+ sky130_fd_sc_hd__fa_1
X_15087_ _06226_ _06270_ _06271_ VSS VSS VDD VDD _06267_ _06272_
+ sky130_fd_sc_hd__fa_1
X_15088_ _06230_ _06274_ _06275_ VSS VSS VDD VDD _06270_ _06276_
+ sky130_fd_sc_hd__fa_1
X_15089_ _06234_ _06278_ _06279_ VSS VSS VDD VDD _06274_ _06280_
+ sky130_fd_sc_hd__fa_1
X_15090_ _06283_ _06282_ _06281_ VSS VSS VDD VDD _06278_ _06284_
+ sky130_fd_sc_hd__fa_1
X_15091_ _06285_ _06286_ _06199_ VSS VSS VDD VDD _06282_ _06287_
+ sky130_fd_sc_hd__fa_1
X_15092_ _06288_ _06289_ _06290_ VSS VSS VDD VDD _06291_ _06292_
+ sky130_fd_sc_hd__fa_1
X_15093_ _06095_ _06293_ _06294_ VSS VSS VDD VDD _06295_ _06296_
+ sky130_fd_sc_hd__fa_1
X_15094_ _06255_ _06297_ _06298_ VSS VSS VDD VDD _06299_ _06300_
+ sky130_fd_sc_hd__fa_1
X_15095_ _06301_ _06302_ _06303_ VSS VSS VDD VDD _06257_ _06304_
+ sky130_fd_sc_hd__fa_1
X_15096_ _06305_ _06306_ _06307_ VSS VSS VDD VDD _06308_ _06309_
+ sky130_fd_sc_hd__fa_1
X_15097_ _06266_ _06311_ _06312_ VSS VSS VDD VDD _06313_ _06314_
+ sky130_fd_sc_hd__fa_1
X_15098_ _06269_ _06315_ _06316_ VSS VSS VDD VDD _06311_ _06317_
+ sky130_fd_sc_hd__fa_1
X_15099_ _06272_ _06318_ _06309_ VSS VSS VDD VDD _06315_ _06319_
+ sky130_fd_sc_hd__fa_1
X_15100_ _06276_ _06320_ _06321_ VSS VSS VDD VDD _06318_ _06322_
+ sky130_fd_sc_hd__fa_1
X_15101_ _06326_ _06325_ _06284_ VSS VSS VDD VDD _06327_ _06328_
+ sky130_fd_sc_hd__fa_1
X_15102_ _06287_ _06330_ _06331_ VSS VSS VDD VDD _06325_ _06332_
+ sky130_fd_sc_hd__fa_1
X_15103_ _06286_ _06333_ _06033_ VSS VSS VDD VDD _06330_ _06334_
+ sky130_fd_sc_hd__fa_1
X_15104_ _06335_ _06337_ _06336_ VSS VSS VDD VDD _06338_ _06339_
+ sky130_fd_sc_hd__fa_1
X_15105_ _06341_ _06340_ net448 VSS VSS VDD VDD _06342_ _06343_
+ sky130_fd_sc_hd__fa_1
X_15106_ _06199_ _06033_ _06202_ VSS VSS VDD VDD _06297_ _06344_
+ sky130_fd_sc_hd__fa_1
X_15107_ _06201_ _06344_ _06345_ VSS VSS VDD VDD _06346_ _06347_
+ sky130_fd_sc_hd__fa_1
X_15108_ _06348_ _06349_ _06350_ VSS VSS VDD VDD _06351_ _06352_
+ sky130_fd_sc_hd__fa_1
X_15109_ _06317_ _06353_ _06354_ VSS VSS VDD VDD _06355_ _06356_
+ sky130_fd_sc_hd__fa_1
X_15110_ _06319_ _06357_ _06358_ VSS VSS VDD VDD _06353_ _06359_
+ sky130_fd_sc_hd__fa_1
X_15111_ _06322_ _06360_ _06352_ VSS VSS VDD VDD _06357_ _06361_
+ sky130_fd_sc_hd__fa_1
X_15112_ _06363_ _06364_ _06365_ VSS VSS VDD VDD _06362_ _06366_
+ sky130_fd_sc_hd__fa_1
X_15113_ _06367_ _06334_ _06368_ VSS VSS VDD VDD _06369_ _06370_
+ sky130_fd_sc_hd__fa_1
X_15114_ _06373_ _06374_ _06375_ VSS VSS VDD VDD _06376_ _06377_
+ sky130_fd_sc_hd__fa_1
X_15115_ _06027_ _06378_ _06379_ VSS VSS VDD VDD _06380_ _06381_
+ sky130_fd_sc_hd__fa_1
X_15116_ _06033_ _06202_ _06382_ VSS VSS VDD VDD _06345_ _06383_
+ sky130_fd_sc_hd__fa_1
X_15117_ _06384_ _06385_ _06386_ VSS VSS VDD VDD _06387_ _06388_
+ sky130_fd_sc_hd__fa_1
X_15118_ _06359_ _06389_ _06390_ VSS VSS VDD VDD _06391_ _06392_
+ sky130_fd_sc_hd__fa_1
X_15119_ _06361_ _06393_ _06394_ VSS VSS VDD VDD _06389_ _06395_
+ sky130_fd_sc_hd__fa_1
X_15120_ _06388_ _06397_ _06396_ VSS VSS VDD VDD _06393_ _06398_
+ sky130_fd_sc_hd__fa_1
X_15121_ _06400_ _06401_ _06402_ VSS VSS VDD VDD _06399_ _06403_
+ sky130_fd_sc_hd__fa_1
X_15122_ _06404_ _06405_ _06406_ VSS VSS VDD VDD _06407_ _06408_
+ sky130_fd_sc_hd__fa_1
X_15123_ _06411_ _06412_ _06413_ VSS VSS VDD VDD _06414_ _06415_
+ sky130_fd_sc_hd__fa_1
X_15124_ _06395_ _06416_ _06417_ VSS VSS VDD VDD _06418_ _06419_
+ sky130_fd_sc_hd__fa_1
X_15125_ _06421_ _06398_ _06420_ VSS VSS VDD VDD _06416_ _06422_
+ sky130_fd_sc_hd__fa_1
X_15126_ _06424_ _06423_ _06415_ VSS VSS VDD VDD _06420_ _06425_
+ sky130_fd_sc_hd__fa_1
X_15127_ _06427_ _06428_ _06429_ VSS VSS VDD VDD _06430_ _06431_
+ sky130_fd_sc_hd__fa_1
X_15128_ _06434_ _06435_ _06436_ VSS VSS VDD VDD _06437_ _06438_
+ sky130_fd_sc_hd__fa_1
X_15129_ _06440_ _06439_ _06422_ VSS VSS VDD VDD _06441_ _06442_
+ sky130_fd_sc_hd__fa_1
X_15130_ _06444_ _06443_ _06425_ VSS VSS VDD VDD _06439_ _06445_
+ sky130_fd_sc_hd__fa_1
X_15131_ _06446_ _06447_ _06448_ VSS VSS VDD VDD _06443_ _06449_
+ sky130_fd_sc_hd__fa_1
X_15132_ _06367_ _06452_ _06453_ VSS VSS VDD VDD _06454_ _06455_
+ sky130_fd_sc_hd__fa_1
X_15133_ _06458_ _06459_ _06460_ VSS VSS VDD VDD _06461_ _06462_
+ sky130_fd_sc_hd__fa_1
X_15134_ _06465_ _06466_ _06467_ VSS VSS VDD VDD _06468_ _06469_
+ sky130_fd_sc_hd__fa_1
X_15135_ _06471_ _06470_ _06445_ VSS VSS VDD VDD _06472_ _06473_
+ sky130_fd_sc_hd__fa_1
X_15136_ _06449_ _06474_ _06475_ VSS VSS VDD VDD _06470_ _06476_
+ sky130_fd_sc_hd__fa_1
X_15137_ _06477_ _06478_ _06479_ VSS VSS VDD VDD _06474_ _06480_
+ sky130_fd_sc_hd__fa_1
X_15138_ _06235_ _06481_ _06482_ VSS VSS VDD VDD _06483_ _06484_
+ sky130_fd_sc_hd__fa_1
X_15139_ _06486_ _06476_ _06485_ VSS VSS VDD VDD _06487_ _06488_
+ sky130_fd_sc_hd__fa_1
X_15140_ _06489_ _06483_ _06480_ VSS VSS VDD VDD _06485_ _06490_
+ sky130_fd_sc_hd__fa_1
X_15141_ _06492_ _06493_ _06494_ VSS VSS VDD VDD _06491_ _06495_
+ sky130_fd_sc_hd__fa_1
X_15142_ _06329_ _06497_ _06498_ VSS VSS VDD VDD _06499_ _06500_
+ sky130_fd_sc_hd__fa_1
X_15143_ _06501_ _06502_ _06503_ VSS VSS VDD VDD _06504_ _06505_
+ sky130_fd_sc_hd__fa_1
X_15144_ _06509_ _06508_ _06490_ VSS VSS VDD VDD _06510_ _06511_
+ sky130_fd_sc_hd__fa_1
X_15145_ _06512_ _06513_ _06514_ VSS VSS VDD VDD _06508_ _06515_
+ sky130_fd_sc_hd__fa_1
X_15146_ _06515_ _06517_ _06518_ VSS VSS VDD VDD _06519_ _06520_
+ sky130_fd_sc_hd__fa_1
X_15147_ _06521_ _06522_ _06523_ VSS VSS VDD VDD _06524_ _06525_
+ sky130_fd_sc_hd__fa_1
X_15148_ _06526_ _06527_ _06528_ VSS VSS VDD VDD _06529_ _06530_
+ sky130_fd_sc_hd__fa_1
X_15149_ _06531_ _06527_ _06532_ VSS VSS VDD VDD _06533_ _06534_
+ sky130_fd_sc_hd__fa_1
X_15150_ _06535_ _06537_ _06536_ VSS VSS VDD VDD _06538_ _06539_
+ sky130_fd_sc_hd__fa_2
X_15151_ _06540_ _06542_ _06541_ VSS VSS VDD VDD _06543_ _06544_
+ sky130_fd_sc_hd__fa_1
X_15152_ _06545_ _06546_ _06547_ VSS VSS VDD VDD _06548_ _06549_
+ sky130_fd_sc_hd__fa_2
X_15153_ _06550_ _06551_ _06552_ VSS VSS VDD VDD _06553_ _06554_
+ sky130_fd_sc_hd__fa_1
X_15154_ _06555_ _06546_ _06547_ VSS VSS VDD VDD _06556_ _06557_
+ sky130_fd_sc_hd__fa_1
X_15155_ _06558_ _06560_ _06559_ VSS VSS VDD VDD _06561_ _06562_
+ sky130_fd_sc_hd__fa_1
X_15156_ _06563_ _06564_ _06565_ VSS VSS VDD VDD _06542_ _06566_
+ sky130_fd_sc_hd__fa_1
X_15157_ _06567_ _06568_ _06569_ VSS VSS VDD VDD _06570_ _06571_
+ sky130_fd_sc_hd__fa_1
X_15158_ _06572_ _06573_ _06557_ VSS VSS VDD VDD _06574_ _06575_
+ sky130_fd_sc_hd__fa_1
X_15159_ _06576_ _06577_ _06551_ VSS VSS VDD VDD _06578_ _06579_
+ sky130_fd_sc_hd__fa_1
X_15160_ _06580_ _06582_ _06581_ VSS VSS VDD VDD _06583_ _06584_
+ sky130_fd_sc_hd__fa_1
X_15161_ _06586_ _06585_ _06548_ VSS VSS VDD VDD _06587_ _06588_
+ sky130_fd_sc_hd__fa_1
X_15162_ _06589_ _06584_ _06590_ VSS VSS VDD VDD _06591_ _06592_
+ sky130_fd_sc_hd__fa_1
X_15163_ _06593_ _06594_ _06571_ VSS VSS VDD VDD _06595_ _06596_
+ sky130_fd_sc_hd__fa_1
X_15164_ _06597_ _06598_ _06599_ VSS VSS VDD VDD _06600_ _06601_
+ sky130_fd_sc_hd__fa_1
X_15165_ _06602_ _06549_ _06603_ VSS VSS VDD VDD _06604_ _06605_
+ sky130_fd_sc_hd__fa_1
X_15166_ _06607_ _06608_ _06577_ VSS VSS VDD VDD _06606_ _06609_
+ sky130_fd_sc_hd__fa_1
X_15167_ _06551_ _06552_ _06610_ VSS VSS VDD VDD _06611_ _06612_
+ sky130_fd_sc_hd__fa_1
X_15168_ _06613_ _06614_ _06605_ VSS VSS VDD VDD _06615_ _06616_
+ sky130_fd_sc_hd__fa_1
X_15169_ _06588_ _06617_ _06618_ VSS VSS VDD VDD _06619_ _06620_
+ sky130_fd_sc_hd__fa_1
X_15170_ _06621_ _06622_ _06623_ VSS VSS VDD VDD _06617_ _06624_
+ sky130_fd_sc_hd__fa_1
X_15171_ _06625_ _06627_ _06626_ VSS VSS VDD VDD _06628_ _06629_
+ sky130_fd_sc_hd__fa_1
X_15172_ _06630_ net466 _06632_ VSS VSS VDD VDD _06633_ _06634_
+ sky130_fd_sc_hd__fa_1
X_15173_ _06636_ _06637_ _06638_ VSS VSS VDD VDD _06639_ _06640_
+ sky130_fd_sc_hd__fa_1
X_15174_ _06641_ _06642_ _06643_ VSS VSS VDD VDD _06644_ _06645_
+ sky130_fd_sc_hd__fa_1
X_15175_ net466 _06648_ _06632_ VSS VSS VDD VDD _06647_ _06649_
+ sky130_fd_sc_hd__fa_1
X_15176_ _06629_ _06650_ _06592_ VSS VSS VDD VDD _06651_ _06652_
+ sky130_fd_sc_hd__fa_1
X_15177_ _06653_ _06654_ _06655_ VSS VSS VDD VDD _06650_ _06656_
+ sky130_fd_sc_hd__fa_1
X_15178_ _06657_ _06658_ _06659_ VSS VSS VDD VDD _06654_ _06660_
+ sky130_fd_sc_hd__fa_1
X_15179_ _06661_ _06662_ _06565_ VSS VSS VDD VDD _06663_ _06664_
+ sky130_fd_sc_hd__fa_1
X_15180_ _06665_ _06666_ _06612_ VSS VSS VDD VDD _06614_ _06667_
+ sky130_fd_sc_hd__fa_1
X_15181_ _06563_ _06564_ _06608_ VSS VSS VDD VDD _06668_ _06669_
+ sky130_fd_sc_hd__fa_1
X_15182_ _06577_ _06551_ _06552_ VSS VSS VDD VDD _06670_ _06671_
+ sky130_fd_sc_hd__fa_1
X_15183_ _06672_ _06667_ _06673_ VSS VSS VDD VDD _06674_ _06675_
+ sky130_fd_sc_hd__fa_1
X_15184_ _06624_ _06676_ _06677_ VSS VSS VDD VDD _06678_ _06679_
+ sky130_fd_sc_hd__fa_1
X_15185_ _06680_ _06681_ _06682_ VSS VSS VDD VDD _06676_ _06683_
+ sky130_fd_sc_hd__fa_2
X_15186_ _06684_ _06685_ _06686_ VSS VSS VDD VDD _06687_ _06688_
+ sky130_fd_sc_hd__fa_1
X_15187_ _06640_ _06689_ _06690_ VSS VSS VDD VDD _06691_ _06692_
+ sky130_fd_sc_hd__fa_1
X_15188_ _06693_ _06649_ _06694_ VSS VSS VDD VDD _06695_ _06696_
+ sky130_fd_sc_hd__fa_1
X_15189_ _06697_ _06698_ _06635_ VSS VSS VDD VDD _06699_ _06700_
+ sky130_fd_sc_hd__fa_1
X_15190_ _06687_ _06692_ _06701_ VSS VSS VDD VDD _06702_ _06703_
+ sky130_fd_sc_hd__fa_1
X_15191_ _06703_ _06704_ _06652_ VSS VSS VDD VDD _06705_ _06706_
+ sky130_fd_sc_hd__fa_1
X_15192_ _06707_ _06656_ _06688_ VSS VSS VDD VDD _06704_ _06708_
+ sky130_fd_sc_hd__fa_2
X_15193_ _06709_ _06710_ _06675_ VSS VSS VDD VDD _06711_ _06712_
+ sky130_fd_sc_hd__fa_1
X_15194_ _06531_ net460 _06532_ VSS VSS VDD VDD _06714_ _06715_
+ sky130_fd_sc_hd__fa_1
X_15195_ _06716_ _06717_ _06671_ VSS VSS VDD VDD _06673_ _06718_
+ sky130_fd_sc_hd__fa_1
X_15196_ _06598_ _06564_ _06599_ VSS VSS VDD VDD _06719_ _06720_
+ sky130_fd_sc_hd__fa_1
X_15197_ _06537_ _06721_ _06722_ VSS VSS VDD VDD _06723_ _06724_
+ sky130_fd_sc_hd__fa_1
X_15198_ _06725_ _06718_ _06726_ VSS VSS VDD VDD _06727_ _06728_
+ sky130_fd_sc_hd__fa_1
X_15199_ net491 _06683_ _06730_ VSS VSS VDD VDD _06731_ _06732_
+ sky130_fd_sc_hd__fa_1
X_15200_ _06723_ _06733_ _06734_ VSS VSS VDD VDD _06730_ _06735_
+ sky130_fd_sc_hd__fa_1
X_15201_ _06736_ _06737_ _06738_ VSS VSS VDD VDD _06739_ _06740_
+ sky130_fd_sc_hd__fa_1
X_15202_ _06741_ _06742_ _06743_ VSS VSS VDD VDD _06701_ _06744_
+ sky130_fd_sc_hd__fa_1
X_15203_ net466 _06745_ _06746_ VSS VSS VDD VDD _06747_ _06748_
+ sky130_fd_sc_hd__fa_1
X_15204_ _06697_ _06698_ _06749_ VSS VSS VDD VDD _06750_ _06751_
+ sky130_fd_sc_hd__fa_1
X_15205_ _06739_ _06744_ _06752_ VSS VSS VDD VDD _06753_ _06754_
+ sky130_fd_sc_hd__fa_1
X_15206_ _06757_ _06755_ _06756_ VSS VSS VDD VDD _06758_ _06759_
+ sky130_fd_sc_hd__fa_1
X_15207_ _06754_ _06761_ _06708_ VSS VSS VDD VDD _06760_ _06762_
+ sky130_fd_sc_hd__fa_1
X_15208_ _06763_ _06764_ _06740_ VSS VSS VDD VDD _06761_ _06765_
+ sky130_fd_sc_hd__fa_1
X_15209_ _06766_ _06767_ _06728_ VSS VSS VDD VDD _06768_ _06769_
+ sky130_fd_sc_hd__fa_1
X_15210_ _06770_ _06771_ _06724_ VSS VSS VDD VDD _06726_ _06772_
+ sky130_fd_sc_hd__fa_1
X_15211_ _06662_ _06599_ _06565_ VSS VSS VDD VDD _06773_ _06774_
+ sky130_fd_sc_hd__fa_1
X_15212_ _06775_ _06537_ _06721_ VSS VSS VDD VDD _06776_ _06777_
+ sky130_fd_sc_hd__fa_1
X_15213_ _06778_ _06735_ _06779_ VSS VSS VDD VDD _06780_ _06781_
+ sky130_fd_sc_hd__fa_1
X_15214_ _06776_ _06782_ _06783_ VSS VSS VDD VDD _06779_ _06784_
+ sky130_fd_sc_hd__fa_1
X_15215_ _06785_ _06781_ _06786_ VSS VSS VDD VDD _06787_ _06788_
+ sky130_fd_sc_hd__fa_1
X_15216_ _06789_ _06790_ _06791_ VSS VSS VDD VDD _06752_ _06792_
+ sky130_fd_sc_hd__fa_1
X_15217_ _06632_ _06793_ _06794_ VSS VSS VDD VDD _06795_ _06796_
+ sky130_fd_sc_hd__fa_1
X_15218_ _06797_ _06697_ _06749_ VSS VSS VDD VDD _06798_ _06799_
+ sky130_fd_sc_hd__fa_1
X_15219_ _06800_ _06792_ _06801_ VSS VSS VDD VDD _06802_ _06803_
+ sky130_fd_sc_hd__fa_1
X_15220_ _06805_ _06759_ _06804_ VSS VSS VDD VDD _06806_ _06807_
+ sky130_fd_sc_hd__fa_2
X_15221_ _06810_ _06809_ _06808_ VSS VSS VDD VDD _06804_ _06811_
+ sky130_fd_sc_hd__fa_1
X_15222_ _06765_ _06813_ _06803_ VSS VSS VDD VDD _06812_ _06814_
+ sky130_fd_sc_hd__fa_1
X_15223_ _06815_ _06816_ _06817_ VSS VSS VDD VDD _06813_ _06818_
+ sky130_fd_sc_hd__fa_1
X_15224_ _06819_ _06820_ _06821_ VSS VSS VDD VDD _06822_ _06823_
+ sky130_fd_sc_hd__fa_1
X_15225_ _06824_ _06825_ _06777_ VSS VSS VDD VDD _06826_ _06827_
+ sky130_fd_sc_hd__fa_1
X_15226_ _06829_ _06597_ _06565_ VSS VSS VDD VDD _06828_ _06830_
+ sky130_fd_sc_hd__fa_1
X_15227_ _06564_ _06599_ _06608_ VSS VSS VDD VDD _06831_ _06832_
+ sky130_fd_sc_hd__fa_1
X_15228_ _06833_ _06784_ _06834_ VSS VSS VDD VDD _06786_ _06835_
+ sky130_fd_sc_hd__fa_1
X_15229_ _06836_ _06837_ _06838_ VSS VSS VDD VDD _06834_ _06839_
+ sky130_fd_sc_hd__fa_1
X_15230_ _06840_ _06841_ _06842_ VSS VSS VDD VDD _06843_ _06844_
+ sky130_fd_sc_hd__fa_1
X_15231_ _06845_ _06846_ _06847_ VSS VSS VDD VDD _06801_ _06848_
+ sky130_fd_sc_hd__fa_1
X_15232_ _06648_ _06849_ _06850_ VSS VSS VDD VDD _06851_ _06852_
+ sky130_fd_sc_hd__fa_1
X_15233_ _06853_ _06797_ _06749_ VSS VSS VDD VDD _06854_ _06855_
+ sky130_fd_sc_hd__fa_1
X_15234_ _06856_ _06857_ _06858_ VSS VSS VDD VDD _06859_ _06860_
+ sky130_fd_sc_hd__fa_1
X_15235_ _06811_ _06861_ _06862_ VSS VSS VDD VDD _06863_ _06864_
+ sky130_fd_sc_hd__fa_1
X_15236_ _06865_ _06866_ _06867_ VSS VSS VDD VDD _06861_ _06868_
+ sky130_fd_sc_hd__fa_1
X_15237_ _06818_ _06870_ _06871_ VSS VSS VDD VDD _06869_ _06872_
+ sky130_fd_sc_hd__fa_1
X_15238_ _06873_ _06874_ _06844_ VSS VSS VDD VDD _06870_ _06875_
+ sky130_fd_sc_hd__fa_1
X_15239_ _06876_ _06877_ _06878_ VSS VSS VDD VDD _06874_ _06879_
+ sky130_fd_sc_hd__fa_1
X_15240_ _06880_ _06881_ _06882_ VSS VSS VDD VDD _06883_ _06884_
+ sky130_fd_sc_hd__fa_1
X_15241_ _06661_ _06597_ _06886_ VSS VSS VDD VDD _06885_ _06887_
+ sky130_fd_sc_hd__fa_1
X_15242_ _06564_ _06599_ _06565_ VSS VSS VDD VDD _06888_ _06889_
+ sky130_fd_sc_hd__fa_1
X_15243_ _06890_ _06891_ _06892_ VSS VSS VDD VDD _06893_ _06894_
+ sky130_fd_sc_hd__fa_1
X_15244_ _06895_ _06896_ _06897_ VSS VSS VDD VDD _06898_ _06899_
+ sky130_fd_sc_hd__fa_1
X_15245_ _06697_ _06855_ _06900_ VSS VSS VDD VDD _06901_ _06902_
+ sky130_fd_sc_hd__fa_1
X_15246_ _06853_ _06903_ _06797_ VSS VSS VDD VDD _06900_ _06904_
+ sky130_fd_sc_hd__fa_1
X_15247_ _06905_ _06906_ _06907_ VSS VSS VDD VDD _06908_ _06909_
+ sky130_fd_sc_hd__fa_1
X_15248_ _06868_ _06910_ _06911_ VSS VSS VDD VDD _06912_ _06913_
+ sky130_fd_sc_hd__fa_1
X_15249_ _06914_ _06915_ _06916_ VSS VSS VDD VDD _06910_ _06917_
+ sky130_fd_sc_hd__fa_1
X_15250_ _06875_ _06919_ _06920_ VSS VSS VDD VDD _06918_ _06921_
+ sky130_fd_sc_hd__fa_1
X_15251_ _06922_ _06923_ _06924_ VSS VSS VDD VDD _06925_ _06926_
+ sky130_fd_sc_hd__fa_1
X_15252_ _06887_ _06927_ _06889_ VSS VSS VDD VDD _06928_ _06929_
+ sky130_fd_sc_hd__fa_1
X_15253_ _06597_ _06599_ _06565_ VSS VSS VDD VDD _06931_ _06932_
+ sky130_fd_sc_hd__fa_1
X_15254_ _06933_ _06934_ _06935_ VSS VSS VDD VDD _06936_ _06937_
+ sky130_fd_sc_hd__fa_1
X_15255_ _06938_ _06939_ _06940_ VSS VSS VDD VDD _06941_ _06942_
+ sky130_fd_sc_hd__fa_1
X_15256_ _06943_ _06944_ _06945_ VSS VSS VDD VDD _06946_ _06947_
+ sky130_fd_sc_hd__fa_1
X_15257_ _06948_ _06853_ _06903_ VSS VSS VDD VDD _06949_ _06950_
+ sky130_fd_sc_hd__fa_1
X_15258_ _06951_ _06952_ _06953_ VSS VSS VDD VDD _06954_ _06955_
+ sky130_fd_sc_hd__fa_1
X_15259_ _06917_ _06956_ _06957_ VSS VSS VDD VDD _06958_ _06959_
+ sky130_fd_sc_hd__fa_1
X_15260_ _06960_ _06961_ _06962_ VSS VSS VDD VDD _06956_ _06963_
+ sky130_fd_sc_hd__fa_1
X_15261_ _06965_ _06966_ _06967_ VSS VSS VDD VDD _06964_ _06968_
+ sky130_fd_sc_hd__fa_1
X_15262_ _06969_ _06970_ _06971_ VSS VSS VDD VDD _06972_ _06973_
+ sky130_fd_sc_hd__fa_1
X_15263_ _06597_ _06661_ _06565_ VSS VSS VDD VDD _06974_ _06975_
+ sky130_fd_sc_hd__fa_1
X_15264_ _06976_ _06977_ _06978_ VSS VSS VDD VDD _06979_ _06980_
+ sky130_fd_sc_hd__fa_1
X_15265_ _06981_ _06982_ _06983_ VSS VSS VDD VDD _06984_ _06985_
+ sky130_fd_sc_hd__fa_1
X_15266_ _06986_ _06987_ _06988_ VSS VSS VDD VDD _06989_ _06990_
+ sky130_fd_sc_hd__fa_1
X_15267_ net488 _06778_ _06991_ VSS VSS VDD VDD _06988_ _06992_
+ sky130_fd_sc_hd__fa_1
X_15268_ _06993_ _06994_ _06995_ VSS VSS VDD VDD _06996_ _06997_
+ sky130_fd_sc_hd__fa_1
X_15269_ _06963_ _06998_ _06999_ VSS VSS VDD VDD _07000_ _07001_
+ sky130_fd_sc_hd__fa_1
X_15270_ _07004_ _07003_ _07002_ VSS VSS VDD VDD _06998_ _07005_
+ sky130_fd_sc_hd__fa_1
X_15271_ _07007_ _07008_ _07009_ VSS VSS VDD VDD _07006_ _07010_
+ sky130_fd_sc_hd__fa_1
X_15272_ _07011_ _07012_ _07013_ VSS VSS VDD VDD _07014_ _07015_
+ sky130_fd_sc_hd__fa_1
X_15273_ _07016_ _07017_ _07018_ VSS VSS VDD VDD _07019_ _07020_
+ sky130_fd_sc_hd__fa_1
X_15274_ _06853_ _07021_ _07022_ VSS VSS VDD VDD _07023_ _07024_
+ sky130_fd_sc_hd__fa_1
X_15275_ net488 _06778_ _06833_ VSS VSS VDD VDD _07025_ _07026_
+ sky130_fd_sc_hd__fa_1
X_15276_ _07027_ _07028_ _07029_ VSS VSS VDD VDD _07030_ _07031_
+ sky130_fd_sc_hd__fa_1
X_15277_ _07005_ _07032_ _07033_ VSS VSS VDD VDD _07034_ _07035_
+ sky130_fd_sc_hd__fa_1
X_15278_ _07038_ _07037_ _07036_ VSS VSS VDD VDD _07032_ _07039_
+ sky130_fd_sc_hd__fa_1
X_15279_ _07015_ _07040_ _07041_ VSS VSS VDD VDD _07037_ _07042_
+ sky130_fd_sc_hd__fa_1
X_15280_ _07043_ _07044_ _07045_ VSS VSS VDD VDD _07040_ _07046_
+ sky130_fd_sc_hd__fa_1
X_15281_ net459 _06526_ _06532_ VSS VSS VDD VDD _07016_ _07047_
+ sky130_fd_sc_hd__fa_1
X_15282_ _06927_ _07048_ _07049_ VSS VSS VDD VDD _07050_ _07051_
+ sky130_fd_sc_hd__fa_1
X_15283_ _07039_ _07052_ _07053_ VSS VSS VDD VDD _07054_ _07055_
+ sky130_fd_sc_hd__fa_1
X_15284_ _07042_ _07056_ _07057_ VSS VSS VDD VDD _07052_ _07058_
+ sky130_fd_sc_hd__fa_1
X_15285_ _07046_ _07059_ _07060_ VSS VSS VDD VDD _07056_ _07061_
+ sky130_fd_sc_hd__fa_1
X_15286_ _07062_ _07063_ _07064_ VSS VSS VDD VDD _07059_ _07065_
+ sky130_fd_sc_hd__fa_1
X_15287_ _06991_ _07066_ _07026_ VSS VSS VDD VDD _07067_ _07068_
+ sky130_fd_sc_hd__fa_1
X_15288_ _07069_ _07070_ _07071_ VSS VSS VDD VDD _07072_ _07073_
+ sky130_fd_sc_hd__fa_1
X_15289_ _07058_ _07074_ _07075_ VSS VSS VDD VDD _07076_ _07077_
+ sky130_fd_sc_hd__fa_1
X_15290_ _07061_ _07078_ _07079_ VSS VSS VDD VDD _07074_ _07080_
+ sky130_fd_sc_hd__fa_1
X_15291_ _07065_ _07081_ _07082_ VSS VSS VDD VDD _07078_ _07083_
+ sky130_fd_sc_hd__fa_1
X_15292_ _07084_ _07085_ _07086_ VSS VSS VDD VDD _07081_ _07087_
+ sky130_fd_sc_hd__fa_1
X_15293_ _07088_ _07083_ _07089_ VSS VSS VDD VDD _07090_ _07091_
+ sky130_fd_sc_hd__fa_1
X_15294_ _07087_ _07092_ _07093_ VSS VSS VDD VDD _07089_ _07094_
+ sky130_fd_sc_hd__fa_1
X_15295_ _07096_ _07097_ _07098_ VSS VSS VDD VDD _07095_ _07099_
+ sky130_fd_sc_hd__fa_1
X_15296_ _07099_ _07100_ _07101_ VSS VSS VDD VDD _07102_ _07103_
+ sky130_fd_sc_hd__fa_1
X_15297_ net385 _07106_ VSS VSS VDD VDD _07107_ _07108_ sky130_fd_sc_hd__ha_4
X_15298_ _05892_ _07109_ VSS VSS VDD VDD _07110_ _07111_ sky130_fd_sc_hd__ha_4
X_15299_ _07113_ _07112_ VSS VSS VDD VDD _07114_ _07115_ sky130_fd_sc_hd__ha_4
X_15300_ _05892_ _07116_ VSS VSS VDD VDD _07117_ _07118_ sky130_fd_sc_hd__ha_1
X_15301_ _07106_ net358 VSS VSS VDD VDD _07119_ _07120_ sky130_fd_sc_hd__ha_1
X_15302_ _07121_ _07122_ VSS VSS VDD VDD _07123_ _07124_ sky130_fd_sc_hd__ha_4
X_15303_ _07112_ _07125_ VSS VSS VDD VDD _07126_ _07127_ sky130_fd_sc_hd__ha_1
X_15304_ _05892_ _07128_ VSS VSS VDD VDD _07129_ _07130_ sky130_fd_sc_hd__ha_1
X_15305_ _07106_ net359 VSS VSS VDD VDD _07131_ _07132_ sky130_fd_sc_hd__ha_1
X_15306_ _07133_ _07134_ VSS VSS VDD VDD _07135_ _07136_ sky130_fd_sc_hd__ha_1
X_15307_ _07121_ _07137_ VSS VSS VDD VDD _07138_ _07139_ sky130_fd_sc_hd__ha_1
X_15308_ _07112_ _07140_ VSS VSS VDD VDD _07141_ _07142_ sky130_fd_sc_hd__ha_4
X_15309_ _05892_ _07143_ VSS VSS VDD VDD _07144_ _07145_ sky130_fd_sc_hd__ha_1
X_15310_ _07106_ net360 VSS VSS VDD VDD _07146_ _07147_ sky130_fd_sc_hd__ha_1
X_15311_ _05892_ _07148_ VSS VSS VDD VDD _07149_ _07150_ sky130_fd_sc_hd__ha_2
X_15312_ _07106_ net361 VSS VSS VDD VDD _07151_ _07152_ sky130_fd_sc_hd__ha_1
X_15313_ _07154_ _07153_ VSS VSS VDD VDD _07155_ _07156_ sky130_fd_sc_hd__ha_2
X_15314_ _07133_ _07157_ VSS VSS VDD VDD _07158_ _07159_ sky130_fd_sc_hd__ha_4
X_15315_ _07121_ _07160_ VSS VSS VDD VDD _07161_ _07162_ sky130_fd_sc_hd__ha_2
X_15316_ _07163_ _07112_ VSS VSS VDD VDD _07164_ _07165_ sky130_fd_sc_hd__ha_4
X_15317_ _07167_ _07166_ VSS VSS VDD VDD _07168_ _07169_ sky130_fd_sc_hd__ha_2
X_15318_ _07153_ _07170_ VSS VSS VDD VDD _07171_ _07172_ sky130_fd_sc_hd__ha_1
X_15319_ _07173_ _07133_ VSS VSS VDD VDD _07174_ _07175_ sky130_fd_sc_hd__ha_4
X_15320_ _07121_ _07176_ VSS VSS VDD VDD _07177_ _07178_ sky130_fd_sc_hd__ha_2
X_15321_ _07112_ _07179_ VSS VSS VDD VDD _07180_ _07181_ sky130_fd_sc_hd__ha_2
X_15322_ _05892_ _07182_ VSS VSS VDD VDD _07183_ _07184_ sky130_fd_sc_hd__ha_1
X_15323_ _07106_ net362 VSS VSS VDD VDD _07185_ _07186_ sky130_fd_sc_hd__ha_2
X_15324_ _07166_ _07187_ VSS VSS VDD VDD _07188_ _07189_ sky130_fd_sc_hd__ha_1
X_15325_ _07153_ _07190_ VSS VSS VDD VDD _07191_ _07192_ sky130_fd_sc_hd__ha_2
X_15326_ _07193_ _07133_ VSS VSS VDD VDD _07194_ _07195_ sky130_fd_sc_hd__ha_4
X_15327_ _07196_ _07121_ VSS VSS VDD VDD _07197_ _07198_ sky130_fd_sc_hd__ha_4
X_15328_ _07112_ _07199_ VSS VSS VDD VDD _07200_ _07201_ sky130_fd_sc_hd__ha_1
X_15329_ _05892_ _07202_ VSS VSS VDD VDD _07203_ _07204_ sky130_fd_sc_hd__ha_1
X_15330_ _07106_ net363 VSS VSS VDD VDD _07205_ _07206_ sky130_fd_sc_hd__ha_2
X_15331_ _07207_ _07208_ VSS VSS VDD VDD _07209_ _07210_ sky130_fd_sc_hd__ha_1
X_15332_ _07166_ _07211_ VSS VSS VDD VDD _07212_ _07213_ sky130_fd_sc_hd__ha_1
X_15333_ _07153_ _07214_ VSS VSS VDD VDD _07215_ _07216_ sky130_fd_sc_hd__ha_1
X_15334_ _07217_ _07133_ VSS VSS VDD VDD _07218_ _07219_ sky130_fd_sc_hd__ha_4
X_15335_ _07121_ _07220_ VSS VSS VDD VDD _07221_ _07222_ sky130_fd_sc_hd__ha_1
X_15336_ _07112_ _07223_ VSS VSS VDD VDD _07224_ _07225_ sky130_fd_sc_hd__ha_1
X_15337_ _05892_ _07226_ VSS VSS VDD VDD _07227_ _07228_ sky130_fd_sc_hd__ha_1
X_15338_ net24 net364 VSS VSS VDD VDD _07229_ _07230_ sky130_fd_sc_hd__ha_1
X_15339_ _07166_ _07231_ VSS VSS VDD VDD _07232_ _07233_ sky130_fd_sc_hd__ha_2
X_15340_ _07153_ _07234_ VSS VSS VDD VDD _07235_ _07236_ sky130_fd_sc_hd__ha_4
X_15341_ _07133_ _07237_ VSS VSS VDD VDD _07238_ _07239_ sky130_fd_sc_hd__ha_1
X_15342_ _07121_ _07240_ VSS VSS VDD VDD _07241_ _07242_ sky130_fd_sc_hd__ha_4
X_15343_ _07112_ _07243_ VSS VSS VDD VDD _07244_ _07245_ sky130_fd_sc_hd__ha_4
X_15344_ _07246_ _05892_ VSS VSS VDD VDD _07247_ _07248_ sky130_fd_sc_hd__ha_4
X_15345_ net24 net365 VSS VSS VDD VDD _07249_ _07250_ sky130_fd_sc_hd__ha_1
X_15346_ _07166_ _07251_ VSS VSS VDD VDD _07252_ _07253_ sky130_fd_sc_hd__ha_2
X_15347_ _07254_ _07153_ VSS VSS VDD VDD _07255_ _07256_ sky130_fd_sc_hd__ha_4
X_15348_ _07257_ _07133_ VSS VSS VDD VDD _07258_ _07259_ sky130_fd_sc_hd__ha_4
X_15349_ _07112_ _07260_ VSS VSS VDD VDD _07261_ _07262_ sky130_fd_sc_hd__ha_1
X_15350_ _05892_ _07263_ VSS VSS VDD VDD _07264_ _07265_ sky130_fd_sc_hd__ha_1
X_15351_ net24 net366 VSS VSS VDD VDD _07266_ _07267_ sky130_fd_sc_hd__ha_1
X_15352_ _07121_ _07268_ VSS VSS VDD VDD _07269_ _07270_ sky130_fd_sc_hd__ha_4
X_15353_ _07166_ _07271_ VSS VSS VDD VDD _07272_ _07273_ sky130_fd_sc_hd__ha_2
X_15354_ _07153_ _07274_ VSS VSS VDD VDD _07275_ _07276_ sky130_fd_sc_hd__ha_1
X_15355_ _07133_ _07277_ VSS VSS VDD VDD _07278_ _07279_ sky130_fd_sc_hd__ha_1
X_15356_ _07121_ _07280_ VSS VSS VDD VDD _07281_ _07282_ sky130_fd_sc_hd__ha_1
X_15357_ _07283_ _07112_ VSS VSS VDD VDD _07284_ _07285_ sky130_fd_sc_hd__ha_1
X_15358_ _05892_ _07286_ VSS VSS VDD VDD _07287_ _07288_ sky130_fd_sc_hd__ha_4
X_15359_ net24 net367 VSS VSS VDD VDD _07289_ _07290_ sky130_fd_sc_hd__ha_1
X_15360_ _07112_ _07291_ VSS VSS VDD VDD _07292_ _07293_ sky130_fd_sc_hd__ha_1
X_15361_ _05892_ _07294_ VSS VSS VDD VDD _07295_ _07296_ sky130_fd_sc_hd__ha_1
X_15362_ _07133_ _07297_ VSS VSS VDD VDD _07298_ _07299_ sky130_fd_sc_hd__ha_1
X_15363_ _07121_ _07300_ VSS VSS VDD VDD _07301_ _07302_ sky130_fd_sc_hd__ha_1
X_15364_ net24 net368 VSS VSS VDD VDD _07303_ _07304_ sky130_fd_sc_hd__ha_1
X_15365_ _07166_ _07305_ VSS VSS VDD VDD _07306_ _07307_ sky130_fd_sc_hd__ha_2
X_15366_ _07153_ _07308_ VSS VSS VDD VDD _07309_ _07310_ sky130_fd_sc_hd__ha_1
X_15367_ _07166_ _07311_ VSS VSS VDD VDD _07312_ _07313_ sky130_fd_sc_hd__ha_1
X_15368_ _07153_ _07314_ VSS VSS VDD VDD _07315_ _07316_ sky130_fd_sc_hd__ha_1
X_15369_ _07133_ _07317_ VSS VSS VDD VDD _07318_ _07319_ sky130_fd_sc_hd__ha_1
X_15370_ _07121_ _07320_ VSS VSS VDD VDD _07321_ _07322_ sky130_fd_sc_hd__ha_1
X_15371_ _07112_ _07323_ VSS VSS VDD VDD _07324_ _07325_ sky130_fd_sc_hd__ha_4
X_15372_ _05892_ _07326_ VSS VSS VDD VDD _07327_ _07328_ sky130_fd_sc_hd__ha_4
X_15373_ net24 net369 VSS VSS VDD VDD _07329_ _07330_ sky130_fd_sc_hd__ha_1
X_15374_ _07166_ _07331_ VSS VSS VDD VDD _07332_ _07333_ sky130_fd_sc_hd__ha_1
X_15375_ _07153_ _07334_ VSS VSS VDD VDD _07335_ _07336_ sky130_fd_sc_hd__ha_1
X_15376_ _07133_ _07337_ VSS VSS VDD VDD _07338_ _07339_ sky130_fd_sc_hd__ha_1
X_15377_ _07121_ _07340_ VSS VSS VDD VDD _07341_ _07342_ sky130_fd_sc_hd__ha_1
X_15378_ _07112_ _07343_ VSS VSS VDD VDD _07344_ _07345_ sky130_fd_sc_hd__ha_1
X_15379_ _07346_ _05892_ VSS VSS VDD VDD _07347_ _07348_ sky130_fd_sc_hd__ha_4
X_15380_ net24 net370 VSS VSS VDD VDD _07349_ _07350_ sky130_fd_sc_hd__ha_1
X_15381_ _07166_ _07351_ VSS VSS VDD VDD _07352_ _07353_ sky130_fd_sc_hd__ha_2
X_15382_ _07153_ _07354_ VSS VSS VDD VDD _07355_ _07356_ sky130_fd_sc_hd__ha_1
X_15383_ _07133_ _07357_ VSS VSS VDD VDD _07358_ _07359_ sky130_fd_sc_hd__ha_1
X_15384_ _07121_ _07360_ VSS VSS VDD VDD _07361_ _07362_ sky130_fd_sc_hd__ha_1
X_15385_ _07363_ _07112_ VSS VSS VDD VDD _07364_ _07365_ sky130_fd_sc_hd__ha_1
X_15386_ _05892_ _07366_ VSS VSS VDD VDD _07367_ _07368_ sky130_fd_sc_hd__ha_4
X_15387_ net24 net371 VSS VSS VDD VDD _07369_ _07370_ sky130_fd_sc_hd__ha_1
X_15388_ net14 net372 VSS VSS VDD VDD _07371_ _07372_ sky130_fd_sc_hd__ha_1
X_15389_ _07166_ _07373_ VSS VSS VDD VDD _07374_ _07375_ sky130_fd_sc_hd__ha_1
X_15390_ _07153_ _07376_ VSS VSS VDD VDD _07377_ _07378_ sky130_fd_sc_hd__ha_1
X_15391_ _07133_ _07379_ VSS VSS VDD VDD _07380_ _07381_ sky130_fd_sc_hd__ha_1
X_15392_ _07121_ _07382_ VSS VSS VDD VDD _07383_ _07384_ sky130_fd_sc_hd__ha_1
X_15393_ _07385_ _07112_ VSS VSS VDD VDD _07386_ _07387_ sky130_fd_sc_hd__ha_1
X_15394_ _05892_ _07388_ VSS VSS VDD VDD _07389_ _07390_ sky130_fd_sc_hd__ha_4
X_15395_ _05892_ _07391_ VSS VSS VDD VDD _07392_ _07393_ sky130_fd_sc_hd__ha_4
X_15396_ net14 net373 VSS VSS VDD VDD _07394_ _07395_ sky130_fd_sc_hd__ha_1
X_15397_ _07166_ _07396_ VSS VSS VDD VDD _07397_ _07398_ sky130_fd_sc_hd__ha_2
X_15398_ _07153_ _07399_ VSS VSS VDD VDD _07400_ _07401_ sky130_fd_sc_hd__ha_1
X_15399_ _07133_ _07402_ VSS VSS VDD VDD _07403_ _07404_ sky130_fd_sc_hd__ha_1
X_15400_ _07121_ _07405_ VSS VSS VDD VDD _07406_ _07407_ sky130_fd_sc_hd__ha_4
X_15401_ _07112_ _07408_ VSS VSS VDD VDD _07409_ _07410_ sky130_fd_sc_hd__ha_1
X_15402_ _07112_ _07411_ VSS VSS VDD VDD _07412_ _07413_ sky130_fd_sc_hd__ha_4
X_15403_ _05892_ _07414_ VSS VSS VDD VDD _07415_ _07416_ sky130_fd_sc_hd__ha_4
X_15404_ net14 net374 VSS VSS VDD VDD _07417_ _07418_ sky130_fd_sc_hd__ha_1
X_15405_ _07166_ _07419_ VSS VSS VDD VDD _07420_ _07421_ sky130_fd_sc_hd__ha_1
X_15406_ _07153_ _07422_ VSS VSS VDD VDD _07423_ _07424_ sky130_fd_sc_hd__ha_1
X_15407_ _07133_ _07425_ VSS VSS VDD VDD _07426_ _07427_ sky130_fd_sc_hd__ha_1
X_15408_ _07121_ _07428_ VSS VSS VDD VDD _07429_ _07430_ sky130_fd_sc_hd__ha_1
X_15409_ _07121_ _07431_ VSS VSS VDD VDD _07432_ _07433_ sky130_fd_sc_hd__ha_1
X_15410_ _07112_ _07434_ VSS VSS VDD VDD _07435_ _07436_ sky130_fd_sc_hd__ha_4
X_15411_ _07437_ _05892_ VSS VSS VDD VDD _07438_ _07439_ sky130_fd_sc_hd__ha_4
X_15412_ net14 net375 VSS VSS VDD VDD _07440_ _07441_ sky130_fd_sc_hd__ha_1
X_15413_ _07166_ _07442_ VSS VSS VDD VDD _07443_ _07444_ sky130_fd_sc_hd__ha_2
X_15414_ _07153_ _07445_ VSS VSS VDD VDD _07446_ _07447_ sky130_fd_sc_hd__ha_1
X_15415_ _07133_ _07448_ VSS VSS VDD VDD _07449_ _07450_ sky130_fd_sc_hd__ha_1
X_15416_ _07133_ _07451_ VSS VSS VDD VDD _07452_ _07453_ sky130_fd_sc_hd__ha_1
X_15417_ _07121_ _07454_ VSS VSS VDD VDD _07455_ _07456_ sky130_fd_sc_hd__ha_1
X_15418_ _07112_ _07457_ VSS VSS VDD VDD _07458_ _07459_ sky130_fd_sc_hd__ha_4
X_15419_ _05892_ _07460_ VSS VSS VDD VDD _07461_ _07462_ sky130_fd_sc_hd__ha_4
X_15420_ net14 net376 VSS VSS VDD VDD _07463_ _07464_ sky130_fd_sc_hd__ha_1
X_15421_ _07166_ _07465_ VSS VSS VDD VDD _07466_ _07467_ sky130_fd_sc_hd__ha_2
X_15422_ _07153_ _07468_ VSS VSS VDD VDD _07469_ _07470_ sky130_fd_sc_hd__ha_1
X_15423_ _07153_ _07471_ VSS VSS VDD VDD _07472_ _07473_ sky130_fd_sc_hd__ha_1
X_15424_ _07133_ _07474_ VSS VSS VDD VDD _07475_ _07476_ sky130_fd_sc_hd__ha_1
X_15425_ _07121_ _07477_ VSS VSS VDD VDD _07478_ _07479_ sky130_fd_sc_hd__ha_1
X_15426_ _07112_ _07480_ VSS VSS VDD VDD _07481_ _07482_ sky130_fd_sc_hd__ha_4
X_15427_ _05892_ _07483_ VSS VSS VDD VDD _07484_ _07485_ sky130_fd_sc_hd__ha_1
X_15428_ net14 net377 VSS VSS VDD VDD _07486_ _07487_ sky130_fd_sc_hd__ha_1
X_15429_ _07166_ _07488_ VSS VSS VDD VDD _07489_ _07490_ sky130_fd_sc_hd__ha_1
X_15430_ _07166_ _07491_ VSS VSS VDD VDD _07492_ _07493_ sky130_fd_sc_hd__ha_1
X_15431_ _07153_ _07494_ VSS VSS VDD VDD _07495_ _07496_ sky130_fd_sc_hd__ha_1
X_15432_ _07133_ _07497_ VSS VSS VDD VDD _07498_ _07499_ sky130_fd_sc_hd__ha_1
X_15433_ _07121_ _07500_ VSS VSS VDD VDD _07501_ _07502_ sky130_fd_sc_hd__ha_1
X_15434_ _07112_ _07503_ VSS VSS VDD VDD _07504_ _07505_ sky130_fd_sc_hd__ha_4
X_15435_ _07506_ _05892_ VSS VSS VDD VDD _07507_ _07508_ sky130_fd_sc_hd__ha_1
X_15436_ net14 net378 VSS VSS VDD VDD _07509_ _07510_ sky130_fd_sc_hd__ha_1
X_15437_ _07166_ _07511_ VSS VSS VDD VDD _07512_ _07513_ sky130_fd_sc_hd__ha_1
X_15438_ _07153_ _07514_ VSS VSS VDD VDD _07515_ _07516_ sky130_fd_sc_hd__ha_1
X_15439_ _07133_ _07517_ VSS VSS VDD VDD _07518_ _07519_ sky130_fd_sc_hd__ha_1
X_15440_ _07121_ _07520_ VSS VSS VDD VDD _07521_ _07522_ sky130_fd_sc_hd__ha_1
X_15441_ _07112_ _07523_ VSS VSS VDD VDD _07524_ _07525_ sky130_fd_sc_hd__ha_4
X_15442_ _05892_ _07526_ VSS VSS VDD VDD _07527_ _07528_ sky130_fd_sc_hd__ha_4
X_15443_ net14 net379 VSS VSS VDD VDD _07529_ _07530_ sky130_fd_sc_hd__ha_1
X_15444_ net14 net380 VSS VSS VDD VDD _07531_ _07532_ sky130_fd_sc_hd__ha_1
X_15445_ _07166_ _07533_ VSS VSS VDD VDD _07534_ _07535_ sky130_fd_sc_hd__ha_1
X_15446_ _07153_ _07536_ VSS VSS VDD VDD _07537_ _07538_ sky130_fd_sc_hd__ha_1
X_15447_ _07133_ _07539_ VSS VSS VDD VDD _07540_ _07541_ sky130_fd_sc_hd__ha_1
X_15448_ _07121_ _07542_ VSS VSS VDD VDD _07543_ _07544_ sky130_fd_sc_hd__ha_1
X_15449_ _07545_ _07112_ VSS VSS VDD VDD _07546_ _07547_ sky130_fd_sc_hd__ha_1
X_15450_ _07548_ _05892_ VSS VSS VDD VDD _07549_ _07550_ sky130_fd_sc_hd__ha_4
X_15451_ _07551_ _05892_ VSS VSS VDD VDD _07552_ _07553_ sky130_fd_sc_hd__ha_1
X_15452_ net14 net381 VSS VSS VDD VDD _07554_ _07555_ sky130_fd_sc_hd__ha_1
X_15453_ _07207_ _07556_ VSS VSS VDD VDD _07557_ _07558_ sky130_fd_sc_hd__ha_1
X_15454_ _07166_ _07559_ VSS VSS VDD VDD _07560_ _07561_ sky130_fd_sc_hd__ha_1
X_15455_ _07153_ _07562_ VSS VSS VDD VDD _07563_ _07564_ sky130_fd_sc_hd__ha_1
X_15456_ _07133_ _07565_ VSS VSS VDD VDD _07566_ _07567_ sky130_fd_sc_hd__ha_1
X_15457_ _07121_ _07568_ VSS VSS VDD VDD _07569_ _07570_ sky130_fd_sc_hd__ha_1
X_15458_ _07112_ _07571_ VSS VSS VDD VDD _07572_ _07573_ sky130_fd_sc_hd__ha_1
X_15459_ net14 net382 VSS VSS VDD VDD _07574_ _07575_ sky130_fd_sc_hd__ha_1
X_15460_ _07112_ _07576_ VSS VSS VDD VDD _07577_ _07578_ sky130_fd_sc_hd__ha_4
X_15461_ _07579_ _05892_ VSS VSS VDD VDD _07580_ _07581_ sky130_fd_sc_hd__ha_4
X_15462_ _07207_ _07582_ VSS VSS VDD VDD _07583_ _07584_ sky130_fd_sc_hd__ha_1
X_15463_ _07166_ _07585_ VSS VSS VDD VDD _07586_ _07587_ sky130_fd_sc_hd__ha_1
X_15464_ _07153_ _07588_ VSS VSS VDD VDD _07589_ _07590_ sky130_fd_sc_hd__ha_1
X_15465_ _07133_ _07591_ VSS VSS VDD VDD _07592_ _07593_ sky130_fd_sc_hd__ha_1
X_15466_ _07121_ _07594_ VSS VSS VDD VDD _07595_ _07596_ sky130_fd_sc_hd__ha_1
X_15467_ _07121_ _07597_ VSS VSS VDD VDD _07598_ _07599_ sky130_fd_sc_hd__ha_1
X_15468_ _07112_ _07600_ VSS VSS VDD VDD _07601_ _07602_ sky130_fd_sc_hd__ha_4
X_15469_ _05892_ _07603_ VSS VSS VDD VDD _07604_ _07605_ sky130_fd_sc_hd__ha_4
X_15470_ net14 net383 VSS VSS VDD VDD _07606_ _07607_ sky130_fd_sc_hd__ha_1
X_15471_ _07207_ _07608_ VSS VSS VDD VDD _07609_ _07610_ sky130_fd_sc_hd__ha_1
X_15472_ _07166_ _07611_ VSS VSS VDD VDD _07612_ _07613_ sky130_fd_sc_hd__ha_1
X_15473_ _07153_ _07614_ VSS VSS VDD VDD _07615_ _07616_ sky130_fd_sc_hd__ha_1
X_15474_ _07133_ _07617_ VSS VSS VDD VDD _07618_ _07619_ sky130_fd_sc_hd__ha_1
X_15475_ net14 net384 VSS VSS VDD VDD _07620_ _07621_ sky130_fd_sc_hd__ha_1
X_15476_ _07112_ _07622_ VSS VSS VDD VDD _07623_ _07624_ sky130_fd_sc_hd__ha_4
X_15477_ _05892_ _07625_ VSS VSS VDD VDD _07626_ _07627_ sky130_fd_sc_hd__ha_4
X_15478_ _07133_ _07628_ VSS VSS VDD VDD _07629_ _07630_ sky130_fd_sc_hd__ha_1
X_15479_ _07121_ _07631_ VSS VSS VDD VDD _07632_ _07633_ sky130_fd_sc_hd__ha_1
X_15480_ _07166_ _07634_ VSS VSS VDD VDD _07635_ _07636_ sky130_fd_sc_hd__ha_1
X_15481_ _07153_ _07637_ VSS VSS VDD VDD _07638_ _07639_ sky130_fd_sc_hd__ha_1
X_15482_ _07207_ _07640_ VSS VSS VDD VDD _07641_ _07642_ sky130_fd_sc_hd__ha_1
X_15483_ _07643_ _05892_ VSS VSS VDD VDD _07644_ _07645_ sky130_fd_sc_hd__ha_4
X_15484_ butterfly_count\[2\] net14 VSS VSS VDD VDD _07646_
+ _07647_ sky130_fd_sc_hd__ha_1
X_15485_ _07153_ _07648_ VSS VSS VDD VDD _07649_ _07650_ sky130_fd_sc_hd__ha_1
X_15486_ _07133_ _07651_ VSS VSS VDD VDD _07652_ _07653_ sky130_fd_sc_hd__ha_1
X_15487_ _07121_ _07654_ VSS VSS VDD VDD _07655_ _07656_ sky130_fd_sc_hd__ha_1
X_15488_ _07657_ _07112_ VSS VSS VDD VDD _07658_ _07659_ sky130_fd_sc_hd__ha_1
X_15489_ _07207_ _07660_ VSS VSS VDD VDD _07661_ _07662_ sky130_fd_sc_hd__ha_1
X_15490_ _07166_ _07663_ VSS VSS VDD VDD _07664_ _07665_ sky130_fd_sc_hd__ha_1
X_15491_ _07666_ _07667_ VSS VSS VDD VDD _07668_ _07669_ sky130_fd_sc_hd__ha_1
X_15492_ butterfly_count\[1\] net14 VSS VSS VDD VDD _07670_
+ _07671_ sky130_fd_sc_hd__ha_1
X_15493_ _07112_ _07672_ VSS VSS VDD VDD _07673_ _07674_ sky130_fd_sc_hd__ha_4
X_15494_ _05892_ _07675_ VSS VSS VDD VDD _07676_ _07677_ sky130_fd_sc_hd__ha_4
X_15495_ _07166_ _07678_ VSS VSS VDD VDD _07679_ _07680_ sky130_fd_sc_hd__ha_2
X_15496_ _07153_ _07681_ VSS VSS VDD VDD _07682_ _07683_ sky130_fd_sc_hd__ha_1
X_15497_ _07133_ _07684_ VSS VSS VDD VDD _07685_ _07686_ sky130_fd_sc_hd__ha_1
X_15498_ _07121_ _07687_ VSS VSS VDD VDD _07688_ _07689_ sky130_fd_sc_hd__ha_1
X_15499_ _07690_ _07691_ VSS VSS VDD VDD _07692_ _07693_ sky130_fd_sc_hd__ha_1
X_15500_ _07695_ _07694_ VSS VSS VDD VDD _07696_ _07697_ sky130_fd_sc_hd__ha_1
X_15501_ _07698_ _07699_ VSS VSS VDD VDD _07700_ _07701_ sky130_fd_sc_hd__ha_4
X_15502_ _07702_ _07703_ VSS VSS VDD VDD _07704_ _07705_ sky130_fd_sc_hd__ha_1
X_15503_ _07706_ _07707_ VSS VSS VDD VDD _07708_ _07709_ sky130_fd_sc_hd__ha_1
X_15504_ _07710_ _07711_ VSS VSS VDD VDD _07712_ _07713_ sky130_fd_sc_hd__ha_1
X_15505_ _05892_ _05893_ VSS VSS VDD VDD _07714_ _07715_ sky130_fd_sc_hd__ha_1
X_15506_ _07716_ net386 VSS VSS VDD VDD _07717_ _07718_ sky130_fd_sc_hd__ha_1
X_15507_ butterfly_count\[0\] net14 VSS VSS VDD VDD _07719_
+ _07720_ sky130_fd_sc_hd__ha_1
X_15508_ _05882_ _07721_ VSS VSS VDD VDD _07722_ _07723_ sky130_fd_sc_hd__ha_2
X_15509_ temp_real\[0\] _07721_ VSS VSS VDD VDD _07724_ _07725_
+ sky130_fd_sc_hd__ha_1
X_15510_ _05882_ _07726_ VSS VSS VDD VDD _07727_ _07728_ sky130_fd_sc_hd__ha_1
X_15511_ net53 _07726_ VSS VSS VDD VDD _07729_ _07730_ sky130_fd_sc_hd__ha_1
X_15512_ net53 net610 VSS VSS VDD VDD _07731_ _07733_ sky130_fd_sc_hd__ha_4
X_15513_ net53 _07734_ VSS VSS VDD VDD _05891_ _07735_ sky130_fd_sc_hd__ha_4
X_15514_ _07736_ _07737_ VSS VSS VDD VDD _07738_ _07739_ sky130_fd_sc_hd__ha_1
X_15515_ _05882_ _07740_ VSS VSS VDD VDD _07741_ _07742_ sky130_fd_sc_hd__ha_1
X_15516_ net53 _07740_ VSS VSS VDD VDD _07743_ _07744_ sky130_fd_sc_hd__ha_1
X_15517_ _05882_ _07745_ VSS VSS VDD VDD _07746_ _07747_ sky130_fd_sc_hd__ha_1
X_15518_ net53 _07745_ VSS VSS VDD VDD _07748_ _07749_ sky130_fd_sc_hd__ha_1
X_15519_ _05882_ _07750_ VSS VSS VDD VDD _07751_ _07752_ sky130_fd_sc_hd__ha_1
X_15520_ net53 _07750_ VSS VSS VDD VDD _07753_ _07754_ sky130_fd_sc_hd__ha_1
X_15521_ _05882_ _07755_ VSS VSS VDD VDD _07756_ _07757_ sky130_fd_sc_hd__ha_1
X_15522_ net53 _07755_ VSS VSS VDD VDD _07758_ _07759_ sky130_fd_sc_hd__ha_1
X_15523_ _05882_ _07760_ VSS VSS VDD VDD _07761_ _07762_ sky130_fd_sc_hd__ha_1
X_15524_ net53 _07760_ VSS VSS VDD VDD _07763_ _07764_ sky130_fd_sc_hd__ha_1
X_15525_ _05882_ _07765_ VSS VSS VDD VDD _07766_ _07767_ sky130_fd_sc_hd__ha_1
X_15526_ net53 _07765_ VSS VSS VDD VDD _07768_ _07769_ sky130_fd_sc_hd__ha_1
X_15527_ _05882_ _07770_ VSS VSS VDD VDD _07771_ _07772_ sky130_fd_sc_hd__ha_1
X_15528_ net53 _07770_ VSS VSS VDD VDD _07773_ _07774_ sky130_fd_sc_hd__ha_1
X_15529_ _05882_ _07775_ VSS VSS VDD VDD _07776_ _07777_ sky130_fd_sc_hd__ha_1
X_15530_ net53 _07775_ VSS VSS VDD VDD _07778_ _07779_ sky130_fd_sc_hd__ha_1
X_15531_ _05882_ _07780_ VSS VSS VDD VDD _07781_ _07782_ sky130_fd_sc_hd__ha_1
X_15532_ net53 _07780_ VSS VSS VDD VDD _07783_ _07784_ sky130_fd_sc_hd__ha_1
X_15533_ _05882_ _07785_ VSS VSS VDD VDD _07786_ _07787_ sky130_fd_sc_hd__ha_4
X_15534_ net53 _07785_ VSS VSS VDD VDD _07788_ _07789_ sky130_fd_sc_hd__ha_1
X_15535_ _07790_ _05882_ VSS VSS VDD VDD _07791_ _07792_ sky130_fd_sc_hd__ha_4
X_15536_ net53 _07790_ VSS VSS VDD VDD _07793_ _07794_ sky130_fd_sc_hd__ha_1
X_15537_ _05887_ _05882_ VSS VSS VDD VDD _07795_ _07796_ sky130_fd_sc_hd__ha_4
X_15538_ net53 net594 VSS VSS VDD VDD _07797_ _07798_ sky130_fd_sc_hd__ha_2
X_15539_ _07716_ _07666_ VSS VSS VDD VDD _07799_ _07800_ sky130_fd_sc_hd__ha_1
X_15540_ butterfly_count\[0\] butterfly_count\[1\] VSS VSS
+ VDD VDD _07801_ _07802_ sky130_fd_sc_hd__ha_1
X_15541_ _07804_ _07803_ VSS VSS VDD VDD _07805_ _07806_ sky130_fd_sc_hd__ha_4
X_15542_ _07803_ _07804_ VSS VSS VDD VDD _07807_ _07808_ sky130_fd_sc_hd__ha_1
X_15543_ _07803_ stage\[1\] VSS VSS VDD VDD _07809_ _07810_
+ sky130_fd_sc_hd__ha_1
X_15544_ stage\[0\] _07804_ VSS VSS VDD VDD _07811_ _07812_
+ sky130_fd_sc_hd__ha_4
X_15545_ stage\[0\] _07804_ VSS VSS VDD VDD _07813_ _07814_
+ sky130_fd_sc_hd__ha_1
X_15546_ stage\[0\] stage\[1\] VSS VSS VDD VDD _07815_ _07816_
+ sky130_fd_sc_hd__ha_2
X_15547_ _07817_ _07818_ VSS VSS VDD VDD _07819_ _07820_ sky130_fd_sc_hd__ha_2
X_15548_ _07817_ _07815_ VSS VSS VDD VDD _07821_ _07822_ sky130_fd_sc_hd__ha_4
X_15549_ _07817_ _07815_ VSS VSS VDD VDD _07706_ _07823_ sky130_fd_sc_hd__ha_4
X_15550_ stage\[2\] _07815_ VSS VSS VDD VDD _07824_ _07825_
+ sky130_fd_sc_hd__ha_1
X_15551_ stage\[2\] _07815_ VSS VSS VDD VDD _07690_ _07826_
+ sky130_fd_sc_hd__ha_4
X_15552_ _07827_ _07828_ VSS VSS VDD VDD _07829_ _07830_ sky130_fd_sc_hd__ha_1
X_15553_ sample_count\[0\] sample_count\[1\] VSS VSS VDD VDD
+ _07831_ _07832_ sky130_fd_sc_hd__ha_1
X_15554_ sample_count\[2\] _07831_ VSS VSS VDD VDD _07833_
+ _07834_ sky130_fd_sc_hd__ha_1
X_15555_ _05897_ _07835_ VSS VSS VDD VDD _07836_ _07837_ sky130_fd_sc_hd__ha_2
X_15556_ temp_imag\[0\] _07835_ VSS VSS VDD VDD _07838_ _07839_
+ sky130_fd_sc_hd__ha_1
X_15557_ _05897_ _07840_ VSS VSS VDD VDD _07841_ _07842_ sky130_fd_sc_hd__ha_1
X_15558_ temp_imag\[0\] _07840_ VSS VSS VDD VDD _07843_ _07844_
+ sky130_fd_sc_hd__ha_1
X_15559_ temp_imag\[0\] net637 VSS VSS VDD VDD _07845_ _07847_
+ sky130_fd_sc_hd__ha_4
X_15560_ temp_imag\[0\] _07848_ VSS VSS VDD VDD _05906_ _07849_
+ sky130_fd_sc_hd__ha_4
X_15561_ _07850_ _07851_ VSS VSS VDD VDD _07852_ _07853_ sky130_fd_sc_hd__ha_1
X_15562_ _05897_ _07854_ VSS VSS VDD VDD _07855_ _07856_ sky130_fd_sc_hd__ha_1
X_15563_ temp_imag\[0\] _07854_ VSS VSS VDD VDD _07857_ _07858_
+ sky130_fd_sc_hd__ha_1
X_15564_ _05897_ _07859_ VSS VSS VDD VDD _07860_ _07861_ sky130_fd_sc_hd__ha_1
X_15565_ temp_imag\[0\] _07859_ VSS VSS VDD VDD _07862_ _07863_
+ sky130_fd_sc_hd__ha_1
X_15566_ _05897_ _07864_ VSS VSS VDD VDD _07865_ _07866_ sky130_fd_sc_hd__ha_1
X_15567_ temp_imag\[0\] _07864_ VSS VSS VDD VDD _07867_ _07868_
+ sky130_fd_sc_hd__ha_1
X_15568_ _05897_ _07869_ VSS VSS VDD VDD _07870_ _07871_ sky130_fd_sc_hd__ha_1
X_15569_ temp_imag\[0\] _07869_ VSS VSS VDD VDD _07872_ _07873_
+ sky130_fd_sc_hd__ha_1
X_15570_ _05897_ _07874_ VSS VSS VDD VDD _07875_ _07876_ sky130_fd_sc_hd__ha_1
X_15571_ temp_imag\[0\] _07874_ VSS VSS VDD VDD _07877_ _07878_
+ sky130_fd_sc_hd__ha_1
X_15572_ _05897_ _07879_ VSS VSS VDD VDD _07880_ _07881_ sky130_fd_sc_hd__ha_1
X_15573_ temp_imag\[0\] _07879_ VSS VSS VDD VDD _07882_ _07883_
+ sky130_fd_sc_hd__ha_1
X_15574_ _05897_ _07884_ VSS VSS VDD VDD _07885_ _07886_ sky130_fd_sc_hd__ha_1
X_15575_ temp_imag\[0\] _07884_ VSS VSS VDD VDD _07887_ _07888_
+ sky130_fd_sc_hd__ha_1
X_15576_ _05897_ _07889_ VSS VSS VDD VDD _07890_ _07891_ sky130_fd_sc_hd__ha_1
X_15577_ temp_imag\[0\] _07889_ VSS VSS VDD VDD _07892_ _07893_
+ sky130_fd_sc_hd__ha_1
X_15578_ _05897_ _07894_ VSS VSS VDD VDD _07895_ _07896_ sky130_fd_sc_hd__ha_1
X_15579_ temp_imag\[0\] _07894_ VSS VSS VDD VDD _07897_ _07898_
+ sky130_fd_sc_hd__ha_1
X_15580_ _05897_ _07899_ VSS VSS VDD VDD _07900_ _07901_ sky130_fd_sc_hd__ha_4
X_15581_ temp_imag\[0\] _07899_ VSS VSS VDD VDD _07902_ _07903_
+ sky130_fd_sc_hd__ha_1
X_15582_ _05897_ _07904_ VSS VSS VDD VDD _07905_ _07906_ sky130_fd_sc_hd__ha_4
X_15583_ temp_imag\[0\] _07904_ VSS VSS VDD VDD _07907_ _07908_
+ sky130_fd_sc_hd__ha_1
X_15584_ _05902_ _05897_ VSS VSS VDD VDD _07909_ _07910_ sky130_fd_sc_hd__ha_1
X_15585_ temp_imag\[0\] _05902_ VSS VSS VDD VDD _07911_ _07912_
+ sky130_fd_sc_hd__ha_1
X_15586_ butterfly_in_group\[0\] _07913_ VSS VSS VDD VDD _07914_
+ _05879_ sky130_fd_sc_hd__ha_1
X_15587_ butterfly_in_group\[1\] _07915_ VSS VSS VDD VDD _07916_
+ _07917_ sky130_fd_sc_hd__ha_1
X_15588_ _07917_ _07918_ VSS VSS VDD VDD _07919_ _07920_ sky130_fd_sc_hd__ha_1
X_15589_ _07920_ _07914_ VSS VSS VDD VDD _07921_ _05880_ sky130_fd_sc_hd__ha_1
X_15590_ net387 _05879_ VSS VSS VDD VDD _05908_ _05881_ sky130_fd_sc_hd__ha_1
X_15591_ _05912_ _05913_ VSS VSS VDD VDD _07922_ _07923_ sky130_fd_sc_hd__ha_1
X_15592_ _06123_ _06175_ VSS VSS VDD VDD _07924_ _07925_ sky130_fd_sc_hd__ha_1
X_15593_ _06124_ _06235_ VSS VSS VDD VDD _07926_ _05943_ sky130_fd_sc_hd__ha_1
X_15594_ _05945_ _07928_ VSS VSS VDD VDD _07929_ _07930_ sky130_fd_sc_hd__ha_1
X_15595_ _05951_ _07931_ VSS VSS VDD VDD _07932_ _07933_ sky130_fd_sc_hd__ha_1
X_15596_ _06175_ _06501_ VSS VSS VDD VDD _05944_ _05985_ sky130_fd_sc_hd__ha_1
X_15597_ _05987_ _06371_ VSS VSS VDD VDD _06012_ _07935_ sky130_fd_sc_hd__ha_1
X_15598_ _07936_ _05997_ VSS VSS VDD VDD _07937_ _06077_ sky130_fd_sc_hd__ha_1
X_15599_ _07938_ _07939_ VSS VSS VDD VDD _07940_ _07941_ sky130_fd_sc_hd__ha_1
X_15600_ _06201_ _06202_ VSS VSS VDD VDD _07942_ _07943_ sky130_fd_sc_hd__ha_1
X_15601_ _07944_ _07943_ VSS VSS VDD VDD _07945_ _07946_ sky130_fd_sc_hd__ha_1
X_15602_ _07938_ _05912_ VSS VSS VDD VDD _06052_ _07947_ sky130_fd_sc_hd__ha_1
X_15603_ _06235_ _07928_ VSS VSS VDD VDD _05986_ _07949_ sky130_fd_sc_hd__ha_1
X_15604_ _05998_ _07950_ VSS VSS VDD VDD _06078_ _06128_ sky130_fd_sc_hd__ha_1
X_15605_ _06079_ _06131_ VSS VSS VDD VDD _06106_ _06114_ sky130_fd_sc_hd__ha_1
X_15606_ _07951_ _06382_ VSS VSS VDD VDD _07948_ _07952_ sky130_fd_sc_hd__ha_1
X_15607_ _07952_ _07953_ VSS VSS VDD VDD _07954_ _06142_ sky130_fd_sc_hd__ha_1
X_15608_ _07955_ _06285_ VSS VSS VDD VDD _07956_ _07957_ sky130_fd_sc_hd__ha_1
X_15609_ _06175_ _06235_ VSS VSS VDD VDD _07958_ _07959_ sky130_fd_sc_hd__ha_1
X_15610_ _06501_ _06371_ VSS VSS VDD VDD _07960_ _07961_ sky130_fd_sc_hd__ha_1
X_15611_ _07958_ _07961_ VSS VSS VDD VDD _06167_ _07962_ sky130_fd_sc_hd__ha_1
X_15612_ _07963_ _07964_ VSS VSS VDD VDD _06129_ _06178_ sky130_fd_sc_hd__ha_1
X_15613_ _06132_ _06181_ VSS VSS VDD VDD _06152_ _06163_ sky130_fd_sc_hd__ha_1
X_15614_ _07943_ _06034_ VSS VSS VDD VDD _06145_ _06195_ sky130_fd_sc_hd__ha_1
X_15615_ _07965_ _07966_ VSS VSS VDD VDD _07967_ _06193_ sky130_fd_sc_hd__ha_1
X_15616_ _06150_ _07954_ VSS VSS VDD VDD _07968_ _06154_ sky130_fd_sc_hd__ha_1
X_15617_ _06235_ _06501_ VSS VSS VDD VDD _07969_ _07970_ sky130_fd_sc_hd__ha_1
X_15618_ _07928_ _07969_ VSS VSS VDD VDD _06227_ _07971_ sky130_fd_sc_hd__ha_1
X_15619_ _07972_ _06185_ VSS VSS VDD VDD _06179_ _06238_ sky130_fd_sc_hd__ha_1
X_15620_ _06182_ _06241_ VSS VSS VDD VDD _06205_ _06223_ sky130_fd_sc_hd__ha_1
X_15621_ _06382_ _06203_ VSS VSS VDD VDD _06196_ _07973_ sky130_fd_sc_hd__ha_1
X_15622_ _05913_ _05937_ VSS VSS VDD VDD _07974_ _07975_ sky130_fd_sc_hd__ha_1
X_15623_ _07976_ _07977_ VSS VSS VDD VDD _07978_ _07979_ sky130_fd_sc_hd__ha_1
X_15624_ _07981_ _07967_ VSS VSS VDD VDD _06211_ _06215_ sky130_fd_sc_hd__ha_1
X_15625_ _06371_ _07982_ VSS VSS VDD VDD _06277_ _07983_ sky130_fd_sc_hd__ha_1
X_15626_ _06186_ _07984_ VSS VSS VDD VDD _06239_ _06288_ sky130_fd_sc_hd__ha_1
X_15627_ _06242_ _06291_ VSS VSS VDD VDD _06256_ _06273_ sky130_fd_sc_hd__ha_1
X_15628_ _06249_ _07973_ VSS VSS VDD VDD _07980_ _07985_ sky130_fd_sc_hd__ha_1
X_15629_ _06032_ _06382_ VSS VSS VDD VDD _07986_ _06298_ sky130_fd_sc_hd__ha_1
X_15630_ _05937_ _05938_ VSS VSS VDD VDD _07987_ _07988_ sky130_fd_sc_hd__ha_1
X_15631_ _05925_ _05918_ VSS VSS VDD VDD _07989_ _07990_ sky130_fd_sc_hd__ha_1
X_15632_ _07992_ _07978_ VSS VSS VDD VDD _06261_ _06265_ sky130_fd_sc_hd__ha_1
X_15633_ _06213_ _06262_ VSS VSS VDD VDD _07993_ _07994_ sky130_fd_sc_hd__ha_1
X_15634_ _07995_ _07996_ VSS VSS VDD VDD _06289_ _06335_ sky130_fd_sc_hd__ha_1
X_15635_ _06292_ _06338_ VSS VSS VDD VDD _06310_ _06324_ sky130_fd_sc_hd__ha_1
X_15636_ _05938_ _05980_ VSS VSS VDD VDD _07997_ _07998_ sky130_fd_sc_hd__ha_1
X_15637_ _07927_ _05935_ VSS VSS VDD VDD _07999_ _08000_ sky130_fd_sc_hd__ha_1
X_15638_ _06299_ _07986_ VSS VSS VDD VDD _07991_ _08001_ sky130_fd_sc_hd__ha_1
X_15639_ _06308_ _07989_ VSS VSS VDD VDD _06312_ _06316_ sky130_fd_sc_hd__ha_1
X_15640_ _06263_ _06313_ VSS VSS VDD VDD _08002_ _08003_ sky130_fd_sc_hd__ha_1
X_15641_ _08004_ _08005_ VSS VSS VDD VDD _06323_ _06363_ sky130_fd_sc_hd__ha_1
X_15642_ _08006_ _08007_ VSS VSS VDD VDD _06336_ _06373_ sky130_fd_sc_hd__ha_1
X_15643_ _06376_ _06339_ VSS VSS VDD VDD _08008_ _06365_ sky130_fd_sc_hd__ha_4
X_15644_ _08000_ _08001_ VSS VSS VDD VDD _06307_ _06349_ sky130_fd_sc_hd__ha_1
X_15645_ _05980_ _06123_ VSS VSS VDD VDD _05942_ _08009_ sky130_fd_sc_hd__ha_1
X_15646_ _07934_ _05978_ VSS VSS VDD VDD _08010_ _08011_ sky130_fd_sc_hd__ha_1
X_15647_ _06351_ _07999_ VSS VSS VDD VDD _06354_ _06358_ sky130_fd_sc_hd__ha_1
X_15648_ _06314_ _06355_ VSS VSS VDD VDD _08012_ _08013_ sky130_fd_sc_hd__ha_1
X_15649_ _08015_ _08014_ VSS VSS VDD VDD _06364_ _06400_ sky130_fd_sc_hd__ha_1
X_15650_ _08016_ _08017_ VSS VSS VDD VDD _08015_ _08018_ sky130_fd_sc_hd__ha_1
X_15651_ _07928_ _06434_ VSS VSS VDD VDD _06372_ _06456_ sky130_fd_sc_hd__ha_1
X_15652_ _06380_ _08019_ VSS VSS VDD VDD _06374_ _06409_ sky130_fd_sc_hd__ha_4
X_15653_ _06383_ _08020_ VSS VSS VDD VDD _08021_ _06406_ sky130_fd_sc_hd__ha_1
X_15654_ _06377_ _08022_ VSS VSS VDD VDD _08023_ _06402_ sky130_fd_sc_hd__ha_1
X_15655_ _08011_ _06346_ VSS VSS VDD VDD _06350_ _06385_ sky130_fd_sc_hd__ha_1
X_15656_ _06123_ _06124_ VSS VSS VDD VDD _05984_ _08024_ sky130_fd_sc_hd__ha_1
X_15657_ _06072_ _06067_ VSS VSS VDD VDD _08025_ _08026_ sky130_fd_sc_hd__ha_1
X_15658_ _06387_ _08010_ VSS VSS VDD VDD _06390_ _06394_ sky130_fd_sc_hd__ha_1
X_15659_ _06356_ _06391_ VSS VSS VDD VDD _08027_ _08028_ sky130_fd_sc_hd__ha_1
X_15660_ _08018_ _08029_ VSS VSS VDD VDD _06401_ _08030_ sky130_fd_sc_hd__ha_1
X_15661_ _06381_ _08031_ VSS VSS VDD VDD _06410_ _06432_ sky130_fd_sc_hd__ha_1
X_15662_ _06046_ _08032_ VSS VSS VDD VDD _08031_ _08033_ sky130_fd_sc_hd__ha_1
X_15663_ _06202_ _06382_ VSS VSS VDD VDD _08020_ _08034_ sky130_fd_sc_hd__ha_1
X_15664_ _08034_ _08035_ VSS VSS VDD VDD _08036_ _06429_ sky130_fd_sc_hd__ha_1
X_15665_ _08038_ _08037_ VSS VSS VDD VDD _08039_ _08040_ sky130_fd_sc_hd__ha_4
X_15666_ _08026_ _08021_ VSS VSS VDD VDD _06386_ _06412_ sky130_fd_sc_hd__ha_1
X_15667_ _06175_ _06124_ VSS VSS VDD VDD _08041_ _08042_ sky130_fd_sc_hd__ha_1
X_15668_ _08043_ _06121_ VSS VSS VDD VDD _08044_ _08045_ sky130_fd_sc_hd__ha_1
X_15669_ _06414_ _08025_ VSS VSS VDD VDD _06417_ _06421_ sky130_fd_sc_hd__ha_1
X_15670_ _06392_ _06418_ VSS VSS VDD VDD _08046_ _08047_ sky130_fd_sc_hd__ha_1
X_15671_ _08040_ _08030_ VSS VSS VDD VDD _06426_ _06450_ sky130_fd_sc_hd__ha_4
X_15672_ _08048_ _08049_ VSS VSS VDD VDD _08029_ _08050_ sky130_fd_sc_hd__ha_1
X_15673_ _08033_ _06437_ VSS VSS VDD VDD _06433_ _06463_ sky130_fd_sc_hd__ha_1
X_15674_ _06382_ _08051_ VSS VSS VDD VDD _08035_ _06460_ sky130_fd_sc_hd__ha_1
X_15675_ _08052_ _08053_ VSS VSS VDD VDD _08054_ _08055_ sky130_fd_sc_hd__ha_1
X_15676_ _08045_ _08036_ VSS VSS VDD VDD _06413_ _08056_ sky130_fd_sc_hd__ha_1
X_15677_ _08057_ _08056_ VSS VSS VDD VDD _08058_ _06446_ sky130_fd_sc_hd__ha_1
X_15678_ _08058_ _08044_ VSS VSS VDD VDD _06440_ _06444_ sky130_fd_sc_hd__ha_1
X_15679_ _06419_ _06441_ VSS VSS VDD VDD _08059_ _08060_ sky130_fd_sc_hd__ha_1
X_15680_ _08050_ _08055_ VSS VSS VDD VDD _06451_ _08061_ sky130_fd_sc_hd__ha_1
X_15681_ _06438_ _06468_ VSS VSS VDD VDD _06464_ _08062_ sky130_fd_sc_hd__ha_1
X_15682_ _08063_ _08064_ VSS VSS VDD VDD _08065_ _08066_ sky130_fd_sc_hd__ha_1
X_15683_ _08067_ _08068_ VSS VSS VDD VDD _08069_ _06479_ sky130_fd_sc_hd__ha_1
X_15684_ _06442_ _06472_ VSS VSS VDD VDD _08070_ _08071_ sky130_fd_sc_hd__ha_1
X_15685_ _08072_ _08066_ VSS VSS VDD VDD _08073_ _06492_ sky130_fd_sc_hd__ha_1
X_15686_ _06371_ _06465_ VSS VSS VDD VDD _06457_ _08074_ sky130_fd_sc_hd__ha_1
X_15687_ _08075_ _08076_ VSS VSS VDD VDD _08077_ _08078_ sky130_fd_sc_hd__ha_1
X_15688_ _06469_ _08079_ VSS VSS VDD VDD _08080_ _08081_ sky130_fd_sc_hd__ha_1
X_15689_ _08082_ _08083_ VSS VSS VDD VDD _08084_ _08085_ sky130_fd_sc_hd__ha_1
X_15690_ _08086_ _08087_ VSS VSS VDD VDD _08088_ _08089_ sky130_fd_sc_hd__ha_1
X_15691_ _06235_ _06481_ VSS VSS VDD VDD _08090_ _08091_ sky130_fd_sc_hd__ha_1
X_15692_ _06482_ _08091_ VSS VSS VDD VDD _08092_ _08093_ sky130_fd_sc_hd__ha_1
X_15693_ _08092_ _08090_ VSS VSS VDD VDD _06486_ _08094_ sky130_fd_sc_hd__ha_1
X_15694_ _06487_ _06473_ VSS VSS VDD VDD _08095_ _08096_ sky130_fd_sc_hd__ha_1
X_15695_ _08097_ _08098_ VSS VSS VDD VDD _06496_ _08099_ sky130_fd_sc_hd__ha_1
X_15696_ _08100_ _08085_ VSS VSS VDD VDD _08101_ _08102_ sky130_fd_sc_hd__ha_1
X_15697_ _06501_ _07928_ VSS VSS VDD VDD _07982_ _06498_ sky130_fd_sc_hd__ha_4
X_15698_ _06326_ _06283_ VSS VSS VDD VDD _06507_ _08103_ sky130_fd_sc_hd__ha_1
X_15699_ _08102_ _08103_ VSS VSS VDD VDD _06506_ _08104_ sky130_fd_sc_hd__ha_1
X_15700_ _06488_ _06510_ VSS VSS VDD VDD _08105_ _08106_ sky130_fd_sc_hd__ha_4
X_15701_ _08107_ _06500_ VSS VSS VDD VDD _06516_ _06521_ sky130_fd_sc_hd__ha_1
X_15702_ _07928_ _06371_ VSS VSS VDD VDD _06329_ _08108_ sky130_fd_sc_hd__ha_4
X_15703_ _08109_ _08108_ VSS VSS VDD VDD _06523_ _08110_ sky130_fd_sc_hd__ha_1
X_15704_ _08111_ _08108_ VSS VSS VDD VDD _08112_ _08113_ sky130_fd_sc_hd__ha_1
X_15705_ _06519_ _06511_ VSS VSS VDD VDD _08115_ _08116_ sky130_fd_sc_hd__ha_4
X_15706_ _06497_ _08117_ VSS VSS VDD VDD _08114_ _08118_ sky130_fd_sc_hd__ha_1
X_15707_ _08119_ _08120_ VSS VSS VDD VDD _08111_ _08121_ sky130_fd_sc_hd__ha_1
X_15708_ _06520_ _08122_ VSS VSS VDD VDD _08123_ _08124_ sky130_fd_sc_hd__ha_1
X_15709_ _06525_ _08125_ VSS VSS VDD VDD _08122_ _08126_ sky130_fd_sc_hd__ha_1
X_15710_ _08118_ _08127_ VSS VSS VDD VDD _08128_ _08129_ sky130_fd_sc_hd__ha_1
X_15711_ _06371_ _08121_ VSS VSS VDD VDD _08127_ _08130_ sky130_fd_sc_hd__ha_1
X_15712_ _08131_ _08132_ VSS VSS VDD VDD _08133_ _08134_ sky130_fd_sc_hd__ha_1
X_15713_ _08135_ _08134_ VSS VSS VDD VDD _08136_ _06558_ sky130_fd_sc_hd__ha_1
X_15714_ _08137_ _06721_ VSS VSS VDD VDD _08138_ _08139_ sky130_fd_sc_hd__ha_1
X_15715_ _06534_ _06646_ VSS VSS VDD VDD _06559_ _06593_ sky130_fd_sc_hd__ha_1
X_15716_ _08131_ _06531_ VSS VSS VDD VDD _06567_ _08140_ sky130_fd_sc_hd__ha_1
X_15717_ _08141_ _08142_ VSS VSS VDD VDD _08143_ _06585_ sky130_fd_sc_hd__ha_1
X_15718_ _08144_ _08145_ VSS VSS VDD VDD _06586_ _06622_ sky130_fd_sc_hd__ha_1
X_15719_ _06778_ net471 VSS VSS VDD VDD _08147_ _06618_ sky130_fd_sc_hd__ha_1
X_15720_ _08140_ _06693_ VSS VSS VDD VDD _06594_ _08148_ sky130_fd_sc_hd__ha_1
X_15721_ _08149_ _08150_ VSS VSS VDD VDD _06613_ _08151_ sky130_fd_sc_hd__ha_1
X_15722_ _08153_ _08154_ VSS VSS VDD VDD _06623_ _06681_ sky130_fd_sc_hd__ha_1
X_15723_ _06833_ _06991_ VSS VSS VDD VDD _08155_ _06677_ sky130_fd_sc_hd__ha_1
X_15724_ _06986_ _08156_ VSS VSS VDD VDD _08157_ _08158_ sky130_fd_sc_hd__ha_1
X_15725_ _06648_ _06943_ VSS VSS VDD VDD _08159_ _08160_ sky130_fd_sc_hd__ha_1
X_15726_ _08157_ _08160_ VSS VSS VDD VDD _08161_ _08162_ sky130_fd_sc_hd__ha_1
X_15727_ net472 _06943_ VSS VSS VDD VDD _08164_ _08165_ sky130_fd_sc_hd__ha_1
X_15728_ _08158_ _08164_ VSS VSS VDD VDD _08163_ _08166_ sky130_fd_sc_hd__ha_1
X_15729_ _08167_ _06695_ VSS VSS VDD VDD _08168_ _08169_ sky130_fd_sc_hd__ha_1
X_15730_ _08171_ _06714_ VSS VSS VDD VDD _06672_ _08172_ sky130_fd_sc_hd__ha_1
X_15731_ _08131_ net466 VSS VSS VDD VDD _08152_ _08173_ sky130_fd_sc_hd__ha_1
X_15732_ _08174_ _08175_ VSS VSS VDD VDD _06682_ _06733_ sky130_fd_sc_hd__ha_1
X_15733_ _08176_ _08166_ VSS VSS VDD VDD _08170_ _08177_ sky130_fd_sc_hd__ha_1
X_15734_ _06991_ _06986_ VSS VSS VDD VDD _08178_ _08179_ sky130_fd_sc_hd__ha_1
X_15735_ _08178_ _08165_ VSS VSS VDD VDD _08176_ _08180_ sky130_fd_sc_hd__ha_1
X_15736_ _06696_ _06747_ VSS VSS VDD VDD _08181_ _08182_ sky130_fd_sc_hd__ha_1
X_15737_ _08172_ _08173_ VSS VSS VDD VDD _06710_ _06766_ sky130_fd_sc_hd__ha_1
X_15738_ _06715_ _08184_ VSS VSS VDD VDD _06725_ _08185_ sky130_fd_sc_hd__ha_1
X_15739_ _08186_ _08187_ VSS VSS VDD VDD _06734_ _06782_ sky130_fd_sc_hd__ha_1
X_15740_ _08188_ _08180_ VSS VSS VDD VDD _08183_ _08189_ sky130_fd_sc_hd__ha_1
X_15741_ net490 net471 VSS VSS VDD VDD _08190_ _08191_ sky130_fd_sc_hd__ha_1
X_15742_ _08190_ _08179_ VSS VSS VDD VDD _08188_ _08192_ sky130_fd_sc_hd__ha_1
X_15743_ _06748_ _06795_ VSS VSS VDD VDD _08193_ _08194_ sky130_fd_sc_hd__ha_1
X_15744_ _08196_ _08181_ VSS VSS VDD VDD _08197_ _06757_ sky130_fd_sc_hd__ha_1
X_15745_ _06632_ _08185_ VSS VSS VDD VDD _06767_ _06819_ sky130_fd_sc_hd__ha_1
X_15746_ _08131_ _06526_ VSS VSS VDD VDD _08184_ _08198_ sky130_fd_sc_hd__ha_1
X_15747_ _06772_ _06826_ VSS VSS VDD VDD _06785_ _06821_ sky130_fd_sc_hd__ha_1
X_15748_ _08199_ _08200_ VSS VSS VDD VDD _06783_ _06837_ sky130_fd_sc_hd__ha_1
X_15749_ _08201_ _08192_ VSS VSS VDD VDD _08195_ _08202_ sky130_fd_sc_hd__ha_1
X_15750_ _06778_ _06991_ VSS VSS VDD VDD _08203_ _08204_ sky130_fd_sc_hd__ha_1
X_15751_ _08203_ _08191_ VSS VSS VDD VDD _08201_ _08205_ sky130_fd_sc_hd__ha_1
X_15752_ _06796_ _06851_ VSS VSS VDD VDD _08206_ _08207_ sky130_fd_sc_hd__ha_1
X_15753_ _08209_ _08193_ VSS VSS VDD VDD _06805_ _06810_ sky130_fd_sc_hd__ha_1
X_15754_ _06648_ _08198_ VSS VSS VDD VDD _06820_ _08210_ sky130_fd_sc_hd__ha_1
X_15755_ _06827_ _06883_ VSS VSS VDD VDD _08211_ _08212_ sky130_fd_sc_hd__ha_1
X_15756_ _08214_ _08215_ VSS VSS VDD VDD _06838_ _06891_ sky130_fd_sc_hd__ha_1
X_15757_ _06852_ _08217_ VSS VSS VDD VDD _08218_ _08219_ sky130_fd_sc_hd__ha_1
X_15758_ _08220_ _08205_ VSS VSS VDD VDD _08208_ _08221_ sky130_fd_sc_hd__ha_1
X_15759_ _06859_ _08206_ VSS VSS VDD VDD _06862_ _06867_ sky130_fd_sc_hd__ha_1
X_15760_ _06807_ _06863_ VSS VSS VDD VDD _08222_ _08223_ sky130_fd_sc_hd__ha_1
X_15761_ _06884_ _08224_ VSS VSS VDD VDD _08225_ _08226_ sky130_fd_sc_hd__ha_1
X_15762_ _06532_ _08156_ VSS VSS VDD VDD _08213_ _08227_ sky130_fd_sc_hd__ha_1
X_15763_ _06839_ _06893_ VSS VSS VDD VDD _08216_ _08228_ sky130_fd_sc_hd__ha_1
X_15764_ _08229_ _08230_ VSS VSS VDD VDD _06892_ _06934_ sky130_fd_sc_hd__ha_1
X_15765_ _08219_ _08221_ VSS VSS VDD VDD _06858_ _06906_ sky130_fd_sc_hd__ha_1
X_15766_ _08232_ _06946_ VSS VSS VDD VDD _08233_ _08234_ sky130_fd_sc_hd__ha_1
X_15767_ _08235_ _08204_ VSS VSS VDD VDD _08220_ _08236_ sky130_fd_sc_hd__ha_1
X_15768_ _06908_ _08218_ VSS VSS VDD VDD _06911_ _06916_ sky130_fd_sc_hd__ha_1
X_15769_ _06864_ _06912_ VSS VSS VDD VDD _08237_ _08238_ sky130_fd_sc_hd__ha_1
X_15770_ _08226_ _08227_ VSS VSS VDD VDD _06923_ _06969_ sky130_fd_sc_hd__ha_1
X_15771_ _06526_ _06532_ VSS VSS VDD VDD _06930_ _08239_ sky130_fd_sc_hd__ha_1
X_15772_ _08240_ _08241_ VSS VSS VDD VDD _08242_ _08243_ sky130_fd_sc_hd__ha_1
X_15773_ _06894_ _06936_ VSS VSS VDD VDD _08231_ _08244_ sky130_fd_sc_hd__ha_1
X_15774_ _08245_ _08246_ VSS VSS VDD VDD _06935_ _06977_ sky130_fd_sc_hd__ha_1
X_15775_ _08234_ _08236_ VSS VSS VDD VDD _06907_ _06952_ sky130_fd_sc_hd__ha_1
X_15776_ _06947_ _06989_ VSS VSS VDD VDD _08248_ _08249_ sky130_fd_sc_hd__ha_1
X_15777_ net489 _06833_ VSS VSS VDD VDD _08235_ _08250_ sky130_fd_sc_hd__ha_1
X_15778_ _06954_ _08233_ VSS VSS VDD VDD _06957_ _06962_ sky130_fd_sc_hd__ha_1
X_15779_ _06913_ _06958_ VSS VSS VDD VDD _08251_ _08252_ sky130_fd_sc_hd__ha_1
X_15780_ _06943_ _08243_ VSS VSS VDD VDD _06970_ _07011_ sky130_fd_sc_hd__ha_1
X_15781_ _08253_ _08239_ VSS VSS VDD VDD _08241_ _08254_ sky130_fd_sc_hd__ha_1
X_15782_ _08254_ _08255_ VSS VSS VDD VDD _08256_ _08257_ sky130_fd_sc_hd__ha_1
X_15783_ _06937_ _06979_ VSS VSS VDD VDD _08247_ _08258_ sky130_fd_sc_hd__ha_1
X_15784_ _08259_ _08260_ VSS VSS VDD VDD _06978_ _07017_ sky130_fd_sc_hd__ha_1
X_15785_ _08249_ _08250_ VSS VSS VDD VDD _06953_ _06994_ sky130_fd_sc_hd__ha_1
X_15786_ _06778_ _06833_ VSS VSS VDD VDD _07066_ _07104_ sky130_fd_sc_hd__ha_1
X_15787_ _06990_ _08262_ VSS VSS VDD VDD _08263_ _08264_ sky130_fd_sc_hd__ha_1
X_15788_ _06996_ _08248_ VSS VSS VDD VDD _06999_ _07004_ sky130_fd_sc_hd__ha_1
X_15789_ _06959_ _07000_ VSS VSS VDD VDD _08265_ _08266_ sky130_fd_sc_hd__ha_1
X_15790_ _06986_ _08257_ VSS VSS VDD VDD _07012_ _07043_ sky130_fd_sc_hd__ha_1
X_15791_ _06532_ _08267_ VSS VSS VDD VDD _08255_ _08268_ sky130_fd_sc_hd__ha_1
X_15792_ _06980_ _07019_ VSS VSS VDD VDD _08261_ _08269_ sky130_fd_sc_hd__ha_1
X_15793_ _08270_ _08271_ VSS VSS VDD VDD _07018_ _08272_ sky130_fd_sc_hd__ha_1
X_15794_ _08269_ _08273_ VSS VSS VDD VDD _08274_ _07045_ sky130_fd_sc_hd__ha_1
X_15795_ _06778_ _08264_ VSS VSS VDD VDD _06995_ _08275_ sky130_fd_sc_hd__ha_1
X_15796_ net492 _07104_ VSS VSS VDD VDD _08276_ _08277_ sky130_fd_sc_hd__ha_1
X_15797_ _07066_ _07026_ VSS VSS VDD VDD _07088_ _07093_ sky130_fd_sc_hd__ha_1
X_15798_ _08278_ _07067_ VSS VSS VDD VDD _08279_ _08280_ sky130_fd_sc_hd__ha_1
X_15799_ _08282_ _08263_ VSS VSS VDD VDD _07033_ _07038_ sky130_fd_sc_hd__ha_1
X_15800_ _07001_ _07034_ VSS VSS VDD VDD _08283_ _08284_ sky130_fd_sc_hd__ha_1
X_15801_ net473 _08268_ VSS VSS VDD VDD _07044_ _07062_ sky130_fd_sc_hd__ha_1
X_15802_ _07020_ _08285_ VSS VSS VDD VDD _08273_ _08286_ sky130_fd_sc_hd__ha_1
X_15803_ _08288_ _08289_ VSS VSS VDD VDD _08287_ _08290_ sky130_fd_sc_hd__ha_1
X_15804_ _08286_ _08291_ VSS VSS VDD VDD _08292_ _07064_ sky130_fd_sc_hd__ha_1
X_15805_ _06833_ _08280_ VSS VSS VDD VDD _08281_ _08293_ sky130_fd_sc_hd__ha_1
X_15806_ _08292_ _08293_ VSS VSS VDD VDD _08294_ _07060_ sky130_fd_sc_hd__ha_1
X_15807_ _08294_ _08279_ VSS VSS VDD VDD _07053_ _07057_ sky130_fd_sc_hd__ha_1
X_15808_ _07035_ _07054_ VSS VSS VDD VDD _08295_ _08296_ sky130_fd_sc_hd__ha_1
X_15809_ _06991_ _07047_ VSS VSS VDD VDD _07063_ _07084_ sky130_fd_sc_hd__ha_1
X_15810_ _08297_ _08298_ VSS VSS VDD VDD _08291_ _08299_ sky130_fd_sc_hd__ha_1
X_15811_ _08300_ _08290_ VSS VSS VDD VDD _08298_ _08301_ sky130_fd_sc_hd__ha_1
X_15812_ _08302_ _08303_ VSS VSS VDD VDD _08300_ _08304_ sky130_fd_sc_hd__ha_1
X_15813_ _08299_ _08305_ VSS VSS VDD VDD _08306_ _07086_ sky130_fd_sc_hd__ha_1
X_15814_ _08276_ _07068_ VSS VSS VDD VDD _08307_ _08308_ sky130_fd_sc_hd__ha_1
X_15815_ _08306_ _08308_ VSS VSS VDD VDD _08309_ _08310_ sky130_fd_sc_hd__ha_1
X_15816_ _08309_ _08307_ VSS VSS VDD VDD _07075_ _08311_ sky130_fd_sc_hd__ha_1
X_15817_ _07055_ _07076_ VSS VSS VDD VDD _08312_ _08313_ sky130_fd_sc_hd__ha_1
X_15818_ net486 _08239_ VSS VSS VDD VDD _07085_ _08314_ sky130_fd_sc_hd__ha_1
X_15819_ _08301_ _08315_ VSS VSS VDD VDD _08305_ _08316_ sky130_fd_sc_hd__ha_1
X_15820_ _07077_ _08318_ VSS VSS VDD VDD _08319_ _08320_ sky130_fd_sc_hd__ha_1
X_15821_ _07080_ _07090_ VSS VSS VDD VDD _08318_ _08321_ sky130_fd_sc_hd__ha_1
X_15822_ _08322_ _08304_ VSS VSS VDD VDD _08315_ _08323_ sky130_fd_sc_hd__ha_1
X_15823_ _06532_ _06778_ VSS VSS VDD VDD _08317_ _08324_ sky130_fd_sc_hd__ha_1
X_15824_ _08321_ _08325_ VSS VSS VDD VDD _08326_ _08327_ sky130_fd_sc_hd__ha_1
X_15825_ _07091_ _08328_ VSS VSS VDD VDD _08325_ _08329_ sky130_fd_sc_hd__ha_1
X_15826_ _07094_ _08330_ VSS VSS VDD VDD _08328_ _08331_ sky130_fd_sc_hd__ha_1
X_15827_ _08323_ _08324_ VSS VSS VDD VDD _07105_ _08332_ sky130_fd_sc_hd__ha_1
X_15828_ _08333_ _08334_ VSS VSS VDD VDD _08322_ _08335_ sky130_fd_sc_hd__ha_1
X_15829_ _08332_ _08336_ VSS VSS VDD VDD _08337_ _08338_ sky130_fd_sc_hd__ha_1
X_15830_ clknet_leaf_49_clk _00002_ VSS VSS VDD VDD _00011_
+ sky130_fd_sc_hd__dfxtp_1
X_15831_ clknet_leaf_43_clk _00001_ VSS VSS VDD VDD _00010_
+ sky130_fd_sc_hd__dfxtp_2
X_15832_ clknet_leaf_49_clk _00000_ VSS VSS VDD VDD _00008_
+ sky130_fd_sc_hd__dfxtp_4
X_15833_ clknet_leaf_49_clk _00020_ VSS VSS VDD VDD _00009_
+ sky130_fd_sc_hd__dfxtp_4
X_15834_ clknet_leaf_48_clk _00021_ VSS VSS VDD VDD _00012_
+ sky130_fd_sc_hd__dfxtp_2
X_15835_ clknet_leaf_49_clk _00022_ VSS VSS VDD VDD _00016_
+ sky130_fd_sc_hd__dfxtp_1
X_15836_ clknet_leaf_49_clk _00023_ VSS VSS VDD VDD _00017_
+ sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
X_15297__327 VSS VSS VDD VDD net385 _unconnected_0 sky130_fd_sc_hd__conb_1
Xbit_rev_idx\[0\]$_DFFE_PN0P_ clknet_leaf_6_clk _00024_ net355
+ VSS VSS VDD VDD bit_rev_idx\[0\] sky130_fd_sc_hd__dfrtp_1
Xbit_rev_idx\[1\]$_DFFE_PN0P_ clknet_leaf_6_clk _00025_ net355
+ VSS VSS VDD VDD bit_rev_idx\[1\] sky130_fd_sc_hd__dfrtp_1
Xbit_rev_idx\[2\]$_DFFE_PN0P_ clknet_leaf_8_clk _00026_ net355
+ VSS VSS VDD VDD bit_rev_idx\[2\] sky130_fd_sc_hd__dfrtp_1
Xbusy$_DFFE_PN0P_ clknet_leaf_7_clk _00027_ net355 VSS VSS
+ VDD VDD net94 sky130_fd_sc_hd__dfrtp_1
Xbutterfly_count\[0\]$_DFFE_PN0P_ clknet_leaf_0_clk _00028_
+ net354 VSS VSS VDD VDD butterfly_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xbutterfly_count\[1\]$_DFFE_PN0P_ clknet_leaf_0_clk _00029_
+ net354 VSS VSS VDD VDD butterfly_count\[1\] sky130_fd_sc_hd__dfrtp_4
Xbutterfly_count\[2\]$_DFFE_PN0P_ clknet_leaf_0_clk _00030_
+ net354 VSS VSS VDD VDD butterfly_count\[2\] sky130_fd_sc_hd__dfrtp_4
Xbutterfly_in_group\[0\]$_DFFE_PP_ clknet_leaf_54_clk _00554_
+ _00007_ VSS VSS VDD VDD butterfly_in_group\[0\] sky130_fd_sc_hd__edfxtp_1
Xbutterfly_in_group\[1\]$_DFFE_PP_ clknet_leaf_54_clk _00555_
+ _00007_ VSS VSS VDD VDD butterfly_in_group\[1\] sky130_fd_sc_hd__edfxtp_1
Xbutterfly_in_group\[2\]$_DFFE_PP_ clknet_leaf_53_clk _00556_
+ _00007_ VSS VSS VDD VDD butterfly_in_group\[2\] sky130_fd_sc_hd__edfxtp_1
Xdata_out_imag\[0\]$_DFFE_PN0P_ clknet_leaf_8_clk _00031_
+ net355 VSS VSS VDD VDD net95 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[100\]$_DFFE_PN0P_ clknet_leaf_7_clk _00032_
+ net355 VSS VSS VDD VDD net96 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[101\]$_DFFE_PN0P_ clknet_leaf_7_clk _00033_
+ net355 VSS VSS VDD VDD net97 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[102\]$_DFFE_PN0P_ clknet_leaf_7_clk _00034_
+ net355 VSS VSS VDD VDD net98 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[103\]$_DFFE_PN0P_ clknet_leaf_7_clk _00035_
+ net355 VSS VSS VDD VDD net99 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[104\]$_DFFE_PN0P_ clknet_leaf_7_clk _00036_
+ net355 VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[105\]$_DFFE_PN0P_ clknet_leaf_4_clk _00037_
+ net354 VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[106\]$_DFFE_PN0P_ clknet_leaf_4_clk _00038_
+ net354 VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[107\]$_DFFE_PN0P_ clknet_leaf_1_clk _00039_
+ net354 VSS VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[108\]$_DFFE_PN0P_ clknet_leaf_4_clk _00040_
+ net354 VSS VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[109\]$_DFFE_PN0P_ clknet_leaf_1_clk _00041_
+ net354 VSS VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[10\]$_DFFE_PN0P_ clknet_leaf_45_clk _00042_
+ net354 VSS VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[110\]$_DFFE_PN0P_ clknet_leaf_4_clk _00043_
+ net354 VSS VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[111\]$_DFFE_PN0P_ clknet_leaf_31_clk _00044_
+ net354 VSS VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[112\]$_DFFE_PN0P_ clknet_leaf_44_clk _00045_
+ net353 VSS VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[113\]$_DFFE_PN0P_ clknet_leaf_51_clk _00046_
+ net353 VSS VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[114\]$_DFFE_PN0P_ clknet_leaf_8_clk _00047_
+ net355 VSS VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[115\]$_DFFE_PN0P_ clknet_leaf_11_clk _00048_
+ net355 VSS VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[116\]$_DFFE_PN0P_ clknet_leaf_10_clk _00049_
+ net355 VSS VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[117\]$_DFFE_PN0P_ clknet_leaf_8_clk _00050_
+ net355 VSS VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[118\]$_DFFE_PN0P_ clknet_leaf_11_clk _00051_
+ net355 VSS VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[119\]$_DFFE_PN0P_ clknet_leaf_12_clk _00052_
+ net355 VSS VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[11\]$_DFFE_PN0P_ clknet_leaf_11_clk _00053_
+ net355 VSS VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[120\]$_DFFE_PN0P_ clknet_leaf_12_clk _00054_
+ net355 VSS VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[121\]$_DFFE_PN0P_ clknet_leaf_12_clk _00055_
+ net355 VSS VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[122\]$_DFFE_PN0P_ clknet_leaf_8_clk _00056_
+ net355 VSS VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[123\]$_DFFE_PN0P_ clknet_leaf_52_clk _00057_
+ net353 VSS VSS VDD VDD net121 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[124\]$_DFFE_PN0P_ clknet_leaf_43_clk _00058_
+ net353 VSS VSS VDD VDD net122 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[125\]$_DFFE_PN0P_ clknet_leaf_52_clk _00059_
+ net353 VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[126\]$_DFFE_PN0P_ clknet_leaf_52_clk _00060_
+ net353 VSS VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[127\]$_DFFE_PN0P_ clknet_leaf_43_clk _00061_
+ net353 VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[12\]$_DFFE_PN0P_ clknet_leaf_49_clk _00062_
+ net353 VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[13\]$_DFFE_PN0P_ clknet_leaf_48_clk _00063_
+ net353 VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[14\]$_DFFE_PN0P_ clknet_leaf_50_clk _00064_
+ net353 VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[15\]$_DFFE_PN0P_ clknet_leaf_48_clk _00065_
+ net353 VSS VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[16\]$_DFFE_PN0P_ clknet_leaf_43_clk _00066_
+ net353 VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[17\]$_DFFE_PN0P_ clknet_leaf_46_clk _00067_
+ net354 VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[18\]$_DFFE_PN0P_ clknet_leaf_4_clk _00068_
+ net354 VSS VSS VDD VDD net132 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[19\]$_DFFE_PN0P_ clknet_leaf_8_clk _00069_
+ net355 VSS VSS VDD VDD net133 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[1\]$_DFFE_PN0P_ clknet_leaf_46_clk _00070_
+ net354 VSS VSS VDD VDD net134 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[20\]$_DFFE_PN0P_ clknet_leaf_2_clk _00071_
+ net354 VSS VSS VDD VDD net135 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[21\]$_DFFE_PN0P_ clknet_leaf_10_clk _00072_
+ net355 VSS VSS VDD VDD net136 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[22\]$_DFFE_PN0P_ clknet_leaf_9_clk _00073_
+ net355 VSS VSS VDD VDD net137 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[23\]$_DFFE_PN0P_ clknet_leaf_13_clk _00074_
+ net355 VSS VSS VDD VDD net138 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[24\]$_DFFE_PN0P_ clknet_leaf_13_clk _00075_
+ net355 VSS VSS VDD VDD net139 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[25\]$_DFFE_PN0P_ clknet_leaf_13_clk _00076_
+ net355 VSS VSS VDD VDD net140 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[26\]$_DFFE_PN0P_ clknet_leaf_51_clk _00077_
+ net353 VSS VSS VDD VDD net141 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[27\]$_DFFE_PN0P_ clknet_leaf_47_clk _00078_
+ net353 VSS VSS VDD VDD net142 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[28\]$_DFFE_PN0P_ clknet_leaf_41_clk _00079_
+ net353 VSS VSS VDD VDD net143 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[29\]$_DFFE_PN0P_ clknet_leaf_48_clk _00080_
+ net353 VSS VSS VDD VDD net144 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[2\]$_DFFE_PN0P_ clknet_leaf_40_clk _00081_
+ net92 VSS VSS VDD VDD net145 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[30\]$_DFFE_PN0P_ clknet_leaf_52_clk _00082_
+ net353 VSS VSS VDD VDD net146 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[31\]$_DFFE_PN0P_ clknet_leaf_40_clk _00083_
+ net92 VSS VSS VDD VDD net147 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[32\]$_DFFE_PN0P_ clknet_leaf_40_clk _00084_
+ net92 VSS VSS VDD VDD net148 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[33\]$_DFFE_PN0P_ clknet_leaf_52_clk _00085_
+ net353 VSS VSS VDD VDD net149 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[34\]$_DFFE_PN0P_ clknet_leaf_51_clk _00086_
+ net353 VSS VSS VDD VDD net150 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[35\]$_DFFE_PN0P_ clknet_leaf_10_clk _00087_
+ net355 VSS VSS VDD VDD net151 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[36\]$_DFFE_PN0P_ clknet_leaf_9_clk _00088_
+ net355 VSS VSS VDD VDD net152 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[37\]$_DFFE_PN0P_ clknet_leaf_10_clk _00089_
+ net355 VSS VSS VDD VDD net153 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[38\]$_DFFE_PN0P_ clknet_leaf_8_clk _00090_
+ net355 VSS VSS VDD VDD net154 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[39\]$_DFFE_PN0P_ clknet_leaf_8_clk _00091_
+ net355 VSS VSS VDD VDD net155 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[3\]$_DFFE_PN0P_ clknet_leaf_50_clk _00092_
+ net353 VSS VSS VDD VDD net156 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[40\]$_DFFE_PN0P_ clknet_leaf_10_clk _00093_
+ net355 VSS VSS VDD VDD net157 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[41\]$_DFFE_PN0P_ clknet_leaf_8_clk _00094_
+ net355 VSS VSS VDD VDD net158 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[42\]$_DFFE_PN0P_ clknet_leaf_51_clk _00095_
+ net353 VSS VSS VDD VDD net159 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[43\]$_DFFE_PN0P_ clknet_leaf_51_clk _00096_
+ net353 VSS VSS VDD VDD net160 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[44\]$_DFFE_PN0P_ clknet_leaf_41_clk _00097_
+ net353 VSS VSS VDD VDD net161 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[45\]$_DFFE_PN0P_ clknet_leaf_47_clk _00098_
+ net353 VSS VSS VDD VDD net162 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[46\]$_DFFE_PN0P_ clknet_leaf_50_clk _00099_
+ net353 VSS VSS VDD VDD net163 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[47\]$_DFFE_PN0P_ clknet_leaf_41_clk _00100_
+ net353 VSS VSS VDD VDD net164 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[48\]$_DFFE_PN0P_ clknet_leaf_40_clk _00101_
+ net353 VSS VSS VDD VDD net165 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[49\]$_DFFE_PN0P_ clknet_leaf_52_clk _00102_
+ net353 VSS VSS VDD VDD net166 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[4\]$_DFFE_PN0P_ clknet_leaf_52_clk _00103_
+ net353 VSS VSS VDD VDD net167 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[50\]$_DFFE_PN0P_ clknet_leaf_53_clk _00104_
+ net353 VSS VSS VDD VDD net168 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[51\]$_DFFE_PN0P_ clknet_leaf_53_clk _00105_
+ net353 VSS VSS VDD VDD net169 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[52\]$_DFFE_PN0P_ clknet_leaf_53_clk _00106_
+ net353 VSS VSS VDD VDD net170 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[53\]$_DFFE_PN0P_ clknet_leaf_1_clk _00107_
+ net354 VSS VSS VDD VDD net171 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[54\]$_DFFE_PN0P_ clknet_leaf_7_clk _00108_
+ net355 VSS VSS VDD VDD net172 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[55\]$_DFFE_PN0P_ clknet_leaf_7_clk _00109_
+ net355 VSS VSS VDD VDD net173 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[56\]$_DFFE_PN0P_ clknet_leaf_7_clk _00110_
+ net355 VSS VSS VDD VDD net174 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[57\]$_DFFE_PN0P_ clknet_leaf_1_clk _00111_
+ net354 VSS VSS VDD VDD net175 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[58\]$_DFFE_PN0P_ clknet_leaf_52_clk _00112_
+ net353 VSS VSS VDD VDD net176 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[59\]$_DFFE_PN0P_ clknet_leaf_54_clk _00113_
+ net353 VSS VSS VDD VDD net177 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[5\]$_DFFE_PN0P_ clknet_leaf_52_clk _00114_
+ net353 VSS VSS VDD VDD net178 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[60\]$_DFFE_PN0P_ clknet_leaf_54_clk _00115_
+ net353 VSS VSS VDD VDD net179 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[61\]$_DFFE_PN0P_ clknet_leaf_52_clk _00116_
+ net353 VSS VSS VDD VDD net180 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[62\]$_DFFE_PN0P_ clknet_leaf_8_clk _00117_
+ net355 VSS VSS VDD VDD net181 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[63\]$_DFFE_PN0P_ clknet_leaf_20_clk _00118_
+ net356 VSS VSS VDD VDD net182 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[64\]$_DFFE_PN0P_ clknet_leaf_20_clk _00119_
+ net356 VSS VSS VDD VDD net183 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[65\]$_DFFE_PN0P_ clknet_leaf_11_clk _00120_
+ net356 VSS VSS VDD VDD net184 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[66\]$_DFFE_PN0P_ clknet_leaf_12_clk _00121_
+ net356 VSS VSS VDD VDD net185 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[67\]$_DFFE_PN0P_ clknet_leaf_12_clk _00122_
+ net356 VSS VSS VDD VDD net186 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[68\]$_DFFE_PN0P_ clknet_leaf_11_clk _00123_
+ net356 VSS VSS VDD VDD net187 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[69\]$_DFFE_PN0P_ clknet_leaf_11_clk _00124_
+ net355 VSS VSS VDD VDD net188 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[6\]$_DFFE_PN0P_ clknet_leaf_11_clk _00125_
+ net355 VSS VSS VDD VDD net189 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[70\]$_DFFE_PN0P_ clknet_leaf_11_clk _00126_
+ net356 VSS VSS VDD VDD net190 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[71\]$_DFFE_PN0P_ clknet_leaf_12_clk _00127_
+ net356 VSS VSS VDD VDD net191 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[72\]$_DFFE_PN0P_ clknet_leaf_20_clk _00128_
+ net356 VSS VSS VDD VDD net192 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[73\]$_DFFE_PN0P_ clknet_leaf_12_clk _00129_
+ net356 VSS VSS VDD VDD net193 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[74\]$_DFFE_PN0P_ clknet_leaf_10_clk _00130_
+ net355 VSS VSS VDD VDD net194 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[75\]$_DFFE_PN0P_ clknet_leaf_10_clk _00131_
+ net355 VSS VSS VDD VDD net195 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[76\]$_DFFE_PN0P_ clknet_leaf_13_clk _00132_
+ net355 VSS VSS VDD VDD net196 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[77\]$_DFFE_PN0P_ clknet_leaf_12_clk _00133_
+ net355 VSS VSS VDD VDD net197 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[78\]$_DFFE_PN0P_ clknet_leaf_11_clk _00134_
+ net356 VSS VSS VDD VDD net198 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[79\]$_DFFE_PN0P_ clknet_leaf_19_clk _00135_
+ net355 VSS VSS VDD VDD net199 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[7\]$_DFFE_PN0P_ clknet_leaf_13_clk _00136_
+ net355 VSS VSS VDD VDD net200 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[80\]$_DFFE_PN0P_ clknet_leaf_19_clk _00137_
+ net355 VSS VSS VDD VDD net201 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[81\]$_DFFE_PN0P_ clknet_leaf_10_clk _00138_
+ net355 VSS VSS VDD VDD net202 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[82\]$_DFFE_PN0P_ clknet_leaf_12_clk _00139_
+ net355 VSS VSS VDD VDD net203 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[83\]$_DFFE_PN0P_ clknet_leaf_12_clk _00140_
+ net355 VSS VSS VDD VDD net204 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[84\]$_DFFE_PN0P_ clknet_leaf_10_clk _00141_
+ net355 VSS VSS VDD VDD net205 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[85\]$_DFFE_PN0P_ clknet_leaf_10_clk _00142_
+ net355 VSS VSS VDD VDD net206 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[86\]$_DFFE_PN0P_ clknet_leaf_11_clk _00143_
+ net355 VSS VSS VDD VDD net207 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[87\]$_DFFE_PN0P_ clknet_leaf_13_clk _00144_
+ net355 VSS VSS VDD VDD net208 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[88\]$_DFFE_PN0P_ clknet_leaf_13_clk _00145_
+ net355 VSS VSS VDD VDD net209 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[89\]$_DFFE_PN0P_ clknet_leaf_13_clk _00146_
+ net355 VSS VSS VDD VDD net210 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[8\]$_DFFE_PN0P_ clknet_leaf_48_clk _00147_
+ net353 VSS VSS VDD VDD net211 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[90\]$_DFFE_PN0P_ clknet_leaf_50_clk _00148_
+ net353 VSS VSS VDD VDD net212 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[91\]$_DFFE_PN0P_ clknet_leaf_50_clk _00149_
+ net353 VSS VSS VDD VDD net213 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[92\]$_DFFE_PN0P_ clknet_leaf_42_clk _00150_
+ net353 VSS VSS VDD VDD net214 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[93\]$_DFFE_PN0P_ clknet_leaf_48_clk _00151_
+ net353 VSS VSS VDD VDD net215 sky130_fd_sc_hd__dfrtp_4
Xdata_out_imag\[94\]$_DFFE_PN0P_ clknet_leaf_50_clk _00152_
+ net353 VSS VSS VDD VDD net216 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[95\]$_DFFE_PN0P_ clknet_leaf_42_clk _00153_
+ net353 VSS VSS VDD VDD net217 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[96\]$_DFFE_PN0P_ clknet_leaf_48_clk _00154_
+ net353 VSS VSS VDD VDD net218 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[97\]$_DFFE_PN0P_ clknet_leaf_50_clk _00155_
+ net353 VSS VSS VDD VDD net219 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[98\]$_DFFE_PN0P_ clknet_leaf_49_clk _00156_
+ net353 VSS VSS VDD VDD net220 sky130_fd_sc_hd__dfrtp_2
Xdata_out_imag\[99\]$_DFFE_PN0P_ clknet_leaf_13_clk _00157_
+ net355 VSS VSS VDD VDD net221 sky130_fd_sc_hd__dfrtp_1
Xdata_out_imag\[9\]$_DFFE_PN0P_ clknet_leaf_19_clk _00158_
+ net355 VSS VSS VDD VDD net222 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[0\]$_DFFE_PN0P_ clknet_leaf_19_clk _00159_
+ net355 VSS VSS VDD VDD net223 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[100\]$_DFFE_PN0P_ clknet_leaf_25_clk _00160_
+ net356 VSS VSS VDD VDD net224 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[101\]$_DFFE_PN0P_ clknet_leaf_25_clk _00161_
+ net356 VSS VSS VDD VDD net225 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[102\]$_DFFE_PN0P_ clknet_leaf_21_clk _00162_
+ net356 VSS VSS VDD VDD net226 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[103\]$_DFFE_PN0P_ clknet_leaf_24_clk _00163_
+ net356 VSS VSS VDD VDD net227 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[104\]$_DFFE_PN0P_ clknet_leaf_23_clk _00164_
+ net356 VSS VSS VDD VDD net228 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[105\]$_DFFE_PN0P_ clknet_leaf_21_clk _00165_
+ net356 VSS VSS VDD VDD net229 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[106\]$_DFFE_PN0P_ clknet_leaf_22_clk _00166_
+ net356 VSS VSS VDD VDD net230 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[107\]$_DFFE_PN0P_ clknet_leaf_26_clk _00167_
+ net356 VSS VSS VDD VDD net231 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[108\]$_DFFE_PN0P_ clknet_leaf_25_clk _00168_
+ net356 VSS VSS VDD VDD net232 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[109\]$_DFFE_PN0P_ clknet_leaf_25_clk _00169_
+ net356 VSS VSS VDD VDD net233 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[10\]$_DFFE_PN0P_ clknet_leaf_21_clk _00170_
+ net356 VSS VSS VDD VDD net234 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[110\]$_DFFE_PN0P_ clknet_leaf_22_clk _00171_
+ net356 VSS VSS VDD VDD net235 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[111\]$_DFFE_PN0P_ clknet_leaf_19_clk _00172_
+ net356 VSS VSS VDD VDD net236 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[112\]$_DFFE_PN0P_ clknet_leaf_19_clk _00173_
+ net355 VSS VSS VDD VDD net237 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[113\]$_DFFE_PN0P_ clknet_leaf_19_clk _00174_
+ net356 VSS VSS VDD VDD net238 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[114\]$_DFFE_PN0P_ clknet_leaf_25_clk _00175_
+ net356 VSS VSS VDD VDD net239 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[115\]$_DFFE_PN0P_ clknet_leaf_25_clk _00176_
+ net356 VSS VSS VDD VDD net240 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[116\]$_DFFE_PN0P_ clknet_leaf_26_clk _00177_
+ net356 VSS VSS VDD VDD net241 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[117\]$_DFFE_PN0P_ clknet_leaf_26_clk _00178_
+ net356 VSS VSS VDD VDD net242 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[118\]$_DFFE_PN0P_ clknet_leaf_21_clk _00179_
+ net356 VSS VSS VDD VDD net243 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[119\]$_DFFE_PN0P_ clknet_leaf_26_clk _00180_
+ net356 VSS VSS VDD VDD net244 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[11\]$_DFFE_PN0P_ clknet_leaf_27_clk _00181_
+ net356 VSS VSS VDD VDD net245 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[120\]$_DFFE_PN0P_ clknet_leaf_26_clk _00182_
+ net356 VSS VSS VDD VDD net246 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[121\]$_DFFE_PN0P_ clknet_leaf_22_clk _00183_
+ net356 VSS VSS VDD VDD net247 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[122\]$_DFFE_PN0P_ clknet_leaf_18_clk _00184_
+ net356 VSS VSS VDD VDD net248 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[123\]$_DFFE_PN0P_ clknet_leaf_26_clk _00185_
+ net356 VSS VSS VDD VDD net249 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[124\]$_DFFE_PN0P_ clknet_leaf_23_clk _00186_
+ net356 VSS VSS VDD VDD net250 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[125\]$_DFFE_PN0P_ clknet_leaf_22_clk _00187_
+ net356 VSS VSS VDD VDD net251 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[126\]$_DFFE_PN0P_ clknet_leaf_21_clk _00188_
+ net356 VSS VSS VDD VDD net252 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[127\]$_DFFE_PN0P_ clknet_leaf_40_clk _00189_
+ net92 VSS VSS VDD VDD net253 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[12\]$_DFFE_PN0P_ clknet_leaf_39_clk _00190_
+ net92 VSS VSS VDD VDD net254 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[13\]$_DFFE_PN0P_ clknet_leaf_40_clk _00191_
+ net92 VSS VSS VDD VDD net255 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[14\]$_DFFE_PN0P_ clknet_leaf_35_clk _00192_
+ net354 VSS VSS VDD VDD net256 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[15\]$_DFFE_PN0P_ clknet_leaf_40_clk _00193_
+ net353 VSS VSS VDD VDD net257 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[16\]$_DFFE_PN0P_ clknet_leaf_40_clk _00194_
+ net92 VSS VSS VDD VDD net258 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[17\]$_DFFE_PN0P_ clknet_leaf_36_clk _00195_
+ net353 VSS VSS VDD VDD net259 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[18\]$_DFFE_PN0P_ clknet_leaf_35_clk _00196_
+ net354 VSS VSS VDD VDD net260 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[19\]$_DFFE_PN0P_ clknet_leaf_37_clk _00197_
+ net92 VSS VSS VDD VDD net261 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[1\]$_DFFE_PN0P_ clknet_leaf_34_clk _00198_
+ net354 VSS VSS VDD VDD net262 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[20\]$_DFFE_PN0P_ clknet_leaf_35_clk _00199_
+ net354 VSS VSS VDD VDD net263 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[21\]$_DFFE_PN0P_ clknet_leaf_37_clk _00200_
+ net92 VSS VSS VDD VDD net264 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[22\]$_DFFE_PN0P_ clknet_leaf_37_clk _00201_
+ net92 VSS VSS VDD VDD net265 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[23\]$_DFFE_PN0P_ clknet_leaf_39_clk _00202_
+ net92 VSS VSS VDD VDD net266 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[24\]$_DFFE_PN0P_ clknet_leaf_34_clk _00203_
+ net354 VSS VSS VDD VDD net267 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[25\]$_DFFE_PN0P_ clknet_leaf_37_clk _00204_
+ net92 VSS VSS VDD VDD net268 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[26\]$_DFFE_PN0P_ clknet_leaf_35_clk _00205_
+ net354 VSS VSS VDD VDD net269 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[27\]$_DFFE_PN0P_ clknet_leaf_38_clk _00206_
+ net92 VSS VSS VDD VDD net270 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[28\]$_DFFE_PN0P_ clknet_leaf_40_clk _00207_
+ net92 VSS VSS VDD VDD net271 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[29\]$_DFFE_PN0P_ clknet_leaf_40_clk _00208_
+ net92 VSS VSS VDD VDD net272 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[2\]$_DFFE_PN0P_ clknet_leaf_38_clk _00209_
+ net92 VSS VSS VDD VDD net273 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[30\]$_DFFE_PN0P_ clknet_leaf_38_clk _00210_
+ net92 VSS VSS VDD VDD net274 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[31\]$_DFFE_PN0P_ clknet_leaf_40_clk _00211_
+ net92 VSS VSS VDD VDD net275 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[32\]$_DFFE_PN0P_ clknet_leaf_43_clk _00212_
+ net353 VSS VSS VDD VDD net276 sky130_fd_sc_hd__dfrtp_2
Xdata_out_real\[33\]$_DFFE_PN0P_ clknet_leaf_40_clk _00213_
+ net92 VSS VSS VDD VDD net277 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[34\]$_DFFE_PN0P_ clknet_leaf_39_clk _00214_
+ net92 VSS VSS VDD VDD net278 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[35\]$_DFFE_PN0P_ clknet_leaf_38_clk _00215_
+ net92 VSS VSS VDD VDD net279 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[36\]$_DFFE_PN0P_ clknet_leaf_38_clk _00216_
+ net92 VSS VSS VDD VDD net280 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[37\]$_DFFE_PN0P_ clknet_leaf_37_clk _00217_
+ net92 VSS VSS VDD VDD net281 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[38\]$_DFFE_PN0P_ clknet_leaf_39_clk _00218_
+ net92 VSS VSS VDD VDD net282 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[39\]$_DFFE_PN0P_ clknet_leaf_38_clk _00219_
+ net92 VSS VSS VDD VDD net283 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[3\]$_DFFE_PN0P_ clknet_leaf_38_clk _00220_
+ net92 VSS VSS VDD VDD net284 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[40\]$_DFFE_PN0P_ clknet_leaf_37_clk _00221_
+ net92 VSS VSS VDD VDD net285 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[41\]$_DFFE_PN0P_ clknet_leaf_38_clk _00222_
+ net92 VSS VSS VDD VDD net286 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[42\]$_DFFE_PN0P_ clknet_leaf_37_clk _00223_
+ net92 VSS VSS VDD VDD net287 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[43\]$_DFFE_PN0P_ clknet_leaf_39_clk _00224_
+ net92 VSS VSS VDD VDD net288 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[44\]$_DFFE_PN0P_ clknet_leaf_37_clk _00225_
+ net92 VSS VSS VDD VDD net289 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[45\]$_DFFE_PN0P_ clknet_leaf_38_clk _00226_
+ net92 VSS VSS VDD VDD net290 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[46\]$_DFFE_PN0P_ clknet_leaf_38_clk _00227_
+ net92 VSS VSS VDD VDD net291 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[47\]$_DFFE_PN0P_ clknet_leaf_38_clk _00228_
+ net92 VSS VSS VDD VDD net292 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[48\]$_DFFE_PN0P_ clknet_leaf_39_clk _00229_
+ net92 VSS VSS VDD VDD net293 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[49\]$_DFFE_PN0P_ clknet_leaf_34_clk _00230_
+ net92 VSS VSS VDD VDD net294 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[4\]$_DFFE_PN0P_ clknet_leaf_39_clk _00231_
+ net92 VSS VSS VDD VDD net295 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[50\]$_DFFE_PN0P_ clknet_leaf_39_clk _00232_
+ net92 VSS VSS VDD VDD net296 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[51\]$_DFFE_PN0P_ clknet_leaf_38_clk _00233_
+ net92 VSS VSS VDD VDD net297 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[52\]$_DFFE_PN0P_ clknet_leaf_34_clk _00234_
+ net92 VSS VSS VDD VDD net298 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[53\]$_DFFE_PN0P_ clknet_leaf_39_clk _00235_
+ net92 VSS VSS VDD VDD net299 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[54\]$_DFFE_PN0P_ clknet_leaf_39_clk _00236_
+ net92 VSS VSS VDD VDD net300 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[55\]$_DFFE_PN0P_ clknet_leaf_34_clk _00237_
+ net92 VSS VSS VDD VDD net301 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[56\]$_DFFE_PN0P_ clknet_leaf_34_clk _00238_
+ net354 VSS VSS VDD VDD net302 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[57\]$_DFFE_PN0P_ clknet_leaf_34_clk _00239_
+ net92 VSS VSS VDD VDD net303 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[58\]$_DFFE_PN0P_ clknet_leaf_33_clk _00240_
+ net357 VSS VSS VDD VDD net304 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[59\]$_DFFE_PN0P_ clknet_leaf_29_clk _00241_
+ net357 VSS VSS VDD VDD net305 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[5\]$_DFFE_PN0P_ clknet_leaf_34_clk _00242_
+ net92 VSS VSS VDD VDD net306 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[60\]$_DFFE_PN0P_ clknet_leaf_33_clk _00243_
+ net357 VSS VSS VDD VDD net307 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[61\]$_DFFE_PN0P_ clknet_leaf_34_clk _00244_
+ net92 VSS VSS VDD VDD net308 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[62\]$_DFFE_PN0P_ clknet_leaf_34_clk _00245_
+ net92 VSS VSS VDD VDD net309 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[63\]$_DFFE_PN0P_ clknet_leaf_33_clk _00246_
+ net357 VSS VSS VDD VDD net310 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[64\]$_DFFE_PN0P_ clknet_leaf_20_clk _00247_
+ net356 VSS VSS VDD VDD net311 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[65\]$_DFFE_PN0P_ clknet_leaf_20_clk _00248_
+ net356 VSS VSS VDD VDD net312 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[66\]$_DFFE_PN0P_ clknet_leaf_24_clk _00249_
+ net356 VSS VSS VDD VDD net313 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[67\]$_DFFE_PN0P_ clknet_leaf_24_clk _00250_
+ net356 VSS VSS VDD VDD net314 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[68\]$_DFFE_PN0P_ clknet_leaf_25_clk _00251_
+ net356 VSS VSS VDD VDD net315 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[69\]$_DFFE_PN0P_ clknet_leaf_25_clk _00252_
+ net356 VSS VSS VDD VDD net316 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[6\]$_DFFE_PN0P_ clknet_leaf_21_clk _00253_
+ net356 VSS VSS VDD VDD net317 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[70\]$_DFFE_PN0P_ clknet_leaf_21_clk _00254_
+ net356 VSS VSS VDD VDD net318 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[71\]$_DFFE_PN0P_ clknet_leaf_24_clk _00255_
+ net356 VSS VSS VDD VDD net319 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[72\]$_DFFE_PN0P_ clknet_leaf_24_clk _00256_
+ net356 VSS VSS VDD VDD net320 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[73\]$_DFFE_PN0P_ clknet_leaf_21_clk _00257_
+ net356 VSS VSS VDD VDD net321 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[74\]$_DFFE_PN0P_ clknet_leaf_20_clk _00258_
+ net356 VSS VSS VDD VDD net322 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[75\]$_DFFE_PN0P_ clknet_leaf_24_clk _00259_
+ net356 VSS VSS VDD VDD net323 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[76\]$_DFFE_PN0P_ clknet_leaf_24_clk _00260_
+ net356 VSS VSS VDD VDD net324 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[77\]$_DFFE_PN0P_ clknet_leaf_21_clk _00261_
+ net356 VSS VSS VDD VDD net325 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[78\]$_DFFE_PN0P_ clknet_leaf_21_clk _00262_
+ net356 VSS VSS VDD VDD net326 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[79\]$_DFFE_PN0P_ clknet_leaf_20_clk _00263_
+ net356 VSS VSS VDD VDD net327 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[7\]$_DFFE_PN0P_ clknet_leaf_24_clk _00264_
+ net356 VSS VSS VDD VDD net328 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[80\]$_DFFE_PN0P_ clknet_leaf_20_clk _00265_
+ net356 VSS VSS VDD VDD net329 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[81\]$_DFFE_PN0P_ clknet_leaf_20_clk _00266_
+ net356 VSS VSS VDD VDD net330 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[82\]$_DFFE_PN0P_ clknet_leaf_26_clk _00267_
+ net356 VSS VSS VDD VDD net331 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[83\]$_DFFE_PN0P_ clknet_leaf_27_clk _00268_
+ net356 VSS VSS VDD VDD net332 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[84\]$_DFFE_PN0P_ clknet_leaf_26_clk _00269_
+ net356 VSS VSS VDD VDD net333 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[85\]$_DFFE_PN0P_ clknet_leaf_27_clk _00270_
+ net356 VSS VSS VDD VDD net334 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[86\]$_DFFE_PN0P_ clknet_leaf_28_clk _00271_
+ net356 VSS VSS VDD VDD net335 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[87\]$_DFFE_PN0P_ clknet_leaf_27_clk _00272_
+ net356 VSS VSS VDD VDD net336 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[88\]$_DFFE_PN0P_ clknet_leaf_27_clk _00273_
+ net356 VSS VSS VDD VDD net337 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[89\]$_DFFE_PN0P_ clknet_leaf_29_clk _00274_
+ net356 VSS VSS VDD VDD net338 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[8\]$_DFFE_PN0P_ clknet_leaf_29_clk _00275_
+ net356 VSS VSS VDD VDD net339 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[90\]$_DFFE_PN0P_ clknet_leaf_26_clk _00276_
+ net356 VSS VSS VDD VDD net340 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[91\]$_DFFE_PN0P_ clknet_leaf_25_clk _00277_
+ net356 VSS VSS VDD VDD net341 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[92\]$_DFFE_PN0P_ clknet_leaf_25_clk _00278_
+ net356 VSS VSS VDD VDD net342 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[93\]$_DFFE_PN0P_ clknet_leaf_25_clk _00279_
+ net356 VSS VSS VDD VDD net343 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[94\]$_DFFE_PN0P_ clknet_leaf_21_clk _00280_
+ net356 VSS VSS VDD VDD net344 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[95\]$_DFFE_PN0P_ clknet_leaf_20_clk _00281_
+ net356 VSS VSS VDD VDD net345 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[96\]$_DFFE_PN0P_ clknet_leaf_19_clk _00282_
+ net355 VSS VSS VDD VDD net346 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[97\]$_DFFE_PN0P_ clknet_leaf_19_clk _00283_
+ net355 VSS VSS VDD VDD net347 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[98\]$_DFFE_PN0P_ clknet_leaf_25_clk _00284_
+ net356 VSS VSS VDD VDD net348 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[99\]$_DFFE_PN0P_ clknet_leaf_25_clk _00285_
+ net356 VSS VSS VDD VDD net349 sky130_fd_sc_hd__dfrtp_1
Xdata_out_real\[9\]$_DFFE_PN0P_ clknet_leaf_21_clk _00286_
+ net356 VSS VSS VDD VDD net350 sky130_fd_sc_hd__dfrtp_1
Xdata_ready$_DFFE_PN1P_ clknet_leaf_7_clk _00287_ net355 VSS
+ VSS VDD VDD net351 sky130_fd_sc_hd__dfstp_1
Xdata_valid_out$_DFFE_PN0P_ clknet_leaf_7_clk _00288_ net355
+ VSS VSS VDD VDD net352 sky130_fd_sc_hd__dfrtp_1
Xgroup\[0\]$_DFFE_PP_ clknet_leaf_54_clk _00551_ _00007_ VSS
+ VSS VDD VDD group\[0\] sky130_fd_sc_hd__edfxtp_1
Xgroup\[1\]$_DFFE_PP_ clknet_leaf_52_clk net35 _00007_ VSS
+ VSS VDD VDD group\[1\] sky130_fd_sc_hd__edfxtp_1
Xgroup\[2\]$_DFFE_PP_ clknet_leaf_53_clk net434 _00007_ VSS
+ VSS VDD VDD group\[2\] sky130_fd_sc_hd__edfxtp_1
Xidx1\[0\]$_DFFE_PP_ clknet_leaf_0_clk _05879_ _00007_ VSS
+ VSS VDD VDD idx1\[0\] sky130_fd_sc_hd__edfxtp_1
Xidx1\[1\]$_DFFE_PP_ clknet_leaf_0_clk _05880_ _00007_ VSS
+ VSS VDD VDD idx1\[1\] sky130_fd_sc_hd__edfxtp_1
Xidx1\[2\]$_DFFE_PP_ clknet_leaf_0_clk _00013_ _00007_ VSS
+ VSS VDD VDD idx1\[2\] sky130_fd_sc_hd__edfxtp_1
Xidx2\[0\]$_DFFE_PP_ clknet_leaf_53_clk _05881_ _00007_ VSS
+ VSS VDD VDD idx2\[0\] sky130_fd_sc_hd__edfxtp_1
Xidx2\[1\]$_DFFE_PP_ clknet_leaf_54_clk _00014_ _00007_ VSS
+ VSS VDD VDD idx2\[1\] sky130_fd_sc_hd__edfxtp_1
Xidx2\[2\]$_DFFE_PP_ clknet_leaf_54_clk _00015_ _00007_ VSS
+ VSS VDD VDD idx2\[2\] sky130_fd_sc_hd__edfxtp_1
Xsample_count\[0\]$_DFFE_PN0P_ clknet_leaf_6_clk _00289_ net355
+ VSS VSS VDD VDD sample_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xsample_count\[1\]$_DFFE_PN0P_ clknet_leaf_6_clk _00290_ net355
+ VSS VSS VDD VDD sample_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xsample_count\[2\]$_DFFE_PN0P_ clknet_leaf_6_clk _00291_ net355
+ VSS VSS VDD VDD sample_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xsamples_imag\[0\]\[0\]$_DFFE_PN0P_ clknet_leaf_44_clk _00292_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[10\]$_DFFE_PN0P_ clknet_leaf_47_clk _00293_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[11\]$_DFFE_PN0P_ clknet_leaf_47_clk _00294_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[12\]$_DFFE_PN0P_ clknet_leaf_47_clk _00295_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[13\]$_DFFE_PN0P_ clknet_leaf_48_clk _00296_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[13\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[0\]\[14\]$_DFFE_PN0P_ clknet_leaf_50_clk _00297_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[14\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[0\]\[15\]$_DFFE_PN0P_ clknet_leaf_44_clk _00298_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[1\]$_DFFE_PN0P_ clknet_leaf_47_clk _00299_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[2\]$_DFFE_PN0P_ clknet_leaf_47_clk _00300_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[3\]$_DFFE_PN0P_ clknet_leaf_47_clk _00301_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[4\]$_DFFE_PN0P_ clknet_leaf_47_clk _00302_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[5\]$_DFFE_PN0P_ clknet_leaf_47_clk _00303_
+ net353 VSS VSS VDD VDD samples_imag\[0\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[6\]$_DFFE_PN0P_ clknet_leaf_46_clk _00304_
+ net354 VSS VSS VDD VDD samples_imag\[0\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[7\]$_DFFE_PN0P_ clknet_leaf_46_clk _00305_
+ net354 VSS VSS VDD VDD samples_imag\[0\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[8\]$_DFFE_PN0P_ clknet_leaf_46_clk _00306_
+ net354 VSS VSS VDD VDD samples_imag\[0\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[0\]\[9\]$_DFFE_PN0P_ clknet_leaf_45_clk _00307_
+ net354 VSS VSS VDD VDD samples_imag\[0\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[0\]$_DFFE_PN0P_ clknet_leaf_43_clk _00308_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[10\]$_DFFE_PN0P_ clknet_leaf_51_clk _00309_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[10\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[1\]\[11\]$_DFFE_PN0P_ clknet_leaf_2_clk _00310_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[11\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[1\]\[12\]$_DFFE_PN0P_ clknet_leaf_48_clk _00311_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[13\]$_DFFE_PN0P_ clknet_leaf_46_clk _00312_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[13\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[1\]\[14\]$_DFFE_PN0P_ clknet_leaf_51_clk _00313_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[15\]$_DFFE_PN0P_ clknet_leaf_44_clk _00314_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[1\]$_DFFE_PN0P_ clknet_leaf_2_clk _00315_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xsamples_imag\[1\]\[2\]$_DFFE_PN0P_ clknet_leaf_55_clk _00316_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[3\]$_DFFE_PN0P_ clknet_leaf_55_clk _00317_
+ net353 VSS VSS VDD VDD samples_imag\[1\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[4\]$_DFFE_PN0P_ clknet_leaf_2_clk _00318_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xsamples_imag\[1\]\[5\]$_DFFE_PN0P_ clknet_leaf_55_clk _00319_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[6\]$_DFFE_PN0P_ clknet_leaf_0_clk _00320_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[7\]$_DFFE_PN0P_ clknet_leaf_45_clk _00321_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[8\]$_DFFE_PN0P_ clknet_leaf_46_clk _00322_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[1\]\[9\]$_DFFE_PN0P_ clknet_leaf_46_clk _00323_
+ net354 VSS VSS VDD VDD samples_imag\[1\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[0\]$_DFFE_PN0P_ clknet_leaf_42_clk _00324_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[10\]$_DFFE_PN0P_ clknet_leaf_50_clk _00325_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[11\]$_DFFE_PN0P_ clknet_leaf_50_clk _00326_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[12\]$_DFFE_PN0P_ clknet_leaf_48_clk _00327_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[13\]$_DFFE_PN0P_ clknet_leaf_47_clk _00328_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[13\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[2\]\[14\]$_DFFE_PN0P_ clknet_leaf_50_clk _00329_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[15\]$_DFFE_PN0P_ clknet_leaf_42_clk _00330_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[1\]$_DFFE_PN0P_ clknet_leaf_51_clk _00331_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[2\]$_DFFE_PN0P_ clknet_leaf_51_clk _00332_
+ net353 VSS VSS VDD VDD samples_imag\[2\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[3\]$_DFFE_PN0P_ clknet_leaf_2_clk _00333_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[4\]$_DFFE_PN0P_ clknet_leaf_2_clk _00334_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[5\]$_DFFE_PN0P_ clknet_leaf_1_clk _00335_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[6\]$_DFFE_PN0P_ clknet_leaf_2_clk _00336_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[7\]$_DFFE_PN0P_ clknet_leaf_2_clk _00337_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[8\]$_DFFE_PN0P_ clknet_leaf_45_clk _00338_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[2\]\[9\]$_DFFE_PN0P_ clknet_leaf_1_clk _00339_
+ net354 VSS VSS VDD VDD samples_imag\[2\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[0\]$_DFFE_PN0P_ clknet_leaf_42_clk _00340_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[10\]$_DFFE_PN0P_ clknet_leaf_54_clk _00341_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[11\]$_DFFE_PN0P_ clknet_leaf_54_clk _00342_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[12\]$_DFFE_PN0P_ clknet_leaf_54_clk _00343_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[13\]$_DFFE_PN0P_ clknet_leaf_54_clk _00344_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[14\]$_DFFE_PN0P_ clknet_leaf_55_clk _00345_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[15\]$_DFFE_PN0P_ clknet_leaf_31_clk _00346_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[1\]$_DFFE_PN0P_ clknet_leaf_55_clk _00347_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[2\]$_DFFE_PN0P_ clknet_leaf_54_clk _00348_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[3\]$_DFFE_PN0P_ clknet_leaf_55_clk _00349_
+ net353 VSS VSS VDD VDD samples_imag\[3\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[4\]$_DFFE_PN0P_ clknet_leaf_55_clk _00350_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[5\]$_DFFE_PN0P_ clknet_leaf_55_clk _00351_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[6\]$_DFFE_PN0P_ clknet_leaf_2_clk _00352_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[7\]$_DFFE_PN0P_ clknet_leaf_1_clk _00353_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[8\]$_DFFE_PN0P_ clknet_leaf_1_clk _00354_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[3\]\[9\]$_DFFE_PN0P_ clknet_leaf_1_clk _00355_
+ net354 VSS VSS VDD VDD samples_imag\[3\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[0\]$_DFFE_PN0P_ clknet_leaf_18_clk _00356_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[10\]$_DFFE_PN0P_ clknet_leaf_10_clk _00357_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[11\]$_DFFE_PN0P_ clknet_leaf_10_clk _00358_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[12\]$_DFFE_PN0P_ clknet_leaf_14_clk _00359_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[12\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[4\]\[13\]$_DFFE_PN0P_ clknet_leaf_14_clk _00360_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[14\]$_DFFE_PN0P_ clknet_leaf_9_clk _00361_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[15\]$_DFFE_PN0P_ clknet_leaf_18_clk _00362_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[1\]$_DFFE_PN0P_ clknet_leaf_10_clk _00363_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[2\]$_DFFE_PN0P_ clknet_leaf_13_clk _00364_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[3\]$_DFFE_PN0P_ clknet_leaf_14_clk _00365_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[3\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[4\]\[4\]$_DFFE_PN0P_ clknet_leaf_9_clk _00366_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[5\]$_DFFE_PN0P_ clknet_leaf_9_clk _00367_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[6\]$_DFFE_PN0P_ clknet_leaf_14_clk _00368_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[7\]$_DFFE_PN0P_ clknet_leaf_13_clk _00369_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[7\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[4\]\[8\]$_DFFE_PN0P_ clknet_leaf_13_clk _00370_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[4\]\[9\]$_DFFE_PN0P_ clknet_leaf_14_clk _00371_
+ net355 VSS VSS VDD VDD samples_imag\[4\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[0\]$_DFFE_PN0P_ clknet_leaf_16_clk _00372_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[10\]$_DFFE_PN0P_ clknet_leaf_3_clk _00373_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[11\]$_DFFE_PN0P_ clknet_leaf_3_clk _00374_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[12\]$_DFFE_PN0P_ clknet_leaf_16_clk _00375_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[13\]$_DFFE_PN0P_ clknet_leaf_15_clk _00376_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[14\]$_DFFE_PN0P_ clknet_leaf_3_clk _00377_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[15\]$_DFFE_PN0P_ clknet_leaf_16_clk _00378_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[1\]$_DFFE_PN0P_ clknet_leaf_3_clk _00379_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[2\]$_DFFE_PN0P_ clknet_leaf_15_clk _00380_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[3\]$_DFFE_PN0P_ clknet_leaf_16_clk _00381_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[4\]$_DFFE_PN0P_ clknet_leaf_15_clk _00382_
+ net357 VSS VSS VDD VDD samples_imag\[5\]\[4\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[5\]\[5\]$_DFFE_PN0P_ clknet_leaf_15_clk _00383_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[6\]$_DFFE_PN0P_ clknet_leaf_15_clk _00384_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[6\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[5\]\[7\]$_DFFE_PN0P_ clknet_leaf_15_clk _00385_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[7\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[5\]\[8\]$_DFFE_PN0P_ clknet_leaf_15_clk _00386_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[5\]\[9\]$_DFFE_PN0P_ clknet_leaf_15_clk _00387_
+ net355 VSS VSS VDD VDD samples_imag\[5\]\[9\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[6\]\[0\]$_DFFE_PN0P_ clknet_leaf_16_clk _00388_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[10\]$_DFFE_PN0P_ clknet_leaf_3_clk _00389_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[11\]$_DFFE_PN0P_ clknet_leaf_3_clk _00390_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[12\]$_DFFE_PN0P_ clknet_leaf_5_clk _00391_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[13\]$_DFFE_PN0P_ clknet_leaf_4_clk _00392_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[14\]$_DFFE_PN0P_ clknet_leaf_5_clk _00393_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[15\]$_DFFE_PN0P_ clknet_leaf_16_clk _00394_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[15\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[6\]\[1\]$_DFFE_PN0P_ clknet_leaf_4_clk _00395_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[2\]$_DFFE_PN0P_ clknet_leaf_4_clk _00396_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[3\]$_DFFE_PN0P_ clknet_leaf_5_clk _00397_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[4\]$_DFFE_PN0P_ clknet_leaf_5_clk _00398_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[5\]$_DFFE_PN0P_ clknet_leaf_5_clk _00399_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[6\]$_DFFE_PN0P_ clknet_leaf_5_clk _00400_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[7\]$_DFFE_PN0P_ clknet_leaf_5_clk _00401_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[8\]$_DFFE_PN0P_ clknet_leaf_5_clk _00402_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[6\]\[9\]$_DFFE_PN0P_ clknet_leaf_5_clk _00403_
+ net357 VSS VSS VDD VDD samples_imag\[6\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[0\]$_DFFE_PN0P_ clknet_leaf_18_clk _00404_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[10\]$_DFFE_PN0P_ clknet_leaf_9_clk _00405_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[11\]$_DFFE_PN0P_ clknet_leaf_6_clk _00406_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[12\]$_DFFE_PN0P_ clknet_leaf_3_clk _00407_
+ net357 VSS VSS VDD VDD samples_imag\[7\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[13\]$_DFFE_PN0P_ clknet_leaf_3_clk _00408_
+ net357 VSS VSS VDD VDD samples_imag\[7\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[14\]$_DFFE_PN0P_ clknet_leaf_5_clk _00409_
+ net357 VSS VSS VDD VDD samples_imag\[7\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[15\]$_DFFE_PN0P_ clknet_leaf_16_clk _00410_
+ net357 VSS VSS VDD VDD samples_imag\[7\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[1\]$_DFFE_PN0P_ clknet_leaf_3_clk _00411_
+ net357 VSS VSS VDD VDD samples_imag\[7\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[2\]$_DFFE_PN0P_ clknet_leaf_9_clk _00412_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[3\]$_DFFE_PN0P_ clknet_leaf_9_clk _00413_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[4\]$_DFFE_PN0P_ clknet_leaf_9_clk _00414_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[5\]$_DFFE_PN0P_ clknet_leaf_9_clk _00415_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[6\]$_DFFE_PN0P_ clknet_leaf_14_clk _00416_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_imag\[7\]\[7\]$_DFFE_PN0P_ clknet_leaf_14_clk _00417_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[7\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[7\]\[8\]$_DFFE_PN0P_ clknet_leaf_14_clk _00418_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xsamples_imag\[7\]\[9\]$_DFFE_PN0P_ clknet_leaf_14_clk _00419_
+ net355 VSS VSS VDD VDD samples_imag\[7\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[0\]$_DFFE_PN0P_ clknet_leaf_44_clk _00420_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[10\]$_DFFE_PN0P_ clknet_leaf_43_clk _00421_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[11\]$_DFFE_PN0P_ clknet_leaf_32_clk _00422_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[12\]$_DFFE_PN0P_ clknet_leaf_32_clk _00423_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[13\]$_DFFE_PN0P_ clknet_leaf_32_clk _00424_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[14\]$_DFFE_PN0P_ clknet_leaf_31_clk _00425_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[15\]$_DFFE_PN0P_ clknet_leaf_43_clk _00426_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[1\]$_DFFE_PN0P_ clknet_leaf_45_clk _00427_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[2\]$_DFFE_PN0P_ clknet_leaf_41_clk _00428_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[3\]$_DFFE_PN0P_ clknet_leaf_41_clk _00429_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[4\]$_DFFE_PN0P_ clknet_leaf_36_clk _00430_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[5\]$_DFFE_PN0P_ clknet_leaf_36_clk _00431_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[6\]$_DFFE_PN0P_ clknet_leaf_32_clk _00432_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[7\]$_DFFE_PN0P_ clknet_leaf_36_clk _00433_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[8\]$_DFFE_PN0P_ clknet_leaf_36_clk _00434_
+ net354 VSS VSS VDD VDD samples_real\[0\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[0\]\[9\]$_DFFE_PN0P_ clknet_leaf_44_clk _00435_
+ net353 VSS VSS VDD VDD samples_real\[0\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[0\]$_DFFE_PN0P_ clknet_leaf_44_clk _00436_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[10\]$_DFFE_PN0P_ clknet_leaf_31_clk _00437_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[11\]$_DFFE_PN0P_ clknet_leaf_41_clk _00438_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[12\]$_DFFE_PN0P_ clknet_leaf_41_clk _00439_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[13\]$_DFFE_PN0P_ clknet_leaf_36_clk _00440_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[14\]$_DFFE_PN0P_ clknet_leaf_31_clk _00441_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[15\]$_DFFE_PN0P_ clknet_leaf_42_clk _00442_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[1\]$_DFFE_PN0P_ clknet_leaf_44_clk _00443_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[2\]$_DFFE_PN0P_ clknet_leaf_35_clk _00444_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[2\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[1\]\[3\]$_DFFE_PN0P_ clknet_leaf_36_clk _00445_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[3\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[1\]\[4\]$_DFFE_PN0P_ clknet_leaf_35_clk _00446_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[4\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[1\]\[5\]$_DFFE_PN0P_ clknet_leaf_36_clk _00447_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[5\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[1\]\[6\]$_DFFE_PN0P_ clknet_leaf_36_clk _00448_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[7\]$_DFFE_PN0P_ clknet_leaf_41_clk _00449_
+ net353 VSS VSS VDD VDD samples_real\[1\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[1\]\[8\]$_DFFE_PN0P_ clknet_leaf_32_clk _00450_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[1\]\[9\]$_DFFE_PN0P_ clknet_leaf_42_clk _00451_
+ net354 VSS VSS VDD VDD samples_real\[1\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[0\]$_DFFE_PN0P_ clknet_leaf_42_clk _00452_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[10\]$_DFFE_PN0P_ clknet_leaf_42_clk _00453_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[11\]$_DFFE_PN0P_ clknet_leaf_41_clk _00454_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[12\]$_DFFE_PN0P_ clknet_leaf_36_clk _00455_
+ net354 VSS VSS VDD VDD samples_real\[2\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[13\]$_DFFE_PN0P_ clknet_leaf_41_clk _00456_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[14\]$_DFFE_PN0P_ clknet_leaf_31_clk _00457_
+ net354 VSS VSS VDD VDD samples_real\[2\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[15\]$_DFFE_PN0P_ clknet_leaf_42_clk _00458_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[1\]$_DFFE_PN0P_ clknet_leaf_42_clk _00459_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[2\]$_DFFE_PN0P_ clknet_leaf_41_clk _00460_
+ net353 VSS VSS VDD VDD samples_real\[2\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[3\]$_DFFE_PN0P_ clknet_leaf_37_clk _00461_
+ net92 VSS VSS VDD VDD samples_real\[2\]\[3\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[2\]\[4\]$_DFFE_PN0P_ clknet_leaf_37_clk _00462_
+ net92 VSS VSS VDD VDD samples_real\[2\]\[4\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[2\]\[5\]$_DFFE_PN0P_ clknet_leaf_35_clk _00463_
+ net354 VSS VSS VDD VDD samples_real\[2\]\[5\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[2\]\[6\]$_DFFE_PN0P_ clknet_leaf_32_clk _00464_
+ net354 VSS VSS VDD VDD samples_real\[2\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[7\]$_DFFE_PN0P_ clknet_leaf_37_clk _00465_
+ net92 VSS VSS VDD VDD samples_real\[2\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[8\]$_DFFE_PN0P_ clknet_leaf_37_clk _00466_
+ net92 VSS VSS VDD VDD samples_real\[2\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[2\]\[9\]$_DFFE_PN0P_ clknet_leaf_45_clk _00467_
+ net354 VSS VSS VDD VDD samples_real\[2\]\[9\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[0\]$_DFFE_PN0P_ clknet_leaf_42_clk _00468_
+ net353 VSS VSS VDD VDD samples_real\[3\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[10\]$_DFFE_PN0P_ clknet_leaf_30_clk _00469_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[11\]$_DFFE_PN0P_ clknet_leaf_29_clk _00470_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[11\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[12\]$_DFFE_PN0P_ clknet_leaf_33_clk _00471_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[12\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[13\]$_DFFE_PN0P_ clknet_leaf_33_clk _00472_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[14\]$_DFFE_PN0P_ clknet_leaf_33_clk _00473_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[15\]$_DFFE_PN0P_ clknet_leaf_31_clk _00474_
+ net354 VSS VSS VDD VDD samples_real\[3\]\[15\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[1\]$_DFFE_PN0P_ clknet_leaf_45_clk _00475_
+ net354 VSS VSS VDD VDD samples_real\[3\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[2\]$_DFFE_PN0P_ clknet_leaf_33_clk _00476_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[3\]$_DFFE_PN0P_ clknet_leaf_33_clk _00477_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[4\]$_DFFE_PN0P_ clknet_leaf_33_clk _00478_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xsamples_real\[3\]\[5\]$_DFFE_PN0P_ clknet_leaf_33_clk _00479_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[6\]$_DFFE_PN0P_ clknet_leaf_33_clk _00480_
+ net357 VSS VSS VDD VDD samples_real\[3\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[3\]\[7\]$_DFFE_PN0P_ clknet_leaf_34_clk _00481_
+ net354 VSS VSS VDD VDD samples_real\[3\]\[7\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[8\]$_DFFE_PN0P_ clknet_leaf_34_clk _00482_
+ net354 VSS VSS VDD VDD samples_real\[3\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[3\]\[9\]$_DFFE_PN0P_ clknet_leaf_31_clk _00483_
+ net354 VSS VSS VDD VDD samples_real\[3\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[0\]$_DFFE_PN0P_ clknet_leaf_18_clk _00484_
+ net355 VSS VSS VDD VDD samples_real\[4\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[10\]$_DFFE_PN0P_ clknet_leaf_19_clk _00485_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[11\]$_DFFE_PN0P_ clknet_leaf_23_clk _00486_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[12\]$_DFFE_PN0P_ clknet_leaf_23_clk _00487_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[13\]$_DFFE_PN0P_ clknet_leaf_22_clk _00488_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[14\]$_DFFE_PN0P_ clknet_leaf_22_clk _00489_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[15\]$_DFFE_PN0P_ clknet_leaf_17_clk _00490_
+ net355 VSS VSS VDD VDD samples_real\[4\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[1\]$_DFFE_PN0P_ clknet_leaf_18_clk _00491_
+ net355 VSS VSS VDD VDD samples_real\[4\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[2\]$_DFFE_PN0P_ clknet_leaf_24_clk _00492_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[3\]$_DFFE_PN0P_ clknet_leaf_23_clk _00493_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[4\]$_DFFE_PN0P_ clknet_leaf_28_clk _00494_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[5\]$_DFFE_PN0P_ clknet_leaf_24_clk _00495_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[6\]$_DFFE_PN0P_ clknet_leaf_22_clk _00496_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[7\]$_DFFE_PN0P_ clknet_leaf_23_clk _00497_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[8\]$_DFFE_PN0P_ clknet_leaf_24_clk _00498_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[4\]\[9\]$_DFFE_PN0P_ clknet_leaf_18_clk _00499_
+ net356 VSS VSS VDD VDD samples_real\[4\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[0\]$_DFFE_PN0P_ clknet_leaf_16_clk _00500_
+ net355 VSS VSS VDD VDD samples_real\[5\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[10\]$_DFFE_PN0P_ clknet_leaf_17_clk _00501_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[11\]$_DFFE_PN0P_ clknet_leaf_23_clk _00502_
+ net356 VSS VSS VDD VDD samples_real\[5\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[12\]$_DFFE_PN0P_ clknet_leaf_23_clk _00503_
+ net356 VSS VSS VDD VDD samples_real\[5\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[13\]$_DFFE_PN0P_ clknet_leaf_30_clk _00504_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[14\]$_DFFE_PN0P_ clknet_leaf_17_clk _00505_
+ net355 VSS VSS VDD VDD samples_real\[5\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[15\]$_DFFE_PN0P_ clknet_leaf_16_clk _00506_
+ net355 VSS VSS VDD VDD samples_real\[5\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[1\]$_DFFE_PN0P_ clknet_leaf_18_clk _00507_
+ net355 VSS VSS VDD VDD samples_real\[5\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[2\]$_DFFE_PN0P_ clknet_leaf_27_clk _00508_
+ net356 VSS VSS VDD VDD samples_real\[5\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[3\]$_DFFE_PN0P_ clknet_leaf_27_clk _00509_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[4\]$_DFFE_PN0P_ clknet_leaf_28_clk _00510_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[5\]$_DFFE_PN0P_ clknet_leaf_29_clk _00511_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[5\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[5\]\[6\]$_DFFE_PN0P_ clknet_leaf_28_clk _00512_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[7\]$_DFFE_PN0P_ clknet_leaf_29_clk _00513_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[8\]$_DFFE_PN0P_ clknet_leaf_29_clk _00514_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[5\]\[9\]$_DFFE_PN0P_ clknet_leaf_30_clk _00515_
+ net357 VSS VSS VDD VDD samples_real\[5\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[0\]$_DFFE_PN0P_ clknet_leaf_16_clk _00516_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[10\]$_DFFE_PN0P_ clknet_leaf_17_clk _00517_
+ net355 VSS VSS VDD VDD samples_real\[6\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[11\]$_DFFE_PN0P_ clknet_leaf_23_clk _00518_
+ net356 VSS VSS VDD VDD samples_real\[6\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[12\]$_DFFE_PN0P_ clknet_leaf_23_clk _00519_
+ net356 VSS VSS VDD VDD samples_real\[6\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[13\]$_DFFE_PN0P_ clknet_leaf_23_clk _00520_
+ net356 VSS VSS VDD VDD samples_real\[6\]\[13\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[14\]$_DFFE_PN0P_ clknet_leaf_17_clk _00521_
+ net355 VSS VSS VDD VDD samples_real\[6\]\[14\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[15\]$_DFFE_PN0P_ clknet_leaf_17_clk _00522_
+ net355 VSS VSS VDD VDD samples_real\[6\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[1\]$_DFFE_PN0P_ clknet_leaf_18_clk _00523_
+ net355 VSS VSS VDD VDD samples_real\[6\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[2\]$_DFFE_PN0P_ clknet_leaf_28_clk _00524_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[3\]$_DFFE_PN0P_ clknet_leaf_28_clk _00525_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[4\]$_DFFE_PN0P_ clknet_leaf_28_clk _00526_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[5\]$_DFFE_PN0P_ clknet_leaf_28_clk _00527_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[6\]$_DFFE_PN0P_ clknet_leaf_30_clk _00528_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[7\]$_DFFE_PN0P_ clknet_leaf_24_clk _00529_
+ net356 VSS VSS VDD VDD samples_real\[6\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[8\]$_DFFE_PN0P_ clknet_leaf_30_clk _00530_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[6\]\[9\]$_DFFE_PN0P_ clknet_leaf_17_clk _00531_
+ net357 VSS VSS VDD VDD samples_real\[6\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[0\]$_DFFE_PN0P_ clknet_leaf_17_clk _00532_
+ net355 VSS VSS VDD VDD samples_real\[7\]\[0\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[10\]$_DFFE_PN0P_ clknet_leaf_18_clk _00533_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[10\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[11\]$_DFFE_PN0P_ clknet_leaf_23_clk _00534_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[11\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[12\]$_DFFE_PN0P_ clknet_leaf_22_clk _00535_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[12\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[13\]$_DFFE_PN0P_ clknet_leaf_22_clk _00536_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[13\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[7\]\[14\]$_DFFE_PN0P_ clknet_leaf_17_clk _00537_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[14\] sky130_fd_sc_hd__dfrtp_2
Xsamples_real\[7\]\[15\]$_DFFE_PN0P_ clknet_leaf_17_clk _00538_
+ net357 VSS VSS VDD VDD samples_real\[7\]\[15\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[1\]$_DFFE_PN0P_ clknet_leaf_18_clk _00539_
+ net355 VSS VSS VDD VDD samples_real\[7\]\[1\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[2\]$_DFFE_PN0P_ clknet_leaf_25_clk _00540_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[3\]$_DFFE_PN0P_ clknet_leaf_28_clk _00541_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[3\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[4\]$_DFFE_PN0P_ clknet_leaf_26_clk _00542_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[4\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[5\]$_DFFE_PN0P_ clknet_leaf_26_clk _00543_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[5\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[6\]$_DFFE_PN0P_ clknet_leaf_22_clk _00544_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[6\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[7\]$_DFFE_PN0P_ clknet_leaf_26_clk _00545_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[7\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[8\]$_DFFE_PN0P_ clknet_leaf_26_clk _00546_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[8\] sky130_fd_sc_hd__dfrtp_4
Xsamples_real\[7\]\[9\]$_DFFE_PN0P_ clknet_leaf_22_clk _00547_
+ net356 VSS VSS VDD VDD samples_real\[7\]\[9\] sky130_fd_sc_hd__dfrtp_4
Xstage\[0\]$_DFFE_PN0P_ clknet_leaf_0_clk _00548_ net354 VSS
+ VSS VDD VDD stage\[0\] sky130_fd_sc_hd__dfrtp_4
Xstage\[1\]$_DFFE_PN0P_ clknet_leaf_0_clk _00549_ net354 VSS
+ VSS VDD VDD stage\[1\] sky130_fd_sc_hd__dfrtp_1
Xstage\[2\]$_DFFE_PN0P_ clknet_leaf_0_clk _00550_ net354 VSS
+ VSS VDD VDD stage\[2\] sky130_fd_sc_hd__dfrtp_1
Xstate\[0\]$_DFF_PN1_ clknet_leaf_7_clk _00004_ net355 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfstp_1
Xstate\[1\]$_DFF_PN0_ clknet_leaf_6_clk _00005_ net357 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_4
Xstate\[2\]$_DFF_PN0_ clknet_leaf_6_clk _00006_ net355 VSS
+ VSS VDD VDD state\[2\] sky130_fd_sc_hd__dfrtp_1
Xstate\[3\]$_DFF_PN0_ clknet_leaf_6_clk _00003_ net357 VSS
+ VSS VDD VDD state\[3\] sky130_fd_sc_hd__dfrtp_1
Xtemp_imag\[0\]$_DFFE_PP_ clknet_leaf_53_clk _00019_ _00007_
+ VSS VSS VDD VDD temp_imag\[0\] sky130_fd_sc_hd__edfxtp_1
Xtemp_real\[0\]$_DFFE_PP_ clknet_leaf_43_clk _00018_ _00007_
+ VSS VSS VDD VDD temp_real\[0\] sky130_fd_sc_hd__edfxtp_1
Xtwiddle_idx\[0\]$_DFFE_PP_ clknet_leaf_53_clk _05877_ _00007_
+ VSS VSS VDD VDD twiddle_idx\[0\] sky130_fd_sc_hd__edfxtp_1
Xtwiddle_idx\[1\]$_DFFE_PP_ clknet_leaf_53_clk _05878_ _00007_
+ VSS VSS VDD VDD twiddle_idx\[1\] sky130_fd_sc_hd__edfxtp_1
Xclone1 _02623_ _02559_ _02621_ VSS VSS VDD VDD net1 sky130_fd_sc_hd__nor3_2
Xclone2 _02206_ _02306_ _02229_ VSS VSS VDD VDD net2 sky130_fd_sc_hd__nor3_4
Xclone3 _02356_ _02359_ _02374_ _02371_ VSS VSS VDD VDD net3
+ sky130_fd_sc_hd__a211oi_2
Xclone4 _01107_ _01105_ _01056_ VSS VSS VDD VDD net4 sky130_fd_sc_hd__nand3_4
Xclone11 _01972_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_2
Xclone12 _02387_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xclone13 _02389_ _02388_ VSS VSS VDD VDD net13 sky130_fd_sc_hd__nor2_2
Xclone14 _07667_ VSS VSS VDD VDD net14 sky130_fd_sc_hd__inv_6
Xclone15 _01215_ VSS VSS VDD VDD net15 sky130_fd_sc_hd__buf_2
Xclone16 _02136_ VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_2
Xclone17 _01376_ VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_2
Xclone19 _02600_ VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_2
Xclone20 _01607_ VSS VSS VDD VDD net20 sky130_fd_sc_hd__buf_2
Xclone21 _01201_ VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_2
Xclone22 _01008_ VSS VSS VDD VDD net22 sky130_fd_sc_hd__buf_2
Xclone23 _02390_ VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_2
Xclone24 _07667_ VSS VSS VDD VDD net24 sky130_fd_sc_hd__inv_4
Xclone25 _01819_ VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_2
Xclone26 _00652_ VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_2
Xclone28 _01878_ VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_2
Xclone29 _01877_ VSS VSS VDD VDD net29 sky130_fd_sc_hd__buf_2
Xclone30 _00819_ VSS VSS VDD VDD net30 sky130_fd_sc_hd__buf_6
Xclone31 _00818_ VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_2
Xclone32 _01006_ VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_2
Xclone33 _01658_ _01730_ VSS VSS VDD VDD net33 sky130_fd_sc_hd__nand2_2
Xclone35 _02978_ VSS VSS VDD VDD net35 sky130_fd_sc_hd__buf_6
Xclone37 net38 VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_2
Xclone38 net404 VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkinv_2
Xclone39 _01497_ VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_2
Xclone42 net443 VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_4
Xclone44 _03299_ VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_4
Xclone45 _03238_ VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in_imag[0] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in_imag[10] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in_imag[11] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in_imag[12] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in_imag[13] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in_imag[14] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in_imag[15] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_2
Xinput8 data_in_imag[1] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput9 data_in_imag[2] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput10 data_in_imag[3] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput11 data_in_imag[4] VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkbuf_1
Xinput12 data_in_imag[5] VSS VSS VDD VDD net69 sky130_fd_sc_hd__clkbuf_1
Xinput13 data_in_imag[6] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_1
Xinput14 data_in_imag[7] VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkbuf_1
Xinput15 data_in_imag[8] VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkbuf_1
Xinput16 data_in_imag[9] VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkbuf_1
Xinput17 data_in_real[0] VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkbuf_1
Xinput18 data_in_real[10] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_1
Xinput19 data_in_real[11] VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkbuf_1
Xinput20 data_in_real[12] VSS VSS VDD VDD net78 sky130_fd_sc_hd__clkbuf_1
Xinput21 data_in_real[13] VSS VSS VDD VDD net79 sky130_fd_sc_hd__clkbuf_1
Xinput22 data_in_real[14] VSS VSS VDD VDD net80 sky130_fd_sc_hd__clkbuf_1
Xinput23 data_in_real[15] VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkbuf_2
Xinput24 data_in_real[1] VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkbuf_1
Xinput25 data_in_real[2] VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkbuf_1
Xinput26 data_in_real[3] VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkbuf_1
Xinput27 data_in_real[4] VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkbuf_1
Xinput28 data_in_real[5] VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkbuf_1
Xinput29 data_in_real[6] VSS VSS VDD VDD net87 sky130_fd_sc_hd__clkbuf_1
Xinput30 data_in_real[7] VSS VSS VDD VDD net88 sky130_fd_sc_hd__clkbuf_1
Xinput31 data_in_real[8] VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkbuf_1
Xinput32 data_in_real[9] VSS VSS VDD VDD net90 sky130_fd_sc_hd__clkbuf_1
Xinput33 net649 VSS VSS VDD VDD net91 sky130_fd_sc_hd__clkbuf_2
Xinput34 net648 VSS VSS VDD VDD net92 sky130_fd_sc_hd__buf_16
Xinput35 start VSS VSS VDD VDD net93 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput36 net94 VSS VSS VDD VDD busy sky130_fd_sc_hd__clkbuf_1
Xoutput37 net95 VSS VSS VDD VDD data_out_imag[0] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net96 VSS VSS VDD VDD data_out_imag[100] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net97 VSS VSS VDD VDD data_out_imag[101] sky130_fd_sc_hd__clkbuf_1
Xoutput40 net98 VSS VSS VDD VDD data_out_imag[102] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net99 VSS VSS VDD VDD data_out_imag[103] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net100 VSS VSS VDD VDD data_out_imag[104] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net101 VSS VSS VDD VDD data_out_imag[105] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net102 VSS VSS VDD VDD data_out_imag[106] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net103 VSS VSS VDD VDD data_out_imag[107] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net104 VSS VSS VDD VDD data_out_imag[108] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net105 VSS VSS VDD VDD data_out_imag[109] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net106 VSS VSS VDD VDD data_out_imag[10] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net107 VSS VSS VDD VDD data_out_imag[110] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net108 VSS VSS VDD VDD data_out_imag[111] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net109 VSS VSS VDD VDD data_out_imag[112] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net110 VSS VSS VDD VDD data_out_imag[113] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net111 VSS VSS VDD VDD data_out_imag[114] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net112 VSS VSS VDD VDD data_out_imag[115] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net113 VSS VSS VDD VDD data_out_imag[116] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net114 VSS VSS VDD VDD data_out_imag[117] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net115 VSS VSS VDD VDD data_out_imag[118] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net116 VSS VSS VDD VDD data_out_imag[119] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net117 VSS VSS VDD VDD data_out_imag[11] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net118 VSS VSS VDD VDD data_out_imag[120] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net119 VSS VSS VDD VDD data_out_imag[121] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net120 VSS VSS VDD VDD data_out_imag[122] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net121 VSS VSS VDD VDD data_out_imag[123] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net122 VSS VSS VDD VDD data_out_imag[124] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net123 VSS VSS VDD VDD data_out_imag[125] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net124 VSS VSS VDD VDD data_out_imag[126] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net125 VSS VSS VDD VDD data_out_imag[127] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net126 VSS VSS VDD VDD data_out_imag[12] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net127 VSS VSS VDD VDD data_out_imag[13] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net128 VSS VSS VDD VDD data_out_imag[14] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net129 VSS VSS VDD VDD data_out_imag[15] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net130 VSS VSS VDD VDD data_out_imag[16] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net131 VSS VSS VDD VDD data_out_imag[17] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net132 VSS VSS VDD VDD data_out_imag[18] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net133 VSS VSS VDD VDD data_out_imag[19] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net134 VSS VSS VDD VDD data_out_imag[1] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net135 VSS VSS VDD VDD data_out_imag[20] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net136 VSS VSS VDD VDD data_out_imag[21] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net137 VSS VSS VDD VDD data_out_imag[22] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net138 VSS VSS VDD VDD data_out_imag[23] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net139 VSS VSS VDD VDD data_out_imag[24] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net140 VSS VSS VDD VDD data_out_imag[25] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net141 VSS VSS VDD VDD data_out_imag[26] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net142 VSS VSS VDD VDD data_out_imag[27] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net143 VSS VSS VDD VDD data_out_imag[28] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net144 VSS VSS VDD VDD data_out_imag[29] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net145 VSS VSS VDD VDD data_out_imag[2] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net146 VSS VSS VDD VDD data_out_imag[30] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net147 VSS VSS VDD VDD data_out_imag[31] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net148 VSS VSS VDD VDD data_out_imag[32] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net149 VSS VSS VDD VDD data_out_imag[33] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net150 VSS VSS VDD VDD data_out_imag[34] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net151 VSS VSS VDD VDD data_out_imag[35] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net152 VSS VSS VDD VDD data_out_imag[36] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net153 VSS VSS VDD VDD data_out_imag[37] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net154 VSS VSS VDD VDD data_out_imag[38] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net155 VSS VSS VDD VDD data_out_imag[39] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net156 VSS VSS VDD VDD data_out_imag[3] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net157 VSS VSS VDD VDD data_out_imag[40] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net158 VSS VSS VDD VDD data_out_imag[41] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net159 VSS VSS VDD VDD data_out_imag[42] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net160 VSS VSS VDD VDD data_out_imag[43] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net161 VSS VSS VDD VDD data_out_imag[44] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net162 VSS VSS VDD VDD data_out_imag[45] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net163 VSS VSS VDD VDD data_out_imag[46] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net164 VSS VSS VDD VDD data_out_imag[47] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net165 VSS VSS VDD VDD data_out_imag[48] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net166 VSS VSS VDD VDD data_out_imag[49] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net167 VSS VSS VDD VDD data_out_imag[4] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net168 VSS VSS VDD VDD data_out_imag[50] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net169 VSS VSS VDD VDD data_out_imag[51] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net170 VSS VSS VDD VDD data_out_imag[52] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net171 VSS VSS VDD VDD data_out_imag[53] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net172 VSS VSS VDD VDD data_out_imag[54] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net173 VSS VSS VDD VDD data_out_imag[55] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net174 VSS VSS VDD VDD data_out_imag[56] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net175 VSS VSS VDD VDD data_out_imag[57] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net176 VSS VSS VDD VDD data_out_imag[58] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net177 VSS VSS VDD VDD data_out_imag[59] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net178 VSS VSS VDD VDD data_out_imag[5] sky130_fd_sc_hd__clkbuf_1
Xoutput121 net179 VSS VSS VDD VDD data_out_imag[60] sky130_fd_sc_hd__clkbuf_1
Xoutput122 net180 VSS VSS VDD VDD data_out_imag[61] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net181 VSS VSS VDD VDD data_out_imag[62] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net182 VSS VSS VDD VDD data_out_imag[63] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net183 VSS VSS VDD VDD data_out_imag[64] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net184 VSS VSS VDD VDD data_out_imag[65] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net185 VSS VSS VDD VDD data_out_imag[66] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net186 VSS VSS VDD VDD data_out_imag[67] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net187 VSS VSS VDD VDD data_out_imag[68] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net188 VSS VSS VDD VDD data_out_imag[69] sky130_fd_sc_hd__clkbuf_1
Xoutput131 net189 VSS VSS VDD VDD data_out_imag[6] sky130_fd_sc_hd__clkbuf_1
Xoutput132 net190 VSS VSS VDD VDD data_out_imag[70] sky130_fd_sc_hd__clkbuf_1
Xoutput133 net191 VSS VSS VDD VDD data_out_imag[71] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net192 VSS VSS VDD VDD data_out_imag[72] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net193 VSS VSS VDD VDD data_out_imag[73] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net194 VSS VSS VDD VDD data_out_imag[74] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net195 VSS VSS VDD VDD data_out_imag[75] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net196 VSS VSS VDD VDD data_out_imag[76] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net197 VSS VSS VDD VDD data_out_imag[77] sky130_fd_sc_hd__clkbuf_1
Xoutput140 net198 VSS VSS VDD VDD data_out_imag[78] sky130_fd_sc_hd__clkbuf_1
Xoutput141 net199 VSS VSS VDD VDD data_out_imag[79] sky130_fd_sc_hd__clkbuf_1
Xoutput142 net200 VSS VSS VDD VDD data_out_imag[7] sky130_fd_sc_hd__clkbuf_1
Xoutput143 net201 VSS VSS VDD VDD data_out_imag[80] sky130_fd_sc_hd__clkbuf_1
Xoutput144 net202 VSS VSS VDD VDD data_out_imag[81] sky130_fd_sc_hd__clkbuf_1
Xoutput145 net203 VSS VSS VDD VDD data_out_imag[82] sky130_fd_sc_hd__clkbuf_1
Xoutput146 net204 VSS VSS VDD VDD data_out_imag[83] sky130_fd_sc_hd__clkbuf_1
Xoutput147 net205 VSS VSS VDD VDD data_out_imag[84] sky130_fd_sc_hd__clkbuf_1
Xoutput148 net206 VSS VSS VDD VDD data_out_imag[85] sky130_fd_sc_hd__clkbuf_1
Xoutput149 net207 VSS VSS VDD VDD data_out_imag[86] sky130_fd_sc_hd__clkbuf_1
Xoutput150 net208 VSS VSS VDD VDD data_out_imag[87] sky130_fd_sc_hd__clkbuf_1
Xoutput151 net209 VSS VSS VDD VDD data_out_imag[88] sky130_fd_sc_hd__clkbuf_1
Xoutput152 net210 VSS VSS VDD VDD data_out_imag[89] sky130_fd_sc_hd__clkbuf_1
Xoutput153 net211 VSS VSS VDD VDD data_out_imag[8] sky130_fd_sc_hd__clkbuf_1
Xoutput154 net212 VSS VSS VDD VDD data_out_imag[90] sky130_fd_sc_hd__clkbuf_1
Xoutput155 net213 VSS VSS VDD VDD data_out_imag[91] sky130_fd_sc_hd__clkbuf_1
Xoutput156 net214 VSS VSS VDD VDD data_out_imag[92] sky130_fd_sc_hd__clkbuf_1
Xoutput157 net215 VSS VSS VDD VDD data_out_imag[93] sky130_fd_sc_hd__clkbuf_1
Xoutput158 net216 VSS VSS VDD VDD data_out_imag[94] sky130_fd_sc_hd__clkbuf_1
Xoutput159 net217 VSS VSS VDD VDD data_out_imag[95] sky130_fd_sc_hd__clkbuf_1
Xoutput160 net218 VSS VSS VDD VDD data_out_imag[96] sky130_fd_sc_hd__clkbuf_1
Xoutput161 net219 VSS VSS VDD VDD data_out_imag[97] sky130_fd_sc_hd__clkbuf_1
Xoutput162 net220 VSS VSS VDD VDD data_out_imag[98] sky130_fd_sc_hd__clkbuf_1
Xoutput163 net221 VSS VSS VDD VDD data_out_imag[99] sky130_fd_sc_hd__clkbuf_1
Xoutput164 net222 VSS VSS VDD VDD data_out_imag[9] sky130_fd_sc_hd__clkbuf_1
Xoutput165 net223 VSS VSS VDD VDD data_out_real[0] sky130_fd_sc_hd__clkbuf_1
Xoutput166 net224 VSS VSS VDD VDD data_out_real[100] sky130_fd_sc_hd__clkbuf_1
Xoutput167 net225 VSS VSS VDD VDD data_out_real[101] sky130_fd_sc_hd__clkbuf_1
Xoutput168 net226 VSS VSS VDD VDD data_out_real[102] sky130_fd_sc_hd__clkbuf_1
Xoutput169 net227 VSS VSS VDD VDD data_out_real[103] sky130_fd_sc_hd__clkbuf_1
Xoutput170 net228 VSS VSS VDD VDD data_out_real[104] sky130_fd_sc_hd__clkbuf_1
Xoutput171 net229 VSS VSS VDD VDD data_out_real[105] sky130_fd_sc_hd__clkbuf_1
Xoutput172 net230 VSS VSS VDD VDD data_out_real[106] sky130_fd_sc_hd__clkbuf_1
Xoutput173 net231 VSS VSS VDD VDD data_out_real[107] sky130_fd_sc_hd__clkbuf_1
Xoutput174 net232 VSS VSS VDD VDD data_out_real[108] sky130_fd_sc_hd__clkbuf_1
Xoutput175 net233 VSS VSS VDD VDD data_out_real[109] sky130_fd_sc_hd__clkbuf_1
Xoutput176 net234 VSS VSS VDD VDD data_out_real[10] sky130_fd_sc_hd__clkbuf_1
Xoutput177 net235 VSS VSS VDD VDD data_out_real[110] sky130_fd_sc_hd__clkbuf_1
Xoutput178 net236 VSS VSS VDD VDD data_out_real[111] sky130_fd_sc_hd__clkbuf_1
Xoutput179 net237 VSS VSS VDD VDD data_out_real[112] sky130_fd_sc_hd__clkbuf_1
Xoutput180 net238 VSS VSS VDD VDD data_out_real[113] sky130_fd_sc_hd__clkbuf_1
Xoutput181 net239 VSS VSS VDD VDD data_out_real[114] sky130_fd_sc_hd__clkbuf_1
Xoutput182 net240 VSS VSS VDD VDD data_out_real[115] sky130_fd_sc_hd__clkbuf_1
Xoutput183 net241 VSS VSS VDD VDD data_out_real[116] sky130_fd_sc_hd__clkbuf_1
Xoutput184 net242 VSS VSS VDD VDD data_out_real[117] sky130_fd_sc_hd__clkbuf_1
Xoutput185 net243 VSS VSS VDD VDD data_out_real[118] sky130_fd_sc_hd__clkbuf_1
Xoutput186 net244 VSS VSS VDD VDD data_out_real[119] sky130_fd_sc_hd__clkbuf_1
Xoutput187 net245 VSS VSS VDD VDD data_out_real[11] sky130_fd_sc_hd__clkbuf_1
Xoutput188 net246 VSS VSS VDD VDD data_out_real[120] sky130_fd_sc_hd__clkbuf_1
Xoutput189 net247 VSS VSS VDD VDD data_out_real[121] sky130_fd_sc_hd__clkbuf_1
Xoutput190 net248 VSS VSS VDD VDD data_out_real[122] sky130_fd_sc_hd__clkbuf_1
Xoutput191 net249 VSS VSS VDD VDD data_out_real[123] sky130_fd_sc_hd__clkbuf_1
Xoutput192 net250 VSS VSS VDD VDD data_out_real[124] sky130_fd_sc_hd__clkbuf_1
Xoutput193 net251 VSS VSS VDD VDD data_out_real[125] sky130_fd_sc_hd__clkbuf_1
Xoutput194 net252 VSS VSS VDD VDD data_out_real[126] sky130_fd_sc_hd__clkbuf_1
Xoutput195 net253 VSS VSS VDD VDD data_out_real[127] sky130_fd_sc_hd__clkbuf_1
Xoutput196 net254 VSS VSS VDD VDD data_out_real[12] sky130_fd_sc_hd__clkbuf_1
Xoutput197 net255 VSS VSS VDD VDD data_out_real[13] sky130_fd_sc_hd__clkbuf_1
Xoutput198 net256 VSS VSS VDD VDD data_out_real[14] sky130_fd_sc_hd__clkbuf_1
Xoutput199 net257 VSS VSS VDD VDD data_out_real[15] sky130_fd_sc_hd__clkbuf_1
Xoutput200 net258 VSS VSS VDD VDD data_out_real[16] sky130_fd_sc_hd__clkbuf_1
Xoutput201 net259 VSS VSS VDD VDD data_out_real[17] sky130_fd_sc_hd__clkbuf_1
Xoutput202 net260 VSS VSS VDD VDD data_out_real[18] sky130_fd_sc_hd__clkbuf_1
Xoutput203 net261 VSS VSS VDD VDD data_out_real[19] sky130_fd_sc_hd__clkbuf_1
Xoutput204 net262 VSS VSS VDD VDD data_out_real[1] sky130_fd_sc_hd__clkbuf_1
Xoutput205 net263 VSS VSS VDD VDD data_out_real[20] sky130_fd_sc_hd__clkbuf_1
Xoutput206 net264 VSS VSS VDD VDD data_out_real[21] sky130_fd_sc_hd__clkbuf_1
Xoutput207 net265 VSS VSS VDD VDD data_out_real[22] sky130_fd_sc_hd__clkbuf_1
Xoutput208 net266 VSS VSS VDD VDD data_out_real[23] sky130_fd_sc_hd__clkbuf_1
Xoutput209 net267 VSS VSS VDD VDD data_out_real[24] sky130_fd_sc_hd__clkbuf_1
Xoutput210 net268 VSS VSS VDD VDD data_out_real[25] sky130_fd_sc_hd__clkbuf_1
Xoutput211 net269 VSS VSS VDD VDD data_out_real[26] sky130_fd_sc_hd__clkbuf_1
Xoutput212 net270 VSS VSS VDD VDD data_out_real[27] sky130_fd_sc_hd__clkbuf_1
Xoutput213 net271 VSS VSS VDD VDD data_out_real[28] sky130_fd_sc_hd__clkbuf_1
Xoutput214 net272 VSS VSS VDD VDD data_out_real[29] sky130_fd_sc_hd__clkbuf_1
Xoutput215 net273 VSS VSS VDD VDD data_out_real[2] sky130_fd_sc_hd__clkbuf_1
Xoutput216 net274 VSS VSS VDD VDD data_out_real[30] sky130_fd_sc_hd__clkbuf_1
Xoutput217 net275 VSS VSS VDD VDD data_out_real[31] sky130_fd_sc_hd__clkbuf_1
Xoutput218 net276 VSS VSS VDD VDD data_out_real[32] sky130_fd_sc_hd__clkbuf_1
Xoutput219 net277 VSS VSS VDD VDD data_out_real[33] sky130_fd_sc_hd__clkbuf_1
Xoutput220 net278 VSS VSS VDD VDD data_out_real[34] sky130_fd_sc_hd__clkbuf_1
Xoutput221 net279 VSS VSS VDD VDD data_out_real[35] sky130_fd_sc_hd__clkbuf_1
Xoutput222 net280 VSS VSS VDD VDD data_out_real[36] sky130_fd_sc_hd__clkbuf_1
Xoutput223 net281 VSS VSS VDD VDD data_out_real[37] sky130_fd_sc_hd__clkbuf_1
Xoutput224 net282 VSS VSS VDD VDD data_out_real[38] sky130_fd_sc_hd__clkbuf_1
Xoutput225 net283 VSS VSS VDD VDD data_out_real[39] sky130_fd_sc_hd__clkbuf_1
Xoutput226 net284 VSS VSS VDD VDD data_out_real[3] sky130_fd_sc_hd__clkbuf_1
Xoutput227 net285 VSS VSS VDD VDD data_out_real[40] sky130_fd_sc_hd__clkbuf_1
Xoutput228 net286 VSS VSS VDD VDD data_out_real[41] sky130_fd_sc_hd__clkbuf_1
Xoutput229 net287 VSS VSS VDD VDD data_out_real[42] sky130_fd_sc_hd__clkbuf_1
Xoutput230 net288 VSS VSS VDD VDD data_out_real[43] sky130_fd_sc_hd__clkbuf_1
Xoutput231 net289 VSS VSS VDD VDD data_out_real[44] sky130_fd_sc_hd__clkbuf_1
Xoutput232 net290 VSS VSS VDD VDD data_out_real[45] sky130_fd_sc_hd__clkbuf_1
Xoutput233 net291 VSS VSS VDD VDD data_out_real[46] sky130_fd_sc_hd__clkbuf_1
Xoutput234 net292 VSS VSS VDD VDD data_out_real[47] sky130_fd_sc_hd__clkbuf_1
Xoutput235 net293 VSS VSS VDD VDD data_out_real[48] sky130_fd_sc_hd__clkbuf_1
Xoutput236 net294 VSS VSS VDD VDD data_out_real[49] sky130_fd_sc_hd__clkbuf_1
Xoutput237 net295 VSS VSS VDD VDD data_out_real[4] sky130_fd_sc_hd__clkbuf_1
Xoutput238 net296 VSS VSS VDD VDD data_out_real[50] sky130_fd_sc_hd__clkbuf_1
Xoutput239 net297 VSS VSS VDD VDD data_out_real[51] sky130_fd_sc_hd__clkbuf_1
Xoutput240 net298 VSS VSS VDD VDD data_out_real[52] sky130_fd_sc_hd__clkbuf_1
Xoutput241 net299 VSS VSS VDD VDD data_out_real[53] sky130_fd_sc_hd__clkbuf_1
Xoutput242 net300 VSS VSS VDD VDD data_out_real[54] sky130_fd_sc_hd__clkbuf_1
Xoutput243 net301 VSS VSS VDD VDD data_out_real[55] sky130_fd_sc_hd__clkbuf_1
Xoutput244 net302 VSS VSS VDD VDD data_out_real[56] sky130_fd_sc_hd__clkbuf_1
Xoutput245 net303 VSS VSS VDD VDD data_out_real[57] sky130_fd_sc_hd__clkbuf_1
Xoutput246 net304 VSS VSS VDD VDD data_out_real[58] sky130_fd_sc_hd__clkbuf_1
Xoutput247 net305 VSS VSS VDD VDD data_out_real[59] sky130_fd_sc_hd__clkbuf_1
Xoutput248 net306 VSS VSS VDD VDD data_out_real[5] sky130_fd_sc_hd__clkbuf_1
Xoutput249 net307 VSS VSS VDD VDD data_out_real[60] sky130_fd_sc_hd__clkbuf_1
Xoutput250 net308 VSS VSS VDD VDD data_out_real[61] sky130_fd_sc_hd__clkbuf_1
Xoutput251 net309 VSS VSS VDD VDD data_out_real[62] sky130_fd_sc_hd__clkbuf_1
Xoutput252 net310 VSS VSS VDD VDD data_out_real[63] sky130_fd_sc_hd__clkbuf_1
Xoutput253 net311 VSS VSS VDD VDD data_out_real[64] sky130_fd_sc_hd__clkbuf_1
Xoutput254 net312 VSS VSS VDD VDD data_out_real[65] sky130_fd_sc_hd__clkbuf_1
Xoutput255 net313 VSS VSS VDD VDD data_out_real[66] sky130_fd_sc_hd__clkbuf_1
Xoutput256 net314 VSS VSS VDD VDD data_out_real[67] sky130_fd_sc_hd__clkbuf_1
Xoutput257 net315 VSS VSS VDD VDD data_out_real[68] sky130_fd_sc_hd__clkbuf_1
Xoutput258 net316 VSS VSS VDD VDD data_out_real[69] sky130_fd_sc_hd__clkbuf_1
Xoutput259 net317 VSS VSS VDD VDD data_out_real[6] sky130_fd_sc_hd__clkbuf_1
Xoutput260 net318 VSS VSS VDD VDD data_out_real[70] sky130_fd_sc_hd__clkbuf_1
Xoutput261 net319 VSS VSS VDD VDD data_out_real[71] sky130_fd_sc_hd__clkbuf_1
Xoutput262 net320 VSS VSS VDD VDD data_out_real[72] sky130_fd_sc_hd__clkbuf_1
Xoutput263 net321 VSS VSS VDD VDD data_out_real[73] sky130_fd_sc_hd__clkbuf_1
Xoutput264 net322 VSS VSS VDD VDD data_out_real[74] sky130_fd_sc_hd__clkbuf_1
Xoutput265 net323 VSS VSS VDD VDD data_out_real[75] sky130_fd_sc_hd__clkbuf_1
Xoutput266 net324 VSS VSS VDD VDD data_out_real[76] sky130_fd_sc_hd__clkbuf_1
Xoutput267 net325 VSS VSS VDD VDD data_out_real[77] sky130_fd_sc_hd__clkbuf_1
Xoutput268 net326 VSS VSS VDD VDD data_out_real[78] sky130_fd_sc_hd__clkbuf_1
Xoutput269 net327 VSS VSS VDD VDD data_out_real[79] sky130_fd_sc_hd__clkbuf_1
Xoutput270 net328 VSS VSS VDD VDD data_out_real[7] sky130_fd_sc_hd__clkbuf_1
Xoutput271 net329 VSS VSS VDD VDD data_out_real[80] sky130_fd_sc_hd__clkbuf_1
Xoutput272 net330 VSS VSS VDD VDD data_out_real[81] sky130_fd_sc_hd__clkbuf_1
Xoutput273 net331 VSS VSS VDD VDD data_out_real[82] sky130_fd_sc_hd__clkbuf_1
Xoutput274 net332 VSS VSS VDD VDD data_out_real[83] sky130_fd_sc_hd__clkbuf_1
Xoutput275 net333 VSS VSS VDD VDD data_out_real[84] sky130_fd_sc_hd__clkbuf_1
Xoutput276 net334 VSS VSS VDD VDD data_out_real[85] sky130_fd_sc_hd__clkbuf_1
Xoutput277 net335 VSS VSS VDD VDD data_out_real[86] sky130_fd_sc_hd__clkbuf_1
Xoutput278 net336 VSS VSS VDD VDD data_out_real[87] sky130_fd_sc_hd__clkbuf_1
Xoutput279 net337 VSS VSS VDD VDD data_out_real[88] sky130_fd_sc_hd__clkbuf_1
Xoutput280 net338 VSS VSS VDD VDD data_out_real[89] sky130_fd_sc_hd__clkbuf_1
Xoutput281 net339 VSS VSS VDD VDD data_out_real[8] sky130_fd_sc_hd__clkbuf_1
Xoutput282 net340 VSS VSS VDD VDD data_out_real[90] sky130_fd_sc_hd__clkbuf_1
Xoutput283 net341 VSS VSS VDD VDD data_out_real[91] sky130_fd_sc_hd__clkbuf_1
Xoutput284 net342 VSS VSS VDD VDD data_out_real[92] sky130_fd_sc_hd__clkbuf_1
Xoutput285 net343 VSS VSS VDD VDD data_out_real[93] sky130_fd_sc_hd__clkbuf_1
Xoutput286 net344 VSS VSS VDD VDD data_out_real[94] sky130_fd_sc_hd__clkbuf_1
Xoutput287 net345 VSS VSS VDD VDD data_out_real[95] sky130_fd_sc_hd__clkbuf_1
Xoutput288 net346 VSS VSS VDD VDD data_out_real[96] sky130_fd_sc_hd__clkbuf_1
Xoutput289 net347 VSS VSS VDD VDD data_out_real[97] sky130_fd_sc_hd__clkbuf_1
Xoutput290 net348 VSS VSS VDD VDD data_out_real[98] sky130_fd_sc_hd__clkbuf_1
Xoutput291 net349 VSS VSS VDD VDD data_out_real[99] sky130_fd_sc_hd__clkbuf_1
Xoutput292 net350 VSS VSS VDD VDD data_out_real[9] sky130_fd_sc_hd__clkbuf_1
Xoutput293 net351 VSS VSS VDD VDD data_ready sky130_fd_sc_hd__clkbuf_1
Xoutput294 net352 VSS VSS VDD VDD data_valid_out sky130_fd_sc_hd__clkbuf_1
Xload_slew295 net92 VSS VSS VDD VDD net353 sky130_fd_sc_hd__buf_16
Xload_slew296 net92 VSS VSS VDD VDD net354 sky130_fd_sc_hd__buf_16
Xload_slew297 net357 VSS VSS VDD VDD net355 sky130_fd_sc_hd__buf_16
Xload_slew298 net357 VSS VSS VDD VDD net356 sky130_fd_sc_hd__buf_16
Xload_slew299 net92 VSS VSS VDD VDD net357 sky130_fd_sc_hd__buf_16
X_15301__300 VSS VSS VDD VDD _unconnected_1 net358 sky130_fd_sc_hd__conb_1
X_15305__301 VSS VSS VDD VDD _unconnected_2 net359 sky130_fd_sc_hd__conb_1
X_15310__302 VSS VSS VDD VDD _unconnected_3 net360 sky130_fd_sc_hd__conb_1
X_15312__303 VSS VSS VDD VDD _unconnected_4 net361 sky130_fd_sc_hd__conb_1
X_15323__304 VSS VSS VDD VDD _unconnected_5 net362 sky130_fd_sc_hd__conb_1
X_15330__305 VSS VSS VDD VDD _unconnected_6 net363 sky130_fd_sc_hd__conb_1
X_15338__306 VSS VSS VDD VDD _unconnected_7 net364 sky130_fd_sc_hd__conb_1
X_15345__307 VSS VSS VDD VDD _unconnected_8 net365 sky130_fd_sc_hd__conb_1
X_15351__308 VSS VSS VDD VDD _unconnected_9 net366 sky130_fd_sc_hd__conb_1
X_15359__309 VSS VSS VDD VDD _unconnected_10 net367 sky130_fd_sc_hd__conb_1
X_15364__310 VSS VSS VDD VDD _unconnected_11 net368 sky130_fd_sc_hd__conb_1
X_15373__311 VSS VSS VDD VDD _unconnected_12 net369 sky130_fd_sc_hd__conb_1
X_15380__312 VSS VSS VDD VDD _unconnected_13 net370 sky130_fd_sc_hd__conb_1
X_15387__313 VSS VSS VDD VDD _unconnected_14 net371 sky130_fd_sc_hd__conb_1
X_15388__314 VSS VSS VDD VDD _unconnected_15 net372 sky130_fd_sc_hd__conb_1
X_15396__315 VSS VSS VDD VDD _unconnected_16 net373 sky130_fd_sc_hd__conb_1
X_15404__316 VSS VSS VDD VDD _unconnected_17 net374 sky130_fd_sc_hd__conb_1
X_15412__317 VSS VSS VDD VDD _unconnected_18 net375 sky130_fd_sc_hd__conb_1
X_15420__318 VSS VSS VDD VDD _unconnected_19 net376 sky130_fd_sc_hd__conb_1
X_15428__319 VSS VSS VDD VDD _unconnected_20 net377 sky130_fd_sc_hd__conb_1
X_15436__320 VSS VSS VDD VDD _unconnected_21 net378 sky130_fd_sc_hd__conb_1
X_15443__321 VSS VSS VDD VDD _unconnected_22 net379 sky130_fd_sc_hd__conb_1
X_15444__322 VSS VSS VDD VDD _unconnected_23 net380 sky130_fd_sc_hd__conb_1
X_15452__323 VSS VSS VDD VDD _unconnected_24 net381 sky130_fd_sc_hd__conb_1
X_15459__324 VSS VSS VDD VDD _unconnected_25 net382 sky130_fd_sc_hd__conb_1
X_15470__325 VSS VSS VDD VDD _unconnected_26 net383 sky130_fd_sc_hd__conb_1
X_15475__326 VSS VSS VDD VDD _unconnected_27 net384 sky130_fd_sc_hd__conb_1
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_2_2__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_2_3__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_2_1__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_53_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_53_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_54_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_54_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_55_clk clknet_2_0__leaf_clk VSS VSS VDD VDD clknet_leaf_55_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__inv_6
Xclkload2 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_1
Xclkload3 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinv_2
Xclkload4 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkinv_2
Xclkload5 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__bufinv_16
Xclkload6 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkbuf_1
Xclkload7 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkinv_1
Xclkload8 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload9 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkbuf_1
Xclkload10 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkinv_2
Xclkload11 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkbuf_1
Xclkload12 clknet_leaf_53_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__clkinv_2
Xclkload13 clknet_leaf_55_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__bufinv_16
Xclkload14 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__bufinv_16
Xclkload15 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__clkinv_4
Xclkload16 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkbuf_1
Xclkload17 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_1
Xclkload18 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload19 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkbuf_8
Xclkload20 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkbuf_1
Xclkload21 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__clkbuf_8
Xclkload22 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__clkbuf_1
Xclkload23 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_51
+ sky130_fd_sc_hd__clkbuf_1
Xclkload24 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_52
+ sky130_fd_sc_hd__clkbuf_1
Xclkload25 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_53
+ sky130_fd_sc_hd__clkinv_2
Xclkload26 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_54
+ sky130_fd_sc_hd__bufinv_16
Xclkload27 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_55
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload28 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_56
+ sky130_fd_sc_hd__bufinv_16
Xclkload29 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_57
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload30 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_58
+ sky130_fd_sc_hd__clkinv_2
Xclkload31 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_59
+ sky130_fd_sc_hd__bufinv_16
Xclkload32 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_60
+ sky130_fd_sc_hd__clkbuf_1
Xclkload33 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_61
+ sky130_fd_sc_hd__clkinv_2
Xclkload34 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_62
+ sky130_fd_sc_hd__clkinv_2
Xclkload35 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_63
+ sky130_fd_sc_hd__clkinv_2
Xclkload36 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_64
+ sky130_fd_sc_hd__clkinv_2
Xclkload37 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_65
+ sky130_fd_sc_hd__clkbuf_1
Xclkload38 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_66
+ sky130_fd_sc_hd__bufinv_16
Xclkload39 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_67
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload40 clknet_leaf_16_clk VSS VSS VDD VDD _unconnected_68
+ sky130_fd_sc_hd__bufinv_16
Xclkload41 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_69
+ sky130_fd_sc_hd__bufinv_16
Xclkload42 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_70
+ sky130_fd_sc_hd__clkinv_2
Xclkload43 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_71
+ sky130_fd_sc_hd__bufinv_16
Xclkload44 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_72
+ sky130_fd_sc_hd__bufinv_16
Xclkload45 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_73
+ sky130_fd_sc_hd__clkbuf_8
Xclkload46 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_74
+ sky130_fd_sc_hd__clkinv_2
Xclkload47 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_75
+ sky130_fd_sc_hd__clkbuf_8
Xclkload48 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_76
+ sky130_fd_sc_hd__clkbuf_8
Xclkload49 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_77
+ sky130_fd_sc_hd__clkbuf_1
Xclkload50 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_78
+ sky130_fd_sc_hd__inv_6
Xclkload51 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_79
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload52 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_80
+ sky130_fd_sc_hd__inv_6
Xclkload53 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_81
+ sky130_fd_sc_hd__inv_8
Xrebuffer1 _07667_ VSS VSS VDD VDD net386 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer2 _07667_ VSS VSS VDD VDD net387 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer3 net411 VSS VSS VDD VDD net388 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer4 _02780_ VSS VSS VDD VDD net389 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer5 _02701_ VSS VSS VDD VDD net390 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer6 _02963_ VSS VSS VDD VDD net391 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer7 net407 VSS VSS VDD VDD net392 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 _02784_ VSS VSS VDD VDD net393 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer9 net393 VSS VSS VDD VDD net394 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 _02978_ VSS VSS VDD VDD net395 sky130_fd_sc_hd__buf_2
Xrebuffer11 _02700_ VSS VSS VDD VDD net396 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer12 _07677_ VSS VSS VDD VDD net397 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 net418 VSS VSS VDD VDD net398 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 net398 VSS VSS VDD VDD net399 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer15 _02778_ VSS VSS VDD VDD net400 sky130_fd_sc_hd__dlygate4sd1_1
Xclone34 _01390_ VSS VSS VDD VDD net401 sky130_fd_sc_hd__clkbuf_16
Xrebuffer35 _02785_ VSS VSS VDD VDD net402 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer36 _02861_ VSS VSS VDD VDD net403 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer37 _02861_ VSS VSS VDD VDD net404 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer38 net404 VSS VSS VDD VDD net405 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer39 net405 VSS VSS VDD VDD net406 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer41 _02962_ VSS VSS VDD VDD net408 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer42 _02960_ VSS VSS VDD VDD net409 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer49 _02958_ VSS VSS VDD VDD net416 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer50 net414 VSS VSS VDD VDD net417 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer51 net419 VSS VSS VDD VDD net418 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer52 net420 VSS VSS VDD VDD net419 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer53 net421 VSS VSS VDD VDD net420 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer54 _07677_ VSS VSS VDD VDD net421 sky130_fd_sc_hd__clkbuf_2
Xrebuffer55 net433 VSS VSS VDD VDD net422 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer56 _02862_ VSS VSS VDD VDD net423 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer57 net423 VSS VSS VDD VDD net424 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer58 _02862_ VSS VSS VDD VDD net425 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer59 _02862_ VSS VSS VDD VDD net426 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer60 _07675_ VSS VSS VDD VDD net427 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer61 _01960_ VSS VSS VDD VDD net428 sky130_fd_sc_hd__buf_4
Xrebuffer75 _03463_ VSS VSS VDD VDD net442 sky130_fd_sc_hd__buf_2
Xrebuffer76 idx2\[2\] VSS VSS VDD VDD net443 sky130_fd_sc_hd__buf_6
Xrebuffer77 net443 VSS VSS VDD VDD net444 sky130_fd_sc_hd__buf_2
Xrebuffer78 net443 VSS VSS VDD VDD net445 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer79 net445 VSS VSS VDD VDD net446 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer80 net443 VSS VSS VDD VDD net447 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer81 _06041_ VSS VSS VDD VDD net448 sky130_fd_sc_hd__buf_2
Xrebuffer82 _06041_ VSS VSS VDD VDD net449 sky130_fd_sc_hd__buf_2
Xrebuffer83 _06041_ VSS VSS VDD VDD net450 sky130_fd_sc_hd__dlygate4sd1_1
Xclone84 _03237_ VSS VSS VDD VDD net451 sky130_fd_sc_hd__clkbuf_16
Xclone85 net470 VSS VSS VDD VDD net452 sky130_fd_sc_hd__clkbuf_16
Xrebuffer86 _05962_ VSS VSS VDD VDD net453 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer87 _05962_ VSS VSS VDD VDD net454 sky130_fd_sc_hd__clkbuf_2
Xrebuffer88 _03442_ VSS VSS VDD VDD net455 sky130_fd_sc_hd__buf_6
Xrebuffer89 net455 VSS VSS VDD VDD net456 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer93 _03342_ VSS VSS VDD VDD net462 sky130_fd_sc_hd__buf_12
Xrebuffer104 _08146_ VSS VSS VDD VDD net471 sky130_fd_sc_hd__buf_6
Xrebuffer105 net471 VSS VSS VDD VDD net472 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer106 net471 VSS VSS VDD VDD net473 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer107 idx2\[0\] VSS VSS VDD VDD net474 sky130_fd_sc_hd__buf_1
Xrebuffer108 net474 VSS VSS VDD VDD net475 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer109 _03269_ VSS VSS VDD VDD net476 sky130_fd_sc_hd__buf_2
Xrebuffer110 net476 VSS VSS VDD VDD net477 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer111 _03324_ VSS VSS VDD VDD net478 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer112 _03354_ VSS VSS VDD VDD net479 sky130_fd_sc_hd__buf_6
Xrebuffer113 net479 VSS VSS VDD VDD net480 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer114 net480 VSS VSS VDD VDD net481 sky130_fd_sc_hd__buf_4
Xrebuffer115 _03277_ VSS VSS VDD VDD net482 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer116 _03378_ VSS VSS VDD VDD net483 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer117 net483 VSS VSS VDD VDD net484 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer118 _03378_ VSS VSS VDD VDD net485 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer119 _06729_ VSS VSS VDD VDD net486 sky130_fd_sc_hd__buf_6
Xrebuffer120 net486 VSS VSS VDD VDD net487 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer121 net486 VSS VSS VDD VDD net488 sky130_fd_sc_hd__buf_6
Xrebuffer122 net488 VSS VSS VDD VDD net489 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer123 net488 VSS VSS VDD VDD net490 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer124 net490 VSS VSS VDD VDD net491 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer125 net486 VSS VSS VDD VDD net492 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer126 idx2\[1\] VSS VSS VDD VDD net493 sky130_fd_sc_hd__clkbuf_2
Xrebuffer127 net493 VSS VSS VDD VDD net494 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer128 _03308_ VSS VSS VDD VDD net495 sky130_fd_sc_hd__buf_6
Xrebuffer129 net495 VSS VSS VDD VDD net496 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer130 net495 VSS VSS VDD VDD net497 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer131 _03415_ VSS VSS VDD VDD net498 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer132 net440 VSS VSS VDD VDD net499 sky130_fd_sc_hd__buf_2
Xrebuffer133 net499 VSS VSS VDD VDD net500 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer134 net499 VSS VSS VDD VDD net501 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer135 _03393_ VSS VSS VDD VDD net502 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer136 net502 VSS VSS VDD VDD net503 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer137 _03386_ VSS VSS VDD VDD net504 sky130_fd_sc_hd__buf_6
Xrebuffer138 net504 VSS VSS VDD VDD net505 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer139 _03277_ VSS VSS VDD VDD net506 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer140 idx2\[0\] VSS VSS VDD VDD net507 sky130_fd_sc_hd__clkbuf_2
Xrebuffer141 _03325_ VSS VSS VDD VDD net508 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer142 _03242_ VSS VSS VDD VDD net509 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer147 idx1\[1\] VSS VSS VDD VDD net514 sky130_fd_sc_hd__buf_6
Xrebuffer148 net514 VSS VSS VDD VDD net515 sky130_fd_sc_hd__clkbuf_2
Xrebuffer149 net579 VSS VSS VDD VDD net516 sky130_fd_sc_hd__buf_6
Xrebuffer150 net635 VSS VSS VDD VDD net517 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer151 _03923_ VSS VSS VDD VDD net518 sky130_fd_sc_hd__buf_12
Xrebuffer152 idx1\[2\] VSS VSS VDD VDD net519 sky130_fd_sc_hd__buf_6
Xrebuffer153 net519 VSS VSS VDD VDD net520 sky130_fd_sc_hd__clkbuf_2
Xrebuffer154 net519 VSS VSS VDD VDD net521 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer155 net521 VSS VSS VDD VDD net522 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer156 net531 VSS VSS VDD VDD net523 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer157 _03922_ VSS VSS VDD VDD net524 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer158 _03922_ VSS VSS VDD VDD net525 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer159 idx1\[0\] VSS VSS VDD VDD net526 sky130_fd_sc_hd__buf_6
Xrebuffer231 net601 VSS VSS VDD VDD net603 sky130_fd_sc_hd__buf_2
Xrebuffer161 net572 VSS VSS VDD VDD net528 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer162 net530 VSS VSS VDD VDD net529 sky130_fd_sc_hd__buf_2
Xrebuffer163 net532 VSS VSS VDD VDD net530 sky130_fd_sc_hd__buf_1
Xrebuffer165 net533 VSS VSS VDD VDD net532 sky130_fd_sc_hd__buf_1
Xrebuffer166 net537 VSS VSS VDD VDD net533 sky130_fd_sc_hd__buf_1
Xrebuffer168 _03156_ VSS VSS VDD VDD net535 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer169 _03156_ VSS VSS VDD VDD net536 sky130_fd_sc_hd__buf_4
Xrebuffer170 net558 VSS VSS VDD VDD net537 sky130_fd_sc_hd__buf_1
Xrebuffer171 _03155_ VSS VSS VDD VDD net538 sky130_fd_sc_hd__dlygate4sd1_1
Xclone172 net540 VSS VSS VDD VDD net539 sky130_fd_sc_hd__buf_2
Xrebuffer173 _03154_ VSS VSS VDD VDD net540 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer174 _03913_ VSS VSS VDD VDD net541 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer175 _03990_ VSS VSS VDD VDD net542 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer176 _03917_ VSS VSS VDD VDD net543 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer177 _03909_ VSS VSS VDD VDD net544 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer178 _03947_ VSS VSS VDD VDD net545 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer179 net633 VSS VSS VDD VDD net546 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer180 _03196_ VSS VSS VDD VDD net547 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer181 net547 VSS VSS VDD VDD net548 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer182 net596 VSS VSS VDD VDD net549 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer183 net549 VSS VSS VDD VDD net550 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer184 net549 VSS VSS VDD VDD net551 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer185 _03161_ VSS VSS VDD VDD net552 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer186 net595 VSS VSS VDD VDD net553 sky130_fd_sc_hd__buf_6
Xrebuffer187 _03951_ VSS VSS VDD VDD net554 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer188 _03160_ VSS VSS VDD VDD net555 sky130_fd_sc_hd__clkbuf_2
Xrebuffer189 net598 VSS VSS VDD VDD net556 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer190 _03955_ VSS VSS VDD VDD net557 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer191 net602 VSS VSS VDD VDD net558 sky130_fd_sc_hd__buf_1
Xrebuffer192 _03152_ VSS VSS VDD VDD net559 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer193 _03152_ VSS VSS VDD VDD net560 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer194 _03152_ VSS VSS VDD VDD net561 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer195 net561 VSS VSS VDD VDD net562 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer196 _03963_ VSS VSS VDD VDD net563 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer198 _05039_ VSS VSS VDD VDD net565 sky130_fd_sc_hd__clkbuf_2
Xrebuffer199 net565 VSS VSS VDD VDD net566 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer200 net611 VSS VSS VDD VDD net567 sky130_fd_sc_hd__clkbuf_2
Xclone201 _05040_ VSS VSS VDD VDD net568 sky130_fd_sc_hd__clkbuf_16
Xrebuffer202 net570 VSS VSS VDD VDD net569 sky130_fd_sc_hd__buf_2
Xrebuffer203 net571 VSS VSS VDD VDD net570 sky130_fd_sc_hd__buf_1
Xrebuffer204 net585 VSS VSS VDD VDD net571 sky130_fd_sc_hd__buf_1
Xrebuffer205 net526 VSS VSS VDD VDD net572 sky130_fd_sc_hd__buf_6
Xrebuffer206 _05032_ VSS VSS VDD VDD net573 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer207 _03167_ VSS VSS VDD VDD net574 sky130_fd_sc_hd__buf_4
Xrebuffer208 _03153_ VSS VSS VDD VDD net575 sky130_fd_sc_hd__clkbuf_2
Xrebuffer209 _03153_ VSS VSS VDD VDD net576 sky130_fd_sc_hd__clkbuf_2
Xrebuffer210 _05092_ VSS VSS VDD VDD net577 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer211 _05885_ VSS VSS VDD VDD net578 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer212 net514 VSS VSS VDD VDD net579 sky130_fd_sc_hd__clkbuf_2
Xrebuffer213 _03167_ VSS VSS VDD VDD net580 sky130_fd_sc_hd__buf_4
Xrebuffer214 _05082_ VSS VSS VDD VDD net581 sky130_fd_sc_hd__clkbuf_2
Xrebuffer215 _03167_ VSS VSS VDD VDD net582 sky130_fd_sc_hd__buf_8
Xrebuffer216 net582 VSS VSS VDD VDD net583 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer217 _03175_ VSS VSS VDD VDD net584 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer218 net512 VSS VSS VDD VDD net585 sky130_fd_sc_hd__buf_1
Xrebuffer219 _03164_ VSS VSS VDD VDD net586 sky130_fd_sc_hd__buf_4
Xrebuffer220 net586 VSS VSS VDD VDD net587 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer221 _05887_ VSS VSS VDD VDD net588 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer222 _03149_ VSS VSS VDD VDD net589 sky130_fd_sc_hd__buf_2
Xrebuffer223 _03149_ VSS VSS VDD VDD net590 sky130_fd_sc_hd__buf_8
Xrebuffer224 _03153_ VSS VSS VDD VDD net591 sky130_fd_sc_hd__buf_4
Xrebuffer225 _05070_ VSS VSS VDD VDD net592 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer235 net637 VSS VSS VDD VDD net602 sky130_fd_sc_hd__buf_1
Xrebuffer229 _03170_ VSS VSS VDD VDD net600 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer243 _07732_ VSS VSS VDD VDD net610 sky130_fd_sc_hd__buf_6
Xrebuffer246 _03202_ VSS VSS VDD VDD net613 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer247 net613 VSS VSS VDD VDD net614 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer248 _03161_ VSS VSS VDD VDD net615 sky130_fd_sc_hd__buf_6
Xrebuffer249 _03967_ VSS VSS VDD VDD net616 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer266 net65 VSS VSS VDD VDD net633 sky130_fd_sc_hd__buf_2
Xrebuffer267 net516 VSS VSS VDD VDD net634 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer268 net634 VSS VSS VDD VDD net635 sky130_fd_sc_hd__buf_2
Xrebuffer269 net635 VSS VSS VDD VDD net636 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer270 _07846_ VSS VSS VDD VDD net637 sky130_fd_sc_hd__buf_8
Xrebuffer271 _03934_ VSS VSS VDD VDD net638 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer272 _04016_ VSS VSS VDD VDD net639 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer273 _03209_ VSS VSS VDD VDD net640 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer274 _03959_ VSS VSS VDD VDD net641 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer275 net643 VSS VSS VDD VDD net642 sky130_fd_sc_hd__dlygate4sd1_1
Xclone276 net591 VSS VSS VDD VDD net643 sky130_fd_sc_hd__clkbuf_16
Xrebuffer277 _03930_ VSS VSS VDD VDD net644 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer279 _04045_ VSS VSS VDD VDD net646 sky130_fd_sc_hd__buf_8
Xrebuffer280 _04097_ VSS VSS VDD VDD net647 sky130_fd_sc_hd__buf_6
Xload_slew1 temp_real\[0\] VSS VSS VDD VDD net53 sky130_fd_sc_hd__buf_16
Xclone40 _01870_ _01886_ VSS VSS VDD VDD net410 sky130_fd_sc_hd__nor2_4
Xrebuffer43 _02692_ VSS VSS VDD VDD net411 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer63 _07674_ VSS VSS VDD VDD net431 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer64 net431 VSS VSS VDD VDD net432 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer65 _02957_ VSS VSS VDD VDD net433 sky130_fd_sc_hd__dlygate4sd1_1
Xclone67 net435 VSS VSS VDD VDD net434 sky130_fd_sc_hd__clkbuf_16
Xrebuffer68 _02863_ VSS VSS VDD VDD net435 sky130_fd_sc_hd__buf_2
Xrebuffer71 _03362_ VSS VSS VDD VDD net438 sky130_fd_sc_hd__buf_8
Xrebuffer72 net438 VSS VSS VDD VDD net439 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer73 _03415_ VSS VSS VDD VDD net440 sky130_fd_sc_hd__buf_6
Xrebuffer74 _03269_ VSS VSS VDD VDD net441 sky130_fd_sc_hd__buf_6
Xrebuffer84 net441 VSS VSS VDD VDD net458 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer85 _06713_ VSS VSS VDD VDD net459 sky130_fd_sc_hd__dlygate4sd3_1
Xrebuffer91 _06713_ VSS VSS VDD VDD net460 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer92 _03607_ VSS VSS VDD VDD net461 sky130_fd_sc_hd__buf_6
Xrebuffer94 net462 VSS VSS VDD VDD net463 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer95 net463 VSS VSS VDD VDD net464 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer96 _03319_ VSS VSS VDD VDD net465 sky130_fd_sc_hd__clkbuf_4
Xrebuffer97 _06631_ VSS VSS VDD VDD net466 sky130_fd_sc_hd__buf_6
Xrebuffer98 _03463_ VSS VSS VDD VDD net467 sky130_fd_sc_hd__buf_6
Xrebuffer99 _03463_ VSS VSS VDD VDD net468 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer100 _03238_ VSS VSS VDD VDD net469 sky130_fd_sc_hd__buf_4
Xrebuffer101 _03235_ VSS VSS VDD VDD net470 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer102 _03286_ VSS VSS VDD VDD net510 sky130_fd_sc_hd__buf_6
Xrebuffer143 _07732_ VSS VSS VDD VDD net512 sky130_fd_sc_hd__clkbuf_2
Xrebuffer144 _05045_ VSS VSS VDD VDD net513 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer145 _05057_ VSS VSS VDD VDD net564 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer146 _05039_ VSS VSS VDD VDD net593 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer172 _05887_ VSS VSS VDD VDD net594 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer197 _03161_ VSS VSS VDD VDD net595 sky130_fd_sc_hd__buf_6
Xrebuffer201 _03161_ VSS VSS VDD VDD net596 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer226 _05074_ VSS VSS VDD VDD net597 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer227 _03160_ VSS VSS VDD VDD net598 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer228 _05078_ VSS VSS VDD VDD net599 sky130_fd_sc_hd__buf_2
Xrebuffer232 _03165_ VSS VSS VDD VDD net604 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer233 _03165_ VSS VSS VDD VDD net605 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer234 net605 VSS VSS VDD VDD net606 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer236 _03164_ VSS VSS VDD VDD net607 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer239 _05105_ VSS VSS VDD VDD net611 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer240 _07792_ VSS VSS VDD VDD net612 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer241 _07792_ VSS VSS VDD VDD net617 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_2 _04194_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 samples_imag\[1\]\[2\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 samples_imag\[1\]\[5\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 samples_imag\[2\]\[7\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 samples_imag\[2\]\[8\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_7 samples_imag\[3\]\[8\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_8 samples_imag\[5\]\[12\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_9 samples_imag\[7\]\[12\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_10 samples_real\[0\]\[10\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_11 samples_real\[0\]\[11\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_12 samples_real\[0\]\[7\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_13 samples_real\[0\]\[9\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_14 samples_real\[0\]\[9\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_15 samples_real\[0\]\[9\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_16 samples_real\[1\]\[14\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_17 samples_real\[2\]\[14\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_18 samples_real\[6\]\[0\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_19 samples_real\[7\]\[0\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_20 samples_real\[7\]\[15\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_21 samples_imag\[0\]\[8\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_22 samples_real\[0\]\[12\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_23 samples_real\[3\]\[1\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_24 samples_real\[5\]\[0\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_25 samples_real\[5\]\[13\] VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_26 net106 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_27 net121 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_28 net121 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_29 net163 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS parameterized_fft
