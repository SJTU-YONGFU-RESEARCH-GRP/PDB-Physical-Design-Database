* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT barrel_rotator data_in[0] data_in[1] data_in[2] data_in[3]
+ data_in[4] data_in[5] data_in[6] data_in[7] data_out[0] data_out[1]
+ data_out[2] data_out[3] data_out[4] data_out[5] data_out[6]
+ data_out[7] direction rotate_amount[0] rotate_amount[1] rotate_amount[2]
X_148_ data_in[0] _071_ VDD VSS BUF_X2
X_149_ net1 _072_ VDD VSS BUF_X4
X_150_ _072_ _073_ VDD VSS CLKBUF_X3
X_151_ _073_ _074_ VDD VSS BUF_X4
X_152_ rotate_amount[1] _075_ VDD VSS BUF_X4
X_153_ _075_ _076_ VDD VSS INV_X4
X_154_ rotate_amount[0] _077_ VDD VSS BUF_X4
X_155_ _077_ _078_ VDD VSS INV_X2
X_156_ _076_ _078_ _079_ VDD VSS NAND2_X2
X_157_ _074_ _079_ _080_ VDD VSS NOR2_X2
X_158_ _071_ _080_ _081_ VDD VSS NAND2_X1
X_159_ _075_ _082_ VDD VSS CLKBUF_X3
X_160_ _072_ _083_ VDD VSS INV_X1
X_161_ _083_ _084_ VDD VSS CLKBUF_X3
X_162_ data_in[6] _085_ VDD VSS CLKBUF_X2
X_163_ data_in[7] _086_ VDD VSS BUF_X2
X_164_ _077_ _087_ VDD VSS BUF_X8
X_165_ _085_ _086_ _087_ _088_ VDD VSS MUX2_X1
X_166_ _084_ _088_ _089_ VDD VSS NOR2_X1
X_167_ _087_ _090_ VDD VSS BUF_X4
X_168_ data_in[2] _091_ VDD VSS BUF_X2
X_169_ _090_ _091_ _092_ VDD VSS OR2_X1
X_170_ data_in[3] _093_ VDD VSS BUF_X4
X_171_ _078_ _094_ VDD VSS CLKBUF_X3
X_172_ _092_ _093_ _094_ _095_ VDD VSS OAI21_X1
X_173_ _089_ _095_ _084_ _096_ VDD VSS AOI21_X1
X_174_ _075_ _097_ VDD VSS CLKBUF_X3
X_175_ data_in[4] _098_ VDD VSS BUF_X2
X_176_ direction _099_ VDD VSS BUF_X4
X_177_ _097_ _074_ _098_ _099_ _100_ VDD VSS OAI22_X1
X_178_ _094_ _100_ _101_ VDD VSS NAND2_X1
X_179_ _099_ _102_ VDD VSS INV_X4
X_180_ data_in[1] _103_ VDD VSS BUF_X2
X_181_ data_in[5] _104_ VDD VSS BUF_X2
X_182_ _103_ _104_ _072_ _105_ VDD VSS MUX2_X1
X_183_ _078_ _105_ _106_ VDD VSS NOR2_X1
X_184_ _102_ _106_ _082_ _107_ VDD VSS OAI21_X1
X_185_ _082_ _096_ _101_ _107_ _108_ VDD VSS AOI22_X1
X_186_ _073_ _098_ _109_ VDD VSS NAND2_X1
X_187_ _087_ _110_ VDD VSS CLKBUF_X3
X_188_ _086_ _093_ net1 _111_ VDD VSS MUX2_X2
X_189_ _110_ _111_ _112_ VDD VSS NAND2_X1
X_190_ _099_ _079_ _109_ _112_ _097_ _113_ VDD VSS OAI221_X1
X_191_ _104_ _103_ _072_ _114_ VDD VSS MUX2_X2
X_192_ _110_ _114_ _115_ VDD VSS NAND2_X1
X_193_ _085_ _091_ _072_ _116_ VDD VSS MUX2_X2
X_194_ _094_ _116_ _117_ VDD VSS NAND2_X1
X_195_ _115_ _117_ _118_ VDD VSS NAND2_X1
X_196_ _113_ _118_ _082_ _119_ VDD VSS AOI21_X1
X_197_ _081_ _108_ _119_ net2 VDD VSS OAI21_X1
X_198_ _074_ _103_ _079_ _120_ VDD VSS NOR3_X1
X_199_ _090_ _086_ _072_ _121_ VDD VSS AOI21_X1
X_200_ _093_ _122_ VDD VSS INV_X1
X_201_ _121_ _122_ _073_ _123_ VDD VSS OAI21_X1
X_202_ _098_ _071_ _072_ _124_ VDD VSS MUX2_X1
X_203_ _078_ _124_ _125_ VDD VSS OR2_X1
X_204_ _082_ _123_ _125_ _126_ VDD VSS NAND3_X1
X_205_ _075_ _077_ _127_ VDD VSS NOR2_X2
X_206_ _083_ _104_ _128_ VDD VSS OR2_X1
X_207_ _091_ _085_ _072_ _129_ VDD VSS MUX2_X1
X_208_ _075_ _078_ _130_ VDD VSS NOR2_X2
X_209_ _099_ _127_ _128_ _129_ _130_ _131_ VDD VSS AOI221_X1
X_210_ _126_ _131_ _132_ VDD VSS AND2_X1
X_211_ _097_ _110_ _116_ _133_ VDD VSS NAND3_X1
X_212_ _071_ _098_ _072_ _134_ VDD VSS MUX2_X1
X_213_ _076_ _090_ _134_ _135_ VDD VSS NAND3_X1
X_214_ _075_ _094_ _111_ _136_ VDD VSS NAND3_X1
X_215_ _099_ _133_ _135_ _136_ _137_ VDD VSS NAND4_X1
X_216_ _137_ _128_ _127_ _138_ VDD VSS AOI21_X1
X_217_ _120_ _132_ _138_ net3 VDD VSS NOR3_X1
X_218_ _075_ _090_ _134_ _139_ VDD VSS OAI21_X1
X_219_ _111_ _140_ VDD VSS INV_X1
X_220_ _139_ _140_ _110_ _141_ VDD VSS AOI21_X1
X_221_ _083_ _087_ _085_ _142_ VDD VSS NOR3_X1
X_222_ _097_ _106_ _142_ _143_ VDD VSS NOR3_X1
X_223_ _074_ _091_ _079_ _141_ _143_ _102_ _144_ VDD VSS OAI33_X1
X_224_ _074_ _094_ _093_ _145_ VDD VSS NOR3_X1
X_225_ _076_ _089_ _145_ _146_ VDD VSS OAI21_X1
X_226_ _114_ _124_ _094_ _147_ VDD VSS MUX2_X1
X_227_ _146_ _147_ _076_ _000_ VDD VSS OAI21_X1
X_228_ _144_ _000_ _102_ net4 VDD VSS AOI21_X1
X_229_ _082_ _121_ _001_ VDD VSS NOR2_X1
X_230_ _114_ _116_ _110_ _002_ VDD VSS MUX2_X1
X_231_ _125_ _001_ _002_ _082_ _003_ VDD VSS AOI22_X2
X_232_ _099_ _080_ _093_ _004_ VDD VSS AOI21_X1
X_233_ _102_ _080_ _093_ _005_ VDD VSS AOI21_X1
X_234_ _086_ _085_ _087_ _006_ VDD VSS MUX2_X1
X_235_ _073_ _006_ _007_ VDD VSS NAND2_X1
X_236_ _084_ _110_ _091_ _008_ VDD VSS NAND3_X1
X_237_ _097_ _007_ _008_ _009_ VDD VSS AOI21_X1
X_238_ _105_ _134_ _110_ _010_ VDD VSS MUX2_X1
X_239_ _009_ _010_ _082_ _011_ VDD VSS AOI21_X2
X_240_ _003_ _004_ _005_ _011_ net5 VDD VSS AOI22_X2
X_241_ _127_ _071_ _084_ _012_ VDD VSS OAI21_X1
X_242_ _102_ _012_ _013_ VDD VSS NAND2_X1
X_243_ _082_ _110_ _114_ _014_ VDD VSS AOI21_X1
X_244_ _014_ _015_ VDD VSS INV_X1
X_245_ _082_ _117_ _112_ _016_ VDD VSS NAND3_X1
X_246_ _013_ _015_ _016_ _017_ VDD VSS AOI21_X1
X_247_ _097_ _110_ _103_ _018_ VDD VSS NAND3_X1
X_248_ _094_ _091_ _076_ _019_ VDD VSS OAI21_X1
X_249_ _074_ _018_ _019_ _020_ VDD VSS AOI21_X1
X_250_ _085_ _104_ _087_ _021_ VDD VSS MUX2_X1
X_251_ _097_ _073_ _021_ _022_ VDD VSS NAND3_X1
X_252_ _099_ _022_ _023_ VDD VSS NAND2_X1
X_253_ _071_ _086_ _087_ _024_ VDD VSS MUX2_X1
X_254_ _073_ _024_ _025_ VDD VSS NAND2_X1
X_255_ _084_ _090_ _093_ _026_ VDD VSS NAND3_X1
X_256_ _097_ _025_ _026_ _027_ VDD VSS AOI21_X1
X_257_ _074_ _098_ _079_ _020_ _023_ _027_ _028_ VDD VSS OAI33_X1
X_258_ _017_ _028_ net6 VDD VSS NOR2_X1
X_259_ _127_ _103_ _083_ _029_ VDD VSS OAI21_X1
X_260_ _102_ _029_ _030_ VDD VSS NAND2_X1
X_261_ _111_ _134_ _087_ _031_ VDD VSS MUX2_X1
X_262_ _030_ _031_ _097_ _116_ _130_ _032_ VDD VSS AOI221_X2
X_263_ _084_ _110_ _098_ _033_ VDD VSS NAND3_X1
X_264_ _103_ _071_ _087_ _034_ VDD VSS MUX2_X1
X_265_ _073_ _034_ _035_ VDD VSS NAND2_X1
X_266_ _097_ _033_ _035_ _036_ VDD VSS AOI21_X1
X_267_ _075_ _090_ _091_ _037_ VDD VSS NAND3_X1
X_268_ _094_ _093_ _076_ _038_ VDD VSS OAI21_X1
X_269_ _074_ _037_ _038_ _039_ VDD VSS AOI21_X1
X_270_ _075_ _073_ _006_ _040_ VDD VSS NAND3_X1
X_271_ _099_ _040_ _041_ VDD VSS NAND2_X1
X_272_ _074_ _104_ _079_ _036_ _039_ _041_ _042_ VDD VSS OAI33_X1
X_273_ _032_ _042_ net7 VDD VSS NOR2_X1
X_274_ _130_ _043_ VDD VSS INV_X1
X_275_ _114_ _111_ _102_ _044_ VDD VSS MUX2_X1
X_276_ _079_ _116_ _043_ _044_ _045_ VDD VSS OAI22_X1
X_277_ _098_ _104_ _090_ _046_ VDD VSS MUX2_X1
X_278_ _074_ _046_ _047_ VDD VSS NAND2_X1
X_279_ _071_ _103_ _090_ _048_ VDD VSS MUX2_X1
X_280_ _084_ _048_ _049_ VDD VSS NAND2_X1
X_281_ _076_ _094_ _111_ _092_ _084_ _050_ VDD VSS OAI221_X1
X_282_ _047_ _049_ _050_ _051_ VDD VSS NAND3_X1
X_283_ _102_ _051_ _052_ VDD VSS NAND2_X1
X_284_ _098_ _093_ _090_ _053_ VDD VSS MUX2_X1
X_285_ _084_ _053_ _054_ VDD VSS NAND2_X1
X_286_ _076_ _094_ _114_ _092_ _084_ _055_ VDD VSS OAI221_X1
X_287_ _025_ _054_ _055_ _056_ VDD VSS NAND3_X1
X_288_ _099_ _056_ _057_ VDD VSS NAND2_X1
X_289_ _045_ _052_ _057_ net8 VDD VSS AOI21_X1
X_290_ _086_ _058_ VDD VSS INV_X1
X_291_ _073_ _122_ _059_ VDD VSS NAND2_X1
X_292_ _102_ _116_ _130_ _059_ _127_ _060_ VDD VSS AOI221_X2
X_293_ _090_ _114_ _061_ VDD VSS OR2_X1
X_294_ _082_ _125_ _061_ _062_ VDD VSS NAND3_X1
X_295_ _093_ _098_ _087_ _063_ VDD VSS MUX2_X1
X_296_ _083_ _063_ _064_ VDD VSS NOR2_X1
X_297_ _073_ _078_ _071_ _065_ VDD VSS NOR3_X1
X_298_ _076_ _064_ _065_ _066_ VDD VSS OAI21_X1
X_299_ _103_ _091_ _077_ _067_ VDD VSS MUX2_X1
X_300_ _104_ _085_ _077_ _068_ VDD VSS MUX2_X1
X_301_ _067_ _068_ _072_ _069_ VDD VSS MUX2_X1
X_302_ _066_ _069_ _076_ _070_ VDD VSS OAI21_X1
X_303_ _058_ _080_ _060_ _062_ _070_ _102_ net9 VDD VSS AOI222_X2
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_87 VDD VSS TAPCELL_X1
Xinput1 rotate_amount[2] net1 VDD VSS BUF_X1
Xoutput2 net2 data_out[0] VDD VSS BUF_X1
Xoutput3 net3 data_out[1] VDD VSS BUF_X1
Xoutput4 net4 data_out[2] VDD VSS BUF_X1
Xoutput5 net5 data_out[3] VDD VSS BUF_X1
Xoutput6 net6 data_out[4] VDD VSS BUF_X1
Xoutput7 net7 data_out[5] VDD VSS BUF_X1
Xoutput8 net8 data_out[6] VDD VSS BUF_X1
Xoutput9 net9 data_out[7] VDD VSS BUF_X1
.ENDS barrel_rotator
