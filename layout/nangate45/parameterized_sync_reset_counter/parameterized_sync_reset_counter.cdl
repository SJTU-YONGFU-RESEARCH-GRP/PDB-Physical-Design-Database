* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_sync_reset_counter clk count[0] count[1]
+ count[2] count[3] count[4] count[5] count[6] count[7] enable
+ sync_rst tc
X_48_ sync_rst _08_ VDD VSS CLKBUF_X3
X_49_ enable _09_ VDD VSS BUF_X4
X_50_ _09_ _10_ VDD VSS INV_X1
X_51_ net1 _10_ _11_ VDD VSS NAND2_X1
X_52_ net8 _12_ VDD VSS INV_X1
X_53_ net4 _13_ VDD VSS BUF_X2
X_54_ net5 _14_ VDD VSS BUF_X2
X_55_ _13_ net6 _14_ net7 _15_ VDD VSS NAND4_X2
X_56_ net3 _16_ VDD VSS BUF_X2
X_57_ _16_ _46_ _17_ VDD VSS NAND2_X1
X_58_ _12_ _15_ _17_ net9 VDD VSS NOR3_X1
X_59_ net1 _10_ _08_ _18_ VDD VSS OR3_X1
X_60_ _08_ _11_ net9 _18_ _00_ VDD VSS OAI22_X1
X_61_ _09_ _47_ _19_ VDD VSS NAND2_X1
X_62_ net2 _10_ _20_ VDD VSS NAND2_X1
X_63_ _08_ _19_ _20_ _01_ VDD VSS AOI21_X1
X_64_ _46_ _09_ _21_ VDD VSS NAND2_X1
X_65_ _16_ _21_ _22_ VDD VSS XOR2_X1
X_66_ _08_ _22_ _02_ VDD VSS NOR2_X1
X_67_ _16_ _46_ _09_ _23_ VDD VSS NAND3_X2
X_68_ _12_ _15_ _23_ _24_ VDD VSS NOR3_X2
X_69_ _16_ net1 net2 _09_ _25_ VDD VSS NAND4_X2
X_70_ _13_ _25_ _26_ VDD VSS XOR2_X1
X_71_ _08_ _24_ _26_ _03_ VDD VSS NOR3_X1
X_72_ _13_ _16_ _46_ _09_ _27_ VDD VSS NAND4_X1
X_73_ _14_ _27_ _28_ VDD VSS XOR2_X1
X_74_ _08_ _28_ _04_ VDD VSS NOR2_X1
X_75_ _13_ _14_ _29_ VDD VSS NAND2_X1
X_76_ net6 _29_ _25_ _30_ VDD VSS OAI21_X1
X_77_ net6 _29_ _25_ _31_ VDD VSS OR3_X1
X_78_ _08_ _24_ _30_ _31_ _05_ VDD VSS AOI211_X2
X_79_ _13_ net6 _14_ _32_ VDD VSS NAND3_X1
X_80_ net7 _32_ _23_ _33_ VDD VSS OAI21_X1
X_81_ net7 _32_ _23_ _34_ VDD VSS OR3_X1
X_82_ _08_ _33_ _34_ _06_ VDD VSS AOI21_X1
X_83_ _12_ _15_ _35_ VDD VSS NOR2_X1
X_84_ _23_ _25_ _36_ VDD VSS NAND2_X1
X_85_ _15_ _25_ _37_ VDD VSS OR2_X1
X_86_ _08_ _35_ _36_ _37_ _12_ _07_ VDD VSS AOI221_X1
X_87_ net1 net2 _46_ _47_ VDD VSS HA_X1
Xcounter_reg\[0\]$_SDFFE_PP0P_ _00_ clknet_1_0__leaf_clk net1
+ _45_ VDD VSS DFF_X2
Xcounter_reg\[1\]$_SDFFE_PP0P_ _01_ clknet_1_0__leaf_clk net2
+ _44_ VDD VSS DFF_X2
Xcounter_reg\[2\]$_SDFFE_PP0P_ _02_ clknet_1_0__leaf_clk net3
+ _43_ VDD VSS DFF_X1
Xcounter_reg\[3\]$_SDFFE_PP0P_ _03_ clknet_1_1__leaf_clk net4
+ _42_ VDD VSS DFF_X1
Xcounter_reg\[4\]$_SDFFE_PP0P_ _04_ clknet_1_1__leaf_clk net5
+ _41_ VDD VSS DFF_X1
Xcounter_reg\[5\]$_SDFFE_PP0P_ _05_ clknet_1_1__leaf_clk net6
+ _40_ VDD VSS DFF_X2
Xcounter_reg\[6\]$_SDFFE_PP0P_ _06_ clknet_1_1__leaf_clk net7
+ _39_ VDD VSS DFF_X2
Xcounter_reg\[7\]$_SDFFE_PP0P_ _07_ clknet_1_0__leaf_clk net8
+ _38_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_59 VDD VSS TAPCELL_X1
Xoutput1 net1 count[0] VDD VSS BUF_X1
Xoutput2 net2 count[1] VDD VSS BUF_X1
Xoutput3 net3 count[2] VDD VSS BUF_X1
Xoutput4 net4 count[3] VDD VSS BUF_X1
Xoutput5 net5 count[4] VDD VSS BUF_X1
Xoutput6 net6 count[5] VDD VSS BUF_X1
Xoutput7 net7 count[6] VDD VSS BUF_X1
Xoutput8 net8 count[7] VDD VSS BUF_X1
Xoutput9 net9 tc VDD VSS BUF_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
.ENDS parameterized_sync_reset_counter
