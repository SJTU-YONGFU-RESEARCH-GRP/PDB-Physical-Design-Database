* cell aes_cipher_top
* pin key[20]
* pin key[53]
* pin text_in[111]
* pin key[120]
* pin text_out[120]
* pin ld
* pin key[21]
* pin key[23]
* pin key[19]
* pin key[22]
* pin key[17]
* pin key[54]
* pin key[16]
* pin key[18]
* pin key[8]
* pin text_in[117]
* pin text_out[54]
* pin key[48]
* pin key[117]
* pin key[14]
* pin key[46]
* pin key[109]
* pin key[113]
* pin key[85]
* pin text_in[112]
* pin key[45]
* pin key[49]
* pin key[116]
* pin key[47]
* pin text_out[78]
* pin key[84]
* pin key[79]
* pin key[81]
* pin text_out[53]
* pin key[52]
* pin text_out[117]
* pin text_in[77]
* pin text_in[115]
* pin text_out[112]
* pin key[41]
* pin text_in[116]
* pin key[43]
* pin text_out[118]
* pin text_in[109]
* pin key[75]
* pin key[73]
* pin text_out[116]
* pin key[119]
* pin text_in[110]
* pin key[111]
* pin text_out[49]
* pin text_in[113]
* pin text_out[113]
* pin text_in[107]
* pin key[44]
* pin key[107]
* pin text_out[109]
* pin text_in[104]
* pin text_out[48]
* pin key[40]
* pin text_in[119]
* pin text_out[119]
* pin text_in[114]
* pin text_out[115]
* pin text_in[105]
* pin key[114]
* pin text_out[111]
* pin text_in[108]
* pin text_out[110]
* pin text_out[107]
* pin text_out[104]
* pin text_out[40]
* pin text_out[52]
* pin text_in[126]
* pin key[122]
* pin text_out[114]
* pin text_out[46]
* pin text_out[108]
* pin text_in[122]
* pin text_out[41]
* pin key[126]
* pin key[125]
* pin text_in[45]
* pin text_out[122]
* pin text_in[120]
* pin text_in[127]
* pin key[124]
* pin key[127]
* pin text_out[125]
* pin text_in[124]
* pin text_in[123]
* pin text_out[124]
* pin key[123]
* pin text_out[123]
* pin text_out[121]
* pin text_in[118]
* pin key[115]
* pin text_out[47]
* pin text_in[125]
* pin PWELL
* pin NWELL
* pin clk
* pin text_in[121]
* pin key[121]
* pin text_out[127]
* pin text_out[126]
* pin text_in[47]
* pin text_in[46]
* pin text_in[54]
* pin text_in[62]
* pin text_in[61]
* pin text_in[63]
* pin text_out[62]
* pin text_out[20]
* pin text_out[45]
* pin text_out[61]
* pin text_out[21]
* pin text_out[23]
* pin text_out[17]
* pin text_out[63]
* pin text_in[60]
* pin text_out[60]
* pin text_in[18]
* pin text_in[17]
* pin text_out[59]
* pin text_out[19]
* pin text_out[16]
* pin text_in[21]
* pin text_out[44]
* pin text_in[59]
* pin text_in[51]
* pin text_in[52]
* pin text_in[53]
* pin text_in[43]
* pin text_in[44]
* pin text_in[40]
* pin text_out[56]
* pin text_out[43]
* pin text_out[22]
* pin text_out[18]
* pin text_in[56]
* pin text_in[58]
* pin text_in[16]
* pin text_out[51]
* pin text_out[42]
* pin text_in[55]
* pin text_out[58]
* pin key[55]
* pin text_in[42]
* pin text_in[57]
* pin text_out[55]
* pin text_in[19]
* pin key[87]
* pin text_out[57]
* pin key[83]
* pin text_in[41]
* pin key[51]
* pin text_in[20]
* pin text_in[49]
* pin text_in[50]
* pin key[50]
* pin key[118]
* pin text_in[48]
* pin key[82]
* pin key[86]
* pin text_out[11]
* pin key[91]
* pin key[59]
* pin text_out[50]
* pin text_out[33]
* pin text_in[23]
* pin key[58]
* pin key[90]
* pin text_out[35]
* pin key[80]
* pin key[112]
* pin key[62]
* pin text_out[39]
* pin text_out[9]
* pin text_in[33]
* pin text_in[83]
* pin text_out[37]
* pin key[11]
* pin text_in[22]
* pin key[13]
* pin text_out[106]
* pin text_out[83]
* pin text_in[103]
* pin key[94]
* pin text_in[37]
* pin key[77]
* pin key[12]
* pin text_out[14]
* pin text_out[13]
* pin text_out[38]
* pin key[61]
* pin text_out[94]
* pin text_out[15]
* pin key[9]
* pin text_out[12]
* pin key[15]
* pin key[93]
* pin text_in[32]
* pin text_out[93]
* pin text_in[9]
* pin key[63]
* pin text_in[93]
* pin key[95]
* pin key[10]
* pin key[30]
* pin text_out[8]
* pin text_out[10]
* pin key[60]
* pin text_in[39]
* pin text_in[94]
* pin key[92]
* pin key[26]
* pin text_in[10]
* pin text_in[102]
* pin text_out[85]
* pin key[78]
* pin key[37]
* pin text_in[85]
* pin text_in[12]
* pin key[27]
* pin text_in[2]
* pin text_in[70]
* pin text_in[69]
* pin text_in[8]
* pin text_in[79]
* pin text_out[69]
* pin key[69]
* pin text_in[0]
* pin text_in[3]
* pin text_in[1]
* pin text_in[11]
* pin text_in[78]
* pin text_out[86]
* pin text_in[86]
* pin text_in[4]
* pin text_out[0]
* pin text_out[70]
* pin text_out[32]
* pin text_in[75]
* pin text_in[7]
* pin text_in[15]
* pin text_out[3]
* pin text_in[95]
* pin text_out[102]
* pin text_in[71]
* pin text_out[1]
* pin key[31]
* pin key[57]
* pin text_out[95]
* pin text_out[71]
* pin text_in[13]
* pin text_in[6]
* pin text_out[29]
* pin key[29]
* pin text_in[5]
* pin key[7]
* pin key[71]
* pin text_in[14]
* pin key[89]
* pin key[39]
* pin text_out[92]
* pin text_out[7]
* pin key[25]
* pin text_out[25]
* pin text_out[2]
* pin key[56]
* pin text_in[92]
* pin text_out[30]
* pin text_out[27]
* pin text_out[31]
* pin text_in[26]
* pin text_out[91]
* pin text_out[101]
* pin text_in[36]
* pin text_out[89]
* pin key[24]
* pin key[28]
* pin key[88]
* pin text_out[24]
* pin text_in[91]
* pin text_out[88]
* pin key[32]
* pin text_in[27]
* pin text_in[28]
* pin text_out[36]
* pin text_out[84]
* pin text_in[84]
* pin text_in[88]
* pin text_in[29]
* pin text_in[100]
* pin text_in[89]
* pin text_in[35]
* pin text_out[90]
* pin text_in[30]
* pin text_in[81]
* pin text_in[64]
* pin text_out[81]
* pin text_out[26]
* pin text_in[87]
* pin text_out[64]
* pin text_in[31]
* pin text_in[80]
* pin text_out[80]
* pin text_out[87]
* pin text_out[28]
* pin text_in[67]
* pin text_out[82]
* pin text_in[25]
* pin text_in[68]
* pin text_out[68]
* pin text_in[82]
* pin text_in[24]
* pin text_out[67]
* pin text_in[66]
* pin text_out[5]
* pin key[96]
* pin text_in[99]
* pin key[36]
* pin key[2]
* pin key[38]
* pin text_out[98]
* pin text_in[38]
* pin key[67]
* pin text_out[4]
* pin text_out[73]
* pin text_out[75]
* pin key[72]
* pin key[108]
* pin key[42]
* pin text_out[76]
* pin key[34]
* pin key[98]
* pin text_in[106]
* pin key[99]
* pin key[4]
* pin text_out[100]
* pin text_out[99]
* pin key[103]
* pin text_in[65]
* pin key[68]
* pin text_in[73]
* pin text_out[79]
* pin key[110]
* pin key[76]
* pin key[74]
* pin key[5]
* pin text_out[74]
* pin key[106]
* pin text_in[101]
* pin key[70]
* pin key[101]
* pin key[0]
* pin key[3]
* pin key[100]
* pin text_in[72]
* pin key[97]
* pin text_in[74]
* pin text_in[90]
* pin text_out[66]
* pin text_out[6]
* pin text_out[65]
* pin rst
* pin text_out[97]
* pin done
* pin key[65]
* pin text_out[34]
* pin key[104]
* pin key[105]
* pin key[33]
* pin text_in[97]
* pin text_out[96]
* pin key[35]
* pin text_in[76]
* pin key[1]
* pin key[66]
* pin text_out[77]
* pin text_out[72]
* pin key[6]
* pin text_out[105]
* pin key[102]
* pin text_in[34]
* pin text_in[98]
* pin text_in[96]
* pin key[64]
* pin text_out[103]
.SUBCKT aes_cipher_top 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48
+ 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74
+ 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 99 102 103 107
+ 112 113 2816 4230 4453 4567 4689 4837 4838 4940 4941 5050 5051 5052 5132 5203
+ 5310 5361 5362 5363 5430 5431 5432 5511 5512 5566 5602 5603 5604 5663 5664
+ 5665 5666 5667 5773 5774 5879 5880 5881 5941 5942 6012 6013 6221 6295 6296
+ 6438 6439 6726 6727 6728 6844 6898 6957 6958 6959 7057 7058 7214 7287 7288
+ 7289 7387 7564 7565 7617 7618 7692 7693 7694 7841 7876 7947 7948 7949 8010
+ 8011 8073 8074 8174 8229 8230 8231 8302 8303 8304 8360 8361 8467 8468 8469
+ 8546 8547 8548 8549 8597 8598 8599 8631 8632 8633 8634 8680 8681 8682 8745
+ 8795 8796 8797 8838 8839 8840 8841 8897 8898 8899 8900 8969 8970 9013 9014
+ 9063 9111 9112 9180 9181 9182 9230 9231 9287 9332 9333 9334 9394 9395 9396
+ 9397 9398 9436 9437 9484 9485 9532 9533 9537 9610 9611 9612 9657 9658 9659
+ 9709 9710 9771 9772 9773 9858 9859 9860 9861 9862 9900 9901 9945 10013 10014
+ 10015 10099 10100 10101 10102 10160 10161 10217 10218 10219 10220 10271 10272
+ 10273 10274 10311 10312 10379 10448 10496 10497 10498 10543 10544 10612 10613
+ 10733 10734 10791 10867 10868 10869 11034 11088 11166 11321 11322 11556 11632
+ 11805 11867 11940 11941 11942 12175 12362 12363 12455 12513 12639 12640 12730
+ 12890 12891 13060 16362 16364 16365 16379 16380 16382 16384 16387 16390 16392
+ 16394 16395 16396 16397 16398 16399 16400 16401 16402 16403 16404 16405 16406
+ 16410 16412 16414 16415 16416 16417 16418 16419 16420 16421 16422 16423 16424
+ 16425 16426 16427 16428 16429 16430 16431 16432 16433 16434 16435 16436 16437
+ 16438 16439 16440 16441 16442 16443 16444 16445 16446 16447 16448 16449 16450
+ 16451 16452 16453 16454 16455 16456 16457 16458
* net 1 key[20]
* net 2 key[53]
* net 3 text_in[111]
* net 4 key[120]
* net 5 text_out[120]
* net 6 ld
* net 7 key[21]
* net 8 key[23]
* net 9 key[19]
* net 10 key[22]
* net 11 key[17]
* net 12 key[54]
* net 13 key[16]
* net 14 key[18]
* net 15 key[8]
* net 16 text_in[117]
* net 17 text_out[54]
* net 18 key[48]
* net 19 key[117]
* net 20 key[14]
* net 21 key[46]
* net 22 key[109]
* net 23 key[113]
* net 24 key[85]
* net 25 text_in[112]
* net 26 key[45]
* net 27 key[49]
* net 28 key[116]
* net 29 key[47]
* net 30 text_out[78]
* net 31 key[84]
* net 32 key[79]
* net 33 key[81]
* net 34 text_out[53]
* net 35 key[52]
* net 36 text_out[117]
* net 37 text_in[77]
* net 38 text_in[115]
* net 39 text_out[112]
* net 40 key[41]
* net 41 text_in[116]
* net 42 key[43]
* net 43 text_out[118]
* net 44 text_in[109]
* net 45 key[75]
* net 46 key[73]
* net 47 text_out[116]
* net 48 key[119]
* net 49 text_in[110]
* net 50 key[111]
* net 51 text_out[49]
* net 52 text_in[113]
* net 53 text_out[113]
* net 54 text_in[107]
* net 55 key[44]
* net 56 key[107]
* net 57 text_out[109]
* net 58 text_in[104]
* net 59 text_out[48]
* net 60 key[40]
* net 61 text_in[119]
* net 62 text_out[119]
* net 63 text_in[114]
* net 64 text_out[115]
* net 65 text_in[105]
* net 66 key[114]
* net 67 text_out[111]
* net 68 text_in[108]
* net 69 text_out[110]
* net 70 text_out[107]
* net 71 text_out[104]
* net 72 text_out[40]
* net 73 text_out[52]
* net 74 text_in[126]
* net 75 key[122]
* net 76 text_out[114]
* net 77 text_out[46]
* net 78 text_out[108]
* net 79 text_in[122]
* net 80 text_out[41]
* net 81 key[126]
* net 82 key[125]
* net 83 text_in[45]
* net 84 text_out[122]
* net 85 text_in[120]
* net 86 text_in[127]
* net 87 key[124]
* net 88 key[127]
* net 89 text_out[125]
* net 90 text_in[124]
* net 91 text_in[123]
* net 92 text_out[124]
* net 93 key[123]
* net 94 text_out[123]
* net 95 text_out[121]
* net 99 text_in[118]
* net 102 key[115]
* net 103 text_out[47]
* net 107 text_in[125]
* net 112 PWELL
* net 113 NWELL
* net 2816 clk
* net 4230 text_in[121]
* net 4453 key[121]
* net 4567 text_out[127]
* net 4689 text_out[126]
* net 4837 text_in[47]
* net 4838 text_in[46]
* net 4940 text_in[54]
* net 4941 text_in[62]
* net 5050 text_in[61]
* net 5051 text_in[63]
* net 5052 text_out[62]
* net 5132 text_out[20]
* net 5203 text_out[45]
* net 5310 text_out[61]
* net 5361 text_out[21]
* net 5362 text_out[23]
* net 5363 text_out[17]
* net 5430 text_out[63]
* net 5431 text_in[60]
* net 5432 text_out[60]
* net 5511 text_in[18]
* net 5512 text_in[17]
* net 5566 text_out[59]
* net 5602 text_out[19]
* net 5603 text_out[16]
* net 5604 text_in[21]
* net 5663 text_out[44]
* net 5664 text_in[59]
* net 5665 text_in[51]
* net 5666 text_in[52]
* net 5667 text_in[53]
* net 5773 text_in[43]
* net 5774 text_in[44]
* net 5879 text_in[40]
* net 5880 text_out[56]
* net 5881 text_out[43]
* net 5941 text_out[22]
* net 5942 text_out[18]
* net 6012 text_in[56]
* net 6013 text_in[58]
* net 6221 text_in[16]
* net 6295 text_out[51]
* net 6296 text_out[42]
* net 6438 text_in[55]
* net 6439 text_out[58]
* net 6726 key[55]
* net 6727 text_in[42]
* net 6728 text_in[57]
* net 6844 text_out[55]
* net 6898 text_in[19]
* net 6957 key[87]
* net 6958 text_out[57]
* net 6959 key[83]
* net 7057 text_in[41]
* net 7058 key[51]
* net 7214 text_in[20]
* net 7287 text_in[49]
* net 7288 text_in[50]
* net 7289 key[50]
* net 7387 key[118]
* net 7564 text_in[48]
* net 7565 key[82]
* net 7617 key[86]
* net 7618 text_out[11]
* net 7692 key[91]
* net 7693 key[59]
* net 7694 text_out[50]
* net 7841 text_out[33]
* net 7876 text_in[23]
* net 7947 key[58]
* net 7948 key[90]
* net 7949 text_out[35]
* net 8010 key[80]
* net 8011 key[112]
* net 8073 key[62]
* net 8074 text_out[39]
* net 8174 text_out[9]
* net 8229 text_in[33]
* net 8230 text_in[83]
* net 8231 text_out[37]
* net 8302 key[11]
* net 8303 text_in[22]
* net 8304 key[13]
* net 8360 text_out[106]
* net 8361 text_out[83]
* net 8467 text_in[103]
* net 8468 key[94]
* net 8469 text_in[37]
* net 8546 key[77]
* net 8547 key[12]
* net 8548 text_out[14]
* net 8549 text_out[13]
* net 8597 text_out[38]
* net 8598 key[61]
* net 8599 text_out[94]
* net 8631 text_out[15]
* net 8632 key[9]
* net 8633 text_out[12]
* net 8634 key[15]
* net 8680 key[93]
* net 8681 text_in[32]
* net 8682 text_out[93]
* net 8745 text_in[9]
* net 8795 key[63]
* net 8796 text_in[93]
* net 8797 key[95]
* net 8838 key[10]
* net 8839 key[30]
* net 8840 text_out[8]
* net 8841 text_out[10]
* net 8897 key[60]
* net 8898 text_in[39]
* net 8899 text_in[94]
* net 8900 key[92]
* net 8969 key[26]
* net 8970 text_in[10]
* net 9013 text_in[102]
* net 9014 text_out[85]
* net 9063 key[78]
* net 9111 key[37]
* net 9112 text_in[85]
* net 9180 text_in[12]
* net 9181 key[27]
* net 9182 text_in[2]
* net 9230 text_in[70]
* net 9231 text_in[69]
* net 9287 text_in[8]
* net 9332 text_in[79]
* net 9333 text_out[69]
* net 9334 key[69]
* net 9394 text_in[0]
* net 9395 text_in[3]
* net 9396 text_in[1]
* net 9397 text_in[11]
* net 9398 text_in[78]
* net 9436 text_out[86]
* net 9437 text_in[86]
* net 9484 text_in[4]
* net 9485 text_out[0]
* net 9532 text_out[70]
* net 9533 text_out[32]
* net 9537 text_in[75]
* net 9610 text_in[7]
* net 9611 text_in[15]
* net 9612 text_out[3]
* net 9657 text_in[95]
* net 9658 text_out[102]
* net 9659 text_in[71]
* net 9709 text_out[1]
* net 9710 key[31]
* net 9771 key[57]
* net 9772 text_out[95]
* net 9773 text_out[71]
* net 9858 text_in[13]
* net 9859 text_in[6]
* net 9860 text_out[29]
* net 9861 key[29]
* net 9862 text_in[5]
* net 9900 key[7]
* net 9901 key[71]
* net 9945 text_in[14]
* net 10013 key[89]
* net 10014 key[39]
* net 10015 text_out[92]
* net 10099 text_out[7]
* net 10100 key[25]
* net 10101 text_out[25]
* net 10102 text_out[2]
* net 10160 key[56]
* net 10161 text_in[92]
* net 10217 text_out[30]
* net 10218 text_out[27]
* net 10219 text_out[31]
* net 10220 text_in[26]
* net 10271 text_out[91]
* net 10272 text_out[101]
* net 10273 text_in[36]
* net 10274 text_out[89]
* net 10311 key[24]
* net 10312 key[28]
* net 10379 key[88]
* net 10448 text_out[24]
* net 10496 text_in[91]
* net 10497 text_out[88]
* net 10498 key[32]
* net 10543 text_in[27]
* net 10544 text_in[28]
* net 10612 text_out[36]
* net 10613 text_out[84]
* net 10733 text_in[84]
* net 10734 text_in[88]
* net 10791 text_in[29]
* net 10867 text_in[100]
* net 10868 text_in[89]
* net 10869 text_in[35]
* net 11034 text_out[90]
* net 11088 text_in[30]
* net 11166 text_in[81]
* net 11321 text_in[64]
* net 11322 text_out[81]
* net 11556 text_out[26]
* net 11632 text_in[87]
* net 11805 text_out[64]
* net 11867 text_in[31]
* net 11940 text_in[80]
* net 11941 text_out[80]
* net 11942 text_out[87]
* net 12175 text_out[28]
* net 12362 text_in[67]
* net 12363 text_out[82]
* net 12455 text_in[25]
* net 12513 text_in[68]
* net 12639 text_out[68]
* net 12640 text_in[82]
* net 12730 text_in[24]
* net 12890 text_out[67]
* net 12891 text_in[66]
* net 13060 text_out[5]
* net 16362 key[96]
* net 16364 text_in[99]
* net 16365 key[36]
* net 16379 key[2]
* net 16380 key[38]
* net 16382 text_out[98]
* net 16384 text_in[38]
* net 16387 key[67]
* net 16390 text_out[4]
* net 16392 text_out[73]
* net 16394 text_out[75]
* net 16395 key[72]
* net 16396 key[108]
* net 16397 key[42]
* net 16398 text_out[76]
* net 16399 key[34]
* net 16400 key[98]
* net 16401 text_in[106]
* net 16402 key[99]
* net 16403 key[4]
* net 16404 text_out[100]
* net 16405 text_out[99]
* net 16406 key[103]
* net 16410 text_in[65]
* net 16412 key[68]
* net 16414 text_in[73]
* net 16415 text_out[79]
* net 16416 key[110]
* net 16417 key[76]
* net 16418 key[74]
* net 16419 key[5]
* net 16420 text_out[74]
* net 16421 key[106]
* net 16422 text_in[101]
* net 16423 key[70]
* net 16424 key[101]
* net 16425 key[0]
* net 16426 key[3]
* net 16427 key[100]
* net 16428 text_in[72]
* net 16429 key[97]
* net 16430 text_in[74]
* net 16431 text_in[90]
* net 16432 text_out[66]
* net 16433 text_out[6]
* net 16434 text_out[65]
* net 16435 rst
* net 16436 text_out[97]
* net 16437 done
* net 16438 key[65]
* net 16439 text_out[34]
* net 16440 key[104]
* net 16441 key[105]
* net 16442 key[33]
* net 16443 text_in[97]
* net 16444 text_out[96]
* net 16445 key[35]
* net 16446 text_in[76]
* net 16447 key[1]
* net 16448 key[66]
* net 16449 text_out[77]
* net 16450 text_out[72]
* net 16451 key[6]
* net 16452 text_out[105]
* net 16453 key[102]
* net 16454 text_in[34]
* net 16455 text_in[98]
* net 16456 text_in[96]
* net 16457 key[64]
* net 16458 text_out[103]
* cell instance $2 r0 *1 95.95,11.2
X$2 1 112 113 115 BUF_X1
* cell instance $4 m0 *1 109.06,14
X$4 2 112 113 168 BUF_X1
* cell instance $6 r0 *1 129.39,11.2
X$6 3 112 113 252 BUF_X1
* cell instance $8 r0 *1 142.88,11.2
X$8 4 112 113 133 BUF_X1
* cell instance $10 r0 *1 149.34,11.2
X$10 158 112 113 5 BUF_X1
* cell instance $12 m0 *1 79.23,14
X$12 6 113 161 112 BUF_X4
* cell instance $16 r0 *1 92.91,11.2
X$16 7 112 113 114 CLKBUF_X2
* cell instance $18 r0 *1 95.38,11.2
X$18 8 112 113 117 BUF_X1
* cell instance $20 r0 *1 99.18,11.2
X$20 9 112 113 118 BUF_X1
* cell instance $22 r0 *1 100.89,11.2
X$22 10 112 113 120 BUF_X1
* cell instance $24 r0 *1 101.65,11.2
X$24 11 112 113 96 BUF_X1
* cell instance $26 r0 *1 102.6,11.2
X$26 12 112 113 121 BUF_X1
* cell instance $28 r0 *1 105.26,11.2
X$28 13 112 113 248 BUF_X1
* cell instance $30 r0 *1 107.16,11.2
X$30 14 112 113 127 BUF_X1
* cell instance $32 r0 *1 103.17,11.2
X$32 15 112 113 122 CLKBUF_X3
* cell instance $36 r0 *1 107.73,14
X$36 16 112 113 226 BUF_X1
* cell instance $38 r0 *1 107.73,11.2
X$38 97 112 113 17 BUF_X1
* cell instance $40 r0 *1 108.3,11.2
X$40 18 112 113 129 BUF_X1
* cell instance $42 r0 *1 108.87,11.2
X$42 19 112 113 131 BUF_X1
* cell instance $44 r0 *1 106.02,11.2
X$44 20 112 113 2431 BUF_X1
* cell instance $48 m0 *1 110.77,14
X$48 21 112 113 170 BUF_X1
* cell instance $50 m0 *1 109.63,14
X$50 22 112 113 169 BUF_X1
* cell instance $54 r0 *1 108.3,14
X$54 23 112 113 207 BUF_X1
* cell instance $58 r0 *1 110.77,14
X$58 24 112 113 209 BUF_X1
* cell instance $64 m0 *1 111.34,14
X$64 25 112 113 148 BUF_X1
* cell instance $66 r0 *1 112.1,14
X$66 26 112 113 185 BUF_X1
* cell instance $68 m0 *1 112.1,14
X$68 27 112 113 173 BUF_X1
* cell instance $72 r0 *1 104.31,11.2
X$72 28 112 113 123 BUF_X1
* cell instance $76 r0 *1 112.86,11.2
X$76 29 112 113 134 BUF_X1
* cell instance $80 r0 *1 112.67,14
X$80 98 112 113 30 BUF_X1
* cell instance $86 m0 *1 112.86,14
X$86 31 112 113 149 BUF_X1
* cell instance $90 r0 *1 114.76,16.8
X$90 32 112 113 303 BUF_X1
* cell instance $92 r0 *1 113.43,14
X$92 33 112 113 214 BUF_X1
* cell instance $96 m0 *1 116.47,16.8
X$96 217 112 113 34 BUF_X1
* cell instance $100 m0 *1 115.9,16.8
X$100 35 112 113 258 BUF_X1
* cell instance $102 m0 *1 117.23,16.8
X$102 260 112 113 36 BUF_X1
* cell instance $108 m0 *1 116.66,14
X$108 37 112 113 180 CLKBUF_X2
* cell instance $110 r0 *1 106.59,11.2
X$110 38 112 113 125 BUF_X1
* cell instance $114 r0 *1 114.57,14
X$114 183 112 113 39 BUF_X1
* cell instance $120 r0 *1 118.56,16.8
X$120 40 112 113 302 BUF_X1
* cell instance $126 r0 *1 114,11.2
X$126 41 112 113 136 BUF_X1
* cell instance $130 m0 *1 118.18,16.8
X$130 42 112 113 257 BUF_X1
* cell instance $132 m0 *1 118.75,16.8
X$132 181 112 113 43 BUF_X1
* cell instance $134 r0 *1 117.8,11.2
X$134 44 112 113 100 BUF_X1
* cell instance $138 m0 *1 119.7,16.8
X$138 45 112 113 221 BUF_X1
* cell instance $140 m0 *1 120.08,14
X$140 46 112 113 179 BUF_X1
* cell instance $144 m0 *1 120.27,16.8
X$144 190 112 113 47 BUF_X1
* cell instance $150 m0 *1 117.8,14
X$150 48 112 113 182 BUF_X1
* cell instance $154 m0 *1 120.65,14
X$154 49 112 113 101 BUF_X1
* cell instance $158 r0 *1 119.13,16.8
X$158 50 112 113 301 BUF_X1
* cell instance $164 m0 *1 121.22,14
X$164 151 112 113 51 BUF_X1
* cell instance $168 r0 *1 113.43,11.2
X$168 52 112 113 175 BUF_X1
* cell instance $172 r0 *1 121.6,11.2
X$172 140 112 113 53 BUF_X1
* cell instance $176 m0 *1 127.3,14
X$176 54 112 113 104 BUF_X1
* cell instance $180 r0 *1 122.55,11.2
X$180 55 112 113 141 BUF_X1
* cell instance $184 m0 *1 121.98,16.8
X$184 56 112 113 256 BUF_X1
* cell instance $188 m0 *1 123.5,14
X$188 174 112 113 57 BUF_X1
* cell instance $192 m0 *1 122.93,14
X$192 58 112 113 176 BUF_X1
* cell instance $196 m0 *1 125.59,16.8
X$196 171 112 113 59 BUF_X1
* cell instance $198 r0 *1 123.12,11.2
X$198 60 112 113 142 BUF_X1
* cell instance $202 m0 *1 126.16,16.8
X$202 61 112 113 476 BUF_X1
* cell instance $206 r0 *1 128.06,14
X$206 154 112 113 62 BUF_X1
* cell instance $210 r0 *1 127.49,11.2
X$210 63 112 113 153 BUF_X1
* cell instance $212 r0 *1 126.92,11.2
X$212 143 112 113 64 BUF_X1
* cell instance $216 r0 *1 128.82,11.2
X$216 65 112 113 216 BUF_X1
* cell instance $218 m0 *1 122.36,14
X$218 66 112 113 178 BUF_X1
* cell instance $222 r0 *1 130.34,11.2
X$222 193 112 113 67 BUF_X1
* cell instance $224 m0 *1 133,14
X$224 68 112 113 164 BUF_X1
* cell instance $228 r0 *1 131.67,11.2
X$228 275 112 113 69 BUF_X1
* cell instance $230 r0 *1 132.81,11.2
X$230 213 112 113 70 BUF_X1
* cell instance $234 r0 *1 131.1,11.2
X$234 105 112 113 71 BUF_X1
* cell instance $238 m0 *1 136.61,14
X$238 162 112 113 72 BUF_X1
* cell instance $242 m0 *1 133.76,16.8
X$242 354 112 113 73 BUF_X1
* cell instance $246 m0 *1 134.9,14
X$246 74 112 113 276 BUF_X1
* cell instance $248 m0 *1 134.33,14
X$248 75 112 113 165 BUF_X1
* cell instance $252 r0 *1 136.8,11.2
X$252 145 112 113 76 BUF_X1
* cell instance $254 r0 *1 141.17,11.2
X$254 111 112 113 77 BUF_X1
* cell instance $258 m0 *1 137.37,14
X$258 155 112 113 78 BUF_X1
* cell instance $260 r0 *1 138.13,14
X$260 79 112 113 195 BUF_X1
* cell instance $262 r0 *1 144.59,11.2
X$262 119 112 113 80 BUF_X1
* cell instance $266 m0 *1 139.08,14
X$266 81 112 113 163 BUF_X1
* cell instance $268 m0 *1 139.65,14
X$268 82 112 113 128 BUF_X1
* cell instance $270 r0 *1 147.25,11.2
X$270 83 112 113 116 CLKBUF_X2
* cell instance $274 r0 *1 140.6,11.2
X$274 147 112 113 84 BUF_X1
* cell instance $276 m0 *1 140.22,14
X$276 85 112 113 210 BUF_X1
* cell instance $280 r0 *1 141.74,11.2
X$280 86 112 113 108 BUF_X1
* cell instance $282 r0 *1 142.31,11.2
X$282 87 112 113 126 BUF_X1
* cell instance $284 r0 *1 143.45,11.2
X$284 88 112 113 132 BUF_X1
* cell instance $286 r0 *1 144.02,11.2
X$286 109 112 113 89 BUF_X1
* cell instance $288 r0 *1 145.73,11.2
X$288 90 112 113 135 BUF_X1
* cell instance $290 r0 *1 146.49,11.2
X$290 91 112 113 138 BUF_X1
* cell instance $292 m0 *1 146.87,14
X$292 157 112 113 92 BUF_X1
* cell instance $294 r0 *1 149.91,11.2
X$294 93 112 113 124 BUF_X1
* cell instance $298 m0 *1 152,14
X$298 159 112 113 94 BUF_X1
* cell instance $302 r0 *1 155.42,11.2
X$302 110 112 113 95 BUF_X1
* cell instance $305 r0 *1 101.65,16.8
X$305 96 224 270 112 113 NOR2_X4
* cell instance $308 m0 *1 105.07,14
X$308 112 16775 97 166 184 113 DFF_X1
* cell instance $311 r0 *1 109.44,11.2
X$311 112 17025 98 130 184 113 DFF_X1
* cell instance $313 r0 *1 114,14
X$313 99 112 113 188 BUF_X1
* cell instance $316 r0 *1 118.56,19.6
X$316 347 194 100 112 113 408 MUX2_X1
* cell instance $319 m0 *1 120.84,19.6
X$319 348 194 101 112 113 315 MUX2_X1
* cell instance $321 m0 *1 121.22,16.8
X$321 102 112 113 222 BUF_X1
* cell instance $323 m0 *1 121.79,14
X$323 200 112 113 103 BUF_X1
* cell instance $327 m0 *1 134.71,16.8
X$327 196 194 104 112 113 212 MUX2_X1
* cell instance $331 m0 *1 127.87,14
X$331 112 16857 105 167 106 113 DFF_X1
* cell instance $333 r0 *1 133.76,14
X$333 189 112 113 106 CLKBUF_X3
* cell instance $335 m0 *1 128.06,16.8
X$335 112 16839 193 218 106 113 DFF_X1
* cell instance $337 r0 *1 134.9,14
X$337 112 17011 155 204 106 113 DFF_X1
* cell instance $339 r0 *1 137.37,11.2
X$339 112 17132 147 146 106 113 DFF_X1
* cell instance $343 m0 *1 133.57,14
X$343 106 112 113 16463 CLKBUF_X1
* cell instance $346 r0 *1 131.86,16.8
X$346 112 250 249 230 106 113 DFF_X1
* cell instance $348 r0 *1 133.57,11.2
X$348 112 17015 145 144 106 113 DFF_X1
* cell instance $350 r0 *1 130.53,14
X$350 112 17010 213 219 106 113 DFF_X1
* cell instance $360 m0 *1 140.98,14
X$360 107 112 113 156 BUF_X1
* cell instance $363 m0 *1 140.6,19.6
X$363 355 316 108 112 113 356 MUX2_X1
* cell instance $365 r0 *1 140.79,14
X$365 112 16949 109 203 231 113 DFF_X1
* cell instance $369 r0 *1 152.19,19.6
X$369 112 17096 110 405 360 113 DFF_X1
* cell instance $371 r0 *1 182.97,16.8
X$371 112 17081 111 242 199 113 DFF_X1
* cell instance $375 m0 *1 147.44,81.2
X$375 4546 3945 113 4924 112 XOR2_X2
* cell instance $376 m0 *1 145.73,81.2
X$376 4923 4922 113 4323 112 XOR2_X2
* cell instance $377 m0 *1 149.15,81.2
X$377 4879 4214 112 113 4823 XNOR2_X2
* cell instance $378 m0 *1 151.05,81.2
X$378 4323 112 113 4879 BUF_X1
* cell instance $379 m0 *1 151.62,81.2
X$379 4925 2981 4816 112 4106 113 NAND3_X4
* cell instance $380 m0 *1 154.09,81.2
X$380 4660 113 3270 112 BUF_X4
* cell instance $381 m0 *1 155.42,81.2
X$381 4103 3585 112 113 4819 NOR2_X2
* cell instance $382 m0 *1 156.37,81.2
X$382 4547 112 113 4759 BUF_X1
* cell instance $386 r0 *1 145.92,81.2
X$386 5111 4922 113 3585 112 XOR2_X2
* cell instance $387 r0 *1 147.63,81.2
X$387 4923 112 113 5111 BUF_X1
* cell instance $388 r0 *1 148.2,81.2
X$388 4324 4660 4214 112 113 NOR2_X4
* cell instance $389 r0 *1 149.91,81.2
X$389 5178 5108 113 112 5298 AND2_X1
* cell instance $391 r0 *1 150.86,81.2
X$391 112 4325 2908 4816 4925 113 AOI21_X4
* cell instance $392 r0 *1 153.33,81.2
X$392 3889 113 2566 112 BUF_X4
* cell instance $393 r0 *1 154.66,81.2
X$393 2566 3585 4737 112 4964 113 AOI21_X2
* cell instance $394 r0 *1 155.99,81.2
X$394 112 2746 2909 4816 4925 113 AOI21_X4
* cell instance $395 m0 *1 158.65,81.2
X$395 2803 4876 4217 4042 2746 112 113 4926 AOI221_X1
* cell instance $396 m0 *1 158.08,81.2
X$396 4214 2981 112 113 4927 NOR2_X1
* cell instance $398 r0 *1 158.46,81.2
X$398 4925 3591 4816 112 3170 113 NAND3_X4
* cell instance $400 m0 *1 160.17,81.2
X$400 4818 4927 2354 112 113 2978 NOR3_X1
* cell instance $401 m0 *1 161.12,81.2
X$401 112 2878 4436 4438 4664 113 NOR3_X4
* cell instance $402 m0 *1 163.78,81.2
X$402 4438 4436 2981 113 4872 112 NOR3_X2
* cell instance $403 m0 *1 165.11,81.2
X$403 4872 4169 3267 112 113 4767 NOR3_X1
* cell instance $405 r0 *1 160.93,81.2
X$405 2404 2466 4924 3561 2642 5098 113 112 AOI221_X2
* cell instance $406 r0 *1 163.02,81.2
X$406 2976 4662 3689 112 113 5097 NOR3_X1
* cell instance $409 r0 *1 164.73,81.2
X$409 2410 3201 3113 112 4662 113 AOI21_X2
* cell instance $410 r0 *1 166.06,81.2
X$410 4819 4927 2803 113 5037 112 OAI21_X1
* cell instance $411 m0 *1 166.44,81.2
X$411 4822 4001 4328 113 112 4928 OAI21_X2
* cell instance $413 m0 *1 167.77,81.2
X$413 112 4663 4169 2639 5221 113 NOR3_X4
* cell instance $414 m0 *1 170.43,81.2
X$414 112 4042 4436 4438 4667 113 NOR3_X4
* cell instance $415 m0 *1 173.09,81.2
X$415 4217 4048 112 113 3893 NOR2_X2
* cell instance $417 m0 *1 174.23,81.2
X$417 4863 2918 4283 112 113 4866 MUX2_X1
* cell instance $418 m0 *1 175.56,81.2
X$418 4824 4825 3893 3479 112 113 4959 NAND4_X1
* cell instance $419 m0 *1 176.51,81.2
X$419 3893 4866 2916 112 113 4930 NAND3_X1
* cell instance $421 m0 *1 178.03,81.2
X$421 4668 3012 4823 112 4860 113 AOI21_X1
* cell instance $423 m0 *1 178.98,81.2
X$423 3210 2511 4826 113 112 4933 AND3_X1
* cell instance $425 m0 *1 180.12,81.2
X$425 4058 3895 3689 112 113 4954 NAND3_X1
* cell instance $427 m0 *1 181.07,81.2
X$427 4860 3341 112 113 4934 NAND2_X1
* cell instance $429 r0 *1 166.82,81.2
X$429 2746 2472 112 113 5182 NAND2_X1
* cell instance $431 r0 *1 167.77,81.2
X$431 4169 4821 112 113 5092 NOR2_X1
* cell instance $432 r0 *1 168.34,81.2
X$432 4217 4383 112 113 3755 NAND2_X2
* cell instance $434 r0 *1 169.67,81.2
X$434 4929 4821 112 113 5036 NOR2_X1
* cell instance $436 r0 *1 171,81.2
X$436 4819 3697 112 113 5085 NOR2_X1
* cell instance $438 r0 *1 173.09,81.2
X$438 4929 3180 2642 112 5189 113 AOI21_X1
* cell instance $439 r0 *1 173.85,81.2
X$439 3200 2577 4583 112 5087 113 AOI21_X1
* cell instance $440 r0 *1 174.61,81.2
X$440 5083 3450 5085 113 112 5038 OAI21_X2
* cell instance $441 r0 *1 175.94,81.2
X$441 4219 2577 112 113 5083 NOR2_X1
* cell instance $443 r0 *1 176.7,81.2
X$443 4930 4931 4959 4551 112 113 5040 NAND4_X1
* cell instance $445 r0 *1 177.84,81.2
X$445 4964 5037 4278 5192 2512 4932 113 112 AOI221_X2
* cell instance $446 r0 *1 179.93,81.2
X$446 4580 5041 4932 4934 4933 4931 113 112 AOI221_X2
* cell instance $450 m0 *1 182.21,81.2
X$450 3689 112 113 3012 CLKBUF_X3
* cell instance $455 r0 *1 182.21,81.2
X$455 4929 4737 3012 113 4272 112 OAI21_X1
* cell instance $458 r0 *1 185.25,81.2
X$458 401 112 113 4554 CLKBUF_X3
* cell instance $459 r0 *1 186.2,81.2
X$459 4554 112 113 17168 INV_X2
* cell instance $460 m0 *1 186.77,81.2
X$460 112 16820 4858 4828 4554 113 DFF_X1
* cell instance $462 m0 *1 190,81.2
X$462 4935 4857 113 112 4855 XNOR2_X1
* cell instance $464 m0 *1 191.33,81.2
X$464 4672 3118 113 4946 112 XOR2_X2
* cell instance $466 m0 *1 193.23,81.2
X$466 3436 4855 113 112 4854 XNOR2_X1
* cell instance $468 m0 *1 194.56,81.2
X$468 4947 4854 4950 113 112 3896 MUX2_X2
* cell instance $474 r0 *1 189.62,81.2
X$474 4858 5042 5043 113 112 3163 MUX2_X2
* cell instance $476 m0 *1 197.22,81.2
X$476 4829 4853 4677 113 112 4558 MUX2_X2
* cell instance $477 m0 *1 196.65,81.2
X$477 4676 4650 112 113 4853 NOR2_X1
* cell instance $480 r0 *1 198.93,81.2
X$480 112 4831 5070 5071 5068 113 DFF_X1
* cell instance $481 m0 *1 199.5,81.2
X$481 4831 4678 4650 112 113 4830 NAND3_X2
* cell instance $483 m0 *1 200.83,81.2
X$483 4830 4949 4831 113 112 4559 OAI21_X4
* cell instance $484 m0 *1 203.3,81.2
X$484 112 16739 4947 4832 5068 113 DFF_X1
* cell instance $488 m0 *1 211.85,81.2
X$488 4852 2381 4833 112 113 4849 MUX2_X1
* cell instance $491 m0 *1 214.13,81.2
X$491 4334 4851 3146 112 113 4936 NAND3_X1
* cell instance $496 r0 *1 203.87,81.2
X$496 4947 4948 4937 112 113 4832 MUX2_X1
* cell instance $501 r0 *1 213.37,81.2
X$501 112 17076 5066 4936 4454 113 DFF_X1
* cell instance $505 m0 *1 218.31,81.2
X$505 112 4834 4845 4938 4843 4846 4119 2610 113 AOI222_X2
* cell instance $509 r0 *1 219.07,81.2
X$509 4699 4835 4938 112 113 5048 NAND3_X1
* cell instance $511 r0 *1 221.35,81.2
X$511 112 17037 5063 4018 4454 113 DFF_X1
* cell instance $515 r0 *1 225.91,81.2
X$515 5049 4939 4945 112 113 5060 MUX2_X1
* cell instance $516 m0 *1 226.86,81.2
X$516 4454 112 113 17156 INV_X2
* cell instance $517 m0 *1 225.91,81.2
X$517 4841 112 113 4454 CLKBUF_X3
* cell instance $520 m0 *1 231.99,81.2
X$520 112 16777 4943 4946 4836 113 DFF_X1
* cell instance $527 r0 *1 229.9,81.2
X$527 5200 4939 4942 112 113 5059 MUX2_X1
* cell instance $530 r0 *1 232.37,81.2
X$530 4940 112 113 4937 BUF_X1
* cell instance $533 r0 *1 233.51,81.2
X$533 5202 4939 4944 112 113 5056 MUX2_X1
* cell instance $539 r0 *1 236.55,81.2
X$539 4941 112 113 4945 BUF_X1
* cell instance $541 r0 *1 237.5,81.2
X$541 5051 112 113 4942 BUF_X1
* cell instance $542 r0 *1 238.07,81.2
X$542 5050 112 113 4944 BUF_X1
* cell instance $546 m0 *1 136.61,53.2
X$546 112 2346 2079 593 2524 113 NOR3_X4
* cell instance $547 m0 *1 135.47,53.2
X$547 2528 2419 1027 1455 2348 113 112 2349 OAI221_X1
* cell instance $548 m0 *1 139.27,53.2
X$548 632 1416 864 1017 2416 112 113 OAI211_X2
* cell instance $549 m0 *1 140.98,53.2
X$549 1282 845 663 112 113 2460 NAND3_X1
* cell instance $550 m0 *1 141.74,53.2
X$550 1292 2526 2416 112 2562 113 AOI21_X1
* cell instance $551 m0 *1 142.5,53.2
X$551 2524 1496 1290 113 2461 112 NOR3_X2
* cell instance $553 r0 *1 135.47,53.2
X$553 2345 1445 2212 112 113 2654 MUX2_X1
* cell instance $554 r0 *1 136.8,53.2
X$554 2349 952 2654 112 2245 113 AOI21_X2
* cell instance $555 r0 *1 138.13,53.2
X$555 952 112 113 1292 CLKBUF_X3
* cell instance $556 r0 *1 139.08,53.2
X$556 2208 1552 632 112 113 2653 NAND3_X1
* cell instance $559 r0 *1 140.98,53.2
X$559 1018 2653 2460 112 2561 113 AOI21_X1
* cell instance $561 r0 *1 142.5,53.2
X$561 1292 1099 112 113 2769 NAND2_X1
* cell instance $563 r0 *1 143.45,53.2
X$563 1018 1099 112 113 2563 NAND2_X1
* cell instance $565 m0 *1 146.11,53.2
X$565 1552 927 663 112 113 2523 NAND3_X1
* cell instance $566 m0 *1 144.21,53.2
X$566 663 532 16490 113 112 2352 HA_X1
* cell instance $567 m0 *1 146.87,53.2
X$567 2523 2353 1018 112 113 2521 NAND3_X1
* cell instance $568 m0 *1 147.63,53.2
X$568 1409 112 113 928 CLKBUF_X3
* cell instance $571 m0 *1 153.14,53.2
X$571 2354 2408 16536 113 112 2519 HA_X1
* cell instance $574 r0 *1 146.3,53.2
X$574 1552 1182 112 113 2462 NAND2_X1
* cell instance $575 r0 *1 146.87,53.2
X$575 2462 1844 1292 587 663 113 112 2565 OAI221_X1
* cell instance $578 r0 *1 154.28,53.2
X$578 2647 2567 2568 2519 2465 2571 113 112 AOI221_X2
* cell instance $579 m0 *1 155.61,53.2
X$579 2356 112 113 2518 INV_X1
* cell instance $582 m0 *1 157.51,53.2
X$582 2354 2355 16512 113 112 2758 HA_X1
* cell instance $583 m0 *1 159.41,53.2
X$583 2358 2357 16515 113 112 2466 HA_X1
* cell instance $587 r0 *1 156.75,53.2
X$587 2464 2517 112 113 2645 NAND2_X1
* cell instance $588 r0 *1 157.32,53.2
X$588 2465 112 113 2467 CLKBUF_X3
* cell instance $590 r0 *1 158.46,53.2
X$590 2568 113 2577 112 BUF_X4
* cell instance $591 r0 *1 159.79,53.2
X$591 2680 2404 112 113 2646 NAND2_X1
* cell instance $593 r0 *1 160.55,53.2
X$593 2405 2466 112 113 2641 NOR2_X1
* cell instance $594 r0 *1 161.12,53.2
X$594 2469 2644 2467 112 2570 113 AOI21_X1
* cell instance $595 r0 *1 161.88,53.2
X$595 2643 2566 112 113 2569 NOR2_X1
* cell instance $596 r0 *1 162.45,53.2
X$596 2642 2640 2576 112 2515 113 AOI21_X1
* cell instance $597 m0 *1 162.64,53.2
X$597 2463 113 2404 112 BUF_X4
* cell instance $600 m0 *1 164.16,53.2
X$600 2358 2408 16509 113 112 2513 HA_X1
* cell instance $601 m0 *1 166.06,53.2
X$601 2360 2355 16510 113 112 2473 HA_X1
* cell instance $604 r0 *1 163.21,53.2
X$604 2470 2469 2467 112 2514 113 AOI21_X1
* cell instance $605 r0 *1 163.97,53.2
X$605 2465 2512 2574 112 113 2470 NOR3_X1
* cell instance $606 r0 *1 164.73,53.2
X$606 2638 2354 112 113 2407 NOR2_X1
* cell instance $607 r0 *1 165.3,53.2
X$607 2639 2471 112 113 2572 NOR2_X1
* cell instance $608 r0 *1 165.87,53.2
X$608 2468 112 113 2472 INV_X2
* cell instance $609 r0 *1 166.44,53.2
X$609 2573 2469 112 113 2637 NOR2_X1
* cell instance $611 r0 *1 168.53,53.2
X$611 112 2634 2360 113 BUF_X16
* cell instance $612 m0 *1 170.05,53.2
X$612 2358 2355 2474 113 112 2749 HA_X1
* cell instance $614 m0 *1 171.95,53.2
X$614 2354 2355 16544 113 112 2475 HA_X1
* cell instance $615 m0 *1 173.85,53.2
X$615 2360 2357 16541 113 112 2476 HA_X1
* cell instance $619 m0 *1 181.07,53.2
X$619 2362 112 113 357 CLKBUF_X3
* cell instance $621 m0 *1 182.21,53.2
X$621 112 2507 113 2363 BUF_X8
* cell instance $622 m0 *1 184.68,53.2
X$622 2364 112 113 1759 BUF_X2
* cell instance $623 m0 *1 185.44,53.2
X$623 2365 2366 112 113 2367 NAND2_X1
* cell instance $624 m0 *1 186.01,53.2
X$624 2509 2508 112 894 113 NAND2_X4
* cell instance $625 m0 *1 187.72,53.2
X$625 2364 113 2366 112 BUF_X4
* cell instance $626 m0 *1 189.05,53.2
X$626 2366 112 113 2136 BUF_X2
* cell instance $627 m0 *1 189.81,53.2
X$627 2505 2477 1855 112 113 NOR2_X4
* cell instance $630 m0 *1 200.64,53.2
X$630 2486 2371 112 113 2158 NOR2_X2
* cell instance $631 m0 *1 201.59,53.2
X$631 2480 113 2484 112 BUF_X4
* cell instance $632 m0 *1 202.92,53.2
X$632 112 2695 1938 2481 2479 113 AOI21_X4
* cell instance $633 m0 *1 205.39,53.2
X$633 2484 113 2257 112 BUF_X4
* cell instance $634 m0 *1 206.72,53.2
X$634 2481 2479 1948 112 113 2485 NAND3_X1
* cell instance $636 m0 *1 207.67,53.2
X$636 112 2369 1939 2039 2503 113 NOR3_X4
* cell instance $637 m0 *1 210.33,53.2
X$637 2250 113 2143 112 BUF_X4
* cell instance $639 r0 *1 173.28,53.2
X$639 2405 2566 112 113 2688 NOR2_X1
* cell instance $642 r0 *1 174.42,53.2
X$642 2404 112 113 2576 CLKBUF_X3
* cell instance $643 r0 *1 175.37,53.2
X$643 112 2689 113 2476 BUF_X8
* cell instance $650 r0 *1 181.45,53.2
X$650 2363 112 113 2631 BUF_X1
* cell instance $651 r0 *1 182.02,53.2
X$651 2363 112 113 1139 BUF_X2
* cell instance $652 r0 *1 182.78,53.2
X$652 2631 113 2510 112 BUF_X4
* cell instance $654 r0 *1 184.3,53.2
X$654 2362 112 113 1305 INV_X4
* cell instance $656 r0 *1 185.44,53.2
X$656 2368 112 113 2508 BUF_X2
* cell instance $657 r0 *1 186.2,53.2
X$657 2364 112 113 2578 BUF_X2
* cell instance $658 r0 *1 186.96,53.2
X$658 2580 1305 2692 113 2505 112 NOR3_X2
* cell instance $659 r0 *1 188.29,53.2
X$659 112 2507 387 113 BUF_X16
* cell instance $663 r0 *1 197.98,53.2
X$663 2627 113 2480 112 BUF_X4
* cell instance $664 r0 *1 199.31,53.2
X$664 2481 2479 112 113 2478 NAND2_X1
* cell instance $665 r0 *1 199.88,53.2
X$665 2478 113 2252 112 BUF_X4
* cell instance $666 r0 *1 201.21,53.2
X$666 2484 113 2626 112 BUF_X4
* cell instance $668 r0 *1 202.73,53.2
X$668 2484 1864 112 113 2622 NAND2_X1
* cell instance $669 r0 *1 203.3,53.2
X$669 2483 2482 2251 2582 2624 2623 113 112 AOI221_X2
* cell instance $670 r0 *1 205.39,53.2
X$670 2482 1858 2371 112 2624 113 AOI21_X1
* cell instance $672 r0 *1 206.34,53.2
X$672 2249 113 2253 112 BUF_X4
* cell instance $673 r0 *1 207.67,53.2
X$673 2482 2621 2249 113 112 2584 OAI21_X2
* cell instance $675 r0 *1 209.38,53.2
X$675 2037 2485 2045 112 113 2617 AND3_X4
* cell instance $677 r0 *1 211.66,53.2
X$677 2143 2486 2370 2484 2487 2618 113 112 AOI221_X2
* cell instance $678 m0 *1 213.37,53.2
X$678 2480 2039 1939 113 112 2397 OAI21_X2
* cell instance $679 m0 *1 212.04,53.2
X$679 2369 2039 1939 113 112 2401 OAI21_X2
* cell instance $680 m0 *1 214.7,53.2
X$680 1867 1766 112 113 2370 NOR2_X2
* cell instance $681 m0 *1 215.65,53.2
X$681 2372 2486 1861 113 2139 112 OAI21_X1
* cell instance $682 m0 *1 216.41,53.2
X$682 2257 1861 2381 113 112 2394 OAI21_X2
* cell instance $683 m0 *1 217.74,53.2
X$683 1940 2486 1870 2371 112 113 2142 AOI22_X1
* cell instance $684 m0 *1 218.69,53.2
X$684 2158 2492 2253 1942 2375 2613 112 113 OAI221_X2
* cell instance $685 m0 *1 220.78,53.2
X$685 2381 2255 112 113 2376 NAND2_X1
* cell instance $687 m0 *1 221.54,53.2
X$687 1861 2378 2391 112 2489 113 AOI21_X1
* cell instance $688 m0 *1 222.3,53.2
X$688 1863 1937 2371 112 2490 113 AOI21_X1
* cell instance $690 m0 *1 223.25,53.2
X$690 2374 2379 112 113 2491 NAND2_X2
* cell instance $692 r0 *1 213.75,53.2
X$692 2617 2278 2484 112 2483 113 AOI21_X2
* cell instance $694 r0 *1 215.46,53.2
X$694 2699 2394 2487 2596 113 112 2616 OAI22_X2
* cell instance $696 r0 *1 217.36,53.2
X$696 2587 2256 2485 112 2586 113 AOI21_X1
* cell instance $697 r0 *1 218.12,53.2
X$697 2491 2616 2388 2488 2613 2610 112 113 OAI221_X2
* cell instance $699 r0 *1 220.4,53.2
X$699 2156 112 113 2587 CLKBUF_X3
* cell instance $700 r0 *1 221.35,53.2
X$700 2258 2253 2490 2607 2375 2603 112 113 OAI221_X2
* cell instance $701 r0 *1 223.44,53.2
X$701 2157 2485 112 113 2703 NAND2_X1
* cell instance $702 r0 *1 224.01,53.2
X$702 2258 2147 2276 112 113 2590 MUX2_X1
* cell instance $704 m0 *1 224.58,53.2
X$704 1864 2153 2493 2495 112 113 2383 AOI22_X1
* cell instance $705 m0 *1 225.72,53.2
X$705 2153 2494 2382 112 2496 113 AOI21_X1
* cell instance $706 m0 *1 226.48,53.2
X$706 2259 2253 2251 113 2384 112 OAI21_X1
* cell instance $707 m0 *1 227.24,53.2
X$707 2146 1866 2145 112 2497 113 AOI21_X1
* cell instance $708 m0 *1 228,53.2
X$708 2498 2040 2145 112 113 2594 MUX2_X1
* cell instance $710 m0 *1 229.52,53.2
X$710 2494 113 2262 112 BUF_X4
* cell instance $711 m0 *1 230.85,53.2
X$711 2147 112 113 2382 CLKBUF_X3
* cell instance $712 m0 *1 231.8,53.2
X$712 2498 113 2493 112 BUF_X4
* cell instance $716 r0 *1 225.53,53.2
X$716 2257 2045 2495 112 2591 113 AOI21_X2
* cell instance $719 r0 *1 227.43,53.2
X$719 2380 2384 2497 2593 2601 2595 112 113 2592 OAI33_X1
* cell instance $720 r0 *1 228.76,53.2
X$720 2251 113 2595 112 BUF_X4
* cell instance $721 r0 *1 230.09,53.2
X$721 2596 1941 16712 113 112 2707 HA_X1
* cell instance $722 r0 *1 231.99,53.2
X$722 2374 113 2494 112 BUF_X4
* cell instance $731 m0 *1 212.8,61.6
X$731 2146 2494 2047 113 112 3149 OAI21_X2
* cell instance $732 m0 *1 211.47,61.6
X$732 2155 3124 3149 112 3023 113 AOI21_X2
* cell instance $733 m0 *1 214.13,61.6
X$733 3053 112 113 3247 INV_X1
* cell instance $734 m0 *1 214.51,61.6
X$734 2927 3147 112 113 3053 NOR2_X1
* cell instance $737 r0 *1 211.66,61.6
X$737 3219 2715 112 113 3250 NOR2_X1
* cell instance $738 r0 *1 212.23,61.6
X$738 3220 2147 2484 113 3150 112 OAI21_X1
* cell instance $741 r0 *1 215.27,61.6
X$741 3311 2140 3243 113 3245 112 OAI21_X1
* cell instance $742 m0 *1 216.79,61.6
X$742 2828 3144 3025 3126 2927 3145 112 113 OAI221_X2
* cell instance $743 m0 *1 215.46,61.6
X$743 2143 2705 1941 112 113 3144 MUX2_X1
* cell instance $744 m0 *1 218.88,61.6
X$744 2494 2492 112 113 2946 NAND2_X1
* cell instance $748 r0 *1 216.41,61.6
X$748 3242 2586 3312 2595 3313 113 112 3243 OAI221_X1
* cell instance $749 r0 *1 217.55,61.6
X$749 2259 2945 2251 113 3242 112 OAI21_X1
* cell instance $751 r0 *1 218.5,61.6
X$751 3315 2587 2373 112 3426 113 AOI21_X1
* cell instance $752 r0 *1 219.26,61.6
X$752 2156 2625 2495 112 3315 113 AOI21_X1
* cell instance $754 m0 *1 220.78,61.6
X$754 2715 2489 3226 112 113 3238 OR3_X1
* cell instance $756 m0 *1 221.73,61.6
X$756 3147 3127 3238 113 112 3502 AND3_X1
* cell instance $759 m0 *1 223.63,61.6
X$759 3221 2143 2371 112 3128 113 AOI21_X1
* cell instance $760 m0 *1 224.39,61.6
X$760 3142 3031 3065 112 113 3237 NAND3_X1
* cell instance $761 m0 *1 225.15,61.6
X$761 2494 2377 112 113 3221 NAND2_X2
* cell instance $763 m0 *1 226.86,61.6
X$763 2398 2494 2587 112 113 3138 NOR3_X1
* cell instance $764 m0 *1 227.62,61.6
X$764 3306 3138 2045 112 3320 113 AOI21_X1
* cell instance $768 r0 *1 224.77,61.6
X$768 2493 2495 3234 113 3316 112 OAI21_X1
* cell instance $769 r0 *1 225.53,61.6
X$769 3316 3322 2930 2712 113 112 3419 OAI22_X1
* cell instance $770 r0 *1 226.48,61.6
X$770 2705 2625 3317 112 3322 113 AOI21_X1
* cell instance $772 r0 *1 227.43,61.6
X$772 2398 2042 112 113 3317 NAND2_X2
* cell instance $773 r0 *1 228.38,61.6
X$773 1937 2945 2397 112 3229 113 AOI21_X1
* cell instance $775 m0 *1 228.76,61.6
X$775 2042 2157 2937 3222 113 112 3228 OAI22_X1
* cell instance $776 m0 *1 230.47,61.6
X$776 2498 1937 112 113 3132 NAND2_X1
* cell instance $777 m0 *1 231.04,61.6
X$777 3223 3130 3131 112 3226 113 AOI21_X1
* cell instance $778 m0 *1 231.8,61.6
X$778 2379 3133 2147 112 3223 113 AOI21_X1
* cell instance $780 r0 *1 229.14,61.6
X$780 3228 3229 2262 113 3319 112 OAI21_X1
* cell instance $782 r0 *1 230.09,61.6
X$782 1870 112 113 3220 INV_X1
* cell instance $784 r0 *1 230.66,61.6
X$784 2492 2377 1937 112 113 3318 MUX2_X1
* cell instance $788 m0 *1 232.94,61.6
X$788 2950 1941 16528 113 112 3133 HA_X1
* cell instance $792 r0 *1 233.32,61.6
X$792 1937 1941 16670 113 112 3906 HA_X1
* cell instance $800 m0 *1 131.86,168
X$800 10781 11243 9876 112 12716 113 NAND3_X4
* cell instance $801 m0 *1 130.53,168
X$801 11243 12607 10822 113 112 11756 OAI21_X2
* cell instance $802 m0 *1 134.33,168
X$802 12609 12608 11001 113 112 12482 MUX2_X2
* cell instance $804 r0 *1 130.53,168
X$804 9979 112 113 11713 CLKBUF_X3
* cell instance $806 r0 *1 131.67,168
X$806 11390 113 10440 112 BUF_X4
* cell instance $808 r0 *1 133.19,168
X$808 12050 113 10213 112 BUF_X4
* cell instance $809 r0 *1 134.52,168
X$809 11555 10662 16656 113 112 12763 HA_X1
* cell instance $810 m0 *1 137.75,168
X$810 12609 113 10340 112 BUF_X4
* cell instance $811 m0 *1 136.42,168
X$811 12763 113 11266 112 BUF_X4
* cell instance $812 m0 *1 139.08,168
X$812 12845 113 10777 112 BUF_X4
* cell instance $815 r0 *1 136.42,168
X$815 12051 112 113 12608 INV_X2
* cell instance $818 r0 *1 137.56,168
X$818 9982 12762 16657 113 112 12847 HA_X1
* cell instance $819 r0 *1 139.46,168
X$819 12847 112 113 12050 BUF_X2
* cell instance $820 r0 *1 140.22,168
X$820 9982 12762 16674 113 112 12845 HA_X1
* cell instance $823 m0 *1 143.83,168
X$823 12610 112 113 9299 CLKBUF_X3
* cell instance $825 m0 *1 148.39,168
X$825 112 16918 12610 12832 11904 113 DFF_X1
* cell instance $827 m0 *1 151.62,168
X$827 12492 12612 12611 113 12842 112 OAI21_X1
* cell instance $828 m0 *1 152.38,168
X$828 12712 12337 12715 113 12612 112 OAI21_X1
* cell instance $830 m0 *1 153.33,168
X$830 11600 12450 12715 112 12613 113 AOI21_X1
* cell instance $832 m0 *1 154.28,168
X$832 11129 12613 112 113 12721 OR2_X1
* cell instance $837 r0 *1 153.14,168
X$837 12841 12764 12842 112 12164 113 AOI21_X1
* cell instance $838 r0 *1 153.9,168
X$838 11008 11123 112 113 12764 NOR2_X1
* cell instance $839 r0 *1 154.47,168
X$839 12834 12615 12764 113 12947 112 OAI21_X1
* cell instance $840 r0 *1 155.23,168
X$840 12840 12944 10833 113 12841 112 OAI21_X1
* cell instance $842 m0 *1 155.42,168
X$842 12839 11072 11277 12721 12837 113 112 12616 OAI221_X1
* cell instance $843 m0 *1 156.75,168
X$843 12447 12340 12617 112 12837 113 AOI21_X1
* cell instance $845 r0 *1 155.99,168
X$845 11437 11432 11908 113 12840 112 OAI21_X1
* cell instance $847 r0 *1 157.51,168
X$847 12335 12617 12838 112 12944 113 AOI21_X1
* cell instance $848 m0 *1 159.22,168
X$848 12727 12617 11129 112 113 12725 NAND3_X1
* cell instance $849 m0 *1 157.89,168
X$849 12222 12725 12709 112 12058 113 AOI21_X2
* cell instance $850 m0 *1 159.98,168
X$850 11536 11448 112 113 12617 NAND2_X1
* cell instance $851 m0 *1 160.55,168
X$851 11684 11601 11600 11603 112 113 12727 AOI22_X1
* cell instance $853 r0 *1 158.27,168
X$853 12450 11602 112 113 12874 NAND2_X1
* cell instance $855 r0 *1 160.36,168
X$855 11442 12816 12625 112 12060 113 AOI21_X1
* cell instance $856 r0 *1 161.12,168
X$856 12770 12627 12492 112 113 12834 NOR3_X1
* cell instance $857 r0 *1 161.88,168
X$857 10951 12830 12765 12766 12728 12824 112 113 12832 OAI33_X1
* cell instance $858 m0 *1 162.07,168
X$858 12625 12831 11603 112 12618 113 AOI21_X1
* cell instance $862 r0 *1 163.21,168
X$862 12767 12875 12876 112 12766 113 AOI21_X1
* cell instance $863 r0 *1 163.97,168
X$863 12828 11972 11281 112 113 12875 NAND3_X1
* cell instance $864 m0 *1 164.92,168
X$864 12619 12722 11444 12621 11072 12724 112 113 OAI221_X2
* cell instance $868 r0 *1 164.73,168
X$868 12619 12621 112 113 12828 NAND2_X1
* cell instance $870 r0 *1 166.06,168
X$870 12768 112 113 12491 BUF_X2
* cell instance $871 r0 *1 166.82,168
X$871 12768 11912 112 113 12722 NOR2_X1
* cell instance $873 r0 *1 167.58,168
X$873 12877 12769 11003 11008 12705 12824 113 112 AOI221_X2
* cell instance $875 m0 *1 168.15,168
X$875 12622 11004 112 113 12769 NOR2_X1
* cell instance $876 m0 *1 168.91,168
X$876 12218 112 113 12621 BUF_X1
* cell instance $877 m0 *1 169.48,168
X$877 12621 12335 12623 113 12823 112 OAI21_X1
* cell instance $878 m0 *1 170.24,168
X$878 11525 12712 12878 11446 12623 11683 112 113 OAI221_X2
* cell instance $879 m0 *1 172.33,168
X$879 112 12711 11288 113 BUF_X16
* cell instance $881 m0 *1 177.27,168
X$881 12501 11289 12715 112 12623 113 NAND3_X4
* cell instance $883 m0 *1 179.93,168
X$883 12707 12625 12223 12505 12706 12709 112 113 OAI221_X2
* cell instance $885 m0 *1 182.21,168
X$885 12624 113 12708 112 BUF_X4
* cell instance $886 m0 *1 183.54,168
X$886 11781 11537 12697 12625 12626 12811 112 113 OAI221_X2
* cell instance $887 m0 *1 185.63,168
X$887 12503 12771 12349 112 113 12699 NAND3_X1
* cell instance $888 m0 *1 186.39,168
X$888 12699 11781 11855 112 113 12626 NAND3_X1
* cell instance $889 m0 *1 187.15,168
X$889 12628 10836 12627 112 12697 113 AOI21_X1
* cell instance $890 m0 *1 187.91,168
X$890 12224 11670 11972 113 12629 112 OAI21_X1
* cell instance $891 m0 *1 188.67,168
X$891 11991 11453 11294 113 112 12624 OAI21_X4
* cell instance $895 r0 *1 169.67,168
X$895 11768 12823 11007 113 12935 112 OAI21_X1
* cell instance $897 r0 *1 170.81,168
X$897 11531 11447 12621 112 113 12770 NOR3_X1
* cell instance $899 r0 *1 171.76,168
X$899 12218 112 113 12819 BUF_X2
* cell instance $900 r0 *1 172.52,168
X$900 11367 12346 11449 112 12497 113 AOI21_X1
* cell instance $901 r0 *1 173.28,168
X$901 11447 11531 11972 11012 11448 113 112 13093 OAI221_X1
* cell instance $903 r0 *1 174.61,168
X$903 12224 11531 11447 113 112 12930 OAI21_X2
* cell instance $905 r0 *1 176.13,168
X$905 12819 11531 11447 113 112 12771 OAI21_X4
* cell instance $906 r0 *1 178.6,168
X$906 11610 12816 12219 12346 12627 12923 113 112 AOI221_X2
* cell instance $911 r0 *1 180.88,168
X$911 1747 112 113 10299 CLKBUF_X3
* cell instance $912 r0 *1 181.83,168
X$912 10299 112 113 17152 INV_X8
* cell instance $914 r0 *1 183.73,168
X$914 12700 12810 11007 10835 12811 12830 113 112 AOI221_X2
* cell instance $915 r0 *1 185.82,168
X$915 11670 112 113 10836 CLKBUF_X3
* cell instance $916 r0 *1 186.77,168
X$916 12627 12628 11837 12808 12629 12810 113 112 AOI221_X2
* cell instance $917 r0 *1 188.86,168
X$917 11670 12922 112 113 12808 OR2_X1
* cell instance $920 m0 *1 199.69,168
X$920 12357 12228 11460 11656 11511 12676 113 112 AOI221_X2
* cell instance $921 m0 *1 198.36,168
X$921 10756 113 12773 112 BUF_X4
* cell instance $922 m0 *1 201.78,168
X$922 112 12228 12350 113 BUF_X16
* cell instance $923 m0 *1 206.53,168
X$923 12245 113 11953 112 BUF_X4
* cell instance $924 m0 *1 207.86,168
X$924 12918 10492 12684 112 12805 113 AOI21_X2
* cell instance $926 m0 *1 209.38,168
X$926 11786 113 11930 112 BUF_X4
* cell instance $927 m0 *1 210.71,168
X$927 12683 11929 11930 112 10918 113 AOI21_X2
* cell instance $928 m0 *1 212.04,168
X$928 10006 11929 11930 112 12630 113 AOI21_X1
* cell instance $929 m0 *1 212.8,168
X$929 12676 12530 11309 112 12650 113 AOI21_X1
* cell instance $930 m0 *1 213.56,168
X$930 12774 10918 11030 113 12632 112 OAI21_X1
* cell instance $931 m0 *1 214.32,168
X$931 10606 12632 11467 112 12647 113 AOI21_X1
* cell instance $933 m0 *1 215.27,168
X$933 12631 11303 112 113 11932 NOR2_X2
* cell instance $934 m0 *1 216.22,168
X$934 10722 10595 12801 112 12668 113 AOI21_X1
* cell instance $935 m0 *1 216.98,168
X$935 12631 10727 112 113 12883 NOR2_X1
* cell instance $936 m0 *1 217.55,168
X$936 10594 11049 11313 11618 113 112 12777 OAI22_X1
* cell instance $937 m0 *1 218.5,168
X$937 11649 12226 10592 112 12800 113 AOI21_X1
* cell instance $938 m0 *1 219.26,168
X$938 10859 12510 12657 112 12799 113 AOI21_X1
* cell instance $942 r0 *1 199.12,168
X$942 11300 112 113 12228 INV_X8
* cell instance $945 r0 *1 201.78,168
X$945 11786 11953 11785 112 11053 113 NAND3_X4
* cell instance $946 r0 *1 204.25,168
X$946 11656 11347 11144 112 113 NOR2_X4
* cell instance $947 r0 *1 205.96,168
X$947 10853 12533 12773 113 112 11927 OAI21_X2
* cell instance $949 r0 *1 207.67,168
X$949 112 12687 113 12772 BUF_X8
* cell instance $950 r0 *1 210.14,168
X$950 112 12772 12773 12533 12775 113 NOR3_X4
* cell instance $951 r0 *1 212.8,168
X$951 12533 12773 11022 112 113 12774 NOR3_X1
* cell instance $952 r0 *1 213.56,168
X$952 12775 12356 10864 113 12915 112 OAI21_X1
* cell instance $954 r0 *1 214.51,168
X$954 12804 11302 12238 112 113 12801 MUX2_X1
* cell instance $955 r0 *1 215.84,168
X$955 12229 11790 11053 113 12911 112 OAI21_X1
* cell instance $956 r0 *1 216.6,168
X$956 12772 11656 112 113 12238 NAND2_X1
* cell instance $958 r0 *1 217.36,168
X$958 12800 12776 10488 10372 12777 112 113 12906 AOI221_X1
* cell instance $959 r0 *1 218.5,168
X$959 12356 12775 11049 112 113 NOR2_X4
* cell instance $960 r0 *1 220.21,168
X$960 12906 12799 12792 112 12778 113 AOI21_X1
* cell instance $962 m0 *1 221.35,168
X$962 11618 11144 112 113 12779 NOR2_X1
* cell instance $965 m0 *1 222.11,168
X$965 12086 12245 112 113 12780 NAND2_X1
* cell instance $966 m0 *1 222.68,168
X$966 11154 12633 12635 11038 12634 113 112 12636 OAI221_X1
* cell instance $968 r0 *1 221.73,168
X$968 10606 12779 12780 112 12781 113 AOI21_X1
* cell instance $969 r0 *1 222.49,168
X$969 10372 12782 10862 11154 12902 113 112 12903 OAI221_X1
* cell instance $970 r0 *1 223.63,168
X$970 11628 11145 10864 113 12902 112 OAI21_X1
* cell instance $971 m0 *1 224.39,168
X$971 12687 112 113 12358 INV_X4
* cell instance $977 r0 *1 225.34,168
X$977 12687 112 113 12253 BUF_X2
* cell instance $979 m0 *1 226.67,168
X$979 11309 10595 12358 112 113 12783 NAND3_X1
* cell instance $981 m0 *1 227.43,168
X$981 11310 11787 112 113 12784 NAND2_X1
* cell instance $985 r0 *1 227.43,168
X$985 12086 12783 12784 112 12797 113 AOI21_X1
* cell instance $987 m0 *1 228.57,168
X$987 12508 10885 12357 112 12638 113 AOI21_X1
* cell instance $989 m0 *1 229.33,168
X$989 12245 12638 12518 113 12785 112 OAI21_X1
* cell instance $990 m0 *1 230.09,168
X$990 11949 11043 112 113 12786 NOR2_X1
* cell instance $993 m0 *1 231.61,168
X$993 11151 11794 12102 112 113 12787 NAND3_X1
* cell instance $995 m0 *1 233.13,168
X$995 12086 12510 16517 113 112 11634 HA_X1
* cell instance $1000 r0 *1 228.57,168
X$1000 12647 12797 112 113 12886 OR2_X1
* cell instance $1003 r0 *1 229.9,168
X$1003 12786 10610 12785 112 12792 113 AOI21_X1
* cell instance $1005 r0 *1 231.04,168
X$1005 10727 10489 112 113 12889 NOR2_X1
* cell instance $1007 r0 *1 231.8,168
X$1007 112 12789 12247 10364 12788 113 DFF_X2
* cell instance $1008 r0 *1 235.41,168
X$1008 12788 4939 12892 112 113 12789 MUX2_X1
* cell instance $1014 r0 *1 238.64,168
X$1014 13194 112 113 12639 BUF_X1
* cell instance $1018 m0 *1 67.83,114.8
X$1018 7981 7738 7407 112 113 7894 NAND3_X2
* cell instance $1020 m0 *1 69.16,114.8
X$1020 112 7982 113 6051 BUF_X8
* cell instance $1021 m0 *1 71.63,114.8
X$1021 7895 113 186 112 BUF_X4
* cell instance $1023 m0 *1 73.15,114.8
X$1023 3672 7805 112 113 7804 NAND2_X1
* cell instance $1025 m0 *1 74.48,114.8
X$1025 3363 112 113 7805 INV_X1
* cell instance $1026 m0 *1 74.86,114.8
X$1026 112 7806 7646 7647 4629 113 NOR3_X4
* cell instance $1029 m0 *1 79.23,114.8
X$1029 112 3094 7732 17226 7898 113 DFF_X2
* cell instance $1032 m0 *1 83.79,114.8
X$1032 6857 7808 7809 113 8127 112 OAI21_X1
* cell instance $1034 m0 *1 84.74,114.8
X$1034 6857 5177 7986 112 113 7809 NAND3_X1
* cell instance $1035 m0 *1 85.5,114.8
X$1035 6516 112 113 7986 INV_X1
* cell instance $1038 r0 *1 67.64,114.8
X$1038 7407 112 113 8117 INV_X1
* cell instance $1042 r0 *1 68.02,114.8
X$1042 7894 7981 8115 113 112 8116 OAI21_X4
* cell instance $1043 r0 *1 70.49,114.8
X$1043 7738 8117 112 113 8115 NAND2_X2
* cell instance $1044 r0 *1 71.44,114.8
X$1044 7648 7407 112 113 8118 NOR2_X1
* cell instance $1046 r0 *1 72.2,114.8
X$1046 8029 5170 3363 112 113 7983 NOR3_X1
* cell instance $1047 r0 *1 72.96,114.8
X$1047 8029 5170 7805 112 113 8120 NOR3_X1
* cell instance $1048 r0 *1 73.72,114.8
X$1048 7983 8121 8120 112 113 7646 MUX2_X1
* cell instance $1049 r0 *1 75.05,114.8
X$1049 8274 8121 8122 112 113 7806 MUX2_X1
* cell instance $1051 r0 *1 79.42,114.8
X$1051 8125 7407 113 7321 112 XOR2_X2
* cell instance $1052 r0 *1 81.13,114.8
X$1052 6775 6516 112 113 8033 NOR2_X1
* cell instance $1053 r0 *1 81.7,114.8
X$1053 6516 112 113 8126 BUF_X1
* cell instance $1054 r0 *1 82.27,114.8
X$1054 8127 7896 7897 112 113 6077 OR3_X4
* cell instance $1055 r0 *1 84.36,114.8
X$1055 7898 112 113 7984 BUF_X1
* cell instance $1057 r0 *1 86.45,114.8
X$1057 8038 8037 112 113 8129 XOR2_X1
* cell instance $1058 m0 *1 87.21,114.8
X$1058 7813 5240 7203 112 113 7810 NAND3_X1
* cell instance $1060 m0 *1 87.97,114.8
X$1060 7899 7812 112 113 8128 NAND2_X1
* cell instance $1062 m0 *1 88.73,114.8
X$1062 7812 7362 7203 112 113 7900 NAND3_X1
* cell instance $1063 m0 *1 89.49,114.8
X$1063 7899 7813 112 113 8130 NAND2_X1
* cell instance $1066 r0 *1 87.59,114.8
X$1066 8129 8128 7810 112 7743 113 AOI21_X2
* cell instance $1067 r0 *1 88.92,114.8
X$1067 8131 7900 8130 112 7811 113 AOI21_X2
* cell instance $1070 m0 *1 91.39,114.8
X$1070 7895 113 7930 112 BUF_X4
* cell instance $1073 m0 *1 92.91,114.8
X$1073 112 7988 7732 7814 7815 113 DFF_X2
* cell instance $1074 m0 *1 96.52,114.8
X$1074 7814 8039 16590 113 112 7867 HA_X1
* cell instance $1075 m0 *1 98.42,114.8
X$1075 7815 8039 16591 113 112 7902 HA_X1
* cell instance $1077 r0 *1 91.39,114.8
X$1077 112 5928 5240 113 BUF_X32
* cell instance $1079 m0 *1 100.7,114.8
X$1079 7901 7974 112 113 7745 NOR2_X1
* cell instance $1080 r0 *1 100.7,114.8
X$1080 8139 7992 113 7901 112 XOR2_X2
* cell instance $1082 m0 *1 101.65,114.8
X$1082 112 7869 7903 7817 7019 113 DFF_X1
* cell instance $1083 m0 *1 105.64,114.8
X$1083 7818 7653 7995 112 113 7994 MUX2_X1
* cell instance $1085 r0 *1 102.41,114.8
X$1085 7902 7901 7867 112 113 8140 MUX2_X1
* cell instance $1087 r0 *1 103.93,114.8
X$1087 8036 7903 113 112 8141 XNOR2_X1
* cell instance $1089 r0 *1 105.45,114.8
X$1089 8141 7458 112 113 7653 XNOR2_X2
* cell instance $1091 m0 *1 107.35,114.8
X$1091 3334 4407 113 7904 112 XOR2_X2
* cell instance $1093 m0 *1 111.34,114.8
X$1093 5401 7203 112 113 7899 NOR2_X1
* cell instance $1094 m0 *1 109.44,114.8
X$1094 4407 3334 112 113 8208 XNOR2_X2
* cell instance $1097 m0 *1 115.14,114.8
X$1097 112 7246 113 7244 BUF_X8
* cell instance $1099 m0 *1 117.8,114.8
X$1099 7905 6509 112 113 7519 NAND2_X1
* cell instance $1100 m0 *1 118.37,114.8
X$1100 7905 7408 112 113 7998 NOR2_X1
* cell instance $1101 m0 *1 118.94,114.8
X$1101 7819 5172 113 7655 112 XOR2_X2
* cell instance $1102 m0 *1 120.65,114.8
X$1102 7871 7998 7820 113 112 6512 MUX2_X2
* cell instance $1103 m0 *1 122.36,114.8
X$1103 3928 113 6983 112 BUF_X4
* cell instance $1105 m0 *1 124.45,114.8
X$1105 7188 8149 113 112 7873 XNOR2_X1
* cell instance $1107 m0 *1 125.78,114.8
X$1107 2809 7873 113 112 8151 XNOR2_X1
* cell instance $1108 m0 *1 126.92,114.8
X$1108 4279 112 113 7335 CLKBUF_X3
* cell instance $1109 m0 *1 127.87,114.8
X$1109 8044 5120 112 113 7999 NOR2_X1
* cell instance $1110 m0 *1 128.44,114.8
X$1110 6983 113 3783 112 BUF_X4
* cell instance $1113 m0 *1 130.72,114.8
X$1113 6983 113 6244 112 BUF_X4
* cell instance $1120 r0 *1 116.28,114.8
X$1120 112 5023 7648 113 BUF_X32
* cell instance $1125 r0 *1 125.78,114.8
X$1125 3068 8044 113 112 8152 AND2_X1
* cell instance $1126 r0 *1 126.54,114.8
X$1126 8152 7999 8151 113 112 3834 MUX2_X2
* cell instance $1128 r0 *1 128.63,114.8
X$1128 6983 113 4389 112 BUF_X4
* cell instance $1133 r0 *1 132.24,114.8
X$1133 6372 5393 8008 112 113 8002 NOR3_X1
* cell instance $1134 r0 *1 133,114.8
X$1134 112 8577 4161 113 BUF_X16
* cell instance $1135 m0 *1 133.38,114.8
X$1135 6373 3571 7823 112 113 8004 NOR3_X1
* cell instance $1137 m0 *1 134.14,114.8
X$1137 8002 8004 7250 113 8003 112 OAI21_X1
* cell instance $1138 m0 *1 134.9,114.8
X$1138 6372 5393 7823 112 113 8005 NOR3_X1
* cell instance $1139 m0 *1 135.66,114.8
X$1139 8005 8007 7612 113 7907 112 OAI21_X1
* cell instance $1140 m0 *1 136.42,114.8
X$1140 6373 7650 8008 112 113 8007 NOR3_X1
* cell instance $1146 m0 *1 143.45,114.8
X$1146 6795 6920 6922 113 112 7524 OAI21_X2
* cell instance $1147 m0 *1 141.36,114.8
X$1147 7908 6196 7870 7662 7659 7785 113 112 AOI221_X2
* cell instance $1148 m0 *1 144.78,114.8
X$1148 6367 6485 6816 113 7909 112 OAI21_X1
* cell instance $1149 m0 *1 145.54,114.8
X$1149 7872 7910 6148 112 113 6097 NAND3_X2
* cell instance $1150 m0 *1 146.87,114.8
X$1150 7872 7910 6653 112 113 6812 NAND3_X2
* cell instance $1152 m0 *1 148.39,114.8
X$1152 7923 7256 7115 112 7825 113 AOI21_X1
* cell instance $1153 m0 *1 149.15,114.8
X$1153 5988 5851 112 113 7911 NAND2_X2
* cell instance $1158 r0 *1 142.12,114.8
X$1158 6495 7534 112 113 7908 NOR2_X1
* cell instance $1159 r0 *1 142.69,114.8
X$1159 6640 8009 7659 112 113 NOR2_X4
* cell instance $1160 r0 *1 144.4,114.8
X$1160 7209 7607 113 112 8162 AND2_X1
* cell instance $1161 r0 *1 145.16,114.8
X$1161 7909 7874 6406 113 8169 112 OAI21_X1
* cell instance $1163 r0 *1 146.11,114.8
X$1163 7872 7910 7534 112 113 6485 NAND3_X2
* cell instance $1164 r0 *1 147.44,114.8
X$1164 6934 6658 8009 112 113 6099 OR3_X1
* cell instance $1165 r0 *1 148.39,114.8
X$1165 8046 8009 7662 112 113 8000 NOR3_X1
* cell instance $1168 r0 *1 150.29,114.8
X$1168 7662 5985 6097 112 8006 113 AOI21_X1
* cell instance $1169 r0 *1 151.05,114.8
X$1169 8006 6795 7255 112 8048 113 AOI21_X1
* cell instance $1170 m0 *1 151.43,114.8
X$1170 7912 7524 112 113 8001 NAND2_X1
* cell instance $1172 m0 *1 152,114.8
X$1172 7255 7030 6701 6811 8001 8168 113 112 AOI221_X2
* cell instance $1175 r0 *1 151.81,114.8
X$1175 6932 6926 7420 113 8167 112 OAI21_X1
* cell instance $1176 r0 *1 152.57,114.8
X$1176 8169 8168 8165 8170 113 112 6482 OAI22_X2
* cell instance $1178 r0 *1 154.47,114.8
X$1178 6081 7664 7913 8000 6074 8051 112 113 OAI221_X2
* cell instance $1179 m0 *1 156.56,114.8
X$1179 6894 7915 112 113 7914 NAND2_X1
* cell instance $1180 m0 *1 155.99,114.8
X$1180 6816 6080 112 113 7532 NAND2_X1
* cell instance $1181 m0 *1 157.13,114.8
X$1181 6932 6688 7791 113 7916 112 OAI21_X1
* cell instance $1182 m0 *1 157.89,114.8
X$1182 7791 7827 6080 112 113 7997 NAND3_X1
* cell instance $1183 m0 *1 158.65,114.8
X$1183 7997 7028 7661 112 7787 113 AOI21_X1
* cell instance $1184 m0 *1 159.41,114.8
X$1184 7534 6795 112 113 7791 NAND2_X1
* cell instance $1186 r0 *1 156.56,114.8
X$1186 6478 7827 112 113 7913 NAND2_X1
* cell instance $1188 r0 *1 157.51,114.8
X$1188 7365 6251 7916 112 8172 113 AOI21_X1
* cell instance $1190 r0 *1 158.65,114.8
X$1190 112 7530 113 7996 BUF_X8
* cell instance $1191 m0 *1 161.12,114.8
X$1191 7911 7865 7991 112 7346 113 AOI21_X2
* cell instance $1192 m0 *1 160.36,114.8
X$1192 8291 6930 6811 112 7993 113 AOI21_X1
* cell instance $1193 m0 *1 162.45,114.8
X$1193 7990 6537 7665 112 7786 113 AOI21_X1
* cell instance $1194 m0 *1 163.21,114.8
X$1194 5913 6933 7866 7917 7989 7991 112 113 OAI221_X2
* cell instance $1195 m0 *1 165.3,114.8
X$1195 6154 7864 7918 6344 6159 112 113 7385 AOI221_X1
* cell instance $1196 m0 *1 166.44,114.8
X$1196 7919 7604 7827 112 7987 113 AOI21_X1
* cell instance $1197 m0 *1 167.2,114.8
X$1197 7596 8161 112 113 7985 NAND2_X1
* cell instance $1198 m0 *1 167.77,114.8
X$1198 7828 6894 6352 6545 112 113 8163 AOI22_X2
* cell instance $1200 r0 *1 161.12,114.8
X$1200 6932 7914 7142 112 7826 113 AOI21_X1
* cell instance $1202 r0 *1 162.07,114.8
X$1202 7260 7028 6074 6251 7993 113 112 7989 OAI221_X1
* cell instance $1203 r0 *1 163.21,114.8
X$1203 6196 5979 7380 113 112 8171 AND3_X1
* cell instance $1205 r0 *1 164.54,114.8
X$1205 6934 6701 7142 113 8166 112 OAI21_X1
* cell instance $1206 r0 *1 165.3,114.8
X$1206 6402 7771 6195 8163 5913 8165 112 113 OAI221_X2
* cell instance $1207 r0 *1 167.39,114.8
X$1207 6352 6930 112 113 8054 NAND2_X1
* cell instance $1208 r0 *1 167.96,114.8
X$1208 7922 113 6811 112 BUF_X4
* cell instance $1210 r0 *1 169.67,114.8
X$1210 8052 112 113 6410 CLKBUF_X3
* cell instance $1211 m0 *1 171,114.8
X$1211 4763 7920 112 113 5851 XNOR2_X2
* cell instance $1212 m0 *1 169.86,114.8
X$1212 7829 5991 6195 7863 7980 113 112 7865 OAI221_X1
* cell instance $1213 m0 *1 172.9,114.8
X$1213 7662 7828 7923 112 7864 113 AOI21_X1
* cell instance $1214 m0 *1 173.66,114.8
X$1214 7534 6407 112 113 8055 NOR2_X1
* cell instance $1215 m0 *1 174.23,114.8
X$1215 6701 6932 112 113 7921 NAND2_X1
* cell instance $1216 m0 *1 174.8,114.8
X$1216 7827 7922 112 113 7862 NAND2_X1
* cell instance $1220 r0 *1 170.62,114.8
X$1220 7596 8158 112 113 7380 NAND2_X1
* cell instance $1221 r0 *1 171.19,114.8
X$1221 7920 4763 113 6405 112 XOR2_X2
* cell instance $1222 r0 *1 172.9,114.8
X$1222 7827 113 6081 112 BUF_X4
* cell instance $1223 r0 *1 174.23,114.8
X$1223 6254 8156 7921 112 8157 113 AOI21_X1
* cell instance $1224 r0 *1 174.99,114.8
X$1224 8218 7862 6650 113 8154 112 OAI21_X1
* cell instance $1225 r0 *1 175.75,114.8
X$1225 7923 6934 112 113 6344 NOR2_X1
* cell instance $1229 r0 *1 177.65,114.8
X$1229 112 7593 8148 113 BUF_X32
* cell instance $1233 m0 *1 180.5,114.8
X$1233 7979 7150 112 113 7924 XNOR2_X2
* cell instance $1235 m0 *1 182.4,114.8
X$1235 8385 7368 112 113 7979 XNOR2_X2
* cell instance $1236 m0 *1 184.3,114.8
X$1236 6164 6186 113 7671 112 XOR2_X2
* cell instance $1237 m0 *1 186.01,114.8
X$1237 7672 7858 7670 112 7857 113 AOI21_X2
* cell instance $1239 r0 *1 186.96,114.8
X$1239 8146 8057 7925 112 7855 113 AOI21_X2
* cell instance $1241 m0 *1 187.72,114.8
X$1241 7856 7590 112 113 7926 XOR2_X1
* cell instance $1242 r0 *1 188.29,114.8
X$1242 7926 8142 7830 112 7927 113 AOI21_X2
* cell instance $1243 m0 *1 190,114.8
X$1243 7673 7854 112 113 8142 NAND2_X1
* cell instance $1244 m0 *1 189.24,114.8
X$1244 7928 5928 7156 112 113 7830 NAND3_X1
* cell instance $1245 m0 *1 190.57,114.8
X$1245 7673 7928 112 113 7925 NAND2_X1
* cell instance $1247 m0 *1 191.9,114.8
X$1247 7974 7976 7853 113 7929 112 OAI21_X1
* cell instance $1250 m0 *1 195.89,114.8
X$1250 7458 4814 113 112 7973 XNOR2_X1
* cell instance $1252 r0 *1 189.62,114.8
X$1252 6553 112 113 7928 BUF_X2
* cell instance $1253 r0 *1 190.38,114.8
X$1253 8058 4410 113 112 7976 XNOR2_X1
* cell instance $1254 r0 *1 191.52,114.8
X$1254 112 16939 8137 7929 6705 113 DFF_X1
* cell instance $1255 r0 *1 194.75,114.8
X$1255 8137 112 113 7156 CLKBUF_X3
* cell instance $1256 r0 *1 195.7,114.8
X$1256 7675 5649 112 113 7458 XNOR2_X2
* cell instance $1257 m0 *1 197.6,114.8
X$1257 7950 7930 112 113 7853 NAND2_X1
* cell instance $1261 r0 *1 197.98,114.8
X$1261 112 16974 8134 8135 8221 113 DFF_X1
* cell instance $1263 m0 *1 198.55,114.8
X$1263 7974 7973 7972 113 8135 112 OAI21_X1
* cell instance $1266 m0 *1 200.45,114.8
X$1266 7699 7930 112 113 7972 NAND2_X1
* cell instance $1268 r0 *1 201.21,114.8
X$1268 8134 112 113 5649 BUF_X2
* cell instance $1269 r0 *1 201.97,114.8
X$1269 7856 112 113 7931 BUF_X1
* cell instance $1270 m0 *1 202.35,114.8
X$1270 7931 7426 113 7063 112 XOR2_X2
* cell instance $1274 m0 *1 205.77,114.8
X$1274 112 6006 113 7831 BUF_X8
* cell instance $1275 m0 *1 208.24,114.8
X$1275 5867 113 7832 112 BUF_X4
* cell instance $1276 m0 *1 209.57,114.8
X$1276 5767 7547 112 113 6329 NAND2_X2
* cell instance $1277 m0 *1 210.52,114.8
X$1277 7832 7932 6839 113 7093 112 OAI21_X1
* cell instance $1279 m0 *1 211.47,114.8
X$1279 5767 7452 113 112 7833 AND2_X1
* cell instance $1280 m0 *1 212.23,114.8
X$1280 6001 6175 7833 112 6875 113 AOI21_X1
* cell instance $1282 m0 *1 213.18,114.8
X$1282 6175 6564 112 113 7834 NAND2_X1
* cell instance $1284 m0 *1 213.94,114.8
X$1284 7834 7835 7298 6827 6745 112 113 7676 AOI221_X1
* cell instance $1285 m0 *1 215.08,114.8
X$1285 7934 7835 7834 112 7327 113 AOI21_X1
* cell instance $1286 m0 *1 215.84,114.8
X$1286 7835 6562 112 113 7935 NOR2_X1
* cell instance $1290 r0 *1 203.11,114.8
X$1290 4841 112 113 7043 CLKBUF_X3
* cell instance $1291 r0 *1 204.06,114.8
X$1291 7043 112 113 17191 INV_X2
* cell instance $1294 r0 *1 205.58,114.8
X$1294 112 6564 113 7547 BUF_X8
* cell instance $1295 r0 *1 208.05,114.8
X$1295 5867 7831 5865 112 8132 113 AOI21_X1
* cell instance $1297 r0 *1 209.19,114.8
X$1297 5767 7547 112 113 8061 NOR2_X2
* cell instance $1298 r0 *1 210.14,114.8
X$1298 7094 112 113 8062 INV_X1
* cell instance $1300 r0 *1 210.71,114.8
X$1300 7298 7094 6745 112 7968 113 AOI21_X2
* cell instance $1301 r0 *1 212.04,114.8
X$1301 7340 6175 112 113 7933 NAND2_X1
* cell instance $1302 r0 *1 212.61,114.8
X$1302 6167 6827 112 113 7932 NOR2_X1
* cell instance $1304 r0 *1 213.94,114.8
X$1304 6167 6006 6278 112 8063 113 AOI21_X2
* cell instance $1305 r0 *1 215.27,114.8
X$1305 7932 6026 7325 112 113 8114 NOR3_X1
* cell instance $1306 r0 *1 216.03,114.8
X$1306 8114 7935 7548 112 113 7936 NOR3_X1
* cell instance $1307 r0 *1 216.79,114.8
X$1307 7962 8111 7428 112 113 7963 NOR3_X1
* cell instance $1309 m0 *1 216.79,114.8
X$1309 7963 6952 7937 112 7849 113 AOI21_X1
* cell instance $1311 m0 *1 194.94,25.2
X$1311 400 544 112 113 486 NAND2_X2
* cell instance $1322 r0 *1 194.75,25.2
X$1322 545 677 112 113 607 OR2_X1
* cell instance $1338 m0 *1 97.28,53.2
X$1338 794 1392 112 113 1913 NAND2_X2
* cell instance $1340 m0 *1 98.23,53.2
X$1340 2429 1242 112 113 2451 NAND2_X1
* cell instance $1342 m0 *1 98.99,53.2
X$1342 1530 1429 112 113 2018 NAND2_X1
* cell instance $1344 m0 *1 100.32,53.2
X$1344 1805 1539 1741 112 113 2336 NAND3_X1
* cell instance $1345 m0 *1 101.08,53.2
X$1345 2453 872 2527 112 2088 113 AOI21_X1
* cell instance $1347 m0 *1 102.03,53.2
X$1347 1278 1429 112 113 2436 NOR2_X1
* cell instance $1349 m0 *1 102.79,53.2
X$1349 474 112 113 1541 CLKBUF_X3
* cell instance $1350 m0 *1 103.74,53.2
X$1350 2335 2436 2454 113 2434 112 OAI21_X1
* cell instance $1351 m0 *1 104.5,53.2
X$1351 2433 1045 1830 112 113 2337 NAND3_X1
* cell instance $1353 r0 *1 97.09,53.2
X$1353 2331 1541 112 113 2525 NAND2_X1
* cell instance $1354 r0 *1 97.66,53.2
X$1354 2451 2452 2450 2525 113 112 2666 OAI22_X1
* cell instance $1355 r0 *1 98.61,53.2
X$1355 2018 1913 1732 112 113 2552 NAND3_X1
* cell instance $1356 r0 *1 99.37,53.2
X$1356 264 306 112 113 2747 NAND2_X1
* cell instance $1358 r0 *1 100.32,53.2
X$1358 794 641 112 113 2553 NAND2_X1
* cell instance $1360 r0 *1 101.08,53.2
X$1360 946 1539 2553 112 2453 113 AOI21_X1
* cell instance $1362 r0 *1 102.6,53.2
X$1362 1361 112 113 1355 CLKBUF_X3
* cell instance $1363 r0 *1 103.55,53.2
X$1363 611 943 112 113 2554 NOR2_X1
* cell instance $1364 r0 *1 104.12,53.2
X$1364 2554 715 1732 112 113 2529 NOR3_X1
* cell instance $1365 r0 *1 104.88,53.2
X$1365 1355 2434 2337 112 2555 113 AOI21_X1
* cell instance $1366 m0 *1 107.35,53.2
X$1366 950 112 113 1830 CLKBUF_X3
* cell instance $1367 m0 *1 105.64,53.2
X$1367 1329 1045 1043 2338 2452 113 112 AOI211_X2
* cell instance $1371 r0 *1 105.64,53.2
X$1371 2337 2336 1802 112 2556 113 AOI21_X1
* cell instance $1372 r0 *1 106.4,53.2
X$1372 2529 2455 1361 113 2752 112 OAI21_X1
* cell instance $1374 r0 *1 107.35,53.2
X$1374 1732 1007 113 112 2455 AND2_X1
* cell instance $1376 m0 *1 112.67,53.2
X$1376 112 2309 568 113 BUF_X16
* cell instance $1381 r0 *1 115.14,53.2
X$1381 530 1440 1439 113 112 927 OAI21_X4
* cell instance $1382 r0 *1 117.61,53.2
X$1382 2240 530 570 112 113 NOR2_X4
* cell instance $1383 m0 *1 118.94,53.2
X$1383 2239 113 529 112 BUF_X4
* cell instance $1384 m0 *1 117.8,53.2
X$1384 2340 1416 2456 1922 2430 112 113 2342 AOI221_X1
* cell instance $1386 m0 *1 120.46,53.2
X$1386 1896 1831 651 112 113 1416 NAND3_X2
* cell instance $1387 m0 *1 121.79,53.2
X$1387 2242 2341 2648 2343 2532 1503 113 112 AOI221_X2
* cell instance $1389 m0 *1 124.07,53.2
X$1389 1455 2457 112 113 2345 NOR2_X1
* cell instance $1390 m0 *1 124.64,53.2
X$1390 880 776 112 113 1290 NAND2_X2
* cell instance $1393 r0 *1 119.7,53.2
X$1393 112 1098 530 1896 1831 113 AOI21_X4
* cell instance $1394 r0 *1 122.17,53.2
X$1394 952 1282 1552 112 2533 113 AOI21_X1
* cell instance $1395 r0 *1 122.93,53.2
X$1395 112 1504 113 2309 BUF_X8
* cell instance $1399 r0 *1 125.4,53.2
X$1399 1653 1504 112 113 1844 NOR2_X2
* cell instance $1400 m0 *1 126.54,53.2
X$1400 2344 2345 2456 1653 709 112 113 2531 AOI221_X1
* cell instance $1401 m0 *1 125.97,53.2
X$1401 2089 2210 112 113 2650 NAND2_X1
* cell instance $1403 m0 *1 127.87,53.2
X$1403 2531 1627 1409 112 113 2532 NOR3_X1
* cell instance $1405 m0 *1 128.82,53.2
X$1405 2339 2651 2078 1204 2422 112 113 2652 AOI221_X1
* cell instance $1406 m0 *1 129.96,53.2
X$1406 1711 2423 1098 2302 113 112 2422 OAI22_X1
* cell instance $1407 m0 *1 130.91,53.2
X$1407 2457 571 112 113 1711 NOR2_X1
* cell instance $1409 m0 *1 131.67,53.2
X$1409 1047 2530 2215 113 2458 112 OAI21_X1
* cell instance $1410 m0 *1 132.43,53.2
X$1410 2297 2344 2345 112 2530 113 AOI21_X1
* cell instance $1412 m0 *1 133.95,53.2
X$1412 880 593 112 113 2528 NAND2_X1
* cell instance $1413 m0 *1 134.52,53.2
X$1413 2079 1109 112 113 2419 NOR2_X1
* cell instance $1416 r0 *1 126.54,53.2
X$1416 112 1504 571 113 INV_X16
* cell instance $1419 r0 *1 130.15,53.2
X$1419 776 2121 112 113 2078 NAND2_X1
* cell instance $1421 r0 *1 131.1,53.2
X$1421 1099 2421 2123 2458 2563 113 112 3107 OAI221_X1
* cell instance $1422 r0 *1 132.24,53.2
X$1422 730 651 112 113 2558 NOR2_X1
* cell instance $1426 m0 *1 33.06,148.4
X$1426 10546 112 113 10545 BUF_X2
* cell instance $1428 m0 *1 33.82,148.4
X$1428 10546 112 113 10736 BUF_X2
* cell instance $1429 m0 *1 34.58,148.4
X$1429 10640 113 10741 112 BUF_X4
* cell instance $1431 m0 *1 36.1,148.4
X$1431 10545 113 10222 112 BUF_X4
* cell instance $1432 m0 *1 37.43,148.4
X$1432 10316 113 10452 112 BUF_X4
* cell instance $1433 m0 *1 38.76,148.4
X$1433 10619 113 10630 112 BUF_X4
* cell instance $1434 m0 *1 40.09,148.4
X$1434 10739 10740 10678 112 10877 113 AOI21_X1
* cell instance $1435 m0 *1 40.85,148.4
X$1435 9950 113 10453 112 BUF_X4
* cell instance $1436 m0 *1 42.18,148.4
X$1436 10619 112 113 10105 INV_X1
* cell instance $1437 m0 *1 42.56,148.4
X$1437 10677 10400 10549 113 112 10744 OAI21_X4
* cell instance $1439 m0 *1 45.22,148.4
X$1439 10550 10228 113 10551 112 AND2_X4
* cell instance $1440 m0 *1 46.93,148.4
X$1440 10748 10622 10645 10227 10513 10679 113 112 AOI221_X2
* cell instance $1441 m0 *1 49.02,148.4
X$1441 10551 10317 10553 10630 10554 112 113 10680 AOI221_X1
* cell instance $1442 m0 *1 50.16,148.4
X$1442 10400 10108 10105 10554 112 113 10746 AOI22_X1
* cell instance $1443 m0 *1 51.11,148.4
X$1443 10228 10511 10748 112 113 NOR2_X4
* cell instance $1444 m0 *1 52.82,148.4
X$1444 10636 10682 10555 112 113 10895 MUX2_X1
* cell instance $1445 m0 *1 54.15,148.4
X$1445 10225 10461 10681 10231 10556 113 112 10636 OAI221_X1
* cell instance $1447 m0 *1 55.48,148.4
X$1447 10553 113 10682 112 BUF_X4
* cell instance $1448 m0 *1 56.81,148.4
X$1448 10228 113 10640 112 BUF_X4
* cell instance $1449 m0 *1 58.14,148.4
X$1449 10326 10284 112 113 10752 NOR2_X2
* cell instance $1452 r0 *1 33.06,148.4
X$1452 112 10794 113 10736 BUF_X8
* cell instance $1453 r0 *1 35.53,148.4
X$1453 10547 9867 10026 113 112 10677 OAI21_X4
* cell instance $1454 r0 *1 38,148.4
X$1454 10645 10225 112 113 10875 NOR2_X2
* cell instance $1455 r0 *1 38.95,148.4
X$1455 10645 112 113 10798 CLKBUF_X3
* cell instance $1456 r0 *1 39.9,148.4
X$1456 10645 113 10797 112 BUF_X4
* cell instance $1457 r0 *1 41.23,148.4
X$1457 10401 10107 113 112 10552 XNOR2_X1
* cell instance $1458 r0 *1 42.37,148.4
X$1458 10548 10551 10463 10456 10455 112 113 10879 AOI221_X1
* cell instance $1460 r0 *1 43.89,148.4
X$1460 10554 10104 10645 10640 10744 10801 113 112 AOI221_X2
* cell instance $1461 r0 *1 45.98,148.4
X$1461 10224 112 113 10394 BUF_X2
* cell instance $1462 r0 *1 46.74,148.4
X$1462 10628 10456 10320 10454 10803 10887 113 112 AOI221_X2
* cell instance $1463 r0 *1 48.83,148.4
X$1463 10888 112 113 10319 INV_X4
* cell instance $1464 r0 *1 49.78,148.4
X$1464 10315 10513 10749 113 10890 112 OAI21_X1
* cell instance $1465 r0 *1 50.54,148.4
X$1465 10458 10891 10320 10547 10554 10459 113 112 AOI221_X2
* cell instance $1467 r0 *1 52.82,148.4
X$1467 10752 10227 10645 10512 10804 10985 113 112 AOI221_X2
* cell instance $1468 r0 *1 54.91,148.4
X$1468 10284 113 11196 112 BUF_X4
* cell instance $1469 r0 *1 56.24,148.4
X$1469 10683 10684 10741 112 113 10805 NAND3_X1
* cell instance $1470 r0 *1 57,148.4
X$1470 10557 112 113 11060 CLKBUF_X3
* cell instance $1472 r0 *1 58.33,148.4
X$1472 10320 113 10684 112 BUF_X4
* cell instance $1474 m0 *1 59.47,148.4
X$1474 9865 113 11393 112 BUF_X4
* cell instance $1477 r0 *1 59.66,148.4
X$1477 9865 112 113 10888 BUF_X1
* cell instance $1479 r0 *1 60.99,148.4
X$1479 112 10684 10892 10039 11199 113 NOR3_X4
* cell instance $1480 m0 *1 63.65,148.4
X$1480 10558 10462 10523 112 113 10685 OR3_X4
* cell instance $1482 m0 *1 65.74,148.4
X$1482 112 10807 10104 10560 10559 113 AOI21_X4
* cell instance $1483 m0 *1 68.21,148.4
X$1483 10676 7738 10686 112 113 10644 NAND3_X1
* cell instance $1484 m0 *1 68.97,148.4
X$1484 10759 5250 9419 112 113 10763 NAND3_X1
* cell instance $1485 m0 *1 69.73,148.4
X$1485 10763 10759 10762 113 112 10643 OAI21_X4
* cell instance $1486 m0 *1 72.2,148.4
X$1486 112 10331 10332 10561 10764 113 NOR3_X4
* cell instance $1487 m0 *1 74.86,148.4
X$1487 10331 10332 10561 112 113 10765 OR3_X2
* cell instance $1488 m0 *1 76,148.4
X$1488 10690 112 113 8620 CLKBUF_X3
* cell instance $1491 r0 *1 63.65,148.4
X$1491 10685 113 10795 112 BUF_X4
* cell instance $1494 r0 *1 65.55,148.4
X$1494 10104 10225 10643 10654 13068 112 113 OAI211_X2
* cell instance $1495 r0 *1 67.26,148.4
X$1495 10792 9800 4163 113 112 10808 MUX2_X2
* cell instance $1499 r0 *1 68.97,148.4
X$1499 10644 10676 10688 113 112 10906 OAI21_X4
* cell instance $1501 r0 *1 71.63,148.4
X$1501 8994 112 113 10686 INV_X1
* cell instance $1502 r0 *1 72.01,148.4
X$1502 3672 10686 112 113 10909 NOR2_X1
* cell instance $1504 r0 *1 72.77,148.4
X$1504 3672 8994 112 113 10907 NOR2_X1
* cell instance $1507 r0 *1 73.91,148.4
X$1507 112 10766 8941 17263 8857 113 DFF_X2
* cell instance $1510 m0 *1 78.09,148.4
X$1510 10767 112 113 8762 BUF_X2
* cell instance $1512 m0 *1 79.61,148.4
X$1512 112 10768 10769 7738 10913 10464 113 OAI211_X4
* cell instance $1513 m0 *1 79.23,148.4
X$1513 10562 112 113 10768 INV_X1
* cell instance $1516 m0 *1 83.79,148.4
X$1516 8403 10530 112 113 10564 NAND2_X1
* cell instance $1517 m0 *1 84.36,148.4
X$1517 9181 112 113 10691 BUF_X2
* cell instance $1518 m0 *1 85.12,148.4
X$1518 8434 10530 112 113 10762 NAND2_X1
* cell instance $1519 m0 *1 85.69,148.4
X$1519 10691 6239 113 10772 112 AND2_X4
* cell instance $1520 m0 *1 87.4,148.4
X$1520 112 10334 10565 10772 10566 11070 113 NOR4_X4
* cell instance $1523 m0 *1 91.77,148.4
X$1523 10566 113 10692 112 BUF_X4
* cell instance $1526 m0 *1 96.9,148.4
X$1526 10567 112 113 8729 CLKBUF_X3
* cell instance $1530 r0 *1 79.61,148.4
X$1530 4678 8994 112 113 10688 NAND2_X1
* cell instance $1531 r0 *1 80.18,148.4
X$1531 10295 4678 112 113 10769 NAND2_X1
* cell instance $1532 r0 *1 80.75,148.4
X$1532 10689 4678 112 113 10915 NAND2_X1
* cell instance $1534 r0 *1 81.51,148.4
X$1534 10295 112 113 10689 INV_X1
* cell instance $1536 r0 *1 82.08,148.4
X$1536 10689 7362 112 113 10917 NOR2_X1
* cell instance $1540 r0 *1 83.98,148.4
X$1540 9956 6773 9337 112 113 10920 OR3_X2
* cell instance $1543 r0 *1 86.07,148.4
X$1543 9114 6239 112 113 10922 NAND2_X2
* cell instance $1545 r0 *1 87.21,148.4
X$1545 112 10692 10812 10923 10926 10334 113 OAI22_X4
* cell instance $1546 r0 *1 90.44,148.4
X$1546 10565 112 113 10923 BUF_X1
* cell instance $1547 r0 *1 91.01,148.4
X$1547 112 10692 10812 9871 11411 10927 113 OAI22_X4
* cell instance $1551 r0 *1 96.9,148.4
X$1551 5120 113 3989 112 BUF_X4
* cell instance $1554 m0 *1 99.75,148.4
X$1554 112 16728 10690 10779 9870 113 DFF_X1
* cell instance $1559 r0 *1 105.64,148.4
X$1559 10122 11229 10932 10931 112 113 10779 NAND4_X1
* cell instance $1560 m0 *1 106.59,148.4
X$1560 10784 10814 10782 112 113 10123 MUX2_X1
* cell instance $1565 r0 *1 106.78,148.4
X$1565 10815 9971 10693 112 10694 113 AOI21_X1
* cell instance $1566 r0 *1 107.54,148.4
X$1566 10702 10781 10571 112 10540 113 AOI21_X1
* cell instance $1568 r0 *1 108.68,148.4
X$1568 10935 10781 112 113 10693 NAND2_X1
* cell instance $1570 m0 *1 109.06,148.4
X$1570 10446 9734 10305 112 10784 113 AOI21_X1
* cell instance $1571 m0 *1 110.58,148.4
X$1571 10466 10786 10785 113 10469 112 OAI21_X1
* cell instance $1572 m0 *1 111.34,148.4
X$1572 10665 10569 112 113 10664 OR2_X1
* cell instance $1574 r0 *1 109.25,148.4
X$1574 10304 10788 10068 113 10935 112 OAI21_X1
* cell instance $1576 r0 *1 110.39,148.4
X$1576 9964 10696 10342 10213 112 113 10785 NAND4_X1
* cell instance $1579 m0 *1 57,89.6
X$1579 5691 5616 4141 5226 112 113 5469 NAND4_X1
* cell instance $1580 m0 *1 56.24,89.6
X$1580 5690 4525 3762 112 113 5691 NAND3_X1
* cell instance $1584 m0 *1 60.42,89.6
X$1584 5527 112 113 5370 INV_X1
* cell instance $1585 m0 *1 60.8,89.6
X$1585 5527 113 4081 112 BUF_X4
* cell instance $1587 m0 *1 65.17,89.6
X$1587 5692 113 5273 112 BUF_X4
* cell instance $1588 m0 *1 66.5,89.6
X$1588 5828 4796 5149 113 112 5484 OAI21_X4
* cell instance $1589 m0 *1 68.97,89.6
X$1589 5528 113 4796 112 BUF_X4
* cell instance $1591 m0 *1 53.39,89.6
X$1591 4141 5523 5595 113 5591 112 OAI21_X1
* cell instance $1593 m0 *1 54.15,89.6
X$1593 4616 4619 4141 3762 5525 113 112 5595 OAI221_X1
* cell instance $1594 m0 *1 55.29,89.6
X$1594 3855 5526 112 113 5690 NAND2_X1
* cell instance $1596 r0 *1 53.2,89.6
X$1596 3863 4067 4613 112 5736 113 AOI21_X1
* cell instance $1601 r0 *1 64.98,89.6
X$1601 4796 5149 5619 113 5475 112 OAI21_X1
* cell instance $1602 r0 *1 65.74,89.6
X$1602 5473 4031 113 5670 112 XOR2_X2
* cell instance $1603 r0 *1 67.45,89.6
X$1603 4480 5620 112 113 5804 NOR2_X1
* cell instance $1607 r0 *1 68.02,89.6
X$1607 5911 4629 5697 112 113 5812 MUX2_X1
* cell instance $1609 r0 *1 69.73,89.6
X$1609 4482 4796 5149 113 112 5706 OAI21_X4
* cell instance $1610 m0 *1 71.63,89.6
X$1610 5528 5621 5376 113 5372 112 NOR3_X2
* cell instance $1611 m0 *1 70.68,89.6
X$1611 5372 4480 112 113 5695 NOR2_X2
* cell instance $1613 r0 *1 72.2,89.6
X$1613 5540 4634 4899 112 113 5530 NOR3_X1
* cell instance $1614 r0 *1 72.96,89.6
X$1614 4260 5701 5532 4981 112 113 5729 AOI22_X2
* cell instance $1615 m0 *1 74.1,89.6
X$1615 4156 5700 112 113 5704 NOR2_X2
* cell instance $1616 m0 *1 73.34,89.6
X$1616 4200 4197 5532 113 5622 112 OAI21_X1
* cell instance $1617 m0 *1 75.05,89.6
X$1617 112 4900 4636 4307 5700 113 NOR3_X4
* cell instance $1618 m0 *1 77.71,89.6
X$1618 4253 5533 5274 4195 113 112 5703 OAI22_X1
* cell instance $1619 m0 *1 78.66,89.6
X$1619 3871 4976 112 113 5624 NAND2_X1
* cell instance $1620 m0 *1 79.23,89.6
X$1620 4899 4089 5709 5274 4987 5599 112 113 OAI221_X2
* cell instance $1622 r0 *1 74.67,89.6
X$1622 112 4976 113 4085 BUF_X8
* cell instance $1623 r0 *1 77.14,89.6
X$1623 5704 5622 4196 4800 5703 5707 113 112 AOI221_X2
* cell instance $1624 r0 *1 79.23,89.6
X$1624 5353 5377 5707 113 5623 112 NOR3_X2
* cell instance $1626 r0 *1 80.75,89.6
X$1626 5377 5816 5100 112 113 5817 OR3_X2
* cell instance $1627 m0 *1 82.65,89.6
X$1627 5011 5534 5536 3986 5718 4382 112 113 OAI221_X2
* cell instance $1628 m0 *1 81.7,89.6
X$1628 5533 4976 112 113 5535 NAND2_X2
* cell instance $1629 m0 *1 84.74,89.6
X$1629 5537 4259 5091 113 112 5738 OAI21_X4
* cell instance $1630 m0 *1 87.21,89.6
X$1630 5534 4315 5014 4083 4260 113 112 5628 OAI221_X1
* cell instance $1631 m0 *1 88.35,89.6
X$1631 112 4803 113 4200 BUF_X8
* cell instance $1632 m0 *1 90.82,89.6
X$1632 4880 3988 4088 112 113 5723 MUX2_X1
* cell instance $1633 m0 *1 92.15,89.6
X$1633 4260 5723 5535 5384 112 113 5625 AOI22_X1
* cell instance $1634 m0 *1 93.1,89.6
X$1634 5375 4642 5625 112 5629 113 AOI21_X1
* cell instance $1635 m0 *1 93.86,89.6
X$1635 5159 4253 112 113 5627 NOR2_X1
* cell instance $1637 m0 *1 94.62,89.6
X$1637 4491 4430 112 113 5386 NAND2_X1
* cell instance $1638 m0 *1 95.19,89.6
X$1638 5542 5695 4606 4026 4640 5728 113 112 AOI221_X2
* cell instance $1639 m0 *1 97.28,89.6
X$1639 5728 5388 5543 112 5285 113 AOI21_X1
* cell instance $1642 m0 *1 98.99,89.6
X$1642 4492 5748 5628 113 112 5730 AND3_X1
* cell instance $1643 m0 *1 99.94,89.6
X$1643 4425 4095 4380 113 5597 112 OAI21_X1
* cell instance $1646 r0 *1 81.89,89.6
X$1646 3987 5359 5624 4745 4537 5819 112 113 OAI221_X2
* cell instance $1647 r0 *1 83.98,89.6
X$1647 5714 4732 3922 112 5716 113 AOI21_X1
* cell instance $1648 r0 *1 84.74,89.6
X$1648 4368 4083 5716 4029 3987 5815 112 113 OAI221_X2
* cell instance $1649 r0 *1 86.83,89.6
X$1649 4194 112 113 4880 BUF_X2
* cell instance $1650 r0 *1 87.59,89.6
X$1650 4748 3871 5090 113 5935 112 OAI21_X1
* cell instance $1651 r0 *1 88.35,89.6
X$1651 4424 5743 112 113 5718 NOR2_X1
* cell instance $1652 r0 *1 88.92,89.6
X$1652 5601 5539 4492 113 5818 112 OAI21_X1
* cell instance $1656 r0 *1 91.01,89.6
X$1656 5724 5718 5722 112 5383 113 AOI21_X2
* cell instance $1657 r0 *1 92.34,89.6
X$1657 4253 5626 4811 5535 5627 5724 113 112 AOI221_X2
* cell instance $1658 r0 *1 94.43,89.6
X$1658 5745 5630 5629 112 5631 113 AOI21_X1
* cell instance $1659 r0 *1 95.19,89.6
X$1659 5746 5016 4639 112 5814 113 AOI21_X1
* cell instance $1660 r0 *1 95.95,89.6
X$1660 4157 5542 5386 112 5813 113 AOI21_X1
* cell instance $1661 r0 *1 96.71,89.6
X$1661 5626 4157 112 113 5809 NOR2_X1
* cell instance $1663 r0 *1 98.04,89.6
X$1663 5747 5623 5631 5810 113 5727 112 NOR4_X2
* cell instance $1666 r0 *1 100.32,89.6
X$1666 5729 4492 4871 5809 5597 113 112 5630 OAI221_X1
* cell instance $1668 m0 *1 102.03,89.6
X$1668 5596 3928 5837 112 5527 113 AOI21_X2
* cell instance $1674 r0 *1 103.55,89.6
X$1674 112 17104 5725 5727 5751 113 DFF_X1
* cell instance $1675 m0 *1 108.87,89.6
X$1675 3579 5633 112 113 5165 XOR2_X1
* cell instance $1676 m0 *1 105.26,89.6
X$1676 112 5726 5288 17224 5554 113 DFF_X2
* cell instance $1677 m0 *1 110.01,89.6
X$1677 3118 5752 113 112 5391 XNOR2_X1
* cell instance $1681 r0 *1 108.3,89.6
X$1681 5273 5633 112 113 5806 XOR2_X1
* cell instance $1683 r0 *1 109.82,89.6
X$1683 3118 5806 113 112 5807 XNOR2_X1
* cell instance $1684 r0 *1 110.96,89.6
X$1684 5725 112 113 3643 CLKBUF_X3
* cell instance $1686 m0 *1 113.24,89.6
X$1686 5288 112 113 16472 CLKBUF_X1
* cell instance $1687 m0 *1 112.29,89.6
X$1687 4279 112 113 5288 CLKBUF_X3
* cell instance $1692 r0 *1 114,89.6
X$1692 5179 5634 112 113 5635 NAND2_X1
* cell instance $1693 r0 *1 114.57,89.6
X$1693 345 5635 5753 113 5803 112 OAI21_X1
* cell instance $1694 r0 *1 115.33,89.6
X$1694 345 5637 5721 112 113 5753 NAND3_X1
* cell instance $1695 m0 *1 118.94,89.6
X$1695 5719 112 113 4919 CLKBUF_X3
* cell instance $1696 m0 *1 115.71,89.6
X$1696 112 16931 5719 5544 5288 113 DFF_X1
* cell instance $1698 m0 *1 122.93,89.6
X$1698 5172 112 113 5396 INV_X1
* cell instance $1701 m0 *1 124.26,89.6
X$1701 5717 5593 5592 112 5545 113 AOI21_X2
* cell instance $1703 m0 *1 127.11,89.6
X$1703 5712 5348 112 113 5711 NAND2_X1
* cell instance $1704 m0 *1 127.68,89.6
X$1704 112 5023 3015 113 BUF_X16
* cell instance $1705 m0 *1 132.43,89.6
X$1705 4279 112 113 4918 CLKBUF_X3
* cell instance $1707 m0 *1 133.57,89.6
X$1707 4918 112 113 17196 INV_X1
* cell instance $1708 m0 *1 133.95,89.6
X$1708 5640 4545 112 113 5548 XOR2_X1
* cell instance $1709 m0 *1 135.09,89.6
X$1709 5549 5402 5711 112 5400 113 AOI21_X1
* cell instance $1710 m0 *1 135.85,89.6
X$1710 5295 3373 112 113 5756 XNOR2_X2
* cell instance $1714 r0 *1 116.09,89.6
X$1714 5634 112 113 5721 INV_X1
* cell instance $1716 r0 *1 117.23,89.6
X$1716 112 17095 5720 5636 4652 113 DFF_X1
* cell instance $1717 r0 *1 120.46,89.6
X$1717 5720 112 113 3573 CLKBUF_X3
* cell instance $1719 r0 *1 121.6,89.6
X$1719 5638 5634 113 215 112 XOR2_X2
* cell instance $1721 r0 *1 123.69,89.6
X$1721 5638 5755 112 113 5717 XOR2_X1
* cell instance $1725 r0 *1 124.83,89.6
X$1725 5638 5755 113 112 5292 XNOR2_X1
* cell instance $1728 r0 *1 126.54,89.6
X$1728 5241 4510 113 5754 112 XOR2_X2
* cell instance $1729 r0 *1 128.25,89.6
X$1729 5712 5028 112 113 5715 NAND2_X1
* cell instance $1730 r0 *1 128.82,89.6
X$1730 5713 5801 113 112 5496 XNOR2_X1
* cell instance $1732 r0 *1 130.15,89.6
X$1732 3881 5844 113 112 5800 XNOR2_X1
* cell instance $1733 r0 *1 131.29,89.6
X$1733 5639 112 113 5713 BUF_X1
* cell instance $1735 r0 *1 132.24,89.6
X$1735 5639 3881 112 113 5843 XNOR2_X2
* cell instance $1736 r0 *1 134.14,89.6
X$1736 5639 113 5640 112 BUF_X4
* cell instance $1737 r0 *1 135.47,89.6
X$1737 5640 5922 113 112 5549 XNOR2_X1
* cell instance $1741 r0 *1 138.7,89.6
X$1741 5757 4966 113 112 5797 XNOR2_X1
* cell instance $1743 r0 *1 140.6,89.6
X$1743 5641 5708 5785 112 5710 113 AOI21_X1
* cell instance $1745 m0 *1 142.12,89.6
X$1745 132 3783 112 113 5641 NOR2_X1
* cell instance $1749 r0 *1 142.5,89.6
X$1749 5642 5797 112 113 5705 XNOR2_X2
* cell instance $1751 m0 *1 143.07,89.6
X$1751 5121 3747 113 112 5585 XNOR2_X1
* cell instance $1752 m0 *1 144.4,89.6
X$1752 5643 5585 113 112 5551 XNOR2_X1
* cell instance $1753 m0 *1 145.54,89.6
X$1753 5705 5551 112 113 5584 XNOR2_X2
* cell instance $1756 m0 *1 149.72,89.6
X$1756 2763 112 113 5583 BUF_X1
* cell instance $1760 r0 *1 148.96,89.6
X$1760 112 17068 5702 5796 5297 113 DFF_X1
* cell instance $1761 m0 *1 151.62,89.6
X$1761 5297 112 113 17166 INV_X2
* cell instance $1762 m0 *1 150.67,89.6
X$1762 401 112 113 5297 CLKBUF_X3
* cell instance $1765 m0 *1 153.9,89.6
X$1765 5645 112 113 5643 CLKBUF_X3
* cell instance $1766 m0 *1 154.85,89.6
X$1766 5581 112 113 3531 BUF_X2
* cell instance $1770 m0 *1 158.08,89.6
X$1770 112 16753 5581 5698 5297 113 DFF_X1
* cell instance $1771 m0 *1 161.31,89.6
X$1771 4659 4654 113 112 5644 XNOR2_X1
* cell instance $1774 r0 *1 152.19,89.6
X$1774 5702 112 113 4966 BUF_X2
* cell instance $1776 r0 *1 153.71,89.6
X$1776 5699 112 113 3736 CLKBUF_X3
* cell instance $1777 r0 *1 154.66,89.6
X$1777 112 17122 5699 5795 5297 113 DFF_X1
* cell instance $1780 r0 *1 159.03,89.6
X$1780 4048 5582 112 113 5224 OR2_X2
* cell instance $1782 m0 *1 163.78,89.6
X$1782 5410 5552 112 113 5553 NOR2_X1
* cell instance $1784 m0 *1 164.35,89.6
X$1784 3087 5553 5696 5411 5412 113 112 5694 OAI221_X1
* cell instance $1787 m0 *1 167.2,89.6
X$1787 112 16754 5645 1609 5758 113 DFF_X1
* cell instance $1791 m0 *1 172.9,89.6
X$1791 112 4163 113 4950 BUF_X8
* cell instance $1792 m0 *1 175.37,89.6
X$1792 112 16884 5693 3894 4554 113 DFF_X1
* cell instance $1796 m0 *1 182.59,89.6
X$1796 5554 112 113 6187 BUF_X2
* cell instance $1799 m0 *1 187.91,89.6
X$1799 5194 4817 112 113 5555 NAND2_X1
* cell instance $1800 m0 *1 188.48,89.6
X$1800 5637 4817 112 113 5575 NOR2_X1
* cell instance $1801 m0 *1 189.05,89.6
X$1801 4817 112 113 5556 INV_X1
* cell instance $1802 m0 *1 189.43,89.6
X$1802 5637 5556 112 113 5576 NOR2_X1
* cell instance $1803 m0 *1 190,89.6
X$1803 5559 5179 5556 112 113 4556 NAND3_X2
* cell instance $1804 m0 *1 191.33,89.6
X$1804 5556 6064 5559 112 113 4675 OR3_X2
* cell instance $1809 r0 *1 172.52,89.6
X$1809 5676 4389 5644 112 113 5759 MUX2_X1
* cell instance $1810 r0 *1 173.85,89.6
X$1810 5506 113 5792 112 BUF_X4
* cell instance $1814 r0 *1 176.51,89.6
X$1814 112 5040 5758 17244 5760 113 DFF_X2
* cell instance $1818 r0 *1 180.12,89.6
X$1818 5693 113 5761 112 BUF_X4
* cell instance $1820 r0 *1 184.49,89.6
X$1820 6067 5646 112 113 2690 XNOR2_X2
* cell instance $1821 r0 *1 186.39,89.6
X$1821 5996 5790 113 112 5415 XNOR2_X1
* cell instance $1822 r0 *1 187.53,89.6
X$1822 5414 5789 113 112 5790 XNOR2_X1
* cell instance $1825 r0 *1 189.81,89.6
X$1825 1747 112 113 401 CLKBUF_X3
* cell instance $1827 r0 *1 191.14,89.6
X$1827 5648 3442 113 112 5647 XNOR2_X1
* cell instance $1829 r0 *1 192.47,89.6
X$1829 5648 5763 112 113 5458 XNOR2_X2
* cell instance $1832 m0 *1 194.37,89.6
X$1832 5305 2809 113 5443 112 XOR2_X2
* cell instance $1833 r0 *1 195.13,89.6
X$1833 3643 5648 112 113 5764 XOR2_X1
* cell instance $1836 m0 *1 196.46,89.6
X$1836 5307 5859 112 113 5573 XNOR2_X2
* cell instance $1838 r0 *1 197.41,89.6
X$1838 5399 5649 112 113 5905 NOR2_X1
* cell instance $1840 r0 *1 198.17,89.6
X$1840 5399 5650 112 113 5904 NOR2_X1
* cell instance $1842 m0 *1 201.97,89.6
X$1842 5651 4948 5654 112 113 5688 MUX2_X1
* cell instance $1843 m0 *1 198.74,89.6
X$1843 112 16762 5651 5688 5558 113 DFF_X1
* cell instance $1846 m0 *1 206.53,89.6
X$1846 5559 4948 5674 112 113 5571 MUX2_X1
* cell instance $1847 m0 *1 207.86,89.6
X$1847 5563 5652 112 113 5560 NOR2_X2
* cell instance $1849 m0 *1 209.57,89.6
X$1849 5653 5560 5422 112 113 5655 MUX2_X1
* cell instance $1850 m0 *1 210.9,89.6
X$1850 5560 5561 5866 112 113 NOR2_X4
* cell instance $1851 m0 *1 212.61,89.6
X$1851 5562 5421 5685 112 113 5868 MUX2_X1
* cell instance $1853 m0 *1 214.13,89.6
X$1853 112 5423 5652 5563 5782 113 NOR3_X4
* cell instance $1855 m0 *1 217.55,89.6
X$1855 5198 5563 5652 113 112 5895 OAI21_X4
* cell instance $1856 m0 *1 220.02,89.6
X$1856 5652 113 5659 112 BUF_X4
* cell instance $1858 m0 *1 221.54,89.6
X$1858 5563 113 5660 112 BUF_X4
* cell instance $1861 r0 *1 199.69,89.6
X$1861 5649 112 113 5650 INV_X1
* cell instance $1862 r0 *1 200.07,89.6
X$1862 5651 5250 5650 112 113 5765 NAND3_X2
* cell instance $1863 r0 *1 201.4,89.6
X$1863 5765 5784 112 5563 113 NAND2_X4
* cell instance $1864 r0 *1 203.11,89.6
X$1864 5784 5765 113 112 5766 AND2_X1
* cell instance $1868 r0 *1 208.62,89.6
X$1868 112 5421 5652 5563 5864 113 NOR3_X4
* cell instance $1870 r0 *1 211.47,89.6
X$1870 5420 113 5780 112 BUF_X4
* cell instance $1872 r0 *1 212.99,89.6
X$1872 5561 5656 5783 112 113 NOR2_X4
* cell instance $1873 r0 *1 214.7,89.6
X$1873 112 5657 5652 5563 5658 113 NOR3_X4
* cell instance $1874 r0 *1 217.36,89.6
X$1874 5656 113 5424 112 BUF_X4
* cell instance $1877 r0 *1 219.26,89.6
X$1877 112 5656 5659 5660 5877 113 NOR3_X4
* cell instance $1879 r0 *1 222.11,89.6
X$1879 5867 5660 5659 113 112 5781 OAI21_X4
* cell instance $1880 m0 *1 224.01,89.6
X$1880 5199 112 113 5680 BUF_X1
* cell instance $1881 m0 *1 223.25,89.6
X$1881 5660 5659 5657 113 5874 112 OAI21_X1
* cell instance $1883 m0 *1 224.77,89.6
X$1883 112 5562 113 5199 BUF_X8
* cell instance $1884 m0 *1 227.24,89.6
X$1884 112 5662 5425 113 BUF_X16
* cell instance $1885 m0 *1 231.99,89.6
X$1885 5666 112 113 5206 BUF_X1
* cell instance $1887 m0 *1 232.75,89.6
X$1887 5665 112 113 5674 BUF_X1
* cell instance $1888 m0 *1 233.32,89.6
X$1888 5664 112 113 5654 BUF_X1
* cell instance $1890 m0 *1 234.08,89.6
X$1890 112 16824 5671 5443 5429 113 DFF_X1
* cell instance $1892 m0 *1 237.5,89.6
X$1892 5667 112 113 5448 BUF_X1
* cell instance $1893 m0 *1 238.07,89.6
X$1893 5672 112 113 5566 BUF_X1
* cell instance $1896 r0 *1 224.77,89.6
X$1896 5661 5660 5659 113 112 5870 OAI21_X4
* cell instance $1898 r0 *1 227.62,89.6
X$1898 112 5771 5659 5660 6023 113 NOR3_X4
* cell instance $1899 r0 *1 230.28,89.6
X$1899 5677 5662 112 113 5779 NAND2_X1
* cell instance $1900 r0 *1 230.85,89.6
X$1900 112 5564 113 6006 BUF_X8
* cell instance $1901 r0 *1 233.32,89.6
X$1901 112 16968 5672 5675 5429 113 DFF_X1
* cell instance $1905 r0 *1 236.55,89.6
X$1905 5773 112 113 4035 BUF_X1
* cell instance $1908 m0 *1 46.17,58.8
X$1908 2825 2887 2220 2774 112 113 2888 NAND4_X1
* cell instance $1909 m0 *1 45.6,58.8
X$1909 2935 2886 112 113 2887 NAND2_X1
* cell instance $1910 m0 *1 47.12,58.8
X$1910 112 2888 2656 2938 2988 1769 2830 3094 113 OAI222_X2
* cell instance $1911 m0 *1 49.78,58.8
X$1911 2657 1905 112 113 2889 NOR2_X1
* cell instance $1912 m0 *1 50.35,58.8
X$1912 2774 2270 2890 112 2773 113 AOI21_X1
* cell instance $1913 m0 *1 51.11,58.8
X$1913 2777 1899 2775 112 2939 113 AOI21_X1
* cell instance $1914 m0 *1 51.87,58.8
X$1914 2220 3039 2940 2939 2660 112 113 OAI211_X2
* cell instance $1915 m0 *1 53.58,58.8
X$1915 112 936 1952 113 BUF_X16
* cell instance $1917 m0 *1 58.52,58.8
X$1917 2942 2662 2608 112 2943 113 AOI21_X1
* cell instance $1918 m0 *1 59.28,58.8
X$1918 2947 2892 2317 112 113 2951 NAND3_X1
* cell instance $1921 r0 *1 45.79,58.8
X$1921 2506 1905 112 113 2886 NOR2_X2
* cell instance $1924 r0 *1 47.31,58.8
X$1924 1960 1728 112 113 3135 NOR2_X1
* cell instance $1926 r0 *1 48.07,58.8
X$1926 1946 2989 2994 112 113 2988 NAND3_X1
* cell instance $1928 r0 *1 49.02,58.8
X$1928 1589 1189 3093 112 113 3037 MUX2_X1
* cell instance $1930 r0 *1 50.54,58.8
X$1930 1901 3037 2886 2094 2317 113 112 3041 OAI221_X1
* cell instance $1932 r0 *1 51.87,58.8
X$1932 1187 112 113 3093 INV_X1
* cell instance $1934 r0 *1 52.63,58.8
X$1934 1313 2990 2889 113 3040 112 OAI21_X1
* cell instance $1935 r0 *1 53.39,58.8
X$1935 2104 1639 2317 113 2990 112 OAI21_X1
* cell instance $1936 r0 *1 54.15,58.8
X$1936 3040 2611 3041 112 113 3095 NAND3_X1
* cell instance $1939 r0 *1 55.48,58.8
X$1939 2317 1883 1187 1807 113 112 3140 OAI22_X1
* cell instance $1941 r0 *1 56.62,58.8
X$1941 2944 2217 3043 112 2991 113 AOI21_X1
* cell instance $1942 r0 *1 57.38,58.8
X$1942 2734 2096 1883 112 3043 113 AOI21_X1
* cell instance $1943 r0 *1 58.14,58.8
X$1943 1639 1587 2892 112 2944 113 AOI21_X1
* cell instance $1944 r0 *1 58.9,58.8
X$1944 2834 2006 112 113 2994 NOR2_X1
* cell instance $1945 r0 *1 59.47,58.8
X$1945 1266 1149 112 113 2992 NAND2_X1
* cell instance $1947 r0 *1 60.23,58.8
X$1947 2176 1266 112 113 2993 NOR2_X1
* cell instance $1949 m0 *1 60.42,58.8
X$1949 2784 2104 2780 2658 1728 2778 113 112 AOI221_X2
* cell instance $1950 m0 *1 62.7,58.8
X$1950 2951 2781 113 112 3000 AND2_X1
* cell instance $1952 m0 *1 63.65,58.8
X$1952 2406 1727 2836 2952 2781 3143 113 112 AOI221_X2
* cell instance $1954 r0 *1 60.8,58.8
X$1954 1961 2993 2723 112 3096 113 AOI21_X1
* cell instance $1955 r0 *1 61.56,58.8
X$1955 2776 1901 112 113 2947 NAND2_X1
* cell instance $1958 r0 *1 62.7,58.8
X$1958 3097 2092 112 113 3148 NOR2_X1
* cell instance $1960 r0 *1 63.46,58.8
X$1960 1639 1510 1906 113 112 3236 AND3_X1
* cell instance $1962 r0 *1 64.6,58.8
X$1962 1721 1906 112 113 2995 NAND2_X1
* cell instance $1963 r0 *1 65.17,58.8
X$1963 3098 3047 1645 1899 112 113 2996 NOR4_X1
* cell instance $1964 r0 *1 66.12,58.8
X$1964 1266 2776 112 113 3047 NOR2_X1
* cell instance $1966 m0 *1 66.12,58.8
X$1966 1587 1510 1813 112 113 2953 NAND3_X1
* cell instance $1969 r0 *1 67.26,58.8
X$1969 2996 3153 3151 112 113 2997 NOR3_X1
* cell instance $1971 m0 *1 67.26,58.8
X$1971 2953 1726 1638 1727 112 113 2893 NAND4_X1
* cell instance $1972 m0 *1 68.4,58.8
X$1972 1638 2839 2542 112 2894 113 AOI21_X1
* cell instance $1974 m0 *1 69.35,58.8
X$1974 1115 1960 2954 2104 1677 113 112 2895 OAI221_X1
* cell instance $1975 m0 *1 70.49,58.8
X$1975 2784 1144 112 113 2954 NAND2_X1
* cell instance $1977 m0 *1 71.82,58.8
X$1977 2319 2663 2104 113 2841 112 OAI21_X1
* cell instance $1979 m0 *1 72.77,58.8
X$1979 2783 2539 2834 112 113 2955 NAND3_X1
* cell instance $1980 m0 *1 73.53,58.8
X$1980 2102 1483 112 113 3058 NAND2_X1
* cell instance $1982 m0 *1 74.86,58.8
X$1982 2896 2102 2176 112 3059 113 AOI21_X1
* cell instance $1983 m0 *1 75.62,58.8
X$1983 1646 2231 2324 113 112 1677 OAI21_X4
* cell instance $1985 m0 *1 78.28,58.8
X$1985 2784 1729 2658 112 113 3060 MUX2_X1
* cell instance $1991 r0 *1 68.02,58.8
X$1991 2893 2093 112 113 2998 NAND2_X1
* cell instance $1992 r0 *1 68.59,58.8
X$1992 2998 2999 3000 112 113 3051 NOR3_X1
* cell instance $1993 r0 *1 69.35,58.8
X$1993 2895 3098 2780 3055 113 112 2999 OAI22_X1
* cell instance $1994 r0 *1 70.3,58.8
X$1994 1314 1643 1266 112 3054 113 AOI21_X1
* cell instance $1995 r0 *1 71.06,58.8
X$1995 1643 1189 1587 113 3323 112 OAI21_X1
* cell instance $1998 r0 *1 74.1,58.8
X$1998 2447 3158 3056 2955 113 112 3101 AND4_X1
* cell instance $1999 r0 *1 75.24,58.8
X$1999 2221 2173 1517 112 113 2896 NAND3_X1
* cell instance $2000 r0 *1 76,58.8
X$2000 3001 2099 2221 112 113 3159 NOR3_X1
* cell instance $2002 r0 *1 77.14,58.8
X$2002 3060 1149 3001 1144 1881 3153 113 112 AOI221_X2
* cell instance $2005 m0 *1 81.51,58.8
X$2005 112 16814 2959 1154 3063 113 DFF_X1
* cell instance $2010 r0 *1 84.55,58.8
X$2010 112 17101 3772 1428 3063 113 DFF_X1
* cell instance $2012 r0 *1 88.16,58.8
X$2012 112 17137 3002 1043 3164 113 DFF_X1
* cell instance $2013 m0 *1 89.11,58.8
X$2013 1236 1045 2630 112 113 3064 MUX2_X1
* cell instance $2016 m0 *1 90.63,58.8
X$2016 525 112 113 1615 CLKBUF_X3
* cell instance $2017 m0 *1 91.58,58.8
X$2017 525 1428 1154 112 113 2964 NAND3_X1
* cell instance $2018 m0 *1 92.34,58.8
X$2018 1428 1357 2964 113 2965 112 OAI21_X1
* cell instance $2019 m0 *1 93.1,58.8
X$2019 2965 1741 1405 112 113 2898 MUX2_X1
* cell instance $2020 m0 *1 94.43,58.8
X$2020 2785 2898 2454 1541 2786 113 112 2899 OAI221_X1
* cell instance $2022 m0 *1 95.76,58.8
X$2022 2969 505 112 113 1888 NAND2_X1
* cell instance $2024 m0 *1 96.52,58.8
X$2024 2969 113 840 112 BUF_X4
* cell instance $2025 m0 *1 97.85,58.8
X$2025 2900 2788 2845 611 2850 113 112 2852 OAI221_X1
* cell instance $2026 m0 *1 98.99,58.8
X$2026 2851 2787 1043 112 113 2973 NOR3_X1
* cell instance $2027 m0 *1 99.75,58.8
X$2027 840 950 112 113 2454 NOR2_X2
* cell instance $2030 m0 *1 101.65,58.8
X$2030 2900 2788 1539 264 2850 113 112 2901 OAI221_X1
* cell instance $2031 m0 *1 102.79,58.8
X$2031 2435 2901 1615 112 113 2902 NAND3_X1
* cell instance $2034 r0 *1 94.43,58.8
X$2034 1888 2077 2899 1043 3064 113 112 3067 OAI221_X1
* cell instance $2036 r0 *1 95.76,58.8
X$2036 2969 112 113 1536 INV_X2
* cell instance $2039 r0 *1 96.9,58.8
X$2039 1536 113 1045 112 BUF_X4
* cell instance $2040 r0 *1 98.23,58.8
X$2040 2900 2788 112 113 522 OR2_X2
* cell instance $2041 r0 *1 99.18,58.8
X$2041 118 3068 112 113 2900 NOR2_X2
* cell instance $2043 m0 *1 104.88,58.8
X$2043 2972 2973 840 113 2903 112 OAI21_X1
* cell instance $2044 m0 *1 103.93,58.8
X$2044 1043 2902 2752 113 112 2972 AND3_X1
* cell instance $2046 m0 *1 105.83,58.8
X$2046 2789 2903 2862 1541 112 113 3528 AOI22_X2
* cell instance $2052 r0 *1 108.49,58.8
X$2052 168 3105 3003 112 113 3103 MUX2_X1
* cell instance $2054 r0 *1 111.34,58.8
X$2054 112 17141 3073 3167 3070 113 DFF_X1
* cell instance $2055 r0 *1 114.57,58.8
X$2055 3073 113 2859 112 BUF_X4
* cell instance $2056 m0 *1 118.18,58.8
X$2056 2456 113 880 112 BUF_X4
* cell instance $2057 m0 *1 115.52,58.8
X$2057 112 2240 2670 2762 572 113 NOR3_X4
* cell instance $2059 m0 *1 119.7,58.8
X$2059 2456 2457 112 113 1048 NOR2_X2
* cell instance $2061 m0 *1 120.84,58.8
X$2061 2790 1653 802 1716 1048 2791 113 112 AOI221_X2
* cell instance $2063 m0 *1 123.12,58.8
X$2063 845 1204 2979 113 2867 112 OAI21_X1
* cell instance $2064 m0 *1 123.88,58.8
X$2064 708 113 1027 112 BUF_X4
* cell instance $2065 m0 *1 125.21,58.8
X$2065 708 1560 1752 112 113 2979 NOR3_X1
* cell instance $2066 m0 *1 125.97,58.8
X$2066 1919 708 112 858 113 NAND2_X4
* cell instance $2067 m0 *1 127.68,58.8
X$2067 1919 730 530 1284 112 113 2904 NOR4_X1
* cell instance $2068 m0 *1 128.63,58.8
X$2068 1443 880 1205 113 2905 112 OAI21_X1
* cell instance $2069 m0 *1 129.39,58.8
X$2069 1922 1919 708 733 572 112 113 2982 AOI221_X1
* cell instance $2071 m0 *1 130.72,58.8
X$2071 2876 2983 1560 113 2984 112 OAI21_X1
* cell instance $2072 m0 *1 131.48,58.8
X$2072 1922 2214 112 2907 113 NAND2_X4
* cell instance $2074 r0 *1 115.9,58.8
X$2074 2240 113 1922 112 BUF_X4
* cell instance $2077 r0 *1 117.8,58.8
X$2077 1919 113 1204 112 BUF_X4
* cell instance $2078 r0 *1 119.13,58.8
X$2078 2457 113 727 112 BUF_X4
* cell instance $2080 r0 *1 120.65,58.8
X$2080 2457 113 1653 112 BUF_X4
* cell instance $2081 r0 *1 121.98,58.8
X$2081 1653 113 1443 112 BUF_X4
* cell instance $2084 r0 *1 123.88,58.8
X$2084 3259 112 113 3106 BUF_X1
* cell instance $2088 r0 *1 124.45,58.8
X$2088 112 1983 1748 3078 3079 113 AOI21_X4
* cell instance $2089 r0 *1 126.92,58.8
X$2089 802 3078 3079 112 1109 113 AOI21_X2
* cell instance $2090 r0 *1 128.25,58.8
X$2090 2904 1455 2905 112 2874 113 AOI21_X1
* cell instance $2095 r0 *1 133.19,58.8
X$2095 880 113 734 112 BUF_X4
* cell instance $2096 m0 *1 133.76,58.8
X$2096 2984 2792 2987 1560 1184 113 112 3108 OAI221_X1
* cell instance $2098 m0 *1 134.9,58.8
X$2098 1555 2906 2121 734 2559 112 113 2983 AOI221_X1
* cell instance $2099 m0 *1 136.04,58.8
X$2099 112 1348 1443 2677 2907 113 AOI21_X4
* cell instance $2104 r0 *1 135.28,58.8
X$2104 1204 1924 113 112 2906 AND2_X1
* cell instance $2106 r0 *1 136.23,58.8
X$2106 2907 2677 727 112 113 1924 NAND3_X1
* cell instance $2109 m0 *1 143.64,58.8
X$2109 112 16812 2986 2883 2133 113 DFF_X1
* cell instance $2111 m0 *1 146.87,58.8
X$2111 112 16741 2985 2132 2133 113 DFF_X1
* cell instance $2116 r0 *1 147.82,58.8
X$2116 401 112 113 2133 CLKBUF_X3
* cell instance $2117 r0 *1 148.77,58.8
X$2117 2985 113 3109 112 BUF_X4
* cell instance $2118 r0 *1 150.1,58.8
X$2118 2133 112 113 17183 INV_X2
* cell instance $2119 r0 *1 150.67,58.8
X$2119 3086 113 3005 112 BUF_X4
* cell instance $2120 m0 *1 151.81,58.8
X$2120 3198 2357 16503 113 112 2910 HA_X1
* cell instance $2121 m0 *1 151.24,58.8
X$2121 2763 112 113 3086 BUF_X1
* cell instance $2122 m0 *1 153.71,58.8
X$2122 112 2464 113 2909 BUF_X8
* cell instance $2123 m0 *1 156.18,58.8
X$2123 2910 113 2981 112 BUF_X4
* cell instance $2124 m0 *1 157.51,58.8
X$2124 2909 112 113 2803 CLKBUF_X3
* cell instance $2125 m0 *1 158.46,58.8
X$2125 2908 2885 2678 113 2798 112 OAI21_X1
* cell instance $2126 m0 *1 159.22,58.8
X$2126 112 3178 2804 2794 2645 113 AOI21_X4
* cell instance $2127 m0 *1 161.69,58.8
X$2127 2803 2634 112 113 2796 NOR2_X1
* cell instance $2128 m0 *1 162.26,58.8
X$2128 2911 3091 2978 113 112 2865 OAI21_X2
* cell instance $2129 m0 *1 163.59,58.8
X$2129 2912 2514 2799 2759 2757 113 112 2682 OAI221_X1
* cell instance $2131 m0 *1 164.92,58.8
X$2131 2963 2463 2797 112 2977 113 AOI21_X2
* cell instance $2132 m0 *1 166.25,58.8
X$2132 2976 2755 2795 112 2638 113 AOI21_X1
* cell instance $2133 m0 *1 167.01,58.8
X$2133 112 2755 113 3008 BUF_X8
* cell instance $2134 m0 *1 169.48,58.8
X$2134 2634 2913 3088 112 113 2869 MUX2_X1
* cell instance $2135 m0 *1 170.81,58.8
X$2135 2473 112 113 2975 BUF_X1
* cell instance $2137 m0 *1 171.57,58.8
X$2137 2870 2804 2974 2755 2681 2960 113 112 AOI221_X2
* cell instance $2139 r0 *1 152,58.8
X$2139 3004 113 3180 112 BUF_X4
* cell instance $2140 r0 *1 153.33,58.8
X$2140 3005 113 2639 112 BUF_X4
* cell instance $2141 r0 *1 154.66,58.8
X$2141 2464 113 3006 112 BUF_X4
* cell instance $2142 r0 *1 155.99,58.8
X$2142 3006 113 2885 112 BUF_X4
* cell instance $2143 r0 *1 157.32,58.8
X$2143 2910 113 2760 112 BUF_X4
* cell instance $2145 r0 *1 158.84,58.8
X$2145 3272 3005 3007 112 113 3090 MUX2_X1
* cell instance $2146 r0 *1 160.17,58.8
X$2146 2760 113 3008 112 BUF_X4
* cell instance $2147 r0 *1 161.5,58.8
X$2147 2640 3090 2465 113 112 3014 OAI21_X2
* cell instance $2148 r0 *1 162.83,58.8
X$2148 2512 2912 2681 112 3092 113 AOI21_X1
* cell instance $2150 r0 *1 163.78,58.8
X$2150 2680 2360 3085 112 3177 113 AOI21_X1
* cell instance $2151 r0 *1 164.54,58.8
X$2151 3112 2963 2358 112 113 3091 NOR3_X1
* cell instance $2153 r0 *1 165.68,58.8
X$2153 2471 2463 2797 112 113 3089 MUX2_X1
* cell instance $2154 r0 *1 167.01,58.8
X$2154 3089 2639 2680 2755 2642 3173 113 112 AOI221_X2
* cell instance $2155 r0 *1 169.1,58.8
X$2155 2407 2873 2916 113 2871 112 OAI21_X1
* cell instance $2156 r0 *1 169.86,58.8
X$2156 3005 2917 3170 112 3009 113 AOI21_X1
* cell instance $2157 r0 *1 170.62,58.8
X$2157 3009 3010 3087 113 3174 112 OAI21_X1
* cell instance $2158 r0 *1 171.38,58.8
X$2158 3112 2913 112 113 3114 NAND2_X1
* cell instance $2159 r0 *1 171.95,58.8
X$2159 3011 3114 3087 112 113 2801 NAND3_X1
* cell instance $2160 r0 *1 172.71,58.8
X$2160 3083 3085 2360 3012 112 113 3011 AOI22_X1
* cell instance $2162 m0 *1 152.76,140
X$2162 9883 3635 7819 112 113 9937 NAND3_X1
* cell instance $2163 m0 *1 151.81,140
X$2163 9883 9743 112 113 9938 NAND2_X2
* cell instance $2164 m0 *1 153.52,140
X$2164 9929 9937 9931 112 10083 113 AOI21_X1
* cell instance $2166 m0 *1 154.47,140
X$2166 9884 3571 8867 112 113 9933 NAND3_X1
* cell instance $2167 m0 *1 155.23,140
X$2167 9635 112 113 9885 BUF_X1
* cell instance $2168 m0 *1 155.8,140
X$2168 3571 8657 112 113 9985 NAND2_X1
* cell instance $2171 r0 *1 151.81,140
X$2171 9882 10083 10079 112 113 9983 OR3_X4
* cell instance $2173 r0 *1 154.09,140
X$2173 9905 6244 112 113 10359 NOR2_X1
* cell instance $2174 r0 *1 154.66,140
X$2174 9933 9884 9985 113 112 10076 OAI21_X2
* cell instance $2175 r0 *1 155.99,140
X$2175 112 10073 10432 10076 10137 113 NOR3_X4
* cell instance $2176 m0 *1 158.08,140
X$2176 7516 8657 112 113 10259 NOR2_X1
* cell instance $2177 m0 *1 157.51,140
X$2177 9857 112 113 9930 BUF_X1
* cell instance $2178 m0 *1 158.65,140
X$2178 9886 10075 8657 112 113 9986 NAND3_X1
* cell instance $2179 m0 *1 159.41,140
X$2179 9888 4508 8657 112 113 10071 NAND3_X1
* cell instance $2180 m0 *1 160.17,140
X$2180 9930 9928 112 113 9987 XOR2_X1
* cell instance $2181 m0 *1 161.31,140
X$2181 10299 112 113 9036 CLKBUF_X3
* cell instance $2182 m0 *1 162.26,140
X$2182 9988 9887 112 113 9886 XNOR2_X2
* cell instance $2184 r0 *1 158.65,140
X$2184 9987 10139 10071 112 10073 113 AOI21_X2
* cell instance $2186 r0 *1 160.17,140
X$2186 9745 9928 113 112 10429 XNOR2_X1
* cell instance $2187 r0 *1 161.31,140
X$2187 112 7212 6413 113 BUF_X32
* cell instance $2188 m0 *1 166.44,140
X$2188 9454 3327 9686 112 113 9748 NAND3_X1
* cell instance $2189 m0 *1 164.54,140
X$2189 10140 9889 112 113 9878 XNOR2_X2
* cell instance $2191 m0 *1 167.39,140
X$2191 10000 9222 112 113 9989 XNOR2_X2
* cell instance $2192 m0 *1 169.29,140
X$2192 5401 7022 112 113 9749 NAND2_X1
* cell instance $2193 m0 *1 169.86,140
X$2193 9857 9990 113 9991 112 XOR2_X2
* cell instance $2195 r0 *1 170.62,140
X$2195 9990 112 113 10260 BUF_X1
* cell instance $2196 r0 *1 171.19,140
X$2196 9988 9750 113 9993 112 XOR2_X2
* cell instance $2197 m0 *1 172.52,140
X$2197 10059 9857 112 113 9584 XNOR2_X2
* cell instance $2198 m0 *1 171.95,140
X$2198 9253 9584 112 113 9992 NAND2_X1
* cell instance $2200 r0 *1 172.9,140
X$2200 10261 8148 8059 112 113 10195 NAND3_X1
* cell instance $2201 r0 *1 173.66,140
X$2201 9857 113 10189 112 BUF_X4
* cell instance $2202 m0 *1 175.56,140
X$2202 9253 9891 112 113 9994 NAND2_X1
* cell instance $2203 m0 *1 174.8,140
X$2203 9751 112 113 9921 BUF_X2
* cell instance $2205 r0 *1 174.99,140
X$2205 9891 6064 9217 112 113 10192 NAND3_X1
* cell instance $2206 r0 *1 175.75,140
X$2206 9217 112 113 10142 INV_X1
* cell instance $2207 r0 *1 176.13,140
X$2207 9996 10143 112 113 9995 XNOR2_X2
* cell instance $2208 m0 *1 177.27,140
X$2208 9706 112 113 9841 BUF_X1
* cell instance $2209 m0 *1 176.51,140
X$2209 9753 112 113 9635 BUF_X2
* cell instance $2211 m0 *1 178.03,140
X$2211 10189 9644 113 9892 112 XOR2_X2
* cell instance $2212 m0 *1 179.74,140
X$2212 9996 9892 113 112 9893 XNOR2_X1
* cell instance $2213 m0 *1 180.88,140
X$2213 9996 112 113 9923 BUF_X2
* cell instance $2215 m0 *1 181.83,140
X$2215 9893 9894 113 112 9911 XNOR2_X1
* cell instance $2217 m0 *1 183.16,140
X$2217 9643 112 113 9997 BUF_X1
* cell instance $2221 r0 *1 178.03,140
X$2221 10143 113 9752 112 BUF_X4
* cell instance $2222 r0 *1 179.36,140
X$2222 9995 112 113 9640 BUF_X1
* cell instance $2223 r0 *1 179.93,140
X$2223 9643 9995 112 113 10144 XNOR2_X2
* cell instance $2227 r0 *1 181.83,140
X$2227 9642 9990 112 113 10145 XNOR2_X2
* cell instance $2228 r0 *1 183.73,140
X$2228 9996 10177 113 112 10147 XNOR2_X1
* cell instance $2229 r0 *1 184.87,140
X$2229 9996 9921 112 113 10148 XOR2_X1
* cell instance $2231 m0 *1 184.49,131.6
X$2231 9323 9237 113 112 9251 XNOR2_X1
* cell instance $2233 m0 *1 185.63,131.6
X$2233 9105 9248 112 113 9363 XNOR2_X2
* cell instance $2234 m0 *1 187.53,131.6
X$2234 9324 5315 113 112 9248 XNOR2_X1
* cell instance $2236 m0 *1 188.86,131.6
X$2236 9106 9224 112 113 9216 XNOR2_X2
* cell instance $2237 m0 *1 190.76,131.6
X$2237 9357 9359 112 113 9247 XNOR2_X2
* cell instance $2238 m0 *1 192.66,131.6
X$2238 8818 9245 112 113 9357 XNOR2_X2
* cell instance $2240 m0 *1 194.75,131.6
X$2240 9324 9240 112 113 9245 XNOR2_X2
* cell instance $2242 m0 *1 196.84,131.6
X$2242 9225 9245 113 112 9226 XNOR2_X1
* cell instance $2243 m0 *1 197.98,131.6
X$2243 9237 9226 113 112 9327 XNOR2_X1
* cell instance $2245 m0 *1 199.31,131.6
X$2245 9225 9227 113 112 9243 XNOR2_X1
* cell instance $2246 m0 *1 200.45,131.6
X$2246 3304 9243 113 112 9354 XNOR2_X1
* cell instance $2249 m0 *1 203.87,131.6
X$2249 112 16836 9128 9228 8887 113 DFF_X1
* cell instance $2250 m0 *1 207.1,131.6
X$2250 5315 4206 113 9234 112 XOR2_X2
* cell instance $2252 m0 *1 209.57,131.6
X$2252 9329 9306 9235 112 113 9353 MUX2_X1
* cell instance $2257 m0 *1 225.34,131.6
X$2257 112 16747 9331 9345 9229 113 DFF_X1
* cell instance $2258 m0 *1 228.57,131.6
X$2258 9331 9209 8906 112 113 9345 MUX2_X1
* cell instance $2259 m0 *1 229.9,131.6
X$2259 9230 112 113 9235 BUF_X1
* cell instance $2262 m0 *1 232.18,131.6
X$2262 112 16804 9339 9343 8794 113 DFF_X1
* cell instance $2264 r0 *1 184.3,131.6
X$2264 9237 9431 113 112 9448 XNOR2_X1
* cell instance $2266 r0 *1 185.82,131.6
X$2266 9007 9431 113 112 9362 XNOR2_X1
* cell instance $2269 r0 *1 187.53,131.6
X$2269 9362 9520 113 112 9361 XNOR2_X1
* cell instance $2271 r0 *1 188.86,131.6
X$2271 9325 9361 3489 113 112 9313 MUX2_X2
* cell instance $2272 r0 *1 190.57,131.6
X$2272 9224 112 113 9519 BUF_X1
* cell instance $2273 r0 *1 191.14,131.6
X$2273 9326 3304 113 112 9359 XNOR2_X1
* cell instance $2276 r0 *1 193.99,131.6
X$2276 3304 9131 113 112 9521 XNOR2_X1
* cell instance $2279 r0 *1 197.41,131.6
X$2279 9329 9327 3465 113 112 9356 MUX2_X2
* cell instance $2280 r0 *1 199.12,131.6
X$2280 9240 9323 113 112 9227 XNOR2_X1
* cell instance $2282 r0 *1 201.02,131.6
X$2282 9224 5294 113 112 9445 XNOR2_X1
* cell instance $2283 r0 *1 202.16,131.6
X$2283 9331 9354 6773 113 112 9328 MUX2_X2
* cell instance $2284 r0 *1 203.87,131.6
X$2284 5315 9444 113 112 9434 XNOR2_X1
* cell instance $2287 r0 *1 205.96,131.6
X$2287 8887 112 113 16480 CLKBUF_X1
* cell instance $2290 r0 *1 208.81,131.6
X$2290 112 17057 9329 9353 9238 113 DFF_X1
* cell instance $2292 r0 *1 212.42,131.6
X$2292 112 16980 9325 9352 9238 113 DFF_X1
* cell instance $2293 r0 *1 215.65,131.6
X$2293 9325 8785 9442 112 113 9352 MUX2_X1
* cell instance $2296 r0 *1 218.69,131.6
X$2296 112 9241 9435 9349 9229 113 DFF_X1
* cell instance $2297 r0 *1 221.92,131.6
X$2297 9435 8785 9770 112 113 9349 MUX2_X1
* cell instance $2300 r0 *1 224.2,131.6
X$2300 4841 112 113 9229 CLKBUF_X3
* cell instance $2301 r0 *1 225.15,131.6
X$2301 9229 112 113 17207 INV_X1
* cell instance $2305 r0 *1 232.18,131.6
X$2305 9330 4939 9338 112 113 9443 MUX2_X1
* cell instance $2306 r0 *1 233.51,131.6
X$2306 9332 112 113 9442 BUF_X1
* cell instance $2307 r0 *1 234.08,131.6
X$2307 112 17049 9336 9234 8794 113 DFF_X1
* cell instance $2308 m0 *1 235.98,131.6
X$2308 9339 112 113 9333 BUF_X1
* cell instance $2310 m0 *1 236.55,131.6
X$2310 9334 112 113 9233 BUF_X1
* cell instance $2317 r0 *1 237.31,131.6
X$2317 9437 112 113 9129 BUF_X1
* cell instance $2321 r0 *1 239.21,131.6
X$2321 9336 112 113 9436 BUF_X1
* cell instance $2324 m0 *1 213.56,47.6
X$2324 112 1766 2040 113 BUF_X16
* cell instance $2328 r0 *1 213.56,47.6
X$2328 2038 2039 1939 113 112 2256 OAI21_X4
* cell instance $2329 r0 *1 216.03,47.6
X$2329 1858 2039 1939 113 112 2157 OAI21_X4
* cell instance $2332 m0 *1 218.69,47.6
X$2332 1942 112 113 1864 INV_X8
* cell instance $2334 r0 *1 218.88,47.6
X$2334 112 2155 113 1860 BUF_X8
* cell instance $2335 r0 *1 221.35,47.6
X$2335 2040 113 2259 112 BUF_X4
* cell instance $2337 m0 *1 222.3,47.6
X$2337 2041 113 2038 112 BUF_X4
* cell instance $2339 m0 *1 230.47,47.6
X$2339 112 2042 1941 113 BUF_X32
* cell instance $2341 r0 *1 222.68,47.6
X$2341 1940 1862 2041 113 112 2141 HA_X1
* cell instance $2342 r0 *1 224.58,47.6
X$2342 2041 112 113 2150 BUF_X1
* cell instance $2344 r0 *1 225.53,47.6
X$2344 112 2040 2042 113 BUF_X32
* cell instance $2352 m0 *1 49.78,100.8
X$2352 112 5826 5953 6850 5146 6511 113 OAI22_X4
* cell instance $2354 m0 *1 53.01,100.8
X$2354 6511 6510 112 113 5820 NOR2_X2
* cell instance $2356 m0 *1 54.15,100.8
X$2356 6511 6512 5943 112 113 NOR2_X4
* cell instance $2357 m0 *1 55.86,100.8
X$2357 6512 112 113 6510 BUF_X1
* cell instance $2360 r0 *1 49.59,100.8
X$2360 6380 4244 6735 112 113 6799 MUX2_X1
* cell instance $2362 r0 *1 51.3,100.8
X$2362 6799 4081 5687 112 113 6738 MUX2_X1
* cell instance $2364 r0 *1 53.01,100.8
X$2364 112 6511 6739 5953 5826 4241 113 NOR4_X4
* cell instance $2365 r0 *1 56.43,100.8
X$2365 6512 112 113 6739 BUF_X1
* cell instance $2367 r0 *1 57.19,100.8
X$2367 112 5686 113 6851 BUF_X8
* cell instance $2369 m0 *1 58.33,100.8
X$2369 112 5612 5686 4791 6740 6381 113 AOI22_X4
* cell instance $2372 r0 *1 60.42,100.8
X$2372 112 17085 6800 4526 6855 113 DFF_X1
* cell instance $2373 m0 *1 62.89,100.8
X$2373 6384 112 113 6590 BUF_X1
* cell instance $2375 m0 *1 63.46,100.8
X$2375 6384 112 113 6666 BUF_X1
* cell instance $2376 m0 *1 64.03,100.8
X$2376 6588 113 6513 112 BUF_X4
* cell instance $2377 m0 *1 65.36,100.8
X$2377 112 6513 5621 5528 5926 113 NOR3_X4
* cell instance $2379 m0 *1 68.21,100.8
X$2379 6590 6513 112 113 6231 NOR2_X2
* cell instance $2380 m0 *1 69.16,100.8
X$2380 112 5011 6513 6747 6514 113 AOI21_X4
* cell instance $2383 r0 *1 63.84,100.8
X$2383 112 5481 113 6513 BUF_X8
* cell instance $2384 r0 *1 66.31,100.8
X$2384 112 5150 5621 5528 6749 113 NOR3_X4
* cell instance $2388 r0 *1 68.97,100.8
X$2388 6055 6742 6056 4633 6454 6864 113 112 AOI221_X2
* cell instance $2389 r0 *1 71.06,100.8
X$2389 6384 113 4633 112 BUF_X4
* cell instance $2390 m0 *1 72.96,100.8
X$2390 6122 5013 5956 5376 113 112 6667 OAI22_X2
* cell instance $2391 m0 *1 72.01,100.8
X$2391 5956 6122 112 113 4980 NAND2_X2
* cell instance $2393 m0 *1 74.86,100.8
X$2393 112 4640 6459 6747 6514 113 AOI21_X4
* cell instance $2394 m0 *1 77.33,100.8
X$2394 4197 6594 113 6385 112 AND2_X4
* cell instance $2395 m0 *1 79.04,100.8
X$2395 6594 112 113 6072 BUF_X1
* cell instance $2396 m0 *1 79.61,100.8
X$2396 4199 4738 6232 5376 5099 6751 112 113 OAI221_X2
* cell instance $2397 m0 *1 81.7,100.8
X$2397 3922 4805 5829 112 6670 113 AOI21_X1
* cell instance $2400 r0 *1 72.58,100.8
X$2400 6385 6863 6056 4307 6667 6801 113 112 AOI221_X2
* cell instance $2401 r0 *1 74.67,100.8
X$2401 6384 5714 112 4151 113 NAND2_X4
* cell instance $2402 r0 *1 76.38,100.8
X$2402 5832 113 4488 112 BUF_X4
* cell instance $2403 r0 *1 77.71,100.8
X$2403 5714 6668 4629 5376 4738 113 112 6752 OAI221_X1
* cell instance $2404 r0 *1 78.85,100.8
X$2404 6668 112 113 4195 CLKBUF_X3
* cell instance $2405 r0 *1 79.8,100.8
X$2405 4631 113 4196 112 BUF_X4
* cell instance $2406 r0 *1 81.13,100.8
X$2406 6231 4088 4875 112 6669 113 AOI21_X1
* cell instance $2408 r0 *1 82.08,100.8
X$2408 6802 6670 4606 4538 4151 113 112 6671 OAI221_X1
* cell instance $2409 m0 *1 83.79,100.8
X$2409 4899 5923 112 113 6596 NAND2_X1
* cell instance $2410 m0 *1 82.84,100.8
X$2410 5014 6671 6515 113 112 5816 AND3_X1
* cell instance $2413 m0 *1 86.07,100.8
X$2413 6598 5535 4631 112 113 6474 NAND3_X1
* cell instance $2414 m0 *1 86.83,100.8
X$2414 4633 4252 112 113 5965 NAND2_X2
* cell instance $2416 m0 *1 87.97,100.8
X$2416 5741 5535 5090 6388 4728 112 113 6675 AOI221_X1
* cell instance $2419 r0 *1 83.41,100.8
X$2419 4732 5829 112 113 5155 NOR2_X2
* cell instance $2420 r0 *1 84.36,100.8
X$2420 6673 4639 5714 112 113 6598 NAND3_X1
* cell instance $2423 r0 *1 86.26,100.8
X$2423 5150 4738 4631 4488 4089 113 112 6756 OAI221_X1
* cell instance $2424 r0 *1 87.4,100.8
X$2424 6756 4260 6389 112 6674 113 AOI21_X1
* cell instance $2425 r0 *1 88.16,100.8
X$2425 6332 4148 6675 112 113 6914 NOR3_X1
* cell instance $2427 m0 *1 90.63,100.8
X$2427 4728 6219 112 113 6604 NAND2_X1
* cell instance $2428 m0 *1 89.49,100.8
X$2428 6388 5484 4734 4433 5965 113 112 6518 OAI221_X1
* cell instance $2429 m0 *1 91.2,100.8
X$2429 6599 6602 112 113 6759 NOR2_X1
* cell instance $2431 m0 *1 91.96,100.8
X$2431 5014 6519 6604 112 6602 113 AOI21_X1
* cell instance $2432 m0 *1 92.72,100.8
X$2432 5743 4904 112 113 6758 NOR2_X1
* cell instance $2434 m0 *1 94.05,100.8
X$2434 6468 4157 4803 112 113 6520 NOR3_X1
* cell instance $2435 m0 *1 94.81,100.8
X$2435 6761 6520 4433 112 113 6607 NOR3_X1
* cell instance $2438 r0 *1 90.63,100.8
X$2438 3983 5155 4432 113 6806 112 OAI21_X1
* cell instance $2439 r0 *1 91.39,100.8
X$2439 3986 5967 6758 4195 4880 113 112 6871 OAI221_X1
* cell instance $2442 r0 *1 93.1,100.8
X$2442 4738 4156 4195 113 6676 112 OAI21_X1
* cell instance $2443 r0 *1 93.86,100.8
X$2443 4196 4538 3983 113 6872 112 OAI21_X1
* cell instance $2444 r0 *1 94.62,100.8
X$2444 4745 4196 3983 112 113 6761 NOR3_X1
* cell instance $2448 m0 *1 95.95,100.8
X$2448 5016 5743 3986 112 6762 113 AOI21_X1
* cell instance $2449 m0 *1 96.9,100.8
X$2449 6762 6521 6220 4091 112 113 6522 NOR4_X1
* cell instance $2450 m0 *1 97.85,100.8
X$2450 6522 6607 6391 113 5836 112 OAI21_X1
* cell instance $2453 r0 *1 95.95,100.8
X$2453 4537 112 113 4734 CLKBUF_X3
* cell instance $2457 r0 *1 99.37,100.8
X$2457 112 6765 6523 6738 7019 113 DFF_X1
* cell instance $2458 m0 *1 102.22,100.8
X$2458 5634 6523 112 113 6877 XOR2_X1
* cell instance $2463 m0 *1 105.83,100.8
X$2463 6073 6767 113 112 6612 XNOR2_X1
* cell instance $2464 m0 *1 106.97,100.8
X$2464 6393 6395 112 113 6524 NAND2_X1
* cell instance $2468 r0 *1 103.55,100.8
X$2468 6765 6106 113 112 6767 XNOR2_X1
* cell instance $2471 m0 *1 109.25,100.8
X$2471 112 16841 6613 6525 5751 113 DFF_X1
* cell instance $2472 m0 *1 107.92,100.8
X$2472 6395 113 6616 112 BUF_X4
* cell instance $2474 m0 *1 112.67,100.8
X$2474 6613 112 113 6073 CLKBUF_X3
* cell instance $2476 m0 *1 116.66,100.8
X$2476 6526 7246 112 113 6241 NOR2_X1
* cell instance $2481 r0 *1 109.06,100.8
X$2481 127 5120 112 113 6677 NAND2_X1
* cell instance $2482 r0 *1 109.63,100.8
X$2482 6395 113 5122 112 BUF_X4
* cell instance $2484 r0 *1 111.72,100.8
X$2484 170 3105 6807 112 113 6769 MUX2_X1
* cell instance $2485 r0 *1 113.05,100.8
X$2485 112 16994 6771 6769 5751 113 DFF_X1
* cell instance $2486 r0 *1 116.28,100.8
X$2486 6771 113 2848 112 BUF_X4
* cell instance $2488 m0 *1 118.56,100.8
X$2488 302 6211 6619 112 113 6678 MUX2_X1
* cell instance $2491 r0 *1 119.13,100.8
X$2491 112 16993 6527 6678 6680 113 DFF_X1
* cell instance $2493 m0 *1 120.27,100.8
X$2493 5854 6679 113 112 6619 XNOR2_X1
* cell instance $2494 m0 *1 121.98,100.8
X$2494 6527 112 113 5854 CLKBUF_X3
* cell instance $2498 r0 *1 122.55,100.8
X$2498 112 17126 6778 6681 6680 113 DFF_X1
* cell instance $2499 m0 *1 124.07,100.8
X$2499 6569 3105 6623 112 113 6626 MUX2_X1
* cell instance $2500 m0 *1 123.31,100.8
X$2500 6624 3776 6528 112 6681 113 AOI21_X1
* cell instance $2502 m0 *1 125.59,100.8
X$2502 6778 113 6625 112 BUF_X4
* cell instance $2504 m0 *1 127.68,100.8
X$2504 6529 409 6530 113 112 6682 OAI21_X2
* cell instance $2505 m0 *1 129.01,100.8
X$2505 6775 5166 112 113 6530 NAND2_X1
* cell instance $2508 m0 *1 130.53,100.8
X$2508 6531 5587 112 113 6782 NAND2_X1
* cell instance $2509 m0 *1 131.1,100.8
X$2509 6683 6632 6783 112 6780 113 AOI21_X2
* cell instance $2510 m0 *1 132.43,100.8
X$2510 5587 5194 5166 112 113 6632 NAND3_X1
* cell instance $2511 m0 *1 133.19,100.8
X$2511 6398 6138 4407 112 113 6635 NAND3_X1
* cell instance $2512 m0 *1 133.95,100.8
X$2512 6634 6988 6635 112 6786 113 AOI21_X2
* cell instance $2519 r0 *1 126.92,100.8
X$2519 112 6779 6780 6682 1479 113 NOR3_X4
* cell instance $2523 r0 *1 130.91,100.8
X$2523 6884 6782 6784 112 6779 113 AOI21_X2
* cell instance $2524 r0 *1 132.24,100.8
X$2524 112 5928 3873 113 BUF_X16
* cell instance $2526 m0 *1 135.66,100.8
X$2526 6502 6533 113 112 6684 XNOR2_X1
* cell instance $2527 m0 *1 136.99,100.8
X$2527 4279 112 113 5919 CLKBUF_X3
* cell instance $2529 m0 *1 138.13,100.8
X$2529 407 6413 6534 112 113 6685 NAND3_X1
* cell instance $2530 m0 *1 138.89,100.8
X$2530 6413 4407 112 113 6687 NAND2_X1
* cell instance $2534 r0 *1 136.99,100.8
X$2534 112 6786 6992 6686 2671 113 NOR3_X4
* cell instance $2535 r0 *1 139.65,100.8
X$2535 6685 407 6687 113 112 6686 OAI21_X2
* cell instance $2536 r0 *1 140.98,100.8
X$2536 6688 112 113 6260 CLKBUF_X3
* cell instance $2537 r0 *1 141.93,100.8
X$2537 6688 6495 6789 112 113 6401 OR3_X1
* cell instance $2539 m0 *1 142.12,100.8
X$2539 6640 6141 5982 113 6639 112 OAI21_X1
* cell instance $2540 m0 *1 143.07,100.8
X$2540 6152 6196 6536 112 6689 113 AOI21_X1
* cell instance $2542 m0 *1 144.02,100.8
X$2542 6537 6641 112 113 6535 OR2_X1
* cell instance $2543 m0 *1 144.78,100.8
X$2543 6548 6692 6152 6643 113 112 6493 OAI22_X1
* cell instance $2544 m0 *1 145.73,100.8
X$2544 6205 6537 6536 113 6643 112 OAI21_X1
* cell instance $2547 r0 *1 143.07,100.8
X$2547 6790 6689 6140 6406 6791 113 112 6891 OAI221_X1
* cell instance $2549 r0 *1 144.4,100.8
X$2549 6795 6537 6205 112 113 6892 MUX2_X1
* cell instance $2550 r0 *1 145.73,100.8
X$2550 6794 6139 6892 112 6791 113 AOI21_X1
* cell instance $2552 r0 *1 146.68,100.8
X$2552 6688 6691 112 113 6692 OR2_X1
* cell instance $2553 m0 *1 148.01,100.8
X$2553 6646 6813 6648 6540 113 112 6539 OAI22_X1
* cell instance $2554 m0 *1 146.87,100.8
X$2554 6365 6538 5846 6406 6539 113 112 6690 OAI221_X1
* cell instance $2555 m0 *1 148.96,100.8
X$2555 6641 6537 112 113 6648 NOR2_X1
* cell instance $2562 r0 *1 150.29,100.8
X$2562 6781 5851 112 113 6364 NAND2_X1
* cell instance $2563 m0 *1 150.86,100.8
X$2563 6141 6653 6251 112 6651 113 AOI21_X2
* cell instance $2566 m0 *1 152.38,100.8
X$2566 6652 6257 6542 6656 6655 6657 112 113 OAI221_X2
* cell instance $2567 m0 *1 154.47,100.8
X$2567 6649 6657 6405 112 113 6815 NAND3_X2
* cell instance $2568 m0 *1 155.8,100.8
X$2568 6660 6543 6140 6150 6692 113 112 6661 OAI221_X1
* cell instance $2569 m0 *1 156.94,100.8
X$2569 6410 6641 113 112 6150 AND2_X1
* cell instance $2570 m0 *1 157.7,100.8
X$2570 5988 6661 6792 112 6636 113 AOI21_X1
* cell instance $2571 m0 *1 158.46,100.8
X$2571 6659 6693 6257 113 6792 112 OAI21_X1
* cell instance $2572 m0 *1 159.22,100.8
X$2572 6541 6545 112 113 6654 NOR2_X1
* cell instance $2577 r0 *1 151.43,100.8
X$2577 6141 113 5987 112 BUF_X4
* cell instance $2578 r0 *1 152.76,100.8
X$2578 6795 6541 5846 113 6656 112 OAI21_X1
* cell instance $2579 r0 *1 153.52,100.8
X$2579 6495 5987 6152 112 113 6787 NOR3_X1
* cell instance $2582 r0 *1 157.7,100.8
X$2582 6470 6793 6139 112 113 6693 NOR3_X1
* cell instance $2584 r0 *1 159.98,100.8
X$2584 6545 112 113 6653 INV_X2
* cell instance $2585 r0 *1 160.55,100.8
X$2585 5985 6642 112 113 6694 NAND2_X1
* cell instance $2586 r0 *1 161.12,100.8
X$2586 6260 6409 5991 112 6788 113 AOI21_X1
* cell instance $2587 r0 *1 161.88,100.8
X$2587 6787 6196 6788 112 6695 113 AOI21_X1
* cell instance $2589 m0 *1 163.97,100.8
X$2589 6547 5991 5982 113 6696 112 OAI21_X1
* cell instance $2590 m0 *1 163.21,100.8
X$2590 6205 6360 6642 113 6546 112 OAI21_X1
* cell instance $2592 m0 *1 165.49,100.8
X$2592 6819 6785 6405 6406 112 113 6637 NAND4_X1
* cell instance $2593 m0 *1 166.44,100.8
X$2593 6405 6549 6637 6636 6550 5698 112 113 OAI221_X2
* cell instance $2595 m0 *1 169.29,100.8
X$2595 6700 6411 6630 6886 6698 6631 113 112 AOI221_X2
* cell instance $2597 m0 *1 171.57,100.8
X$2597 6629 112 113 6545 BUF_X2
* cell instance $2598 m0 *1 172.33,100.8
X$2598 5982 6367 16539 113 112 6777 HA_X1
* cell instance $2601 r0 *1 163.4,100.8
X$2601 5982 6694 6817 6548 6696 113 112 6785 OAI221_X1
* cell instance $2602 r0 *1 164.54,100.8
X$2602 6255 6697 5991 113 6818 112 OAI21_X1
* cell instance $2605 r0 *1 165.87,100.8
X$2605 6701 112 113 5846 CLKBUF_X3
* cell instance $2606 r0 *1 166.82,100.8
X$2606 6537 112 113 5991 CLKBUF_X3
* cell instance $2608 r0 *1 168.15,100.8
X$2608 6081 6781 112 113 6698 NOR2_X2
* cell instance $2609 r0 *1 169.1,100.8
X$2609 6699 6148 6352 112 6700 113 AOI21_X1
* cell instance $2610 r0 *1 169.86,100.8
X$2610 6701 6781 112 113 6699 NAND2_X1
* cell instance $2614 r0 *1 171.76,100.8
X$2614 6537 6777 112 113 6885 NAND2_X1
* cell instance $2617 m0 *1 175.56,100.8
X$2617 6551 6269 112 113 6776 NAND2_X1
* cell instance $2619 m0 *1 176.13,100.8
X$2619 6162 6773 6073 112 113 6622 NAND3_X1
* cell instance $2620 m0 *1 176.89,100.8
X$2620 6620 6776 6622 112 6621 113 AOI21_X1
* cell instance $2622 m0 *1 177.84,100.8
X$2622 5853 6271 113 112 6620 XNOR2_X1
* cell instance $2625 m0 *1 182.21,100.8
X$2625 6552 6618 113 112 6702 XNOR2_X1
* cell instance $2626 m0 *1 183.35,100.8
X$2626 6770 6272 112 113 6618 XNOR2_X2
* cell instance $2627 m0 *1 185.25,100.8
X$2627 6617 6274 112 113 6615 XNOR2_X2
* cell instance $2628 m0 *1 187.15,100.8
X$2628 6768 6615 112 113 4677 XNOR2_X2
* cell instance $2631 m0 *1 190,100.8
X$2631 6704 6611 113 112 4555 XNOR2_X1
* cell instance $2632 m0 *1 191.14,100.8
X$2632 6422 6273 113 112 6611 XNOR2_X1
* cell instance $2635 m0 *1 193.23,100.8
X$2635 4674 6610 112 113 6555 XNOR2_X2
* cell instance $2636 m0 *1 195.13,100.8
X$2636 6556 5995 6570 112 113 6766 MUX2_X1
* cell instance $2640 m0 *1 204.25,100.8
X$2640 6708 6423 112 113 6425 XNOR2_X2
* cell instance $2644 r0 *1 176.32,100.8
X$2644 6775 6073 112 113 6774 NAND2_X1
* cell instance $2645 r0 *1 176.89,100.8
X$2645 6073 112 113 6820 INV_X1
* cell instance $2651 r0 *1 181.07,100.8
X$2651 5394 112 113 6772 BUF_X1
* cell instance $2652 r0 *1 181.64,100.8
X$2652 6989 6772 112 113 6552 XNOR2_X2
* cell instance $2653 r0 *1 183.54,100.8
X$2653 6703 3926 6702 112 113 6418 MUX2_X1
* cell instance $2655 r0 *1 185.25,100.8
X$2655 6822 7270 112 113 6768 XNOR2_X2
* cell instance $2656 r0 *1 187.15,100.8
X$2656 6274 112 113 6269 BUF_X1
* cell instance $2659 r0 *1 189.43,100.8
X$2659 5997 6165 112 113 6704 XNOR2_X2
* cell instance $2661 r0 *1 192.85,100.8
X$2661 112 6703 6556 6766 6705 113 DFF_X1
* cell instance $2664 r0 *1 197.22,100.8
X$2664 112 6764 5558 6706 6707 113 DFF_X2
* cell instance $2665 r0 *1 200.83,100.8
X$2665 6707 4948 6730 112 113 6764 MUX2_X1
* cell instance $2668 r0 *1 204.44,100.8
X$2668 6709 112 113 6421 BUF_X2
* cell instance $2671 m0 *1 207.48,100.8
X$2671 5767 6710 6557 112 113 6711 NAND3_X1
* cell instance $2673 m0 *1 208.24,100.8
X$2673 6557 6558 6711 113 6606 112 OAI21_X1
* cell instance $2674 m0 *1 209,100.8
X$2674 6170 6754 6605 6606 5427 112 113 6760 AOI221_X1
* cell instance $2675 m0 *1 210.14,100.8
X$2675 6006 6712 6277 112 6605 113 AOI21_X1
* cell instance $2676 m0 *1 210.9,100.8
X$2676 6167 6001 112 113 6712 NAND2_X1
* cell instance $2677 m0 *1 211.47,100.8
X$2677 6004 6167 6169 113 6713 112 OAI21_X1
* cell instance $2679 r0 *1 207.48,100.8
X$2679 6763 112 113 6827 INV_X4
* cell instance $2680 r0 *1 208.43,100.8
X$2680 5450 112 113 6763 BUF_X1
* cell instance $2681 r0 *1 209,100.8
X$2681 6947 6835 6760 113 112 6824 OAI21_X2
* cell instance $2683 r0 *1 210.71,100.8
X$2683 112 6825 6166 6757 6755 113 AOI21_X4
* cell instance $2684 m0 *1 213.56,100.8
X$2684 5657 112 113 6328 BUF_X1
* cell instance $2685 m0 *1 212.61,100.8
X$2685 6166 5569 112 113 6560 NOR2_X2
* cell instance $2686 m0 *1 214.13,100.8
X$2686 6557 5869 6560 5863 6714 113 112 6597 OAI221_X1
* cell instance $2687 m0 *1 215.27,100.8
X$2687 6004 112 113 6714 CLKBUF_X3
* cell instance $2688 m0 *1 216.22,100.8
X$2688 5427 6277 6561 5781 113 112 6754 OAI22_X1
* cell instance $2690 r0 *1 213.18,100.8
X$2690 5865 6427 113 112 6757 AND2_X1
* cell instance $2691 r0 *1 213.94,100.8
X$2691 5783 6006 112 113 6755 NAND2_X1
* cell instance $2692 r0 *1 214.51,100.8
X$2692 6278 6006 6167 112 6746 113 AOI21_X1
* cell instance $2694 r0 *1 215.65,100.8
X$2694 5450 112 113 6750 BUF_X2
* cell instance $2696 r0 *1 216.6,100.8
X$2696 6870 5898 6283 112 113 6753 NAND3_X1
* cell instance $2697 r0 *1 217.36,100.8
X$2697 6585 6753 6830 112 6869 113 AOI21_X1
* cell instance $2698 m0 *1 218.5,100.8
X$2698 6287 6002 6169 113 112 6718 AND3_X1
* cell instance $2699 m0 *1 217.55,100.8
X$2699 5863 112 113 6717 CLKBUF_X3
* cell instance $2701 m0 *1 219.64,100.8
X$2701 6562 6169 6002 112 6748 113 AOI21_X1
* cell instance $2702 m0 *1 220.4,100.8
X$2702 6563 6748 6432 113 6716 112 OAI21_X1
* cell instance $2704 m0 *1 221.35,100.8
X$2704 6717 5872 6329 113 6563 112 OAI21_X1
* cell instance $2707 r0 *1 218.12,100.8
X$2707 6032 6715 6721 112 113 6870 NAND3_X1
* cell instance $2709 r0 *1 219.64,100.8
X$2709 6430 6427 6750 6717 113 112 6832 OAI22_X1
* cell instance $2711 r0 *1 220.78,100.8
X$2711 6745 6003 112 113 6430 NOR2_X1
* cell instance $2713 r0 *1 221.54,100.8
X$2713 6746 6440 6710 5427 6280 112 113 6719 AOI221_X1
* cell instance $2715 r0 *1 223.06,100.8
X$2715 6435 6719 6835 6720 6866 113 112 6744 OAI221_X1
* cell instance $2717 m0 *1 223.25,100.8
X$2717 6434 6564 112 113 6720 NOR2_X1
* cell instance $2719 m0 *1 224.2,100.8
X$2719 6721 6589 5564 6717 113 112 6743 OAI22_X1
* cell instance $2721 r0 *1 224.58,100.8
X$2721 6744 6953 6460 113 6722 112 OAI21_X1
* cell instance $2723 m0 *1 225.72,100.8
X$2723 6561 6175 6311 6564 5770 5876 112 113 OAI221_X2
* cell instance $2725 m0 *1 227.81,100.8
X$2725 6280 112 113 6721 CLKBUF_X3
* cell instance $2726 m0 *1 228.76,100.8
X$2726 5769 112 113 6561 INV_X2
* cell instance $2728 r0 *1 225.53,100.8
X$2728 5780 113 6723 112 BUF_X4
* cell instance $2729 r0 *1 226.86,100.8
X$2729 6173 5424 5564 112 113 6837 NAND3_X1
* cell instance $2730 r0 *1 227.62,100.8
X$2730 5658 6173 6721 113 6861 112 OAI21_X1
* cell instance $2731 r0 *1 228.38,100.8
X$2731 5658 6710 112 113 6724 NOR2_X1
* cell instance $2733 r0 *1 229.33,100.8
X$2733 6724 6839 112 113 6854 NAND2_X1
* cell instance $2734 m0 *1 229.9,100.8
X$2734 5565 6277 6839 6562 6575 113 112 6725 OAI221_X1
* cell instance $2736 m0 *1 231.04,100.8
X$2736 6171 113 6562 112 BUF_X4
* cell instance $2737 m0 *1 232.37,100.8
X$2737 6011 6733 6571 112 113 6732 MUX2_X1
* cell instance $2740 r0 *1 230.66,100.8
X$2740 6725 6723 6732 112 113 6734 MUX2_X1
* cell instance $2741 r0 *1 231.99,100.8
X$2741 6734 6841 6842 6722 6848 5201 112 113 OAI221_X2
* cell instance $2742 m0 *1 234.27,100.8
X$2742 6726 112 113 5676 BUF_X1
* cell instance $2747 r0 *1 234.08,100.8
X$2747 6710 5770 113 112 6847 XNOR2_X1
* cell instance $2753 r0 *1 236.36,100.8
X$2753 6728 112 113 6730 BUF_X1
* cell instance $2754 r0 *1 236.93,100.8
X$2754 6727 112 113 6846 BUF_X1
* cell instance $2756 r0 *1 238.26,100.8
X$2756 6729 112 113 6844 BUF_X1
* cell instance $2761 m0 *1 37.05,70
X$2761 112 3762 113 3765 BUF_X8
* cell instance $2763 m0 *1 39.52,70
X$2763 3857 3810 3766 112 113 3858 MUX2_X1
* cell instance $2764 m0 *1 40.85,70
X$2764 3859 112 113 3855 CLKBUF_X3
* cell instance $2766 m0 *1 42.56,70
X$2766 3763 3811 16600 113 112 3767 HA_X1
* cell instance $2767 m0 *1 44.46,70
X$2767 3763 3811 16578 113 112 3916 HA_X1
* cell instance $2769 m0 *1 46.55,70
X$2769 3767 113 4072 112 BUF_X4
* cell instance $2774 r0 *1 37.05,70
X$2774 3975 3973 3851 112 113 3911 MUX2_X1
* cell instance $2776 r0 *1 38.57,70
X$2776 3856 3911 3860 113 3857 112 OAI21_X1
* cell instance $2778 r0 *1 39.52,70
X$2778 3858 3865 3913 112 113 4019 MUX2_X1
* cell instance $2781 r0 *1 41.42,70
X$2781 3810 4072 3861 112 3862 113 AOI21_X1
* cell instance $2782 r0 *1 42.18,70
X$2782 3854 3862 3860 112 4070 113 AOI21_X1
* cell instance $2784 r0 *1 43.13,70
X$2784 3863 3811 112 113 3914 NOR2_X1
* cell instance $2787 r0 *1 44.27,70
X$2787 3914 3861 3866 113 3978 112 OAI21_X1
* cell instance $2788 r0 *1 45.03,70
X$2788 3979 3978 3864 112 4022 113 AOI21_X1
* cell instance $2789 r0 *1 45.79,70
X$2789 3855 4024 112 113 3917 NOR2_X1
* cell instance $2790 r0 *1 46.36,70
X$2790 3865 4023 3917 112 3864 113 AOI21_X1
* cell instance $2792 r0 *1 47.31,70
X$2792 3863 3866 112 113 4023 NAND2_X1
* cell instance $2794 r0 *1 48.07,70
X$2794 3859 3763 3661 112 113 3980 NAND3_X1
* cell instance $2796 m0 *1 50.73,70
X$2796 1899 1112 16596 113 112 3812 HA_X1
* cell instance $2798 m0 *1 52.63,70
X$2798 3812 112 113 3564 INV_X1
* cell instance $2800 m0 *1 54.53,70
X$2800 2217 1113 1727 112 3867 113 AOI21_X1
* cell instance $2801 m0 *1 55.29,70
X$2801 3867 1952 1871 112 3919 113 AOI21_X1
* cell instance $2806 m0 *1 56.43,70
X$2806 3814 2096 3919 112 3920 113 AOI21_X1
* cell instance $2808 m0 *1 164.73,179.2
X$2808 12218 11442 11602 13398 12930 113 112 13505 OAI221_X1
* cell instance $2809 m0 *1 163.97,179.2
X$2809 13183 13099 12218 112 113 13173 NAND3_X1
* cell instance $2810 m0 *1 165.87,179.2
X$2810 12838 11526 11914 112 113 13506 NAND3_X1
* cell instance $2811 m0 *1 166.63,179.2
X$2811 13505 13506 11129 112 113 11231 NAND3_X1
* cell instance $2812 m0 *1 167.39,179.2
X$2812 11919 11525 11526 113 13444 112 OAI21_X1
* cell instance $2814 m0 *1 169.67,179.2
X$2814 13410 11770 112 113 13400 NOR2_X1
* cell instance $2816 m0 *1 170.43,179.2
X$2816 13445 13507 11914 113 13476 112 OAI21_X1
* cell instance $2817 m0 *1 171.19,179.2
X$2817 11004 11690 13507 112 13536 113 AOI21_X1
* cell instance $2819 m0 *1 172.14,179.2
X$2819 11446 11448 11842 112 13507 113 AOI21_X1
* cell instance $2820 m0 *1 172.9,179.2
X$2820 13508 112 113 12150 CLKBUF_X2
* cell instance $2821 m0 *1 173.66,179.2
X$2821 13183 13099 11690 112 113 13267 NAND3_X1
* cell instance $2823 m0 *1 174.61,179.2
X$2823 13183 13099 13311 112 113 13359 NAND3_X1
* cell instance $2824 m0 *1 175.37,179.2
X$2824 112 13508 11294 11453 12551 113 NOR3_X4
* cell instance $2825 m0 *1 178.03,179.2
X$2825 112 11012 11294 11453 11860 113 NOR3_X4
* cell instance $2826 m0 *1 180.69,179.2
X$2826 12068 112 113 11600 CLKBUF_X3
* cell instance $2828 m0 *1 181.83,179.2
X$2828 12342 113 10949 112 BUF_X4
* cell instance $2829 m0 *1 183.16,179.2
X$2829 10949 113 12625 112 BUF_X4
* cell instance $2830 m0 *1 184.49,179.2
X$2830 112 11437 113 11012 BUF_X8
* cell instance $2833 m0 *1 187.91,179.2
X$2833 112 13532 13638 17238 8220 113 DFF_X2
* cell instance $2837 r0 *1 164.16,179.2
X$2837 13183 13099 11602 12150 112 113 13605 NAND4_X1
* cell instance $2838 r0 *1 165.11,179.2
X$2838 12068 112 113 11602 CLKBUF_X3
* cell instance $2840 r0 *1 166.44,179.2
X$2840 13444 12619 13602 112 12839 113 AOI21_X1
* cell instance $2842 r0 *1 167.39,179.2
X$2842 13092 11855 112 113 13667 NOR2_X1
* cell instance $2843 r0 *1 167.96,179.2
X$2843 12880 11860 112 113 13602 OR2_X1
* cell instance $2845 r0 *1 169.1,179.2
X$2845 11289 113 12335 112 BUF_X4
* cell instance $2846 r0 *1 170.43,179.2
X$2846 11765 13321 12349 11693 13577 13475 113 112 AOI221_X2
* cell instance $2848 r0 *1 172.9,179.2
X$2848 13508 112 113 13311 BUF_X2
* cell instance $2849 r0 *1 173.66,179.2
X$2849 10835 13727 113 112 13180 AND2_X1
* cell instance $2850 r0 *1 174.42,179.2
X$2850 11525 13398 112 113 13663 NOR2_X1
* cell instance $2851 r0 *1 174.99,179.2
X$2851 11784 113 13099 112 BUF_X4
* cell instance $2852 r0 *1 176.32,179.2
X$2852 11780 11784 13533 112 113 13090 NAND3_X2
* cell instance $2853 r0 *1 177.65,179.2
X$2853 11780 113 13183 112 BUF_X4
* cell instance $2855 r0 *1 179.74,179.2
X$2855 13599 13030 12215 10834 13578 13604 113 112 AOI221_X2
* cell instance $2860 r0 *1 182.02,179.2
X$2860 11913 11765 12771 113 13658 112 OAI21_X1
* cell instance $2862 r0 *1 182.97,179.2
X$2862 12342 113 11855 112 BUF_X4
* cell instance $2864 r0 *1 184.49,179.2
X$2864 12344 113 11765 112 BUF_X4
* cell instance $2865 r0 *1 185.82,179.2
X$2865 11780 11784 112 12344 113 NAND2_X4
* cell instance $2868 m0 *1 195.13,179.2
X$2868 112 16821 13447 13652 13184 113 DFF_X1
* cell instance $2873 m0 *1 202.35,179.2
X$2873 112 12350 12103 113 BUF_X32
* cell instance $2875 m0 *1 211.85,179.2
X$2875 11649 113 10372 112 BUF_X4
* cell instance $2876 m0 *1 213.18,179.2
X$2876 13103 112 113 13219 BUF_X2
* cell instance $2877 m0 *1 213.94,179.2
X$2877 13103 112 113 13363 BUF_X2
* cell instance $2878 m0 *1 214.7,179.2
X$2878 13529 11649 112 113 13450 NAND2_X1
* cell instance $2879 m0 *1 215.27,179.2
X$2879 11790 113 11335 112 BUF_X4
* cell instance $2880 m0 *1 216.6,179.2
X$2880 12366 11030 11787 112 113 13531 NAND3_X1
* cell instance $2881 m0 *1 217.36,179.2
X$2881 11624 11790 11937 113 13529 112 OAI21_X1
* cell instance $2883 m0 *1 218.31,179.2
X$2883 12266 112 113 11029 CLKBUF_X3
* cell instance $2884 m0 *1 219.26,179.2
X$2884 11646 11960 13368 112 113 13451 NOR3_X1
* cell instance $2885 m0 *1 220.02,179.2
X$2885 11460 11628 10910 113 13384 112 OAI21_X1
* cell instance $2889 r0 *1 197.79,179.2
X$2889 9356 13579 113 13651 112 XOR2_X2
* cell instance $2890 r0 *1 199.5,179.2
X$2890 9807 10267 113 13580 112 XOR2_X2
* cell instance $2896 r0 *1 207.1,179.2
X$2896 11790 112 113 11305 CLKBUF_X3
* cell instance $2897 r0 *1 208.05,179.2
X$2897 11638 12103 16687 113 112 12530 HA_X1
* cell instance $2898 r0 *1 209.95,179.2
X$2898 13214 13648 13364 112 12124 113 AOI21_X1
* cell instance $2900 r0 *1 210.9,179.2
X$2900 13449 113 11346 112 BUF_X4
* cell instance $2901 r0 *1 212.23,179.2
X$2901 11313 12103 16702 113 112 13596 HA_X1
* cell instance $2902 r0 *1 214.13,179.2
X$2902 13596 12366 13531 113 11653 112 OAI21_X1
* cell instance $2903 r0 *1 214.89,179.2
X$2903 13596 112 113 12804 INV_X1
* cell instance $2904 r0 *1 215.27,179.2
X$2904 13587 13365 11302 112 113 13015 OR3_X1
* cell instance $2905 r0 *1 216.22,179.2
X$2905 13368 11790 113 112 13593 XNOR2_X1
* cell instance $2906 r0 *1 217.36,179.2
X$2906 13581 10488 11029 13593 10898 113 112 AOI211_X2
* cell instance $2908 r0 *1 219.45,179.2
X$2908 11029 113 12086 112 BUF_X4
* cell instance $2909 r0 *1 220.78,179.2
X$2909 11964 112 113 13452 BUF_X1
* cell instance $2910 m0 *1 222.49,179.2
X$2910 11305 10488 112 113 13525 NAND2_X1
* cell instance $2911 m0 *1 221.16,179.2
X$2911 13527 13525 13590 12366 12526 13454 112 113 13273 OAI33_X1
* cell instance $2912 m0 *1 223.06,179.2
X$2912 11649 11147 11302 112 113 12522 MUX2_X1
* cell instance $2913 m0 *1 224.39,179.2
X$2913 13448 11313 16497 113 112 13016 HA_X1
* cell instance $2915 r0 *1 221.35,179.2
X$2915 10864 11624 112 113 13590 NOR2_X1
* cell instance $2916 r0 *1 221.92,179.2
X$2916 12266 13368 112 113 13527 NOR2_X1
* cell instance $2917 r0 *1 222.49,179.2
X$2917 13104 11022 11309 112 13453 113 AOI21_X1
* cell instance $2918 r0 *1 223.25,179.2
X$2918 12237 10488 112 113 13106 NOR2_X1
* cell instance $2919 r0 *1 223.82,179.2
X$2919 11638 13448 13641 113 112 13587 HA_X1
* cell instance $2921 r0 *1 226.1,179.2
X$2921 13642 113 11787 112 BUF_X4
* cell instance $2923 m0 *1 226.67,179.2
X$2923 10372 11313 12985 112 113 13513 NOR3_X1
* cell instance $2924 m0 *1 227.62,179.2
X$2924 13514 13513 12088 13509 12366 113 112 13205 OAI221_X1
* cell instance $2926 m0 *1 228.95,179.2
X$2926 11335 113 12366 112 BUF_X4
* cell instance $2929 m0 *1 231.23,179.2
X$2929 11638 12510 16545 113 112 13509 HA_X1
* cell instance $2935 r0 *1 229.9,179.2
X$2935 13509 12366 13513 112 113 11808 MUX2_X1
* cell instance $2946 m0 *1 164.54,22.4
X$2946 327 463 324 357 464 113 112 404 OAI221_X1
* cell instance $2947 m0 *1 163.4,22.4
X$2947 424 283 113 112 464 XNOR2_X1
* cell instance $2948 m0 *1 165.68,22.4
X$2948 425 534 372 113 462 112 OAI21_X1
* cell instance $2949 m0 *1 166.44,22.4
X$2949 479 425 423 113 372 112 OAI21_X1
* cell instance $2950 m0 *1 167.2,22.4
X$2950 426 389 112 113 463 NAND2_X1
* cell instance $2951 m0 *1 167.77,22.4
X$2951 404 284 462 112 457 113 AOI21_X1
* cell instance $2954 r0 *1 163.59,22.4
X$2954 478 423 380 389 326 113 112 596 OAI221_X1
* cell instance $2955 r0 *1 164.73,22.4
X$2955 425 113 281 112 BUF_X4
* cell instance $2957 r0 *1 166.44,22.4
X$2957 424 112 113 506 CLKBUF_X3
* cell instance $2959 r0 *1 167.58,22.4
X$2959 427 318 112 113 518 NOR2_X1
* cell instance $2960 r0 *1 168.15,22.4
X$2960 426 241 112 113 480 NAND2_X2
* cell instance $2961 m0 *1 169.1,22.4
X$2961 424 428 112 113 427 NAND2_X1
* cell instance $2963 m0 *1 169.67,22.4
X$2963 402 296 112 113 460 NAND2_X1
* cell instance $2964 m0 *1 170.24,22.4
X$2964 324 429 459 112 516 113 AOI21_X1
* cell instance $2965 m0 *1 171,22.4
X$2965 373 374 427 112 458 113 AOI21_X1
* cell instance $2968 r0 *1 169.48,22.4
X$2968 425 478 318 112 429 113 AOI21_X1
* cell instance $2970 r0 *1 170.43,22.4
X$2970 537 516 515 538 113 112 432 OAI22_X1
* cell instance $2971 r0 *1 171.38,22.4
X$2971 481 234 112 113 459 NAND2_X1
* cell instance $2973 m0 *1 173.47,22.4
X$2973 457 431 112 113 376 NOR2_X1
* cell instance $2974 m0 *1 172.14,22.4
X$2974 386 400 375 112 113 477 MUX2_X1
* cell instance $2975 m0 *1 174.04,22.4
X$2975 112 376 398 294 379 512 392 456 113 AOI222_X2
* cell instance $2976 m0 *1 176.7,22.4
X$2976 440 377 432 112 456 113 AOI21_X1
* cell instance $2977 m0 *1 177.46,22.4
X$2977 296 434 455 112 377 113 AOI21_X1
* cell instance $2979 m0 *1 178.98,22.4
X$2979 380 425 112 113 381 NOR2_X1
* cell instance $2980 m0 *1 179.55,22.4
X$2980 383 381 382 112 453 113 AOI21_X1
* cell instance $2981 m0 *1 180.31,22.4
X$2981 438 441 112 113 383 NAND2_X1
* cell instance $2982 m0 *1 180.88,22.4
X$2982 320 423 357 112 113 338 MUX2_X1
* cell instance $2983 m0 *1 182.21,22.4
X$2983 450 318 324 113 390 112 OAI21_X1
* cell instance $2985 m0 *1 183.16,22.4
X$2985 440 296 112 113 504 NAND2_X1
* cell instance $2987 r0 *1 172.14,22.4
X$2987 232 112 113 430 BUF_X1
* cell instance $2989 r0 *1 173.09,22.4
X$2989 482 463 237 112 113 483 NAND3_X1
* cell instance $2991 r0 *1 174.04,22.4
X$2991 401 112 113 199 CLKBUF_X3
* cell instance $2992 r0 *1 174.99,22.4
X$2992 237 480 482 112 433 113 AOI21_X1
* cell instance $2994 r0 *1 175.94,22.4
X$2994 431 435 483 112 564 113 AOI21_X1
* cell instance $2996 r0 *1 176.89,22.4
X$2996 352 484 237 113 455 112 OAI21_X1
* cell instance $2997 r0 *1 177.65,22.4
X$2997 436 357 485 112 434 113 AOI21_X1
* cell instance $2999 r0 *1 178.79,22.4
X$2999 433 511 541 113 559 112 OAI21_X1
* cell instance $3000 r0 *1 179.55,22.4
X$3000 437 112 113 428 BUF_X1
* cell instance $3005 r0 *1 180.31,22.4
X$3005 439 357 485 112 435 113 AOI21_X1
* cell instance $3006 r0 *1 181.07,22.4
X$3006 437 486 319 553 506 385 112 113 OAI221_X2
* cell instance $3007 r0 *1 183.16,22.4
X$3007 503 603 504 112 113 379 NOR3_X1
* cell instance $3009 m0 *1 184.3,22.4
X$3009 448 446 447 287 112 113 392 NAND4_X1
* cell instance $3011 m0 *1 185.25,22.4
X$3011 489 490 441 112 113 446 NOR3_X1
* cell instance $3013 m0 *1 186.2,22.4
X$3013 444 241 112 113 447 NAND2_X1
* cell instance $3014 m0 *1 186.77,22.4
X$3014 423 380 112 113 388 NOR2_X1
* cell instance $3015 m0 *1 187.34,22.4
X$3015 283 238 112 113 442 NAND2_X1
* cell instance $3016 m0 *1 187.91,22.4
X$3016 442 496 388 237 436 546 112 113 444 OAI33_X1
* cell instance $3018 r0 *1 184.11,22.4
X$3018 504 112 113 488 INV_X1
* cell instance $3021 r0 *1 185.44,22.4
X$3021 491 486 112 113 490 NOR2_X1
* cell instance $3024 r0 *1 186.58,22.4
X$3024 492 498 327 113 491 112 OAI21_X1
* cell instance $3026 r0 *1 187.53,22.4
X$3026 492 498 494 547 112 113 496 NOR4_X1
* cell instance $3027 r0 *1 188.48,22.4
X$3027 386 495 112 113 493 NOR2_X1
* cell instance $3029 r0 *1 189.24,22.4
X$3029 400 113 423 112 BUF_X4
* cell instance $3030 m0 *1 190.95,22.4
X$3030 330 112 113 443 BUF_X1
* cell instance $3031 m0 *1 189.62,22.4
X$3031 400 113 426 112 BUF_X4
* cell instance $3043 r0 *1 190.57,22.4
X$3043 494 113 234 112 BUF_X4
* cell instance $3044 r0 *1 191.9,22.4
X$3044 237 387 605 113 112 495 HA_X1
* cell instance $3057 m0 *1 102.03,179.2
X$3057 13534 13540 11520 112 113 13541 NOR3_X1
* cell instance $3058 m0 *1 100.7,179.2
X$3058 13303 12135 13539 112 113 13437 MUX2_X1
* cell instance $3061 m0 *1 109.63,179.2
X$3061 112 16874 9694 13560 13562 113 DFF_X1
* cell instance $3063 m0 *1 113.05,179.2
X$3063 3162 113 3928 112 BUF_X4
* cell instance $3065 m0 *1 114.57,179.2
X$3065 13603 112 113 10562 CLKBUF_X3
* cell instance $3066 m0 *1 115.52,179.2
X$3066 112 13563 13562 8292 8144 113 DFF_X2
* cell instance $3067 m0 *1 119.13,179.2
X$3067 5172 13542 112 113 13564 XOR2_X1
* cell instance $3068 m0 *1 120.27,179.2
X$3068 8144 112 113 13542 BUF_X1
* cell instance $3071 m0 *1 122.55,179.2
X$3071 13497 113 5172 112 BUF_X4
* cell instance $3075 m0 *1 126.35,179.2
X$3075 10021 3162 13498 112 113 13566 MUX2_X1
* cell instance $3078 m0 *1 129.96,179.2
X$3078 10109 12844 113 112 13567 XNOR2_X1
* cell instance $3081 m0 *1 90.82,179.2
X$3081 13556 13347 11984 12413 13433 13496 112 113 13029 OAI33_X1
* cell instance $3082 m0 *1 92.34,179.2
X$3082 11888 13434 13495 11259 13492 12688 112 113 OAI221_X2
* cell instance $3084 m0 *1 95.19,179.2
X$3084 11574 12591 11411 113 13538 112 OAI21_X1
* cell instance $3085 m0 *1 95.95,179.2
X$3085 12133 112 113 12270 CLKBUF_X3
* cell instance $3086 m0 *1 96.9,179.2
X$3086 12820 12320 11663 13537 13540 113 112 AOI211_X2
* cell instance $3088 r0 *1 90.82,179.2
X$3088 13557 13493 10120 113 13556 112 OAI21_X1
* cell instance $3091 r0 *1 92.53,179.2
X$3091 11577 12602 10658 13495 113 112 13661 OAI22_X1
* cell instance $3093 r0 *1 93.67,179.2
X$3093 13558 12598 11884 113 13728 112 OAI21_X1
* cell instance $3094 r0 *1 94.43,179.2
X$3094 12602 13558 12273 112 113 12146 NOR3_X1
* cell instance $3096 r0 *1 95.57,179.2
X$3096 12746 12319 112 113 13559 NAND2_X1
* cell instance $3097 r0 *1 96.14,179.2
X$3097 13435 13555 12320 112 113 13600 NAND3_X1
* cell instance $3098 r0 *1 96.9,179.2
X$3098 12270 113 12857 112 BUF_X4
* cell instance $3101 m0 *1 98.99,179.2
X$3101 13436 11577 13538 112 113 13537 MUX2_X1
* cell instance $3103 r0 *1 101.65,179.2
X$3103 10120 112 113 12413 CLKBUF_X3
* cell instance $3104 r0 *1 102.6,179.2
X$3104 13541 11520 13691 112 13601 113 AOI21_X1
* cell instance $3108 r0 *1 110.58,179.2
X$3108 13668 112 113 10109 CLKBUF_X3
* cell instance $3109 r0 *1 111.53,179.2
X$3109 112 17018 13603 13561 13562 113 DFF_X1
* cell instance $3111 r0 *1 115.14,179.2
X$3111 13737 113 9091 112 BUF_X4
* cell instance $3114 r0 *1 117.42,179.2
X$3114 8133 112 113 13562 CLKBUF_X3
* cell instance $3115 r0 *1 118.37,179.2
X$3115 13562 112 113 17178 INV_X2
* cell instance $3117 r0 *1 119.7,179.2
X$3117 112 17016 13497 13565 13562 113 DFF_X1
* cell instance $3123 r0 *1 126.35,179.2
X$3123 112 13608 13083 17253 9600 113 DFF_X2
* cell instance $3126 m0 *1 131.67,179.2
X$3126 13544 8295 13546 112 113 13543 MUX2_X1
* cell instance $3128 m0 *1 133,179.2
X$3128 112 16906 13547 13543 13083 113 DFF_X1
* cell instance $3129 m0 *1 136.23,179.2
X$3129 13547 113 8008 112 BUF_X4
* cell instance $3130 m0 *1 137.56,179.2
X$3130 1747 112 113 8539 CLKBUF_X3
* cell instance $3131 m0 *1 138.51,179.2
X$3131 8539 112 113 17164 INV_X2
* cell instance $3136 r0 *1 134.9,179.2
X$3136 13568 113 9217 112 BUF_X4
* cell instance $3138 r0 *1 136.42,179.2
X$3138 5757 8008 113 13609 112 XOR2_X2
* cell instance $3140 r0 *1 138.51,179.2
X$3140 13579 13570 113 13814 112 XOR2_X2
* cell instance $3143 m0 *1 140.22,179.2
X$3143 10709 13481 112 113 13499 XOR2_X1
* cell instance $3147 r0 *1 140.79,179.2
X$3147 13610 8295 13499 112 113 13569 MUX2_X1
* cell instance $3151 r0 *1 143.45,179.2
X$3151 13612 4209 13548 112 113 13613 MUX2_X1
* cell instance $3152 m0 *1 144.21,179.2
X$3152 13500 13417 112 113 13548 XOR2_X1
* cell instance $3156 r0 *1 144.78,179.2
X$3156 112 17036 13615 13613 11904 113 DFF_X1
* cell instance $3157 r0 *1 148.01,179.2
X$3157 13615 112 113 13500 CLKBUF_X3
* cell instance $3158 m0 *1 148.96,179.2
X$3158 10267 13500 113 13439 112 XOR2_X2
* cell instance $3162 r0 *1 148.96,179.2
X$3162 11118 13362 112 113 13614 XNOR2_X2
* cell instance $3164 r0 *1 151.05,179.2
X$3164 4655 13570 113 12641 112 XOR2_X2
* cell instance $3166 m0 *1 152.57,179.2
X$3166 12492 11913 112 113 13549 NOR2_X1
* cell instance $3167 m0 *1 153.33,179.2
X$3167 13549 12619 13501 112 13611 113 AOI21_X1
* cell instance $3168 m0 *1 154.09,179.2
X$3168 13441 11914 13440 112 13422 113 AOI21_X1
* cell instance $3169 m0 *1 154.85,179.2
X$3169 11778 12337 11129 113 13571 112 OAI21_X1
* cell instance $3170 m0 *1 155.61,179.2
X$3170 12551 11861 12337 112 13501 113 AOI21_X1
* cell instance $3172 m0 *1 156.56,179.2
X$3172 10949 112 113 11914 CLKBUF_X3
* cell instance $3173 m0 *1 157.51,179.2
X$3173 13572 11765 12493 112 113 13502 MUX2_X1
* cell instance $3174 m0 *1 158.84,179.2
X$3174 13502 11004 12222 13503 13443 13545 113 112 AOI221_X2
* cell instance $3175 m0 *1 160.93,179.2
X$3175 12215 11288 11860 112 13503 113 AOI21_X1
* cell instance $3176 m0 *1 161.69,179.2
X$3176 13090 12625 112 113 13504 NAND2_X1
* cell instance $3177 m0 *1 162.26,179.2
X$3177 13504 13445 112 113 13607 NOR2_X1
* cell instance $3183 r0 *1 154.09,179.2
X$3183 13636 13571 11129 13611 10835 12720 112 113 OAI221_X2
* cell instance $3185 r0 *1 156.56,179.2
X$3185 11765 113 11442 112 BUF_X4
* cell instance $3186 r0 *1 157.89,179.2
X$3186 13573 112 113 13572 INV_X1
* cell instance $3187 r0 *1 158.27,179.2
X$3187 13573 11433 13605 113 13442 112 OAI21_X1
* cell instance $3190 r0 *1 160.17,179.2
X$3190 12335 13574 13173 113 112 13575 AND3_X1
* cell instance $3191 r0 *1 161.12,179.2
X$3191 13607 13575 13357 112 113 13606 NOR3_X1
* cell instance $3192 r0 *1 161.88,179.2
X$3192 13606 11003 13604 13576 113 12765 112 NOR4_X2
* cell instance $3194 m0 *1 174.99,58.8
X$3194 2803 2917 113 112 2962 AND2_X1
* cell instance $3195 m0 *1 174.04,58.8
X$3195 2689 112 113 3083 INV_X4
* cell instance $3196 m0 *1 175.75,58.8
X$3196 2804 2913 112 113 2806 NOR2_X2
* cell instance $3197 m0 *1 176.7,58.8
X$3197 2757 2746 2640 3012 2970 112 113 3080 AOI221_X1
* cell instance $3199 r0 *1 174.04,58.8
X$3199 3082 2864 3084 113 112 3166 OAI21_X2
* cell instance $3200 r0 *1 175.37,58.8
X$3200 2911 2404 2971 113 112 3208 OAI21_X4
* cell instance $3201 r0 *1 177.84,58.8
X$3201 2916 3081 3080 3076 3210 3169 112 113 OAI221_X2
* cell instance $3202 m0 *1 179.93,58.8
X$3202 2358 2806 2963 113 112 2967 OAI21_X2
* cell instance $3203 m0 *1 178.22,58.8
X$3203 2968 2967 2745 2961 112 113 2966 AOI22_X2
* cell instance $3206 m0 *1 184.49,58.8
X$3206 2861 2919 112 113 2741 NOR2_X1
* cell instance $3209 r0 *1 179.93,58.8
X$3209 2865 2966 3077 3115 112 3168 113 NAND4_X2
* cell instance $3213 r0 *1 181.64,58.8
X$3213 3112 2358 2574 113 2860 112 OAI21_X1
* cell instance $3214 r0 *1 182.4,58.8
X$3214 3014 2916 112 113 3076 NAND2_X1
* cell instance $3217 r0 *1 185.25,58.8
X$3217 2919 3075 112 113 1936 XNOR2_X2
* cell instance $3218 m0 *1 186.39,58.8
X$3218 2861 2920 112 113 2365 NOR2_X1
* cell instance $3221 m0 *1 187.15,58.8
X$3221 2919 112 113 2920 INV_X1
* cell instance $3223 m0 *1 187.72,58.8
X$3223 3015 2920 112 113 2580 NAND2_X1
* cell instance $3226 m0 *1 195.89,58.8
X$3226 2958 113 2037 112 BUF_X4
* cell instance $3228 m0 *1 197.41,58.8
X$3228 2921 112 113 2627 INV_X2
* cell instance $3229 m0 *1 197.98,58.8
X$3229 2037 113 2810 112 BUF_X4
* cell instance $3230 m0 *1 199.31,58.8
X$3230 2921 112 113 2958 BUF_X2
* cell instance $3232 m0 *1 200.26,58.8
X$3232 2957 3072 2846 2374 2925 2956 113 112 AOI221_X2
* cell instance $3233 m0 *1 202.35,58.8
X$3233 2581 1858 2811 113 2957 112 OAI21_X1
* cell instance $3235 m0 *1 203.3,58.8
X$3235 2044 2257 1937 113 2922 112 OAI21_X1
* cell instance $3237 r0 *1 187.15,58.8
X$3237 2920 3075 112 113 1667 XNOR2_X2
* cell instance $3238 r0 *1 189.05,58.8
X$3238 3015 2919 112 113 2738 NAND2_X1
* cell instance $3240 r0 *1 189.81,58.8
X$3240 3163 3118 113 1674 112 XOR2_X2
* cell instance $3244 r0 *1 196.84,58.8
X$3244 2482 3061 2248 2158 3074 3119 113 112 AOI221_X2
* cell instance $3246 r0 *1 199.31,58.8
X$3246 2369 2482 113 112 3074 AND2_X1
* cell instance $3247 r0 *1 200.07,58.8
X$3247 2945 3021 112 113 3072 NOR2_X1
* cell instance $3248 r0 *1 200.64,58.8
X$3248 3071 2036 1856 113 112 2625 OAI21_X4
* cell instance $3251 r0 *1 203.68,58.8
X$3251 3069 2922 3152 3156 112 113 3017 AOI22_X2
* cell instance $3252 m0 *1 205.01,58.8
X$3252 2153 2581 2923 2260 2258 3069 113 112 AOI221_X2
* cell instance $3253 m0 *1 204.44,58.8
X$3253 2482 2811 112 113 2923 NAND2_X1
* cell instance $3255 m0 *1 207.29,58.8
X$3255 2262 2697 2846 112 3018 113 AOI21_X1
* cell instance $3256 m0 *1 208.05,58.8
X$3256 2924 2813 112 113 3019 NOR2_X1
* cell instance $3257 m0 *1 208.62,58.8
X$3257 2810 113 2498 112 BUF_X4
* cell instance $3258 m0 *1 209.95,58.8
X$3258 2156 2276 112 113 2837 NAND2_X1
* cell instance $3260 m0 *1 210.71,58.8
X$3260 3022 2484 2276 2381 3050 113 112 AOI211_X2
* cell instance $3261 m0 *1 212.42,58.8
X$3261 2276 2398 2701 113 2925 112 OAI21_X1
* cell instance $3263 m0 *1 213.37,58.8
X$3263 1940 2372 2607 2926 112 113 2949 AOI22_X1
* cell instance $3264 m0 *1 214.32,58.8
X$3264 2950 2949 2376 1940 2930 2948 112 113 OAI221_X2
* cell instance $3266 m0 *1 216.6,58.8
X$3266 2494 2695 2589 2828 2946 3052 113 112 AOI221_X2
* cell instance $3268 m0 *1 218.88,58.8
X$3268 2937 2945 2595 2587 2927 2488 112 113 OAI221_X2
* cell instance $3270 m0 *1 221.16,58.8
X$3270 2700 2137 2814 2588 2941 3030 113 112 AOI221_X2
* cell instance $3273 r0 *1 205.77,58.8
X$3273 2153 2369 112 113 3122 NAND2_X1
* cell instance $3274 r0 *1 206.34,58.8
X$3274 3027 3020 3218 113 3066 112 OAI21_X1
* cell instance $3276 r0 *1 207.29,58.8
X$3276 3065 3066 3018 113 3123 112 OAI21_X1
* cell instance $3277 r0 *1 208.05,58.8
X$3277 3022 1942 2264 112 3020 113 AOI21_X1
* cell instance $3278 r0 *1 208.81,58.8
X$3278 2498 3020 3045 2945 2148 113 112 3157 OAI221_X1
* cell instance $3279 r0 *1 209.95,58.8
X$3279 2923 3062 3157 113 3125 112 OAI21_X1
* cell instance $3281 r0 *1 211.09,58.8
X$3281 3061 1940 3025 112 3062 113 AOI21_X1
* cell instance $3283 r0 *1 212.23,58.8
X$3283 2372 3126 3023 3024 2926 3057 113 112 AOI221_X2
* cell instance $3285 r0 *1 214.51,58.8
X$3285 3057 2930 3052 2948 3053 3146 112 113 OAI221_X2
* cell instance $3286 r0 *1 216.6,58.8
X$3286 2150 113 3021 112 BUF_X4
* cell instance $3287 r0 *1 217.93,58.8
X$3287 2381 2276 112 113 3025 NAND2_X1
* cell instance $3289 r0 *1 218.88,58.8
X$3289 2587 3042 2625 112 3049 113 AOI21_X1
* cell instance $3290 r0 *1 219.64,58.8
X$3290 3050 3049 2927 112 113 3046 NOR3_X1
* cell instance $3291 r0 *1 220.4,58.8
X$3291 1859 112 113 3048 BUF_X1
* cell instance $3293 r0 *1 221.35,58.8
X$3293 2702 3046 3045 113 3127 112 OAI21_X1
* cell instance $3296 r0 *1 223.25,58.8
X$3296 1862 2585 2720 2492 3027 113 112 3044 OAI221_X1
* cell instance $3297 m0 *1 223.82,58.8
X$3297 2494 2815 2382 113 112 2928 OAI21_X2
* cell instance $3299 m0 *1 225.15,58.8
X$3299 2926 2832 2701 112 3029 113 AOI21_X1
* cell instance $3300 m0 *1 225.91,58.8
X$3300 2491 2819 2828 112 2929 113 AOI21_X1
* cell instance $3302 m0 *1 226.86,58.8
X$3302 2592 2930 2927 112 113 2932 NOR3_X1
* cell instance $3303 m0 *1 227.62,58.8
X$3303 2827 2846 112 113 2931 NOR2_X1
* cell instance $3305 r0 *1 224.39,58.8
X$3305 3128 3028 3044 2929 112 113 3142 AOI22_X1
* cell instance $3306 r0 *1 225.34,58.8
X$3306 3042 2625 3027 112 113 3028 NAND3_X1
* cell instance $3307 r0 *1 226.1,58.8
X$3307 2829 2928 3036 113 3139 112 OAI21_X1
* cell instance $3309 r0 *1 227.05,58.8
X$3309 2931 3030 3129 3034 112 113 3038 NOR4_X1
* cell instance $3310 r0 *1 228,58.8
X$3310 2492 2153 2819 2720 112 113 3035 AOI22_X1
* cell instance $3311 m0 *1 229.52,58.8
X$3311 2937 2594 3130 113 2936 112 OAI21_X1
* cell instance $3312 m0 *1 228.57,58.8
X$3312 2251 112 113 2926 CLKBUF_X3
* cell instance $3313 m0 *1 230.28,58.8
X$3313 2950 1941 16529 113 112 2819 HA_X1
* cell instance $3314 m0 *1 232.18,58.8
X$3314 2157 2493 1941 112 113 2933 NAND3_X1
* cell instance $3319 r0 *1 229.14,58.8
X$3319 3034 3035 2926 112 3036 113 AOI21_X1
* cell instance $3322 r0 *1 231.04,58.8
X$3322 2936 3033 2926 3034 2934 113 112 3031 OAI221_X1
* cell instance $3323 r0 *1 232.18,58.8
X$3323 3132 2382 2155 112 113 3032 NAND3_X1
* cell instance $3324 r0 *1 232.94,58.8
X$3324 3032 2933 112 113 3033 NAND2_X1
* cell instance $3331 m0 *1 26.03,75.6
X$3331 4609 4354 113 112 4343 AND2_X1
* cell instance $3334 m0 *1 26.98,75.6
X$3334 4343 4289 4458 112 4344 113 AOI21_X1
* cell instance $3335 m0 *1 27.74,75.6
X$3335 3974 113 4067 112 BUF_X4
* cell instance $3336 m0 *1 29.07,75.6
X$3336 4290 112 113 4291 INV_X4
* cell instance $3337 m0 *1 30.02,75.6
X$3337 4354 3971 4346 113 112 4461 AND3_X1
* cell instance $3338 m0 *1 30.97,75.6
X$3338 4347 4294 4346 4182 4348 113 112 4233 OAI221_X1
* cell instance $3340 m0 *1 32.87,75.6
X$3340 4065 4291 112 113 4292 NOR2_X1
* cell instance $3341 m0 *1 33.44,75.6
X$3341 4292 4414 3855 113 4184 112 OAI21_X1
* cell instance $3345 m0 *1 38.95,75.6
X$3345 3563 112 113 4293 INV_X2
* cell instance $3347 m0 *1 39.71,75.6
X$3347 4294 4347 4290 112 113 4295 NOR3_X1
* cell instance $3348 m0 *1 40.47,75.6
X$3348 4296 4295 4182 113 3860 112 OAI21_X1
* cell instance $3363 r0 *1 23.37,75.6
X$3363 3973 112 113 4289 CLKBUF_X3
* cell instance $3364 r0 *1 24.32,75.6
X$3364 4062 4411 3851 112 113 4457 MUX2_X1
* cell instance $3365 r0 *1 25.65,75.6
X$3365 4291 4460 4514 112 113 4458 MUX2_X1
* cell instance $3366 r0 *1 26.98,75.6
X$3366 4457 4412 4459 112 113 4515 MUX2_X1
* cell instance $3367 r0 *1 28.31,75.6
X$3367 4413 4354 4517 113 4459 112 OAI21_X1
* cell instance $3370 r0 *1 29.64,75.6
X$3370 4180 113 4422 112 BUF_X4
* cell instance $3371 r0 *1 30.97,75.6
X$3371 4460 4413 112 113 3853 NAND2_X2
* cell instance $3373 r0 *1 32.11,75.6
X$3373 4182 4462 4063 4422 3852 4416 113 112 AOI221_X2
* cell instance $3374 r0 *1 34.2,75.6
X$3374 4422 3853 4463 113 4415 112 OAI21_X1
* cell instance $3375 r0 *1 34.96,75.6
X$3375 4301 4415 4516 113 4464 112 OAI21_X1
* cell instance $3378 r0 *1 36.29,75.6
X$3378 4464 4069 4466 112 113 4186 MUX2_X1
* cell instance $3380 r0 *1 38,75.6
X$3380 4467 4067 4468 112 3913 113 AOI21_X1
* cell instance $3381 r0 *1 38.76,75.6
X$3381 4298 4300 3563 112 113 4517 NAND3_X1
* cell instance $3382 r0 *1 39.52,75.6
X$3382 4469 4301 112 113 4467 NOR2_X1
* cell instance $3383 r0 *1 40.09,75.6
X$3383 4412 4574 4290 4289 112 113 4469 AOI22_X1
* cell instance $3384 r0 *1 41.04,75.6
X$3384 4072 4520 4416 113 4188 112 OAI21_X1
* cell instance $3386 m0 *1 41.61,75.6
X$3386 3916 4298 4300 112 4296 113 AOI21_X2
* cell instance $3388 r0 *1 43.32,75.6
X$3388 4578 4297 4472 4471 4418 4189 112 113 4417 OAI33_X1
* cell instance $3389 m0 *1 43.51,75.6
X$3389 3976 4062 112 113 4297 NOR2_X1
* cell instance $3391 m0 *1 44.08,75.6
X$3391 3976 4062 4354 112 4418 113 AOI21_X1
* cell instance $3393 m0 *1 45.6,75.6
X$3393 3765 3763 3811 4298 4300 112 113 4299 AOI221_X1
* cell instance $3394 m0 *1 46.74,75.6
X$3394 4291 4294 4347 113 112 4076 OAI21_X2
* cell instance $3395 m0 *1 48.07,75.6
X$3395 4357 4359 112 113 4361 NAND2_X1
* cell instance $3396 m0 *1 48.64,75.6
X$3396 4344 4301 4361 112 113 4143 MUX2_X1
* cell instance $3398 m0 *1 50.16,75.6
X$3398 4079 4074 4302 112 4075 113 AOI21_X1
* cell instance $3402 m0 *1 53.39,75.6
X$3402 4476 4141 3865 4079 4249 113 112 4303 OAI221_X1
* cell instance $3403 m0 *1 54.53,75.6
X$3403 4303 4524 113 112 4364 AND2_X1
* cell instance $3404 m0 *1 55.29,75.6
X$3404 4363 4478 4244 4364 113 112 4304 OAI22_X1
* cell instance $3405 m0 *1 56.24,75.6
X$3405 4348 4422 3866 112 113 4421 MUX2_X1
* cell instance $3409 m0 *1 66.88,75.6
X$3409 4082 112 113 4365 CLKBUF_X3
* cell instance $3413 r0 *1 44.65,75.6
X$3413 4418 3763 112 113 4521 NOR2_X1
* cell instance $3414 r0 *1 45.22,75.6
X$3414 4521 4474 112 113 4522 NOR2_X1
* cell instance $3415 r0 *1 45.79,75.6
X$3415 4620 4514 3859 112 4191 113 AOI21_X1
* cell instance $3418 r0 *1 48.45,75.6
X$3418 3763 4241 112 113 4710 OR2_X1
* cell instance $3421 r0 *1 49.78,75.6
X$3421 4301 112 113 4141 CLKBUF_X3
* cell instance $3423 r0 *1 50.92,75.6
X$3423 4475 4574 4076 113 112 4419 AND3_X1
* cell instance $3426 r0 *1 53.01,75.6
X$3426 4419 3863 4523 112 4476 113 AOI21_X1
* cell instance $3427 r0 *1 53.77,75.6
X$3427 4420 3863 4071 112 113 4586 MUX2_X1
* cell instance $3428 r0 *1 55.1,75.6
X$3428 4471 3762 4421 112 4477 113 AOI21_X1
* cell instance $3430 r0 *1 56.05,75.6
X$3430 4074 4076 4525 113 112 4527 AND3_X1
* cell instance $3432 r0 *1 57.76,75.6
X$3432 4479 4081 4588 112 113 4032 MUX2_X1
* cell instance $3435 r0 *1 60.8,75.6
X$3435 112 17088 4719 3768 4423 113 DFF_X1
* cell instance $3436 r0 *1 64.03,75.6
X$3436 4279 112 113 4423 CLKBUF_X3
* cell instance $3437 r0 *1 64.98,75.6
X$3437 4423 112 113 17184 INV_X2
* cell instance $3441 r0 *1 67.64,75.6
X$3441 4480 113 3922 112 BUF_X4
* cell instance $3445 r0 *1 68.97,75.6
X$3445 4480 113 3985 112 BUF_X4
* cell instance $3448 r0 *1 71.25,75.6
X$3448 4194 113 4867 112 BUF_X4
* cell instance $3449 r0 *1 72.58,75.6
X$3449 4591 4531 4424 4425 4489 4484 113 112 AOI221_X2
* cell instance $3450 m0 *1 74.1,75.6
X$3450 4366 112 113 3987 CLKBUF_X3
* cell instance $3451 m0 *1 72.77,75.6
X$3451 4305 113 4368 112 BUF_X4
* cell instance $3453 r0 *1 74.67,75.6
X$3453 4366 4482 112 4532 113 NAND2_X4
* cell instance $3454 m0 *1 75.62,75.6
X$3454 4317 4200 112 113 4372 NAND2_X1
* cell instance $3458 m0 *1 77.14,75.6
X$3458 4156 4307 112 113 4310 NOR2_X2
* cell instance $3459 m0 *1 78.09,75.6
X$3459 4372 4371 4308 4485 112 113 4309 AOI22_X1
* cell instance $3460 m0 *1 79.04,75.6
X$3460 4309 4375 4148 113 4376 112 OAI21_X1
* cell instance $3461 m0 *1 79.8,75.6
X$3461 4307 113 4308 112 BUF_X4
* cell instance $3462 m0 *1 81.13,75.6
X$3462 4380 4196 112 113 4375 NAND2_X1
* cell instance $3464 r0 *1 76.38,75.6
X$3464 4368 113 4260 112 BUF_X4
* cell instance $3465 r0 *1 77.71,75.6
X$3465 4533 4308 112 113 4371 NOR2_X1
* cell instance $3466 r0 *1 78.28,75.6
X$3466 4376 4595 4484 4428 4534 4431 112 113 4426 OAI33_X1
* cell instance $3467 r0 *1 79.61,75.6
X$3467 4535 4425 4317 112 4485 113 AOI21_X1
* cell instance $3468 r0 *1 80.37,75.6
X$3468 3922 4530 112 113 4427 NAND2_X1
* cell instance $3470 r0 *1 81.13,75.6
X$3470 4368 4026 4317 112 4599 113 AOI21_X1
* cell instance $3471 r0 *1 81.89,75.6
X$3471 3870 4197 4425 4538 113 112 4601 OAI22_X1
* cell instance $3472 m0 *1 82.27,75.6
X$3472 4310 3987 112 113 4487 NAND2_X1
* cell instance $3474 m0 *1 82.84,75.6
X$3474 4375 4311 4382 113 4314 112 OAI21_X1
* cell instance $3476 r0 *1 82.84,75.6
X$3476 4488 4029 112 113 4536 NOR2_X1
* cell instance $3477 r0 *1 83.41,75.6
X$3477 4489 4429 4424 4430 4538 112 113 4605 AOI221_X1
* cell instance $3479 m0 *1 83.98,75.6
X$3479 4252 3984 112 113 4429 NOR2_X2
* cell instance $3481 r0 *1 84.93,75.6
X$3481 4317 4198 4537 113 4312 112 OAI21_X1
* cell instance $3482 m0 *1 86.07,75.6
X$3482 4200 4153 4491 4199 4253 113 112 4388 OAI221_X1
* cell instance $3483 m0 *1 85.31,75.6
X$3483 4312 4315 4313 112 4490 113 AOI21_X1
* cell instance $3484 m0 *1 87.21,75.6
X$3484 3871 3984 112 113 4315 NOR2_X2
* cell instance $3487 r0 *1 85.88,75.6
X$3487 4490 4607 4492 112 113 4428 NOR3_X1
* cell instance $3489 r0 *1 87.02,75.6
X$3489 4092 4315 4313 112 4385 113 AOI21_X1
* cell instance $3490 r0 *1 87.78,75.6
X$3490 4430 4487 4429 4493 113 112 4386 OAI22_X1
* cell instance $3491 m0 *1 90.25,75.6
X$3491 4317 112 113 4433 CLKBUF_X3
* cell instance $3492 m0 *1 88.54,75.6
X$3492 4386 4316 4497 4385 113 4496 112 NOR4_X2
* cell instance $3495 r0 *1 88.92,75.6
X$3495 4314 4494 4495 4431 4496 4604 112 113 4739 OAI33_X1
* cell instance $3496 r0 *1 90.25,75.6
X$3496 4310 4538 112 113 4493 NAND2_X1
* cell instance $3497 r0 *1 90.82,75.6
X$3497 4368 4432 112 113 4313 NAND2_X1
* cell instance $3499 m0 *1 91.77,75.6
X$3499 4318 4086 4091 112 113 4498 NOR3_X1
* cell instance $3505 m0 *1 98.04,75.6
X$3505 4308 113 4157 112 BUF_X4
* cell instance $3508 m0 *1 100.32,75.6
X$3508 3369 4204 112 113 4434 XOR2_X1
* cell instance $3509 m0 *1 101.46,75.6
X$3509 4206 3369 113 4036 112 XOR2_X2
* cell instance $3510 m0 *1 103.17,75.6
X$3510 4203 112 113 16467 CLKBUF_X1
* cell instance $3511 m0 *1 103.74,75.6
X$3511 112 16887 4391 4096 4097 113 DFF_X1
* cell instance $3512 m0 *1 106.97,75.6
X$3512 4391 113 4206 112 BUF_X4
* cell instance $3515 r0 *1 91.58,75.6
X$3515 4499 4498 112 113 4494 NOR2_X1
* cell instance $3516 r0 *1 92.15,75.6
X$3516 4500 4433 4642 113 4499 112 OAI21_X1
* cell instance $3520 r0 *1 94.24,75.6
X$3520 4432 3983 112 113 4318 NOR2_X1
* cell instance $3521 r0 *1 94.81,75.6
X$3521 4095 4541 16662 113 112 4500 HA_X1
* cell instance $3525 r0 *1 99.37,75.6
X$3525 4380 113 4492 112 BUF_X4
* cell instance $3526 r0 *1 100.7,75.6
X$3526 3828 3335 4434 112 113 4502 MUX2_X1
* cell instance $3528 r0 *1 102.41,75.6
X$3528 112 17111 4503 4502 4203 113 DFF_X1
* cell instance $3529 r0 *1 105.64,75.6
X$3529 4503 112 113 3369 CLKBUF_X3
* cell instance $3534 m0 *1 109.63,75.6
X$3534 112 4208 4319 4505 4097 113 DFF_X1
* cell instance $3537 m0 *1 113.62,75.6
X$3537 2859 4319 113 112 4507 XNOR2_X1
* cell instance $3540 m0 *1 115.71,75.6
X$3540 4395 4167 113 4273 112 XOR2_X2
* cell instance $3542 r0 *1 109.44,75.6
X$3542 4322 4207 112 113 4598 XNOR2_X2
* cell instance $3545 r0 *1 112.29,75.6
X$3545 4279 112 113 4097 CLKBUF_X3
* cell instance $3546 r0 *1 113.24,75.6
X$3546 4273 4507 112 113 4597 XNOR2_X2
* cell instance $3548 m0 *1 121.03,75.6
X$3548 4399 112 113 4167 BUF_X2
* cell instance $3549 m0 *1 117.8,75.6
X$3549 112 16781 4399 4396 4097 113 DFF_X1
* cell instance $3554 r0 *1 120.08,75.6
X$3554 182 3335 4544 112 113 4511 MUX2_X1
* cell instance $3555 r0 *1 121.41,75.6
X$3555 112 17135 4513 4511 4097 113 DFF_X1
* cell instance $3560 r0 *1 124.83,75.6
X$3560 4513 112 113 3621 CLKBUF_X3
* cell instance $3562 m0 *1 125.21,75.6
X$3562 348 4401 4320 113 112 4546 MUX2_X2
* cell instance $3564 m0 *1 130.15,75.6
X$3564 3782 5125 113 112 4321 XNOR2_X1
* cell instance $3566 m0 *1 131.48,75.6
X$3566 3531 3782 112 113 4435 XNOR2_X2
* cell instance $3567 m0 *1 133.38,75.6
X$3567 4280 3775 4410 112 4409 113 AOI21_X1
* cell instance $3568 m0 *1 134.14,75.6
X$3568 112 16758 4408 4409 4057 113 DFF_X1
* cell instance $3569 m0 *1 137.37,75.6
X$3569 4408 113 4407 112 BUF_X4
* cell instance $3570 m0 *1 138.7,75.6
X$3570 3373 4406 112 113 4404 XNOR2_X2
* cell instance $3572 m0 *1 140.79,75.6
X$3572 4405 4400 113 112 4403 XNOR2_X1
* cell instance $3573 m0 *1 141.93,75.6
X$3573 4402 4403 113 112 3634 XNOR2_X1
* cell instance $3574 m0 *1 143.07,75.6
X$3574 737 3109 112 113 4400 XOR2_X1
* cell instance $3578 r0 *1 125.97,75.6
X$3578 4510 3621 113 192 112 XOR2_X2
* cell instance $3579 r0 *1 127.68,75.6
X$3579 4210 3775 5294 112 4764 113 AOI21_X1
* cell instance $3580 r0 *1 128.44,75.6
X$3580 4512 3530 112 113 4887 NOR2_X1
* cell instance $3587 r0 *1 131.48,75.6
X$3587 4656 4435 113 3469 112 XOR2_X2
* cell instance $3589 r0 *1 134.71,75.6
X$3589 3680 4435 112 113 4769 XNOR2_X2
* cell instance $3593 r0 *1 139.08,75.6
X$3593 3373 3367 113 4456 112 XOR2_X2
* cell instance $3595 r0 *1 141.17,75.6
X$3595 465 4592 4508 113 112 3175 MUX2_X2
* cell instance $3597 r0 *1 143.07,75.6
X$3597 4402 4921 113 112 3883 XNOR2_X1
* cell instance $3601 r0 *1 145.54,75.6
X$3601 2294 112 113 4774 BUF_X2
* cell instance $3605 r0 *1 147.63,75.6
X$3605 4214 113 3594 112 BUF_X4
* cell instance $3606 m0 *1 147.82,75.6
X$3606 112 2355 113 4323 BUF_X8
* cell instance $3609 m0 *1 150.48,75.6
X$3609 2355 3198 4398 113 112 4504 HA_X1
* cell instance $3610 m0 *1 152.38,75.6
X$3610 4285 3006 2912 113 4397 112 OAI21_X1
* cell instance $3611 m0 *1 153.14,75.6
X$3611 4216 4397 4506 3478 2681 4394 113 112 AOI221_X2
* cell instance $3612 m0 *1 155.23,75.6
X$3612 4324 113 3292 112 BUF_X4
* cell instance $3613 m0 *1 156.56,75.6
X$3613 4325 3487 112 113 4393 OR2_X2
* cell instance $3615 r0 *1 148.96,75.6
X$3615 4215 112 113 3887 INV_X8
* cell instance $3616 r0 *1 150.67,75.6
X$3616 3198 2357 16652 113 112 4590 HA_X1
* cell instance $3619 r0 *1 153.14,75.6
X$3619 2512 4217 112 113 4506 NAND2_X1
* cell instance $3620 r0 *1 153.71,75.6
X$3620 2403 2566 4737 112 113 3786 MUX2_X1
* cell instance $3622 r0 *1 155.23,75.6
X$3622 4504 112 113 3451 CLKBUF_X3
* cell instance $3623 r0 *1 156.18,75.6
X$3623 3594 2464 112 3587 113 NAND2_X4
* cell instance $3626 m0 *1 157.89,75.6
X$3626 4055 3006 4393 112 113 4392 MUX2_X1
* cell instance $3627 m0 *1 159.41,75.6
X$3627 3964 2640 4392 112 4580 113 AOI21_X2
* cell instance $3628 m0 *1 160.74,75.6
X$3628 3180 2465 3200 113 3961 112 OAI21_X1
* cell instance $3630 m0 *1 161.69,75.6
X$3630 4218 4373 3966 113 4287 112 OAI21_X1
* cell instance $3631 m0 *1 162.45,75.6
X$3631 2885 3887 112 113 4501 NAND2_X1
* cell instance $3633 r0 *1 158.27,75.6
X$3633 2981 3292 3270 113 112 3895 OAI21_X2
* cell instance $3634 r0 *1 159.6,75.6
X$3634 3270 113 4436 112 BUF_X4
* cell instance $3635 r0 *1 160.93,75.6
X$3635 4438 4436 2517 113 4218 112 NOR3_X2
* cell instance $3636 r0 *1 162.26,75.6
X$3636 4326 4001 4390 112 113 4587 MUX2_X1
* cell instance $3638 m0 *1 163.4,75.6
X$3638 4331 2885 4055 112 4390 113 AOI21_X1
* cell instance $3639 m0 *1 164.35,75.6
X$3639 2681 3339 2512 2639 4327 3788 113 112 AOI221_X2
* cell instance $3640 m0 *1 166.44,75.6
X$3640 4437 4058 113 112 4327 AND2_X1
* cell instance $3641 m0 *1 167.2,75.6
X$3641 3478 2681 3296 3760 112 113 4328 AOI22_X1
* cell instance $3642 m0 *1 168.15,75.6
X$3642 2755 2465 4384 113 3760 112 OAI21_X1
* cell instance $3645 r0 *1 163.59,75.6
X$3645 3451 112 113 3687 INV_X2
* cell instance $3646 r0 *1 164.16,75.6
X$3646 3180 112 113 3657 INV_X1
* cell instance $3649 r0 *1 165.49,75.6
X$3649 3887 3292 3270 113 112 4437 OAI21_X2
* cell instance $3650 r0 *1 166.82,75.6
X$3650 3088 4438 4436 113 112 3340 OAI21_X4
* cell instance $3652 r0 *1 169.48,75.6
X$3652 2464 4438 4436 113 112 3482 OAI21_X2
* cell instance $3653 m0 *1 171,75.6
X$3653 3296 4329 4439 112 3844 113 AOI21_X1
* cell instance $3654 m0 *1 170.05,75.6
X$3654 4001 4383 112 113 3206 NAND2_X2
* cell instance $3655 m0 *1 171.76,75.6
X$3655 3296 4330 4384 112 3789 113 AOI21_X1
* cell instance $3656 m0 *1 172.52,75.6
X$3656 3291 2566 112 3299 113 NAND2_X4
* cell instance $3658 r0 *1 170.81,75.6
X$3658 3687 4438 4436 113 112 4439 OAI21_X2
* cell instance $3659 r0 *1 172.14,75.6
X$3659 4217 4383 112 113 3082 NOR2_X2
* cell instance $3660 r0 *1 173.09,75.6
X$3660 3012 4329 4437 112 4440 113 AOI21_X1
* cell instance $3661 r0 *1 173.85,75.6
X$3661 3012 4439 4384 112 4486 113 AOI21_X1
* cell instance $3663 m0 *1 174.61,75.6
X$3663 2410 2576 4439 113 4377 112 OAI21_X1
* cell instance $3664 m0 *1 175.56,75.6
X$3664 3170 3088 4330 112 113 4331 AND3_X4
* cell instance $3667 r0 *1 174.8,75.6
X$3667 2976 3083 2403 112 4579 113 AOI21_X1
* cell instance $3670 r0 *1 176.13,75.6
X$3670 4581 3299 3082 4582 4111 113 112 4551 OAI221_X1
* cell instance $3672 r0 *1 177.46,75.6
X$3672 3687 2685 2574 112 113 4553 MUX2_X1
* cell instance $3673 m0 *1 178.79,75.6
X$3673 4106 4220 2469 4374 4112 4378 113 112 AOI221_X2
* cell instance $3674 m0 *1 178.03,75.6
X$3674 4381 4378 2916 113 4379 112 OAI21_X1
* cell instance $3675 m0 *1 180.88,75.6
X$3675 2803 4437 3209 113 112 4370 AND3_X2
* cell instance $3677 r0 *1 178.79,75.6
X$3677 3170 4437 3012 112 113 4483 NAND3_X1
* cell instance $3682 r0 *1 180.31,75.6
X$3682 3012 4377 4483 113 4577 112 OAI21_X1
* cell instance $3684 m0 *1 184.49,75.6
X$3684 4270 4369 112 3751 113 NAND2_X4
* cell instance $3685 m0 *1 182.4,75.6
X$3685 3588 4370 4331 112 113 4369 OR3_X4
* cell instance $3688 r0 *1 187.15,75.6
X$3688 112 16947 4441 4481 4554 113 DFF_X1
* cell instance $3689 m0 *1 187.53,75.6
X$3689 4367 112 113 4672 BUF_X2
* cell instance $3693 m0 *1 190,75.6
X$3693 4441 4442 3489 113 112 2807 MUX2_X2
* cell instance $3695 m0 *1 197.79,75.6
X$3695 112 2371 2921 2481 2479 113 AOI21_X4
* cell instance $3696 m0 *1 200.26,75.6
X$3696 2731 113 3602 112 BUF_X4
* cell instance $3697 m0 *1 201.59,75.6
X$3697 4223 113 2138 112 BUF_X4
* cell instance $3698 m0 *1 202.92,75.6
X$3698 4223 112 113 1858 INV_X4
* cell instance $3699 m0 *1 203.87,75.6
X$3699 2479 113 3704 112 BUF_X4
* cell instance $3701 m0 *1 205.96,75.6
X$3701 3705 3704 2148 2810 3602 4362 113 112 AOI221_X2
* cell instance $3703 r0 *1 190.38,75.6
X$3703 4441 3947 4575 112 113 4481 MUX2_X1
* cell instance $3706 r0 *1 192.28,75.6
X$3706 112 2479 113 4443 BUF_X8
* cell instance $3708 r0 *1 196.27,75.6
X$3708 112 1856 113 4444 BUF_X8
* cell instance $3711 r0 *1 200.64,75.6
X$3711 2481 2479 3071 112 113 3441 NAND3_X2
* cell instance $3712 r0 *1 201.97,75.6
X$3712 4558 4559 1859 112 113 NOR2_X4
* cell instance $3714 r0 *1 204.06,75.6
X$3714 2479 4223 2481 112 2495 113 NAND3_X4
* cell instance $3717 r0 *1 207.1,75.6
X$3717 2146 112 113 3027 CLKBUF_X3
* cell instance $3719 r0 *1 208.24,75.6
X$3719 4332 2146 2814 1943 2371 4562 113 112 AOI221_X2
* cell instance $3721 m0 *1 208.43,75.6
X$3721 2141 2145 2401 113 4332 112 OAI21_X1
* cell instance $3723 m0 *1 210.52,75.6
X$3723 4224 4446 3326 112 113 4358 NAND3_X1
* cell instance $3727 r0 *1 210.33,75.6
X$3727 4445 4362 3065 113 4446 112 OAI21_X1
* cell instance $3728 r0 *1 211.09,75.6
X$3728 3071 2810 2369 112 113 4833 MUX2_X1
* cell instance $3729 r0 *1 212.42,75.6
X$3729 2927 3314 112 113 3252 NAND2_X1
* cell instance $3730 m0 *1 213.56,75.6
X$3730 4226 4358 4257 113 112 4334 AND3_X2
* cell instance $3731 m0 *1 212.42,75.6
X$3731 4116 4355 4465 4345 3247 113 112 4360 OAI221_X1
* cell instance $3733 r0 *1 212.99,75.6
X$3733 3252 4447 4448 112 4333 113 AOI21_X1
* cell instance $3735 r0 *1 213.94,75.6
X$3735 2720 2369 2589 112 4448 113 AOI21_X1
* cell instance $3737 r0 *1 214.89,75.6
X$3737 4563 4473 3536 113 112 4449 AND3_X1
* cell instance $3739 m0 *1 215.08,75.6
X$3739 4449 4356 3500 112 113 4355 NOR3_X1
* cell instance $3740 m0 *1 216.03,75.6
X$3740 2145 1943 112 113 3532 NOR2_X1
* cell instance $3745 r0 *1 216.03,75.6
X$3745 4450 3532 2595 113 4473 112 OAI21_X1
* cell instance $3746 r0 *1 216.79,75.6
X$3746 2589 4115 3400 2720 113 112 4564 OAI22_X1
* cell instance $3747 r0 *1 217.74,75.6
X$3747 4362 2274 112 113 4470 NOR2_X1
* cell instance $3749 r0 *1 218.5,75.6
X$3749 3426 3130 4470 112 113 4845 MUX2_X1
* cell instance $3750 m0 *1 219.45,75.6
X$3750 2371 2369 112 113 4139 NAND2_X1
* cell instance $3753 m0 *1 220.21,75.6
X$3753 4353 3121 4139 112 113 4352 NAND3_X1
* cell instance $3754 m0 *1 220.97,75.6
X$3754 2828 3807 113 112 4335 AND2_X1
* cell instance $3755 m0 *1 221.73,75.6
X$3755 4336 4352 4240 112 113 4465 NAND3_X1
* cell instance $3757 m0 *1 222.68,75.6
X$3757 3130 3314 112 113 3500 NOR2_X2
* cell instance $3758 m0 *1 223.63,75.6
X$3758 2493 3400 112 113 4351 NOR2_X1
* cell instance $3762 r0 *1 220.4,75.6
X$3762 3061 2371 112 113 4569 NOR2_X1
* cell instance $3763 r0 *1 220.97,75.6
X$3763 2700 4335 2950 113 4353 112 OAI21_X1
* cell instance $3766 r0 *1 223.63,75.6
X$3766 2495 2607 112 113 4698 NOR2_X1
* cell instance $3767 r0 *1 224.2,75.6
X$3767 2257 112 113 2589 CLKBUF_X3
* cell instance $3768 m0 *1 225.72,75.6
X$3768 2589 2937 112 113 4337 NAND2_X1
* cell instance $3769 m0 *1 224.58,75.6
X$3769 4351 3901 2927 2044 4337 113 112 4350 OAI221_X1
* cell instance $3770 m0 *1 226.29,75.6
X$3770 2262 112 113 3129 CLKBUF_X3
* cell instance $3773 m0 *1 228.19,75.6
X$3773 2262 2950 112 113 4239 NOR2_X1
* cell instance $3774 m0 *1 228.76,75.6
X$3774 2930 2385 4342 4235 112 113 4345 AOI22_X2
* cell instance $3775 m0 *1 230.47,75.6
X$3775 1870 2493 2148 112 113 4340 MUX2_X1
* cell instance $3776 m0 *1 231.8,75.6
X$3776 4338 112 113 4341 INV_X1
* cell instance $3777 m0 *1 232.18,75.6
X$3777 2828 4341 3234 112 4339 113 AOI21_X1
* cell instance $3778 m0 *1 232.94,75.6
X$3778 4339 2828 4340 112 3408 113 AOI21_X1
* cell instance $3780 r0 *1 225.15,75.6
X$3780 2382 2141 112 113 4566 NAND2_X1
* cell instance $3783 r0 *1 226.67,75.6
X$3783 3234 112 113 2930 CLKBUF_X3
* cell instance $3784 r0 *1 227.62,75.6
X$3784 3130 112 113 3034 CLKBUF_X3
* cell instance $3785 r0 *1 228.57,75.6
X$3785 2274 2720 2148 112 4451 113 AOI21_X1
* cell instance $3786 r0 *1 229.33,75.6
X$3786 4451 2926 2950 113 4452 112 OAI21_X1
* cell instance $3789 r0 *1 231.8,75.6
X$3789 112 17039 4455 4456 4454 113 DFF_X1
* cell instance $3790 m0 *1 234.27,75.6
X$3790 2493 113 2950 112 BUF_X4
* cell instance $3801 r0 *1 237.12,75.6
X$3801 4455 112 113 4567 BUF_X1
* cell instance $3803 r0 *1 238.07,75.6
X$3803 4453 112 113 4512 CLKBUF_X2
* cell instance $3808 m0 *1 177.84,30.8
X$3808 910 909 822 113 561 112 OAI21_X1
* cell instance $3809 m0 *1 176.89,30.8
X$3809 284 912 895 113 112 910 AND3_X1
* cell instance $3810 m0 *1 178.6,30.8
X$3810 894 821 284 112 113 909 NOR3_X1
* cell instance $3812 m0 *1 179.55,30.8
X$3812 742 821 506 112 113 906 NOR3_X1
* cell instance $3815 m0 *1 182.02,30.8
X$3815 907 238 750 485 818 503 113 112 AOI221_X2
* cell instance $3816 m0 *1 184.11,30.8
X$3816 896 906 296 836 113 112 825 OAI22_X1
* cell instance $3818 m0 *1 185.82,30.8
X$3818 837 897 996 822 905 752 113 112 AOI221_X2
* cell instance $3819 m0 *1 187.91,30.8
X$3819 902 898 541 112 113 839 NAND3_X1
* cell instance $3820 m0 *1 188.67,30.8
X$3820 498 494 112 113 827 NOR2_X1
* cell instance $3821 m0 *1 189.24,30.8
X$3821 547 827 903 112 837 113 AOI21_X1
* cell instance $3822 m0 *1 190,30.8
X$3822 373 1141 112 113 902 OR2_X1
* cell instance $3825 r0 *1 177.08,30.8
X$3825 423 975 112 113 895 NAND2_X1
* cell instance $3828 r0 *1 178.22,30.8
X$3828 973 280 112 113 976 NOR2_X2
* cell instance $3835 r0 *1 180.5,30.8
X$3835 978 741 112 113 747 NOR2_X1
* cell instance $3837 r0 *1 181.26,30.8
X$3837 439 289 976 112 1002 113 AOI21_X1
* cell instance $3839 r0 *1 182.4,30.8
X$3839 1002 979 977 112 113 675 NAND3_X1
* cell instance $3841 r0 *1 183.35,30.8
X$3841 319 825 981 286 440 1000 112 113 OAI221_X2
* cell instance $3843 r0 *1 185.63,30.8
X$3843 894 549 436 998 994 996 113 112 AOI221_X2
* cell instance $3845 r0 *1 187.91,30.8
X$3845 289 838 975 485 112 113 898 AOI22_X1
* cell instance $3846 r0 *1 188.86,30.8
X$3846 983 283 112 113 436 NAND2_X2
* cell instance $3851 m0 *1 191.14,30.8
X$3851 542 609 899 900 566 113 112 836 OAI221_X1
* cell instance $3852 m0 *1 192.47,30.8
X$3852 322 373 403 112 113 899 NAND3_X1
* cell instance $3854 m0 *1 193.42,30.8
X$3854 284 238 16573 113 112 986 HA_X1
* cell instance $3855 m0 *1 195.32,30.8
X$3855 497 112 113 547 CLKBUF_X3
* cell instance $3866 r0 *1 191.14,30.8
X$3866 610 984 862 112 113 900 MUX2_X1
* cell instance $3867 r0 *1 192.47,30.8
X$3867 280 984 112 113 609 NAND2_X2
* cell instance $3869 r0 *1 193.61,30.8
X$3869 986 112 113 990 INV_X1
* cell instance $3883 m0 *1 192.47,28
X$3883 280 566 112 113 757 NAND2_X1
* cell instance $3884 m0 *1 191.33,28
X$3884 547 682 756 113 112 759 AND3_X2
* cell instance $3886 m0 *1 193.23,28
X$3886 757 684 630 112 113 683 NAND3_X1
* cell instance $3887 m0 *1 193.99,28
X$3887 497 684 609 113 112 829 AND3_X1
* cell instance $3889 m0 *1 195.13,28
X$3889 545 547 494 113 754 112 OAI21_X1
* cell instance $3890 m0 *1 195.89,28
X$3890 755 544 684 112 113 685 MUX2_X1
* cell instance $3900 r0 *1 191.52,28
X$3900 753 113 681 112 BUF_X4
* cell instance $3902 r0 *1 193.23,28
X$3902 753 777 112 113 684 NAND2_X1
* cell instance $3904 r0 *1 194.18,28
X$3904 373 685 829 754 113 112 828 OAI22_X1
* cell instance $3905 r0 *1 195.13,28
X$3905 284 238 16721 113 112 755 HA_X1
* cell instance $3918 m0 *1 24.89,117.6
X$3918 7441 7637 112 113 7954 NOR2_X1
* cell instance $3920 m0 *1 25.46,117.6
X$3920 7970 8084 8013 113 8085 112 OAI21_X1
* cell instance $3921 m0 *1 26.22,117.6
X$3921 7391 7296 6853 113 8082 112 OAI21_X1
* cell instance $3922 m0 *1 26.98,117.6
X$3922 8177 8176 8476 112 8084 113 AOI21_X1
* cell instance $3923 m0 *1 27.74,117.6
X$3923 7635 7619 7793 112 113 7301 NAND3_X1
* cell instance $3924 m0 *1 28.5,117.6
X$3924 112 8014 8015 8307 8306 113 NOR3_X4
* cell instance $3925 m0 *1 31.16,117.6
X$3925 112 8089 7970 8238 8087 113 AOI21_X4
* cell instance $3926 m0 *1 33.63,117.6
X$3926 7492 8016 112 113 8178 NOR2_X1
* cell instance $3927 m0 *1 34.2,117.6
X$3927 112 7794 7624 8093 8484 8017 113 OAI22_X4
* cell instance $3928 m0 *1 37.43,117.6
X$3928 7627 8020 8089 112 113 8092 OR3_X4
* cell instance $3929 m0 *1 39.52,117.6
X$3929 7493 8014 112 113 8093 NAND2_X1
* cell instance $3930 m0 *1 40.09,117.6
X$3930 7487 7178 112 113 7886 NOR2_X2
* cell instance $3932 m0 *1 41.23,117.6
X$3932 7222 7860 7637 7495 113 112 8179 OAI22_X1
* cell instance $3933 m0 *1 42.18,117.6
X$3933 7708 112 113 7797 BUF_X1
* cell instance $3934 m0 *1 42.75,117.6
X$3934 8248 7885 112 113 8181 OR2_X1
* cell instance $3935 m0 *1 43.51,117.6
X$3935 7965 8180 7301 112 8096 113 AOI21_X1
* cell instance $3938 m0 *1 45.22,117.6
X$3938 7218 7622 112 113 8099 NOR2_X1
* cell instance $3940 m0 *1 46.55,117.6
X$3940 8183 7703 112 113 8101 NOR2_X1
* cell instance $3941 m0 *1 47.12,117.6
X$3941 8019 8101 8085 8103 112 113 8251 AOI22_X1
* cell instance $3942 m0 *1 48.07,117.6
X$3942 7637 112 113 8184 INV_X1
* cell instance $3943 m0 *1 48.45,117.6
X$3943 8022 7636 112 113 8312 NAND2_X1
* cell instance $3944 m0 *1 49.02,117.6
X$3944 8104 7848 112 113 8257 NOR2_X1
* cell instance $3945 m0 *1 49.59,117.6
X$3945 7879 7313 7622 113 7715 112 OAI21_X1
* cell instance $3947 m0 *1 50.54,117.6
X$3947 8561 8253 8188 112 8490 113 AOI21_X1
* cell instance $3949 m0 *1 10.83,117.6
X$3949 7952 112 113 8174 BUF_X1
* cell instance $3953 m0 *1 15.2,117.6
X$3953 8077 6899 8075 112 113 8078 MUX2_X1
* cell instance $3954 m0 *1 16.53,117.6
X$3954 112 16903 8077 8078 8232 113 DFF_X1
* cell instance $3966 r0 *1 13.68,117.6
X$3966 8303 112 113 8233 BUF_X1
* cell instance $3968 r0 *1 14.44,117.6
X$3968 8302 112 113 6797 BUF_X2
* cell instance $3971 r0 *1 17.1,117.6
X$3971 8175 6899 8233 112 113 8234 MUX2_X1
* cell instance $3973 r0 *1 18.62,117.6
X$3973 112 17105 8175 8234 8232 113 DFF_X1
* cell instance $3976 r0 *1 22.42,117.6
X$3976 112 8305 7637 7632 7633 113 AOI21_X4
* cell instance $3978 r0 *1 25.08,117.6
X$3978 7391 7296 8236 113 8012 112 NOR3_X2
* cell instance $3979 r0 *1 26.41,117.6
X$3979 7391 7296 7293 113 8416 112 NOR3_X2
* cell instance $3981 r0 *1 27.93,117.6
X$3981 7403 112 113 7848 CLKBUF_X3
* cell instance $3982 r0 *1 28.88,117.6
X$3982 7879 7487 7588 6798 8307 113 112 AOI211_X2
* cell instance $3984 r0 *1 30.97,117.6
X$3984 7217 7293 7882 7305 8110 8371 113 112 AOI221_X2
* cell instance $3985 r0 *1 33.06,117.6
X$3985 7630 8373 7957 113 112 8374 AND3_X1
* cell instance $3986 r0 *1 34.01,117.6
X$3986 112 8376 113 7793 BUF_X8
* cell instance $3988 r0 *1 36.67,117.6
X$3988 8242 8309 8310 113 112 8378 OAI21_X4
* cell instance $3990 r0 *1 39.33,117.6
X$3990 8379 7391 7296 113 112 8247 OAI21_X4
* cell instance $3992 r0 *1 41.99,117.6
X$3992 7179 6969 7709 112 8248 113 AOI21_X2
* cell instance $3993 r0 *1 43.32,117.6
X$3993 7010 7800 7180 112 8249 113 AOI21_X1
* cell instance $3994 r0 *1 44.08,117.6
X$3994 7636 8180 7880 112 8250 113 AOI21_X1
* cell instance $3995 r0 *1 44.84,117.6
X$3995 7444 7881 8383 112 113 8310 NOR3_X1
* cell instance $3996 r0 *1 45.6,117.6
X$3996 8182 7311 8183 8181 8242 8386 113 112 AOI221_X2
* cell instance $3997 r0 *1 47.69,117.6
X$3997 8185 7224 8417 112 8311 113 AOI21_X1
* cell instance $3998 r0 *1 48.45,117.6
X$3998 8186 8187 7493 113 8313 112 OAI21_X1
* cell instance $3999 r0 *1 49.21,117.6
X$3999 7180 8245 7395 6965 112 113 8187 AOI22_X1
* cell instance $4000 r0 *1 50.16,117.6
X$4000 7129 113 7226 112 BUF_X4
* cell instance $4001 r0 *1 51.49,117.6
X$4001 112 6967 113 8258 BUF_X8
* cell instance $4002 m0 *1 52.44,117.6
X$4002 8096 8105 7630 113 8189 112 OAI21_X1
* cell instance $4003 m0 *1 51.68,117.6
X$4003 7391 7296 7640 112 113 8256 NOR3_X1
* cell instance $4006 m0 *1 53.58,117.6
X$4006 7879 5947 7180 112 113 8108 NOR3_X1
* cell instance $4007 r0 *1 53.96,117.6
X$4007 8186 8105 8257 7970 8021 8023 112 113 8394 OAI33_X1
* cell instance $4009 m0 *1 54.72,117.6
X$4009 7128 112 113 8191 CLKBUF_X3
* cell instance $4011 r0 *1 55.48,117.6
X$4011 8190 8185 8183 113 8395 112 OAI21_X1
* cell instance $4013 m0 *1 56.05,117.6
X$4013 8107 8025 8183 8016 7801 8314 113 112 AOI221_X2
* cell instance $4014 r0 *1 56.24,117.6
X$4014 7313 8491 8191 112 8024 113 AOI21_X1
* cell instance $4015 r0 *1 57,117.6
X$4015 7180 6902 112 113 8396 NOR2_X1
* cell instance $4018 r0 *1 58.14,117.6
X$4018 8260 8315 8396 112 8193 113 AOI21_X1
* cell instance $4020 m0 *1 58.52,117.6
X$4020 7128 7802 7229 6853 112 113 8260 NOR4_X1
* cell instance $4022 m0 *1 60.42,117.6
X$4022 8027 7002 8026 112 8192 113 AOI21_X1
* cell instance $4023 m0 *1 61.18,117.6
X$4023 7128 7503 112 113 8027 NOR2_X1
* cell instance $4026 r0 *1 59.28,117.6
X$4026 7588 8263 8192 6796 8193 8709 112 113 OAI221_X2
* cell instance $4028 r0 *1 61.75,117.6
X$4028 8194 7499 112 113 8263 NOR2_X1
* cell instance $4030 m0 *1 62.13,117.6
X$4030 7128 7802 7180 112 113 8194 NOR3_X1
* cell instance $4032 m0 *1 63.84,117.6
X$4032 6800 112 113 8267 CLKBUF_X3
* cell instance $4035 m0 *1 65.36,117.6
X$4035 112 7981 8270 8266 6855 113 DFF_X1
* cell instance $4037 m0 *1 68.59,117.6
X$4037 8116 8028 7129 112 113 NOR2_X4
* cell instance $4038 m0 *1 70.3,117.6
X$4038 8119 8271 8118 112 113 8028 MUX2_X1
* cell instance $4039 m0 *1 71.63,117.6
X$4039 7648 8117 112 113 8119 NOR2_X1
* cell instance $4041 m0 *1 73.72,117.6
X$4041 8030 3015 3363 112 113 8122 NOR3_X1
* cell instance $4042 m0 *1 74.48,117.6
X$4042 8030 3015 7805 112 113 8274 NOR3_X1
* cell instance $4045 r0 *1 66.88,117.6
X$4045 8270 7895 8384 112 113 8266 MUX2_X1
* cell instance $4050 r0 *1 69.73,117.6
X$4050 8077 8316 8317 113 112 7235 MUX2_X2
* cell instance $4052 r0 *1 71.63,117.6
X$4052 8402 8195 113 8029 112 XOR2_X2
* cell instance $4053 r0 *1 73.34,117.6
X$4053 8195 8402 113 112 8030 XNOR2_X1
* cell instance $4056 m0 *1 75.62,117.6
X$4056 8124 8031 112 113 7512 XNOR2_X2
* cell instance $4057 m0 *1 77.71,117.6
X$4057 8196 7598 113 8032 112 XOR2_X2
* cell instance $4058 m0 *1 79.42,117.6
X$4058 8032 8318 113 112 8124 XNOR2_X1
* cell instance $4062 r0 *1 77.14,117.6
X$4062 8624 8404 112 113 7597 XNOR2_X2
* cell instance $4064 r0 *1 79.42,117.6
X$4064 8196 8318 113 112 8404 XNOR2_X1
* cell instance $4066 m0 *1 81.51,117.6
X$4066 8033 8032 112 113 8197 NAND2_X1
* cell instance $4067 m0 *1 80.94,117.6
X$4067 8033 8034 112 113 8275 NAND2_X1
* cell instance $4068 m0 *1 82.08,117.6
X$4068 3926 8126 8032 112 8276 113 NAND3_X4
* cell instance $4070 m0 *1 84.74,117.6
X$4070 8034 5043 6516 112 113 8035 NAND3_X1
* cell instance $4073 m0 *1 86.45,117.6
X$4073 7732 112 113 17194 INV_X1
* cell instance $4074 m0 *1 86.83,117.6
X$4074 8038 112 113 8125 BUF_X1
* cell instance $4075 m0 *1 87.4,117.6
X$4075 7230 7812 113 112 8198 XNOR2_X1
* cell instance $4076 m0 *1 88.54,117.6
X$4076 8038 8037 113 112 8131 XNOR2_X1
* cell instance $4077 m0 *1 89.68,117.6
X$4077 8133 112 113 7732 CLKBUF_X3
* cell instance $4082 r0 *1 81.89,117.6
X$4082 112 7896 8502 8275 8276 113 AOI21_X4
* cell instance $4083 r0 *1 84.36,117.6
X$4083 8405 8035 8197 112 7897 113 AOI21_X1
* cell instance $4084 r0 *1 85.12,117.6
X$4084 8319 8277 113 8037 112 XOR2_X2
* cell instance $4085 r0 *1 86.83,117.6
X$4085 3725 112 113 8277 BUF_X1
* cell instance $4086 r0 *1 87.4,117.6
X$4086 8198 8320 8278 112 8279 113 AOI21_X2
* cell instance $4088 m0 *1 91.96,117.6
X$4088 112 8281 7732 8408 8039 113 DFF_X2
* cell instance $4092 m0 *1 97.28,117.6
X$4092 7815 8039 16599 113 112 8201 HA_X1
* cell instance $4093 m0 *1 99.18,117.6
X$4093 7815 8039 8202 112 113 8139 NAND3_X1
* cell instance $4098 r0 *1 92.91,117.6
X$4098 5708 8200 113 112 8281 AND2_X1
* cell instance $4099 r0 *1 93.67,117.6
X$4099 7814 8408 8200 113 112 8204 HA_X1
* cell instance $4100 r0 *1 95.57,117.6
X$4100 7815 8408 16603 113 112 8206 HA_X1
* cell instance $4101 r0 *1 97.47,117.6
X$4101 7895 113 194 112 BUF_X4
* cell instance $4102 r0 *1 98.8,117.6
X$4102 8205 8326 113 112 8410 AND2_X1
* cell instance $4103 r0 *1 99.56,117.6
X$4103 8200 7901 8203 113 8326 112 OAI21_X1
* cell instance $4104 r0 *1 100.32,117.6
X$4104 7901 8204 112 113 8203 NAND2_X1
* cell instance $4105 r0 *1 100.89,117.6
X$4105 8327 7895 112 113 8205 NOR2_X1
* cell instance $4106 r0 *1 101.46,117.6
X$4106 8204 7901 8206 112 113 8328 MUX2_X1
* cell instance $4107 m0 *1 102.03,117.6
X$4107 8205 8140 113 112 7817 AND2_X1
* cell instance $4111 m0 *1 106.02,117.6
X$4111 8199 8041 113 112 8143 XNOR2_X1
* cell instance $4113 r0 *1 102.79,117.6
X$4113 8205 8328 113 112 8284 AND2_X1
* cell instance $4115 r0 *1 103.74,117.6
X$4115 112 8289 8041 8284 8519 113 DFF_X1
* cell instance $4117 m0 *1 108.11,117.6
X$4117 7904 7750 112 113 8042 NOR2_X1
* cell instance $4118 m0 *1 107.54,117.6
X$4118 7904 6616 112 113 8207 NAND2_X1
* cell instance $4119 m0 *1 108.68,117.6
X$4119 8042 8287 8043 113 112 8040 MUX2_X2
* cell instance $4120 m0 *1 110.39,117.6
X$4120 8143 8058 112 113 8043 XNOR2_X2
* cell instance $4121 m0 *1 112.29,117.6
X$4121 7244 113 5120 112 BUF_X4
* cell instance $4125 m0 *1 117.61,117.6
X$4125 8144 7982 112 113 7906 XNOR2_X2
* cell instance $4126 m0 *1 119.51,117.6
X$4126 5172 7819 112 113 7905 XNOR2_X2
* cell instance $4129 r0 *1 107.92,117.6
X$4129 8286 8207 8043 113 112 8864 MUX2_X2
* cell instance $4130 r0 *1 109.63,117.6
X$4130 8208 6616 112 113 8286 NAND2_X1
* cell instance $4131 r0 *1 110.2,117.6
X$4131 8208 7750 112 113 8287 NOR2_X1
* cell instance $4132 r0 *1 110.77,117.6
X$4132 8289 8208 112 113 4410 XNOR2_X2
* cell instance $4135 r0 *1 113.81,117.6
X$4135 112 7244 8329 113 BUF_X16
* cell instance $4136 r0 *1 118.56,117.6
X$4136 8292 7905 112 113 6370 XNOR2_X2
* cell instance $4138 m0 *1 125.02,117.6
X$4138 8294 8044 113 112 7821 XNOR2_X1
* cell instance $4139 m0 *1 121.79,117.6
X$4139 112 8294 8149 8147 7335 113 DFF_X1
* cell instance $4146 r0 *1 125.4,117.6
X$4146 112 17078 8527 8412 7335 113 DFF_X1
* cell instance $4148 m0 *1 126.54,117.6
X$4148 3581 8153 112 113 8044 XNOR2_X2
* cell instance $4150 m0 *1 130.72,117.6
X$4150 6983 113 8295 112 BUF_X4
* cell instance $4154 m0 *1 134.52,117.6
X$4154 8008 112 113 7823 INV_X1
* cell instance $4156 r0 *1 128.63,117.6
X$4156 3581 8149 112 113 8528 XOR2_X1
* cell instance $4159 r0 *1 130.15,117.6
X$4159 112 17079 8297 8296 8298 113 DFF_X1
* cell instance $4160 r0 *1 133.38,117.6
X$4160 8297 112 113 3581 CLKBUF_X3
* cell instance $4161 r0 *1 134.33,117.6
X$4161 7658 112 113 8330 INV_X1
* cell instance $4164 r0 *1 135.28,117.6
X$4164 8434 7658 112 113 8533 NAND2_X1
* cell instance $4165 m0 *1 135.47,117.6
X$4165 8159 7907 8003 112 113 8299 AND3_X4
* cell instance $4169 r0 *1 135.85,117.6
X$4169 5177 8008 112 113 8331 NAND2_X1
* cell instance $4170 r0 *1 136.42,117.6
X$4170 5177 7823 112 113 8332 NAND2_X1
* cell instance $4174 m0 *1 140.98,117.6
X$4174 5643 7658 113 8301 112 XOR2_X2
* cell instance $4178 r0 *1 142.5,117.6
X$4178 8212 8409 8333 8162 8209 8335 112 113 7523 OAI33_X1
* cell instance $4179 r0 *1 143.83,117.6
X$4179 6153 6924 8210 113 8334 112 OAI21_X1
* cell instance $4180 m0 *1 144.4,117.6
X$4180 6145 8213 8045 113 7344 112 NOR3_X2
* cell instance $4181 m0 *1 143.83,117.6
X$4181 8211 6410 112 113 8300 NAND2_X1
* cell instance $4182 m0 *1 145.73,117.6
X$4182 7607 8164 113 112 8212 AND2_X1
* cell instance $4183 m0 *1 146.49,117.6
X$4183 7528 6691 112 113 8214 OR2_X1
* cell instance $4185 m0 *1 147.44,117.6
X$4185 8300 8049 6074 6816 8167 8213 113 112 AOI221_X2
* cell instance $4186 m0 *1 149.53,117.6
X$4186 7256 7604 7121 113 8047 112 OAI21_X1
* cell instance $4187 m0 *1 150.29,117.6
X$4187 6816 8542 6781 8048 8049 7360 113 112 AOI221_X2
* cell instance $4189 r0 *1 144.59,117.6
X$4189 8334 7870 6494 113 8209 112 OAI21_X1
* cell instance $4191 r0 *1 145.54,117.6
X$4191 7915 7872 7910 112 7528 113 AOI21_X2
* cell instance $4192 r0 *1 146.87,117.6
X$4192 7911 112 113 6494 INV_X1
* cell instance $4193 r0 *1 147.25,117.6
X$4193 8046 6895 6934 8047 113 112 8164 OAI22_X1
* cell instance $4194 r0 *1 148.2,117.6
X$4194 7772 6793 7662 113 8215 112 OAI21_X1
* cell instance $4197 r0 *1 149.91,117.6
X$4197 7119 7872 7910 112 6658 113 AOI21_X2
* cell instance $4200 r0 *1 151.81,117.6
X$4200 8339 7872 7910 112 7531 113 AOI21_X2
* cell instance $4201 m0 *1 152.95,117.6
X$4201 5988 6405 112 113 8050 NOR2_X2
* cell instance $4203 m0 *1 153.9,117.6
X$4203 7922 6789 112 113 6660 OR2_X1
* cell instance $4204 m0 *1 154.66,117.6
X$4204 6548 6355 7205 6895 113 112 8397 OAI22_X1
* cell instance $4205 m0 *1 155.61,117.6
X$4205 7119 8052 7534 113 6355 112 OAI21_X1
* cell instance $4206 m0 *1 156.37,117.6
X$4206 8290 8051 8216 8172 8049 5916 113 112 AOI221_X2
* cell instance $4208 m0 *1 158.65,117.6
X$4208 8342 113 5988 112 BUF_X4
* cell instance $4211 r0 *1 153.33,117.6
X$4211 7596 6789 112 113 6895 OR2_X1
* cell instance $4215 r0 *1 155.42,117.6
X$4215 6660 6548 6701 112 113 8293 NOR3_X1
* cell instance $4217 r0 *1 156.37,117.6
X$4217 7365 7923 8397 8545 8293 8154 112 113 8216 OAI33_X1
* cell instance $4219 r0 *1 157.89,117.6
X$4219 8342 6080 112 113 7365 NAND2_X1
* cell instance $4221 r0 *1 158.65,117.6
X$4221 112 8049 8217 7604 8340 113 AOI21_X4
* cell instance $4222 m0 *1 161.12,117.6
X$4222 6156 7914 113 112 8288 AND2_X1
* cell instance $4223 m0 *1 160.36,117.6
X$4223 6410 7923 8173 112 113 8156 NAND3_X1
* cell instance $4225 r0 *1 161.12,117.6
X$4225 8285 8288 8342 8171 8054 8290 113 112 AOI221_X2
* cell instance $4226 m0 *1 163.4,117.6
X$4226 7662 5985 7121 113 8583 112 OAI21_X1
* cell instance $4227 m0 *1 162.26,117.6
X$4227 7915 7109 113 112 7260 XNOR2_X1
* cell instance $4228 m0 *1 164.16,117.6
X$4228 7919 6926 8053 113 8285 112 OAI21_X1
* cell instance $4229 m0 *1 164.92,117.6
X$4229 8282 112 113 7467 INV_X8
* cell instance $4230 m0 *1 166.63,117.6
X$4230 8055 8052 7662 7470 7535 113 112 AOI211_X2
* cell instance $4231 m0 *1 168.34,117.6
X$4231 8160 8157 8056 6094 8273 7594 112 113 7666 OAI33_X1
* cell instance $4233 r0 *1 163.21,117.6
X$4233 8282 112 113 7470 INV_X8
* cell instance $4234 r0 *1 164.92,117.6
X$4234 6697 7533 8217 7470 112 113 7918 NOR4_X1
* cell instance $4235 r0 *1 165.87,117.6
X$4235 8283 113 7109 112 BUF_X4
* cell instance $4236 r0 *1 167.2,117.6
X$4236 7604 113 5981 112 BUF_X4
* cell instance $4237 r0 *1 168.53,117.6
X$4237 6930 112 113 8393 BUF_X1
* cell instance $4238 r0 *1 169.1,117.6
X$4238 6268 6255 7777 113 112 6930 HA_X1
* cell instance $4239 m0 *1 171,117.6
X$4239 8150 7109 7827 8218 8056 113 112 AOI211_X2
* cell instance $4240 m0 *1 170.05,117.6
X$4240 8280 8217 112 113 7778 NAND2_X2
* cell instance $4242 r0 *1 171,117.6
X$4242 6932 7985 7119 6688 113 112 8272 OAI22_X1
* cell instance $4243 r0 *1 171.95,117.6
X$4243 112 8540 6255 113 BUF_X16
* cell instance $4244 m0 *1 174.8,117.6
X$4244 4206 8155 112 113 8342 XNOR2_X2
* cell instance $4245 m0 *1 173.09,117.6
X$4245 8155 4206 113 6781 112 XOR2_X2
* cell instance $4246 m0 *1 176.7,117.6
X$4246 8052 8219 112 113 7980 NAND2_X1
* cell instance $4247 m0 *1 177.27,117.6
X$4247 8052 7827 112 113 8150 NOR2_X1
* cell instance $4250 r0 *1 176.7,117.6
X$4250 6781 8219 112 113 6650 NOR2_X2
* cell instance $4251 r0 *1 177.65,117.6
X$4251 6816 8272 6251 112 8273 113 AOI21_X1
* cell instance $4252 r0 *1 178.41,117.6
X$4252 5177 7020 112 113 8390 NAND2_X1
* cell instance $4253 r0 *1 178.98,117.6
X$4253 6821 112 113 8535 INV_X1
* cell instance $4255 r0 *1 179.74,117.6
X$4255 5177 6821 112 113 8343 NAND2_X1
* cell instance $4259 r0 *1 180.31,117.6
X$4259 112 8388 113 7648 BUF_X8
* cell instance $4260 m0 *1 183.35,117.6
X$4260 8220 7856 112 113 6617 XNOR2_X2
* cell instance $4261 m0 *1 181.26,117.6
X$4261 8389 7374 7269 112 113 8268 OR3_X4
* cell instance $4262 m0 *1 185.25,117.6
X$4262 6164 8145 113 112 8264 XNOR2_X1
* cell instance $4263 m0 *1 186.39,117.6
X$4263 7856 7590 113 112 8146 XNOR2_X1
* cell instance $4264 m0 *1 187.53,117.6
X$4264 7854 6138 7156 112 113 8057 NAND3_X1
* cell instance $4265 m0 *1 188.29,117.6
X$4265 6553 112 113 8145 BUF_X1
* cell instance $4267 r0 *1 182.78,117.6
X$4267 8265 8269 113 8344 112 XOR2_X2
* cell instance $4268 r0 *1 184.49,117.6
X$4268 8220 112 113 8269 BUF_X1
* cell instance $4269 r0 *1 185.06,117.6
X$4269 8220 112 113 7461 BUF_X2
* cell instance $4270 r0 *1 185.82,117.6
X$4270 7856 112 113 8265 BUF_X1
* cell instance $4271 r0 *1 186.39,117.6
X$4271 6617 112 113 8346 BUF_X1
* cell instance $4273 m0 *1 189.43,117.6
X$4273 8059 7156 112 113 8058 XNOR2_X2
* cell instance $4275 m0 *1 191.33,117.6
X$4275 8059 4410 113 112 8261 XNOR2_X1
* cell instance $4276 m0 *1 192.47,117.6
X$4276 8076 4389 8261 112 113 8138 MUX2_X1
* cell instance $4277 m0 *1 193.8,117.6
X$4277 112 16915 8136 8138 8221 113 DFF_X1
* cell instance $4278 m0 *1 197.03,117.6
X$4278 8136 113 8059 112 BUF_X4
* cell instance $4281 m0 *1 200.64,117.6
X$4281 8080 4389 8060 112 113 8222 MUX2_X1
* cell instance $4284 m0 *1 206.53,117.6
X$4284 5767 113 6745 112 BUF_X4
* cell instance $4289 r0 *1 197.6,117.6
X$4289 112 8244 8221 17264 7856 113 DFF_X2
* cell instance $4290 r0 *1 201.21,117.6
X$4290 112 16973 8259 8222 8221 113 DFF_X1
* cell instance $4291 r0 *1 204.44,117.6
X$4291 8259 112 113 6708 CLKBUF_X3
* cell instance $4294 m0 *1 210.14,117.6
X$4294 8061 7170 8091 5767 8062 112 113 8254 AOI221_X1
* cell instance $4295 m0 *1 209,117.6
X$4295 6052 8132 7548 6827 7832 112 113 8255 AOI221_X1
* cell instance $4296 m0 *1 211.28,117.6
X$4296 6001 113 7298 112 BUF_X4
* cell instance $4297 m0 *1 212.61,117.6
X$4297 6001 6425 112 113 8223 NAND2_X1
* cell instance $4300 r0 *1 210.71,117.6
X$4300 8224 8254 8255 112 113 8349 OR3_X1
* cell instance $4301 r0 *1 211.66,117.6
X$4301 6166 6425 112 113 8091 NAND2_X2
* cell instance $4302 r0 *1 212.61,117.6
X$4302 6002 5895 113 112 8350 AND2_X1
* cell instance $4303 r0 *1 213.37,117.6
X$4303 8252 7274 8223 6426 5866 8351 113 112 AOI221_X2
* cell instance $4305 m0 *1 213.56,117.6
X$4305 6293 6331 112 113 8224 NAND2_X1
* cell instance $4306 m0 *1 214.32,117.6
X$4306 6002 5870 112 113 8252 NAND2_X1
* cell instance $4307 m0 *1 214.89,117.6
X$4307 5871 6714 112 113 8064 NOR2_X1
* cell instance $4309 m0 *1 215.65,117.6
X$4309 8061 5782 6562 112 113 8112 NOR3_X1
* cell instance $4310 m0 *1 216.41,117.6
X$4310 8112 8064 6831 113 7677 112 OAI21_X1
* cell instance $4311 m0 *1 217.17,117.6
X$4311 8064 7274 6429 113 8090 112 OAI21_X1
* cell instance $4312 m0 *1 217.93,117.6
X$4312 6032 6002 7051 112 113 8355 NAND3_X1
* cell instance $4316 r0 *1 215.84,117.6
X$4316 7431 7728 8225 7548 8065 8353 112 113 8243 OAI33_X1
* cell instance $4317 r0 *1 217.17,117.6
X$4317 5782 6714 7689 112 8354 113 AOI21_X1
* cell instance $4318 r0 *1 217.93,117.6
X$4318 1747 112 113 4841 CLKBUF_X3
* cell instance $4320 r0 *1 219.07,117.6
X$4320 8224 8239 8377 8226 113 112 7678 OAI22_X2
* cell instance $4322 m0 *1 219.83,117.6
X$4322 6287 6827 6436 112 7940 113 AOI21_X1
* cell instance $4323 m0 *1 221.35,117.6
X$4323 6827 5781 8246 113 8067 112 OAI21_X1
* cell instance $4324 m0 *1 222.11,117.6
X$4324 7433 8100 7298 6287 7578 8357 113 112 AOI221_X2
* cell instance $4325 m0 *1 224.2,117.6
X$4325 7832 6591 113 112 8100 AND2_X1
* cell instance $4327 m0 *1 225.72,117.6
X$4327 5870 6715 113 112 7574 AND2_X2
* cell instance $4328 m0 *1 226.67,117.6
X$4328 8592 5876 6289 112 113 8240 NAND3_X1
* cell instance $4331 m0 *1 228.38,117.6
X$4331 8237 8094 6289 112 8239 113 AOI21_X2
* cell instance $4332 m0 *1 229.71,117.6
X$4332 6329 8066 8091 6023 8070 112 113 8237 AOI221_X1
* cell instance $4333 m0 *1 230.85,117.6
X$4333 8070 7933 6429 112 113 8069 NAND3_X1
* cell instance $4334 m0 *1 231.61,117.6
X$4334 8066 7563 112 113 8071 NOR2_X1
* cell instance $4335 m0 *1 232.18,117.6
X$4335 8071 7933 7944 6436 112 113 8227 AOI22_X1
* cell instance $4336 m0 *1 233.13,117.6
X$4336 6280 7095 5662 6170 112 113 8474 AOI22_X1
* cell instance $4337 m0 *1 234.08,117.6
X$4337 6838 8072 7838 8070 113 112 8228 OAI22_X1
* cell instance $4338 m0 *1 235.03,117.6
X$4338 6710 112 113 7838 CLKBUF_X3
* cell instance $4341 m0 *1 237.69,117.6
X$4341 8073 112 113 8080 BUF_X1
* cell instance $4344 r0 *1 220.78,117.6
X$4344 6878 6723 112 113 8377 NAND2_X1
* cell instance $4345 r0 *1 221.35,117.6
X$4345 6440 6032 6171 112 113 8246 NAND3_X1
* cell instance $4347 r0 *1 222.3,117.6
X$4347 8067 6432 6425 113 8356 112 OAI21_X1
* cell instance $4350 r0 *1 224.2,117.6
X$4350 6287 6032 6052 112 8372 113 AOI21_X1
* cell instance $4351 r0 *1 224.96,117.6
X$4351 8370 8243 8068 7943 113 112 8244 OAI22_X2
* cell instance $4353 r0 *1 227.05,117.6
X$4353 8359 8240 6331 112 113 8370 NAND3_X1
* cell instance $4354 r0 *1 227.81,117.6
X$4354 6721 6329 5568 112 8368 113 AOI21_X1
* cell instance $4357 r0 *1 229.52,117.6
X$4357 6023 6426 7689 112 8367 113 AOI21_X1
* cell instance $4358 r0 *1 230.28,117.6
X$4358 6329 7690 7051 112 113 8480 NAND3_X1
* cell instance $4359 r0 *1 231.04,117.6
X$4359 6300 6831 8227 112 113 8358 MUX2_X1
* cell instance $4360 r0 *1 232.37,117.6
X$4360 8229 112 113 8366 BUF_X1
* cell instance $4363 r0 *1 234.08,117.6
X$4363 8230 112 113 8688 BUF_X1
* cell instance $4365 r0 *1 235.41,117.6
X$4365 112 16991 8235 8301 6437 113 DFF_X1
* cell instance $4369 r0 *1 238.64,117.6
X$4369 8235 112 113 8360 BUF_X1
* cell instance $4370 r0 *1 239.21,117.6
X$4370 8362 112 113 8231 BUF_X1
* cell instance $4372 m0 *1 33.44,165.2
X$4372 12300 12181 112 113 12367 NOR2_X1
* cell instance $4374 m0 *1 34.01,165.2
X$4374 10803 113 12649 112 BUF_X4
* cell instance $4375 m0 *1 35.34,165.2
X$4375 10547 10640 9952 112 113 12520 MUX2_X1
* cell instance $4376 m0 *1 36.67,165.2
X$4376 11058 112 113 12303 CLKBUF_X3
* cell instance $4378 m0 *1 37.81,165.2
X$4378 12367 12368 12176 12022 112 113 12523 AOI22_X2
* cell instance $4379 m0 *1 39.52,165.2
X$4379 11395 10630 112 113 12018 NOR2_X1
* cell instance $4380 m0 *1 40.09,165.2
X$4380 11718 11251 11719 10630 12524 12457 112 113 OAI221_X2
* cell instance $4381 m0 *1 42.18,165.2
X$4381 10798 10682 112 113 12107 NAND2_X1
* cell instance $4382 m0 *1 42.75,165.2
X$4382 10390 10630 12303 112 12525 113 AOI21_X1
* cell instance $4383 m0 *1 43.51,165.2
X$4383 12459 11398 12525 112 11177 113 AOI21_X1
* cell instance $4384 m0 *1 44.27,165.2
X$4384 11882 11718 10458 112 12577 113 AOI21_X1
* cell instance $4385 m0 *1 45.03,165.2
X$4385 11875 10681 11880 112 113 12302 NAND3_X1
* cell instance $4386 m0 *1 45.79,165.2
X$4386 10741 11476 10549 112 12459 113 AOI21_X2
* cell instance $4387 m0 *1 47.12,165.2
X$4387 10803 11255 12182 112 113 NOR2_X4
* cell instance $4388 m0 *1 48.83,165.2
X$4388 12649 11054 11251 10630 113 112 12305 OAI22_X2
* cell instance $4389 m0 *1 50.54,165.2
X$4389 112 10975 12179 113 BUF_X16
* cell instance $4391 m0 *1 55.48,165.2
X$4391 11569 10450 11641 113 12461 112 OAI21_X1
* cell instance $4393 m0 *1 56.43,165.2
X$4393 10682 11479 12179 112 113 12307 NAND3_X1
* cell instance $4394 m0 *1 57.19,165.2
X$4394 10873 12308 12307 112 12462 113 AOI21_X1
* cell instance $4399 m0 *1 12.54,165.2
X$4399 12455 112 113 12364 BUF_X1
* cell instance $4415 r0 *1 33.44,165.2
X$4415 10450 10401 16626 113 112 12099 HA_X1
* cell instance $4417 r0 *1 35.53,165.2
X$4417 10453 10451 12015 10803 11641 12573 113 112 AOI221_X2
* cell instance $4418 r0 *1 37.62,165.2
X$4418 12643 10873 12520 112 113 12644 MUX2_X1
* cell instance $4419 r0 *1 38.95,165.2
X$4419 11481 12456 112 113 12301 NAND2_X1
* cell instance $4420 r0 *1 39.52,165.2
X$4420 10280 11058 10624 112 12575 113 AOI21_X1
* cell instance $4421 r0 *1 40.28,165.2
X$4421 12457 11486 12371 12523 12458 12582 113 112 AOI221_X2
* cell instance $4423 r0 *1 42.56,165.2
X$4423 12177 11870 10806 112 113 12383 NOR3_X1
* cell instance $4425 r0 *1 43.7,165.2
X$4425 12644 12460 112 113 12535 NAND2_X2
* cell instance $4427 r0 *1 44.84,165.2
X$4427 12576 11823 12019 112 113 12645 NOR3_X1
* cell instance $4428 r0 *1 45.6,165.2
X$4428 12304 12460 12109 12578 12579 12645 112 113 12527 OAI33_X1
* cell instance $4430 r0 *1 47.31,165.2
X$4430 11392 12184 11944 11251 113 112 12652 OAI22_X1
* cell instance $4431 r0 *1 48.26,165.2
X$4431 12646 12460 12648 12019 12651 12653 112 113 OAI221_X2
* cell instance $4432 r0 *1 50.35,165.2
X$4432 12304 11817 12652 112 12651 113 AOI21_X1
* cell instance $4434 r0 *1 51.3,165.2
X$4434 12735 12582 12377 12528 12653 10766 112 113 OAI221_X2
* cell instance $4436 r0 *1 54.15,165.2
X$4436 12389 12460 10795 112 113 12386 NAND3_X1
* cell instance $4438 r0 *1 55.29,165.2
X$4438 11823 11398 112 113 12584 NOR2_X1
* cell instance $4439 r0 *1 55.86,165.2
X$4439 12303 12461 12016 112 12464 113 AOI21_X1
* cell instance $4440 r0 *1 56.62,165.2
X$4440 12464 12462 12463 12658 113 11344 112 NOR4_X2
* cell instance $4441 r0 *1 58.33,165.2
X$4441 12179 12465 12259 112 12658 113 AOI21_X1
* cell instance $4442 m0 *1 58.9,165.2
X$4442 12465 11875 12585 112 11967 113 AOI21_X1
* cell instance $4443 m0 *1 58.33,165.2
X$4443 11399 11479 112 113 12465 NAND2_X1
* cell instance $4445 r0 *1 59.09,165.2
X$4445 10873 10891 112 113 12585 NAND2_X1
* cell instance $4447 m0 *1 60.23,165.2
X$4447 12534 12185 113 112 12466 AND2_X1
* cell instance $4449 m0 *1 60.99,165.2
X$4449 12536 12527 12384 12187 113 10233 112 NOR4_X2
* cell instance $4450 m0 *1 62.7,165.2
X$4450 112 12536 11731 12537 12310 113 AOI21_X4
* cell instance $4454 r0 *1 61.18,165.2
X$4454 12459 12458 112 113 12538 NAND2_X1
* cell instance $4455 r0 *1 61.75,165.2
X$4455 112 12538 11571 12535 11724 12310 113 NAND4_X4
* cell instance $4462 m0 *1 70.3,165.2
X$4462 12663 12311 11573 112 113 12467 MUX2_X1
* cell instance $4465 m0 *1 71.82,165.2
X$4465 11521 113 12398 112 BUF_X4
* cell instance $4466 m0 *1 73.15,165.2
X$4466 12311 10531 11573 112 113 12541 MUX2_X1
* cell instance $4467 m0 *1 74.48,165.2
X$4467 11513 12667 12469 11669 12541 12144 113 112 AOI221_X2
* cell instance $4470 m0 *1 77.52,165.2
X$4470 11403 11068 12543 112 113 12394 NOR3_X1
* cell instance $4471 m0 *1 78.28,165.2
X$4471 12394 11733 12543 12470 12544 113 112 AOI211_X2
* cell instance $4472 m0 *1 79.99,165.2
X$4472 12027 112 113 12395 INV_X1
* cell instance $4473 m0 *1 80.37,165.2
X$4473 11733 12029 11973 112 12545 113 AOI21_X1
* cell instance $4474 m0 *1 81.13,165.2
X$4474 11403 11661 112 113 12471 NAND2_X2
* cell instance $4478 r0 *1 71.06,165.2
X$4478 12916 12398 12467 112 113 12128 MUX2_X1
* cell instance $4479 r0 *1 72.39,165.2
X$4479 12588 11521 12665 112 113 12664 NAND3_X1
* cell instance $4481 r0 *1 73.34,165.2
X$4481 12133 12664 11405 112 12807 113 AOI21_X1
* cell instance $4482 r0 *1 74.1,165.2
X$4482 12665 113 12667 112 BUF_X4
* cell instance $4483 r0 *1 75.43,165.2
X$4483 12468 12590 12588 12398 12312 12542 113 112 AOI221_X2
* cell instance $4484 r0 *1 77.52,165.2
X$4484 12469 12029 11665 112 12669 113 AOI21_X1
* cell instance $4486 r0 *1 78.66,165.2
X$4486 11513 11209 112 12470 113 OR2_X4
* cell instance $4487 r0 *1 80.37,165.2
X$4487 12674 12263 12544 112 113 12675 MUX2_X1
* cell instance $4489 r0 *1 81.89,165.2
X$4489 12312 112 113 12677 INV_X1
* cell instance $4490 r0 *1 82.27,165.2
X$4490 11521 11661 112 113 12593 NAND2_X2
* cell instance $4492 m0 *1 82.46,165.2
X$4492 11886 11892 113 112 12546 AND2_X1
* cell instance $4493 r0 *1 83.22,165.2
X$4493 12595 11663 12545 112 12548 113 AOI21_X1
* cell instance $4494 m0 *1 84.93,165.2
X$4494 12031 11995 112 113 12549 NAND2_X1
* cell instance $4495 m0 *1 83.6,165.2
X$4495 12031 113 12469 112 BUF_X4
* cell instance $4496 m0 *1 85.5,165.2
X$4496 112 12312 10812 10692 12550 113 NOR3_X4
* cell instance $4497 m0 *1 88.16,165.2
X$4497 11360 112 113 12315 INV_X1
* cell instance $4498 m0 *1 88.54,165.2
X$4498 12315 11521 11886 113 12473 112 OAI21_X1
* cell instance $4500 m0 *1 89.49,165.2
X$4500 11661 11405 10926 112 12316 113 AOI21_X2
* cell instance $4501 m0 *1 90.82,165.2
X$4501 10692 10812 11407 113 12602 112 NOR3_X2
* cell instance $4502 m0 *1 92.15,165.2
X$4502 11410 10812 11260 113 12474 112 NOR3_X2
* cell instance $4503 m0 *1 93.48,165.2
X$4503 12474 11981 12270 113 12317 112 OAI21_X1
* cell instance $4506 r0 *1 83.98,165.2
X$4506 12469 11665 11735 112 113 12681 NAND3_X1
* cell instance $4509 r0 *1 85.88,165.2
X$4509 12312 112 113 12194 BUF_X1
* cell instance $4511 r0 *1 86.64,165.2
X$4511 12682 11738 12135 112 113 12925 NAND3_X1
* cell instance $4512 r0 *1 87.4,165.2
X$4512 12472 11515 11262 112 113 12682 NAND3_X1
* cell instance $4515 r0 *1 90.06,165.2
X$4515 12395 11410 11578 113 112 12472 OAI21_X2
* cell instance $4516 r0 *1 91.39,165.2
X$4516 11410 11578 12028 112 113 12598 NOR3_X1
* cell instance $4517 r0 *1 92.15,165.2
X$4517 11359 11410 11578 113 112 12319 OAI21_X2
* cell instance $4518 r0 *1 93.48,165.2
X$4518 10120 12688 12686 112 12558 113 AOI21_X1
* cell instance $4521 r0 *1 94.81,165.2
X$4521 12035 11405 112 113 12600 NAND2_X2
* cell instance $4523 m0 *1 96.9,165.2
X$4523 11892 11411 11262 112 113 12409 NAND3_X1
* cell instance $4524 m0 *1 96.14,165.2
X$4524 12555 11263 12399 112 12476 113 AOI21_X1
* cell instance $4525 m0 *1 97.66,165.2
X$4525 11892 12319 112 113 12037 NAND2_X1
* cell instance $4527 m0 *1 98.99,165.2
X$4527 12320 12411 12317 112 12694 113 AOI21_X1
* cell instance $4532 r0 *1 97.09,165.2
X$4532 11743 12409 12599 112 12475 113 AOI21_X1
* cell instance $4533 r0 *1 97.85,165.2
X$4533 12475 10928 12690 112 12556 113 AOI21_X1
* cell instance $4534 r0 *1 98.61,165.2
X$4534 11263 12556 12149 113 12693 112 OAI21_X1
* cell instance $4536 r0 *1 99.75,165.2
X$4536 12542 12694 12321 112 113 12557 NOR3_X1
* cell instance $4538 m0 *1 218.12,114.8
X$4538 7832 5198 112 113 7938 NOR2_X1
* cell instance $4540 m0 *1 218.69,114.8
X$4540 7938 6745 7298 6838 5866 112 113 7939 AOI221_X1
* cell instance $4541 m0 *1 219.83,114.8
X$4541 7939 6825 7836 113 7552 112 OAI21_X1
* cell instance $4543 r0 *1 217.93,114.8
X$4543 8066 7938 7689 112 113 7962 NOR3_X1
* cell instance $4545 r0 *1 219.07,114.8
X$4545 6278 5873 112 113 8066 NOR2_X1
* cell instance $4548 r0 *1 220.21,114.8
X$4548 6174 7940 7941 112 7836 113 AOI21_X1
* cell instance $4550 m0 *1 221.16,114.8
X$4550 7689 6173 5424 112 113 7941 NAND3_X1
* cell instance $4555 r0 *1 221.54,114.8
X$4555 7325 7941 8102 113 112 7580 AND3_X1
* cell instance $4556 r0 *1 222.49,114.8
X$4556 7838 5425 112 113 8102 NAND2_X1
* cell instance $4559 m0 *1 223.06,114.8
X$4559 5782 6280 112 113 7837 NOR2_X1
* cell instance $4561 r0 *1 224.01,114.8
X$4561 7959 8098 7448 112 113 7682 NOR3_X1
* cell instance $4563 m0 *1 224.01,114.8
X$4563 7837 6839 7838 6287 6865 112 113 8098 AOI221_X1
* cell instance $4564 m0 *1 225.34,114.8
X$4564 7953 6436 6173 113 7942 112 OAI21_X1
* cell instance $4565 m0 *1 226.1,114.8
X$4565 112 6006 7280 7953 7832 6827 113 AOI22_X4
* cell instance $4566 m0 *1 229.33,114.8
X$4566 112 7557 6170 7953 6745 113 AOI21_X4
* cell instance $4567 m0 *1 231.8,114.8
X$4567 5424 6053 7298 6171 112 113 7842 AOI22_X2
* cell instance $4568 m0 *1 233.51,114.8
X$4568 7563 6170 112 113 7945 NAND2_X1
* cell instance $4569 m0 *1 234.08,114.8
X$4569 7170 7945 7842 5425 113 112 7946 OAI22_X2
* cell instance $4570 m0 *1 235.79,114.8
X$4570 6053 7838 112 113 7840 NAND2_X1
* cell instance $4571 m0 *1 236.36,114.8
X$4571 5427 7839 7840 112 7951 113 AOI21_X1
* cell instance $4572 m0 *1 237.12,114.8
X$4572 7947 112 113 7950 BUF_X1
* cell instance $4575 r0 *1 224.77,114.8
X$4575 7577 7936 7448 8086 113 7943 112 NOR4_X2
* cell instance $4578 r0 *1 227.05,114.8
X$4578 8241 7686 7570 113 8068 112 NOR3_X2
* cell instance $4580 r0 *1 228.76,114.8
X$4580 8069 7968 6174 7557 8090 7286 113 112 AOI221_X2
* cell instance $4581 r0 *1 230.85,114.8
X$4581 6745 112 113 6436 CLKBUF_X3
* cell instance $4582 r0 *1 231.8,114.8
X$4582 7832 6557 112 113 8070 NAND2_X1
* cell instance $4584 r0 *1 232.56,114.8
X$4584 6003 6710 6280 112 113 8072 MUX2_X1
* cell instance $4585 r0 *1 233.89,114.8
X$4585 7173 7951 6835 7946 113 8086 112 NOR4_X2
* cell instance $4590 r0 *1 235.98,114.8
X$4590 7563 6173 5662 112 113 7839 NAND3_X1
* cell instance $4591 r0 *1 236.74,114.8
X$4591 8595 112 113 7841 BUF_X1
* cell instance $4594 r0 *1 237.88,114.8
X$4594 8079 112 113 8074 BUF_X1
* cell instance $4595 r0 *1 238.45,114.8
X$4595 8081 112 113 7949 BUF_X1
* cell instance $4597 r0 *1 239.21,114.8
X$4597 7948 112 113 8076 BUF_X1
* cell instance $4601 m0 *1 82.65,229.6
X$4601 14988 16354 112 113 16346 NOR2_X1
* cell instance $4603 m0 *1 83.22,229.6
X$4603 16327 16346 15981 112 113 16347 NOR3_X1
* cell instance $4605 m0 *1 84.17,229.6
X$4605 14546 14379 14891 112 113 16328 NOR3_X1
* cell instance $4608 m0 *1 87.21,229.6
X$4608 15723 113 15405 112 BUF_X4
* cell instance $4612 m0 *1 93.29,229.6
X$4612 14379 113 14856 112 BUF_X4
* cell instance $4618 m0 *1 117.42,229.6
X$4618 112 16798 16370 16322 16355 113 DFF_X1
* cell instance $4621 m0 *1 123.88,229.6
X$4621 112 16879 16371 16330 16311 113 DFF_X1
* cell instance $4622 m0 *1 127.11,229.6
X$4622 16371 112 113 16333 BUF_X1
* cell instance $4624 m0 *1 128.44,229.6
X$4624 16334 16335 112 113 16336 NOR2_X1
* cell instance $4626 m0 *1 129.2,229.6
X$4626 16372 16336 16337 113 16357 112 OAI21_X1
* cell instance $4627 m0 *1 129.96,229.6
X$4627 16309 16333 112 113 16372 OR2_X1
* cell instance $4628 m0 *1 130.72,229.6
X$4628 16334 16333 16309 112 113 16373 NOR3_X1
* cell instance $4629 m0 *1 131.48,229.6
X$4629 16373 16312 3783 113 16339 112 OAI21_X1
* cell instance $4630 m0 *1 132.24,229.6
X$4630 16359 16334 16372 112 16349 113 AOI21_X1
* cell instance $4631 m0 *1 133,229.6
X$4631 16372 16334 16312 112 113 16359 NOR3_X1
* cell instance $4634 m0 *1 142.88,229.6
X$4634 112 16796 16341 16376 16361 113 DFF_X1
* cell instance $4666 m0 *1 74.1,229.6
X$4666 14887 113 15723 112 BUF_X4
* cell instance $4668 m0 *1 75.62,229.6
X$4668 15405 14930 16587 113 112 16196 HA_X1
* cell instance $4669 m0 *1 77.52,229.6
X$4669 16196 15981 16367 112 113 16343 MUX2_X1
* cell instance $4670 m0 *1 78.85,229.6
X$4670 14846 14930 112 113 16326 NOR2_X1
* cell instance $4671 m0 *1 79.42,229.6
X$4671 15405 14930 16507 113 112 15988 HA_X1
* cell instance $4694 r0 *1 81.7,229.6
X$4694 15537 14930 16694 113 112 16354 HA_X1
* cell instance $4707 r0 *1 128.44,229.6
X$4707 16332 16357 113 112 16356 AND2_X1
* cell instance $4712 r0 *1 131.86,229.6
X$4712 16332 16339 113 112 16374 AND2_X1
* cell instance $4713 r0 *1 132.62,229.6
X$4713 112 16961 16335 16374 16361 113 DFF_X1
* cell instance $4717 r0 *1 139.84,229.6
X$4717 112 17108 16385 13354 16361 113 DFF_X1
* cell instance $4720 r0 *1 144.97,229.6
X$4720 112 16989 16366 14259 16298 113 DFF_X1
* cell instance $4744 m0 *1 105.26,86.8
X$4744 5393 4890 112 113 5287 NOR2_X1
* cell instance $4745 m0 *1 101.65,86.8
X$4745 112 4600 3063 17221 5506 113 DFF_X2
* cell instance $4746 m0 *1 105.83,86.8
X$4746 5286 5287 5971 113 112 3619 MUX2_X2
* cell instance $4747 m0 *1 107.54,86.8
X$4747 112 5390 5167 5507 5288 113 DFF_X1
* cell instance $4749 m0 *1 110.96,86.8
X$4749 112 5161 5288 17220 5394 113 DFF_X2
* cell instance $4750 m0 *1 114.57,86.8
X$4750 5510 113 3118 112 BUF_X4
* cell instance $4753 m0 *1 99.18,86.8
X$4753 5388 4431 112 113 5389 NOR2_X1
* cell instance $4754 m0 *1 98.61,86.8
X$4754 5388 4904 112 113 5502 NAND2_X1
* cell instance $4757 r0 *1 98.61,86.8
X$4757 5632 5284 5500 5389 112 113 5503 NAND4_X1
* cell instance $4760 r0 *1 100.13,86.8
X$4760 5750 5502 5503 5494 5113 113 112 5726 OAI221_X1
* cell instance $4763 r0 *1 102.98,86.8
X$4763 2431 3928 112 113 5596 NOR2_X1
* cell instance $4766 r0 *1 105.83,86.8
X$4766 112 5170 113 5023 BUF_X8
* cell instance $4769 r0 *1 110.2,86.8
X$4769 185 3105 5391 112 113 5509 MUX2_X1
* cell instance $4770 r0 *1 111.53,86.8
X$4770 112 17098 5510 5509 5288 113 DFF_X1
* cell instance $4772 r0 *1 115.14,86.8
X$4772 256 4209 5392 112 113 5544 MUX2_X1
* cell instance $4775 m0 *1 117.8,86.8
X$4775 5491 4890 113 139 112 XOR2_X2
* cell instance $4778 m0 *1 121.98,86.8
X$4778 300 5508 5290 113 5289 112 OAI21_X1
* cell instance $4781 r0 *1 118.18,86.8
X$4781 5394 112 113 4813 BUF_X1
* cell instance $4786 r0 *1 121.6,86.8
X$4786 5395 5172 112 113 5508 NAND2_X1
* cell instance $4787 r0 *1 122.17,86.8
X$4787 300 5395 5396 112 113 5290 NAND3_X1
* cell instance $4788 r0 *1 122.93,86.8
X$4788 5396 5177 5173 112 113 5593 OR3_X1
* cell instance $4790 m0 *1 123.12,86.8
X$4790 5172 5393 5173 112 113 5505 OR3_X1
* cell instance $4791 m0 *1 124.83,86.8
X$4791 112 5397 5292 5505 5293 113 AOI21_X4
* cell instance $4792 m0 *1 127.3,86.8
X$4792 299 5399 5504 112 113 5501 NAND3_X1
* cell instance $4793 m0 *1 128.06,86.8
X$4793 4322 112 113 5504 INV_X1
* cell instance $4794 m0 *1 128.44,86.8
X$4794 5499 5400 5497 112 113 3260 OR3_X4
* cell instance $4795 m0 *1 130.53,86.8
X$4795 5496 5715 5347 112 5497 113 AOI21_X1
* cell instance $4796 m0 *1 131.29,86.8
X$4796 5401 4322 112 113 5712 NOR2_X1
* cell instance $4797 m0 *1 131.86,86.8
X$4797 5028 5043 4322 112 113 5402 NAND3_X1
* cell instance $4799 r0 *1 123.88,86.8
X$4799 5173 3635 5396 112 113 5592 NAND3_X1
* cell instance $4803 r0 *1 124.64,86.8
X$4803 5289 5545 5397 112 113 5109 OR3_X4
* cell instance $4805 r0 *1 126.92,86.8
X$4805 299 5493 5501 113 5499 112 OAI21_X1
* cell instance $4806 r0 *1 127.68,86.8
X$4806 5498 5800 112 113 5174 XNOR2_X2
* cell instance $4809 r0 *1 130.15,86.8
X$4809 5348 5587 112 113 5498 XNOR2_X2
* cell instance $4810 r0 *1 132.05,86.8
X$4810 3373 4510 113 5348 112 XOR2_X2
* cell instance $4811 m0 *1 133.19,86.8
X$4811 5547 5176 112 113 5344 XNOR2_X2
* cell instance $4813 m0 *1 135.09,86.8
X$4813 5490 5344 113 112 5030 XNOR2_X1
* cell instance $4817 r0 *1 133.95,86.8
X$4817 5403 112 113 5491 BUF_X1
* cell instance $4818 r0 *1 134.52,86.8
X$4818 5548 5403 113 112 5490 XNOR2_X1
* cell instance $4821 r0 *1 136.23,86.8
X$4821 3747 5489 113 112 5550 XNOR2_X1
* cell instance $4824 r0 *1 139.27,86.8
X$4824 112 17030 5488 5710 4918 113 DFF_X1
* cell instance $4825 r0 *1 142.5,86.8
X$4825 3376 5295 113 112 5642 XNOR2_X1
* cell instance $4827 m0 *1 142.69,86.8
X$4827 112 16769 5233 5296 5297 113 DFF_X1
* cell instance $4828 m0 *1 146.11,86.8
X$4828 4676 5031 112 113 5404 NOR2_X1
* cell instance $4832 r0 *1 145.92,86.8
X$4832 4676 4919 112 113 5486 NOR2_X1
* cell instance $4833 r0 *1 146.49,86.8
X$4833 5404 5486 5584 113 112 4660 MUX2_X2
* cell instance $4835 m0 *1 147.06,86.8
X$4835 4320 4919 112 113 5405 NAND2_X1
* cell instance $4837 m0 *1 148.01,86.8
X$4837 4320 5031 112 113 5406 NAND2_X1
* cell instance $4838 r0 *1 148.2,86.8
X$4838 5405 5406 5584 113 112 5407 MUX2_X2
* cell instance $4840 m0 *1 148.96,86.8
X$4840 5298 5407 112 113 4103 NAND2_X2
* cell instance $4841 r0 *1 149.91,86.8
X$4841 112 4925 113 5407 BUF_X8
* cell instance $4843 m0 *1 150.29,86.8
X$4843 112 4816 113 5298 BUF_X8
* cell instance $4844 r0 *1 152.38,86.8
X$4844 4816 113 3201 112 BUF_X4
* cell instance $4845 m0 *1 155.61,86.8
X$4845 2803 112 113 3689 CLKBUF_X3
* cell instance $4846 m0 *1 153.14,86.8
X$4846 112 4169 5180 3201 3113 113 AOI21_X4
* cell instance $4847 m0 *1 156.56,86.8
X$4847 2878 2909 3198 112 113 5409 MUX2_X1
* cell instance $4849 m0 *1 158.08,86.8
X$4849 112 4929 2878 4816 4925 113 AOI21_X4
* cell instance $4851 m0 *1 160.74,86.8
X$4851 3088 113 3267 112 BUF_X4
* cell instance $4852 m0 *1 162.07,86.8
X$4852 5098 4001 5181 112 5477 113 AOI21_X1
* cell instance $4854 m0 *1 163.02,86.8
X$4854 5339 5299 5301 113 5474 112 OAI21_X1
* cell instance $4855 m0 *1 163.78,86.8
X$4855 4587 5336 3479 5337 4383 113 112 5411 OAI221_X1
* cell instance $4856 m0 *1 164.92,86.8
X$4856 3087 4048 112 113 5336 NAND2_X1
* cell instance $4858 r0 *1 153.71,86.8
X$4858 4925 113 3113 112 BUF_X4
* cell instance $4861 r0 *1 156.94,86.8
X$4861 5583 113 3088 112 BUF_X4
* cell instance $4862 r0 *1 158.27,86.8
X$4862 4924 2804 5409 113 112 5580 OAI21_X2
* cell instance $4865 r0 *1 160.17,86.8
X$4865 5580 4174 2469 113 5478 112 NOR3_X2
* cell instance $4866 r0 *1 161.5,86.8
X$4866 5579 5478 5301 4286 5552 113 112 AOI211_X2
* cell instance $4867 r0 *1 163.21,86.8
X$4867 4820 5552 5410 5477 112 113 5696 AOI22_X1
* cell instance $4868 r0 *1 164.16,86.8
X$4868 2684 4048 112 113 5579 NAND2_X1
* cell instance $4870 r0 *1 164.92,86.8
X$4870 4383 2684 5474 5334 113 112 5410 AND4_X2
* cell instance $4871 m0 *1 166.06,86.8
X$4871 5333 5182 2640 4001 112 113 5334 NAND4_X1
* cell instance $4873 m0 *1 167.01,86.8
X$4873 4394 4383 5472 112 113 5467 OR3_X2
* cell instance $4874 m0 *1 168.15,86.8
X$4874 5332 2916 5184 112 5472 113 AOI21_X1
* cell instance $4875 m0 *1 168.91,86.8
X$4875 4929 4667 3294 112 113 5185 NOR3_X1
* cell instance $4876 m0 *1 169.67,86.8
X$4876 5183 5186 112 113 5190 OR2_X2
* cell instance $4877 m0 *1 170.62,86.8
X$4877 4924 4048 112 113 3077 NOR2_X2
* cell instance $4878 m0 *1 171.57,86.8
X$4878 4049 5464 5329 5467 5461 112 113 OAI211_X2
* cell instance $4880 m0 *1 173.47,86.8
X$4880 2469 5189 5413 5188 113 112 5039 OAI22_X2
* cell instance $4881 m0 *1 175.18,86.8
X$4881 3689 5302 2512 113 5413 112 OAI21_X1
* cell instance $4883 m0 *1 176.13,86.8
X$4883 5325 4379 3077 112 113 5464 NAND3_X1
* cell instance $4884 m0 *1 176.89,86.8
X$4884 5303 5465 3479 3087 4040 113 112 5325 OAI221_X1
* cell instance $4887 r0 *1 166.25,86.8
X$4887 2512 4924 112 113 5301 NOR2_X2
* cell instance $4890 r0 *1 168.15,86.8
X$4890 4924 112 113 4001 CLKBUF_X3
* cell instance $4891 r0 *1 169.1,86.8
X$4891 4048 112 113 4383 INV_X2
* cell instance $4892 r0 *1 169.67,86.8
X$4892 2684 112 113 2916 CLKBUF_X3
* cell instance $4896 m0 *1 179.17,86.8
X$4896 2469 112 113 3087 CLKBUF_X3
* cell instance $4897 m0 *1 180.31,86.8
X$4897 3267 113 2358 112 BUF_X4
* cell instance $4901 m0 *1 185.63,86.8
X$4901 112 16920 5459 5461 4554 113 DFF_X1
* cell instance $4902 m0 *1 188.86,86.8
X$4902 5194 5556 112 113 5460 NAND2_X1
* cell instance $4912 r0 *1 188.29,86.8
X$4912 5555 5415 5460 112 113 4443 MUX2_X1
* cell instance $4913 r0 *1 189.62,86.8
X$4913 5576 5415 5575 112 113 4444 MUX2_X1
* cell instance $4914 m0 *1 191.33,86.8
X$4914 5458 5306 113 112 5322 XNOR2_X1
* cell instance $4915 m0 *1 190.57,86.8
X$4915 5459 112 113 5305 BUF_X2
* cell instance $4919 r0 *1 191.9,86.8
X$4919 5414 5647 113 112 5416 XNOR2_X1
* cell instance $4920 m0 *1 193.04,86.8
X$4920 5305 5193 112 113 5557 XOR2_X1
* cell instance $4925 r0 *1 194.18,86.8
X$4925 5457 5557 113 112 5574 XNOR2_X1
* cell instance $4926 m0 *1 194.75,86.8
X$4926 5305 5309 113 112 5320 XNOR2_X1
* cell instance $4930 r0 *1 195.32,86.8
X$4930 5416 5574 113 112 5417 XNOR2_X1
* cell instance $4932 r0 *1 196.84,86.8
X$4932 5416 5573 112 113 5456 XOR2_X1
* cell instance $4934 m0 *1 197.03,86.8
X$4934 5308 5456 5231 113 112 2847 MUX2_X2
* cell instance $4938 m0 *1 26.22,106.4
X$4938 6902 7002 16572 113 112 7295 HA_X1
* cell instance $4941 m0 *1 28.31,106.4
X$4941 7002 6796 7124 113 112 7066 HA_X1
* cell instance $4942 m0 *1 30.21,106.4
X$4942 112 7637 113 7067 BUF_X8
* cell instance $4943 m0 *1 32.68,106.4
X$4943 112 7067 7004 7005 7176 113 NOR3_X4
* cell instance $4944 m0 *1 35.34,106.4
X$4944 112 7177 7004 7005 7218 113 NOR3_X4
* cell instance $4945 m0 *1 38,106.4
X$4945 112 7069 7003 6904 7217 113 NOR3_X4
* cell instance $4946 m0 *1 40.66,106.4
X$4946 7176 7072 112 113 7073 NOR2_X1
* cell instance $4947 m0 *1 41.23,106.4
X$4947 7008 7007 7009 112 113 7125 MUX2_X1
* cell instance $4948 m0 *1 42.56,106.4
X$4948 7179 7178 112 113 7006 NAND2_X1
* cell instance $4949 m0 *1 43.13,106.4
X$4949 6910 7002 7180 112 113 7126 MUX2_X1
* cell instance $4950 m0 *1 44.46,106.4
X$4950 7008 7011 7009 112 113 7181 MUX2_X1
* cell instance $4951 m0 *1 45.79,106.4
X$4951 7010 7011 7127 112 113 7182 NOR3_X1
* cell instance $4954 m0 *1 47.5,106.4
X$4954 7179 7127 7011 112 113 7185 MUX2_X1
* cell instance $4955 m0 *1 48.83,106.4
X$4955 7190 112 113 7310 BUF_X1
* cell instance $4956 m0 *1 49.4,106.4
X$4956 7179 7065 112 113 7186 NOR2_X1
* cell instance $4957 m0 *1 49.97,106.4
X$4957 112 7127 6901 113 BUF_X32
* cell instance $4960 m0 *1 60.23,106.4
X$4960 7179 112 113 7180 CLKBUF_X3
* cell instance $4961 m0 *1 61.18,106.4
X$4961 7078 112 113 7188 CLKBUF_X3
* cell instance $4963 m0 *1 62.32,106.4
X$4963 112 6665 113 7189 BUF_X8
* cell instance $4964 m0 *1 64.79,106.4
X$4964 6513 112 113 5150 INV_X8
* cell instance $4965 m0 *1 66.5,106.4
X$4965 5528 5621 5956 112 113 NOR2_X4
* cell instance $4966 m0 *1 68.21,106.4
X$4966 112 6747 7013 6862 7014 113 AOI21_X4
* cell instance $4967 m0 *1 70.68,106.4
X$4967 6747 6514 112 5832 113 NAND2_X4
* cell instance $4968 m0 *1 72.39,106.4
X$4968 4629 113 4424 112 BUF_X4
* cell instance $4969 m0 *1 73.72,106.4
X$4969 112 4636 7085 6747 6514 113 AOI21_X4
* cell instance $4971 m0 *1 13.87,106.4
X$4971 6862 6899 7059 112 113 7175 MUX2_X1
* cell instance $4972 m0 *1 10.64,106.4
X$4972 112 16859 6504 6906 7061 113 DFF_X1
* cell instance $4973 m0 *1 15.2,106.4
X$4973 112 16872 7062 7175 7061 113 DFF_X1
* cell instance $4974 m0 *1 18.43,106.4
X$4974 7062 112 113 6862 CLKBUF_X3
* cell instance $4986 r0 *1 14.63,106.4
X$4986 7290 6899 5669 112 113 7215 MUX2_X1
* cell instance $4990 r0 *1 18.62,106.4
X$4990 7292 6899 5776 112 113 7291 MUX2_X1
* cell instance $4992 m0 *1 19.76,106.4
X$4992 112 7001 7061 17223 6960 113 DFF_X2
* cell instance $4998 r0 *1 24.13,106.4
X$4998 7124 113 7216 112 BUF_X4
* cell instance $4999 r0 *1 25.46,106.4
X$4999 7009 6904 7003 113 112 6968 OAI21_X4
* cell instance $5002 r0 *1 28.5,106.4
X$5002 6904 113 7391 112 BUF_X4
* cell instance $5003 r0 *1 29.83,106.4
X$5003 7124 112 113 7178 BUF_X2
* cell instance $5004 r0 *1 30.59,106.4
X$5004 112 7009 6902 113 BUF_X32
* cell instance $5005 r0 *1 39.9,106.4
X$5005 112 7003 7216 6904 7299 113 NOR3_X4
* cell instance $5006 r0 *1 42.56,106.4
X$5006 7496 112 113 7008 INV_X8
* cell instance $5007 r0 *1 44.27,106.4
X$5007 7128 112 113 7220 CLKBUF_X3
* cell instance $5009 r0 *1 45.41,106.4
X$5009 7223 6968 7182 7185 7306 7498 113 112 AOI221_X2
* cell instance $5011 r0 *1 47.69,106.4
X$5011 112 7190 7127 113 INV_X16
* cell instance $5012 r0 *1 50.92,106.4
X$5012 7186 7180 7227 112 7311 113 AOI21_X1
* cell instance $5013 r0 *1 51.68,106.4
X$5013 7313 7127 7128 112 7227 113 AOI21_X1
* cell instance $5014 r0 *1 52.44,106.4
X$5014 6970 113 7312 112 BUF_X4
* cell instance $5015 r0 *1 53.77,106.4
X$5015 112 6970 7004 7005 7313 113 NOR3_X4
* cell instance $5016 r0 *1 56.43,106.4
X$5016 7005 7004 7011 112 113 NOR2_X4
* cell instance $5017 r0 *1 58.14,106.4
X$5017 112 7002 113 7129 BUF_X8
* cell instance $5018 r0 *1 60.61,106.4
X$5018 112 7315 7190 113 BUF_X16
* cell instance $5019 r0 *1 65.36,106.4
X$5019 4720 113 7230 112 BUF_X4
* cell instance $5020 r0 *1 66.69,106.4
X$5020 112 6666 5621 5528 4728 113 NOR3_X4
* cell instance $5025 r0 *1 69.73,106.4
X$5025 6384 4194 5956 112 6863 113 AOI21_X1
* cell instance $5026 r0 *1 70.49,106.4
X$5026 7319 6862 7318 113 112 7320 OAI21_X4
* cell instance $5028 r0 *1 73.15,106.4
X$5028 112 5714 113 7085 BUF_X8
* cell instance $5029 r0 *1 75.62,106.4
X$5029 112 6077 4252 113 BUF_X16
* cell instance $5030 m0 *1 79.04,106.4
X$5030 7015 6749 4732 4980 6231 7198 113 112 AOI221_X2
* cell instance $5031 m0 *1 76.57,106.4
X$5031 5269 6077 5270 112 5013 113 NAND3_X4
* cell instance $5032 m0 *1 81.13,106.4
X$5032 7198 4148 5743 6751 7092 113 112 AOI211_X2
* cell instance $5033 m0 *1 82.84,106.4
X$5033 5743 7016 7087 113 7017 112 OAI21_X1
* cell instance $5034 m0 *1 83.6,106.4
X$5034 7087 112 113 4904 CLKBUF_X3
* cell instance $5036 m0 *1 85.31,106.4
X$5036 6864 4148 4537 6913 7091 113 112 AOI211_X2
* cell instance $5037 m0 *1 87.02,106.4
X$5037 6056 113 4537 112 BUF_X4
* cell instance $5038 m0 *1 88.35,106.4
X$5038 6804 7091 6914 5246 113 112 7324 OAI22_X2
* cell instance $5040 m0 *1 90.25,106.4
X$5040 7092 4809 4492 112 113 7201 NOR3_X1
* cell instance $5041 m0 *1 91.01,106.4
X$5041 6517 4431 112 113 7131 NAND2_X1
* cell instance $5042 m0 *1 91.58,106.4
X$5042 6759 6804 4431 112 113 7132 NAND3_X1
* cell instance $5043 m0 *1 92.34,106.4
X$5043 5744 112 113 4809 CLKBUF_X3
* cell instance $5048 r0 *1 80.37,106.4
X$5048 7233 3875 113 4148 112 XOR2_X2
* cell instance $5049 r0 *1 82.08,106.4
X$5049 6673 113 4606 112 BUF_X4
* cell instance $5050 r0 *1 83.41,106.4
X$5050 3875 7233 113 112 7087 XNOR2_X1
* cell instance $5052 r0 *1 86.07,106.4
X$5052 7230 7203 113 6906 112 XOR2_X2
* cell instance $5053 r0 *1 87.78,106.4
X$5053 7235 3575 113 5744 112 XOR2_X2
* cell instance $5057 r0 *1 90.82,106.4
X$5057 7131 7201 7130 7324 7132 7138 113 112 AOI221_X2
* cell instance $5060 r0 *1 93.86,106.4
X$5060 112 5177 5395 113 BUF_X16
* cell instance $5062 m0 *1 99.18,106.4
X$5062 112 16837 7096 7018 7019 113 DFF_X1
* cell instance $5064 m0 *1 102.41,106.4
X$5064 7096 113 5634 112 BUF_X4
* cell instance $5065 m0 *1 103.74,106.4
X$5065 112 16801 7099 7098 7019 113 DFF_X1
* cell instance $5066 m0 *1 106.97,106.4
X$5066 7099 113 7020 112 BUF_X4
* cell instance $5069 r0 *1 101.65,106.4
X$5069 4279 112 113 7019 CLKBUF_X3
* cell instance $5070 r0 *1 102.6,106.4
X$5070 7019 112 113 16478 CLKBUF_X1
* cell instance $5074 r0 *1 105.26,106.4
X$5074 3365 3541 113 7237 112 XOR2_X2
* cell instance $5075 r0 *1 106.97,106.4
X$5075 3541 3365 112 113 7469 XNOR2_X2
* cell instance $5077 r0 *1 109.06,106.4
X$5077 7133 7134 7241 7239 112 113 7137 NAND4_X1
* cell instance $5078 m0 *1 110.39,106.4
X$5078 7135 7133 113 112 7102 AND2_X1
* cell instance $5079 m0 *1 109.44,106.4
X$5079 7135 7134 7203 6395 112 113 7136 NAND4_X1
* cell instance $5081 r0 *1 110.01,106.4
X$5081 112 7240 7329 7137 7136 6917 113 AND4_X4
* cell instance $5082 m0 *1 112.29,106.4
X$5082 7022 5166 113 7134 112 XOR2_X2
* cell instance $5083 m0 *1 111.53,106.4
X$5083 7242 7102 7021 113 7104 112 OAI21_X1
* cell instance $5084 m0 *1 114,106.4
X$5084 5166 7022 112 113 7021 XNOR2_X2
* cell instance $5087 r0 *1 112.48,106.4
X$5087 7133 7134 6916 7245 112 113 7329 NAND4_X1
* cell instance $5090 r0 *1 115.14,106.4
X$5090 7239 112 113 7245 INV_X2
* cell instance $5093 r0 *1 116.66,106.4
X$5093 3068 7023 113 112 7332 AND2_X1
* cell instance $5094 r0 *1 117.42,106.4
X$5094 7332 7139 7330 113 112 6905 MUX2_X2
* cell instance $5095 m0 *1 117.99,106.4
X$5095 7023 7408 112 113 7139 NOR2_X1
* cell instance $5098 m0 *1 119.89,106.4
X$5098 7409 7023 113 112 6679 XNOR2_X1
* cell instance $5099 m0 *1 118.94,106.4
X$5099 7106 112 113 7334 CLKBUF_X3
* cell instance $5102 m0 *1 123.31,106.4
X$5102 7518 5634 112 113 6111 NOR2_X1
* cell instance $5103 m0 *1 123.88,106.4
X$5103 6983 113 3105 112 BUF_X4
* cell instance $5106 m0 *1 126.16,106.4
X$5106 112 16759 7110 7108 7335 113 DFF_X1
* cell instance $5107 m0 *1 129.39,106.4
X$5107 7110 113 2809 112 BUF_X4
* cell instance $5108 m0 *1 130.72,106.4
X$5108 3375 5757 113 6919 112 XOR2_X2
* cell instance $5112 r0 *1 119.51,106.4
X$5112 4922 7334 112 113 7023 XNOR2_X2
* cell instance $5113 r0 *1 121.41,106.4
X$5113 112 7138 6680 17255 5794 113 DFF_X2
* cell instance $5119 r0 *1 125.59,106.4
X$5119 7213 3105 7248 112 113 7336 MUX2_X1
* cell instance $5124 r0 *1 130.72,106.4
X$5124 6532 112 113 7249 BUF_X1
* cell instance $5125 r0 *1 131.29,106.4
X$5125 5757 3375 112 113 7140 XNOR2_X2
* cell instance $5127 r0 *1 133.57,106.4
X$5127 5643 5237 113 6398 112 XOR2_X2
* cell instance $5129 r0 *1 135.47,106.4
X$5129 5237 5643 112 113 6990 XNOR2_X2
* cell instance $5131 m0 *1 135.85,106.4
X$5131 7112 6398 112 113 6809 NAND2_X1
* cell instance $5134 m0 *1 138.13,106.4
X$5134 7114 6498 112 113 6246 NOR2_X1
* cell instance $5135 m0 *1 137.56,106.4
X$5135 7212 4407 112 113 7112 NOR2_X1
* cell instance $5139 m0 *1 140.79,106.4
X$5139 112 7024 6922 6920 6141 113 NOR3_X4
* cell instance $5142 m0 *1 143.64,106.4
X$5142 7030 6920 6922 113 112 6536 OAI21_X2
* cell instance $5143 m0 *1 144.97,106.4
X$5143 6694 7109 6921 112 113 7209 MUX2_X1
* cell instance $5144 m0 *1 146.3,106.4
X$5144 6255 6537 6536 113 7208 112 OAI21_X1
* cell instance $5145 m0 *1 147.06,106.4
X$5145 6920 6922 6647 113 6691 112 NOR3_X2
* cell instance $5146 m0 *1 148.39,106.4
X$5146 6920 6922 7032 112 113 7025 NOR3_X1
* cell instance $5147 m0 *1 149.15,106.4
X$5147 7025 6410 7026 112 7111 113 AOI21_X2
* cell instance $5148 m0 *1 150.48,106.4
X$5148 7122 7027 6406 112 113 7207 NAND3_X1
* cell instance $5149 m0 *1 151.24,106.4
X$5149 6255 6199 7024 6929 112 113 7122 AOI22_X1
* cell instance $5150 m0 *1 152.19,106.4
X$5150 7115 112 113 6360 CLKBUF_X3
* cell instance $5155 r0 *1 142.5,106.4
X$5155 7141 6257 112 113 7251 NAND2_X1
* cell instance $5158 r0 *1 143.64,106.4
X$5158 7210 7207 7141 6140 112 113 7342 NAND4_X1
* cell instance $5159 r0 *1 144.59,106.4
X$5159 7347 7345 5913 112 113 7210 NAND3_X1
* cell instance $5160 r0 *1 145.35,106.4
X$5160 6641 6360 6142 113 7345 112 OAI21_X1
* cell instance $5162 r0 *1 146.3,106.4
X$5162 7348 6260 7208 112 5408 113 AOI21_X2
* cell instance $5163 r0 *1 147.63,106.4
X$5163 112 7253 6793 6688 7348 113 NOR3_X4
* cell instance $5164 r0 *1 150.29,106.4
X$5164 6260 7352 6353 6352 112 113 6814 AOI22_X1
* cell instance $5165 r0 *1 151.24,106.4
X$5165 6647 112 113 7256 BUF_X1
* cell instance $5167 r0 *1 152.19,106.4
X$5167 6646 6139 112 113 7257 NOR2_X1
* cell instance $5168 r0 *1 152.76,106.4
X$5168 7257 7258 7356 113 7354 112 OAI21_X1
* cell instance $5169 r0 *1 153.52,106.4
X$5169 7360 7354 5848 113 6923 112 NOR3_X2
* cell instance $5172 m0 *1 155.04,106.4
X$5172 6360 6349 112 113 7206 NAND2_X1
* cell instance $5174 r0 *1 155.23,106.4
X$5174 7206 7142 6195 6781 112 113 7258 NAND4_X1
* cell instance $5175 r0 *1 156.18,106.4
X$5175 6148 6485 7142 7143 6255 113 112 7029 OAI221_X1
* cell instance $5176 m0 *1 157.51,106.4
X$5176 7116 7259 7204 7118 112 113 6999 AOI22_X2
* cell instance $5177 m0 *1 156.75,106.4
X$5177 6257 7029 7120 113 7118 112 OAI21_X1
* cell instance $5178 m0 *1 159.22,106.4
X$5178 5988 6405 5848 112 113 7204 NOR3_X1
* cell instance $5180 r0 *1 157.32,106.4
X$5180 7365 6405 112 113 7259 NOR2_X1
* cell instance $5182 m0 *1 161.69,106.4
X$5182 6934 7030 112 113 7144 NAND2_X1
* cell instance $5183 m0 *1 160.36,106.4
X$5183 7202 6195 6931 112 113 7116 MUX2_X1
* cell instance $5184 m0 *1 162.26,106.4
X$5184 6688 6470 7121 6255 113 112 7031 OAI22_X2
* cell instance $5185 m0 *1 163.97,106.4
X$5185 7115 6205 112 113 7145 NAND2_X1
* cell instance $5186 m0 *1 164.54,106.4
X$5186 6688 6647 112 113 7033 NAND2_X1
* cell instance $5187 m0 *1 165.11,106.4
X$5187 7032 5981 7113 112 113 7200 MUX2_X1
* cell instance $5189 m0 *1 167.96,106.4
X$5189 7031 7149 6816 7111 5913 5852 112 113 OAI221_X2
* cell instance $5190 m0 *1 170.05,106.4
X$5190 112 6064 5194 113 BUF_X16
* cell instance $5194 r0 *1 160.93,106.4
X$5194 7370 5408 6140 113 112 7373 OAI21_X2
* cell instance $5195 r0 *1 162.26,106.4
X$5195 7117 7144 7375 6642 113 112 7202 OAI22_X1
* cell instance $5196 r0 *1 163.21,106.4
X$5196 7260 7145 6140 6924 6547 113 112 6473 OAI221_X1
* cell instance $5197 r0 *1 164.35,106.4
X$5197 7033 7144 6360 112 113 7146 NAND3_X1
* cell instance $5198 r0 *1 165.11,106.4
X$5198 6697 7145 6816 6360 7261 113 112 7379 OAI221_X1
* cell instance $5199 r0 *1 166.25,106.4
X$5199 7146 7147 6195 112 113 7370 NAND3_X1
* cell instance $5200 r0 *1 167.01,106.4
X$5200 7199 6646 7380 112 7034 113 AOI21_X1
* cell instance $5202 r0 *1 168.15,106.4
X$5202 7148 5981 112 113 7147 OR2_X1
* cell instance $5203 r0 *1 168.91,106.4
X$5203 6139 6255 16638 113 112 7148 HA_X1
* cell instance $5204 r0 *1 170.81,106.4
X$5204 6537 7148 7262 112 113 7199 NOR3_X1
* cell instance $5205 r0 *1 171.57,106.4
X$5205 7109 7024 112 113 7035 NOR2_X1
* cell instance $5210 r0 *1 177.65,106.4
X$5210 7371 7197 113 7266 112 XOR2_X2
* cell instance $5211 m0 *1 179.55,106.4
X$5211 6942 6271 112 113 7150 XNOR2_X2
* cell instance $5212 m0 *1 178.98,106.4
X$5212 5394 112 113 7197 BUF_X1
* cell instance $5214 m0 *1 181.64,106.4
X$5214 5760 113 7376 112 BUF_X4
* cell instance $5216 r0 *1 179.36,106.4
X$5216 5760 5394 112 113 7368 XNOR2_X2
* cell instance $5220 r0 *1 181.26,106.4
X$5220 5760 113 7270 112 BUF_X4
* cell instance $5221 r0 *1 182.59,106.4
X$5221 7196 6941 7036 112 7269 113 AOI21_X1
* cell instance $5223 m0 *1 185.82,106.4
X$5223 6940 7037 113 112 7195 XNOR2_X1
* cell instance $5224 m0 *1 183.35,106.4
X$5224 3926 6821 6987 112 7372 113 NAND3_X4
* cell instance $5225 m0 *1 186.96,106.4
X$5225 5394 112 113 7369 BUF_X1
* cell instance $5226 m0 *1 187.53,106.4
X$5226 6943 6942 112 113 7194 NAND2_X1
* cell instance $5227 m0 *1 188.1,106.4
X$5227 6939 7037 112 113 7038 XOR2_X1
* cell instance $5229 m0 *1 189.43,106.4
X$5229 5179 7039 112 113 7040 NOR2_X1
* cell instance $5231 r0 *1 183.54,106.4
X$5231 112 7374 7195 7194 7372 113 AOI21_X4
* cell instance $5232 r0 *1 186.01,106.4
X$5232 7367 112 113 7371 BUF_X1
* cell instance $5234 r0 *1 186.96,106.4
X$5234 6945 7368 112 113 7366 XNOR2_X2
* cell instance $5235 r0 *1 188.86,106.4
X$5235 6704 7362 7039 112 113 7363 NAND3_X1
* cell instance $5236 r0 *1 189.62,106.4
X$5236 7038 7363 7358 112 7193 113 AOI21_X1
* cell instance $5238 m0 *1 190.38,106.4
X$5238 7105 7042 7103 112 7152 113 AOI21_X1
* cell instance $5239 r0 *1 190.38,106.4
X$5239 7040 6704 112 113 7042 NAND2_X1
* cell instance $5240 r0 *1 190.95,106.4
X$5240 7152 7193 7153 112 113 7357 OR3_X1
* cell instance $5242 m0 *1 191.52,106.4
X$5242 6945 5043 7039 112 113 7103 NAND3_X1
* cell instance $5243 r0 *1 191.9,106.4
X$5243 7357 113 5656 112 BUF_X4
* cell instance $5244 m0 *1 192.85,106.4
X$5244 6940 7155 113 5885 112 XOR2_X2
* cell instance $5247 m0 *1 196.08,106.4
X$5247 7192 4948 6016 112 113 7191 MUX2_X1
* cell instance $5249 m0 *1 197.6,106.4
X$5249 6164 7156 113 7064 112 XOR2_X2
* cell instance $5250 m0 *1 199.31,106.4
X$5250 6706 3926 7100 113 7157 112 NOR3_X2
* cell instance $5252 m0 *1 201.4,106.4
X$5252 112 16794 7097 7044 7043 113 DFF_X1
* cell instance $5253 m0 *1 204.63,106.4
X$5253 7045 7273 5656 112 7095 113 NAND3_X4
* cell instance $5255 m0 *1 207.29,106.4
X$5255 5657 5867 5562 112 113 7046 MUX2_X1
* cell instance $5256 m0 *1 208.62,106.4
X$5256 7187 6823 7093 112 7047 113 AOI21_X1
* cell instance $5257 m0 *1 209.38,106.4
X$5257 7161 5677 6823 5867 5655 112 113 7187 AOI221_X1
* cell instance $5258 m0 *1 210.52,106.4
X$5258 6710 5420 112 113 7163 NAND2_X1
* cell instance $5259 m0 *1 211.09,106.4
X$5259 6001 5420 112 113 6952 NOR2_X2
* cell instance $5261 r0 *1 193.23,106.4
X$5261 112 7154 7192 7191 6705 113 DFF_X1
* cell instance $5265 r0 *1 198.93,106.4
X$5265 3465 7100 112 113 7158 NAND2_X1
* cell instance $5266 r0 *1 199.5,106.4
X$5266 112 7045 7157 6706 7349 113 AOI21_X4
* cell instance $5268 r0 *1 202.16,106.4
X$5268 5656 112 113 7160 INV_X2
* cell instance $5269 r0 *1 202.73,106.4
X$5269 112 5661 113 7160 BUF_X8
* cell instance $5270 r0 *1 205.2,106.4
X$5270 112 7274 5421 7273 7045 113 AOI21_X4
* cell instance $5272 r0 *1 208.05,106.4
X$5272 7274 5865 7162 113 7164 112 NOR3_X2
* cell instance $5273 r0 *1 209.38,106.4
X$5273 7164 5446 7094 112 7275 113 AOI21_X1
* cell instance $5274 r0 *1 210.14,106.4
X$5274 7162 5767 112 113 7339 NOR2_X1
* cell instance $5275 r0 *1 210.71,106.4
X$5275 5867 5565 112 113 7162 NOR2_X1
* cell instance $5277 r0 *1 211.47,106.4
X$5277 6175 6713 7163 5565 6053 112 113 7184 AOI221_X1
* cell instance $5278 m0 *1 213.56,106.4
X$5278 7046 7048 112 113 7086 NAND2_X1
* cell instance $5279 m0 *1 212.42,106.4
X$5279 6006 7088 7165 5873 5677 112 113 7183 AOI221_X1
* cell instance $5280 m0 *1 214.13,106.4
X$5280 7166 7086 6949 112 113 7081 NAND3_X1
* cell instance $5282 m0 *1 215.08,106.4
X$5282 6878 112 113 7049 INV_X1
* cell instance $5283 m0 *1 215.46,106.4
X$5283 7049 6428 7083 7183 112 113 7050 OR4_X1
* cell instance $5284 m0 *1 216.6,106.4
X$5284 7082 7050 7167 7080 113 112 7044 AND4_X1
* cell instance $5285 m0 *1 217.74,106.4
X$5285 6171 6715 7433 6949 113 112 7083 AND4_X1
* cell instance $5286 m0 *1 218.88,106.4
X$5286 7165 7077 7081 113 7084 112 OAI21_X1
* cell instance $5288 m0 *1 219.83,106.4
X$5288 7168 7079 6716 112 113 7080 NAND3_X1
* cell instance $5291 m0 *1 221.54,106.4
X$5291 6714 112 113 7169 INV_X1
* cell instance $5295 r0 *1 212.61,106.4
X$5295 6166 5569 112 113 7165 NAND2_X2
* cell instance $5297 r0 *1 213.94,106.4
X$5297 7274 5783 6733 113 7166 112 OAI21_X1
* cell instance $5300 r0 *1 216.98,106.4
X$5300 6835 6460 112 113 7052 NAND2_X2
* cell instance $5303 r0 *1 218.88,106.4
X$5303 7164 6174 112 113 6950 NOR2_X1
* cell instance $5305 r0 *1 219.64,106.4
X$5305 7052 7448 112 113 7168 NOR2_X1
* cell instance $5306 r0 *1 220.21,106.4
X$5306 6005 6170 112 113 7276 NOR2_X1
* cell instance $5307 r0 *1 220.78,106.4
X$5307 5680 113 6852 112 BUF_X4
* cell instance $5309 r0 *1 222.3,106.4
X$5309 6453 5782 6721 113 7278 112 OAI21_X1
* cell instance $5311 r0 *1 223.44,106.4
X$5311 6328 7316 7170 7095 7048 113 112 7314 OAI221_X1
* cell instance $5313 m0 *1 224.77,106.4
X$5313 6717 7095 7170 6949 113 112 7074 AND4_X1
* cell instance $5316 m0 *1 227.43,106.4
X$5316 5677 6053 112 113 7053 NOR2_X2
* cell instance $5320 r0 *1 226.29,106.4
X$5320 112 5869 5771 7053 5427 5564 5870 7281 113 OAI222_X2
* cell instance $5322 r0 *1 229.14,106.4
X$5322 7435 6577 6560 112 7171 113 AOI21_X1
* cell instance $5323 m0 *1 229.71,106.4
X$5323 5783 6291 7070 7048 7068 113 112 7172 OAI221_X1
* cell instance $5326 r0 *1 229.9,106.4
X$5326 7171 7172 113 112 7304 AND2_X1
* cell instance $5327 r0 *1 230.66,106.4
X$5327 7298 6293 112 113 7070 NOR2_X1
* cell instance $5329 m0 *1 231.23,106.4
X$5329 6750 5878 6003 112 113 7068 MUX2_X1
* cell instance $5332 r0 *1 231.8,106.4
X$5332 5771 6175 6750 112 113 7283 MUX2_X1
* cell instance $5334 m0 *1 232.94,106.4
X$5334 7056 7286 6835 113 6842 112 NOR3_X2
* cell instance $5335 m0 *1 234.46,106.4
X$5335 112 16846 6845 7064 6437 113 DFF_X1
* cell instance $5336 m0 *1 237.69,106.4
X$5336 7287 112 113 5062 BUF_X1
* cell instance $5339 r0 *1 233.13,106.4
X$5339 5771 7298 6429 113 7284 112 OAI21_X1
* cell instance $5340 r0 *1 233.89,106.4
X$5340 6028 7284 6956 112 7173 113 AOI21_X1
* cell instance $5346 r0 *1 236.36,106.4
X$5346 112 17062 7174 7063 6437 113 DFF_X1
* cell instance $5349 m0 *1 101.84,165.2
X$5349 10120 112 113 12321 INV_X1
* cell instance $5350 m0 *1 100.89,165.2
X$5350 12321 112 113 11520 CLKBUF_X3
* cell instance $5353 m0 *1 108.49,165.2
X$5353 12479 12433 9701 112 113 12478 NOR3_X1
* cell instance $5354 m0 *1 109.25,165.2
X$5354 12564 12432 10240 112 113 12479 NOR3_X1
* cell instance $5355 m0 *1 110.01,165.2
X$5355 9966 11851 12565 112 12564 113 AOI21_X1
* cell instance $5356 m0 *1 110.77,165.2
X$5356 11713 12323 112 113 12565 NAND2_X1
* cell instance $5358 r0 *1 100.89,165.2
X$5358 10928 12558 12557 112 113 12695 OR3_X1
* cell instance $5360 r0 *1 102.03,165.2
X$5360 12402 12603 12695 113 12696 112 OAI21_X1
* cell instance $5364 r0 *1 106.4,165.2
X$5364 10821 12562 10956 12827 112 113 12420 AOI22_X1
* cell instance $5365 r0 *1 107.35,165.2
X$5365 11753 112 113 10305 CLKBUF_X3
* cell instance $5369 r0 *1 110.77,165.2
X$5369 12323 10696 12481 112 113 12425 MUX2_X1
* cell instance $5370 m0 *1 111.91,165.2
X$5370 10127 12438 12325 10074 12428 12418 112 113 OAI221_X2
* cell instance $5373 m0 *1 114.76,165.2
X$5373 10072 12326 113 112 12428 AND2_X1
* cell instance $5376 m0 *1 116.47,165.2
X$5376 12328 12329 112 113 11271 NAND2_X1
* cell instance $5377 m0 *1 117.04,165.2
X$5377 12005 9962 112 113 12329 NAND2_X1
* cell instance $5378 m0 *1 117.61,165.2
X$5378 12482 9876 112 113 12328 NAND2_X1
* cell instance $5380 m0 *1 118.94,165.2
X$5380 12703 12568 10243 10474 12331 12433 113 112 AOI221_X2
* cell instance $5383 r0 *1 112.48,165.2
X$5383 10776 9733 11266 112 113 12481 MUX2_X1
* cell instance $5384 r0 *1 113.81,165.2
X$5384 11713 10817 112 113 12605 NOR2_X1
* cell instance $5385 r0 *1 114.38,165.2
X$5385 12605 12160 12606 10472 10814 113 112 12326 OAI221_X1
* cell instance $5387 r0 *1 117.04,165.2
X$5387 11748 10340 9942 10342 12483 12432 113 112 AOI221_X2
* cell instance $5388 r0 *1 119.13,165.2
X$5388 10476 10441 112 113 10947 NOR2_X2
* cell instance $5390 r0 *1 120.46,165.2
X$5390 9969 12607 10662 112 12484 113 AOI21_X1
* cell instance $5391 r0 *1 121.22,165.2
X$5391 10439 12484 12606 12608 10445 113 112 11548 OAI221_X1
* cell instance $5392 m0 *1 121.6,165.2
X$5392 10702 9967 12448 112 12332 113 AOI21_X1
* cell instance $5394 m0 *1 122.36,165.2
X$5394 12485 12013 11267 112 12276 113 AOI21_X1
* cell instance $5395 m0 *1 123.12,165.2
X$5395 10440 11590 112 113 12571 NAND2_X1
* cell instance $5396 m0 *1 123.69,165.2
X$5396 12571 12013 9964 10198 12290 12200 113 112 AOI221_X2
* cell instance $5397 m0 *1 125.78,165.2
X$5397 11752 10240 12440 112 12438 113 AOI21_X1
* cell instance $5398 m0 *1 126.54,165.2
X$5398 10444 12572 9934 112 12486 113 AOI21_X1
* cell instance $5400 m0 *1 127.49,165.2
X$5400 11110 12486 10956 113 12570 112 OAI21_X1
* cell instance $5401 m0 *1 128.25,165.2
X$5401 12487 10814 12206 112 12440 113 AOI21_X1
* cell instance $5406 r0 *1 123.31,165.2
X$5406 9876 9942 112 113 10956 NOR2_X2
* cell instance $5411 r0 *1 124.45,165.2
X$5411 11001 10340 112 113 12485 NOR2_X1
* cell instance $5414 r0 *1 125.59,165.2
X$5414 10696 9982 112 113 11899 NAND2_X2
* cell instance $5417 r0 *1 128.25,165.2
X$5417 12570 12714 11748 10213 112 113 12293 AOI22_X2
* cell instance $5420 r0 *1 130.34,165.2
X$5420 9964 10213 112 113 12569 NAND2_X1
* cell instance $5421 r0 *1 130.91,165.2
X$5421 10349 12050 112 113 10216 NAND2_X2
* cell instance $5423 m0 *1 130.91,165.2
X$5423 12482 10439 112 113 11755 NOR2_X1
* cell instance $5425 r0 *1 131.86,165.2
X$5425 112 12207 10198 12569 12716 113 AOI21_X4
* cell instance $5426 m0 *1 132.81,165.2
X$5426 9982 10829 11000 113 112 12448 OAI21_X2
* cell instance $5428 m0 *1 134.14,165.2
X$5428 11266 10829 11000 113 112 10781 OAI21_X4
* cell instance $5429 m0 *1 136.61,165.2
X$5429 112 11266 11000 10829 10444 113 NOR3_X4
* cell instance $5431 m0 *1 140.03,165.2
X$5431 112 10441 113 12210 BUF_X8
* cell instance $5432 m0 *1 142.5,165.2
X$5432 12567 113 12053 112 BUF_X4
* cell instance $5437 r0 *1 134.52,165.2
X$5437 11001 113 10476 112 BUF_X4
* cell instance $5438 r0 *1 135.85,165.2
X$5438 12609 112 113 10304 INV_X4
* cell instance $5439 r0 *1 136.8,165.2
X$5439 11590 10473 10701 12448 113 112 10962 OAI22_X1
* cell instance $5440 r0 *1 137.75,165.2
X$5440 10662 11555 16665 113 112 12609 HA_X1
* cell instance $5441 r0 *1 139.65,165.2
X$5441 12762 10662 12567 113 112 12717 HA_X1
* cell instance $5442 r0 *1 141.55,165.2
X$5442 112 12210 113 12053 BUF_X8
* cell instance $5443 r0 *1 144.02,165.2
X$5443 12717 113 10472 112 BUF_X4
* cell instance $5446 r0 *1 147.25,165.2
X$5446 112 13044 11904 17258 10423 113 DFF_X2
* cell instance $5447 r0 *1 150.86,165.2
X$5447 12625 12551 12488 112 113 12611 OR3_X1
* cell instance $5448 r0 *1 151.81,165.2
X$5448 12551 12488 12718 113 12719 112 OAI21_X1
* cell instance $5449 r0 *1 152.57,165.2
X$5449 11008 11914 112 113 12718 NOR2_X1
* cell instance $5450 r0 *1 153.14,165.2
X$5450 11277 12563 12719 113 112 12489 AND3_X1
* cell instance $5451 m0 *1 153.52,165.2
X$5451 12056 12333 12566 113 12490 112 OAI21_X1
* cell instance $5455 r0 *1 154.09,165.2
X$5455 12489 12490 11125 113 12614 112 OAI21_X1
* cell instance $5457 r0 *1 155.23,165.2
X$5457 12720 12616 11125 11007 112 113 11863 NAND4_X1
* cell instance $5459 m0 *1 156.18,165.2
X$5459 11007 12443 11908 112 12566 113 AOI21_X1
* cell instance $5460 m0 *1 157.7,165.2
X$5460 11860 12492 12547 112 12445 113 AOI21_X1
* cell instance $5464 r0 *1 156.56,165.2
X$5464 12491 12561 12447 112 113 12615 NOR3_X1
* cell instance $5465 r0 *1 157.32,165.2
X$5465 12491 112 113 12835 BUF_X1
* cell instance $5467 r0 *1 158.08,165.2
X$5467 12726 11234 11072 112 113 12563 NAND3_X1
* cell instance $5469 m0 *1 160.55,165.2
X$5469 11208 12492 12493 113 12441 112 OAI21_X1
* cell instance $5470 m0 *1 159.6,165.2
X$5470 11914 12491 11437 11522 113 112 12443 OAI22_X1
* cell instance $5472 m0 *1 161.5,165.2
X$5472 12559 12056 11007 112 113 12729 NOR3_X1
* cell instance $5473 m0 *1 162.26,165.2
X$5473 12335 12494 11549 11601 112 113 12559 AOI22_X1
* cell instance $5474 m0 *1 163.21,165.2
X$5474 11972 12493 11921 112 113 12336 NAND3_X1
* cell instance $5478 r0 *1 161.5,165.2
X$5478 11125 12729 12560 112 113 12728 OR3_X1
* cell instance $5479 r0 *1 162.45,165.2
X$5479 12618 12431 11007 11768 112 113 12560 NOR4_X1
* cell instance $5482 m0 *1 164.92,165.2
X$5482 11431 113 11778 112 BUF_X4
* cell instance $5483 m0 *1 164.35,165.2
X$5483 12336 11072 112 113 12495 NAND2_X1
* cell instance $5484 m0 *1 166.25,165.2
X$5484 12063 11921 12338 112 113 12494 MUX2_X1
* cell instance $5485 m0 *1 167.58,165.2
X$5485 12339 112 113 12338 BUF_X1
* cell instance $5487 r0 *1 164.35,165.2
X$5487 11913 11433 12492 113 12620 112 OAI21_X1
* cell instance $5488 r0 *1 165.11,165.2
X$5488 12620 12496 11277 12619 12723 113 112 12292 OAI221_X1
* cell instance $5489 r0 *1 166.25,165.2
X$5489 12338 11281 12503 113 12723 112 OAI21_X1
* cell instance $5490 r0 *1 167.01,165.2
X$5490 12496 11602 12499 112 113 11230 MUX2_X1
* cell instance $5491 r0 *1 168.34,165.2
X$5491 12497 12066 11138 112 113 12622 NOR3_X1
* cell instance $5492 m0 *1 168.72,165.2
X$5492 12067 11777 12337 12335 12417 113 112 12554 OAI221_X1
* cell instance $5494 m0 *1 169.86,165.2
X$5494 12220 12553 12554 112 12552 113 AOI21_X1
* cell instance $5496 m0 *1 170.81,165.2
X$5496 10951 11007 112 113 12427 NAND2_X2
* cell instance $5498 m0 *1 171.95,165.2
X$5498 12339 11531 11447 113 112 12340 OAI21_X2
* cell instance $5499 m0 *1 173.28,165.2
X$5499 12341 113 12334 112 BUF_X4
* cell instance $5500 m0 *1 174.61,165.2
X$5500 12415 12340 12349 112 113 11218 NAND3_X1
* cell instance $5501 m0 *1 175.37,165.2
X$5501 112 12341 11431 11780 11784 113 AOI21_X4
* cell instance $5502 m0 *1 177.84,165.2
X$5502 12218 112 113 12422 BUF_X2
* cell instance $5503 m0 *1 178.6,165.2
X$5503 12347 12547 11126 11289 12343 113 112 12221 OAI221_X1
* cell instance $5504 m0 *1 179.74,165.2
X$5504 12349 12346 112 113 12417 NAND2_X1
* cell instance $5505 m0 *1 180.31,165.2
X$5505 112 12224 113 8268 BUF_X8
* cell instance $5506 m0 *1 182.78,165.2
X$5506 11130 11610 12346 112 113 12415 NAND3_X1
* cell instance $5507 m0 *1 183.54,165.2
X$5507 12219 12502 112 113 12347 OR2_X1
* cell instance $5508 m0 *1 184.3,165.2
X$5508 11765 12349 10949 112 113 12410 NAND3_X1
* cell instance $5509 m0 *1 185.06,165.2
X$5509 12410 11777 11437 112 113 12540 NAND3_X1
* cell instance $5510 m0 *1 185.82,165.2
X$5510 12079 12408 12417 113 12504 112 OAI21_X1
* cell instance $5511 m0 *1 186.58,165.2
X$5511 12345 113 12346 112 BUF_X4
* cell instance $5512 m0 *1 187.91,165.2
X$5512 12345 11449 11610 112 12348 113 AOI21_X1
* cell instance $5513 m0 *1 188.67,165.2
X$5513 11456 112 113 12505 BUF_X1
* cell instance $5514 m0 *1 189.24,165.2
X$5514 12403 112 113 11670 BUF_X2
* cell instance $5515 m0 *1 190,165.2
X$5515 12225 112 113 12539 BUF_X1
* cell instance $5520 r0 *1 169.48,165.2
X$5520 11367 12224 11915 112 113 12488 NOR3_X1
* cell instance $5521 r0 *1 170.24,165.2
X$5521 12342 12551 12341 113 112 12285 OAI21_X4
* cell instance $5522 r0 *1 172.71,165.2
X$5522 12073 12500 12821 11277 11003 12767 112 113 OAI221_X2
* cell instance $5523 r0 *1 174.8,165.2
X$5523 12349 12498 12341 112 12283 113 AOI21_X2
* cell instance $5524 r0 *1 176.13,165.2
X$5524 12414 11531 11447 113 112 11603 OAI21_X2
* cell instance $5525 r0 *1 177.46,165.2
X$5525 11610 12342 112 113 11445 NOR2_X2
* cell instance $5527 r0 *1 178.6,165.2
X$5527 12624 12501 11855 112 113 12706 NAND3_X2
* cell instance $5528 r0 *1 179.93,165.2
X$5528 12414 112 113 12712 BUF_X1
* cell instance $5532 r0 *1 180.5,165.2
X$5532 112 11210 12704 12068 12499 113 AOI21_X4
* cell instance $5533 r0 *1 182.97,165.2
X$5533 12708 12219 12503 112 113 12704 AND3_X4
* cell instance $5534 r0 *1 185.06,165.2
X$5534 12502 12339 12344 112 12499 113 AOI21_X1
* cell instance $5535 r0 *1 185.82,165.2
X$5535 11437 12504 12540 113 12700 112 OAI21_X1
* cell instance $5536 r0 *1 186.58,165.2
X$5536 12505 112 113 12500 BUF_X1
* cell instance $5537 r0 *1 187.15,165.2
X$5537 11670 113 12349 112 BUF_X4
* cell instance $5538 r0 *1 188.48,165.2
X$5538 12627 12215 112 113 12404 NAND2_X1
* cell instance $5539 r0 *1 189.05,165.2
X$5539 11670 12345 112 113 12628 NOR2_X1
* cell instance $5541 r0 *1 190,165.2
X$5541 112 16966 12506 12691 10847 113 DFF_X1
* cell instance $5542 r0 *1 193.23,165.2
X$5542 12506 4939 12642 112 113 12691 MUX2_X1
* cell instance $5544 m0 *1 193.23,165.2
X$5544 12506 10289 10075 113 112 12507 MUX2_X2
* cell instance $5545 m0 *1 195.13,165.2
X$5545 112 6939 113 12921 BUF_X8
* cell instance $5547 m0 *1 197.79,165.2
X$5547 12227 113 11302 112 BUF_X4
* cell instance $5550 r0 *1 196.08,165.2
X$5550 13101 112 113 5648 CLKBUF_X3
* cell instance $5551 r0 *1 197.03,165.2
X$5551 11785 11786 112 12227 113 NAND2_X4
* cell instance $5553 r0 *1 198.93,165.2
X$5553 112 11347 10756 11016 12508 113 NOR3_X4
* cell instance $5554 m0 *1 199.69,165.2
X$5554 112 11620 10853 12228 12227 113 AOI21_X4
* cell instance $5558 r0 *1 201.59,165.2
X$5558 112 12533 113 11016 BUF_X8
* cell instance $5559 m0 *1 204.63,165.2
X$5559 11017 12239 12532 11353 12679 12684 113 112 AOI221_X2
* cell instance $5560 m0 *1 203.3,165.2
X$5560 12531 11460 12350 112 113 12351 MUX2_X1
* cell instance $5561 m0 *1 206.72,165.2
X$5561 11302 12239 112 113 11158 NOR2_X2
* cell instance $5562 m0 *1 207.67,165.2
X$5562 11927 112 113 11314 CLKBUF_X3
* cell instance $5563 m0 *1 208.62,165.2
X$5563 12245 112 113 12531 BUF_X1
* cell instance $5564 m0 *1 209.19,165.2
X$5564 11785 113 11929 112 BUF_X4
* cell instance $5565 m0 *1 210.52,165.2
X$5565 10592 113 12237 112 BUF_X4
* cell instance $5568 r0 *1 204.25,165.2
X$5568 12687 12533 12773 113 112 11026 OAI21_X4
* cell instance $5569 r0 *1 206.72,165.2
X$5569 11927 11346 112 113 12532 NOR2_X1
* cell instance $5570 r0 *1 207.29,165.2
X$5570 12530 11302 10592 12683 11017 112 113 12529 AOI221_X1
* cell instance $5571 r0 *1 208.43,165.2
X$5571 112 12244 11347 11785 11786 113 AOI21_X4
* cell instance $5572 r0 *1 210.9,165.2
X$5572 12239 11302 11649 113 12679 112 OAI21_X1
* cell instance $5574 r0 *1 212.04,165.2
X$5574 12630 11144 11172 12510 112 113 12670 AOI22_X2
* cell instance $5575 m0 *1 212.99,165.2
X$5575 10606 12529 112 113 12265 OR2_X1
* cell instance $5576 m0 *1 212.23,165.2
X$5576 11022 11308 10722 113 12352 112 OAI21_X1
* cell instance $5577 m0 *1 213.75,165.2
X$5577 12356 10488 11335 112 12392 113 AOI21_X2
* cell instance $5578 m0 *1 215.08,165.2
X$5578 11926 11787 12509 10372 12391 12354 112 113 OAI221_X2
* cell instance $5579 m0 *1 217.17,165.2
X$5579 12244 11346 11305 112 12509 113 AOI21_X1
* cell instance $5581 m0 *1 218.12,165.2
X$5581 10488 12103 12226 112 12391 113 AOI21_X1
* cell instance $5583 r0 *1 213.75,165.2
X$5583 11350 12671 12392 10860 12670 12666 112 113 OAI221_X2
* cell instance $5584 r0 *1 215.84,165.2
X$5584 12668 12354 10610 12666 112 113 10751 AOI22_X2
* cell instance $5587 r0 *1 218.12,165.2
X$5587 11929 11930 12229 112 113 11625 NAND3_X2
* cell instance $5588 m0 *1 220.4,165.2
X$5588 12356 12508 112 113 12385 NOR2_X1
* cell instance $5589 m0 *1 219.26,165.2
X$5589 11151 11628 11158 11030 12385 112 113 12355 AOI221_X1
* cell instance $5590 m0 *1 220.97,165.2
X$5590 11038 11477 10856 11643 113 112 12657 OAI22_X1
* cell instance $5591 m0 *1 221.92,165.2
X$5591 11478 11338 12357 112 12526 113 AOI21_X1
* cell instance $5593 m0 *1 222.87,165.2
X$5593 10727 12511 11059 112 12517 113 AOI21_X1
* cell instance $5595 m0 *1 223.82,165.2
X$5595 12522 12358 11059 12244 12521 12376 112 113 OAI221_X2
* cell instance $5597 r0 *1 219.45,165.2
X$5597 11625 12266 112 113 12633 NAND2_X1
* cell instance $5598 r0 *1 220.02,165.2
X$5598 11930 11929 10626 10885 11157 12511 113 112 AOI221_X2
* cell instance $5600 r0 *1 222.3,165.2
X$5600 11147 11305 10910 113 12634 112 OAI21_X1
* cell instance $5601 r0 *1 223.06,165.2
X$5601 10594 10737 112 113 12635 NOR2_X1
* cell instance $5603 r0 *1 224.39,165.2
X$5603 12650 12635 9768 12088 12376 12515 113 112 AOI221_X2
* cell instance $5604 m0 *1 226.86,165.2
X$5604 11026 11937 113 112 12519 AND2_X1
* cell instance $5605 m0 *1 226.29,165.2
X$5605 11960 12092 112 113 11477 NAND2_X1
* cell instance $5606 m0 *1 227.62,165.2
X$5606 12356 11172 11030 113 11636 112 NOR3_X2
* cell instance $5608 r0 *1 226.48,165.2
X$5608 11043 11032 10885 112 113 12521 NAND3_X1
* cell instance $5609 r0 *1 227.24,165.2
X$5609 11643 11161 12226 112 12518 113 AOI21_X1
* cell instance $5610 r0 *1 228,165.2
X$5610 11032 10593 112 113 11949 NAND2_X1
* cell instance $5611 r0 *1 228.57,165.2
X$5611 12637 10856 11310 112 113 12516 OR3_X1
* cell instance $5612 m0 *1 229.52,165.2
X$5612 12519 11638 12370 112 113 12514 MUX2_X1
* cell instance $5615 m0 *1 231.04,165.2
X$5615 12517 12516 10599 12514 12512 112 113 OAI211_X2
* cell instance $5623 r0 *1 231.61,165.2
X$5623 12512 12515 10373 12365 112 113 11635 AOI22_X1
* cell instance $5624 r0 *1 232.56,165.2
X$5624 12513 112 113 12642 BUF_X1
* cell instance $5628 r0 *1 235.79,165.2
X$5628 112 17151 9777 12641 12247 113 DFF_X1
* cell instance $5633 m0 *1 238.45,165.2
X$5633 12640 112 113 9784 BUF_X1
* cell instance $5634 m0 *1 239.21,165.2
X$5634 12361 112 113 12363 BUF_X1
* cell instance $5638 m0 *1 77.9,173.6
X$5638 11735 12133 11576 112 113 13292 MUX2_X1
* cell instance $5640 m0 *1 79.23,173.6
X$5640 11209 112 113 12860 BUF_X1
* cell instance $5642 m0 *1 79.99,173.6
X$5642 11359 12685 12669 113 13134 112 OAI21_X1
* cell instance $5643 m0 *1 80.75,173.6
X$5643 12273 12817 11839 12590 13009 113 112 13069 OAI221_X1
* cell instance $5644 m0 *1 81.89,173.6
X$5644 12311 11572 112 113 13070 XNOR2_X2
* cell instance $5645 m0 *1 83.79,173.6
X$5645 11581 13222 11744 13071 13134 113 112 13255 OAI221_X1
* cell instance $5648 m0 *1 76,173.6
X$5648 13216 11665 13130 112 113 13290 MUX2_X1
* cell instance $5651 r0 *1 75.81,173.6
X$5651 13385 13215 12469 11665 13291 13217 113 112 AOI221_X2
* cell instance $5652 r0 *1 77.9,173.6
X$5652 11583 13218 13254 113 13291 112 OAI21_X1
* cell instance $5656 r0 *1 79.99,173.6
X$5656 13069 11743 13290 113 112 13297 OAI21_X2
* cell instance $5659 r0 *1 81.89,173.6
X$5659 13133 13158 12263 13296 13132 113 112 AOI211_X2
* cell instance $5660 r0 *1 83.6,173.6
X$5660 11263 13297 13255 113 13299 112 OAI21_X1
* cell instance $5662 r0 *1 85.88,173.6
X$5662 12034 11408 11261 112 13298 113 AOI21_X2
* cell instance $5664 m0 *1 86.07,173.6
X$5664 13072 12865 13070 112 13222 113 AOI21_X1
* cell instance $5666 m0 *1 87.4,173.6
X$5666 13161 11669 113 112 12751 XNOR2_X1
* cell instance $5668 m0 *1 88.54,173.6
X$5668 11577 12473 12663 12313 112 113 13076 AOI22_X1
* cell instance $5669 m0 *1 89.49,173.6
X$5669 13256 112 113 12747 INV_X2
* cell instance $5670 m0 *1 90.06,173.6
X$5670 12195 11408 11261 112 12692 113 AOI21_X2
* cell instance $5671 m0 *1 91.39,173.6
X$5671 11410 11578 12747 113 13162 112 OAI21_X1
* cell instance $5673 m0 *1 92.34,173.6
X$5673 12967 12591 13163 113 13074 112 OAI21_X1
* cell instance $5674 m0 *1 93.1,173.6
X$5674 11410 11578 12967 113 13164 112 NOR3_X2
* cell instance $5675 m0 *1 94.43,173.6
X$5675 12311 11669 13257 113 13075 112 OAI21_X1
* cell instance $5676 m0 *1 95.19,173.6
X$5676 13026 12270 13075 112 13230 113 AOI21_X1
* cell instance $5677 m0 *1 95.95,173.6
X$5677 13228 12270 13070 112 13229 113 AOI21_X1
* cell instance $5678 m0 *1 96.71,173.6
X$5678 12133 12472 13257 112 13228 113 AOI21_X2
* cell instance $5680 m0 *1 98.23,173.6
X$5680 13217 10928 13139 112 13142 113 AOI21_X1
* cell instance $5681 m0 *1 98.99,173.6
X$5681 13141 12135 12937 112 113 13231 MUX2_X1
* cell instance $5684 m0 *1 101.27,173.6
X$5684 13231 11520 13142 112 113 13233 MUX2_X1
* cell instance $5689 r0 *1 87.4,173.6
X$5689 12273 13163 11739 112 13160 113 AOI21_X1
* cell instance $5690 r0 *1 88.16,173.6
X$5690 11732 11665 13161 112 113 13392 NAND3_X1
* cell instance $5692 r0 *1 89.68,173.6
X$5692 13256 112 113 13073 BUF_X2
* cell instance $5693 r0 *1 90.44,173.6
X$5693 13256 113 13227 112 BUF_X4
* cell instance $5694 r0 *1 91.77,173.6
X$5694 11661 12817 13162 112 13224 113 AOI21_X1
* cell instance $5695 r0 *1 92.53,173.6
X$5695 13071 13224 112 113 13225 OR2_X1
* cell instance $5698 r0 *1 93.86,173.6
X$5698 11574 11408 11261 112 13226 113 AOI21_X1
* cell instance $5701 r0 *1 95.19,173.6
X$5701 11261 13227 11408 112 13257 113 NAND3_X4
* cell instance $5704 r0 *1 98.61,173.6
X$5704 13230 12263 13076 112 113 13305 MUX2_X1
* cell instance $5705 r0 *1 99.94,173.6
X$5705 13304 12135 13305 112 113 13308 MUX2_X1
* cell instance $5709 r0 *1 109.63,173.6
X$5709 10068 12572 16681 113 112 12323 HA_X1
* cell instance $5710 m0 *1 112.29,173.6
X$5710 13078 112 113 10817 CLKBUF_X3
* cell instance $5711 m0 *1 111.34,173.6
X$5711 10474 112 113 9966 CLKBUF_X3
* cell instance $5712 m0 *1 113.24,173.6
X$5712 10817 10696 10470 112 113 12870 MUX2_X1
* cell instance $5714 m0 *1 116.09,173.6
X$5714 13234 10702 13166 10947 10474 13080 113 112 AOI221_X2
* cell instance $5716 m0 *1 118.37,173.6
X$5716 11266 9942 12607 112 113 13234 MUX2_X1
* cell instance $5721 r0 *1 112.86,173.6
X$5721 10439 13165 13309 112 113 13079 NOR3_X1
* cell instance $5722 r0 *1 113.62,173.6
X$5722 10068 12762 12757 113 112 13309 HA_X1
* cell instance $5723 r0 *1 115.52,173.6
X$5723 13258 9934 112 113 13166 NAND2_X1
* cell instance $5724 r0 *1 116.09,173.6
X$5724 9942 10084 10470 112 113 13258 NAND3_X1
* cell instance $5725 r0 *1 116.85,173.6
X$5725 13406 11702 9966 112 13081 113 AOI21_X1
* cell instance $5726 r0 *1 117.61,173.6
X$5726 10250 13259 10696 112 12568 113 AOI21_X1
* cell instance $5727 r0 *1 118.37,173.6
X$5727 9826 112 113 10470 CLKBUF_X3
* cell instance $5730 r0 *1 119.89,173.6
X$5730 11753 9942 10470 112 113 13167 NAND3_X1
* cell instance $5731 m0 *1 120.27,173.6
X$5731 11110 13167 13235 112 13144 113 AOI21_X1
* cell instance $5733 m0 *1 121.03,173.6
X$5733 9934 9942 10065 112 113 13145 NAND3_X1
* cell instance $5734 m0 *1 121.79,173.6
X$5734 112 10701 12572 113 BUF_X16
* cell instance $5735 m0 *1 126.54,173.6
X$5735 13147 10696 13082 112 113 12430 MUX2_X1
* cell instance $5736 m0 *1 127.87,173.6
X$5736 10065 113 10814 112 BUF_X4
* cell instance $5739 m0 *1 130.15,173.6
X$5739 112 10701 11555 113 BUF_X32
* cell instance $5741 r0 *1 120.65,173.6
X$5741 112 12760 113 9826 BUF_X8
* cell instance $5742 r0 *1 123.12,173.6
X$5742 11753 10250 10702 112 113 13310 NAND3_X1
* cell instance $5743 r0 *1 123.88,173.6
X$5743 10439 10817 112 113 13235 NAND2_X1
* cell instance $5747 r0 *1 124.45,173.6
X$5747 10814 11555 16651 113 112 13147 HA_X1
* cell instance $5749 r0 *1 126.54,173.6
X$5749 9979 112 113 9934 CLKBUF_X3
* cell instance $5757 r0 *1 132.62,173.6
X$5757 13168 7246 112 113 13412 NOR2_X1
* cell instance $5760 r0 *1 134.9,173.6
X$5760 13149 5120 112 113 13312 NOR2_X1
* cell instance $5761 r0 *1 135.47,173.6
X$5761 13149 6616 112 113 13313 NAND2_X1
* cell instance $5762 r0 *1 136.04,173.6
X$5762 13168 6616 112 113 13262 NAND2_X1
* cell instance $5763 r0 *1 136.61,173.6
X$5763 13315 13149 113 112 13413 XNOR2_X1
* cell instance $5764 r0 *1 137.75,173.6
X$5764 6498 13084 112 113 13264 XOR2_X1
* cell instance $5766 r0 *1 139.08,173.6
X$5766 13316 8295 13264 112 113 13317 MUX2_X1
* cell instance $5767 m0 *1 140.03,173.6
X$5767 10844 10709 113 13168 112 XOR2_X2
* cell instance $5771 r0 *1 140.41,173.6
X$5771 112 17006 13320 13317 13083 113 DFF_X1
* cell instance $5772 r0 *1 143.64,173.6
X$5772 13320 113 6498 112 BUF_X4
* cell instance $5773 r0 *1 144.97,173.6
X$5773 13323 6211 13170 112 113 13324 MUX2_X1
* cell instance $5775 m0 *1 145.16,173.6
X$5775 10367 13413 113 112 13170 XNOR2_X1
* cell instance $5778 m0 *1 154.09,173.6
X$5778 12771 12831 12447 112 113 13242 NAND3_X1
* cell instance $5779 m0 *1 154.85,173.6
X$5779 13241 13085 13242 113 112 13086 AND3_X1
* cell instance $5781 r0 *1 146.3,173.6
X$5781 112 17087 13326 13324 11904 113 DFF_X1
* cell instance $5783 r0 *1 149.72,173.6
X$5783 13326 113 10367 112 BUF_X4
* cell instance $5786 r0 *1 152.76,173.6
X$5786 11008 13422 112 113 12055 NOR2_X2
* cell instance $5788 r0 *1 153.9,173.6
X$5788 11008 12222 112 113 13241 NOR2_X1
* cell instance $5789 r0 *1 154.47,173.6
X$5789 12715 12831 12447 112 113 13328 NAND3_X1
* cell instance $5790 r0 *1 155.23,173.6
X$5790 13328 13330 13171 112 113 13148 NAND3_X1
* cell instance $5792 m0 *1 156.37,173.6
X$5792 13172 12619 112 113 13146 NOR2_X1
* cell instance $5795 m0 *1 157.13,173.6
X$5795 11549 11281 13173 113 13172 112 OAI21_X1
* cell instance $5796 m0 *1 157.89,173.6
X$5796 12447 13172 13087 113 12444 112 OAI21_X1
* cell instance $5797 m0 *1 158.65,173.6
X$5797 13090 11527 12447 112 113 13087 NAND3_X1
* cell instance $5799 m0 *1 160.17,173.6
X$5799 12450 11602 12624 112 113 13143 NAND3_X2
* cell instance $5800 m0 *1 161.5,173.6
X$5800 13239 13171 12974 112 13089 113 AOI21_X1
* cell instance $5802 m0 *1 162.45,173.6
X$5802 13143 13091 12222 112 113 13136 AND3_X4
* cell instance $5803 m0 *1 164.54,173.6
X$5803 13174 13238 11768 112 113 13239 NOR3_X1
* cell instance $5804 m0 *1 165.3,173.6
X$5804 13090 11527 112 113 12976 NAND2_X1
* cell instance $5806 m0 *1 166.63,173.6
X$5806 12492 12503 11527 112 13238 113 AOI21_X1
* cell instance $5808 r0 *1 157.51,173.6
X$5808 13173 12838 12619 112 113 13330 NAND3_X1
* cell instance $5809 r0 *1 158.27,173.6
X$5809 11283 12222 112 113 13171 NOR2_X2
* cell instance $5811 r0 *1 159.6,173.6
X$5811 13088 13265 112 113 13421 OR2_X2
* cell instance $5814 r0 *1 161.5,173.6
X$5814 12215 113 11008 112 BUF_X4
* cell instance $5816 r0 *1 163.59,173.6
X$5816 13240 11284 11914 112 113 13174 NOR3_X1
* cell instance $5817 r0 *1 164.35,173.6
X$5817 12150 13183 13099 112 13240 113 AOI21_X1
* cell instance $5820 r0 *1 167.39,173.6
X$5820 12492 13236 12286 12771 11008 13322 112 113 OAI221_X2
* cell instance $5821 m0 *1 168.53,173.6
X$5821 12816 11446 12286 112 113 13236 MUX2_X1
* cell instance $5822 m0 *1 167.77,173.6
X$5822 11433 12070 13182 113 13237 112 OAI21_X1
* cell instance $5823 m0 *1 169.86,173.6
X$5823 12972 11921 112 113 13175 NOR2_X1
* cell instance $5824 m0 *1 170.43,173.6
X$5824 11991 11453 11294 113 112 12838 OAI21_X2
* cell instance $5825 m0 *1 171.76,173.6
X$5825 13266 13136 11072 112 113 13177 NOR3_X1
* cell instance $5826 m0 *1 172.52,173.6
X$5826 11842 12346 112 113 12878 NAND2_X1
* cell instance $5827 m0 *1 173.09,173.6
X$5827 13177 11124 13178 12427 13180 13181 112 113 13055 OAI33_X1
* cell instance $5828 m0 *1 174.42,173.6
X$5828 12977 13400 11124 13094 112 113 12424 NOR4_X1
* cell instance $5829 m0 *1 175.37,173.6
X$5829 11536 11448 112 113 13095 NOR2_X1
* cell instance $5830 m0 *1 175.94,173.6
X$5830 12224 12345 112 113 13092 NAND2_X1
* cell instance $5831 m0 *1 176.51,173.6
X$5831 13232 11367 13090 113 12881 112 OAI21_X1
* cell instance $5833 m0 *1 177.46,173.6
X$5833 12137 11283 13098 113 13182 112 NOR3_X2
* cell instance $5834 m0 *1 178.79,173.6
X$5834 11450 13183 13099 112 12547 113 AOI21_X2
* cell instance $5835 m0 *1 180.12,173.6
X$5835 13099 11431 13183 112 12501 113 NAND3_X4
* cell instance $5836 m0 *1 182.59,173.6
X$5836 11765 12711 11012 112 12496 113 AOI21_X2
* cell instance $5837 m0 *1 183.92,173.6
X$5837 11522 12933 112 113 13097 NOR2_X1
* cell instance $5838 m0 *1 184.49,173.6
X$5838 112 12342 113 11519 BUF_X8
* cell instance $5839 m0 *1 186.96,173.6
X$5839 12502 113 12922 112 BUF_X4
* cell instance $5840 m0 *1 188.29,173.6
X$5840 12502 112 113 12768 BUF_X1
* cell instance $5843 m0 *1 195.7,173.6
X$5843 112 6273 113 13223 BUF_X8
* cell instance $5846 r0 *1 169.48,173.6
X$5846 12295 112 113 13318 INV_X1
* cell instance $5849 r0 *1 170.81,173.6
X$5849 12878 13175 13321 11287 112 113 13179 AOI22_X1
* cell instance $5851 r0 *1 171.95,173.6
X$5851 10713 13318 11921 112 13176 113 AOI21_X1
* cell instance $5853 r0 *1 172.9,173.6
X$5853 13176 13093 11283 11138 13179 112 113 13178 AOI221_X1
* cell instance $5854 r0 *1 174.04,173.6
X$5854 13311 112 113 13314 BUF_X1
* cell instance $5856 r0 *1 175.37,173.6
X$5856 11525 13232 112 113 12137 NOR2_X1
* cell instance $5857 r0 *1 175.94,173.6
X$5857 11855 13267 11527 112 13096 113 AOI21_X1
* cell instance $5858 r0 *1 176.7,173.6
X$5858 11431 112 113 13042 BUF_X1
* cell instance $5859 r0 *1 177.27,173.6
X$5859 13183 13099 13232 112 113 12450 NAND3_X2
* cell instance $5860 r0 *1 178.6,173.6
X$5860 11283 13268 12222 12978 13306 13181 113 112 AOI221_X2
* cell instance $5864 r0 *1 180.69,173.6
X$5864 12450 12838 12625 112 113 13306 NAND3_X1
* cell instance $5865 r0 *1 181.45,173.6
X$5865 12707 13307 12496 13301 113 112 13268 OAI22_X1
* cell instance $5866 r0 *1 182.4,173.6
X$5866 12879 11912 11600 112 113 12979 NOR3_X1
* cell instance $5867 r0 *1 183.16,173.6
X$5867 13269 12980 11138 112 113 12812 NOR3_X1
* cell instance $5868 r0 *1 183.92,173.6
X$5868 11919 11367 12342 113 13301 112 OAI21_X1
* cell instance $5870 r0 *1 185.06,173.6
X$5870 11784 11977 11780 112 12503 113 NAND3_X4
* cell instance $5873 r0 *1 194.37,173.6
X$5873 10299 112 113 13184 CLKBUF_X3
* cell instance $5874 r0 *1 195.32,173.6
X$5874 112 17116 13223 13221 13184 113 DFF_X1
* cell instance $5875 r0 *1 198.55,173.6
X$5875 13447 113 5762 112 BUF_X4
* cell instance $5876 r0 *1 199.88,173.6
X$5876 13271 112 113 6422 CLKBUF_X3
* cell instance $5877 m0 *1 201.4,173.6
X$5877 11511 12533 12773 113 112 10883 OAI21_X4
* cell instance $5878 m0 *1 200.07,173.6
X$5878 11656 113 12266 112 BUF_X4
* cell instance $5883 r0 *1 202.73,173.6
X$5883 11302 113 11145 112 BUF_X4
* cell instance $5885 r0 *1 204.25,173.6
X$5885 13125 12533 12773 113 112 11799 OAI21_X4
* cell instance $5887 m0 *1 205.01,173.6
X$5887 11353 12533 12773 113 112 11631 OAI21_X4
* cell instance $5888 m0 *1 207.67,173.6
X$5888 10593 12915 12981 112 12918 113 AOI21_X2
* cell instance $5889 m0 *1 209,173.6
X$5889 13103 113 12772 112 BUF_X4
* cell instance $5891 m0 *1 210.52,173.6
X$5891 13219 112 113 11511 INV_X4
* cell instance $5892 m0 *1 211.47,173.6
X$5892 11353 11656 112 113 11646 XNOR2_X2
* cell instance $5893 m0 *1 213.37,173.6
X$5893 13123 11960 10006 113 12260 112 OAI21_X1
* cell instance $5894 m0 *1 214.13,173.6
X$5894 10853 11624 11460 112 13126 113 AOI21_X1
* cell instance $5895 m0 *1 214.89,173.6
X$5895 13105 12366 12882 112 10753 113 AOI21_X1
* cell instance $5896 m0 *1 215.65,173.6
X$5896 11305 11511 12237 112 13207 113 AOI21_X2
* cell instance $5897 m0 *1 216.98,173.6
X$5897 12984 12366 10492 113 13105 112 OAI21_X1
* cell instance $5899 m0 *1 217.93,173.6
X$5899 13210 12884 13122 13187 10373 10896 112 113 OAI221_X2
* cell instance $5901 m0 *1 220.21,173.6
X$5901 11144 12985 112 113 11793 NOR2_X1
* cell instance $5902 m0 *1 220.78,173.6
X$5902 13121 11310 13188 13189 12102 13197 113 112 AOI221_X2
* cell instance $5903 m0 *1 222.87,173.6
X$5903 11032 10722 11038 112 113 13107 NAND3_X1
* cell instance $5905 r0 *1 206.72,173.6
X$5905 11787 112 113 12229 INV_X4
* cell instance $5906 r0 *1 207.67,173.6
X$5906 11147 10594 11649 112 113 13021 MUX2_X1
* cell instance $5908 r0 *1 209.19,173.6
X$5908 13125 113 11150 112 BUF_X4
* cell instance $5909 r0 *1 210.52,173.6
X$5909 12683 11303 11353 112 113 13185 MUX2_X1
* cell instance $5910 r0 *1 211.85,173.6
X$5910 11484 10853 11353 112 113 13293 MUX2_X1
* cell instance $5911 r0 *1 213.18,173.6
X$5911 13295 112 113 11330 INV_X4
* cell instance $5912 r0 *1 214.13,173.6
X$5912 11460 112 113 11960 CLKBUF_X3
* cell instance $5913 r0 *1 215.08,173.6
X$5913 10910 11964 11303 112 13214 113 AOI21_X1
* cell instance $5914 r0 *1 215.84,173.6
X$5914 13293 11145 10006 113 13286 112 OAI21_X1
* cell instance $5915 r0 *1 216.6,173.6
X$5915 13104 12508 112 113 13289 OR2_X2
* cell instance $5916 r0 *1 217.55,173.6
X$5916 10599 12983 12883 112 12387 113 AOI21_X1
* cell instance $5917 r0 *1 218.31,173.6
X$5917 11022 112 113 12984 INV_X1
* cell instance $5918 r0 *1 218.69,173.6
X$5918 11335 13185 10595 13272 11155 13280 113 112 AOI221_X2
* cell instance $5919 r0 *1 220.78,173.6
X$5919 11038 13207 13190 11313 113 112 13189 OAI22_X2
* cell instance $5920 r0 *1 222.49,173.6
X$5920 10599 13273 13106 13274 112 113 13281 AOI22_X1
* cell instance $5921 r0 *1 223.44,173.6
X$5921 12102 13190 13107 113 12379 112 OAI21_X1
* cell instance $5923 m0 *1 224.01,173.6
X$5923 112 12350 12510 113 BUF_X16
* cell instance $5924 r0 *1 224.2,173.6
X$5924 13119 11032 112 113 13188 NOR2_X1
* cell instance $5925 r0 *1 224.77,173.6
X$5925 11649 11147 11960 112 13108 113 AOI21_X1
* cell instance $5926 r0 *1 225.53,173.6
X$5926 13280 11794 10489 113 13115 112 OAI21_X1
* cell instance $5927 r0 *1 226.29,173.6
X$5927 11145 12229 112 113 12988 NAND2_X1
* cell instance $5928 r0 *1 226.86,173.6
X$5928 12089 13016 12366 112 13191 113 AOI21_X1
* cell instance $5929 r0 *1 227.62,173.6
X$5929 11335 10595 12637 112 113 13210 NOR3_X1
* cell instance $5930 r0 *1 228.38,173.6
X$5930 11305 12237 112 113 13190 NAND2_X1
* cell instance $5931 r0 *1 228.95,173.6
X$5931 11484 11335 12984 112 113 13198 MUX2_X1
* cell instance $5933 m0 *1 229.14,173.6
X$5933 12086 13198 13199 12508 10610 13116 112 113 OAI221_X2
* cell instance $5934 r0 *1 230.28,173.6
X$5934 11313 12103 16693 113 112 12245 HA_X1
* cell instance $5935 m0 *1 231.8,173.6
X$5935 12997 13197 13113 13111 10373 12898 112 113 OAI221_X2
* cell instance $5937 m0 *1 233.89,173.6
X$5937 13195 12996 10608 12990 13193 113 112 12989 OAI221_X1
* cell instance $5943 r0 *1 232.56,173.6
X$5943 11313 11794 12086 113 13277 112 OAI21_X1
* cell instance $5944 r0 *1 233.32,173.6
X$5944 13277 11794 13191 112 13193 113 AOI21_X1
* cell instance $5946 r0 *1 235.6,173.6
X$5946 112 17128 13194 13276 12247 113 DFF_X1
* cell instance $5953 m0 *1 109.06,16.8
X$5953 208 186 175 112 113 205 MUX2_X1
* cell instance $5954 m0 *1 105.45,16.8
X$5954 112 205 184 251 208 113 DFF_X2
* cell instance $5955 m0 *1 110.39,16.8
X$5955 184 112 113 17197 INV_X1
* cell instance $5956 m0 *1 110.77,16.8
X$5956 112 16744 187 211 184 113 DFF_X1
* cell instance $5957 m0 *1 114,16.8
X$5957 187 186 188 112 113 211 MUX2_X1
* cell instance $5959 r0 *1 105.45,16.8
X$5959 248 224 112 113 272 NOR2_X2
* cell instance $5962 r0 *1 106.97,16.8
X$5962 254 186 226 112 113 342 MUX2_X1
* cell instance $5967 r0 *1 111.15,16.8
X$5967 344 186 148 112 113 273 MUX2_X1
* cell instance $5970 r0 *1 115.33,16.8
X$5970 112 17071 260 259 150 113 DFF_X1
* cell instance $5977 r0 *1 120.08,16.8
X$5977 112 228 227 300 255 113 DFF_X2
* cell instance $5980 m0 *1 123.12,16.8
X$5980 255 194 176 112 113 228 MUX2_X1
* cell instance $5985 r0 *1 124.45,16.8
X$5985 112 253 152 299 229 113 DFF_X2
* cell instance $5986 m0 *1 126.73,16.8
X$5986 189 112 113 152 CLKBUF_X3
* cell instance $5989 r0 *1 128.06,16.8
X$5989 229 186 210 112 113 253 MUX2_X1
* cell instance $5990 r0 *1 129.39,16.8
X$5990 152 112 113 16484 CLKBUF_X1
* cell instance $5993 m0 *1 131.86,16.8
X$5993 249 194 216 112 113 230 MUX2_X1
* cell instance $5999 m0 *1 136.04,16.8
X$5999 112 212 231 17231 196 113 DFF_X2
* cell instance $6000 m0 *1 139.65,16.8
X$6000 112 197 231 17216 198 113 DFF_X2
* cell instance $6009 m0 *1 180.69,16.8
X$6009 112 16861 200 201 199 113 DFF_X1
* cell instance $6025 r0 *1 143.64,16.8
X$6025 112 16988 157 297 231 113 DFF_X1
* cell instance $6032 r0 *1 169.86,16.8
X$6032 241 238 16613 113 112 232 HA_X1
* cell instance $6034 r0 *1 171.95,16.8
X$6034 235 112 113 296 CLKBUF_X3
* cell instance $6037 r0 *1 174.8,16.8
X$6037 234 282 112 113 233 NOR2_X1
* cell instance $6040 r0 *1 175.94,16.8
X$6040 235 236 112 113 246 NAND2_X1
* cell instance $6043 r0 *1 178.79,16.8
X$6043 237 238 16602 113 112 239 HA_X1
* cell instance $6044 r0 *1 180.69,16.8
X$6044 239 235 246 113 292 112 OAI21_X1
* cell instance $6045 r0 *1 181.45,16.8
X$6045 239 234 113 112 285 AND2_X1
* cell instance $6047 r0 *1 186.2,16.8
X$6047 282 240 241 112 113 288 MUX2_X1
* cell instance $6070 m0 *1 112.67,148.4
X$6070 10776 9876 10125 112 113 10786 MUX2_X1
* cell instance $6072 m0 *1 114,148.4
X$6072 9965 10471 9476 10960 10570 10787 113 112 AOI221_X2
* cell instance $6074 m0 *1 116.28,148.4
X$6074 9974 9936 10573 112 113 10570 NOR3_X1
* cell instance $6076 r0 *1 112.48,148.4
X$6076 10572 10663 9873 112 113 10930 NAND3_X1
* cell instance $6079 r0 *1 114.95,148.4
X$6079 10788 10818 113 112 10695 XNOR2_X1
* cell instance $6080 r0 *1 116.09,148.4
X$6080 9966 10946 10945 10695 10253 113 112 10942 OAI221_X1
* cell instance $6082 m0 *1 118.75,148.4
X$6082 9967 9732 9827 112 10948 113 AOI21_X2
* cell instance $6083 m0 *1 117.42,148.4
X$6083 9969 9732 10084 112 10818 113 AOI21_X2
* cell instance $6085 m0 *1 120.27,148.4
X$6085 10662 10697 10574 112 10698 113 AOI21_X1
* cell instance $6086 m0 *1 121.03,148.4
X$6086 10575 10698 10121 112 113 10699 NOR3_X1
* cell instance $6088 m0 *1 121.98,148.4
X$6088 10240 10669 10577 113 10672 112 OAI21_X1
* cell instance $6089 m0 *1 122.74,148.4
X$6089 10777 10473 9962 113 10671 112 OAI21_X1
* cell instance $6091 r0 *1 117.61,148.4
X$6091 10780 9973 10790 112 113 10946 MUX2_X1
* cell instance $6092 r0 *1 118.94,148.4
X$6092 10948 10697 10947 112 10790 113 AOI21_X1
* cell instance $6093 r0 *1 119.7,148.4
X$6093 10696 10470 112 113 10697 NAND2_X1
* cell instance $6095 r0 *1 120.65,148.4
X$6095 9476 10200 112 113 10820 NAND2_X1
* cell instance $6099 r0 *1 122.55,148.4
X$6099 10441 10822 9831 112 113 10700 MUX2_X1
* cell instance $6100 r0 *1 123.88,148.4
X$6100 112 10084 113 10097 BUF_X8
* cell instance $6101 m0 *1 124.64,148.4
X$6101 10671 10255 112 113 10789 NOR2_X1
* cell instance $6102 m0 *1 123.88,148.4
X$6102 9873 10700 10354 113 10670 112 OAI21_X1
* cell instance $6104 m0 *1 125.97,148.4
X$6104 10580 10446 10476 113 10248 112 OAI21_X1
* cell instance $6105 m0 *1 126.73,148.4
X$6105 10574 10578 10579 113 10824 112 OAI21_X1
* cell instance $6111 r0 *1 126.35,148.4
X$6111 10701 10822 113 112 10578 XNOR2_X1
* cell instance $6113 r0 *1 128.25,148.4
X$6113 10057 10571 10476 112 113 10825 NAND3_X1
* cell instance $6115 m0 *1 128.63,148.4
X$6115 10573 113 10065 112 BUF_X4
* cell instance $6116 m0 *1 130.72,148.4
X$6116 10580 10701 10130 112 10667 113 AOI21_X1
* cell instance $6120 r0 *1 129.2,148.4
X$6120 10581 10444 10065 112 113 10959 NOR3_X1
* cell instance $6122 r0 *1 130.15,148.4
X$6122 10998 10571 10573 112 113 10354 NAND3_X2
* cell instance $6124 r0 *1 131.86,148.4
X$6124 10959 10783 10243 112 113 10826 NOR3_X1
* cell instance $6125 r0 *1 132.62,148.4
X$6125 10342 10057 10571 112 10783 113 AOI21_X1
* cell instance $6126 m0 *1 133.95,148.4
X$6126 10472 10355 10254 112 10581 113 AOI21_X2
* cell instance $6127 m0 *1 132.62,148.4
X$6127 10703 10446 10573 113 10133 112 NOR3_X2
* cell instance $6128 m0 *1 135.28,148.4
X$6128 9936 10661 113 112 10706 AND2_X1
* cell instance $6130 r0 *1 133.38,148.4
X$6130 10962 10662 10705 112 10443 113 AOI21_X1
* cell instance $6131 r0 *1 134.14,148.4
X$6131 9936 10573 10348 112 10827 113 AOI21_X1
* cell instance $6132 r0 *1 134.9,148.4
X$6132 10775 10352 10705 112 10780 113 AOI21_X1
* cell instance $6133 r0 *1 135.66,148.4
X$6133 10706 10778 9476 9593 10707 112 113 10704 AOI221_X1
* cell instance $6135 m0 *1 136.42,148.4
X$6135 10257 10125 112 113 10778 NAND2_X1
* cell instance $6136 m0 *1 137.75,148.4
X$6136 10777 10473 10776 10708 113 112 10775 OAI22_X1
* cell instance $6138 m0 *1 138.89,148.4
X$6138 112 10472 10136 10096 10580 113 NOR3_X4
* cell instance $6142 r0 *1 136.8,148.4
X$6142 10581 10703 10573 113 10965 112 OAI21_X1
* cell instance $6143 r0 *1 137.56,148.4
X$6143 10828 10662 10705 112 10707 113 AOI21_X1
* cell instance $6144 r0 *1 138.32,148.4
X$6144 10441 10708 10965 113 10963 112 OAI21_X1
* cell instance $6145 r0 *1 139.08,148.4
X$6145 10096 113 10346 112 BUF_X4
* cell instance $6147 r0 *1 143.45,148.4
X$6147 10437 112 113 10830 INV_X1
* cell instance $6148 r0 *1 143.83,148.4
X$6148 10830 3937 112 113 10831 NOR2_X1
* cell instance $6149 m0 *1 144.4,148.4
X$6149 10437 3489 10709 112 113 10774 NOR3_X1
* cell instance $6151 m0 *1 145.16,148.4
X$6151 3639 10479 112 113 10710 NOR2_X1
* cell instance $6152 m0 *1 145.73,148.4
X$6152 10709 112 113 10479 INV_X1
* cell instance $6155 r0 *1 144.4,148.4
X$6155 10831 10711 10709 112 113 10966 NOR3_X1
* cell instance $6156 r0 *1 145.16,148.4
X$6156 10966 10711 10710 112 10773 113 AOI21_X2
* cell instance $6158 m0 *1 149.91,148.4
X$6158 9509 8317 10583 112 113 10358 OR3_X2
* cell instance $6159 m0 *1 148.01,148.4
X$6159 4404 4921 112 113 11002 XNOR2_X2
* cell instance $6163 r0 *1 148.2,148.4
X$6163 4921 4404 113 11073 112 XOR2_X2
* cell instance $6165 r0 *1 150.1,148.4
X$6165 112 17003 10583 10832 9850 113 DFF_X1
* cell instance $6166 m0 *1 152.38,148.4
X$6166 6821 11275 113 112 10656 XNOR2_X1
* cell instance $6169 r0 *1 153.33,148.4
X$6169 112 17029 10961 10712 9850 113 DFF_X1
* cell instance $6171 m0 *1 153.9,148.4
X$6171 10359 7107 10585 112 10712 113 AOI21_X1
* cell instance $6174 r0 *1 156.56,148.4
X$6174 10961 113 10267 112 BUF_X4
* cell instance $6176 r0 *1 158.65,148.4
X$6176 112 3672 113 4676 BUF_X8
* cell instance $6177 m0 *1 159.03,148.4
X$6177 10587 5995 10770 112 113 10647 MUX2_X1
* cell instance $6179 m0 *1 160.36,148.4
X$6179 10428 9209 10771 112 113 10430 MUX2_X1
* cell instance $6180 m0 *1 161.69,148.4
X$6180 112 16822 10587 10647 10586 113 DFF_X1
* cell instance $6184 m0 *1 165.49,148.4
X$6184 10587 10642 8317 113 112 10588 MUX2_X2
* cell instance $6190 r0 *1 165.87,148.4
X$6190 10586 112 113 17182 INV_X2
* cell instance $6191 r0 *1 166.44,148.4
X$6191 9765 10588 112 113 10957 XNOR2_X2
* cell instance $6192 r0 *1 168.34,148.4
X$6192 10299 112 113 10586 CLKBUF_X3
* cell instance $6195 r0 *1 171,148.4
X$6195 112 10958 10586 17262 10143 113 DFF_X2
* cell instance $6196 r0 *1 174.61,148.4
X$6196 10415 8939 112 113 10952 XNOR2_X2
* cell instance $6198 m0 *1 175.18,148.4
X$6198 112 10589 10586 17225 10767 113 DFF_X2
* cell instance $6200 r0 *1 176.51,148.4
X$6200 10713 10949 112 113 11011 NOR2_X1
* cell instance $6202 r0 *1 177.27,148.4
X$6202 10143 112 113 10940 BUF_X1
* cell instance $6205 r0 *1 179.74,148.4
X$6205 3678 10484 112 113 10950 NAND2_X1
* cell instance $6210 r0 *1 180.5,148.4
X$6210 3678 10714 112 113 10837 NAND2_X1
* cell instance $6211 r0 *1 181.07,148.4
X$6211 8434 10714 112 113 10838 NOR2_X1
* cell instance $6212 r0 *1 181.64,148.4
X$6212 10484 112 113 10714 INV_X1
* cell instance $6214 m0 *1 182.4,148.4
X$6214 8434 10484 112 113 10590 NOR2_X1
* cell instance $6218 r0 *1 182.4,148.4
X$6218 10838 10590 7924 113 112 11014 MUX2_X2
* cell instance $6219 m0 *1 184.68,148.4
X$6219 112 9998 10715 10758 10847 113 DFF_X1
* cell instance $6220 m0 *1 184.11,148.4
X$6220 7650 10367 112 113 10761 NOR2_X1
* cell instance $6221 m0 *1 187.91,148.4
X$6221 10715 4939 10760 112 113 10758 MUX2_X1
* cell instance $6222 m0 *1 189.24,148.4
X$6222 10514 10140 112 113 10842 XNOR2_X2
* cell instance $6224 r0 *1 184.11,148.4
X$6224 10367 3873 113 112 10839 AND2_X1
* cell instance $6225 r0 *1 184.87,148.4
X$6225 10839 112 113 10944 INV_X1
* cell instance $6227 r0 *1 185.44,148.4
X$6227 10940 9999 113 10911 112 XOR2_X2
* cell instance $6228 r0 *1 187.15,148.4
X$6228 10761 112 113 10939 INV_X1
* cell instance $6231 r0 *1 188.1,148.4
X$6231 10938 6773 112 113 10841 NOR2_X1
* cell instance $6233 r0 *1 188.86,148.4
X$6233 10757 112 113 10938 INV_X1
* cell instance $6234 r0 *1 189.24,148.4
X$6234 10938 4676 112 113 10843 NAND2_X1
* cell instance $6235 r0 *1 189.81,148.4
X$6235 10140 10514 113 10845 112 XOR2_X2
* cell instance $6237 m0 *1 191.71,148.4
X$6237 112 16929 10716 10641 10847 113 DFF_X1
* cell instance $6241 m0 *1 197.22,148.4
X$6241 10487 113 10756 112 BUF_X4
* cell instance $6244 m0 *1 204.82,148.4
X$6244 10755 113 10594 112 BUF_X4
* cell instance $6247 m0 *1 209.38,148.4
X$6247 10155 113 10737 112 BUF_X4
* cell instance $6249 r0 *1 191.71,148.4
X$6249 5393 10716 113 112 10846 AND2_X1
* cell instance $6252 r0 *1 194.37,148.4
X$6252 10716 4508 112 113 10848 NOR2_X1
* cell instance $6255 r0 *1 195.51,148.4
X$6255 6183 5573 113 112 10849 XNOR2_X1
* cell instance $6259 r0 *1 197.98,148.4
X$6259 10591 10717 113 112 11361 AND2_X2
* cell instance $6260 r0 *1 198.93,148.4
X$6260 10717 10591 112 11016 113 NAND2_X4
* cell instance $6262 r0 *1 200.83,148.4
X$6262 10515 113 10853 112 BUF_X4
* cell instance $6266 r0 *1 206.34,148.4
X$6266 9768 10637 112 113 10603 NOR2_X2
* cell instance $6268 r0 *1 207.48,148.4
X$6268 10719 10854 10718 112 113 10924 NOR3_X1
* cell instance $6270 m0 *1 211.28,148.4
X$6270 10594 113 10722 112 BUF_X4
* cell instance $6273 r0 *1 211.28,148.4
X$6273 10606 10489 112 113 10719 NAND2_X1
* cell instance $6274 r0 *1 211.85,148.4
X$6274 10720 10372 10373 112 10921 113 AOI21_X1
* cell instance $6275 r0 *1 212.61,148.4
X$6275 10912 10910 112 113 10754 NAND2_X1
* cell instance $6276 m0 *1 213.75,148.4
X$6276 10721 10753 10598 112 113 10597 NOR3_X1
* cell instance $6277 m0 *1 212.99,148.4
X$6277 10599 10754 10596 112 10721 113 AOI21_X1
* cell instance $6279 m0 *1 214.7,148.4
X$6279 10625 10724 10598 10751 113 112 10490 OAI22_X2
* cell instance $6281 m0 *1 216.6,148.4
X$6281 10599 10600 10602 113 10375 112 OAI21_X1
* cell instance $6283 m0 *1 217.55,148.4
X$6283 10898 10727 10725 112 10600 113 AOI21_X1
* cell instance $6285 m0 *1 218.5,148.4
X$6285 10626 10399 112 113 10726 NOR2_X1
* cell instance $6287 r0 *1 213.18,148.4
X$6287 10912 11023 113 112 10903 AND2_X1
* cell instance $6289 r0 *1 214.13,148.4
X$6289 10857 10596 10855 10723 112 113 10631 AOI22_X1
* cell instance $6290 r0 *1 215.08,148.4
X$6290 10905 10610 112 113 10723 NOR2_X1
* cell instance $6293 r0 *1 216.6,148.4
X$6293 10903 10725 10859 113 10893 112 OAI21_X1
* cell instance $6295 r0 *1 217.55,148.4
X$6295 10747 10900 10726 10606 10731 113 112 10745 OAI221_X1
* cell instance $6298 r0 *1 219.26,148.4
X$6298 10896 10745 113 112 10889 AND2_X2
* cell instance $6299 m0 *1 220.78,148.4
X$6299 10607 10608 112 113 10625 NAND2_X2
* cell instance $6300 m0 *1 219.45,148.4
X$6300 10729 10606 10605 112 10894 113 AOI21_X2
* cell instance $6301 m0 *1 221.73,148.4
X$6301 10722 10608 112 113 10729 NAND2_X1
* cell instance $6303 r0 *1 220.21,148.4
X$6303 10607 10893 10894 112 10728 113 AOI21_X2
* cell instance $6304 r0 *1 221.54,148.4
X$6304 10889 10728 10732 10886 10603 10623 113 112 AOI221_X2
* cell instance $6305 m0 *1 223.63,148.4
X$6305 10730 10599 10743 112 113 10494 MUX2_X1
* cell instance $6306 m0 *1 222.68,148.4
X$6306 10595 112 113 10727 CLKBUF_X3
* cell instance $6307 m0 *1 224.96,148.4
X$6307 10610 10373 112 113 10620 NAND2_X1
* cell instance $6308 m0 *1 225.53,148.4
X$6308 10722 112 113 10610 CLKBUF_X3
* cell instance $6311 r0 *1 223.82,148.4
X$6311 10883 10885 10720 113 112 10882 OAI21_X2
* cell instance $6312 r0 *1 225.15,148.4
X$6312 11040 10882 10372 112 10731 113 AOI21_X2
* cell instance $6313 r0 *1 226.48,148.4
X$6313 10727 10880 10881 113 10865 112 OAI21_X1
* cell instance $6315 m0 *1 226.86,148.4
X$6315 10593 113 10599 112 BUF_X4
* cell instance $6316 m0 *1 228.95,148.4
X$6316 4841 112 113 10376 CLKBUF_X3
* cell instance $6317 m0 *1 229.9,148.4
X$6317 10376 112 113 16464 CLKBUF_X1
* cell instance $6318 m0 *1 230.47,148.4
X$6318 10489 10608 112 113 10604 NAND2_X1
* cell instance $6322 r0 *1 227.62,148.4
X$6322 10876 10599 10865 112 10732 113 AOI21_X1
* cell instance $6324 r0 *1 228.76,148.4
X$6324 10737 113 10859 112 BUF_X4
* cell instance $6325 r0 *1 230.09,148.4
X$6325 112 16981 10735 10850 10376 113 DFF_X1
* cell instance $6326 r0 *1 233.32,148.4
X$6326 112 17063 11168 10025 10376 113 DFF_X1
* cell instance $6328 m0 *1 234.46,148.4
X$6328 10496 112 113 10616 BUF_X1
* cell instance $6329 m0 *1 238.07,148.4
X$6329 10735 112 113 10612 BUF_X1
* cell instance $6330 m0 *1 238.64,148.4
X$6330 10498 112 113 10505 BUF_X1
* cell instance $6331 m0 *1 239.21,148.4
X$6331 10378 112 113 10613 BUF_X1
* cell instance $6339 m0 *1 77.33,53.2
X$6339 2324 113 1423 112 BUF_X4
* cell instance $6340 m0 *1 75.62,53.2
X$6340 2231 2324 1427 112 113 NOR2_X4
* cell instance $6343 r0 *1 75.62,53.2
X$6343 1425 1427 2296 112 113 2628 MUX2_X1
* cell instance $6344 r0 *1 76.95,53.2
X$6344 2448 1907 2628 112 113 2418 MUX2_X1
* cell instance $6347 r0 *1 79.42,53.2
X$6347 1729 2231 2324 113 112 2000 OAI21_X4
* cell instance $6350 r0 *1 83.79,53.2
X$6350 943 1530 1428 112 113 2629 MUX2_X1
* cell instance $6351 m0 *1 85.31,53.2
X$6351 1196 2420 2114 617 793 1156 112 113 OAI221_X2
* cell instance $6353 m0 *1 87.4,53.2
X$6353 1192 2325 2326 113 112 2516 AND3_X1
* cell instance $6354 m0 *1 88.35,53.2
X$6354 2516 1355 2424 112 2630 113 AOI21_X1
* cell instance $6356 r0 *1 85.12,53.2
X$6356 793 2629 576 1688 112 113 2543 AOI22_X1
* cell instance $6357 r0 *1 86.07,53.2
X$6357 2543 1732 112 113 2546 NOR2_X1
* cell instance $6358 r0 *1 86.64,53.2
X$6358 1428 1688 1154 1166 112 113 2449 AOI22_X1
* cell instance $6359 r0 *1 87.59,53.2
X$6359 2185 1238 2449 112 2544 113 AOI21_X1
* cell instance $6362 r0 *1 89.3,53.2
X$6362 1428 2428 1045 113 2545 112 OAI21_X1
* cell instance $6363 m0 *1 89.68,53.2
X$6363 1355 2327 2328 113 112 2520 AND3_X1
* cell instance $6365 m0 *1 90.63,53.2
X$6365 1392 2114 1615 113 2426 112 OAI21_X1
* cell instance $6366 m0 *1 91.39,53.2
X$6366 2426 2329 1830 113 2427 112 OAI21_X1
* cell instance $6367 m0 *1 92.15,53.2
X$6367 2520 2427 2330 113 2331 112 OAI21_X1
* cell instance $6368 m0 *1 92.91,53.2
X$6368 525 1830 112 113 2232 NOR2_X1
* cell instance $6370 m0 *1 95,53.2
X$6370 2109 1043 1192 2332 2551 113 112 AOI211_X2
* cell instance $6372 r0 *1 90.06,53.2
X$6372 1032 112 113 1741 CLKBUF_X3
* cell instance $6373 r0 *1 91.01,53.2
X$6373 871 1032 576 112 113 2522 NAND3_X1
* cell instance $6374 r0 *1 91.77,53.2
X$6374 1392 871 617 793 112 113 2632 AOI22_X1
* cell instance $6375 r0 *1 92.72,53.2
X$6375 1732 2632 2522 113 2635 112 OAI21_X1
* cell instance $6376 r0 *1 93.48,53.2
X$6376 1161 1830 1360 2635 2636 113 112 AOI211_X2
* cell instance $6377 r0 *1 95.19,53.2
X$6377 2636 2551 840 112 113 2450 NOR3_X1
* cell instance $6455 m0 *1 114,44.8
X$6455 1747 112 113 189 CLKBUF_X3
* cell instance $6456 m0 *1 113.43,44.8
X$6456 189 112 113 17163 INV_X2
* cell instance $6457 m0 *1 114.95,44.8
X$6457 112 724 113 1831 BUF_X8
* cell instance $6461 r0 *1 113.62,44.8
X$6461 112 1996 1439 854 1558 113 NOR3_X4
* cell instance $6462 r0 *1 116.28,44.8
X$6462 112 1748 1439 1440 953 113 NOR3_X4
* cell instance $6463 m0 *1 118.75,44.8
X$6463 652 112 113 1716 INV_X2
* cell instance $6465 m0 *1 119.32,44.8
X$6465 112 662 113 1543 BUF_X8
* cell instance $6469 r0 *1 120.65,44.8
X$6469 112 1654 791 1896 1831 113 AOI21_X4
* cell instance $6471 m0 *1 122.17,44.8
X$6471 1749 1126 1652 1653 1897 113 112 AOI211_X2
* cell instance $6472 r0 *1 123.12,44.8
X$6472 1922 1543 723 112 113 NOR2_X4
* cell instance $6476 m0 *1 125.4,44.8
X$6476 1751 880 528 112 113 1750 NAND3_X1
* cell instance $6477 m0 *1 124.26,44.8
X$6477 1832 1508 1752 1750 1897 113 112 1657 OAI221_X1
* cell instance $6479 m0 *1 126.35,44.8
X$6479 728 848 1126 1543 112 113 1751 NAND4_X1
* cell instance $6482 r0 *1 125.59,44.8
X$6482 1259 792 1997 1549 731 113 112 1923 OAI221_X1
* cell instance $6483 r0 *1 126.73,44.8
X$6483 585 792 1204 574 1753 113 112 2087 OAI221_X1
* cell instance $6484 m0 *1 127.87,44.8
X$6484 1749 801 1445 112 113 1834 NOR3_X1
* cell instance $6486 m0 *1 128.63,44.8
X$6486 1834 1717 1752 112 113 1835 NOR3_X1
* cell instance $6487 m0 *1 129.39,44.8
X$6487 1654 801 574 113 1799 112 OAI21_X1
* cell instance $6488 m0 *1 130.15,44.8
X$6488 1509 1749 707 112 113 1836 NOR3_X1
* cell instance $6489 m0 *1 130.91,44.8
X$6489 1508 1995 1836 1895 113 112 1994 OAI22_X1
* cell instance $6490 m0 *1 131.86,44.8
X$6490 528 1836 1797 112 113 1893 OR3_X1
* cell instance $6493 r0 *1 127.87,44.8
X$6493 1833 632 1753 112 1795 113 AOI21_X1
* cell instance $6494 r0 *1 128.63,44.8
X$6494 791 1443 707 660 1098 112 113 1833 AOI221_X1
* cell instance $6497 r0 *1 130.15,44.8
X$6497 112 2214 113 791 BUF_X8
* cell instance $6498 r0 *1 132.62,44.8
X$6498 1799 1186 112 113 1895 NAND2_X1
* cell instance $6499 r0 *1 133.19,44.8
X$6499 1023 1447 585 705 112 113 1992 AOI22_X1
* cell instance $6501 m0 *1 133.95,44.8
X$6501 734 704 112 113 1754 NOR2_X1
* cell instance $6503 m0 *1 139.08,44.8
X$6503 1340 845 591 112 113 1793 NAND3_X1
* cell instance $6505 m0 *1 140.6,44.8
X$6505 1282 1713 113 112 1837 AND2_X1
* cell instance $6506 m0 *1 141.36,44.8
X$6506 585 632 1047 113 1838 112 OAI21_X1
* cell instance $6507 m0 *1 142.12,44.8
X$6507 705 587 635 1182 1786 1976 113 112 AOI221_X2
* cell instance $6509 r0 *1 134.14,44.8
X$6509 1986 1893 1754 112 113 2123 NAND3_X1
* cell instance $6510 r0 *1 134.9,44.8
X$6510 1844 1660 1409 1364 1289 113 112 1986 OAI221_X1
* cell instance $6513 r0 *1 137.75,44.8
X$6513 574 1364 112 113 1926 NOR2_X1
* cell instance $6514 r0 *1 138.32,44.8
X$6514 1926 1983 659 113 1925 112 OAI21_X1
* cell instance $6517 r0 *1 139.65,44.8
X$6517 787 1443 731 113 1496 112 NOR3_X2
* cell instance $6518 r0 *1 140.98,44.8
X$6518 632 1837 113 112 1928 AND2_X1
* cell instance $6519 r0 *1 141.74,44.8
X$6519 1838 1928 1018 1047 1795 113 112 1978 OAI221_X1
* cell instance $6520 r0 *1 142.88,44.8
X$6520 1289 1837 1793 113 1929 112 OAI21_X1
* cell instance $6522 r0 *1 144.4,44.8
X$6522 1839 574 112 113 1789 NOR2_X1
* cell instance $6523 m0 *1 144.78,44.8
X$6523 723 734 112 113 1840 NOR2_X1
* cell instance $6525 m0 *1 145.35,44.8
X$6525 1635 1186 1785 112 1841 113 AOI21_X1
* cell instance $6527 m0 *1 146.3,44.8
X$6527 1629 734 1409 1840 1845 112 113 1886 AOI221_X1
* cell instance $6528 m0 *1 147.44,44.8
X$6528 1412 1886 1560 113 1846 112 OAI21_X1
* cell instance $6529 m0 *1 148.2,44.8
X$6529 1752 1124 662 112 1885 113 AOI21_X1
* cell instance $6533 m0 *1 164.16,44.8
X$6533 424 630 113 112 1847 XNOR2_X1
* cell instance $6537 r0 *1 145.92,44.8
X$6537 1976 1842 1099 112 113 1843 NOR3_X1
* cell instance $6538 r0 *1 146.68,44.8
X$6538 1445 1844 1509 112 113 1845 OR3_X1
* cell instance $6545 r0 *1 164.16,44.8
X$6545 1963 1618 112 113 1930 NOR2_X1
* cell instance $6546 r0 *1 164.73,44.8
X$6546 824 357 1847 112 1848 113 AOI21_X1
* cell instance $6549 m0 *1 165.68,44.8
X$6549 1757 1681 1884 113 1692 112 OAI21_X1
* cell instance $6550 m0 *1 168.15,44.8
X$6550 241 998 543 112 1973 113 AOI21_X1
* cell instance $6551 m0 *1 166.82,44.8
X$6551 1215 1060 600 112 113 1971 MUX2_X1
* cell instance $6553 m0 *1 169.67,44.8
X$6553 1060 606 329 112 113 1849 NOR3_X1
* cell instance $6554 m0 *1 170.43,44.8
X$6554 1666 862 424 113 1850 112 OAI21_X1
* cell instance $6556 m0 *1 171.95,44.8
X$6556 1309 1759 112 113 916 NAND2_X1
* cell instance $6557 m0 *1 172.52,44.8
X$6557 1307 1759 1218 113 112 669 OAI21_X2
* cell instance $6558 m0 *1 173.85,44.8
X$6558 753 112 113 424 CLKBUF_X3
* cell instance $6560 m0 *1 174.99,44.8
X$6560 1167 669 1760 1070 113 112 1932 OAI22_X2
* cell instance $6561 m0 *1 176.7,44.8
X$6561 1467 785 112 113 1167 NOR2_X2
* cell instance $6564 r0 *1 167.39,44.8
X$6564 1972 1757 112 113 1011 NOR2_X1
* cell instance $6567 r0 *1 168.53,44.8
X$6567 1973 1758 1968 1757 1172 113 112 2192 OAI221_X1
* cell instance $6569 r0 *1 169.86,44.8
X$6569 1964 1849 547 1931 1850 113 112 1968 OAI221_X1
* cell instance $6570 r0 *1 171,44.8
X$6570 235 630 241 112 113 1931 NOR3_X1
* cell instance $6571 r0 *1 171.76,44.8
X$6571 610 1302 235 113 112 1964 OAI21_X2
* cell instance $6572 r0 *1 173.09,44.8
X$6572 1757 1962 1169 112 1963 113 AOI21_X1
* cell instance $6575 r0 *1 174.42,44.8
X$6575 1303 358 112 600 113 NAND2_X4
* cell instance $6576 r0 *1 176.13,44.8
X$6576 893 1467 1214 112 113 1760 MUX2_X1
* cell instance $6578 m0 *1 178.22,44.8
X$6578 357 1303 1307 113 1761 112 OAI21_X1
* cell instance $6580 m0 *1 178.98,44.8
X$6580 1756 1779 1876 1682 112 113 1778 AOI22_X2
* cell instance $6581 m0 *1 180.69,44.8
X$6581 322 862 112 113 824 NOR2_X2
* cell instance $6583 r0 *1 178.98,44.8
X$6583 753 1164 1761 113 1956 112 OAI21_X1
* cell instance $6584 r0 *1 179.74,44.8
X$6584 1682 1774 1566 1756 1956 1776 113 112 AOI221_X2
* cell instance $6588 r0 *1 181.83,44.8
X$6588 1303 1851 1376 1759 838 1082 113 112 AOI221_X2
* cell instance $6589 m0 *1 182.21,44.8
X$6589 1762 1305 112 113 450 NOR2_X2
* cell instance $6592 m0 *1 183.73,44.8
X$6592 557 818 1215 1214 1853 1774 112 113 OAI221_X2
* cell instance $6594 m0 *1 185.82,44.8
X$6594 1675 998 1874 112 1876 113 AOI21_X1
* cell instance $6595 m0 *1 186.58,44.8
X$6595 1070 1389 862 112 1874 113 AOI21_X1
* cell instance $6596 m0 *1 187.34,44.8
X$6596 1855 1854 543 112 113 978 NAND3_X1
* cell instance $6597 m0 *1 188.1,44.8
X$6597 818 112 113 1852 INV_X2
* cell instance $6598 m0 *1 188.67,44.8
X$6598 1307 546 282 1303 1764 113 112 AOI211_X2
* cell instance $6599 m0 *1 190.38,44.8
X$6599 1317 1763 1764 113 112 756 OAI21_X2
* cell instance $6600 m0 *1 191.71,44.8
X$6600 610 289 606 112 1763 113 AOI21_X1
* cell instance $6602 m0 *1 192.66,44.8
X$6602 677 113 630 112 BUF_X4
* cell instance $6603 m0 *1 193.99,44.8
X$6603 1574 112 113 785 INV_X2
* cell instance $6605 m0 *1 195.32,44.8
X$6605 112 1218 113 1309 BUF_X8
* cell instance $6609 r0 *1 183.92,44.8
X$6609 1759 1467 1852 112 113 1155 MUX2_X1
* cell instance $6610 r0 *1 185.25,44.8
X$6610 1935 112 113 1762 BUF_X1
* cell instance $6612 r0 *1 186.2,44.8
X$6612 1852 113 282 112 BUF_X4
* cell instance $6613 r0 *1 187.53,44.8
X$6613 2136 112 113 566 INV_X4
* cell instance $6614 r0 *1 188.48,44.8
X$6614 1462 1140 112 113 1081 NOR2_X2
* cell instance $6615 r0 *1 189.43,44.8
X$6615 1855 1854 112 113 546 NAND2_X2
* cell instance $6616 r0 *1 190.38,44.8
X$6616 1855 1854 753 112 113 1580 NAND3_X1
* cell instance $6617 r0 *1 191.14,44.8
X$6617 241 238 16646 113 112 1574 HA_X1
* cell instance $6618 r0 *1 193.04,44.8
X$6618 1376 113 240 112 BUF_X4
* cell instance $6619 r0 *1 194.37,44.8
X$6619 1467 113 677 112 BUF_X4
* cell instance $6623 r0 *1 202.35,44.8
X$6623 1937 1862 16635 113 112 1938 HA_X1
* cell instance $6624 m0 *1 202.92,44.8
X$6624 1765 113 1870 112 BUF_X4
* cell instance $6629 m0 *1 212.04,44.8
X$6629 1864 1867 1766 112 113 2278 MUX2_X1
* cell instance $6630 m0 *1 213.37,44.8
X$6630 1857 113 1942 112 BUF_X4
* cell instance $6631 m0 *1 214.7,44.8
X$6631 1857 112 113 1866 BUF_X2
* cell instance $6634 m0 *1 217.17,44.8
X$6634 112 1860 113 1859 BUF_X8
* cell instance $6637 m0 *1 222.87,44.8
X$6637 112 1861 1862 113 BUF_X32
* cell instance $6642 r0 *1 204.44,44.8
X$6642 1937 1862 16620 113 112 1765 HA_X1
* cell instance $6643 r0 *1 206.34,44.8
X$6643 112 1939 113 1856 BUF_X8
* cell instance $6644 r0 *1 208.81,44.8
X$6644 1948 113 1943 112 BUF_X4
* cell instance $6645 r0 *1 210.14,44.8
X$6645 1940 1862 16649 113 112 1948 HA_X1
* cell instance $6646 r0 *1 212.04,44.8
X$6646 1945 113 1947 112 BUF_X4
* cell instance $6648 r0 *1 213.75,44.8
X$6648 1944 112 113 1766 INV_X8
* cell instance $6651 r0 *1 216.03,44.8
X$6651 112 1858 1939 2039 1863 113 NOR3_X4
* cell instance $6652 r0 *1 218.69,44.8
X$6652 1859 113 1944 112 BUF_X4
* cell instance $6654 r0 *1 220.21,44.8
X$6654 112 1860 1861 113 BUF_X16
* cell instance $6665 m0 *1 115.9,240.8
X$6665 16409 112 113 16449 BUF_X1
* cell instance $6666 m0 *1 117.23,240.8
X$6666 16435 112 113 16332 BUF_X1
* cell instance $6668 m0 *1 119.32,240.8
X$6668 16370 112 113 16437 BUF_X1
* cell instance $6669 m0 *1 119.89,240.8
X$6669 16416 112 113 8518 CLKBUF_X2
* cell instance $6670 m0 *1 120.65,240.8
X$6670 16440 112 113 13671 BUF_X1
* cell instance $6673 m0 *1 122.17,240.8
X$6673 16441 112 113 7753 BUF_X2
* cell instance $6674 m0 *1 122.93,240.8
X$6674 16393 112 113 16392 BUF_X1
* cell instance $6675 m0 *1 123.5,240.8
X$6675 16377 112 113 16394 BUF_X1
* cell instance $6676 m0 *1 124.07,240.8
X$6676 16395 112 113 9052 CLKBUF_X2
* cell instance $6679 m0 *1 125.78,240.8
X$6679 16417 112 113 8523 BUF_X2
* cell instance $6680 m0 *1 126.54,240.8
X$6680 16411 112 113 16450 BUF_X1
* cell instance $6681 m0 *1 127.11,240.8
X$6681 16451 112 113 13871 BUF_X1
* cell instance $6682 m0 *1 127.68,240.8
X$6682 16421 112 113 13740 BUF_X1
* cell instance $6683 m0 *1 128.25,240.8
X$6683 16418 112 113 13260 CLKBUF_X2
* cell instance $6685 m0 *1 129.2,240.8
X$6685 16396 112 113 8529 CLKBUF_X2
* cell instance $6687 m0 *1 130.15,240.8
X$6687 16358 112 113 16398 BUF_X1
* cell instance $6688 m0 *1 130.72,240.8
X$6688 16399 112 113 13744 BUF_X1
* cell instance $6694 m0 *1 96.71,98
X$6694 4432 6351 6236 113 6132 112 OAI21_X1
* cell instance $6695 m0 *1 98.23,98
X$6695 4537 4308 112 113 6236 NAND2_X1
* cell instance $6697 m0 *1 101.84,98
X$6697 2959 6523 112 113 6480 XNOR2_X2
* cell instance $6699 m0 *1 103.93,98
X$6699 6608 3530 112 113 4542 NOR2_X1
* cell instance $6700 m0 *1 104.5,98
X$6700 6480 6073 112 113 6237 XNOR2_X2
* cell instance $6703 r0 *1 96.9,98
X$6703 4537 4308 3870 112 113 6521 NOR3_X1
* cell instance $6704 r0 *1 97.66,98
X$6704 4643 4432 6220 112 6391 113 AOI21_X1
* cell instance $6707 r0 *1 104.69,98
X$6707 6392 6609 6481 112 113 6587 MUX2_X1
* cell instance $6708 r0 *1 106.02,98
X$6708 6393 6239 112 113 6392 NOR2_X1
* cell instance $6710 r0 *1 106.78,98
X$6710 6394 6524 6609 113 112 6484 MUX2_X2
* cell instance $6711 m0 *1 107.35,98
X$6711 6238 6239 112 113 6481 NOR2_X1
* cell instance $6712 m0 *1 106.78,98
X$6712 6238 6395 112 113 6394 NAND2_X1
* cell instance $6715 r0 *1 108.49,98
X$6715 129 3105 6612 112 113 6525 MUX2_X1
* cell instance $6716 m0 *1 109.25,98
X$6716 6486 6244 112 113 6361 NOR2_X1
* cell instance $6721 m0 *1 111.15,98
X$6721 112 6240 5972 6487 5751 113 DFF_X1
* cell instance $6723 m0 *1 114.38,98
X$6723 4919 6396 112 113 6238 XNOR2_X2
* cell instance $6725 m0 *1 116.47,98
X$6725 6488 6241 6242 113 112 2788 MUX2_X2
* cell instance $6729 r0 *1 114.57,98
X$6729 6396 4919 113 6393 112 XOR2_X2
* cell instance $6731 r0 *1 117.04,98
X$6731 6616 6526 113 112 6488 AND2_X1
* cell instance $6732 r0 *1 117.8,98
X$6732 6213 6526 113 112 6528 XNOR2_X1
* cell instance $6734 m0 *1 118.56,98
X$6734 112 16810 6491 6489 6680 113 DFF_X1
* cell instance $6735 m0 *1 121.98,98
X$6735 6491 113 6396 112 BUF_X4
* cell instance $6738 r0 *1 119.7,98
X$6738 3573 6625 112 113 6526 XNOR2_X2
* cell instance $6740 r0 *1 123.12,98
X$6740 4817 6528 113 112 6623 XNOR2_X1
* cell instance $6741 m0 *1 125.4,98
X$6741 5794 112 113 6371 BUF_X1
* cell instance $6742 m0 *1 123.69,98
X$6742 6371 6073 113 172 112 XOR2_X2
* cell instance $6750 r0 *1 124.45,98
X$6750 112 17125 6628 6626 5919 113 DFF_X1
* cell instance $6751 r0 *1 127.68,98
X$6751 6628 112 113 4817 CLKBUF_X3
* cell instance $6757 r0 *1 130.53,98
X$6757 6397 6245 112 113 5587 XNOR2_X2
* cell instance $6758 m0 *1 131.48,98
X$6758 6245 5801 112 113 6374 XNOR2_X2
* cell instance $6759 m0 *1 130.91,98
X$6759 6397 112 113 5403 BUF_X1
* cell instance $6760 m0 *1 133.38,98
X$6760 6245 112 113 6532 BUF_X1
* cell instance $6761 m0 *1 133.95,98
X$6761 6107 3470 112 113 6373 XNOR2_X2
* cell instance $6762 m0 *1 135.85,98
X$6762 3470 112 113 6399 BUF_X1
* cell instance $6765 m0 *1 137.37,98
X$6765 5801 6064 6498 112 113 6501 NAND3_X1
* cell instance $6766 m0 *1 138.13,98
X$6766 5920 6501 6247 112 6499 113 AOI21_X1
* cell instance $6767 m0 *1 138.89,98
X$6767 5921 6500 6369 112 6400 113 AOI21_X1
* cell instance $6769 m0 *1 142.69,98
X$6769 6496 6497 6403 6494 112 113 6248 NAND4_X1
* cell instance $6770 m0 *1 143.64,98
X$6770 6495 6368 6156 113 6496 112 OAI21_X1
* cell instance $6771 m0 *1 144.4,98
X$6771 6139 6367 16543 113 112 6250 HA_X1
* cell instance $6772 m0 *1 146.3,98
X$6772 6250 6251 6144 113 6365 112 OAI21_X1
* cell instance $6774 m0 *1 147.25,98
X$6774 6265 6251 112 113 5980 NAND2_X1
* cell instance $6775 m0 *1 147.82,98
X$6775 6251 6144 6402 112 113 6490 NAND3_X1
* cell instance $6776 m0 *1 148.58,98
X$6776 6478 6490 6253 112 6252 113 AOI21_X1
* cell instance $6780 r0 *1 132.62,98
X$6780 6503 5166 112 113 6531 NOR2_X1
* cell instance $6781 r0 *1 133.19,98
X$6781 5757 5403 113 6533 112 XOR2_X2
* cell instance $6782 r0 *1 134.9,98
X$6782 6533 6399 113 6634 112 XOR2_X2
* cell instance $6783 r0 *1 136.61,98
X$6783 6399 112 113 6502 BUF_X2
* cell instance $6784 r0 *1 137.37,98
X$6784 5919 112 113 17206 INV_X1
* cell instance $6786 r0 *1 138.51,98
X$6786 4407 112 113 6534 INV_X1
* cell instance $6788 r0 *1 139.08,98
X$6788 6638 6499 6400 112 113 7211 OR3_X4
* cell instance $6791 r0 *1 142.31,98
X$6791 6639 6401 5979 112 113 6497 NAND3_X1
* cell instance $6794 r0 *1 143.64,98
X$6794 6152 6535 6401 113 6644 112 OAI21_X1
* cell instance $6796 r0 *1 144.59,98
X$6796 6493 6406 6644 112 113 6492 MUX2_X1
* cell instance $6799 r0 *1 146.87,98
X$6799 6144 112 113 6406 CLKBUF_X3
* cell instance $6801 r0 *1 148.2,98
X$6801 6360 5913 112 113 6253 NAND2_X1
* cell instance $6802 r0 *1 148.77,98
X$6802 6265 5981 6254 113 6540 112 OAI21_X1
* cell instance $6803 r0 *1 149.53,98
X$6803 6159 6541 6144 113 6790 112 OAI21_X1
* cell instance $6805 r0 *1 150.48,98
X$6805 6404 6152 6651 112 113 6652 MUX2_X1
* cell instance $6806 m0 *1 151.24,98
X$6806 5988 6405 112 113 6145 NAND2_X1
* cell instance $6807 m0 *1 150.48,98
X$6807 6199 6255 6360 112 6404 113 AOI21_X1
* cell instance $6809 r0 *1 151.81,98
X$6809 5988 6406 112 113 6655 NOR2_X1
* cell instance $6811 m0 *1 152.19,98
X$6811 6485 5848 112 113 6359 NOR2_X1
* cell instance $6814 r0 *1 152.95,98
X$6814 6146 6139 112 113 6542 NOR2_X1
* cell instance $6815 m0 *1 153.9,98
X$6815 6482 6094 6405 6350 6479 113 112 6358 OAI221_X1
* cell instance $6816 m0 *1 153.14,98
X$6816 5848 6483 6257 113 6357 112 OAI21_X1
* cell instance $6819 r0 *1 153.52,98
X$6819 6658 6201 112 113 6146 NOR2_X1
* cell instance $6822 r0 *1 155.04,98
X$6822 6360 6148 112 113 6543 NOR2_X1
* cell instance $6823 r0 *1 155.61,98
X$6823 6349 6360 6074 6407 6541 113 112 6477 OAI221_X1
* cell instance $6824 m0 *1 156.37,98
X$6824 6477 6476 6140 112 113 6354 NOR3_X1
* cell instance $6828 m0 *1 158.84,98
X$6828 6471 112 113 6349 INV_X8
* cell instance $6829 m0 *1 160.55,98
X$6829 6148 6251 6260 6255 6261 113 112 6263 OAI221_X1
* cell instance $6830 m0 *1 161.69,98
X$6830 6140 6263 6155 113 112 6408 AND3_X1
* cell instance $6831 m0 *1 162.64,98
X$6831 6081 112 113 6140 CLKBUF_X3
* cell instance $6832 m0 *1 163.59,98
X$6832 6348 6473 5848 112 113 6403 NAND3_X1
* cell instance $6833 m0 *1 164.35,98
X$6833 5991 6139 112 113 6266 NAND2_X1
* cell instance $6835 m0 *1 165.11,98
X$6835 6159 6255 16549 113 112 6262 HA_X1
* cell instance $6837 m0 *1 167.77,98
X$6837 6267 113 6471 112 BUF_X4
* cell instance $6838 m0 *1 169.1,98
X$6838 6367 6268 16552 113 112 6267 HA_X1
* cell instance $6839 m0 *1 171,98
X$6839 6470 6412 6254 113 6411 112 OAI21_X1
* cell instance $6840 m0 *1 171.76,98
X$6840 6405 6074 112 113 6630 NAND2_X1
* cell instance $6843 m0 *1 175.56,98
X$6843 6269 3874 6073 112 113 6343 NAND3_X1
* cell instance $6844 m0 *1 176.32,98
X$6844 5853 6270 113 112 6414 XNOR2_X1
* cell instance $6846 m0 *1 178.22,98
X$6846 6270 3874 5993 112 113 6340 NAND3_X1
* cell instance $6847 m0 *1 178.98,98
X$6847 6416 6270 112 113 6341 NAND2_X1
* cell instance $6848 m0 *1 179.55,98
X$6848 6416 6271 112 113 6417 NAND2_X1
* cell instance $6849 m0 *1 180.12,98
X$6849 6466 6417 6340 112 6160 113 AOI21_X1
* cell instance $6850 m0 *1 180.88,98
X$6850 5794 6272 113 112 6466 XNOR2_X1
* cell instance $6851 m0 *1 182.02,98
X$6851 6419 6272 112 113 6339 XOR2_X1
* cell instance $6854 r0 *1 156.94,98
X$6854 6265 6360 112 113 6544 NOR2_X1
* cell instance $6855 r0 *1 157.51,98
X$6855 6544 5987 5982 112 113 6659 NOR3_X1
* cell instance $6857 r0 *1 159.03,98
X$6857 6476 6654 6140 112 113 6475 NOR3_X1
* cell instance $6858 r0 *1 159.79,98
X$6858 6205 6261 6156 6541 6409 113 112 5990 OAI221_X1
* cell instance $6859 r0 *1 160.93,98
X$6859 6262 112 113 6647 BUF_X2
* cell instance $6860 r0 *1 161.69,98
X$6860 6475 6408 6650 113 6649 112 OAI21_X1
* cell instance $6861 r0 *1 162.45,98
X$6861 6254 6201 112 113 6645 OR2_X1
* cell instance $6862 r0 *1 163.21,98
X$6862 6265 112 113 6547 INV_X1
* cell instance $6863 r0 *1 163.59,98
X$6863 6152 6546 6548 6645 113 112 6472 OAI22_X1
* cell instance $6864 r0 *1 164.54,98
X$6864 6407 5981 6642 113 6345 112 OAI21_X1
* cell instance $6865 r0 *1 165.3,98
X$6865 5913 112 113 5848 CLKBUF_X3
* cell instance $6866 r0 *1 166.25,98
X$6866 6472 6094 7034 112 113 6633 MUX2_X1
* cell instance $6867 r0 *1 167.58,98
X$6867 6262 112 113 6407 INV_X4
* cell instance $6868 r0 *1 168.53,98
X$6868 6631 6257 6633 113 112 6550 OAI21_X2
* cell instance $6869 r0 *1 169.86,98
X$6869 6410 112 113 6251 CLKBUF_X3
* cell instance $6870 r0 *1 170.81,98
X$6870 6410 6409 112 113 6412 NOR2_X1
* cell instance $6871 r0 *1 171.38,98
X$6871 6159 6255 16629 113 112 6629 HA_X1
* cell instance $6874 r0 *1 175.18,98
X$6874 6413 6073 112 113 6551 NOR2_X1
* cell instance $6875 r0 *1 175.75,98
X$6875 6551 6162 112 113 6627 NAND2_X1
* cell instance $6876 r0 *1 176.32,98
X$6876 6414 6343 6627 112 6467 113 AOI21_X1
* cell instance $6877 r0 *1 177.08,98
X$6877 6621 6467 6415 112 113 4673 OR3_X2
* cell instance $6878 r0 *1 178.22,98
X$6878 6413 5993 112 113 6416 NOR2_X1
* cell instance $6884 r0 *1 182.59,98
X$6884 5794 112 113 6419 BUF_X1
* cell instance $6886 m0 *1 183.73,98
X$6886 6273 3442 112 113 6272 XNOR2_X2
* cell instance $6892 r0 *1 186.01,98
X$6892 6553 6274 113 112 5996 XNOR2_X1
* cell instance $6893 m0 *1 186.2,98
X$6893 3442 6163 112 113 6274 XNOR2_X2
* cell instance $6895 m0 *1 188.1,98
X$6895 6274 112 113 6420 BUF_X1
* cell instance $6900 r0 *1 187.53,98
X$6900 6420 6614 113 112 5304 XNOR2_X1
* cell instance $6901 r0 *1 188.67,98
X$6901 6421 6273 113 112 6614 XNOR2_X1
* cell instance $6902 r0 *1 189.81,98
X$6902 3442 4935 113 112 6554 XNOR2_X1
* cell instance $6903 r0 *1 190.95,98
X$6903 6422 6421 112 113 4935 XNOR2_X2
* cell instance $6904 m0 *1 191.52,98
X$6904 4674 6276 113 112 6336 XNOR2_X1
* cell instance $6907 m0 *1 192.85,98
X$6907 6424 6335 3784 113 112 4726 MUX2_X2
* cell instance $6909 m0 *1 196.08,98
X$6909 6422 6334 113 112 6465 XNOR2_X1
* cell instance $6910 m0 *1 197.22,98
X$6910 5049 6465 4508 113 112 6423 MUX2_X2
* cell instance $6912 m0 *1 199.69,98
X$6912 6424 4948 6017 112 113 6463 MUX2_X1
* cell instance $6915 m0 *1 201.97,98
X$6915 6462 112 113 5858 BUF_X2
* cell instance $6917 m0 *1 203.49,98
X$6917 112 16922 6462 5768 5558 113 DFF_X1
* cell instance $6918 m0 *1 206.72,98
X$6918 5572 6333 113 6460 112 XOR2_X2
* cell instance $6920 m0 *1 209.19,98
X$6920 6278 6330 5661 6053 112 113 6458 AOI22_X1
* cell instance $6924 r0 *1 193.8,98
X$6924 5309 6421 113 112 6610 XNOR2_X1
* cell instance $6928 r0 *1 197.6,98
X$6928 112 16951 6424 6463 5558 113 DFF_X1
* cell instance $6929 r0 *1 200.83,98
X$6929 401 112 113 5558 CLKBUF_X3
* cell instance $6930 r0 *1 201.78,98
X$6930 5558 112 113 17188 INV_X2
* cell instance $6933 r0 *1 204.25,98
X$6933 6421 6708 113 5197 112 XOR2_X2
* cell instance $6937 r0 *1 207.29,98
X$6937 5865 6166 5863 112 113 6558 MUX2_X1
* cell instance $6939 r0 *1 209,98
X$6939 5421 113 6278 112 BUF_X4
* cell instance $6940 r0 *1 210.33,98
X$6940 6458 6425 6456 112 113 6559 MUX2_X1
* cell instance $6942 m0 *1 210.52,98
X$6942 6426 5865 6004 112 113 6457 MUX2_X1
* cell instance $6943 m0 *1 212.04,98
X$6943 6278 6457 5873 5863 113 112 6456 OAI22_X1
* cell instance $6944 m0 *1 212.99,98
X$6944 6281 5780 6330 112 6452 113 AOI21_X1
* cell instance $6946 m0 *1 213.94,98
X$6946 5424 6329 6280 112 6326 113 AOI21_X1
* cell instance $6947 m0 *1 214.7,98
X$6947 6597 6326 6455 6282 6452 113 112 6312 OAI221_X1
* cell instance $6948 m0 *1 215.84,98
X$6948 6283 6324 6047 112 6428 113 AOI21_X1
* cell instance $6949 m0 *1 216.6,98
X$6949 5450 112 113 6595 BUF_X1
* cell instance $6950 m0 *1 217.17,98
X$6950 6170 6284 5564 6285 112 113 6324 AOI22_X1
* cell instance $6951 m0 *1 218.12,98
X$6951 6278 5661 112 6311 113 NAND2_X4
* cell instance $6953 m0 *1 220.02,98
X$6953 5658 6430 6287 113 6168 112 OAI21_X1
* cell instance $6954 m0 *1 220.78,98
X$6954 6431 6315 6432 6283 6036 113 112 6433 OAI221_X1
* cell instance $6956 m0 *1 222.11,98
X$6956 6277 5781 112 113 6007 NAND2_X1
* cell instance $6957 m0 *1 222.68,98
X$6957 5999 5875 5661 112 113 6434 NAND3_X2
* cell instance $6958 m0 *1 224.01,98
X$6958 6426 5999 5875 112 6589 113 AOI21_X2
* cell instance $6961 r0 *1 211.66,98
X$6961 5657 112 113 6426 INV_X2
* cell instance $6963 r0 *1 212.42,98
X$6963 5867 5656 112 113 6427 NAND2_X1
* cell instance $6964 r0 *1 212.99,98
X$6964 5569 112 113 6293 CLKBUF_X3
* cell instance $6965 r0 *1 213.94,98
X$6965 6425 5876 6279 112 6455 113 AOI21_X1
* cell instance $6966 r0 *1 214.7,98
X$6966 112 6453 6595 5999 5875 113 AOI21_X4
* cell instance $6968 r0 *1 217.36,98
X$6968 5427 5863 6434 113 6284 112 OAI21_X1
* cell instance $6969 r0 *1 218.12,98
X$6969 6278 112 113 6280 CLKBUF_X3
* cell instance $6971 r0 *1 219.45,98
X$6971 6429 5564 112 113 6592 NOR2_X1
* cell instance $6973 r0 *1 220.21,98
X$6973 6592 6427 6293 113 6431 112 OAI21_X1
* cell instance $6974 r0 *1 220.97,98
X$6974 5999 5875 6004 112 113 6440 NAND3_X2
* cell instance $6977 r0 *1 222.87,98
X$6977 5999 5875 5769 112 113 6591 NAND3_X2
* cell instance $6978 r0 *1 224.2,98
X$6978 5871 5877 6589 113 112 6027 OAI21_X2
* cell instance $6980 r0 *1 225.72,98
X$6980 5875 5873 5999 112 6715 113 NAND3_X4
* cell instance $6982 m0 *1 226.48,98
X$6982 5999 5875 5878 5565 112 113 6441 NAND4_X1
* cell instance $6983 m0 *1 229.14,98
X$6983 5770 6003 112 113 6291 NAND2_X1
* cell instance $6984 m0 *1 227.81,98
X$6984 6331 6312 6290 6178 113 112 6565 AND4_X2
* cell instance $6986 m0 *1 229.9,98
X$6986 6293 113 6283 112 BUF_X4
* cell instance $6989 r0 *1 228.19,98
X$6989 6291 6311 6293 6561 6436 113 112 6566 OAI221_X1
* cell instance $6990 r0 *1 229.33,98
X$6990 6432 6566 6307 112 6585 113 AOI21_X1
* cell instance $6992 r0 *1 230.28,98
X$6992 6011 6436 6441 113 6577 112 OAI21_X1
* cell instance $6993 r0 *1 231.04,98
X$6993 5870 6440 113 112 6575 AND2_X1
* cell instance $6994 r0 *1 231.8,98
X$6994 5878 6426 112 113 6567 NOR2_X1
* cell instance $6995 m0 *1 232.56,98
X$6995 6280 5771 112 113 6571 NOR2_X1
* cell instance $6997 m0 *1 233.13,98
X$6997 6438 112 113 6017 BUF_X1
* cell instance $7000 m0 *1 235.98,98
X$7000 112 16835 6294 6275 5429 113 DFF_X1
* cell instance $7001 m0 *1 239.21,98
X$7001 6845 112 113 6439 BUF_X1
* cell instance $7003 r0 *1 232.37,98
X$7003 6567 6571 6429 113 6573 112 OAI21_X1
* cell instance $7005 r0 *1 233.51,98
X$7005 5446 113 6429 112 BUF_X4
* cell instance $7006 r0 *1 234.84,98
X$7006 112 16977 6568 6177 6437 113 DFF_X1
* cell instance $7010 r0 *1 238.07,98
X$7010 6568 112 113 6296 BUF_X1
* cell instance $7015 m0 *1 204.06,184.8
X$7015 13709 13776 112 113 13773 NOR2_X1
* cell instance $7016 m0 *1 205.39,184.8
X$7016 13772 13781 13838 13775 113 13774 112 NOR4_X2
* cell instance $7017 m0 *1 207.1,184.8
X$7017 13778 13709 112 113 13775 NOR2_X2
* cell instance $7018 m0 *1 208.05,184.8
X$7018 13707 13712 112 113 13705 NOR2_X1
* cell instance $7020 r0 *1 204.06,184.8
X$7020 13708 13928 13773 113 13858 112 OAI21_X1
* cell instance $7022 r0 *1 205.58,184.8
X$7022 13774 13853 13988 13855 113 13532 112 NOR4_X2
* cell instance $7023 r0 *1 207.29,184.8
X$7023 13839 13776 112 113 13852 NOR2_X1
* cell instance $7024 r0 *1 207.86,184.8
X$7024 13835 13837 112 113 13840 NOR2_X1
* cell instance $7026 r0 *1 208.81,184.8
X$7026 13840 13710 13912 112 113 13913 NOR3_X1
* cell instance $7027 m0 *1 209.19,184.8
X$7027 13779 13710 13776 113 13777 112 OAI21_X1
* cell instance $7038 r0 *1 209.57,184.8
X$7038 13777 13851 13923 13841 13914 13847 112 113 13221 OAI33_X1
* cell instance $7041 r0 *1 211.85,184.8
X$7041 13843 13845 13712 113 13847 112 OAI21_X1
* cell instance $7042 r0 *1 212.61,184.8
X$7042 13921 13916 13844 112 13845 113 AOI21_X1
* cell instance $7043 r0 *1 213.37,184.8
X$7043 14037 13915 13797 112 113 13844 MUX2_X1
* cell instance $7044 r0 *1 214.7,184.8
X$7044 13842 13706 13839 112 113 13843 NAND3_X1
* cell instance $7054 m0 *1 94.43,170.8
X$7054 12966 11070 12133 112 113 13026 NOR3_X1
* cell instance $7055 m0 *1 95.95,170.8
X$7055 12934 12133 12936 112 113 12968 MUX2_X1
* cell instance $7057 r0 *1 94.43,170.8
X$7057 12749 11583 13074 112 13077 113 AOI21_X1
* cell instance $7060 r0 *1 96.14,170.8
X$7060 13026 11583 13070 112 13028 113 AOI21_X1
* cell instance $7061 r0 *1 96.9,170.8
X$7061 12477 13027 13138 113 13139 112 OAI21_X1
* cell instance $7062 m0 *1 97.85,170.8
X$7062 12751 12273 12037 112 113 13027 MUX2_X1
* cell instance $7066 r0 *1 97.66,170.8
X$7066 12968 11732 13028 112 113 13141 MUX2_X1
* cell instance $7068 m0 *1 100.51,170.8
X$7068 12867 12413 12938 112 113 12939 MUX2_X1
* cell instance $7075 r0 *1 103.55,170.8
X$7075 12939 9307 13029 112 113 13038 MUX2_X1
* cell instance $7080 r0 *1 110.39,170.8
X$7080 10662 12762 16710 113 112 13078 HA_X1
* cell instance $7081 m0 *1 110.77,170.8
X$7081 10662 10470 10198 112 113 12868 MUX2_X1
* cell instance $7083 m0 *1 112.1,170.8
X$7083 13079 10788 12868 112 12480 113 AOI21_X1
* cell instance $7085 m0 *1 113.05,170.8
X$7085 12756 13165 10788 112 11853 113 AOI21_X1
* cell instance $7087 r0 *1 112.29,170.8
X$7087 10342 113 10068 112 BUF_X4
* cell instance $7088 r0 *1 113.62,170.8
X$7088 10439 112 113 10788 CLKBUF_X3
* cell instance $7090 m0 *1 114.19,170.8
X$7090 12871 11110 12870 112 11586 113 AOI21_X1
* cell instance $7091 m0 *1 116.47,170.8
X$7091 10822 113 10696 112 BUF_X4
* cell instance $7095 r0 *1 115.14,170.8
X$7095 11270 13031 13080 13033 10072 12753 112 113 OAI221_X2
* cell instance $7096 r0 *1 117.23,170.8
X$7096 10788 13081 11270 113 13033 112 OAI21_X1
* cell instance $7099 m0 *1 118.18,170.8
X$7099 12483 10702 12941 112 113 12969 MUX2_X1
* cell instance $7103 r0 *1 119.32,170.8
X$7103 12969 9966 13034 112 113 13031 MUX2_X1
* cell instance $7104 m0 *1 121.79,170.8
X$7104 9733 10701 10822 112 113 12942 MUX2_X1
* cell instance $7105 m0 *1 120.65,170.8
X$7105 12448 9830 12759 12942 10441 112 113 13034 AOI221_X1
* cell instance $7106 m0 *1 123.12,170.8
X$7106 9982 11555 16500 113 112 10343 HA_X1
* cell instance $7107 m0 *1 125.02,170.8
X$7107 9940 113 10702 112 BUF_X4
* cell instance $7111 r0 *1 121.22,170.8
X$7111 13036 13035 13144 11270 112 113 12009 NOR4_X1
* cell instance $7113 r0 *1 122.36,170.8
X$7113 10441 13145 13310 112 13036 113 AOI21_X1
* cell instance $7114 r0 *1 123.12,170.8
X$7114 112 12760 10701 113 INV_X16
* cell instance $7118 r0 *1 126.35,170.8
X$7118 11266 11001 10098 112 113 13082 MUX2_X1
* cell instance $7119 m0 *1 128.82,170.8
X$7119 11001 10343 112 113 13037 NAND2_X1
* cell instance $7120 m0 *1 126.73,170.8
X$7120 12761 13037 11390 13147 9974 12846 113 112 AOI221_X2
* cell instance $7122 m0 *1 129.58,170.8
X$7122 11390 113 10822 112 BUF_X4
* cell instance $7123 m0 *1 130.91,170.8
X$7123 10349 113 10198 112 BUF_X4
* cell instance $7124 m0 *1 132.24,170.8
X$7124 9733 113 10349 112 BUF_X4
* cell instance $7125 m0 *1 133.57,170.8
X$7125 11001 113 9940 112 BUF_X4
* cell instance $7126 m0 *1 134.9,170.8
X$7126 12763 113 12051 112 BUF_X4
* cell instance $7127 m0 *1 136.23,170.8
X$7127 112 10098 10662 113 BUF_X32
* cell instance $7128 m0 *1 145.54,170.8
X$7128 13043 112 113 9300 CLKBUF_X3
* cell instance $7130 m0 *1 148.01,170.8
X$7130 10299 112 113 11904 CLKBUF_X3
* cell instance $7132 m0 *1 149.15,170.8
X$7132 112 16917 13043 13047 11904 113 DFF_X1
* cell instance $7134 m0 *1 152.57,170.8
X$7134 12872 11004 112 113 13050 NOR2_X1
* cell instance $7135 m0 *1 153.14,170.8
X$7135 11600 12551 12771 113 12872 112 OAI21_X1
* cell instance $7136 m0 *1 153.9,170.8
X$7136 13050 12222 112 113 12945 NOR2_X1
* cell instance $7137 m0 *1 154.47,170.8
X$7137 12946 12873 12614 13051 113 112 13047 OAI22_X1
* cell instance $7139 m0 *1 155.61,170.8
X$7139 12945 12943 11003 10835 12552 112 113 13051 AOI221_X1
* cell instance $7141 m0 *1 156.94,170.8
X$7141 12874 11911 11008 11537 12492 113 112 12943 OAI221_X1
* cell instance $7143 m0 *1 158.27,170.8
X$7143 10951 12971 112 113 12873 NAND2_X1
* cell instance $7144 m0 *1 158.84,170.8
X$7144 12973 11908 112 113 13058 NAND2_X1
* cell instance $7148 r0 *1 127.87,170.8
X$7148 11592 9827 12607 11753 12487 113 112 AOI211_X2
* cell instance $7152 r0 *1 130.34,170.8
X$7152 9940 113 10342 112 BUF_X4
* cell instance $7153 r0 *1 131.67,170.8
X$7153 9827 113 11110 112 BUF_X4
* cell instance $7156 r0 *1 134.9,170.8
X$7156 112 13038 13083 11554 9605 113 DFF_X2
* cell instance $7157 r0 *1 138.51,170.8
X$7157 9605 112 113 13084 BUF_X1
* cell instance $7159 r0 *1 139.84,170.8
X$7159 10709 10844 112 113 13149 XNOR2_X2
* cell instance $7163 r0 *1 144.4,170.8
X$7163 112 17022 13046 13169 11904 113 DFF_X1
* cell instance $7164 r0 *1 147.63,170.8
X$7164 13046 113 10844 112 BUF_X4
* cell instance $7169 r0 *1 153.33,170.8
X$7169 13148 12947 112 113 13052 NAND2_X1
* cell instance $7171 r0 *1 154.28,170.8
X$7171 12835 11911 12619 113 13085 112 OAI21_X1
* cell instance $7172 r0 *1 155.04,170.8
X$7172 13086 12970 13052 113 13054 112 NOR3_X2
* cell instance $7173 r0 *1 156.37,170.8
X$7173 13054 13053 13055 113 13044 112 NOR3_X2
* cell instance $7174 r0 *1 157.7,170.8
X$7174 13146 13058 10833 113 12970 112 OAI21_X1
* cell instance $7175 r0 *1 158.46,170.8
X$7175 11762 12625 113 112 13059 AND2_X1
* cell instance $7176 r0 *1 159.22,170.8
X$7176 12972 13059 11281 113 12726 112 OAI21_X1
* cell instance $7177 r0 *1 159.98,170.8
X$7177 11442 12062 12972 112 113 13088 NOR3_X1
* cell instance $7178 m0 *1 160.74,170.8
X$7178 11921 11684 112 113 11911 NOR2_X1
* cell instance $7181 m0 *1 161.5,170.8
X$7181 12627 12070 11536 12712 12619 11281 112 113 12974 OAI33_X1
* cell instance $7183 m0 *1 163.02,170.8
X$7183 12063 11444 11549 12831 113 112 12975 OAI22_X1
* cell instance $7184 m0 *1 163.97,170.8
X$7184 13057 11072 10835 12495 12821 113 112 13056 OAI221_X1
* cell instance $7186 m0 *1 165.87,170.8
X$7186 11523 12933 112 12493 113 NAND2_X4
* cell instance $7187 m0 *1 167.58,170.8
X$7187 12722 12335 112 113 13049 NAND2_X1
* cell instance $7189 m0 *1 168.34,170.8
X$7189 11770 12337 12286 112 13048 113 AOI21_X1
* cell instance $7191 m0 *1 169.29,170.8
X$7191 12879 12880 11914 112 113 13045 NOR3_X1
* cell instance $7192 m0 *1 170.05,170.8
X$7192 11281 12973 12878 112 12821 113 AOI21_X2
* cell instance $7194 m0 *1 171.57,170.8
X$7194 11912 12879 112 113 12932 NOR2_X2
* cell instance $7198 r0 *1 161.31,170.8
X$7198 11005 13089 13056 112 13053 113 AOI21_X1
* cell instance $7199 r0 *1 162.07,170.8
X$7199 11762 11855 112 113 12973 OR2_X1
* cell instance $7200 r0 *1 162.83,170.8
X$7200 12340 11526 12625 112 113 13091 NAND3_X1
* cell instance $7202 r0 *1 164.35,170.8
X$7202 11762 11607 11912 11602 12976 112 113 13057 AOI221_X1
* cell instance $7205 r0 *1 166.44,170.8
X$7205 11123 13041 13049 112 13140 113 AOI21_X1
* cell instance $7206 r0 *1 167.2,170.8
X$7206 13237 13140 12935 13137 13048 12946 113 112 AOI221_X2
* cell instance $7207 r0 *1 169.29,170.8
X$7207 13045 12447 12768 112 13137 113 AOI21_X1
* cell instance $7209 r0 *1 170.24,170.8
X$7209 11601 13092 12349 13042 11607 13041 113 112 AOI221_X2
* cell instance $7210 r0 *1 172.33,170.8
X$7210 12219 12933 12972 112 113 NOR2_X4
* cell instance $7211 m0 *1 174.99,170.8
X$7211 112 12880 12063 11780 11784 113 AOI21_X4
* cell instance $7212 m0 *1 172.9,170.8
X$7212 11444 12712 11600 12932 12928 12931 112 113 OAI221_X2
* cell instance $7213 m0 *1 177.46,170.8
X$7213 12431 11289 12881 112 11369 113 AOI21_X1
* cell instance $7214 m0 *1 178.22,170.8
X$7214 12770 10836 112 113 12928 NOR2_X1
* cell instance $7215 m0 *1 178.79,170.8
X$7215 11126 11778 11445 112 12978 113 AOI21_X1
* cell instance $7216 m0 *1 179.55,170.8
X$7216 10949 12927 12501 113 11530 112 OAI21_X1
* cell instance $7217 m0 *1 180.31,170.8
X$7217 11837 12150 11445 112 13030 113 AOI21_X1
* cell instance $7218 m0 *1 181.07,170.8
X$7218 12923 12979 12222 112 113 12416 NOR3_X1
* cell instance $7220 r0 *1 174.04,170.8
X$7220 13032 13040 12931 113 112 13094 AND3_X2
* cell instance $7221 r0 *1 175.18,170.8
X$7221 13095 11292 11004 113 13040 112 OAI21_X1
* cell instance $7223 r0 *1 176.32,170.8
X$7223 12927 13096 13097 11768 112 113 12977 NOR4_X1
* cell instance $7224 r0 *1 177.27,170.8
X$7224 11522 12501 11448 11842 112 113 13098 AOI22_X1
* cell instance $7225 r0 *1 178.22,170.8
X$7225 12345 11012 11670 113 13100 112 OAI21_X1
* cell instance $7226 r0 *1 178.98,170.8
X$7226 13097 13100 10713 12711 11601 13032 113 112 AOI221_X2
* cell instance $7230 r0 *1 181.07,170.8
X$7230 11610 12711 11012 112 12707 113 AOI21_X2
* cell instance $7231 m0 *1 183.35,170.8
X$7231 112 11294 11991 11453 12879 113 NOR3_X4
* cell instance $7232 m0 *1 182.21,170.8
X$7232 11919 11610 11523 12345 12627 112 113 12980 AOI221_X1
* cell instance $7233 m0 *1 186.01,170.8
X$7233 112 13270 11294 11453 12502 113 NOR3_X4
* cell instance $7234 m0 *1 188.67,170.8
X$7234 11977 112 113 11991 INV_X8
* cell instance $7236 m0 *1 191.14,170.8
X$7236 10000 10844 113 12893 112 XOR2_X2
* cell instance $7239 m0 *1 193.8,170.8
X$7239 112 16817 12921 13220 13184 113 DFF_X1
* cell instance $7240 m0 *1 197.03,170.8
X$7240 13102 112 113 5321 CLKBUF_X3
* cell instance $7243 r0 *1 182.4,170.8
X$7243 12879 12547 10949 112 113 13269 NOR3_X1
* cell instance $7244 r0 *1 183.16,170.8
X$7244 112 11450 11537 113 BUF_X16
* cell instance $7246 r0 *1 188.67,170.8
X$7246 112 12345 12711 113 BUF_X16
* cell instance $7251 r0 *1 199.12,170.8
X$7251 11656 11172 12919 113 13025 112 NOR3_X2
* cell instance $7252 m0 *1 201.21,170.8
X$7252 112 12919 11330 11785 11786 113 AOI21_X4
* cell instance $7253 m0 *1 199.88,170.8
X$7253 12228 113 12239 112 BUF_X4
* cell instance $7255 m0 *1 204.44,170.8
X$7255 11347 12533 12773 113 112 11461 OAI21_X4
* cell instance $7256 m0 *1 206.91,170.8
X$7256 12687 11656 12917 112 113 11020 MUX2_X1
* cell instance $7257 m0 *1 208.24,170.8
X$7257 11053 11461 11021 112 113 12981 NAND3_X2
* cell instance $7258 m0 *1 209.57,170.8
X$7258 12245 112 113 12917 BUF_X1
* cell instance $7259 m0 *1 210.14,170.8
X$7259 112 12533 12773 13017 12631 113 NOR3_X4
* cell instance $7260 m0 *1 212.8,170.8
X$7260 11623 13126 10006 10864 12911 12910 113 112 AOI221_X2
* cell instance $7262 r0 *1 200.45,170.8
X$7262 12350 11460 113 112 13024 XNOR2_X1
* cell instance $7263 r0 *1 201.59,170.8
X$7263 13025 10006 12266 13024 13122 113 112 AOI211_X2
* cell instance $7264 r0 *1 203.3,170.8
X$7264 12266 11147 12533 12773 10884 12983 112 113 OAI221_X2
* cell instance $7267 r0 *1 205.96,170.8
X$7267 13103 112 113 13022 BUF_X1
* cell instance $7268 r0 *1 206.53,170.8
X$7268 11786 13022 11785 112 10910 113 NAND3_X4
* cell instance $7270 r0 *1 209.19,170.8
X$7270 12683 13021 13019 113 13121 112 OAI21_X1
* cell instance $7272 r0 *1 210.14,170.8
X$7272 112 13104 13016 11785 11786 113 AOI21_X4
* cell instance $7273 r0 *1 212.61,170.8
X$7273 10638 10885 112 113 13019 NAND2_X1
* cell instance $7274 r0 *1 213.18,170.8
X$7274 13104 113 12356 112 BUF_X4
* cell instance $7275 r0 *1 214.51,170.8
X$7275 13125 112 113 13017 BUF_X2
* cell instance $7276 m0 *1 216.03,170.8
X$7276 13014 12910 10610 112 113 13011 NOR3_X1
* cell instance $7277 m0 *1 215.27,170.8
X$7277 12982 12882 10593 113 12884 112 OAI21_X1
* cell instance $7278 m0 *1 216.79,170.8
X$7278 10884 11021 112 113 12882 NOR2_X1
* cell instance $7279 m0 *1 217.36,170.8
X$7279 10625 13011 13186 113 12907 112 NOR3_X2
* cell instance $7280 m0 *1 218.69,170.8
X$7280 12778 10508 12907 13007 12986 10028 113 112 AOI221_X2
* cell instance $7282 m0 *1 220.97,170.8
X$7282 10727 12805 10607 12905 12781 12897 113 112 AOI221_X2
* cell instance $7284 m0 *1 223.25,170.8
X$7284 10607 12903 12987 12636 113 112 12901 AND4_X1
* cell instance $7285 m0 *1 224.39,170.8
X$7285 10608 12901 13205 112 13007 113 AOI21_X1
* cell instance $7287 r0 *1 215.27,170.8
X$7287 13016 112 113 11958 BUF_X2
* cell instance $7288 r0 *1 216.03,170.8
X$7288 11144 12984 11303 112 13123 113 AOI21_X1
* cell instance $7289 r0 *1 216.79,170.8
X$7289 10859 13015 12983 112 13014 113 AOI21_X1
* cell instance $7291 r0 *1 217.74,170.8
X$7291 11461 12985 112 113 11154 NOR2_X2
* cell instance $7292 r0 *1 218.69,170.8
X$7292 12985 113 10885 112 BUF_X4
* cell instance $7293 r0 *1 220.02,170.8
X$7293 12884 13008 112 12905 113 OR2_X4
* cell instance $7294 r0 *1 221.73,170.8
X$7294 11144 10885 10626 112 13119 113 AOI21_X1
* cell instance $7295 r0 *1 222.49,170.8
X$7295 11335 11793 13106 11022 11308 113 112 12987 OAI221_X1
* cell instance $7296 r0 *1 223.63,170.8
X$7296 11302 112 113 11032 CLKBUF_X3
* cell instance $7297 r0 *1 224.58,170.8
X$7297 11032 112 113 11310 CLKBUF_X3
* cell instance $7298 r0 *1 225.53,170.8
X$7298 12988 13108 10737 10372 12782 12360 113 112 AOI221_X2
* cell instance $7299 m0 *1 226.1,170.8
X$7299 10626 11313 11338 112 113 12885 NOR3_X1
* cell instance $7300 m0 *1 225.53,170.8
X$7300 10910 11631 112 113 12782 NAND2_X1
* cell instance $7301 m0 *1 226.86,170.8
X$7301 12998 12775 12885 10860 12888 12994 113 112 AOI221_X2
* cell instance $7303 r0 *1 227.62,170.8
X$7303 12984 11314 10492 12253 11308 113 112 13110 OAI221_X1
* cell instance $7304 r0 *1 228.76,170.8
X$7304 10883 11038 112 113 13199 NAND2_X2
* cell instance $7306 m0 *1 229.33,170.8
X$7306 11794 12886 13115 11963 112 113 12887 AOI22_X1
* cell instance $7307 r0 *1 229.71,170.8
X$7307 12237 11021 112 113 12998 NOR2_X1
* cell instance $7308 r0 *1 230.28,170.8
X$7308 13116 11794 13192 113 112 13113 OAI21_X2
* cell instance $7309 m0 *1 230.85,170.8
X$7309 12898 12887 12897 12989 113 112 10611 OAI22_X2
* cell instance $7311 m0 *1 232.56,170.8
X$7311 11310 11043 11638 11461 113 112 12895 OAI22_X1
* cell instance $7312 m0 *1 233.51,170.8
X$7312 10599 11043 12889 113 12997 112 OAI21_X1
* cell instance $7313 m0 *1 234.27,170.8
X$7313 12994 12889 12787 112 113 12990 NAND3_X1
* cell instance $7314 m0 *1 235.03,170.8
X$7314 12894 112 113 13111 INV_X1
* cell instance $7317 r0 *1 231.61,170.8
X$7317 12984 11308 10610 12510 11461 113 112 13109 OAI221_X1
* cell instance $7318 r0 *1 232.75,170.8
X$7318 11335 10885 10626 112 12888 113 AOI21_X1
* cell instance $7319 r0 *1 233.51,170.8
X$7319 12086 10910 11631 112 12993 113 AOI21_X1
* cell instance $7320 r0 *1 234.27,170.8
X$7320 13110 12102 12895 112 12996 113 AOI21_X1
* cell instance $7321 r0 *1 235.03,170.8
X$7321 12993 13109 12894 113 13195 112 OAI21_X1
* cell instance $7322 r0 *1 235.79,170.8
X$7322 10859 10489 112 113 12894 NOR2_X1
* cell instance $7327 m0 *1 236.74,170.8
X$7327 10299 112 113 12247 CLKBUF_X3
* cell instance $7329 m0 *1 237.69,170.8
X$7329 12891 112 113 12892 BUF_X1
* cell instance $7330 m0 *1 238.26,170.8
X$7330 12247 112 113 17199 INV_X1
* cell instance $7332 r0 *1 236.55,170.8
X$7332 112 17138 12991 12893 12247 113 DFF_X1
* cell instance $7333 m0 *1 239.21,170.8
X$7333 12991 112 113 12890 BUF_X1
* cell instance $7338 m0 *1 201.59,212.8
X$7338 15763 14037 15674 112 113 15035 MUX2_X1
* cell instance $7339 m0 *1 203.68,212.8
X$7339 15783 15764 13785 15857 15785 13853 113 112 AOI221_X2
* cell instance $7342 r0 *1 201.59,212.8
X$7342 14314 113 14433 112 BUF_X4
* cell instance $7345 r0 *1 203.87,212.8
X$7345 15570 15847 13707 113 15916 112 OAI21_X1
* cell instance $7346 r0 *1 204.63,212.8
X$7346 15916 14548 15856 112 15857 113 AOI21_X1
* cell instance $7347 r0 *1 205.39,212.8
X$7347 14750 14833 15847 113 15915 112 OAI21_X1
* cell instance $7348 r0 *1 206.15,212.8
X$7348 14209 15847 15853 113 15856 112 OAI21_X1
* cell instance $7349 r0 *1 206.91,212.8
X$7349 14245 13702 14573 113 15853 112 OAI21_X1
* cell instance $7350 m0 *1 207.1,212.8
X$7350 15267 14780 14544 14531 14029 15851 113 112 AOI221_X2
* cell instance $7352 m0 *1 209.19,212.8
X$7352 13837 14779 15679 113 15766 112 OAI21_X1
* cell instance $7353 m0 *1 209.95,212.8
X$7353 14649 14108 112 113 15679 NAND2_X1
* cell instance $7357 r0 *1 209.95,212.8
X$7357 14551 112 113 15852 INV_X1
* cell instance $7358 r0 *1 210.33,212.8
X$7358 15852 13975 14128 113 15912 112 OAI21_X1
* cell instance $7359 m0 *1 213.37,212.8
X$7359 13706 15850 15771 113 112 15490 OAI21_X4
* cell instance $7360 m0 *1 210.9,212.8
X$7360 112 15769 15768 13925 15767 15771 113 AND4_X4
* cell instance $7361 m0 *1 215.84,212.8
X$7361 14544 112 113 14037 CLKBUF_X3
* cell instance $7363 m0 *1 216.98,212.8
X$7363 14539 113 13975 112 BUF_X4
* cell instance $7370 r0 *1 211.09,212.8
X$7370 13911 15912 15851 113 112 15850 OAI21_X2
* cell instance $7371 r0 *1 212.42,212.8
X$7371 13915 13916 16680 113 112 15848 HA_X1
* cell instance $7372 r0 *1 214.32,212.8
X$7372 15165 14833 13984 15265 113 112 15683 OAI22_X1
* cell instance $7373 r0 *1 215.27,212.8
X$7373 15165 14209 15266 112 15849 113 AOI21_X1
* cell instance $7374 r0 *1 216.03,212.8
X$7374 15911 13975 13911 113 14929 112 OAI21_X1
* cell instance $7375 r0 *1 216.79,212.8
X$7375 14311 14353 112 113 15686 NAND2_X1
* cell instance $7376 r0 *1 217.36,212.8
X$7376 14353 112 113 14212 BUF_X1
* cell instance $7390 m0 *1 11.21,137.2
X$7390 9776 112 113 9612 BUF_X1
* cell instance $7394 m0 *1 16.53,137.2
X$7394 9610 112 113 9625 BUF_X1
* cell instance $7400 r0 *1 10.26,137.2
X$7400 9710 112 113 9781 BUF_X2
* cell instance $7408 r0 *1 13.87,137.2
X$7408 9859 112 113 9775 BUF_X1
* cell instance $7411 r0 *1 16.15,137.2
X$7411 112 16954 9776 9774 8903 113 DFF_X1
* cell instance $7412 r0 *1 19.38,137.2
X$7412 112 16944 9906 9717 8903 113 DFF_X1
* cell instance $7415 m0 *1 28.12,137.2
X$7415 8176 6901 16513 113 112 8844 HA_X1
* cell instance $7419 r0 *1 30.4,137.2
X$7419 9399 112 113 17187 INV_X2
* cell instance $7420 r0 *1 30.97,137.2
X$7420 6050 112 113 9399 CLKBUF_X3
* cell instance $7423 m0 *1 31.92,137.2
X$7423 8554 7002 9664 113 112 9668 HA_X1
* cell instance $7425 r0 *1 32.11,137.2
X$7425 8176 7002 16677 113 112 9133 HA_X1
* cell instance $7426 r0 *1 34.01,137.2
X$7426 8554 6901 16609 113 112 9486 HA_X1
* cell instance $7428 m0 *1 34.96,137.2
X$7428 7628 112 113 8014 CLKBUF_X3
* cell instance $7429 m0 *1 37.43,137.2
X$7429 8016 8553 8554 112 113 9711 NAND3_X1
* cell instance $7430 m0 *1 38.19,137.2
X$7430 9712 8807 9188 9782 112 9677 113 NAND4_X2
* cell instance $7434 r0 *1 37.81,137.2
X$7434 7306 9670 9711 112 9713 113 AOI21_X1
* cell instance $7435 r0 *1 38.57,137.2
X$7435 9783 9713 9614 113 9712 112 OAI21_X1
* cell instance $7436 r0 *1 39.33,137.2
X$7436 7293 7572 112 113 9714 OR2_X1
* cell instance $7438 m0 *1 40.47,137.2
X$7438 9714 7710 8014 8176 9487 113 112 9783 OAI221_X1
* cell instance $7441 m0 *1 42.37,137.2
X$7441 7293 8757 9551 112 113 9785 MUX2_X1
* cell instance $7442 m0 *1 43.7,137.2
X$7442 9674 9715 8014 112 113 9262 NOR3_X1
* cell instance $7443 m0 *1 44.46,137.2
X$7443 9488 9615 9407 9786 112 113 9782 NAND4_X1
* cell instance $7446 r0 *1 40.85,137.2
X$7446 8176 6901 16621 113 112 9073 HA_X1
* cell instance $7448 r0 *1 43.51,137.2
X$7448 9785 8553 112 113 9715 NOR2_X1
* cell instance $7451 r0 *1 46.36,137.2
X$7451 8554 6901 16691 113 112 9489 HA_X1
* cell instance $7453 m0 *1 47.31,137.2
X$7453 9616 9787 8014 8176 9617 113 112 9786 OAI221_X1
* cell instance $7454 m0 *1 49.21,137.2
X$7454 8176 7002 16553 113 112 9618 HA_X1
* cell instance $7460 r0 *1 51.87,137.2
X$7460 9865 112 113 10400 BUF_X1
* cell instance $7462 m0 *1 52.25,137.2
X$7462 7882 9618 112 113 9789 NAND2_X1
* cell instance $7465 m0 *1 55.29,137.2
X$7465 9619 7628 9620 113 9197 112 NOR3_X2
* cell instance $7467 m0 *1 57.38,137.2
X$7467 112 16778 9795 9677 9201 113 DFF_X1
* cell instance $7469 m0 *1 61.37,137.2
X$7469 9564 9683 113 112 9681 XNOR2_X1
* cell instance $7470 m0 *1 62.51,137.2
X$7470 9490 9564 9683 112 9793 113 AOI21_X1
* cell instance $7471 m0 *1 63.27,137.2
X$7471 9795 113 9729 112 BUF_X4
* cell instance $7476 r0 *1 54.53,137.2
X$7476 112 16996 9790 9040 9201 113 DFF_X1
* cell instance $7478 r0 *1 57.95,137.2
X$7478 9790 113 9703 112 BUF_X4
* cell instance $7482 r0 *1 61.94,137.2
X$7482 9474 9909 9564 112 113 9794 NOR3_X1
* cell instance $7483 r0 *1 62.7,137.2
X$7483 3639 9794 9277 112 9718 113 AOI21_X1
* cell instance $7485 r0 *1 63.84,137.2
X$7485 8199 9716 113 112 9910 XNOR2_X1
* cell instance $7487 m0 *1 64.98,137.2
X$7487 8199 112 113 9564 INV_X2
* cell instance $7488 m0 *1 66.31,137.2
X$7488 9716 3327 112 113 9797 NOR2_X1
* cell instance $7489 m0 *1 66.88,137.2
X$7489 9716 3327 9564 112 113 9799 NOR3_X1
* cell instance $7491 m0 *1 67.83,137.2
X$7491 9797 8199 112 113 9798 NOR2_X1
* cell instance $7493 m0 *1 68.59,137.2
X$7493 9621 9799 9798 9690 9914 113 112 AOI211_X2
* cell instance $7494 m0 *1 70.3,137.2
X$7494 8402 9203 113 112 9685 XNOR2_X1
* cell instance $7496 m0 *1 71.63,137.2
X$7496 9298 9685 113 112 9689 XNOR2_X1
* cell instance $7502 r0 *1 66.31,137.2
X$7502 9719 3327 9864 112 113 9912 OR3_X2
* cell instance $7509 r0 *1 68.78,137.2
X$7509 8402 8729 113 9717 112 XOR2_X2
* cell instance $7513 m0 *1 73.91,137.2
X$7513 9623 9277 9624 112 113 9690 MUX2_X1
* cell instance $7515 r0 *1 75.05,137.2
X$7515 8622 8195 113 112 9916 XNOR2_X1
* cell instance $7516 r0 *1 76.19,137.2
X$7516 8036 112 113 9719 INV_X1
* cell instance $7518 r0 *1 76.95,137.2
X$7518 9720 9917 9721 112 113 9802 MUX2_X1
* cell instance $7519 m0 *1 77.71,137.2
X$7519 6775 9719 112 113 9721 NOR2_X1
* cell instance $7520 m0 *1 77.14,137.2
X$7520 6775 8036 112 113 9720 NOR2_X1
* cell instance $7523 r0 *1 78.28,137.2
X$7523 9869 9568 113 112 9917 XNOR2_X1
* cell instance $7524 m0 *1 79.61,137.2
X$7524 8761 9081 112 113 9722 XNOR2_X2
* cell instance $7526 m0 *1 81.51,137.2
X$7526 8038 9722 112 113 9723 XNOR2_X2
* cell instance $7528 m0 *1 84.17,137.2
X$7528 8857 9805 113 112 9693 XNOR2_X1
* cell instance $7529 m0 *1 85.31,137.2
X$7529 9726 8723 112 113 9809 NAND2_X1
* cell instance $7531 m0 *1 86.07,137.2
X$7531 9726 8988 112 113 9725 NAND2_X1
* cell instance $7532 m0 *1 86.64,137.2
X$7532 112 9811 9693 9627 9809 113 AOI21_X4
* cell instance $7535 r0 *1 80.94,137.2
X$7535 9722 112 113 9805 BUF_X1
* cell instance $7536 r0 *1 81.51,137.2
X$7536 9083 9723 112 113 9724 XNOR2_X2
* cell instance $7538 r0 *1 83.79,137.2
X$7538 8857 112 113 9806 BUF_X1
* cell instance $7539 r0 *1 84.36,137.2
X$7539 9806 9805 112 113 9808 XOR2_X1
* cell instance $7541 r0 *1 85.69,137.2
X$7541 9808 9626 9725 112 9810 113 AOI21_X1
* cell instance $7542 r0 *1 86.45,137.2
X$7542 9696 9811 9810 112 113 9925 OR3_X4
* cell instance $7544 r0 *1 88.73,137.2
X$7544 9926 113 8038 112 BUF_X4
* cell instance $7545 m0 *1 90.25,137.2
X$7545 9628 3527 9727 112 113 9699 NAND3_X1
* cell instance $7546 m0 *1 89.49,137.2
X$7546 9628 9812 9699 113 9696 112 OAI21_X1
* cell instance $7547 m0 *1 91.01,137.2
X$7547 5393 9728 112 113 9812 NAND2_X1
* cell instance $7548 m0 *1 91.58,137.2
X$7548 8870 9728 112 113 9726 NOR2_X1
* cell instance $7549 m0 *1 92.15,137.2
X$7549 9815 8785 9625 112 113 9813 MUX2_X1
* cell instance $7550 m0 *1 93.48,137.2
X$7550 9815 9482 8403 113 112 9817 MUX2_X2
* cell instance $7551 m0 *1 95.19,137.2
X$7551 9175 112 113 17195 INV_X1
* cell instance $7553 r0 *1 90.06,137.2
X$7553 9728 112 113 9575 BUF_X2
* cell instance $7555 r0 *1 91.01,137.2
X$7555 9728 112 113 9727 INV_X1
* cell instance $7556 r0 *1 91.39,137.2
X$7556 112 17021 9815 9813 9175 113 DFF_X1
* cell instance $7560 r0 *1 95.95,137.2
X$7560 9818 9306 9775 112 113 9927 MUX2_X1
* cell instance $7561 m0 *1 96.14,137.2
X$7561 8819 9689 113 112 9708 XNOR2_X1
* cell instance $7565 r0 *1 97.28,137.2
X$7565 9821 113 8195 112 BUF_X4
* cell instance $7567 m0 *1 98.42,137.2
X$7567 9818 9708 4320 113 112 9819 MUX2_X2
* cell instance $7568 m0 *1 101.65,137.2
X$7568 8133 112 113 8992 CLKBUF_X3
* cell instance $7569 m0 *1 102.6,137.2
X$7569 8992 112 113 17203 INV_X1
* cell instance $7574 r0 *1 98.61,137.2
X$7574 112 17054 9821 9820 8992 113 DFF_X1
* cell instance $7577 r0 *1 108.11,137.2
X$7577 9825 10124 9734 113 10060 112 OAI21_X1
* cell instance $7582 r0 *1 111.72,137.2
X$7582 9935 9730 112 113 10471 NOR2_X1
* cell instance $7583 r0 *1 112.29,137.2
X$7583 9730 113 9936 112 BUF_X4
* cell instance $7584 m0 *1 113.81,137.2
X$7584 9731 9631 9421 9501 113 112 9707 OAI22_X2
* cell instance $7585 m0 *1 113.24,137.2
X$7585 9694 112 113 9728 BUF_X1
* cell instance $7586 m0 *1 115.52,137.2
X$7586 9501 9421 9827 113 9875 112 OAI21_X1
* cell instance $7590 r0 *1 113.81,137.2
X$7590 9733 9731 9631 113 112 9935 OAI21_X2
* cell instance $7592 r0 *1 115.52,137.2
X$7592 9826 112 113 9831 BUF_X1
* cell instance $7594 r0 *1 116.85,137.2
X$7594 9940 9503 9829 112 9939 113 AOI21_X2
* cell instance $7596 m0 *1 117.42,137.2
X$7596 9421 112 113 9829 INV_X1
* cell instance $7597 m0 *1 118.56,137.2
X$7597 9501 9421 112 113 9732 NOR2_X2
* cell instance $7598 m0 *1 119.51,137.2
X$7598 9729 6396 113 9832 112 XOR2_X2
* cell instance $7602 r0 *1 118.37,137.2
X$7602 9733 9503 9829 112 9830 113 AOI21_X2
* cell instance $7606 r0 *1 121.03,137.2
X$7606 9831 113 9734 112 BUF_X4
* cell instance $7609 m0 *1 122.36,137.2
X$7609 9827 113 9873 112 BUF_X4
* cell instance $7611 r0 *1 123.12,137.2
X$7611 9835 7819 113 9834 112 XOR2_X2
* cell instance $7615 r0 *1 124.83,137.2
X$7615 9706 112 113 9835 BUF_X1
* cell instance $7617 m0 *1 126.92,137.2
X$7617 8818 8153 113 9837 112 XOR2_X2
* cell instance $7618 m0 *1 125.59,137.2
X$7618 9700 113 9942 112 BUF_X4
* cell instance $7619 m0 *1 128.63,137.2
X$7619 112 9840 9735 9506 9475 10074 113 NAND4_X4
* cell instance $7621 r0 *1 128.44,137.2
X$7621 9475 9506 112 113 10252 NAND2_X2
* cell instance $7625 r0 *1 130.15,137.2
X$7625 9703 8657 113 9839 112 XOR2_X2
* cell instance $7628 r0 *1 132.43,137.2
X$7628 9735 9840 112 9876 113 NAND2_X4
* cell instance $7629 m0 *1 132.62,137.2
X$7629 112 8153 9698 3639 9840 9633 113 OAI211_X4
* cell instance $7631 m0 *1 135.85,137.2
X$7631 8153 112 113 9842 INV_X1
* cell instance $7632 m0 *1 136.23,137.2
X$7632 9634 112 113 9697 INV_X1
* cell instance $7633 m0 *1 136.61,137.2
X$7633 9695 9842 3784 9736 9631 113 112 AOI211_X2
* cell instance $7639 r0 *1 136.23,137.2
X$7639 112 9842 9634 3639 9735 9736 113 OAI211_X4
* cell instance $7640 m0 *1 139.65,137.2
X$7640 9742 9737 112 113 9633 XNOR2_X2
* cell instance $7642 m0 *1 141.55,137.2
X$7642 112 9740 9850 17222 8856 113 DFF_X2
* cell instance $7643 m0 *1 145.16,137.2
X$7643 112 8148 3874 113 BUF_X32
* cell instance $7644 m0 *1 154.47,137.2
X$7644 112 16886 9744 9853 9036 113 DFF_X1
* cell instance $7645 m0 *1 157.7,137.2
X$7645 112 16864 9512 9855 9036 113 DFF_X1
* cell instance $7646 m0 *1 160.93,137.2
X$7646 9857 112 113 9745 BUF_X1
* cell instance $7647 m0 *1 161.5,137.2
X$7647 9548 9514 113 9928 112 XOR2_X2
* cell instance $7648 m0 *1 163.21,137.2
X$7648 9036 112 113 17160 INV_X2
* cell instance $7649 m0 *1 163.78,137.2
X$7649 112 9747 9429 9638 9220 113 NOR3_X4
* cell instance $7650 m0 *1 166.44,137.2
X$7650 7022 112 113 9686 INV_X1
* cell instance $7651 m0 *1 166.82,137.2
X$7651 9515 9596 9749 113 112 9638 OAI21_X2
* cell instance $7652 m0 *1 168.15,137.2
X$7652 9742 9676 113 112 9688 XNOR2_X1
* cell instance $7653 m0 *1 169.29,137.2
X$7653 5399 3733 112 113 9592 NOR2_X1
* cell instance $7654 m0 *1 169.86,137.2
X$7654 9639 9846 112 113 9504 XNOR2_X2
* cell instance $7655 m0 *1 171.76,137.2
X$7655 9750 9843 112 113 9846 XNOR2_X2
* cell instance $7656 m0 *1 173.66,137.2
X$7656 9706 9752 113 9843 112 XOR2_X2
* cell instance $7657 m0 *1 175.37,137.2
X$7657 9841 9640 113 112 9585 XNOR2_X1
* cell instance $7658 m0 *1 176.51,137.2
X$7658 9004 112 113 9258 BUF_X1
* cell instance $7659 m0 *1 177.08,137.2
X$7659 9729 9684 112 113 9742 XNOR2_X2
* cell instance $7660 m0 *1 178.98,137.2
X$7660 9642 112 113 9454 BUF_X1
* cell instance $7662 m0 *1 179.74,137.2
X$7662 9822 9729 113 9682 112 XOR2_X2
* cell instance $7663 m0 *1 181.45,137.2
X$7663 9517 112 113 9576 BUF_X1
* cell instance $7665 m0 *1 182.21,137.2
X$7665 5065 9518 113 9754 112 XOR2_X2
* cell instance $7666 m0 *1 183.92,137.2
X$7666 9836 9679 113 112 9833 XNOR2_X1
* cell instance $7667 m0 *1 185.06,137.2
X$7667 9645 6138 9519 112 113 9755 NAND3_X1
* cell instance $7668 m0 *1 185.82,137.2
X$7668 9646 9432 112 113 9828 NAND2_X1
* cell instance $7669 m0 *1 186.39,137.2
X$7669 9646 9645 112 113 9756 NAND2_X1
* cell instance $7672 r0 *1 139.65,137.2
X$7672 9737 9742 113 9736 112 XOR2_X2
* cell instance $7673 r0 *1 141.36,137.2
X$7673 9845 9877 112 10096 113 NAND2_X4
* cell instance $7674 r0 *1 143.07,137.2
X$7674 9739 3882 9738 112 113 9845 NAND3_X2
* cell instance $7676 r0 *1 144.78,137.2
X$7676 3784 6396 112 113 10093 NAND2_X1
* cell instance $7678 r0 *1 145.54,137.2
X$7678 6396 112 113 9738 INV_X1
* cell instance $7679 r0 *1 145.92,137.2
X$7679 4676 9738 112 113 10090 NOR2_X1
* cell instance $7680 r0 *1 146.49,137.2
X$7680 4676 6396 112 113 10092 NOR2_X1
* cell instance $7682 r0 *1 147.44,137.2
X$7682 9692 9510 112 113 9849 NAND2_X1
* cell instance $7684 r0 *1 148.2,137.2
X$7684 9848 9849 4173 113 112 9880 MUX2_X2
* cell instance $7685 r0 *1 149.91,137.2
X$7685 9741 9851 4173 113 112 9881 MUX2_X2
* cell instance $7686 r0 *1 151.62,137.2
X$7686 8657 112 113 8867 INV_X1
* cell instance $7687 r0 *1 152,137.2
X$7687 112 10079 9852 9636 9938 113 AOI21_X4
* cell instance $7688 r0 *1 154.47,137.2
X$7688 7650 7819 112 113 9743 NOR2_X1
* cell instance $7689 r0 *1 155.04,137.2
X$7689 9743 9885 112 113 9931 NAND2_X1
* cell instance $7690 r0 *1 155.61,137.2
X$7690 9116 6211 9854 112 113 9855 MUX2_X1
* cell instance $7692 r0 *1 157.32,137.2
X$7692 9744 112 113 9524 CLKBUF_X3
* cell instance $7695 r0 *1 159.41,137.2
X$7695 9644 9746 113 112 9852 XNOR2_X1
* cell instance $7696 r0 *1 160.55,137.2
X$7696 9644 9746 112 113 9929 XOR2_X1
* cell instance $7698 r0 *1 162.07,137.2
X$7698 9703 9886 113 112 9856 XNOR2_X1
* cell instance $7699 r0 *1 163.21,137.2
X$7699 9887 9988 113 9888 112 XOR2_X2
* cell instance $7701 r0 *1 165.11,137.2
X$7701 9856 9748 9847 112 9747 113 AOI21_X2
* cell instance $7702 r0 *1 166.44,137.2
X$7702 9703 9888 113 112 9637 XNOR2_X1
* cell instance $7703 r0 *1 167.58,137.2
X$7703 9686 6503 9454 112 113 9847 OR3_X1
* cell instance $7704 r0 *1 168.53,137.2
X$7704 5025 7516 113 112 9590 AND2_X1
* cell instance $7705 r0 *1 169.29,137.2
X$7705 5393 3733 112 113 9513 NAND2_X1
* cell instance $7707 r0 *1 170.24,137.2
X$7707 9746 9991 113 112 9639 XNOR2_X1
* cell instance $7708 r0 *1 171.38,137.2
X$7708 9548 7022 113 9844 112 XOR2_X2
* cell instance $7710 r0 *1 173.28,137.2
X$7710 9706 9644 112 113 9751 XNOR2_X2
* cell instance $7712 r0 *1 175.37,137.2
X$7712 9752 9923 113 9753 112 XOR2_X2
* cell instance $7714 r0 *1 177.27,137.2
X$7714 9222 9431 112 113 9746 XNOR2_X2
* cell instance $7716 r0 *1 179.36,137.2
X$7716 9644 7020 113 9838 112 XOR2_X2
* cell instance $7721 r0 *1 181.26,137.2
X$7721 9642 9754 113 112 9894 XNOR2_X1
* cell instance $7724 r0 *1 183.35,137.2
X$7724 9754 112 113 9645 BUF_X1
* cell instance $7725 r0 *1 183.92,137.2
X$7725 9836 9921 112 113 9922 XOR2_X1
* cell instance $7726 r0 *1 185.06,137.2
X$7726 9833 9828 9755 112 9919 113 AOI21_X1
* cell instance $7727 r0 *1 185.82,137.2
X$7727 9921 112 113 9679 BUF_X2
* cell instance $7728 r0 *1 186.58,137.2
X$7728 9922 9678 9756 112 9757 113 AOI21_X1
* cell instance $7731 m0 *1 187.34,137.2
X$7731 9432 8148 9519 112 113 9678 NAND3_X1
* cell instance $7733 m0 *1 189.05,137.2
X$7733 9519 112 113 9758 INV_X1
* cell instance $7734 m0 *1 189.43,137.2
X$7734 5637 9519 112 113 9824 NAND2_X1
* cell instance $7736 m0 *1 190.19,137.2
X$7736 8818 9647 112 113 9675 XOR2_X1
* cell instance $7737 m0 *1 191.33,137.2
X$7737 9761 9675 113 112 9676 XNOR2_X1
* cell instance $7739 m0 *1 192.66,137.2
X$7739 9822 8818 113 112 9915 XNOR2_X1
* cell instance $7741 r0 *1 187.72,137.2
X$7741 9919 9757 9823 112 113 9918 OR3_X1
* cell instance $7742 r0 *1 188.67,137.2
X$7742 9759 5637 9758 112 113 9760 NAND3_X1
* cell instance $7743 r0 *1 189.43,137.2
X$7743 9759 9824 9760 113 9823 112 OAI21_X1
* cell instance $7748 r0 *1 193.04,137.2
X$7748 9518 9915 113 112 10001 XNOR2_X1
* cell instance $7749 m0 *1 194.37,137.2
X$7749 9524 112 113 9649 INV_X1
* cell instance $7751 m0 *1 194.75,137.2
X$7751 9326 9240 112 113 9648 XOR2_X1
* cell instance $7752 m0 *1 195.89,137.2
X$7752 9648 5393 9649 112 113 9814 NOR3_X1
* cell instance $7753 m0 *1 196.65,137.2
X$7753 9648 3527 9524 112 113 9816 NOR3_X1
* cell instance $7755 m0 *1 198.93,137.2
X$7755 9652 9522 8317 113 112 9807 MUX2_X2
* cell instance $7756 m0 *1 200.64,137.2
X$7756 9525 112 113 9672 BUF_X1
* cell instance $7757 m0 *1 201.21,137.2
X$7757 9650 112 113 9558 BUF_X1
* cell instance $7759 r0 *1 194.18,137.2
X$7759 9762 3571 9649 112 113 9763 NOR3_X1
* cell instance $7760 r0 *1 194.94,137.2
X$7760 9762 3571 9524 112 113 9913 NOR3_X1
* cell instance $7762 r0 *1 195.89,137.2
X$7762 9816 9814 9673 113 112 9764 MUX2_X2
* cell instance $7764 r0 *1 198.36,137.2
X$7764 6422 9765 113 9778 112 XOR2_X2
* cell instance $7765 r0 *1 200.07,137.2
X$7765 9110 9324 113 112 9804 XNOR2_X1
* cell instance $7767 r0 *1 201.97,137.2
X$7767 9804 3882 9766 112 113 10043 NOR3_X1
* cell instance $7768 m0 *1 202.35,137.2
X$7768 9662 7930 112 113 9433 NAND2_X1
* cell instance $7772 m0 *1 205.2,137.2
X$7772 8884 9651 112 113 9768 XNOR2_X2
* cell instance $7776 m0 *1 216.98,137.2
X$7776 8884 9518 112 113 9788 XOR2_X1
* cell instance $7777 m0 *1 218.12,137.2
X$7777 112 16766 9796 4132 9238 113 DFF_X1
* cell instance $7781 m0 *1 225.34,137.2
X$7781 112 16868 9767 9654 9656 113 DFF_X1
* cell instance $7782 m0 *1 228.57,137.2
X$7782 112 16925 9780 9788 9656 113 DFF_X1
* cell instance $7783 m0 *1 231.8,137.2
X$7783 9771 112 113 9662 BUF_X1
* cell instance $7785 m0 *1 233.13,137.2
X$7785 112 16826 8079 9779 9656 113 DFF_X1
* cell instance $7786 m0 *1 236.36,137.2
X$7786 9904 112 113 9773 BUF_X1
* cell instance $7789 m0 *1 239.21,137.2
X$7789 9777 112 113 9658 BUF_X1
* cell instance $7792 r0 *1 203.11,137.2
X$7792 8672 112 113 9766 INV_X1
* cell instance $7794 r0 *1 203.68,137.2
X$7794 10038 4678 9766 112 113 9896 NOR3_X1
* cell instance $7795 r0 *1 204.44,137.2
X$7795 8388 9766 112 113 9801 NAND2_X1
* cell instance $7797 r0 *1 205.2,137.2
X$7797 9767 8388 8672 112 113 9803 NAND3_X1
* cell instance $7798 r0 *1 205.96,137.2
X$7798 9803 9767 9801 113 112 9897 OAI21_X2
* cell instance $7799 r0 *1 207.29,137.2
X$7799 9552 9898 112 113 9769 XOR2_X1
* cell instance $7803 r0 *1 209.76,137.2
X$7803 9739 9306 9540 112 113 9899 MUX2_X1
* cell instance $7805 r0 *1 211.47,137.2
X$7805 9796 113 9644 112 BUF_X4
* cell instance $7810 r0 *1 218.5,137.2
X$7810 9907 112 113 9237 BUF_X2
* cell instance $7812 r0 *1 220.78,137.2
X$7812 112 9792 10024 9596 9791 113 DFF_X2
* cell instance $7813 r0 *1 224.39,137.2
X$7813 9791 8785 9784 112 113 9792 MUX2_X1
* cell instance $7816 r0 *1 230.28,137.2
X$7816 4841 112 113 9656 CLKBUF_X3
* cell instance $7817 r0 *1 231.23,137.2
X$7817 9656 112 113 16482 CLKBUF_X1
* cell instance $7820 r0 *1 233.7,137.2
X$7820 9780 112 113 9772 BUF_X1
* cell instance $7821 r0 *1 234.27,137.2
X$7821 112 17046 9531 9778 9656 113 DFF_X1
* cell instance $7830 m0 *1 16.91,131.6
X$7830 9287 112 113 9232 BUF_X1
* cell instance $7835 m0 *1 22.23,131.6
X$7835 9099 112 113 6899 CLKBUF_X3
* cell instance $7838 m0 *1 24.13,131.6
X$7838 7487 113 8383 112 BUF_X4
* cell instance $7839 m0 *1 25.46,131.6
X$7839 8305 8376 6798 112 9064 113 AOI21_X1
* cell instance $7840 m0 *1 26.22,131.6
X$7840 6798 112 113 8553 CLKBUF_X3
* cell instance $7842 m0 *1 27.36,131.6
X$7842 7707 9064 9340 113 9350 112 OAI21_X1
* cell instance $7843 m0 *1 28.12,131.6
X$7843 7497 7300 7623 112 9342 113 AOI21_X1
* cell instance $7850 r0 *1 11.02,131.6
X$7850 9396 112 113 9438 BUF_X1
* cell instance $7851 r0 *1 11.59,131.6
X$7851 9398 112 113 9376 BUF_X1
* cell instance $7857 r0 *1 13.3,131.6
X$7857 9335 6899 9438 112 113 9439 MUX2_X1
* cell instance $7858 r0 *1 14.63,131.6
X$7858 112 9439 8903 9337 9335 113 DFF_X2
* cell instance $7859 r0 *1 18.24,131.6
X$7859 6050 112 113 8903 CLKBUF_X3
* cell instance $7860 r0 *1 19.19,131.6
X$7860 8903 112 113 17211 INV_X1
* cell instance $7863 r0 *1 26.41,131.6
X$7863 8383 112 113 7623 CLKBUF_X3
* cell instance $7864 r0 *1 27.36,131.6
X$7864 7701 8305 7487 113 9137 112 NOR3_X2
* cell instance $7866 r0 *1 29.07,131.6
X$7866 7300 7847 8553 113 9341 112 OAI21_X1
* cell instance $7867 m0 *1 29.45,131.6
X$7867 8016 9068 9344 113 9288 112 OAI21_X1
* cell instance $7869 m0 *1 30.21,131.6
X$7869 7703 9342 9340 112 9344 113 AOI21_X1
* cell instance $7871 m0 *1 31.16,131.6
X$7871 7847 8637 113 112 9346 AND2_X1
* cell instance $7872 m0 *1 31.92,131.6
X$7872 9250 9070 7970 9350 112 113 9185 AOI22_X1
* cell instance $7873 m0 *1 32.87,131.6
X$7873 7441 7393 112 113 9289 NOR2_X1
* cell instance $7874 m0 *1 33.44,131.6
X$7874 8185 9189 9186 113 9187 112 OAI21_X1
* cell instance $7875 m0 *1 34.2,131.6
X$7875 8971 8555 9187 113 112 9188 OAI21_X2
* cell instance $7876 m0 *1 35.53,131.6
X$7876 7497 8110 5947 112 9250 113 AOI21_X1
* cell instance $7877 m0 *1 36.29,131.6
X$7877 8378 8185 9348 113 112 9254 OAI21_X4
* cell instance $7878 m0 *1 38.76,131.6
X$7878 7848 9037 7703 7300 7495 113 112 9290 OAI221_X1
* cell instance $7879 m0 *1 39.9,131.6
X$7879 7217 8638 9355 7395 8557 9192 113 112 AOI221_X2
* cell instance $7881 m0 *1 42.75,131.6
X$7881 112 8558 7582 9189 7880 9295 7306 7796 113 AOI222_X2
* cell instance $7882 m0 *1 45.41,131.6
X$7882 8561 7706 7217 112 9292 113 AOI21_X1
* cell instance $7885 r0 *1 30.02,131.6
X$7885 7223 9341 9347 113 9541 112 OAI21_X1
* cell instance $7886 r0 *1 30.78,131.6
X$7886 9244 7065 9289 7217 7293 9348 113 112 AOI221_X2
* cell instance $7887 r0 *1 32.87,131.6
X$7887 8185 8748 9400 112 113 9351 OR3_X2
* cell instance $7888 r0 *1 34.01,131.6
X$7888 112 9446 9351 9546 8971 8972 113 AND4_X4
* cell instance $7889 r0 *1 36.48,131.6
X$7889 8242 9259 9346 113 112 9446 OAI21_X2
* cell instance $7890 r0 *1 37.81,131.6
X$7890 7882 7219 8242 112 113 NOR2_X4
* cell instance $7891 r0 *1 39.52,131.6
X$7891 7848 9191 7630 7293 7710 113 112 9401 OAI221_X1
* cell instance $7893 r0 *1 40.85,131.6
X$7893 9402 8557 7847 112 113 9291 NAND3_X1
* cell instance $7894 r0 *1 41.61,131.6
X$7894 9191 8253 112 113 9355 NOR2_X1
* cell instance $7896 r0 *1 42.56,131.6
X$7896 8638 7623 8557 113 9404 112 OAI21_X1
* cell instance $7897 r0 *1 43.32,131.6
X$7897 8558 7848 112 113 9405 NOR2_X1
* cell instance $7898 r0 *1 43.89,131.6
X$7898 7641 9405 9292 7441 7065 113 112 9488 OAI221_X1
* cell instance $7899 r0 *1 45.03,131.6
X$7899 8849 112 113 9407 INV_X1
* cell instance $7901 r0 *1 45.6,131.6
X$7901 7884 7707 8553 113 9456 112 OAI21_X1
* cell instance $7902 r0 *1 46.36,131.6
X$7902 8383 8110 112 113 9295 NOR2_X2
* cell instance $7903 m0 *1 46.74,131.6
X$7903 9358 9293 112 113 9266 NAND2_X1
* cell instance $7905 m0 *1 47.31,131.6
X$7905 9194 9074 9264 113 112 9265 AND3_X2
* cell instance $7907 m0 *1 48.64,131.6
X$7907 8016 8557 9295 112 9358 113 AOI21_X1
* cell instance $7909 r0 *1 47.31,131.6
X$7909 7888 9294 112 113 9459 OR2_X2
* cell instance $7910 r0 *1 48.26,131.6
X$7910 9456 9295 7970 113 9294 112 OAI21_X1
* cell instance $7912 r0 *1 49.21,131.6
X$7912 8808 9408 113 112 9293 AND2_X1
* cell instance $7913 m0 *1 50.54,131.6
X$7913 8561 9360 112 113 9296 OR2_X1
* cell instance $7914 m0 *1 49.78,131.6
X$7914 9195 7848 8022 112 9360 113 AOI21_X1
* cell instance $7915 m0 *1 51.3,131.6
X$7915 9266 9296 9288 8971 112 113 8492 NAND4_X1
* cell instance $7916 m0 *1 52.25,131.6
X$7916 7630 5947 113 112 9559 XNOR2_X1
* cell instance $7917 m0 *1 53.39,131.6
X$7917 9409 7890 7572 7710 9267 113 112 9410 OAI221_X1
* cell instance $7918 m0 *1 54.53,131.6
X$7918 8757 113 7621 112 BUF_X4
* cell instance $7919 m0 *1 55.86,131.6
X$7919 6796 8110 7501 112 9267 113 AOI21_X1
* cell instance $7921 m0 *1 56.81,131.6
X$7921 8110 9364 9268 8642 7623 113 112 9198 OAI221_X1
* cell instance $7922 m0 *1 57.95,131.6
X$7922 9269 9198 9199 112 9466 113 AOI21_X1
* cell instance $7927 r0 *1 49.97,131.6
X$7927 1747 112 113 6050 CLKBUF_X3
* cell instance $7928 r0 *1 50.92,131.6
X$7928 6050 112 113 16723 INV_X4
* cell instance $7929 r0 *1 51.87,131.6
X$7929 8971 9453 9460 113 112 9465 OAI21_X2
* cell instance $7931 r0 *1 53.39,131.6
X$7931 9466 8566 9254 112 113 9468 OR3_X4
* cell instance $7933 r0 *1 55.86,131.6
X$7933 7621 113 8016 112 BUF_X4
* cell instance $7934 r0 *1 57.19,131.6
X$7934 8253 6796 7621 112 9364 113 AOI21_X1
* cell instance $7939 r0 *1 62.32,131.6
X$7939 9201 112 113 17179 INV_X2
* cell instance $7940 r0 *1 62.89,131.6
X$7940 6050 112 113 9201 CLKBUF_X3
* cell instance $7941 r0 *1 63.84,131.6
X$7941 112 17024 9366 9265 9201 113 DFF_X1
* cell instance $7943 m0 *1 64.41,131.6
X$7943 112 16765 8853 9365 9201 113 DFF_X1
* cell instance $7948 m0 *1 69.16,131.6
X$7948 5954 8568 112 113 9298 XNOR2_X2
* cell instance $7949 m0 *1 68.02,131.6
X$7949 8568 9272 113 112 9202 XNOR2_X1
* cell instance $7952 m0 *1 72.01,131.6
X$7952 7598 9204 113 112 9800 XNOR2_X1
* cell instance $7956 r0 *1 69.35,131.6
X$7956 9366 113 9131 112 BUF_X4
* cell instance $7959 r0 *1 71.25,131.6
X$7959 9299 9203 112 113 8570 XNOR2_X2
* cell instance $7960 r0 *1 73.15,131.6
X$7960 4163 113 8403 112 BUF_X4
* cell instance $7961 m0 *1 74.48,131.6
X$7961 9300 8196 113 112 9205 XNOR2_X1
* cell instance $7965 r0 *1 74.48,131.6
X$7965 4365 9300 113 112 9411 XNOR2_X1
* cell instance $7967 r0 *1 76,131.6
X$7967 7230 8762 113 112 9412 XNOR2_X1
* cell instance $7969 r0 *1 77.33,131.6
X$7969 9299 8761 113 112 9301 XNOR2_X1
* cell instance $7971 m0 *1 77.52,131.6
X$7971 9370 9301 113 112 9272 XNOR2_X1
* cell instance $7973 m0 *1 79.61,131.6
X$7973 9206 8570 113 112 9278 XNOR2_X1
* cell instance $7975 r0 *1 78.47,131.6
X$7975 9206 112 113 9370 BUF_X1
* cell instance $7976 r0 *1 79.04,131.6
X$7976 8626 9167 112 113 9414 XOR2_X1
* cell instance $7978 r0 *1 80.56,131.6
X$7978 8626 9415 113 112 9570 XNOR2_X1
* cell instance $7979 m0 *1 81.32,131.6
X$7979 7598 9081 113 9279 112 XOR2_X2
* cell instance $7981 m0 *1 83.03,131.6
X$7981 9084 113 9168 112 BUF_X4
* cell instance $7983 m0 *1 85.88,131.6
X$7983 9085 8988 113 112 9374 XNOR2_X1
* cell instance $7984 m0 *1 87.02,131.6
X$7984 9206 6773 9208 112 113 9207 NAND3_X1
* cell instance $7985 m0 *1 87.78,131.6
X$7985 9304 9279 112 113 9375 NAND2_X1
* cell instance $7990 r0 *1 82.46,131.6
X$7990 9304 9206 112 113 9302 NAND2_X1
* cell instance $7991 r0 *1 83.03,131.6
X$7991 8856 8723 113 112 9303 XNOR2_X1
* cell instance $7992 r0 *1 84.17,131.6
X$7992 9303 9302 9417 112 9495 113 AOI21_X1
* cell instance $7993 r0 *1 84.93,131.6
X$7993 9279 5043 9208 112 113 9417 NAND3_X1
* cell instance $7995 r0 *1 86.07,131.6
X$7995 9374 9207 9375 112 9373 113 AOI21_X1
* cell instance $7998 r0 *1 91.39,131.6
X$7998 8196 9278 113 112 9482 XNOR2_X1
* cell instance $8000 r0 *1 92.72,131.6
X$8000 112 9061 9305 9481 9175 113 DFF_X1
* cell instance $8001 m0 *1 93.48,131.6
X$8001 9099 113 3947 112 BUF_X4
* cell instance $8006 m0 *1 98.8,131.6
X$8006 112 9087 9479 8410 8992 113 DFF_X1
* cell instance $8008 m0 *1 102.22,131.6
X$8008 9099 113 9209 112 BUF_X4
* cell instance $8011 r0 *1 95.95,131.6
X$8011 9305 9209 9232 112 113 9481 MUX2_X1
* cell instance $8015 r0 *1 101.46,131.6
X$8015 9308 9306 9376 112 113 9478 MUX2_X1
* cell instance $8016 r0 *1 102.79,131.6
X$8016 112 17072 9308 9478 8773 113 DFF_X1
* cell instance $8017 m0 *1 104.88,131.6
X$8017 9099 113 8785 112 BUF_X4
* cell instance $8022 r0 *1 106.02,131.6
X$8022 112 17002 9378 9307 8773 113 DFF_X1
* cell instance $8023 m0 *1 109.82,131.6
X$8023 9282 9284 9380 113 112 9379 MUX2_X2
* cell instance $8024 m0 *1 108.87,131.6
X$8024 8133 112 113 8773 CLKBUF_X3
* cell instance $8025 m0 *1 111.53,131.6
X$8025 9283 9216 112 113 9380 XNOR2_X2
* cell instance $8029 m0 *1 115.9,131.6
X$8029 9381 9306 9383 112 113 9382 MUX2_X1
* cell instance $8031 r0 *1 109.25,131.6
X$8031 9378 112 113 8865 BUF_X2
* cell instance $8034 r0 *1 110.58,131.6
X$8034 9308 9363 8317 113 112 9420 MUX2_X2
* cell instance $8035 r0 *1 112.29,131.6
X$8035 9131 6215 113 9500 112 XOR2_X2
* cell instance $8036 r0 *1 114,131.6
X$8036 112 9210 9381 9382 8773 113 DFF_X1
* cell instance $8037 r0 *1 117.23,131.6
X$8037 9384 9309 9210 113 112 9421 OAI21_X4
* cell instance $8039 m0 *1 117.61,131.6
X$8039 9210 3882 7334 112 113 9384 NAND3_X1
* cell instance $8041 m0 *1 119.32,131.6
X$8041 9312 9306 180 112 113 9311 MUX2_X1
* cell instance $8042 m0 *1 120.65,131.6
X$8042 112 9311 9211 17241 9312 113 DFF_X2
* cell instance $8045 m0 *1 125.97,131.6
X$8045 6215 112 113 9314 INV_X1
* cell instance $8047 m0 *1 127.11,131.6
X$8047 3489 6215 112 113 9389 NAND2_X1
* cell instance $8048 m0 *1 127.68,131.6
X$8048 7750 9095 9215 9315 112 113 9390 OR4_X1
* cell instance $8049 m0 *1 128.82,131.6
X$8049 8999 112 113 9391 INV_X1
* cell instance $8051 m0 *1 129.39,131.6
X$8051 9212 9276 8998 9390 113 112 9387 AND4_X1
* cell instance $8052 m0 *1 130.53,131.6
X$8052 9391 8454 9095 7246 112 113 9392 NOR4_X1
* cell instance $8053 m0 *1 131.48,131.6
X$8053 9213 9214 9215 113 9317 112 OAI21_X1
* cell instance $8055 r0 *1 119.7,131.6
X$8055 4678 9310 112 113 9309 NAND2_X2
* cell instance $8056 r0 *1 120.65,131.6
X$8056 7334 112 113 9310 INV_X1
* cell instance $8060 r0 *1 123.12,131.6
X$8060 9313 4395 113 9476 112 XOR2_X2
* cell instance $8064 r0 *1 124.83,131.6
X$8064 9312 3489 9314 113 9597 112 NOR3_X2
* cell instance $8065 r0 *1 126.16,131.6
X$8065 3489 9314 112 113 9388 NAND2_X1
* cell instance $8066 r0 *1 126.73,131.6
X$8066 8317 6215 112 113 9423 NOR2_X1
* cell instance $8067 r0 *1 127.3,131.6
X$8067 9389 9388 9247 113 112 9506 MUX2_X2
* cell instance $8068 r0 *1 129.01,131.6
X$8068 9315 9091 7246 112 113 9393 NOR3_X1
* cell instance $8072 r0 *1 130.34,131.6
X$8072 9393 9392 9215 113 9472 112 OAI21_X1
* cell instance $8074 r0 *1 131.48,131.6
X$8074 9316 9387 9317 9472 113 112 9469 AND4_X2
* cell instance $8075 m0 *1 132.81,131.6
X$8075 8008 9217 112 113 9215 XNOR2_X2
* cell instance $8077 m0 *1 134.71,131.6
X$8077 9274 9096 9385 113 112 9386 MUX2_X2
* cell instance $8080 m0 *1 140.98,131.6
X$8080 9218 9271 112 8661 113 NAND2_X4
* cell instance $8081 m0 *1 142.69,131.6
X$8081 9271 9218 113 112 9219 AND2_X2
* cell instance $8084 r0 *1 133,131.6
X$8084 112 16983 9318 9470 8780 113 DFF_X1
* cell instance $8086 r0 *1 137.75,131.6
X$8086 112 3639 113 7738 BUF_X8
* cell instance $8088 r0 *1 140.41,131.6
X$8088 5637 6498 112 113 9425 NAND2_X1
* cell instance $8090 r0 *1 141.74,131.6
X$8090 6498 112 113 9426 INV_X1
* cell instance $8092 r0 *1 142.88,131.6
X$8092 112 8148 5928 113 BUF_X32
* cell instance $8093 m0 *1 144.21,131.6
X$8093 8878 6625 112 113 9319 NAND2_X1
* cell instance $8095 m0 *1 144.78,131.6
X$8095 112 8338 113 9219 BUF_X8
* cell instance $8098 m0 *1 147.63,131.6
X$8098 9427 9219 112 8052 113 NAND2_X4
* cell instance $8099 m0 *1 149.53,131.6
X$8099 6625 8878 113 112 9603 AND2_X1
* cell instance $8102 m0 *1 150.67,131.6
X$8102 8718 6625 112 113 9320 NOR2_X1
* cell instance $8104 m0 *1 152.95,131.6
X$8104 112 7596 8661 8580 6929 113 NOR3_X4
* cell instance $8105 m0 *1 155.61,131.6
X$8105 8341 112 113 7922 CLKBUF_X3
* cell instance $8106 m0 *1 156.56,131.6
X$8106 9220 8443 8338 112 8874 113 AOI21_X2
* cell instance $8107 m0 *1 157.89,131.6
X$8107 112 9153 8661 8580 7416 113 NOR3_X4
* cell instance $8109 r0 *1 152.19,131.6
X$8109 112 8580 113 9464 BUF_X8
* cell instance $8110 r0 *1 154.66,131.6
X$8110 9128 4967 8403 113 112 9377 MUX2_X2
* cell instance $8111 r0 *1 156.37,131.6
X$8111 9463 7107 9462 112 9853 113 AOI21_X1
* cell instance $8113 r0 *1 157.32,131.6
X$8113 112 7212 6503 113 BUF_X16
* cell instance $8114 m0 *1 161.88,131.6
X$8114 9220 113 7596 112 BUF_X4
* cell instance $8115 m0 *1 160.93,131.6
X$8115 8581 112 113 7923 CLKBUF_X3
* cell instance $8116 m0 *1 163.21,131.6
X$8116 5399 9458 112 113 9321 NOR2_X1
* cell instance $8117 m0 *1 163.78,131.6
X$8117 8283 8161 9005 9258 112 113 9261 AOI22_X2
* cell instance $8118 m0 *1 165.49,131.6
X$8118 112 9153 8783 113 BUF_X16
* cell instance $8119 m0 *1 170.24,131.6
X$8119 9153 112 113 7915 INV_X8
* cell instance $8120 m0 *1 171.95,131.6
X$8120 5025 5401 112 113 9588 OR2_X1
* cell instance $8121 m0 *1 172.71,131.6
X$8121 112 8666 8282 113 BUF_X16
* cell instance $8122 m0 *1 177.46,131.6
X$8122 9255 9369 9452 112 113 9153 OR3_X4
* cell instance $8123 m0 *1 179.55,131.6
X$8123 9241 8390 9256 113 9255 112 OAI21_X1
* cell instance $8124 m0 *1 180.31,131.6
X$8124 9241 5399 9368 112 113 9256 NAND3_X1
* cell instance $8125 m0 *1 181.07,131.6
X$8125 5401 7020 112 113 9449 NOR2_X1
* cell instance $8126 m0 *1 181.64,131.6
X$8126 7020 112 113 9368 INV_X1
* cell instance $8128 m0 *1 182.21,131.6
X$8128 9221 112 113 9322 BUF_X1
* cell instance $8129 m0 *1 182.78,131.6
X$8129 9225 9223 113 112 9252 XNOR2_X1
* cell instance $8131 r0 *1 162.07,131.6
X$8131 7866 7917 8581 112 113 NOR2_X4
* cell instance $8132 r0 *1 163.78,131.6
X$8132 3733 112 113 9458 INV_X1
* cell instance $8133 r0 *1 164.16,131.6
X$8133 9372 113 8217 112 BUF_X4
* cell instance $8134 r0 *1 165.49,131.6
X$8134 7917 7866 112 113 9372 OR2_X1
* cell instance $8135 r0 *1 166.25,131.6
X$8135 8782 8217 112 113 8544 NAND2_X1
* cell instance $8136 r0 *1 166.82,131.6
X$8136 112 8783 8173 113 BUF_X32
* cell instance $8137 r0 *1 176.13,131.6
X$8137 9099 113 9306 112 BUF_X4
* cell instance $8139 r0 *1 177.84,131.6
X$8139 7020 5240 9450 112 9583 113 NAND3_X4
* cell instance $8143 r0 *1 180.31,131.6
X$8143 9517 9222 113 9450 112 XOR2_X2
* cell instance $8144 r0 *1 182.02,131.6
X$8144 5043 5025 112 113 9367 NAND2_X1
* cell instance $8146 r0 *1 182.78,131.6
X$8146 9322 9448 113 112 9444 XNOR2_X1
* cell instance $8148 m0 *1 11.21,134.4
X$8148 9394 112 113 9403 BUF_X1
* cell instance $8149 m0 *1 10.64,134.4
X$8149 9534 112 113 9485 BUF_X1
* cell instance $8160 r0 *1 11.97,134.4
X$8160 9611 112 113 9440 BUF_X1
* cell instance $8161 r0 *1 12.54,134.4
X$8161 9484 112 113 9660 BUF_X1
* cell instance $8163 m0 *1 12.92,134.4
X$8163 9395 112 113 9661 BUF_X1
* cell instance $8165 m0 *1 14.06,134.4
X$8165 112 16818 9534 9471 8903 113 DFF_X1
* cell instance $8167 m0 *1 17.29,134.4
X$8167 9397 112 113 6194 BUF_X1
* cell instance $8170 m0 *1 18.81,134.4
X$8170 9275 8585 9613 112 113 9535 MUX2_X1
* cell instance $8171 m0 *1 20.14,134.4
X$8171 112 16825 9275 9535 9399 113 DFF_X1
* cell instance $8176 m0 *1 24.51,134.4
X$8176 8383 113 8554 112 BUF_X4
* cell instance $8177 m0 *1 26.6,134.4
X$8177 7707 113 8176 112 BUF_X4
* cell instance $8178 m0 *1 27.93,134.4
X$8178 8416 7002 7222 112 9538 113 AOI21_X1
* cell instance $8180 m0 *1 28.88,134.4
X$8180 8376 7441 7497 7847 9538 113 112 9666 OAI221_X1
* cell instance $8184 r0 *1 28.5,134.4
X$8184 7497 112 113 7970 CLKBUF_X3
* cell instance $8186 r0 *1 30.21,134.4
X$8186 7882 112 113 7497 CLKBUF_X3
* cell instance $8187 m0 *1 31.16,134.4
X$8187 7628 9664 7222 112 9347 113 AOI21_X1
* cell instance $8188 m0 *1 30.4,134.4
X$8188 9541 9543 8016 112 113 9127 NAND3_X1
* cell instance $8189 m0 *1 31.92,134.4
X$8189 9137 9289 7630 113 9543 112 OAI21_X1
* cell instance $8191 m0 *1 32.87,134.4
X$8191 6965 8376 9071 112 113 NOR2_X4
* cell instance $8193 m0 *1 34.77,134.4
X$8193 7622 112 113 7847 CLKBUF_X3
* cell instance $8194 m0 *1 35.72,134.4
X$8194 8376 7217 9486 7222 112 113 9257 AOI22_X1
* cell instance $8197 r0 *1 31.35,134.4
X$8197 9667 9071 8253 112 113 9400 NOR3_X1
* cell instance $8198 r0 *1 32.11,134.4
X$8198 9666 8014 9545 112 113 9546 NAND3_X2
* cell instance $8200 r0 *1 33.82,134.4
X$8200 7220 9133 9668 112 113 7956 NOR3_X1
* cell instance $8201 r0 *1 34.58,134.4
X$8201 8253 7393 112 113 9669 NOR2_X1
* cell instance $8202 r0 *1 35.15,134.4
X$8202 9486 8553 9671 9669 7572 9545 112 113 OAI221_X2
* cell instance $8203 m0 *1 37.81,134.4
X$8203 8182 9190 8566 8242 9140 9614 113 112 AOI221_X2
* cell instance $8204 m0 *1 37.05,134.4
X$8204 7970 8557 8176 112 113 9670 NAND3_X1
* cell instance $8205 m0 *1 39.9,134.4
X$8205 8016 9401 9290 113 112 9453 AND3_X1
* cell instance $8206 m0 *1 40.85,134.4
X$8206 7497 8558 7884 8557 112 113 9487 AOI22_X1
* cell instance $8207 m0 *1 41.8,134.4
X$8207 7487 9402 113 112 9551 AND2_X1
* cell instance $8208 m0 *1 42.56,134.4
X$8208 7293 7229 6853 112 113 9409 MUX2_X1
* cell instance $8210 m0 *1 44.65,134.4
X$8210 7441 7395 112 113 9406 NOR2_X1
* cell instance $8211 m0 *1 45.22,134.4
X$8211 9406 9193 8242 113 9455 112 OAI21_X1
* cell instance $8212 m0 *1 45.98,134.4
X$8212 112 9407 9459 9239 9455 9467 113 NAND4_X4
* cell instance $8214 m0 *1 49.59,134.4
X$8214 7219 7395 7217 112 9408 113 AOI21_X1
* cell instance $8216 r0 *1 37.24,134.4
X$8216 8191 8974 112 113 9671 OR2_X2
* cell instance $8217 r0 *1 38.19,134.4
X$8217 9402 7220 112 113 9667 NOR2_X1
* cell instance $8218 r0 *1 38.76,134.4
X$8218 7299 8191 9402 112 9072 113 AOI21_X1
* cell instance $8219 r0 *1 39.52,134.4
X$8219 7395 7312 9402 112 113 NOR2_X4
* cell instance $8222 r0 *1 41.8,134.4
X$8222 8974 8757 8191 8491 7622 112 113 9674 AOI221_X1
* cell instance $8225 r0 *1 43.51,134.4
X$8225 9404 9551 8182 8557 9409 113 112 9615 OAI221_X1
* cell instance $8227 r0 *1 45.03,134.4
X$8227 8757 7219 8182 112 113 NOR2_X4
* cell instance $8228 r0 *1 46.74,134.4
X$8228 8387 8176 112 113 9616 NAND2_X1
* cell instance $8230 r0 *1 47.5,134.4
X$8230 7701 7572 8022 112 113 9617 MUX2_X1
* cell instance $8231 r0 *1 48.83,134.4
X$8231 8642 8553 112 113 9787 NOR2_X1
* cell instance $8232 r0 *1 49.4,134.4
X$8232 7393 7217 9489 7222 112 113 9556 AOI22_X1
* cell instance $8234 m0 *1 52.82,134.4
X$8234 9410 7706 9559 112 9263 113 AOI21_X1
* cell instance $8235 m0 *1 50.73,134.4
X$8235 9293 9196 7572 7630 9556 9460 113 112 AOI221_X2
* cell instance $8237 r0 *1 51.11,134.4
X$8237 9489 7497 9789 113 9297 112 OAI21_X1
* cell instance $8238 r0 *1 51.87,134.4
X$8238 8757 6965 9618 112 113 9619 NOR3_X1
* cell instance $8239 r0 *1 52.63,134.4
X$8239 7628 113 7630 112 BUF_X4
* cell instance $8240 r0 *1 53.96,134.4
X$8240 8757 112 113 7572 CLKBUF_X3
* cell instance $8241 m0 *1 57.38,134.4
X$8241 7219 113 7628 112 BUF_X4
* cell instance $8242 m0 *1 53.96,134.4
X$8242 112 9468 9467 7969 9465 9477 113 NAND4_X4
* cell instance $8244 m0 *1 64.79,134.4
X$8244 7230 8319 112 113 9491 XNOR2_X2
* cell instance $8248 r0 *1 55.1,134.4
X$8248 8191 9409 112 113 9620 NOR2_X2
* cell instance $8250 r0 *1 62.13,134.4
X$8250 9277 9474 113 112 9683 XNOR2_X1
* cell instance $8254 r0 *1 64.6,134.4
X$8254 9491 9277 9564 112 113 9490 NOR3_X1
* cell instance $8257 r0 *1 67.07,134.4
X$8257 9491 7518 9564 112 113 9492 NOR3_X1
* cell instance $8258 r0 *1 67.83,134.4
X$8258 9492 9277 9562 112 113 9621 MUX2_X1
* cell instance $8263 m0 *1 68.59,134.4
X$8263 8319 7230 113 9474 112 XOR2_X2
* cell instance $8265 r0 *1 69.16,134.4
X$8265 9474 7518 9564 112 113 9562 NOR3_X1
* cell instance $8268 r0 *1 71.06,134.4
X$8268 9299 9687 113 112 9622 XNOR2_X1
* cell instance $8270 m0 *1 71.44,134.4
X$8270 9298 9163 113 112 9687 XNOR2_X1
* cell instance $8271 m0 *1 72.77,134.4
X$8271 9300 9163 112 113 8769 XNOR2_X2
* cell instance $8272 m0 *1 74.67,134.4
X$8272 8647 9411 112 113 9565 XNOR2_X2
* cell instance $8273 m0 *1 76.57,134.4
X$8273 8647 9412 113 112 9568 XNOR2_X1
* cell instance $8278 r0 *1 74.1,134.4
X$8278 9474 6138 112 113 9623 NAND2_X1
* cell instance $8279 r0 *1 74.67,134.4
X$8279 9491 6138 112 113 9624 NAND2_X1
* cell instance $8282 r0 *1 76.38,134.4
X$8282 9567 112 113 8568 BUF_X2
* cell instance $8284 r0 *1 78.66,134.4
X$8284 9491 6138 9091 112 113 9569 NAND3_X1
* cell instance $8285 m0 *1 79.04,134.4
X$8285 7518 9091 112 113 9413 NOR2_X1
* cell instance $8287 m0 *1 79.61,134.4
X$8287 9413 9474 112 113 9494 NAND2_X1
* cell instance $8288 m0 *1 80.18,134.4
X$8288 9413 9491 112 113 9571 NAND2_X1
* cell instance $8289 m0 *1 80.75,134.4
X$8289 9167 112 113 9415 BUF_X1
* cell instance $8290 m0 *1 81.32,134.4
X$8290 9570 9571 9416 112 9572 113 AOI21_X2
* cell instance $8292 r0 *1 79.42,134.4
X$8292 9414 9569 9494 112 9493 113 AOI21_X2
* cell instance $8295 r0 *1 81.7,134.4
X$8295 112 9572 9493 9280 9691 113 NOR3_X4
* cell instance $8296 m0 *1 83.79,134.4
X$8296 8856 9574 113 9471 112 XOR2_X2
* cell instance $8297 m0 *1 83.03,134.4
X$8297 9474 5928 9091 112 113 9416 NAND3_X1
* cell instance $8300 m0 *1 86.45,134.4
X$8300 8856 112 113 9085 BUF_X1
* cell instance $8302 m0 *1 87.78,134.4
X$8302 112 9628 9418 9483 9175 113 DFF_X1
* cell instance $8303 m0 *1 91.01,134.4
X$8303 9418 7930 9403 112 113 9483 MUX2_X1
* cell instance $8304 m0 *1 92.34,134.4
X$8304 8133 112 113 9175 CLKBUF_X3
* cell instance $8307 r0 *1 85.12,134.4
X$8307 8723 3926 9575 112 113 9626 NAND3_X1
* cell instance $8308 r0 *1 85.88,134.4
X$8308 9575 112 113 9574 BUF_X1
* cell instance $8310 r0 *1 86.64,134.4
X$8310 9575 8577 8988 112 9627 113 NAND3_X4
* cell instance $8312 r0 *1 89.49,134.4
X$8312 112 17034 9629 9578 9175 113 DFF_X1
* cell instance $8313 r0 *1 92.72,134.4
X$8313 9629 3947 9660 112 113 9578 MUX2_X1
* cell instance $8314 m0 *1 93.86,134.4
X$8314 3989 113 8862 112 BUF_X4
* cell instance $8322 r0 *1 96.9,134.4
X$8322 9480 9498 9496 112 113 9871 MUX2_X1
* cell instance $8323 m0 *1 97.28,134.4
X$8323 7816 3989 112 113 9496 NOR2_X1
* cell instance $8325 m0 *1 97.85,134.4
X$8325 7816 3068 112 113 9581 NAND2_X1
* cell instance $8326 m0 *1 98.42,134.4
X$8326 7868 3989 112 113 9480 NOR2_X1
* cell instance $8327 m0 *1 98.99,134.4
X$8327 7868 3068 112 113 9497 NAND2_X1
* cell instance $8330 r0 *1 98.23,134.4
X$8330 9581 9497 9498 113 112 9630 MUX2_X2
* cell instance $8332 r0 *1 100.13,134.4
X$8332 9650 9582 112 113 9498 XNOR2_X2
* cell instance $8334 m0 *1 100.7,134.4
X$8334 9419 9479 112 113 9582 XNOR2_X2
* cell instance $8336 m0 *1 104.88,134.4
X$8336 112 9156 8773 17235 9505 113 DFF_X2
* cell instance $8338 m0 *1 111.53,134.4
X$8338 8738 9420 112 113 9730 XNOR2_X2
* cell instance $8339 m0 *1 113.43,134.4
X$8339 9420 8738 113 9593 112 XOR2_X2
* cell instance $8342 m0 *1 117.42,134.4
X$8342 8403 7334 112 113 9502 NAND2_X1
* cell instance $8343 m0 *1 117.99,134.4
X$8343 9502 9504 9422 112 113 9503 MUX2_X1
* cell instance $8344 m0 *1 119.32,134.4
X$8344 8403 9310 112 113 9422 NAND2_X1
* cell instance $8346 r0 *1 102.03,134.4
X$8346 112 17069 9567 9499 8992 113 DFF_X1
* cell instance $8348 r0 *1 105.64,134.4
X$8348 112 9477 8773 17248 9706 113 DFF_X2
* cell instance $8352 r0 *1 114.19,134.4
X$8352 9421 9501 9826 112 113 NOR2_X4
* cell instance $8354 r0 *1 116.09,134.4
X$8354 9222 4395 113 9704 112 XOR2_X2
* cell instance $8355 r0 *1 117.8,134.4
X$8355 5170 7334 112 113 9705 NOR2_X1
* cell instance $8356 r0 *1 118.37,134.4
X$8356 9595 9705 9504 113 112 9501 MUX2_X2
* cell instance $8357 r0 *1 120.08,134.4
X$8357 9505 7334 113 9702 112 XOR2_X2
* cell instance $8359 m0 *1 120.27,134.4
X$8359 5170 9310 112 113 9595 NOR2_X1
* cell instance $8362 m0 *1 125.59,134.4
X$8362 112 9475 9597 9312 9423 113 AOI21_X4
* cell instance $8367 r0 *1 123.12,134.4
X$8367 4395 9313 112 113 9632 XNOR2_X2
* cell instance $8373 r0 *1 127.3,134.4
X$8373 9599 112 113 8999 BUF_X2
* cell instance $8374 r0 *1 128.06,134.4
X$8374 9506 9475 113 112 9700 AND2_X1
* cell instance $8375 m0 *1 128.63,134.4
X$8375 8999 9600 112 113 9315 NAND2_X1
* cell instance $8377 m0 *1 129.2,134.4
X$8377 9600 113 8454 112 BUF_X4
* cell instance $8379 m0 *1 130.72,134.4
X$8379 8999 9215 112 113 9473 XNOR2_X2
* cell instance $8380 m0 *1 132.62,134.4
X$8380 9318 9306 9602 112 113 9470 MUX2_X1
* cell instance $8388 r0 *1 131.29,134.4
X$8388 9601 5120 112 113 9316 NAND2_X1
* cell instance $8391 r0 *1 132.81,134.4
X$8391 8317 9318 112 113 9698 OR2_X1
* cell instance $8393 r0 *1 135.09,134.4
X$8393 9697 8153 3784 9633 9731 113 112 AOI211_X2
* cell instance $8394 m0 *1 136.04,134.4
X$8394 9318 7510 112 113 9634 NAND2_X2
* cell instance $8397 r0 *1 136.8,134.4
X$8397 9318 4320 112 113 9695 NOR2_X1
* cell instance $8398 r0 *1 137.37,134.4
X$8398 9605 9694 112 113 9424 XNOR2_X2
* cell instance $8399 m0 *1 137.56,134.4
X$8399 9424 6821 112 113 9385 XNOR2_X2
* cell instance $8403 m0 *1 140.41,134.4
X$8403 9507 9425 9607 113 6638 112 OAI21_X1
* cell instance $8405 m0 *1 141.36,134.4
X$8405 9507 6503 9426 112 113 9607 NAND3_X1
* cell instance $8408 r0 *1 139.27,134.4
X$8408 112 9507 9508 9606 8780 113 DFF_X1
* cell instance $8409 r0 *1 142.5,134.4
X$8409 9508 9209 9609 112 113 9606 MUX2_X1
* cell instance $8411 m0 *1 144.78,134.4
X$8411 9319 9608 9604 113 112 9427 MUX2_X2
* cell instance $8412 m0 *1 144.02,134.4
X$8412 6625 7516 112 113 9608 OR2_X1
* cell instance $8413 m0 *1 146.49,134.4
X$8413 112 8443 113 9427 BUF_X8
* cell instance $8417 r0 *1 145.92,134.4
X$8417 3882 9509 112 113 9692 NOR2_X1
* cell instance $8418 r0 *1 146.49,134.4
X$8418 2764 3109 113 9510 112 XOR2_X2
* cell instance $8420 r0 *1 148.39,134.4
X$8420 3109 2764 113 112 9511 XNOR2_X1
* cell instance $8421 m0 *1 149.91,134.4
X$8421 9603 9604 9320 112 113 9464 MUX2_X1
* cell instance $8422 m0 *1 149.34,134.4
X$8422 9233 6244 112 113 9463 NOR2_X1
* cell instance $8424 r0 *1 149.53,134.4
X$8424 9510 3489 9509 112 113 9848 NAND3_X1
* cell instance $8425 r0 *1 150.29,134.4
X$8425 9511 3489 9509 112 113 9851 NAND3_X1
* cell instance $8427 r0 *1 151.24,134.4
X$8427 112 5240 4054 113 BUF_X32
* cell instance $8428 m0 *1 154.09,134.4
X$8428 8933 9462 113 112 9854 XNOR2_X1
* cell instance $8429 m0 *1 151.62,134.4
X$8429 4054 7819 9635 112 9636 113 NAND3_X4
* cell instance $8430 m0 *1 155.23,134.4
X$8430 112 7212 5637 113 BUF_X16
* cell instance $8431 m0 *1 159.98,134.4
X$8431 9220 112 113 8341 INV_X2
* cell instance $8432 m0 *1 160.55,134.4
X$8432 6929 8581 8052 112 9461 113 AOI21_X1
* cell instance $8434 m0 *1 161.5,134.4
X$8434 9428 3571 9458 112 113 9457 NAND3_X1
* cell instance $8435 m0 *1 162.26,134.4
X$8435 9457 9428 9513 113 112 7866 OAI21_X4
* cell instance $8436 m0 *1 164.73,134.4
X$8436 9505 112 113 9514 BUF_X1
* cell instance $8437 m0 *1 165.3,134.4
X$8437 9637 9598 9594 112 9429 113 AOI21_X2
* cell instance $8438 m0 *1 166.63,134.4
X$8438 7022 7518 9454 112 113 9594 OR3_X1
* cell instance $8439 m0 *1 167.58,134.4
X$8439 9596 5401 9686 112 113 9515 NAND3_X1
* cell instance $8441 m0 *1 168.53,134.4
X$8441 9430 7362 5025 113 9591 112 NOR3_X2
* cell instance $8442 m0 *1 169.86,134.4
X$8442 112 9005 9591 9430 9590 113 AOI21_X4
* cell instance $8443 m0 *1 172.33,134.4
X$8443 9454 112 113 9589 BUF_X1
* cell instance $8444 m0 *1 172.9,134.4
X$8444 9587 9586 112 113 9516 XNOR2_X2
* cell instance $8445 m0 *1 174.8,134.4
X$8445 9584 9221 112 113 9587 XNOR2_X2
* cell instance $8446 m0 *1 176.7,134.4
X$8446 112 9452 9585 9583 9577 113 AOI21_X4
* cell instance $8447 m0 *1 179.17,134.4
X$8447 9580 9451 9573 112 9369 113 AOI21_X2
* cell instance $8448 m0 *1 180.5,134.4
X$8448 9449 9221 112 113 9577 NAND2_X1
* cell instance $8449 m0 *1 181.07,134.4
X$8449 9222 5065 112 113 9221 XNOR2_X2
* cell instance $8450 m0 *1 182.97,134.4
X$8450 9449 9450 112 113 9573 NAND2_X1
* cell instance $8453 r0 *1 160.55,134.4
X$8453 9512 113 8933 112 BUF_X4
* cell instance $8455 r0 *1 162.07,134.4
X$8455 9589 5194 7022 112 113 9598 NAND3_X1
* cell instance $8456 r0 *1 162.83,134.4
X$8456 9321 9592 9688 113 112 7917 MUX2_X2
* cell instance $8457 r0 *1 164.54,134.4
X$8457 112 6413 8718 113 BUF_X16
* cell instance $8458 r0 *1 169.29,134.4
X$8458 9890 9680 112 113 9604 XNOR2_X2
* cell instance $8459 r0 *1 171.19,134.4
X$8459 9505 9750 112 113 9642 XNOR2_X2
* cell instance $8460 r0 *1 173.09,134.4
X$8460 9367 9588 9516 113 112 9103 MUX2_X2
* cell instance $8461 r0 *1 174.8,134.4
X$8461 9579 9751 113 112 9586 XNOR2_X1
* cell instance $8462 r0 *1 175.94,134.4
X$8462 9841 9753 113 112 9580 XNOR2_X1
* cell instance $8463 r0 *1 177.08,134.4
X$8463 9584 7593 9217 112 113 9641 NAND3_X1
* cell instance $8464 r0 *1 177.84,134.4
X$8464 9326 9222 113 112 9684 XNOR2_X1
* cell instance $8465 r0 *1 178.98,134.4
X$8465 9505 112 113 9579 BUF_X1
* cell instance $8466 r0 *1 179.55,134.4
X$8466 9576 9682 112 113 9680 XNOR2_X2
* cell instance $8471 r0 *1 181.83,134.4
X$8471 9518 9431 112 113 9643 XNOR2_X2
* cell instance $8472 r0 *1 183.73,134.4
X$8472 5065 112 113 9517 BUF_X1
* cell instance $8473 r0 *1 184.3,134.4
X$8473 9643 112 113 9223 BUF_X1
* cell instance $8475 r0 *1 185.06,134.4
X$8475 7518 9519 112 113 9646 NOR2_X1
* cell instance $8476 m0 *1 185.63,134.4
X$8476 9237 9222 113 112 9447 XNOR2_X1
* cell instance $8478 m0 *1 186.77,134.4
X$8478 9323 9432 113 112 9520 XNOR2_X1
* cell instance $8480 m0 *1 188.1,134.4
X$8480 9520 9447 113 112 9522 XNOR2_X1
* cell instance $8483 m0 *1 193.04,134.4
X$8483 6939 6821 113 9539 112 XOR2_X2
* cell instance $8485 m0 *1 196.27,134.4
X$8485 9330 3780 9524 112 113 9523 NAND3_X1
* cell instance $8488 r0 *1 186.01,134.4
X$8488 9518 9566 112 113 9432 XNOR2_X2
* cell instance $8489 r0 *1 187.91,134.4
X$8489 5065 112 113 9566 BUF_X1
* cell instance $8490 r0 *1 188.48,134.4
X$8490 5065 112 113 9563 BUF_X1
* cell instance $8493 r0 *1 191.33,134.4
X$8493 5213 9563 113 9761 112 XOR2_X2
* cell instance $8496 r0 *1 194.18,134.4
X$8496 9647 9521 112 113 9673 XNOR2_X2
* cell instance $8497 r0 *1 196.08,134.4
X$8497 5395 9649 112 113 9561 NAND2_X1
* cell instance $8498 r0 *1 196.65,134.4
X$8498 9523 9330 9561 113 112 9895 OAI21_X2
* cell instance $8500 m0 *1 197.41,134.4
X$8500 9324 9524 113 9343 112 XOR2_X2
* cell instance $8501 m0 *1 199.31,134.4
X$8501 9558 4888 113 112 9560 XNOR2_X1
* cell instance $8503 m0 *1 200.64,134.4
X$8503 7974 9560 9433 113 9526 112 OAI21_X1
* cell instance $8508 r0 *1 198.36,134.4
X$8508 9554 9525 112 113 9650 XNOR2_X2
* cell instance $8509 r0 *1 200.26,134.4
X$8509 112 17070 9554 9526 8887 113 DFF_X1
* cell instance $8510 r0 *1 203.49,134.4
X$8510 9554 112 113 7426 BUF_X1
* cell instance $8512 m0 *1 204.25,134.4
X$8512 9555 4389 9445 112 113 9557 MUX2_X1
* cell instance $8514 m0 *1 205.58,134.4
X$8514 112 16844 9224 9557 8887 113 DFF_X1
* cell instance $8516 m0 *1 209,134.4
X$8516 9224 112 113 9552 BUF_X1
* cell instance $8518 r0 *1 204.44,134.4
X$8518 9655 8317 9434 112 113 9651 MUX2_X1
* cell instance $8520 r0 *1 205.96,134.4
X$8520 112 16945 9652 9553 8887 113 DFF_X1
* cell instance $8521 r0 *1 209.19,134.4
X$8521 9652 9306 9530 112 113 9553 MUX2_X1
* cell instance $8522 m0 *1 210.14,134.4
X$8522 9525 4888 113 112 9550 XNOR2_X1
* cell instance $8526 m0 *1 212.23,134.4
X$8526 112 16823 9525 9527 9238 113 DFF_X1
* cell instance $8527 m0 *1 215.46,134.4
X$8527 4841 112 113 9238 CLKBUF_X3
* cell instance $8530 m0 *1 217.36,134.4
X$8530 9525 112 113 9528 BUF_X1
* cell instance $8531 m0 *1 217.93,134.4
X$8531 9238 112 113 17200 INV_X1
* cell instance $8535 r0 *1 211.28,134.4
X$8535 9653 4389 9550 112 113 9527 MUX2_X1
* cell instance $8538 r0 *1 214.51,134.4
X$8538 112 9549 9238 17259 9428 113 DFF_X2
* cell instance $8539 r0 *1 218.12,134.4
X$8539 9428 8785 9663 112 113 9549 MUX2_X1
* cell instance $8541 r0 *1 219.64,134.4
X$8541 112 9547 9229 9430 9529 113 DFF_X2
* cell instance $8542 m0 *1 220.4,134.4
X$8542 5063 113 9548 112 BUF_X4
* cell instance $8547 m0 *1 225.72,134.4
X$8547 112 3405 9229 17229 9750 113 DFF_X2
* cell instance $8549 m0 *1 229.52,134.4
X$8549 112 9443 9656 17215 9330 113 DFF_X2
* cell instance $8552 r0 *1 223.25,134.4
X$8552 9529 8785 9665 112 113 9547 MUX2_X1
* cell instance $8555 r0 *1 225.15,134.4
X$8555 9767 9209 9019 112 113 9654 MUX2_X1
* cell instance $8556 r0 *1 226.48,134.4
X$8556 112 17040 9655 9544 9656 113 DFF_X1
* cell instance $8557 r0 *1 229.71,134.4
X$8557 9655 9209 9542 112 113 9544 MUX2_X1
* cell instance $8561 r0 *1 233.7,134.4
X$8561 9657 112 113 9542 BUF_X1
* cell instance $8562 m0 *1 237.5,134.4
X$8562 9536 112 113 9533 BUF_X1
* cell instance $8563 m0 *1 234.27,134.4
X$8563 112 16829 9536 9539 8794 113 DFF_X1
* cell instance $8568 r0 *1 234.46,134.4
X$8568 9659 112 113 9530 BUF_X1
* cell instance $8569 r0 *1 235.03,134.4
X$8569 9537 112 113 9540 BUF_X1
* cell instance $8575 r0 *1 237.88,134.4
X$8575 10866 112 113 9532 BUF_X1
* cell instance $8580 m0 *1 10.26,142.8
X$8580 10162 112 113 10101 BUF_X1
* cell instance $8585 r0 *1 10.26,142.8
X$8585 10100 112 113 10325 BUF_X2
* cell instance $8588 r0 *1 11.59,142.8
X$8588 10380 112 113 10217 BUF_X1
* cell instance $8592 m0 *1 12.54,142.8
X$8592 112 16797 10164 10163 9946 113 DFF_X1
* cell instance $8593 m0 *1 11.97,142.8
X$8593 10164 112 113 10099 BUF_X1
* cell instance $8594 m0 *1 15.77,142.8
X$8594 10275 112 113 10102 BUF_X1
* cell instance $8599 r0 *1 13.3,142.8
X$8599 10220 112 113 10277 BUF_X1
* cell instance $8600 r0 *1 13.87,142.8
X$8600 10279 112 113 10218 BUF_X1
* cell instance $8604 r0 *1 16.91,142.8
X$8604 112 16986 10275 10381 9946 113 DFF_X1
* cell instance $8605 m0 *1 18.81,142.8
X$8605 6050 112 113 9946 CLKBUF_X3
* cell instance $8606 m0 *1 18.24,142.8
X$8606 10018 112 113 10219 BUF_X1
* cell instance $8607 m0 *1 19.76,142.8
X$8607 9946 112 113 17165 INV_X2
* cell instance $8612 m0 *1 35.72,142.8
X$8612 10450 10314 16568 113 112 10165 HA_X1
* cell instance $8614 m0 *1 38.38,142.8
X$8614 10103 9949 10107 112 113 NOR2_X4
* cell instance $8616 m0 *1 40.85,142.8
X$8616 112 10104 9949 10103 10742 113 NOR3_X4
* cell instance $8618 r0 *1 20.14,142.8
X$8618 112 16987 10380 10221 10313 113 DFF_X1
* cell instance $8621 r0 *1 25.08,142.8
X$8621 10384 8585 11323 112 113 10386 MUX2_X1
* cell instance $8622 r0 *1 26.41,142.8
X$8622 112 10386 10313 10112 10384 113 DFF_X2
* cell instance $8623 r0 *1 30.02,142.8
X$8623 112 17047 10279 10318 9399 113 DFF_X1
* cell instance $8626 r0 *1 34.96,142.8
X$8626 112 10222 9949 10103 10280 113 NOR3_X4
* cell instance $8628 r0 *1 37.81,142.8
X$8628 112 10507 9949 10103 10390 113 NOR3_X4
* cell instance $8630 r0 *1 40.66,142.8
X$8630 10316 10224 112 10169 113 OR2_X4
* cell instance $8632 r0 *1 43.13,142.8
X$8632 10394 113 10223 112 BUF_X4
* cell instance $8633 m0 *1 44.08,142.8
X$8633 112 10223 9949 10103 10284 113 NOR3_X4
* cell instance $8636 r0 *1 44.46,142.8
X$8636 10224 10103 9949 113 112 10550 OAI21_X4
* cell instance $8638 r0 *1 47.12,142.8
X$8638 10286 10225 112 10396 113 OR2_X4
* cell instance $8639 m0 *1 47.31,142.8
X$8639 10107 10105 112 113 10455 NAND2_X1
* cell instance $8641 m0 *1 47.88,142.8
X$8641 9950 9866 112 10226 113 NAND2_X4
* cell instance $8643 m0 *1 49.78,142.8
X$8643 9948 10319 112 113 10227 NAND2_X1
* cell instance $8644 m0 *1 50.35,142.8
X$8644 112 10229 10401 113 INV_X32
* cell instance $8645 m0 *1 56.62,142.8
X$8645 112 10230 113 9865 BUF_X8
* cell instance $8646 m0 *1 59.09,142.8
X$8646 9909 112 113 10231 INV_X1
* cell instance $8649 m0 *1 60.42,142.8
X$8649 10231 8403 112 113 10170 NAND2_X1
* cell instance $8650 m0 *1 60.99,142.8
X$8650 10232 10104 10106 112 113 NOR2_X4
* cell instance $8651 m0 *1 62.7,142.8
X$8651 10041 113 9950 112 BUF_X4
* cell instance $8652 m0 *1 64.03,142.8
X$8652 9914 113 10228 112 BUF_X4
* cell instance $8654 m0 *1 65.55,142.8
X$8654 112 16900 10292 10233 10234 113 DFF_X1
* cell instance $8657 r0 *1 49.02,142.8
X$8657 10226 113 10457 112 BUF_X4
* cell instance $8658 r0 *1 50.35,142.8
X$8658 9865 113 10398 112 BUF_X4
* cell instance $8659 r0 *1 51.68,142.8
X$8659 112 10398 10229 113 BUF_X16
* cell instance $8660 r0 *1 56.43,142.8
X$8660 10519 10108 10396 113 112 10408 OAI21_X4
* cell instance $8661 r0 *1 58.9,142.8
X$8661 10232 113 10326 112 BUF_X4
* cell instance $8664 r0 *1 61.18,142.8
X$8664 112 10232 9949 10103 10406 113 NOR3_X4
* cell instance $8665 r0 *1 63.84,142.8
X$8665 9914 112 113 10232 INV_X2
* cell instance $8667 r0 *1 65.17,142.8
X$8667 8865 112 113 10328 INV_X1
* cell instance $8669 r0 *1 65.93,142.8
X$8669 3639 10328 112 113 10413 NOR2_X1
* cell instance $8671 r0 *1 66.69,142.8
X$8671 3639 8865 112 113 10414 NOR2_X1
* cell instance $8672 r0 *1 67.26,142.8
X$8672 9203 8865 113 10221 112 XOR2_X2
* cell instance $8678 m0 *1 69.16,142.8
X$8678 112 9081 113 10292 BUF_X8
* cell instance $8679 m0 *1 73.15,142.8
X$8679 10109 112 113 10175 INV_X1
* cell instance $8680 m0 *1 73.53,142.8
X$8680 10110 5170 10175 112 113 10236 NOR3_X1
* cell instance $8681 m0 *1 74.29,142.8
X$8681 8133 112 113 8941 CLKBUF_X3
* cell instance $8682 m0 *1 75.24,142.8
X$8682 10110 5170 10109 112 113 10294 NOR3_X1
* cell instance $8684 m0 *1 76.19,142.8
X$8684 8984 10047 113 10113 112 XOR2_X2
* cell instance $8686 m0 *1 79.42,142.8
X$8686 10295 5995 9661 112 113 10238 MUX2_X1
* cell instance $8689 m0 *1 81.7,142.8
X$8689 5393 9956 112 113 10179 NOR2_X1
* cell instance $8690 m0 *1 82.27,142.8
X$8690 10239 10179 9724 113 112 10563 MUX2_X2
* cell instance $8695 r0 *1 71.82,142.8
X$8695 8622 8036 113 10318 112 XOR2_X2
* cell instance $8696 r0 *1 73.53,142.8
X$8696 10236 10294 8769 113 112 10331 MUX2_X2
* cell instance $8700 r0 *1 77.33,142.8
X$8700 8432 9091 113 10381 112 XOR2_X2
* cell instance $8702 r0 *1 79.42,142.8
X$8702 112 17066 10295 10238 8941 113 DFF_X1
* cell instance $8704 m0 *1 85.69,142.8
X$8704 9956 112 113 10181 BUF_X1
* cell instance $8705 m0 *1 84.36,142.8
X$8705 9337 3571 9956 112 113 10297 NAND3_X2
* cell instance $8707 m0 *1 89.3,142.8
X$8707 10112 10114 10115 113 10183 112 OAI21_X1
* cell instance $8708 m0 *1 90.06,142.8
X$8708 10112 8870 10185 112 113 10115 NAND3_X1
* cell instance $8710 m0 *1 91.01,142.8
X$8710 112 10116 9959 8388 10186 10113 113 OAI211_X4
* cell instance $8712 m0 *1 94.43,142.8
X$8712 8761 10300 113 10163 112 XOR2_X2
* cell instance $8713 m0 *1 96.14,142.8
X$8713 112 8761 113 10117 BUF_X8
* cell instance $8714 m0 *1 98.61,142.8
X$8714 112 16771 10119 10118 8992 113 DFF_X1
* cell instance $8718 m0 *1 105.83,142.8
X$8718 10121 113 10127 112 BUF_X4
* cell instance $8719 m0 *1 107.16,142.8
X$8719 9701 10193 10302 10241 10123 113 112 10122 OAI221_X1
* cell instance $8721 m0 *1 108.49,142.8
X$8721 10199 10124 10121 113 10303 112 OAI21_X1
* cell instance $8724 r0 *1 89.11,142.8
X$8724 10423 112 113 8432 CLKBUF_X3
* cell instance $8728 r0 *1 102.41,142.8
X$8728 112 10811 113 7654 BUF_X8
* cell instance $8730 r0 *1 105.26,142.8
X$8730 9973 112 113 10240 CLKBUF_X3
* cell instance $8731 r0 *1 106.21,142.8
X$8731 9971 10433 9980 10336 10335 112 113 OAI211_X2
* cell instance $8732 r0 *1 107.92,142.8
X$8732 10240 9701 112 113 10241 NAND2_X1
* cell instance $8733 r0 *1 108.49,142.8
X$8733 10436 10338 10469 10303 9980 10433 112 113 OAI221_X2
* cell instance $8734 m0 *1 109.82,142.8
X$8734 9941 113 10243 112 BUF_X4
* cell instance $8736 m0 *1 111.15,142.8
X$8736 10194 10198 112 113 10199 NAND2_X1
* cell instance $8738 m0 *1 112.48,142.8
X$8738 10305 10242 10203 9731 9631 113 112 10193 OAI221_X1
* cell instance $8741 m0 *1 114.57,142.8
X$8741 9827 10125 112 113 10244 NOR2_X1
* cell instance $8744 r0 *1 111.34,142.8
X$8744 10247 10342 10304 112 113 10242 MUX2_X1
* cell instance $8745 r0 *1 112.67,142.8
X$8745 10307 10203 10243 10121 112 113 10337 NAND4_X1
* cell instance $8747 r0 *1 114,142.8
X$8747 10244 10345 10439 113 10307 112 OAI21_X1
* cell instance $8749 r0 *1 115.14,142.8
X$8749 9940 10084 112 113 10345 NOR2_X1
* cell instance $8751 m0 *1 115.52,142.8
X$8751 9875 10202 10245 112 113 10203 NAND3_X1
* cell instance $8753 m0 *1 120.84,142.8
X$8753 10205 10246 9975 112 10310 113 AOI21_X1
* cell instance $8756 r0 *1 115.71,142.8
X$8756 9940 10256 112 113 10202 NAND2_X2
* cell instance $8760 r0 *1 117.99,142.8
X$8760 9827 10077 10344 10473 113 112 9972 OAI22_X1
* cell instance $8762 r0 *1 119.32,142.8
X$8762 10247 10440 10470 112 113 10246 MUX2_X1
* cell instance $8765 r0 *1 122.55,142.8
X$8765 9942 113 10121 112 BUF_X4
* cell instance $8766 r0 *1 123.88,142.8
X$8766 10444 10074 10348 10342 112 113 10205 NOR4_X1
* cell instance $8771 m0 *1 125.21,142.8
X$8771 10125 10130 9732 112 113 10249 MUX2_X1
* cell instance $8775 r0 *1 125.21,142.8
X$8775 10247 10445 10250 10198 10249 113 112 10078 OAI221_X1
* cell instance $8776 r0 *1 126.35,142.8
X$8776 10125 10445 10250 10475 10198 113 112 10350 OAI221_X1
* cell instance $8777 r0 *1 127.49,142.8
X$8777 9631 9731 10350 10443 10474 113 112 10308 OAI221_X1
* cell instance $8778 m0 *1 127.87,142.8
X$8778 10127 10200 10209 10087 113 10302 112 NOR4_X2
* cell instance $8780 m0 *1 129.58,142.8
X$8780 10130 112 113 9979 CLKBUF_X3
* cell instance $8781 m0 *1 130.53,142.8
X$8781 10211 10351 10200 112 113 10207 OR3_X2
* cell instance $8782 m0 *1 131.67,142.8
X$8782 10214 10074 10253 10306 113 112 10211 OAI22_X1
* cell instance $8783 m0 *1 132.62,142.8
X$8783 10133 10198 10131 112 10214 113 AOI21_X1
* cell instance $8785 r0 *1 128.63,142.8
X$8785 9731 9631 112 113 10447 NOR2_X2
* cell instance $8788 r0 *1 130.15,142.8
X$8788 9964 10250 112 113 10253 NAND2_X2
* cell instance $8790 r0 *1 131.48,142.8
X$8790 10198 10353 10354 113 10306 112 OAI21_X1
* cell instance $8793 r0 *1 132.81,142.8
X$8793 9731 9631 10355 10254 10442 113 112 AOI211_X2
* cell instance $8794 m0 *1 134.33,142.8
X$8794 10057 10134 112 113 10131 NAND2_X1
* cell instance $8795 m0 *1 133.76,142.8
X$8795 10216 9979 112 113 10215 NOR2_X1
* cell instance $8797 r0 *1 134.52,142.8
X$8797 10355 10254 10256 112 113 10134 NAND3_X2
* cell instance $8799 m0 *1 135.28,142.8
X$8799 112 10132 10304 10210 10135 113 AOI21_X4
* cell instance $8802 r0 *1 136.99,142.8
X$8802 112 10355 113 10210 BUF_X8
* cell instance $8803 m0 *1 138.32,142.8
X$8803 10212 113 9733 112 BUF_X4
* cell instance $8806 m0 *1 139.84,142.8
X$8806 10137 112 113 10212 INV_X1
* cell instance $8809 m0 *1 144.78,142.8
X$8809 112 10135 113 10208 BUF_X8
* cell instance $8810 m0 *1 147.25,142.8
X$8810 112 9984 10085 10206 9850 113 DFF_X1
* cell instance $8814 r0 *1 139.65,142.8
X$8814 112 10212 10136 10096 10257 113 NOR3_X4
* cell instance $8815 r0 *1 142.31,142.8
X$8815 5114 5705 112 113 10711 XNOR2_X2
* cell instance $8816 r0 *1 144.21,142.8
X$8816 5705 5114 113 10356 112 XOR2_X2
* cell instance $8819 r0 *1 147.06,142.8
X$8819 4172 9509 113 10389 112 XOR2_X2
* cell instance $8820 r0 *1 148.77,142.8
X$8820 9524 9509 113 10357 112 XOR2_X2
* cell instance $8821 r0 *1 150.48,142.8
X$8821 8539 112 113 9850 CLKBUF_X3
* cell instance $8823 m0 *1 151.81,142.8
X$8823 112 9884 10301 10258 9036 113 DFF_X1
* cell instance $8825 m0 *1 155.04,142.8
X$8825 112 6413 8870 113 BUF_X32
* cell instance $8826 m0 *1 164.35,142.8
X$8826 10259 9888 112 113 10520 NAND2_X1
* cell instance $8828 r0 *1 151.62,142.8
X$8828 10301 9306 10435 112 113 10258 MUX2_X1
* cell instance $8831 r0 *1 156.37,142.8
X$8831 112 6773 113 8148 BUF_X8
* cell instance $8833 r0 *1 159.22,142.8
X$8833 10259 9886 112 113 10139 NAND2_X1
* cell instance $8834 r0 *1 159.79,142.8
X$8834 112 8577 4950 113 BUF_X32
* cell instance $8835 m0 *1 166.44,142.8
X$8835 9703 9548 113 10141 112 XOR2_X2
* cell instance $8836 m0 *1 165.3,142.8
X$8836 9703 9989 113 112 9889 XNOR2_X1
* cell instance $8837 m0 *1 168.15,142.8
X$8837 9548 9703 112 113 10261 XNOR2_X2
* cell instance $8838 m0 *1 170.05,142.8
X$8838 10141 9989 113 112 9890 XNOR2_X1
* cell instance $8839 m0 *1 171.19,142.8
X$8839 10141 8148 8059 112 113 10296 NAND3_X1
* cell instance $8841 r0 *1 169.1,142.8
X$8841 10427 6503 10298 112 113 10518 NAND3_X1
* cell instance $8842 r0 *1 169.86,142.8
X$8842 10260 9993 112 113 10424 XOR2_X1
* cell instance $8843 r0 *1 171,142.8
X$8843 10260 9993 113 112 10362 XNOR2_X1
* cell instance $8844 r0 *1 172.14,142.8
X$8844 9887 10261 113 112 10262 XNOR2_X1
* cell instance $8846 m0 *1 172.33,142.8
X$8846 9887 10141 113 112 10191 XNOR2_X1
* cell instance $8847 m0 *1 173.66,142.8
X$8847 9990 113 10059 112 BUF_X4
* cell instance $8848 m0 *1 174.99,142.8
X$8848 10191 9641 9994 112 10263 113 AOI21_X2
* cell instance $8849 m0 *1 176.32,142.8
X$8849 9640 112 113 9883 BUF_X1
* cell instance $8851 r0 *1 173.28,142.8
X$8851 10262 9992 10192 112 10421 113 AOI21_X2
* cell instance $8853 r0 *1 174.99,142.8
X$8853 10364 7114 10142 112 113 10420 NAND3_X1
* cell instance $8854 r0 *1 175.75,142.8
X$8854 10420 10364 10293 113 112 10363 OAI21_X2
* cell instance $8856 m0 *1 177.84,142.8
X$8856 7114 9217 112 113 10293 NAND2_X1
* cell instance $8857 m0 *1 177.27,142.8
X$8857 9752 112 113 9836 BUF_X1
* cell instance $8861 m0 *1 178.79,142.8
X$8861 5401 9999 112 113 10146 NOR2_X1
* cell instance $8862 m0 *1 180.12,142.8
X$8862 10144 10145 112 113 10188 XNOR2_X2
* cell instance $8864 m0 *1 182.21,142.8
X$8864 10146 10264 112 113 10180 NAND2_X1
* cell instance $8865 m0 *1 182.78,142.8
X$8865 10146 9997 112 113 10265 NAND2_X1
* cell instance $8866 m0 *1 183.35,142.8
X$8866 9997 7362 9999 112 113 10184 NAND3_X1
* cell instance $8868 m0 *1 184.3,142.8
X$8868 10148 10184 10180 112 10290 113 AOI21_X1
* cell instance $8869 m0 *1 185.06,142.8
X$8869 10182 112 113 9324 CLKBUF_X3
* cell instance $8870 m0 *1 186.01,142.8
X$8870 9921 112 113 10177 BUF_X1
* cell instance $8872 m0 *1 186.77,142.8
X$8872 9887 9729 113 112 10416 XNOR2_X1
* cell instance $8875 m0 *1 188.86,142.8
X$8875 10150 10176 112 113 9737 XNOR2_X2
* cell instance $8878 r0 *1 179.36,142.8
X$8878 9988 5213 113 112 10482 XNOR2_X1
* cell instance $8885 r0 *1 182.59,142.8
X$8885 10264 5240 9999 112 113 10418 NAND3_X1
* cell instance $8886 r0 *1 183.35,142.8
X$8886 10147 10265 10418 112 10291 113 AOI21_X1
* cell instance $8887 r0 *1 184.11,142.8
X$8887 9518 9431 112 113 10264 XOR2_X1
* cell instance $8888 r0 *1 185.25,142.8
X$8888 10178 10290 10291 112 113 10840 OR3_X4
* cell instance $8890 r0 *1 187.72,142.8
X$8890 9518 10416 112 113 10514 XNOR2_X2
* cell instance $8892 r0 *1 189.81,142.8
X$8892 6273 10415 113 9779 112 XOR2_X2
* cell instance $8893 r0 *1 191.52,142.8
X$8893 9761 10266 113 112 10365 XNOR2_X1
* cell instance $8894 m0 *1 193.04,142.8
X$8894 10001 9737 113 112 10289 XNOR2_X1
* cell instance $8895 m0 *1 191.9,142.8
X$8895 9548 10000 113 112 10266 XNOR2_X1
* cell instance $8899 m0 *1 198.17,142.8
X$8899 3527 10171 112 113 10173 NOR2_X1
* cell instance $8900 m0 *1 198.74,142.8
X$8900 3527 9672 112 113 10172 NOR2_X1
* cell instance $8901 m0 *1 199.31,142.8
X$8901 9672 112 113 10171 INV_X1
* cell instance $8902 m0 *1 199.69,142.8
X$8902 10154 5250 9672 112 113 10287 NAND3_X1
* cell instance $8905 r0 *1 193.04,142.8
X$8905 9431 10267 113 10009 112 XOR2_X2
* cell instance $8907 r0 *1 194.94,142.8
X$8907 8718 7675 112 113 10411 NOR2_X1
* cell instance $8909 r0 *1 195.7,142.8
X$8909 8718 10486 112 113 10412 NOR2_X1
* cell instance $8913 r0 *1 198.36,142.8
X$8913 8434 10171 112 113 10288 NAND2_X1
* cell instance $8914 r0 *1 198.93,142.8
X$8914 10287 10288 10154 113 112 10852 OAI21_X4
* cell instance $8915 m0 *1 201.4,142.8
X$8915 10152 10153 10168 113 112 10371 MUX2_X2
* cell instance $8916 m0 *1 200.83,142.8
X$8916 4678 10268 112 113 10152 NOR2_X1
* cell instance $8919 r0 *1 201.4,142.8
X$8919 7738 9108 112 113 10369 NAND2_X1
* cell instance $8921 r0 *1 202.16,142.8
X$8921 10370 3672 10268 112 113 10407 NAND3_X1
* cell instance $8924 r0 *1 203.49,142.8
X$8924 9108 112 113 10268 INV_X1
* cell instance $8926 m0 *1 204.44,142.8
X$8926 112 10285 10024 17219 9996 113 DFF_X2
* cell instance $8930 r0 *1 204.82,142.8
X$8930 8348 9328 112 113 10399 XNOR2_X2
* cell instance $8933 m0 *1 212.04,142.8
X$8933 10283 9209 10281 112 113 10269 MUX2_X1
* cell instance $8934 m0 *1 208.43,142.8
X$8934 112 10269 10024 10154 10283 113 DFF_X2
* cell instance $8936 r0 *1 208.62,142.8
X$8936 112 17051 10007 10397 10024 113 DFF_X1
* cell instance $8938 m0 *1 213.94,142.8
X$8938 4841 112 113 10024 CLKBUF_X3
* cell instance $8940 m0 *1 214.89,142.8
X$8940 10024 112 113 16459 CLKBUF_X1
* cell instance $8941 m0 *1 215.46,142.8
X$8941 112 16923 10027 10156 10024 113 DFF_X1
* cell instance $8944 m0 *1 219.26,142.8
X$8944 9528 9990 112 113 10282 XOR2_X1
* cell instance $8948 m0 *1 222.11,142.8
X$8948 10166 113 9518 112 BUF_X4
* cell instance $8951 m0 *1 226.67,142.8
X$8951 112 16881 10159 10282 10158 113 DFF_X1
* cell instance $8952 m0 *1 229.9,142.8
X$8952 112 16840 10378 10023 10158 113 DFF_X1
* cell instance $8953 m0 *1 233.13,142.8
X$8953 112 16827 8595 10278 10158 113 DFF_X1
* cell instance $8954 m0 *1 236.36,142.8
X$8954 4841 112 113 10158 CLKBUF_X3
* cell instance $8955 m0 *1 237.31,142.8
X$8955 10160 112 113 9242 BUF_X1
* cell instance $8960 r0 *1 220.02,142.8
X$8960 112 16956 10166 10270 10376 113 DFF_X1
* cell instance $8961 r0 *1 223.25,142.8
X$8961 10370 9209 10387 112 113 10506 MUX2_X1
* cell instance $8964 r0 *1 225.15,142.8
X$8964 7675 9822 112 113 10395 XOR2_X1
* cell instance $8966 r0 *1 227.05,142.8
X$8966 112 16976 10383 10395 10376 113 DFF_X1
* cell instance $8967 r0 *1 230.28,142.8
X$8967 10379 112 113 9555 BUF_X1
* cell instance $8968 r0 *1 230.85,142.8
X$8968 8059 9887 112 113 10391 XOR2_X1
* cell instance $8969 r0 *1 231.99,142.8
X$8969 112 16967 10388 10389 10158 113 DFF_X1
* cell instance $8970 r0 *1 235.22,142.8
X$8970 10388 112 113 10272 BUF_X1
* cell instance $8975 r0 *1 236.55,142.8
X$8975 10014 112 113 10276 BUF_X1
* cell instance $8976 r0 *1 237.12,142.8
X$8976 10161 112 113 10387 BUF_X1
* cell instance $8977 r0 *1 237.69,142.8
X$8977 10159 112 113 10274 BUF_X1
* cell instance $8979 r0 *1 238.64,142.8
X$8979 10383 112 113 10271 BUF_X1
* cell instance $8980 m0 *1 239.21,142.8
X$8980 10012 112 113 10015 BUF_X1
* cell instance $8986 m0 *1 239.21,89.6
X$8986 5671 112 113 5663 BUF_X1
* cell instance $8990 r0 *1 239.21,89.6
X$8990 5774 112 113 5445 BUF_X1
* cell instance $8992 m0 *1 10.26,86.8
X$8992 5311 112 113 5363 BUF_X1
* cell instance $8997 m0 *1 20.71,86.8
X$8997 4776 3811 16559 113 112 5434 HA_X1
* cell instance $8998 m0 *1 22.61,86.8
X$8998 3661 4776 6299 113 112 4413 HA_X1
* cell instance $9000 m0 *1 25.27,86.8
X$9000 3973 4614 4460 112 5136 113 AOI21_X1
* cell instance $9003 r0 *1 10.26,86.8
X$9003 112 17120 5433 5369 5133 113 DFF_X1
* cell instance $9007 r0 *1 13.49,86.8
X$9007 5433 112 113 5361 BUF_X1
* cell instance $9008 r0 *1 14.06,86.8
X$9008 5567 112 113 5362 BUF_X1
* cell instance $9014 r0 *1 23.56,86.8
X$9014 5434 112 113 5516 CLKBUF_X3
* cell instance $9015 r0 *1 24.51,86.8
X$9015 5454 112 113 4180 CLKBUF_X3
* cell instance $9016 r0 *1 25.46,86.8
X$9016 5515 113 4514 112 BUF_X4
* cell instance $9017 m0 *1 26.6,86.8
X$9017 3764 5439 112 113 5253 NAND2_X1
* cell instance $9020 m0 *1 27.36,86.8
X$9020 5441 3974 5442 112 113 5254 MUX2_X1
* cell instance $9021 m0 *1 28.69,86.8
X$9021 4993 4180 5214 112 113 5442 MUX2_X1
* cell instance $9024 r0 *1 26.79,86.8
X$9024 5513 4613 4611 112 113 5440 MUX2_X1
* cell instance $9025 r0 *1 28.12,86.8
X$9025 4844 4840 5515 112 113 4993 MUX2_X1
* cell instance $9028 r0 *1 30.4,86.8
X$9028 4840 5454 112 113 5143 XNOR2_X2
* cell instance $9029 m0 *1 31.35,86.8
X$9029 5570 3764 5447 112 113 5441 MUX2_X1
* cell instance $9031 m0 *1 32.68,86.8
X$9031 4290 5256 4997 112 113 5257 MUX2_X1
* cell instance $9034 r0 *1 32.3,86.8
X$9034 5516 112 113 4997 INV_X1
* cell instance $9037 r0 *1 33.25,86.8
X$9037 5137 5143 5517 4520 4850 113 112 5519 OAI221_X1
* cell instance $9040 r0 *1 34.96,86.8
X$9040 5519 3974 5731 112 113 5577 MUX2_X1
* cell instance $9042 m0 *1 35.15,86.8
X$9042 3811 4354 5364 113 5324 112 OAI21_X1
* cell instance $9044 m0 *1 37.62,86.8
X$9044 5454 5256 112 113 5002 NAND2_X2
* cell instance $9045 m0 *1 38.57,86.8
X$9045 5326 5327 5455 4955 113 112 5328 OAI22_X2
* cell instance $9046 m0 *1 40.28,86.8
X$9046 5002 3811 5365 4850 5259 5327 112 113 OAI221_X2
* cell instance $9048 m0 *1 42.56,86.8
X$9048 4411 5256 112 113 5366 NAND2_X1
* cell instance $9051 r0 *1 36.67,86.8
X$9051 5577 4069 5578 112 113 5142 MUX2_X1
* cell instance $9054 r0 *1 38.57,86.8
X$9054 4024 5682 5143 3715 112 113 5455 AOI22_X2
* cell instance $9055 r0 *1 40.28,86.8
X$9055 3973 4514 112 113 5521 NOR2_X1
* cell instance $9056 r0 *1 40.85,86.8
X$9056 3661 5143 5368 4520 113 112 5522 OAI22_X1
* cell instance $9057 r0 *1 41.8,86.8
X$9057 4791 3661 3856 112 5365 113 AOI21_X1
* cell instance $9059 r0 *1 42.75,86.8
X$9059 3975 5366 4462 5733 113 112 4472 OAI22_X1
* cell instance $9061 m0 *1 43.51,86.8
X$9061 4015 3861 5004 5330 4616 112 113 5367 AOI221_X1
* cell instance $9062 m0 *1 44.84,86.8
X$9062 3811 5330 5368 3861 112 113 5079 AOI22_X1
* cell instance $9064 m0 *1 45.98,86.8
X$9064 4413 4294 4347 113 112 5260 OAI21_X2
* cell instance $9066 m0 *1 47.5,86.8
X$9066 3762 5447 4623 4291 4619 113 112 5335 OAI221_X1
* cell instance $9067 m0 *1 48.64,86.8
X$9067 4788 5146 4460 112 113 5524 NAND3_X1
* cell instance $9069 m0 *1 49.59,86.8
X$9069 4301 4789 5261 113 112 5463 AND3_X1
* cell instance $9070 m0 *1 50.54,86.8
X$9070 5463 4955 5689 112 4624 113 AOI21_X1
* cell instance $9071 m0 *1 51.3,86.8
X$9071 4619 5368 112 113 5265 NOR2_X1
* cell instance $9073 r0 *1 43.7,86.8
X$9073 5440 4141 5367 112 113 5588 MUX2_X1
* cell instance $9075 r0 *1 45.22,86.8
X$9075 5462 5008 4475 112 113 4789 NAND3_X1
* cell instance $9076 r0 *1 45.98,86.8
X$9076 112 4024 113 5137 BUF_X8
* cell instance $9077 r0 *1 48.45,86.8
X$9077 5462 4192 112 5447 113 NAND2_X4
* cell instance $9078 r0 *1 50.16,86.8
X$9078 4024 5366 3854 4526 4702 113 112 5590 OAI221_X1
* cell instance $9080 r0 *1 51.49,86.8
X$9080 5588 5226 5258 4471 5594 5589 112 113 OAI221_X2
* cell instance $9082 m0 *1 52.25,86.8
X$9082 4623 5260 112 113 5466 NAND2_X1
* cell instance $9083 m0 *1 55.29,86.8
X$9083 4024 4525 5340 4526 5147 5468 112 113 OAI221_X2
* cell instance $9084 m0 *1 53.2,86.8
X$9084 5468 5264 5466 5265 4244 4363 112 113 OAI221_X2
* cell instance $9087 r0 *1 53.58,86.8
X$9087 5370 4025 5335 113 112 5594 AND3_X1
* cell instance $9089 r0 *1 54.72,86.8
X$9089 4783 4348 3855 112 5525 113 AOI21_X1
* cell instance $9090 r0 *1 55.48,86.8
X$9090 5226 5591 113 112 5148 AND2_X1
* cell instance $9092 r0 *1 57.76,86.8
X$9092 4244 5370 112 113 5470 NAND2_X1
* cell instance $9094 r0 *1 58.52,86.8
X$9094 5342 5370 5471 5470 5589 5507 112 113 OAI221_X2
* cell instance $9096 m0 *1 59.28,86.8
X$9096 4025 5370 112 113 5345 NOR2_X1
* cell instance $9099 r0 *1 60.61,86.8
X$9099 112 17086 5692 4141 4795 113 DFF_X1
* cell instance $9102 r0 *1 65.55,86.8
X$9102 5371 3363 113 5369 112 XOR2_X2
* cell instance $9103 m0 *1 67.64,86.8
X$9103 112 4200 113 5096 BUF_X8
* cell instance $9104 m0 *1 67.07,86.8
X$9104 5228 4629 112 113 5089 NOR2_X1
* cell instance $9105 m0 *1 70.11,86.8
X$9105 5096 4366 113 112 5268 XNOR2_X1
* cell instance $9106 m0 *1 71.25,86.8
X$9106 4724 4368 112 113 5350 NOR2_X1
* cell instance $9107 m0 *1 71.82,86.8
X$9107 5372 5275 4305 112 113 5476 NOR3_X1
* cell instance $9108 m0 *1 72.58,86.8
X$9108 5476 4368 5268 112 5349 113 AOI21_X1
* cell instance $9109 m0 *1 73.34,86.8
X$9109 5531 5267 5090 112 113 4531 NAND3_X1
* cell instance $9110 m0 *1 74.1,86.8
X$9110 112 4630 4252 5270 5269 113 AOI21_X4
* cell instance $9111 m0 *1 76.57,86.8
X$9111 112 5159 3982 5270 5269 113 AOI21_X4
* cell instance $9112 m0 *1 79.04,86.8
X$9112 4432 4631 5358 113 5356 112 OAI21_X1
* cell instance $9113 m0 *1 79.8,86.8
X$9113 3985 5156 4535 113 112 5271 OAI21_X2
* cell instance $9115 m0 *1 81.32,86.8
X$9115 5010 113 5274 112 BUF_X4
* cell instance $9116 m0 *1 82.65,86.8
X$9116 4724 4732 4307 113 5358 112 OAI21_X1
* cell instance $9117 m0 *1 83.41,86.8
X$9117 5275 4535 3985 112 113 5276 NOR3_X1
* cell instance $9118 m0 *1 84.17,86.8
X$9118 5276 4095 5268 112 5378 113 AOI21_X1
* cell instance $9119 m0 *1 84.93,86.8
X$9119 5091 5276 112 113 5277 NOR2_X1
* cell instance $9120 m0 *1 85.5,86.8
X$9120 5277 5482 5377 4642 5483 112 113 5278 AOI221_X1
* cell instance $9122 m0 *1 86.83,86.8
X$9122 5378 4492 4871 5379 4804 113 112 5279 OAI221_X1
* cell instance $9124 m0 *1 88.16,86.8
X$9124 4745 5274 4253 112 5487 113 AOI21_X1
* cell instance $9125 m0 *1 88.92,86.8
X$9125 4630 4728 3870 113 5380 112 OAI21_X1
* cell instance $9126 m0 *1 89.68,86.8
X$9126 4380 5487 5155 112 5492 113 AOI21_X1
* cell instance $9127 m0 *1 90.44,86.8
X$9127 5156 4430 3987 112 5382 113 AOI21_X1
* cell instance $9129 r0 *1 67.26,86.8
X$9129 5621 113 5149 112 BUF_X4
* cell instance $9133 r0 *1 68.59,86.8
X$9133 4796 5149 5620 113 5152 112 NOR3_X2
* cell instance $9134 r0 *1 69.92,86.8
X$9134 4480 5475 113 112 5529 AND2_X1
* cell instance $9136 r0 *1 70.87,86.8
X$9136 4899 5372 112 113 5534 OR2_X1
* cell instance $9137 r0 *1 71.63,86.8
X$9137 5373 5530 4424 113 5374 112 OAI21_X1
* cell instance $9138 r0 *1 72.39,86.8
X$9138 5228 3922 112 113 5532 NOR2_X1
* cell instance $9139 r0 *1 72.96,86.8
X$9139 4306 4368 5091 4981 5350 5375 113 112 AOI221_X2
* cell instance $9141 r0 *1 75.43,86.8
X$9141 4724 4029 4488 112 5701 113 AOI21_X2
* cell instance $9143 r0 *1 76.95,86.8
X$9143 5096 113 3984 112 BUF_X4
* cell instance $9144 r0 *1 78.28,86.8
X$9144 4639 5376 112 113 4084 NAND2_X1
* cell instance $9145 r0 *1 78.85,86.8
X$9145 4368 5479 5271 113 5600 112 OAI21_X1
* cell instance $9146 r0 *1 79.61,86.8
X$9146 4088 4488 5706 113 5479 112 OAI21_X1
* cell instance $9147 r0 *1 80.37,86.8
X$9147 5356 4088 5480 5599 4537 5357 113 112 AOI221_X2
* cell instance $9148 r0 *1 82.46,86.8
X$9148 112 4199 113 5481 BUF_X8
* cell instance $9149 r0 *1 84.93,86.8
X$9149 4533 5376 4433 112 5538 113 AOI21_X1
* cell instance $9150 r0 *1 85.69,86.8
X$9150 3986 4306 4642 4083 5484 113 112 5537 OAI221_X1
* cell instance $9151 r0 *1 86.83,86.8
X$9151 4643 4148 112 113 5377 NAND2_X1
* cell instance $9152 r0 *1 87.4,86.8
X$9152 4535 4083 4639 112 5485 113 AOI21_X1
* cell instance $9153 r0 *1 88.16,86.8
X$9153 5014 5485 3870 5381 113 112 5601 OAI22_X1
* cell instance $9154 r0 *1 89.11,86.8
X$9154 4734 5380 5535 112 5539 113 AOI21_X1
* cell instance $9155 r0 *1 89.87,86.8
X$9155 4640 4491 4745 112 5381 113 AOI21_X1
* cell instance $9158 r0 *1 91.2,86.8
X$9158 3986 5598 4538 112 5384 113 AOI21_X1
* cell instance $9159 m0 *1 91.77,86.8
X$9159 4431 5355 5383 112 5157 113 AOI21_X2
* cell instance $9161 m0 *1 93.1,86.8
X$9161 4871 4741 5541 5354 4157 113 112 5355 OAI221_X1
* cell instance $9165 r0 *1 92.53,86.8
X$9165 5540 4535 4260 112 113 5385 NOR3_X1
* cell instance $9166 r0 *1 93.29,86.8
X$9166 4156 5090 112 113 4811 NAND2_X1
* cell instance $9167 r0 *1 93.86,86.8
X$9167 4488 4978 112 113 5542 NAND2_X1
* cell instance $9168 r0 *1 94.43,86.8
X$9168 4909 4433 4637 112 5387 113 AOI21_X1
* cell instance $9169 m0 *1 94.81,86.8
X$9169 5283 5492 4809 4492 4255 5494 113 112 AOI221_X2
* cell instance $9173 r0 *1 95.38,86.8
X$9173 5384 5386 112 113 5495 NAND2_X1
* cell instance $9174 r0 *1 95.95,86.8
X$9174 5385 4095 5387 112 5543 113 AOI21_X1
* cell instance $9177 m0 *1 97.47,86.8
X$9177 5357 5388 4904 112 113 5107 NOR3_X1
* cell instance $9180 r0 *1 97.28,86.8
X$9180 5352 5495 4809 4871 112 113 5500 NAND4_X1
* cell instance $9182 m0 *1 12.35,84
X$9182 5053 112 113 5132 BUF_X1
* cell instance $9187 m0 *1 15.39,84
X$9187 112 16938 5053 5054 5133 113 DFF_X1
* cell instance $9190 m0 *1 19.57,84
X$9190 112 4988 4776 113 BUF_X16
* cell instance $9191 m0 *1 24.32,84
X$9191 4063 4989 5055 112 5057 113 AOI21_X1
* cell instance $9193 m0 *1 25.27,84
X$9193 4610 4182 5137 112 113 5055 NAND3_X1
* cell instance $9194 m0 *1 26.03,84
X$9194 4776 4526 16487 113 112 4992 HA_X1
* cell instance $9197 m0 *1 28.88,84
X$9197 4993 4422 112 113 4996 NOR2_X1
* cell instance $9203 r0 *1 10.26,84
X$9203 112 17119 5311 3924 5133 113 DFF_X1
* cell instance $9211 r0 *1 21.66,84
X$9211 112 3866 113 4988 BUF_X8
* cell instance $9212 r0 *1 24.13,84
X$9212 4125 4180 5134 112 113 5135 MUX2_X1
* cell instance $9213 r0 *1 25.46,84
X$9213 5135 3974 5317 112 113 5208 MUX2_X1
* cell instance $9214 r0 *1 26.79,84
X$9214 5136 5253 4992 3859 112 113 5317 AOI22_X1
* cell instance $9216 r0 *1 28.12,84
X$9216 5208 3865 5254 112 113 5319 MUX2_X1
* cell instance $9217 r0 *1 29.45,84
X$9217 5137 4460 4180 113 5255 112 OAI21_X1
* cell instance $9219 m0 *1 29.83,84
X$9219 4065 4628 112 113 5138 NOR2_X1
* cell instance $9220 m0 *1 30.59,84
X$9220 4988 4065 3859 113 4994 112 OAI21_X1
* cell instance $9222 m0 *1 31.54,84
X$9222 4412 4892 112 113 5139 NOR2_X1
* cell instance $9224 r0 *1 30.21,84
X$9224 5255 5138 5209 4994 113 112 5210 OAI22_X1
* cell instance $9225 r0 *1 31.16,84
X$9225 5255 5139 4064 113 4995 112 OAI21_X1
* cell instance $9226 r0 *1 31.92,84
X$9226 3854 5210 4995 5140 4955 5141 112 113 OAI221_X2
* cell instance $9228 m0 *1 32.49,84
X$9228 3856 4997 112 113 5209 NOR2_X1
* cell instance $9231 m0 *1 34.39,84
X$9231 3856 4780 4697 113 4998 112 OAI21_X1
* cell instance $9233 m0 *1 35.15,84
X$9233 4988 5002 4063 4475 4780 113 112 5000 OAI221_X1
* cell instance $9234 m0 *1 36.29,84
X$9234 3810 5074 5000 113 112 4894 AND3_X1
* cell instance $9236 m0 *1 37.43,84
X$9236 4141 4996 5074 4474 5075 4895 112 113 5006 OAI33_X1
* cell instance $9238 r0 *1 34.39,84
X$9238 4289 5257 4064 113 5074 112 OAI21_X1
* cell instance $9239 r0 *1 35.15,84
X$9239 5073 3765 5324 112 4779 113 AOI21_X1
* cell instance $9243 r0 *1 38,84
X$9243 4241 3811 3765 112 5212 113 AOI21_X1
* cell instance $9244 r0 *1 38.76,84
X$9244 4628 5212 3810 113 5326 112 OAI21_X1
* cell instance $9246 m0 *1 39.14,84
X$9246 5001 4241 4182 113 4697 112 OAI21_X1
* cell instance $9247 m0 *1 40.09,84
X$9247 4791 4293 4180 112 4963 113 AOI21_X1
* cell instance $9250 r0 *1 39.71,84
X$9250 4289 4065 3811 112 113 5259 NAND3_X2
* cell instance $9252 m0 *1 41.99,84
X$9252 5077 4786 4185 4703 5144 4861 113 112 AOI221_X2
* cell instance $9253 m0 *1 41.23,84
X$9253 4289 5214 112 113 5077 OR2_X1
* cell instance $9255 m0 *1 44.27,84
X$9255 4471 4289 5331 112 4786 113 AOI21_X2
* cell instance $9257 m0 *1 45.79,84
X$9257 5216 5079 4703 112 113 4621 NAND3_X1
* cell instance $9259 m0 *1 46.74,84
X$9259 4896 4244 5217 112 113 5687 MUX2_X1
* cell instance $9260 m0 *1 48.07,84
X$9260 4955 5005 5141 113 5217 112 OAI21_X1
* cell instance $9263 r0 *1 41.23,84
X$9263 5143 4850 5002 4628 5259 5144 112 113 OAI221_X2
* cell instance $9264 r0 *1 43.32,84
X$9264 5002 3811 112 113 5004 NOR2_X1
* cell instance $9266 r0 *1 44.27,84
X$9266 5262 4064 112 113 4471 NAND2_X2
* cell instance $9268 r0 *1 45.6,84
X$9268 5145 3715 112 113 5216 NAND2_X1
* cell instance $9270 r0 *1 46.93,84
X$9270 4291 5145 3972 4412 5219 112 113 5218 AOI221_X1
* cell instance $9272 r0 *1 48.26,84
X$9272 4574 5146 112 113 5219 NAND2_X1
* cell instance $9274 r0 *1 49.21,84
X$9274 4412 4192 5146 112 5082 113 AOI21_X1
* cell instance $9275 r0 *1 49.97,84
X$9275 5260 4463 3765 112 113 5261 NAND3_X1
* cell instance $9276 r0 *1 50.73,84
X$9276 5262 113 4955 112 BUF_X4
* cell instance $9278 m0 *1 50.73,84
X$9278 5080 3854 5081 112 113 5084 MUX2_X1
* cell instance $9279 m0 *1 52.25,84
X$9279 5082 3765 5007 112 5081 113 AOI21_X1
* cell instance $9280 m0 *1 53.01,84
X$9280 3715 4422 5008 113 5007 112 OAI21_X1
* cell instance $9281 m0 *1 53.77,84
X$9281 4955 5084 5067 113 5222 112 OAI21_X1
* cell instance $9282 m0 *1 54.53,84
X$9282 4783 5001 4526 113 5086 112 OAI21_X1
* cell instance $9287 m0 *1 66.69,84
X$9287 4633 4796 5149 113 112 4738 OAI21_X4
* cell instance $9288 m0 *1 69.16,84
X$9288 5150 4796 5149 113 112 5012 OAI21_X4
* cell instance $9289 m0 *1 71.63,84
X$9289 5011 4480 4868 112 113 NOR2_X4
* cell instance $9290 m0 *1 73.34,84
X$9290 4868 5013 5091 4253 5093 4595 113 112 AOI221_X2
* cell instance $9291 m0 *1 75.43,84
X$9291 4978 3988 5012 113 5093 112 OAI21_X1
* cell instance $9294 m0 *1 77.14,84
X$9294 4425 112 113 4978 INV_X2
* cell instance $9295 m0 *1 77.71,84
X$9295 112 5236 4253 4638 5012 113 AOI21_X4
* cell instance $9296 m0 *1 80.18,84
X$9296 5096 113 4029 112 BUF_X4
* cell instance $9297 m0 *1 81.51,84
X$9297 4380 5271 4084 113 112 5151 AND3_X2
* cell instance $9298 m0 *1 82.65,84
X$9298 5013 4803 5014 112 4986 113 AOI21_X1
* cell instance $9299 m0 *1 83.41,84
X$9299 5274 4492 4489 113 5239 112 OAI21_X1
* cell instance $9303 r0 *1 52.63,84
X$9303 4067 4069 112 113 5147 NOR2_X1
* cell instance $9306 r0 *1 53.77,84
X$9306 5222 4025 5319 112 113 5342 MUX2_X1
* cell instance $9307 r0 *1 55.1,84
X$9307 4241 4072 3855 112 5340 113 AOI21_X1
* cell instance $9308 r0 *1 55.86,84
X$9308 5147 5086 5259 113 112 5227 AND3_X1
* cell instance $9309 r0 *1 56.81,84
X$9309 5341 4955 112 113 5266 NOR2_X1
* cell instance $9310 r0 *1 57.38,84
X$9310 4794 5266 5226 112 113 5346 NOR3_X1
* cell instance $9312 r0 *1 58.33,84
X$9312 5226 5225 5469 113 5343 112 OAI21_X1
* cell instance $9313 r0 *1 59.09,84
X$9313 5227 5343 5345 113 5009 112 OAI21_X1
* cell instance $9315 r0 *1 60.04,84
X$9315 5006 5346 112 113 5471 NOR2_X1
* cell instance $9319 r0 *1 65.93,84
X$9319 4796 5149 4194 112 113 5228 NOR3_X1
* cell instance $9320 r0 *1 66.69,84
X$9320 4365 3572 113 5054 112 XOR2_X2
* cell instance $9325 r0 *1 68.59,84
X$9325 112 4530 5149 4796 4533 113 NOR3_X4
* cell instance $9328 r0 *1 71.82,84
X$9328 5270 5269 3982 112 113 4638 NAND3_X2
* cell instance $9330 r0 *1 73.34,84
X$9330 4606 5349 5014 4310 5232 5353 113 112 AOI221_X2
* cell instance $9331 r0 *1 75.43,84
X$9331 4029 4197 4026 4317 113 112 5232 OAI22_X1
* cell instance $9333 r0 *1 76.57,84
X$9333 112 5156 5150 5270 5269 113 AOI21_X4
* cell instance $9334 r0 *1 79.04,84
X$9334 112 5236 4492 5272 5235 5238 113 NOR4_X4
* cell instance $9335 r0 *1 82.46,84
X$9335 5094 5239 5151 5238 4871 5360 112 113 OAI221_X2
* cell instance $9337 m0 *1 84.55,84
X$9337 5015 5012 4095 4429 112 113 5102 AOI22_X1
* cell instance $9338 m0 *1 85.69,84
X$9338 5011 4088 4535 112 5153 113 AOI21_X1
* cell instance $9340 r0 *1 84.55,84
X$9340 5015 4200 3985 112 5359 113 AOI21_X1
* cell instance $9341 r0 *1 85.31,84
X$9341 5152 4315 3986 113 5482 112 OAI21_X1
* cell instance $9342 r0 *1 86.07,84
X$9342 4260 5153 4432 4195 113 112 5483 OAI22_X1
* cell instance $9343 m0 *1 88.16,84
X$9343 4738 5017 5245 5102 4871 113 112 5018 OAI221_X1
* cell instance $9344 m0 *1 86.83,84
X$9344 5016 4196 3983 112 113 5017 MUX2_X1
* cell instance $9345 m0 *1 89.3,84
X$9345 5018 5104 4808 113 112 5158 AND3_X2
* cell instance $9346 m0 *1 90.44,84
X$9346 5152 5011 4260 112 113 5019 NOR3_X1
* cell instance $9349 r0 *1 87.02,84
X$9349 5278 5360 5244 5279 112 113 5280 AOI22_X2
* cell instance $9350 r0 *1 88.73,84
X$9350 5155 4429 5246 3986 5154 112 113 5245 AOI221_X1
* cell instance $9351 r0 *1 89.87,84
X$9351 5274 5090 4317 113 5154 112 OAI21_X1
* cell instance $9352 r0 *1 90.63,84
X$9352 5152 5156 4308 113 5281 112 OAI21_X1
* cell instance $9354 r0 *1 91.77,84
X$9354 5280 5158 5157 113 112 5161 OAI21_X2
* cell instance $9355 m0 *1 93.1,84
X$9355 4978 4899 4637 112 113 5252 MUX2_X1
* cell instance $9356 m0 *1 92.34,84
X$9356 5159 4978 4491 112 5105 113 AOI21_X1
* cell instance $9358 r0 *1 93.1,84
X$9358 5282 4742 5160 112 5244 113 AOI21_X1
* cell instance $9359 r0 *1 93.86,84
X$9359 5011 4535 4095 113 5352 112 OAI21_X1
* cell instance $9360 r0 *1 94.62,84
X$9360 4091 5252 5160 113 5283 112 OAI21_X1
* cell instance $9361 m0 *1 95,84
X$9361 4091 4978 5014 112 5020 113 AOI21_X1
* cell instance $9366 r0 *1 95.38,84
X$9366 4909 5159 4095 112 113 5351 NOR3_X1
* cell instance $9368 r0 *1 96.52,84
X$9368 5275 4803 4091 112 5162 113 AOI21_X1
* cell instance $9369 r0 *1 97.28,84
X$9369 5351 4095 5162 112 5163 113 AOI21_X1
* cell instance $9370 r0 *1 98.04,84
X$9370 5163 4809 4497 112 113 5284 NAND3_X1
* cell instance $9371 m0 *1 98.61,84
X$9371 4904 4497 5285 112 113 5021 NOR3_X1
* cell instance $9377 m0 *1 106.02,84
X$9377 5023 5251 112 113 5119 NAND2_X1
* cell instance $9379 m0 *1 106.59,84
X$9379 4890 112 113 5251 INV_X1
* cell instance $9380 m0 *1 106.97,84
X$9380 5164 251 5119 113 112 3568 OAI21_X4
* cell instance $9382 m0 *1 109.63,84
X$9382 4917 5120 112 113 5024 NOR2_X1
* cell instance $9385 m0 *1 113.43,84
X$9385 5166 5167 112 113 5124 XOR2_X1
* cell instance $9386 m0 *1 114.57,84
X$9386 178 3335 5124 112 113 5168 MUX2_X1
* cell instance $9389 m0 *1 117.61,84
X$9389 4652 112 113 16462 CLKBUF_X1
* cell instance $9391 m0 *1 118.37,84
X$9391 5127 5129 5169 113 112 2670 MUX2_X2
* cell instance $9393 r0 *1 106.4,84
X$9393 3527 5251 112 113 5286 NOR2_X1
* cell instance $9395 r0 *1 107.35,84
X$9395 251 5250 4890 112 113 5164 NAND3_X1
* cell instance $9398 r0 *1 109.25,84
X$9398 169 4209 5165 112 113 5249 MUX2_X1
* cell instance $9399 r0 *1 110.58,84
X$9399 112 17099 5248 5249 5288 113 DFF_X1
* cell instance $9400 r0 *1 113.81,84
X$9400 5248 112 113 3579 CLKBUF_X3
* cell instance $9402 r0 *1 115.14,84
X$9402 112 17093 5247 5168 4652 113 DFF_X1
* cell instance $9403 r0 *1 118.37,84
X$9403 112 5166 113 5247 BUF_X8
* cell instance $9404 m0 *1 120.65,84
X$9404 5131 5169 5130 112 113 4889 MUX2_X1
* cell instance $9407 m0 *1 122.74,84
X$9407 3646 112 113 5026 INV_X1
* cell instance $9408 m0 *1 123.12,84
X$9408 5170 5026 112 113 5171 NOR2_X1
* cell instance $9409 m0 *1 123.69,84
X$9409 3678 5026 112 113 5242 NAND2_X1
* cell instance $9410 m0 *1 124.26,84
X$9410 3678 3646 112 113 5027 NAND2_X1
* cell instance $9411 m0 *1 124.83,84
X$9411 5027 5242 5174 113 112 3078 MUX2_X2
* cell instance $9412 m0 *1 126.54,84
X$9412 4545 5172 113 167 112 XOR2_X2
* cell instance $9413 m0 *1 128.25,84
X$9413 5176 112 113 5173 BUF_X2
* cell instance $9415 m0 *1 129.77,84
X$9415 5028 5175 113 112 5125 XNOR2_X1
* cell instance $9416 m0 *1 130.91,84
X$9416 3373 4510 112 113 5028 XNOR2_X2
* cell instance $9419 r0 *1 120.84,84
X$9419 4279 112 113 4652 CLKBUF_X3
* cell instance $9420 r0 *1 121.79,84
X$9420 5170 3646 112 113 5291 NOR2_X1
* cell instance $9421 r0 *1 122.36,84
X$9421 5171 5291 5174 113 112 3258 MUX2_X2
* cell instance $9425 r0 *1 124.07,84
X$9425 4054 5172 5173 112 5293 113 NAND3_X4
* cell instance $9427 r0 *1 126.92,84
X$9427 5295 5241 113 5176 112 XOR2_X2
* cell instance $9429 r0 *1 128.82,84
X$9429 4655 5295 113 112 5175 XNOR2_X1
* cell instance $9432 r0 *1 130.53,84
X$9432 5177 4322 112 113 5493 NAND2_X1
* cell instance $9433 r0 *1 131.1,84
X$9433 5348 5240 4322 112 113 5347 NAND3_X1
* cell instance $9435 r0 *1 132.05,84
X$9435 5028 4100 113 112 5489 XNOR2_X1
* cell instance $9437 r0 *1 133.57,84
X$9437 5237 5166 113 144 112 XOR2_X2
* cell instance $9438 m0 *1 134.14,84
X$9438 5121 3376 112 113 5029 XOR2_X1
* cell instance $9442 m0 *1 136.23,84
X$9442 5114 5118 112 113 5169 XNOR2_X2
* cell instance $9444 r0 *1 135.28,84
X$9444 5176 112 113 4656 BUF_X1
* cell instance $9446 r0 *1 136.04,84
X$9446 5237 5121 113 112 5117 XNOR2_X1
* cell instance $9449 m0 *1 138.51,84
X$9449 3373 5116 112 113 5114 XNOR2_X2
* cell instance $9452 r0 *1 140.41,84
X$9452 5488 112 113 3367 CLKBUF_X3
* cell instance $9455 m0 *1 142.5,84
X$9455 4101 5234 112 113 4921 XNOR2_X2
* cell instance $9458 m0 *1 145.92,84
X$9458 4919 112 113 5031 INV_X1
* cell instance $9459 m0 *1 146.3,84
X$9459 196 4676 5031 112 113 5108 NAND3_X2
* cell instance $9460 m0 *1 147.63,84
X$9460 5109 112 113 3591 INV_X8
* cell instance $9461 m0 *1 149.34,84
X$9461 112 3787 113 5109 BUF_X8
* cell instance $9463 m0 *1 152,84
X$9463 3787 112 113 5180 BUF_X1
* cell instance $9464 m0 *1 152.57,84
X$9464 112 5180 4660 4324 4737 113 NOR3_X4
* cell instance $9465 m0 *1 155.23,84
X$9465 112 3112 3591 4816 4925 113 AOI21_X4
* cell instance $9466 m0 *1 157.7,84
X$9466 4816 4925 3180 112 113 4384 NAND3_X2
* cell instance $9467 m0 *1 159.03,84
X$9467 4816 4925 3451 112 113 4058 NAND3_X2
* cell instance $9468 m0 *1 160.36,84
X$9468 3339 3587 5032 113 5181 112 OAI21_X1
* cell instance $9469 m0 *1 161.12,84
X$9469 4218 4325 2358 113 5032 112 OAI21_X1
* cell instance $9470 m0 *1 161.88,84
X$9470 3698 5033 4664 112 113 5034 NOR3_X1
* cell instance $9471 m0 *1 162.64,84
X$9471 5034 5097 4001 112 113 5338 NOR3_X1
* cell instance $9472 m0 *1 163.4,84
X$9472 4872 3180 2404 112 5223 113 AOI21_X1
* cell instance $9473 m0 *1 164.16,84
X$9473 2885 5223 3587 2410 113 112 5035 OAI22_X2
* cell instance $9476 r0 *1 142.31,84
X$9476 5121 5295 113 112 5234 XNOR2_X1
* cell instance $9479 r0 *1 144.59,84
X$9479 5233 112 113 4098 CLKBUF_X3
* cell instance $9483 r0 *1 146.87,84
X$9483 5031 5231 196 112 113 5178 OR3_X2
* cell instance $9484 r0 *1 148.01,84
X$9484 5108 5178 112 4324 113 NAND2_X4
* cell instance $9486 r0 *1 150.1,84
X$9486 112 3787 3198 113 BUF_X16
* cell instance $9487 r0 *1 154.85,84
X$9487 3889 4924 112 113 5230 NAND2_X1
* cell instance $9488 r0 *1 155.42,84
X$9488 2909 3272 4103 112 5229 113 AOI21_X1
* cell instance $9490 r0 *1 156.37,84
X$9490 5229 4384 5230 3451 2642 112 113 5582 AOI221_X1
* cell instance $9493 r0 *1 158.08,84
X$9493 112 4373 3272 4816 4925 113 AOI21_X4
* cell instance $9494 r0 *1 160.55,84
X$9494 4818 4169 3267 112 113 5339 NOR3_X1
* cell instance $9495 r0 *1 161.31,84
X$9495 3451 3201 3113 112 5033 113 AOI21_X1
* cell instance $9496 r0 *1 162.07,84
X$9496 2683 5338 4926 112 113 5337 OR3_X1
* cell instance $9497 r0 *1 163.02,84
X$9497 5033 4872 3450 112 113 5299 NOR3_X1
* cell instance $9499 r0 *1 164.16,84
X$9499 2640 4001 112 113 5300 NOR2_X1
* cell instance $9500 r0 *1 164.73,84
X$9500 5035 5300 5224 2918 4928 5412 113 112 AOI221_X2
* cell instance $9501 r0 *1 166.82,84
X$9501 4667 4169 3450 113 5333 112 OAI21_X1
* cell instance $9502 r0 *1 167.58,84
X$9502 2684 4548 5301 113 5332 112 OAI21_X1
* cell instance $9503 m0 *1 167.96,84
X$9503 2885 5092 3114 3451 3587 113 112 5184 OAI221_X1
* cell instance $9507 r0 *1 168.53,84
X$9507 5185 2469 5221 113 5183 112 NOR3_X2
* cell instance $9508 m0 *1 169.67,84
X$9508 2577 3966 5036 112 5186 113 AOI21_X1
* cell instance $9511 m0 *1 170.62,84
X$9511 3339 2804 4058 113 5187 112 OAI21_X1
* cell instance $9512 m0 *1 171.38,84
X$9512 4325 113 3697 112 BUF_X4
* cell instance $9513 m0 *1 172.71,84
X$9513 4823 3088 112 113 5188 NOR2_X2
* cell instance $9515 r0 *1 169.86,84
X$9515 3966 5036 5188 5187 3698 5220 113 112 AOI221_X2
* cell instance $9516 r0 *1 171.95,84
X$9516 5220 2683 4053 3479 5190 5329 113 112 AOI221_X2
* cell instance $9518 m0 *1 174.23,84
X$9518 5038 5087 3755 3479 5039 3652 113 112 AOI221_X2
* cell instance $9520 m0 *1 176.32,84
X$9520 3755 3200 112 113 5041 NOR2_X1
* cell instance $9521 m0 *1 176.89,84
X$9521 3487 4325 112 113 5191 NOR2_X1
* cell instance $9523 m0 *1 177.65,84
X$9523 3200 113 3479 112 BUF_X4
* cell instance $9524 m0 *1 178.98,84
X$9524 5078 4954 2961 112 113 4826 NAND3_X1
* cell instance $9526 m0 *1 179.93,84
X$9526 3294 112 113 3450 CLKBUF_X3
* cell instance $9529 r0 *1 174.23,84
X$9529 2640 112 113 2918 CLKBUF_X3
* cell instance $9530 r0 *1 175.18,84
X$9530 4373 2755 2804 112 5302 113 AOI21_X1
* cell instance $9532 r0 *1 176.13,84
X$9532 2640 4666 112 113 5303 OR2_X1
* cell instance $9533 r0 *1 176.89,84
X$9533 5191 2358 112 113 5465 NOR2_X1
* cell instance $9535 r0 *1 177.84,84
X$9535 3112 4737 2803 113 5215 112 OAI21_X1
* cell instance $9537 r0 *1 178.98,84
X$9537 2803 5191 5215 113 5192 112 OAI21_X1
* cell instance $9538 r0 *1 179.74,84
X$9538 4373 3088 112 113 4827 NOR2_X1
* cell instance $9542 r0 *1 180.31,84
X$9542 3088 112 113 3698 CLKBUF_X3
* cell instance $9544 m0 *1 182.21,84
X$9544 4929 4737 3698 113 5078 112 OAI21_X1
* cell instance $9548 m0 *1 189.81,84
X$9548 5044 4935 113 112 4221 XNOR2_X1
* cell instance $9549 m0 *1 190.95,84
X$9549 4672 5321 112 113 5044 XNOR2_X2
* cell instance $9552 m0 *1 193.8,84
X$9552 3643 5046 113 112 5045 XNOR2_X1
* cell instance $9554 m0 *1 195.13,84
X$9554 5196 5417 5043 113 112 3703 MUX2_X2
* cell instance $9555 m0 *1 196.84,84
X$9555 5044 5307 113 112 5047 XNOR2_X1
* cell instance $9557 m0 *1 198.17,84
X$9557 3436 5047 113 112 5069 XNOR2_X1
* cell instance $9560 m0 *1 201.02,84
X$9560 5070 3947 5062 112 113 5071 MUX2_X1
* cell instance $9564 r0 *1 187.72,84
X$9564 4269 5304 113 112 5211 XNOR2_X1
* cell instance $9566 r0 *1 189.62,84
X$9566 5458 5323 113 112 5042 XNOR2_X1
* cell instance $9567 r0 *1 190.76,84
X$9567 5305 5321 113 112 5323 XNOR2_X1
* cell instance $9568 r0 *1 191.9,84
X$9568 5193 4672 113 112 5306 XNOR2_X1
* cell instance $9570 r0 *1 193.23,84
X$9570 5318 5045 5194 113 112 3391 MUX2_X2
* cell instance $9571 r0 *1 194.94,84
X$9571 5044 5320 113 112 5046 XNOR2_X1
* cell instance $9574 r0 *1 196.65,84
X$9574 3643 5193 112 113 5307 XNOR2_X2
* cell instance $9578 r0 *1 200.64,84
X$9578 5200 5211 3489 113 112 5572 MUX2_X2
* cell instance $9581 r0 *1 205.58,84
X$9581 401 112 113 5068 CLKBUF_X3
* cell instance $9583 m0 *1 205.77,84
X$9583 5202 5069 3438 113 112 5195 MUX2_X2
* cell instance $9584 r0 *1 206.53,84
X$9584 112 17000 5196 5207 5068 113 DFF_X1
* cell instance $9586 m0 *1 207.86,84
X$9586 5196 4948 5206 112 113 5207 MUX2_X1
* cell instance $9593 r0 *1 212.23,84
X$9593 112 17044 5316 4360 5068 113 DFF_X1
* cell instance $9594 r0 *1 215.46,84
X$9594 5066 112 113 5315 CLKBUF_X3
* cell instance $9597 m0 *1 217.93,84
X$9597 112 5048 4454 17236 5065 113 DFF_X2
* cell instance $9602 r0 *1 224.39,84
X$9602 5199 112 113 5198 INV_X2
* cell instance $9604 m0 *1 228.95,84
X$9604 112 16793 5200 5059 4836 113 DFF_X1
* cell instance $9605 m0 *1 225.72,84
X$9605 112 16784 5049 5060 4836 113 DFF_X1
* cell instance $9609 r0 *1 227.62,84
X$9609 5205 112 113 5193 BUF_X2
* cell instance $9613 r0 *1 229.71,84
X$9613 112 17014 5205 5201 4836 113 DFF_X1
* cell instance $9615 m0 *1 232.56,84
X$9615 112 16865 5202 5056 4836 113 DFF_X1
* cell instance $9617 m0 *1 239.02,84
X$9617 4943 112 113 5203 BUF_X1
* cell instance $9620 r0 *1 232.94,84
X$9620 4841 112 113 4836 CLKBUF_X3
* cell instance $9627 r0 *1 235.98,84
X$9627 112 16946 5204 5197 4836 113 DFF_X1
* cell instance $9628 r0 *1 239.21,84
X$9628 5204 112 113 5052 BUF_X1
* cell instance $9630 m0 *1 136.23,196
X$9630 9386 112 113 14285 BUF_X1
* cell instance $9633 m0 *1 136.99,196
X$9633 14000 14019 14285 8862 14586 112 113 14582 AOI221_X1
* cell instance $9635 m0 *1 138.32,196
X$9635 14284 112 113 14586 INV_X1
* cell instance $9637 m0 *1 138.89,196
X$9637 8862 113 7895 112 BUF_X4
* cell instance $9638 m0 *1 140.22,196
X$9638 7211 112 113 14402 INV_X8
* cell instance $9639 m0 *1 141.93,196
X$9639 112 14402 14403 113 BUF_X16
* cell instance $9640 m0 *1 146.68,196
X$9640 11596 112 113 14513 BUF_X1
* cell instance $9642 m0 *1 147.44,196
X$9642 112 12002 14024 14179 14489 14404 113 OAI211_X4
* cell instance $9646 m0 *1 134.71,196
X$9646 14582 112 113 14500 CLKBUF_X3
* cell instance $9647 r0 *1 134.71,196
X$9647 14624 14389 14625 112 113 14583 MUX2_X1
* cell instance $9650 r0 *1 136.61,196
X$9650 14102 113 14733 112 BUF_X4
* cell instance $9653 r0 *1 141.17,196
X$9653 14402 14513 14075 113 112 15083 OAI21_X4
* cell instance $9654 r0 *1 143.64,196
X$9654 112 11238 10660 12002 14024 14630 113 NAND4_X4
* cell instance $9655 r0 *1 147.06,196
X$9655 14075 14513 14515 14514 14628 113 112 AOI211_X2
* cell instance $9657 r0 *1 149.15,196
X$9657 7211 14513 14075 113 112 14410 OAI21_X2
* cell instance $9658 r0 *1 150.48,196
X$9658 14626 112 113 14627 BUF_X1
* cell instance $9659 r0 *1 151.05,196
X$9659 14515 14514 7211 112 113 14631 NAND3_X1
* cell instance $9660 r0 *1 151.81,196
X$9660 14289 14179 14404 113 112 14524 OAI21_X4
* cell instance $9661 m0 *1 152,196
X$9661 14104 113 14516 112 BUF_X4
* cell instance $9664 m0 *1 153.52,196
X$9664 14184 14406 14593 14595 14407 14365 112 113 OAI221_X2
* cell instance $9665 m0 *1 155.61,196
X$9665 14419 14408 14525 113 14595 112 OAI21_X1
* cell instance $9666 m0 *1 156.37,196
X$9666 14181 113 14424 112 BUF_X4
* cell instance $9667 m0 *1 157.7,196
X$9667 14410 14408 14424 14411 14412 113 112 14597 OAI221_X1
* cell instance $9668 m0 *1 158.84,196
X$9668 14104 14490 14600 14411 14295 113 112 14413 OAI221_X1
* cell instance $9670 m0 *1 161.5,196
X$9670 14425 14289 112 113 14518 NOR2_X1
* cell instance $9674 r0 *1 154.85,196
X$9674 14262 14594 14489 112 14593 113 AOI21_X1
* cell instance $9675 r0 *1 155.61,196
X$9675 14290 112 113 14706 INV_X4
* cell instance $9676 r0 *1 156.56,196
X$9676 14292 14517 112 113 14596 OR2_X1
* cell instance $9677 r0 *1 157.32,196
X$9677 14597 14592 14596 112 14705 113 AOI21_X1
* cell instance $9679 r0 *1 158.46,196
X$9679 14600 14181 112 113 14409 NOR2_X2
* cell instance $9682 r0 *1 159.98,196
X$9682 14517 14190 112 113 14798 NOR2_X1
* cell instance $9684 r0 *1 162.07,196
X$9684 14518 14703 14185 14702 14299 112 113 14519 AOI221_X1
* cell instance $9686 m0 *1 162.45,196
X$9686 14602 14414 112 113 14482 NAND2_X1
* cell instance $9688 m0 *1 163.59,196
X$9688 14421 14484 14413 113 14415 112 OAI21_X1
* cell instance $9690 m0 *1 164.35,196
X$9690 14520 14706 14416 14294 14411 14298 113 112 AOI221_X2
* cell instance $9692 r0 *1 163.97,196
X$9692 14483 14403 112 113 14632 NAND2_X2
* cell instance $9694 r0 *1 165.11,196
X$9694 14601 14700 14301 14293 14633 14599 113 112 AOI221_X2
* cell instance $9695 m0 *1 167.77,196
X$9695 14422 14598 14478 112 14476 113 AOI21_X1
* cell instance $9696 m0 *1 166.82,196
X$9696 14419 14522 14421 14293 113 112 14478 OAI22_X1
* cell instance $9697 m0 *1 168.53,196
X$9697 14636 14524 14516 113 14591 112 OAI21_X1
* cell instance $9698 m0 *1 169.29,196
X$9698 14423 14524 14412 14636 14424 14422 112 113 OAI221_X2
* cell instance $9699 m0 *1 171.38,196
X$9699 14421 14424 112 113 14590 NAND2_X1
* cell instance $9700 m0 *1 171.95,196
X$9700 14190 14425 14424 14632 112 113 14426 AOI22_X1
* cell instance $9701 m0 *1 172.9,196
X$9701 14293 14590 14589 14526 14426 113 112 14427 OAI221_X1
* cell instance $9705 r0 *1 167.2,196
X$9705 14405 14521 14592 112 14633 113 AOI21_X1
* cell instance $9706 r0 *1 167.96,196
X$9706 14591 14634 14635 112 113 14523 NOR3_X1
* cell instance $9708 r0 *1 169.1,196
X$9708 14419 14524 14412 14411 14301 14695 112 113 OAI221_X2
* cell instance $9709 r0 *1 171.19,196
X$9709 14471 14694 14423 112 113 14637 NAND3_X1
* cell instance $9712 r0 *1 173.09,196
X$9712 14427 14525 14689 112 14588 113 AOI21_X1
* cell instance $9714 r0 *1 174.61,196
X$9714 14188 14407 112 113 14685 NOR2_X1
* cell instance $9715 r0 *1 175.18,196
X$9715 14638 14470 14588 14686 14685 112 113 14587 AOI221_X1
* cell instance $9716 r0 *1 176.32,196
X$9716 14260 14587 14681 113 14682 112 OAI21_X1
* cell instance $9717 m0 *1 176.89,196
X$9717 112 16934 14585 14682 14106 113 DFF_X1
* cell instance $9722 m0 *1 185.44,196
X$9722 14257 14026 14025 113 112 14432 OAI21_X4
* cell instance $9724 m0 *1 188.1,196
X$9724 14527 112 113 14428 INV_X1
* cell instance $9725 m0 *1 188.48,196
X$9725 13903 14428 112 113 13971 NAND2_X1
* cell instance $9727 m0 *1 189.24,196
X$9727 112 14830 14527 11204 11362 113 AOI21_X4
* cell instance $9728 m0 *1 191.71,196
X$9728 11362 14527 11204 112 14028 113 NAND3_X4
* cell instance $9729 m0 *1 194.18,196
X$9729 14245 13903 13639 14314 14430 14464 113 112 AOI221_X2
* cell instance $9730 m0 *1 196.27,196
X$9730 14302 113 14448 112 BUF_X4
* cell instance $9732 m0 *1 197.79,196
X$9732 14302 113 14544 112 BUF_X4
* cell instance $9733 m0 *1 199.12,196
X$9733 13769 14573 14202 14204 14053 112 113 14530 AOI221_X1
* cell instance $9735 m0 *1 200.45,196
X$9735 14128 14454 14460 112 14643 113 AOI21_X2
* cell instance $9736 m0 *1 201.78,196
X$9736 14306 14113 14202 112 113 14460 NAND3_X1
* cell instance $9743 r0 *1 183.92,196
X$9743 14584 113 14257 112 BUF_X4
* cell instance $9744 r0 *1 185.25,196
X$9744 13984 14651 14584 113 112 14640 HA_X1
* cell instance $9745 r0 *1 187.15,196
X$9745 112 14303 113 14257 BUF_X8
* cell instance $9746 r0 *1 189.62,196
X$9746 14746 14528 14680 112 113 14678 MUX2_X1
* cell instance $9748 r0 *1 191.14,196
X$9748 14674 14534 14679 112 14783 113 AOI21_X1
* cell instance $9750 r0 *1 192.09,196
X$9750 14641 14528 14304 13903 14303 14676 113 112 AOI221_X2
* cell instance $9751 r0 *1 194.18,196
X$9751 14108 13797 13639 14649 14642 112 113 14668 AOI221_X1
* cell instance $9752 r0 *1 195.32,196
X$9752 14640 14448 14345 113 14430 112 OAI21_X1
* cell instance $9754 r0 *1 196.27,196
X$9754 13703 10368 112 113 14197 NAND2_X2
* cell instance $9756 r0 *1 197.6,196
X$9756 14640 112 113 13769 CLKBUF_X3
* cell instance $9757 r0 *1 198.55,196
X$9757 15034 14308 13706 14667 14529 13906 113 112 AOI221_X2
* cell instance $9758 r0 *1 200.64,196
X$9758 14530 14340 112 113 13771 NOR2_X1
* cell instance $9760 r0 *1 201.59,196
X$9760 14433 14644 14645 14531 13903 112 113 14646 AOI221_X1
* cell instance $9761 r0 *1 202.73,196
X$9761 14027 14028 112 113 14644 NAND2_X1
* cell instance $9762 m0 *1 203.68,196
X$9762 14342 14070 112 113 14458 NOR2_X1
* cell instance $9763 m0 *1 202.92,196
X$9763 14111 14134 112 113 14532 OR2_X1
* cell instance $9764 m0 *1 204.25,196
X$9764 13903 13978 112 113 14114 NAND2_X1
* cell instance $9768 r0 *1 203.68,196
X$9768 14534 14532 14197 13834 13984 112 113 14562 AOI221_X1
* cell instance $9770 r0 *1 205.2,196
X$9770 14660 14562 13995 14533 112 113 13988 NOR4_X1
* cell instance $9771 m0 *1 207.29,196
X$9771 14448 14071 112 113 14447 NAND2_X2
* cell instance $9772 m0 *1 205.96,196
X$9772 14053 14534 14205 113 14434 112 NOR3_X2
* cell instance $9773 m0 *1 208.24,196
X$9773 14555 14554 13969 14548 14441 13986 113 112 AOI221_X2
* cell instance $9774 m0 *1 210.33,196
X$9774 13837 13834 13973 14551 112 113 14550 AOI22_X2
* cell instance $9777 r0 *1 206.34,196
X$9777 14534 14553 14345 113 112 14648 AND3_X1
* cell instance $9779 r0 *1 207.67,196
X$9779 14649 14108 14448 112 14554 113 AOI21_X2
* cell instance $9780 r0 *1 209,196
X$9780 14053 14205 112 113 14659 NOR2_X1
* cell instance $9781 r0 *1 209.57,196
X$9781 112 14658 13978 113 BUF_X16
* cell instance $9782 m0 *1 213.37,196
X$9782 14043 14345 113 112 14441 AND2_X1
* cell instance $9783 m0 *1 212.42,196
X$9783 14205 14536 13900 14309 112 113 14315 NOR4_X1
* cell instance $9784 m0 *1 214.13,196
X$9784 14134 14209 14544 112 14439 113 AOI21_X1
* cell instance $9785 m0 *1 214.89,196
X$9785 14540 14311 14439 112 113 13778 MUX2_X1
* cell instance $9787 m0 *1 216.41,196
X$9787 13769 14038 13915 112 113 14541 MUX2_X1
* cell instance $9788 m0 *1 217.74,196
X$9788 13975 14541 14537 113 14436 112 OAI21_X1
* cell instance $9789 m0 *1 218.5,196
X$9789 14436 14069 112 113 14318 NAND2_X1
* cell instance $9797 r0 *1 214.32,196
X$9797 13925 14209 13797 112 14653 113 AOI21_X1
* cell instance $9798 r0 *1 215.08,196
X$9798 13973 14310 112 113 14536 NOR2_X1
* cell instance $9800 r0 *1 215.84,196
X$9800 14540 14651 14548 112 14214 113 AOI21_X2
* cell instance $9801 r0 *1 217.17,196
X$9801 14539 112 113 13918 CLKBUF_X3
* cell instance $9811 m0 *1 137.56,240.8
X$9811 16423 112 113 13745 BUF_X1
* cell instance $9814 m0 *1 138.32,240.8
X$9814 16425 112 113 14284 BUF_X2
* cell instance $9815 m0 *1 139.08,240.8
X$9815 16426 112 113 14021 BUF_X2
* cell instance $9816 m0 *1 139.84,240.8
X$9816 16454 112 113 9270 CLKBUF_X2
* cell instance $9818 m0 *1 12.54,126
X$9818 8901 112 113 8841 BUF_X1
* cell instance $9819 m0 *1 11.97,126
X$9819 8745 112 113 8384 BUF_X1
* cell instance $9821 m0 *1 13.3,126
X$9821 8838 112 113 8798 CLKBUF_X2
* cell instance $9824 m0 *1 15.01,126
X$9824 112 16878 8901 8755 8903 113 DFF_X1
* cell instance $9825 m0 *1 18.24,126
X$9825 8839 112 113 8902 BUF_X1
* cell instance $9828 m0 *1 10.26,126
X$9828 8800 112 113 8840 BUF_X1
* cell instance $9838 r0 *1 14.06,126
X$9838 8970 112 113 8627 BUF_X1
* cell instance $9842 m0 *1 20.71,126
X$9842 112 16851 8800 8799 8903 113 DFF_X1
* cell instance $9848 r0 *1 26.22,126
X$9848 8012 7072 8176 113 9018 112 OAI21_X1
* cell instance $9849 m0 *1 28.31,126
X$9849 8909 8801 7497 112 113 8912 NAND3_X1
* cell instance $9850 m0 *1 26.6,126
X$9850 8305 7403 7588 7887 8907 113 112 AOI211_X2
* cell instance $9851 m0 *1 29.07,126
X$9851 7176 7588 7445 112 8843 113 AOI21_X1
* cell instance $9852 m0 *1 29.83,126
X$9852 8638 7495 7572 7707 8843 113 112 8747 OAI221_X1
* cell instance $9853 m0 *1 30.97,126
X$9853 8912 8747 7703 112 113 8911 NAND3_X1
* cell instance $9854 m0 *1 31.73,126
X$9854 7637 8550 7641 7847 113 112 8749 OAI22_X1
* cell instance $9856 r0 *1 26.98,126
X$9856 8907 8176 8746 112 8842 113 AOI21_X1
* cell instance $9857 r0 *1 27.74,126
X$9857 7218 7072 8554 113 9020 112 OAI21_X1
* cell instance $9861 r0 *1 29.83,126
X$9861 8844 6798 8249 112 113 8913 MUX2_X1
* cell instance $9863 r0 *1 31.35,126
X$9863 8749 8845 8913 8016 8014 9028 112 113 OAI221_X2
* cell instance $9864 m0 *1 33.82,126
X$9864 112 8916 8849 8088 9028 113 AOI21_X4
* cell instance $9865 m0 *1 33.06,126
X$9865 8553 8914 7572 113 8845 112 OAI21_X1
* cell instance $9867 m0 *1 36.48,126
X$9867 8917 8846 8750 112 8702 113 AOI21_X1
* cell instance $9868 m0 *1 37.24,126
X$9868 8752 7623 8696 112 8750 113 AOI21_X1
* cell instance $9871 r0 *1 33.63,126
X$9871 112 8972 8915 8484 8916 8759 113 NOR4_X4
* cell instance $9873 r0 *1 37.43,126
X$9873 7229 7800 112 113 8974 NOR2_X2
* cell instance $9874 m0 *1 39.14,126
X$9874 7623 8751 8641 113 8919 112 OAI21_X1
* cell instance $9875 m0 *1 38.38,126
X$9875 7299 7072 8176 113 8847 112 OAI21_X1
* cell instance $9876 m0 *1 39.9,126
X$9876 7487 7881 7620 113 112 8808 OAI21_X2
* cell instance $9878 m0 *1 41.42,126
X$9878 7636 8247 7880 112 8752 113 AOI21_X2
* cell instance $9880 r0 *1 38.38,126
X$9880 7622 8751 8550 8491 7628 9038 112 113 OAI221_X2
* cell instance $9882 r0 *1 40.66,126
X$9882 8020 8848 8179 112 8922 113 AOI21_X1
* cell instance $9883 r0 *1 41.42,126
X$9883 8186 8919 8922 113 8977 112 OAI21_X1
* cell instance $9884 r0 *1 42.18,126
X$9884 7228 7499 112 113 8811 NOR2_X2
* cell instance $9885 m0 *1 44.08,126
X$9885 112 8811 7306 7710 6902 7637 7441 8927 113 OAI222_X2
* cell instance $9886 m0 *1 43.13,126
X$9886 8757 8247 7625 113 112 8753 AND3_X1
* cell instance $9887 m0 *1 46.74,126
X$9887 112 8110 113 7002 BUF_X8
* cell instance $9888 m0 *1 49.21,126
X$9888 8756 8926 8911 112 8813 113 AOI21_X2
* cell instance $9890 r0 *1 43.13,126
X$9890 7072 7313 112 113 9037 OR2_X1
* cell instance $9891 r0 *1 43.89,126
X$9891 6969 8247 8554 112 113 8976 NAND3_X1
* cell instance $9893 r0 *1 45.03,126
X$9893 8561 7395 7499 112 8978 113 AOI21_X1
* cell instance $9894 r0 *1 45.79,126
X$9894 8183 8426 112 113 8849 NAND2_X2
* cell instance $9895 r0 *1 46.74,126
X$9895 8808 8754 8020 8846 8927 8926 113 112 AOI221_X2
* cell instance $9896 r0 *1 48.83,126
X$9896 7882 7219 112 113 8186 NAND2_X2
* cell instance $9897 r0 *1 49.78,126
X$9897 8929 8753 8930 7848 113 112 9039 OAI22_X2
* cell instance $9898 m0 *1 51.68,126
X$9898 7395 7621 7403 113 8929 112 OAI21_X1
* cell instance $9899 m0 *1 50.92,126
X$9899 7300 8757 8642 113 8931 112 OAI21_X1
* cell instance $9900 m0 *1 52.44,126
X$9900 7445 8931 8932 113 8930 112 OAI21_X1
* cell instance $9902 m0 *1 53.39,126
X$9902 8186 8814 8752 8934 113 112 8851 OAI22_X1
* cell instance $9904 m0 *1 54.53,126
X$9904 8262 113 8757 112 BUF_X4
* cell instance $9906 m0 *1 56.05,126
X$9906 7882 7503 112 113 8848 NOR2_X2
* cell instance $9908 m0 *1 57.19,126
X$9908 8262 7503 8846 112 113 NOR2_X4
* cell instance $9911 r0 *1 51.49,126
X$9911 8183 7630 112 113 8980 NOR2_X1
* cell instance $9912 r0 *1 52.06,126
X$9912 7313 7065 8191 112 8935 113 AOI21_X1
* cell instance $9913 r0 *1 52.82,126
X$9913 8426 8564 8851 113 112 8850 OAI21_X2
* cell instance $9914 r0 *1 54.15,126
X$9914 7800 7882 7226 112 113 8981 MUX2_X1
* cell instance $9915 r0 *1 55.48,126
X$9915 7965 8935 8848 113 8934 112 OAI21_X1
* cell instance $9917 r0 *1 56.43,126
X$9917 6798 7886 7621 112 8982 113 AOI21_X1
* cell instance $9918 r0 *1 57.19,126
X$9918 6967 7002 112 113 8914 NAND2_X1
* cell instance $9921 r0 *1 58.33,126
X$9921 8183 8756 112 113 8566 NAND2_X2
* cell instance $9923 r0 *1 59.66,126
X$9923 112 8258 6910 113 BUF_X16
* cell instance $9924 m0 *1 62.13,126
X$9924 112 16890 8938 8759 9201 113 DFF_X1
* cell instance $9925 m0 *1 60.8,126
X$9925 8758 113 8262 112 BUF_X4
* cell instance $9926 m0 *1 65.36,126
X$9926 8319 8267 113 8755 112 XOR2_X2
* cell instance $9928 m0 *1 67.26,126
X$9928 112 8760 8941 17212 8765 113 DFF_X2
* cell instance $9934 r0 *1 67.26,126
X$9934 8765 316 8940 112 113 8760 MUX2_X1
* cell instance $9938 r0 *1 68.59,126
X$9938 8938 113 9007 112 BUF_X4
* cell instance $9941 r0 *1 70.87,126
X$9941 8983 8944 5231 113 112 8428 MUX2_X2
* cell instance $9942 m0 *1 71.44,126
X$9942 8855 5371 113 112 8942 XNOR2_X1
* cell instance $9945 m0 *1 73.34,126
X$9945 8121 8942 112 113 8943 XNOR2_X2
* cell instance $9946 m0 *1 75.24,126
X$9946 8195 8855 112 113 8821 XOR2_X1
* cell instance $9947 m0 *1 76.38,126
X$9947 8647 8821 113 112 8820 XNOR2_X1
* cell instance $9949 m0 *1 79.04,126
X$9949 8431 7982 113 8799 112 XOR2_X2
* cell instance $9952 r0 *1 72.77,126
X$9952 112 9048 8854 3438 8943 113 AOI21_X4
* cell instance $9954 r0 *1 75.62,126
X$9954 8646 8984 113 112 8944 XNOR2_X1
* cell instance $9955 r0 *1 76.76,126
X$9955 8855 8761 113 112 8985 XNOR2_X1
* cell instance $9958 r0 *1 79.61,126
X$9958 3725 112 113 8822 BUF_X1
* cell instance $9959 r0 *1 80.18,126
X$9959 3725 8650 112 113 8986 XNOR2_X2
* cell instance $9960 m0 *1 83.03,126
X$9960 8856 113 8649 112 BUF_X4
* cell instance $9961 m0 *1 81.13,126
X$9961 8857 8856 112 113 8763 XNOR2_X2
* cell instance $9962 m0 *1 84.36,126
X$9962 8763 112 113 8625 BUF_X2
* cell instance $9963 m0 *1 85.12,126
X$9963 8947 112 113 8858 BUF_X1
* cell instance $9966 m0 *1 88.92,126
X$9966 8761 8196 113 8949 112 XOR2_X2
* cell instance $9967 m0 *1 90.63,126
X$9967 3571 7982 112 113 8950 NOR2_X1
* cell instance $9970 r0 *1 82.08,126
X$9970 7898 8857 112 113 8947 XNOR2_X2
* cell instance $9971 r0 *1 83.98,126
X$9971 3725 8947 112 113 8987 XNOR2_X2
* cell instance $9972 r0 *1 85.88,126
X$9972 8431 7898 113 8988 112 XOR2_X2
* cell instance $9973 r0 *1 87.59,126
X$9973 8950 8948 112 113 9051 NAND2_X1
* cell instance $9974 r0 *1 88.16,126
X$9974 9050 8858 113 112 9053 XNOR2_X1
* cell instance $9976 r0 *1 89.49,126
X$9976 8950 8949 112 113 9054 NAND2_X1
* cell instance $9977 r0 *1 90.06,126
X$9977 4950 7982 8949 112 9171 113 NAND3_X4
* cell instance $9978 m0 *1 93.67,126
X$9978 8859 8767 8768 8766 113 112 8758 AND4_X1
* cell instance $9979 m0 *1 92.34,126
X$9979 8765 8388 5273 112 113 8766 NAND3_X2
* cell instance $9981 m0 *1 95,126
X$9981 8952 8769 8826 112 113 8767 MUX2_X1
* cell instance $9982 m0 *1 96.33,126
X$9982 8770 8771 112 113 8952 NAND2_X1
* cell instance $9983 m0 *1 96.9,126
X$9983 8771 3438 5273 112 113 8826 NAND3_X1
* cell instance $9986 r0 *1 92.53,126
X$9986 8948 3635 7982 112 113 9173 NAND3_X1
* cell instance $9987 r0 *1 93.29,126
X$9987 5273 3678 8765 112 113 8768 OR3_X2
* cell instance $9988 r0 *1 94.43,126
X$9988 8861 8769 9059 112 113 8859 MUX2_X1
* cell instance $9989 r0 *1 95.76,126
X$9989 8770 8860 112 113 9059 NAND2_X1
* cell instance $9990 r0 *1 96.33,126
X$9990 8860 3784 5273 112 113 8861 NAND3_X1
* cell instance $9991 r0 *1 97.09,126
X$9991 7982 112 113 9060 INV_X1
* cell instance $9992 r0 *1 97.47,126
X$9992 3780 7982 112 113 8990 NAND2_X1
* cell instance $9994 r0 *1 98.42,126
X$9994 3434 3989 112 113 8991 NOR2_X1
* cell instance $9995 m0 *1 100.7,126
X$9995 112 8148 3327 113 BUF_X16
* cell instance $9996 m0 *1 98.8,126
X$9996 3774 8730 112 113 9286 XNOR2_X2
* cell instance $9997 m0 *1 105.45,126
X$9997 8902 3928 8835 112 113 8863 MUX2_X1
* cell instance $9998 m0 *1 106.78,126
X$9998 8955 8825 113 112 8833 XNOR2_X1
* cell instance $9999 m0 *1 107.92,126
X$9999 8267 112 113 8321 INV_X2
* cell instance $10001 m0 *1 109.25,126
X$10001 7238 113 7750 112 BUF_X4
* cell instance $10005 r0 *1 99.56,126
X$10005 112 8953 8993 8436 8992 113 DFF_X1
* cell instance $10006 r0 *1 102.79,126
X$10006 8953 3434 112 113 3841 XNOR2_X2
* cell instance $10007 r0 *1 104.69,126
X$10007 8954 3928 112 113 8996 NAND2_X1
* cell instance $10008 r0 *1 105.26,126
X$10008 8863 112 113 9307 CLKBUF_X3
* cell instance $10010 r0 *1 106.59,126
X$10010 112 8956 9089 8832 8773 113 DFF_X1
* cell instance $10011 r0 *1 109.82,126
X$10011 8956 4598 112 113 5294 XNOR2_X2
* cell instance $10012 m0 *1 114.19,126
X$10012 8958 112 113 8738 CLKBUF_X3
* cell instance $10013 m0 *1 110.96,126
X$10013 112 16894 8958 8772 8773 113 DFF_X1
* cell instance $10014 m0 *1 115.14,126
X$10014 8798 5120 112 113 8959 NAND2_X1
* cell instance $10015 m0 *1 115.71,126
X$10015 112 8961 8834 8866 8959 7189 113 AND4_X4
* cell instance $10017 r0 *1 111.72,126
X$10017 112 17089 8957 8703 8773 113 DFF_X1
* cell instance $10019 r0 *1 115.14,126
X$10019 112 9222 113 8957 BUF_X8
* cell instance $10021 r0 *1 117.8,126
X$10021 8963 8962 8653 113 8961 112 OAI21_X1
* cell instance $10022 r0 *1 118.56,126
X$10022 8652 8267 7246 112 113 8963 NOR3_X1
* cell instance $10023 m0 *1 119.7,126
X$10023 8831 8775 8653 113 8834 112 OAI21_X1
* cell instance $10024 m0 *1 118.56,126
X$10024 8774 8964 8776 8837 113 112 8866 AND4_X1
* cell instance $10025 m0 *1 120.46,126
X$10025 8657 7539 112 113 8654 NOR2_X1
* cell instance $10027 r0 *1 119.32,126
X$10027 8267 7238 112 113 8655 NOR2_X1
* cell instance $10029 r0 *1 120.27,126
X$10029 8655 8656 8867 7539 112 113 8964 NAND4_X1
* cell instance $10031 m0 *1 121.6,126
X$10031 8867 7539 8321 8329 112 113 8962 NOR4_X1
* cell instance $10033 m0 *1 122.55,126
X$10033 7658 8868 112 113 8653 XNOR2_X2
* cell instance $10035 m0 *1 125.21,126
X$10035 112 16897 8828 8777 8780 113 DFF_X1
* cell instance $10036 m0 *1 128.44,126
X$10036 8828 112 113 8657 CLKBUF_X3
* cell instance $10037 m0 *1 129.39,126
X$10037 112 16895 8658 8779 8780 113 DFF_X1
* cell instance $10038 m0 *1 132.62,126
X$10038 112 8441 8869 8967 8780 113 DFF_X1
* cell instance $10039 m0 *1 135.85,126
X$10039 8869 194 8968 112 113 8967 MUX2_X1
* cell instance $10043 r0 *1 122.55,126
X$10043 8868 7658 113 8656 112 XOR2_X2
* cell instance $10049 r0 *1 127.68,126
X$10049 13260 6244 112 113 8966 NOR2_X1
* cell instance $10055 m0 *1 137.75,126
X$10055 112 3874 8577 113 BUF_X32
* cell instance $10057 m0 *1 147.06,126
X$10057 6159 6367 16499 113 112 8339 HA_X1
* cell instance $10058 m0 *1 148.96,126
X$10058 7534 112 113 6688 CLKBUF_X3
* cell instance $10059 m0 *1 149.91,126
X$10059 8283 8536 112 113 7026 NAND2_X2
* cell instance $10060 m0 *1 150.86,126
X$10060 8581 7667 112 113 7870 NAND2_X2
* cell instance $10061 m0 *1 151.81,126
X$10061 8339 7255 6159 6929 112 113 8781 AOI22_X1
* cell instance $10062 m0 *1 152.76,126
X$10062 6789 6080 6934 112 113 8960 NOR3_X1
* cell instance $10063 m0 *1 153.52,126
X$10063 8960 8873 6402 113 8663 112 OAI21_X1
* cell instance $10065 m0 *1 154.47,126
X$10065 7827 6080 112 113 7607 NOR2_X2
* cell instance $10067 m0 *1 155.61,126
X$10067 8280 6367 112 113 7205 NOR2_X2
* cell instance $10069 m0 *1 156.75,126
X$10069 7596 113 7534 112 BUF_X4
* cell instance $10072 r0 *1 139.46,126
X$10072 8870 8454 112 113 9002 NAND2_X1
* cell instance $10077 r0 *1 142.88,126
X$10077 112 6795 8661 8580 8009 113 NOR3_X4
* cell instance $10078 r0 *1 145.54,126
X$10078 112 8871 8536 8443 8338 113 AOI21_X4
* cell instance $10079 r0 *1 148.01,126
X$10079 8871 113 7772 112 BUF_X4
* cell instance $10080 r0 *1 149.34,126
X$10080 8009 8871 112 113 7352 NOR2_X2
* cell instance $10081 r0 *1 150.29,126
X$10081 7604 8823 112 113 8965 NAND2_X1
* cell instance $10082 r0 *1 150.86,126
X$10082 7870 8875 8965 112 8872 113 AOI21_X1
* cell instance $10083 r0 *1 151.62,126
X$10083 8280 112 113 7115 CLKBUF_X3
* cell instance $10086 r0 *1 153.14,126
X$10086 5985 6074 112 113 8873 NOR2_X1
* cell instance $10089 r0 *1 154.66,126
X$10089 6352 7915 6894 112 8951 113 AOI21_X1
* cell instance $10090 r0 *1 155.42,126
X$10090 7596 7915 112 113 6478 NAND2_X2
* cell instance $10091 r0 *1 156.37,126
X$10091 8874 113 6352 112 BUF_X4
* cell instance $10092 r0 *1 157.7,126
X$10092 6478 7115 6701 112 113 8945 NOR3_X1
* cell instance $10095 m0 *1 158.46,126
X$10095 6929 7470 6080 6795 8782 7781 113 112 AOI221_X2
* cell instance $10096 r0 *1 158.65,126
X$10096 8783 8580 8661 113 112 6261 OAI21_X4
* cell instance $10098 m0 *1 160.93,126
X$10098 8782 113 7255 112 BUF_X4
* cell instance $10099 m0 *1 162.45,126
X$10099 8540 112 113 6932 CLKBUF_X3
* cell instance $10100 m0 *1 163.4,126
X$10100 7024 7534 7985 7919 7533 8875 112 113 OAI221_X2
* cell instance $10101 m0 *1 165.49,126
X$10101 8052 8158 112 113 6154 NOR2_X2
* cell instance $10102 m0 *1 166.44,126
X$10102 112 8783 7828 113 BUF_X16
* cell instance $10103 m0 *1 171.19,126
X$10103 8052 113 7533 112 BUF_X4
* cell instance $10105 m0 *1 172.71,126
X$10105 112 7212 5179 113 BUF_X16
* cell instance $10106 m0 *1 177.46,126
X$10106 6775 113 5393 112 BUF_X4
* cell instance $10107 m0 *1 178.79,126
X$10107 8668 8784 112 113 8724 NAND2_X1
* cell instance $10110 r0 *1 161.12,126
X$10110 6154 7375 112 113 9042 OR2_X1
* cell instance $10112 r0 *1 162.07,126
X$10112 8951 6932 8737 7923 8448 9102 112 113 OAI221_X2
* cell instance $10114 r0 *1 164.35,126
X$10114 8945 8876 8946 8877 113 7471 112 NOR4_X2
* cell instance $10115 r0 *1 166.06,126
X$10115 112 8161 113 9153 BUF_X8
* cell instance $10117 r0 *1 168.91,126
X$10117 7915 9004 9005 112 6935 113 AOI21_X2
* cell instance $10118 r0 *1 170.24,126
X$10118 112 8536 7024 113 BUF_X16
* cell instance $10119 r0 *1 174.99,126
X$10119 7923 6688 8173 112 113 8877 NOR3_X1
* cell instance $10120 r0 *1 175.75,126
X$10120 7533 8217 7922 112 113 8784 NAND3_X1
* cell instance $10121 r0 *1 176.51,126
X$10121 8282 112 113 8735 BUF_X1
* cell instance $10122 r0 *1 177.08,126
X$10122 9103 112 113 9004 BUF_X1
* cell instance $10124 r0 *1 178.03,126
X$10124 8879 7041 8403 113 112 8939 MUX2_X2
* cell instance $10129 r0 *1 180.12,126
X$10129 8881 7518 112 113 8878 NAND2_X2
* cell instance $10132 r0 *1 182.02,126
X$10132 112 17114 8879 8937 8880 113 DFF_X1
* cell instance $10134 m0 *1 182.78,126
X$10134 8870 7539 112 113 8812 NAND2_X1
* cell instance $10135 m0 *1 184.87,126
X$10135 8810 4763 113 8883 112 XOR2_X2
* cell instance $10136 m0 *1 186.58,126
X$10136 112 16876 8881 8936 8880 113 DFF_X1
* cell instance $10137 m0 *1 189.81,126
X$10137 8881 8785 8688 112 113 8936 MUX2_X1
* cell instance $10138 m0 *1 191.14,126
X$10138 112 7516 5250 113 BUF_X16
* cell instance $10140 r0 *1 185.25,126
X$10140 8879 5995 9016 112 113 8937 MUX2_X1
* cell instance $10143 r0 *1 189.81,126
X$10143 8880 112 113 17181 INV_X2
* cell instance $10147 r0 *1 192.85,126
X$10147 8882 9031 3937 113 112 8616 MUX2_X2
* cell instance $10148 r0 *1 194.56,126
X$10148 5321 8933 113 8908 112 XOR2_X2
* cell instance $10149 m0 *1 198.74,126
X$10149 3304 3932 113 8786 112 XOR2_X2
* cell instance $10150 m0 *1 196.27,126
X$10150 112 7738 113 3780 BUF_X8
* cell instance $10156 r0 *1 201.21,126
X$10156 8910 7930 112 113 9010 NAND2_X1
* cell instance $10157 m0 *1 203.49,126
X$10157 8884 5785 113 112 8885 XNOR2_X1
* cell instance $10158 m0 *1 201.59,126
X$10158 6333 8884 112 113 8825 XNOR2_X2
* cell instance $10161 m0 *1 205.58,126
X$10161 8687 8295 8885 112 113 8886 MUX2_X1
* cell instance $10162 m0 *1 206.91,126
X$10162 8928 112 113 6333 CLKBUF_X3
* cell instance $10168 r0 *1 206.15,126
X$10168 112 16964 9027 8886 8887 113 DFF_X1
* cell instance $10170 m0 *1 208.24,126
X$10170 112 16855 8928 8787 8887 113 DFF_X1
* cell instance $10176 m0 *1 215.08,126
X$10176 6562 5425 8888 113 112 8889 HA_X1
* cell instance $10177 m0 *1 214.13,126
X$10177 8674 8063 8888 6733 112 113 9125 AOI22_X1
* cell instance $10179 r0 *1 214.13,126
X$10179 7325 5425 16705 113 112 8925 HA_X1
* cell instance $10182 r0 *1 216.98,126
X$10182 8923 7048 8675 112 8924 113 AOI21_X1
* cell instance $10184 m0 *1 217.36,126
X$10184 7689 8925 8889 112 113 7934 NOR3_X1
* cell instance $10185 r0 *1 217.74,126
X$10185 9021 112 113 8676 INV_X1
* cell instance $10186 r0 *1 218.12,126
X$10186 7048 8891 112 113 8923 NOR2_X1
* cell instance $10188 m0 *1 218.5,126
X$10188 8920 8677 8063 112 7446 113 AOI21_X1
* cell instance $10189 m0 *1 219.45,126
X$10189 8806 7833 6831 7051 8788 113 112 8805 OAI221_X1
* cell instance $10190 m0 *1 220.59,126
X$10190 7563 8921 6311 112 8920 113 AOI21_X1
* cell instance $10194 r0 *1 218.88,126
X$10194 7095 6311 112 113 9022 NAND2_X1
* cell instance $10196 r0 *1 219.83,126
X$10196 6831 8890 8805 113 8226 112 OAI21_X1
* cell instance $10198 r0 *1 220.97,126
X$10198 6562 5564 16643 113 112 8891 HA_X1
* cell instance $10200 m0 *1 132.24,240.8
X$10200 16400 112 113 13544 BUF_X1
* cell instance $10201 m0 *1 131.67,240.8
X$10201 16419 112 113 16378 BUF_X1
* cell instance $10202 m0 *1 132.81,240.8
X$10202 16446 112 113 9602 CLKBUF_X2
* cell instance $10203 m0 *1 133.57,240.8
X$10203 16360 112 113 16420 BUF_X1
* cell instance $10204 m0 *1 134.14,240.8
X$10204 16413 112 113 16452 BUF_X1
* cell instance $10206 m0 *1 134.9,240.8
X$10206 16448 112 113 13746 BUF_X1
* cell instance $10207 m0 *1 135.47,240.8
X$10207 16447 112 113 14067 BUF_X2
* cell instance $10208 m0 *1 136.23,240.8
X$10208 16401 112 113 8968 CLKBUF_X2
* cell instance $10210 m0 *1 152.19,240.8
X$10210 16369 112 113 16439 BUF_X1
* cell instance $10211 m0 *1 151.62,240.8
X$10211 16430 112 113 10435 BUF_X1
* cell instance $10212 m0 *1 152.76,240.8
X$10212 16438 112 113 14077 BUF_X1
* cell instance $10215 m0 *1 146.49,240.8
X$10215 16412 112 113 13880 BUF_X1
* cell instance $10217 m0 *1 147.06,240.8
X$10217 16457 112 113 11866 BUF_X1
* cell instance $10219 m0 *1 148.39,240.8
X$10219 16428 112 113 10089 BUF_X1
* cell instance $10220 m0 *1 148.96,240.8
X$10220 16366 112 113 16458 BUF_X1
* cell instance $10221 m0 *1 149.53,240.8
X$10221 16443 112 113 16317 BUF_X1
* cell instance $10222 m0 *1 150.1,240.8
X$10222 16429 112 113 13944 BUF_X1
* cell instance $10223 m0 *1 150.67,240.8
X$10223 16442 112 113 14007 BUF_X1
* cell instance $10225 m0 *1 155.42,240.8
X$10225 16388 112 113 16436 BUF_X1
* cell instance $10230 m0 *1 160.36,240.8
X$10230 16431 112 113 10771 BUF_X1
* cell instance $10232 m0 *1 160.93,240.8
X$10232 16410 112 113 13939 BUF_X1
* cell instance $10234 m0 *1 161.69,240.8
X$10234 16407 112 113 16434 BUF_X1
* cell instance $10237 m0 *1 163.97,240.8
X$10237 16408 112 113 16432 BUF_X1
* cell instance $10259 m0 *1 235.98,120.4
X$10259 8469 112 113 8364 BUF_X1
* cell instance $10260 m0 *1 235.41,120.4
X$10260 8598 112 113 8365 BUF_X1
* cell instance $10262 m0 *1 238.07,120.4
X$10262 8468 112 113 8363 BUF_X1
* cell instance $10263 m0 *1 238.64,120.4
X$10263 8596 112 113 8599 BUF_X1
* cell instance $10264 m0 *1 239.21,120.4
X$10264 8466 112 113 8361 BUF_X1
* cell instance $10267 r0 *1 235.6,120.4
X$10267 8467 112 113 8534 CLKBUF_X2
* cell instance $10272 r0 *1 236.55,120.4
X$10272 112 16969 8466 8473 6437 113 DFF_X1
* cell instance $10274 m0 *1 110.39,240.8
X$10274 16368 112 113 16433 BUF_X1
* cell instance $10288 r0 *1 123.69,11.2
X$10288 112 17136 143 274 152 113 DFF_X1
* cell instance $10310 m0 *1 12.35,159.6
X$10310 11867 112 113 11167 BUF_X1
* cell instance $10320 r0 *1 19.95,159.6
X$10320 112 16965 12097 11202 11557 113 DFF_X1
* cell instance $10324 m0 *1 33.63,159.6
X$10324 10224 113 11944 112 BUF_X4
* cell instance $10325 m0 *1 33.06,159.6
X$10325 10803 10975 112 113 11947 NAND2_X1
* cell instance $10326 m0 *1 34.96,159.6
X$10326 10967 11716 11868 112 113 NOR2_X4
* cell instance $10327 m0 *1 36.67,159.6
X$10327 10967 10401 11058 112 113 11811 MUX2_X1
* cell instance $10328 m0 *1 38,159.6
X$10328 11170 11947 11948 11811 11718 113 112 11810 OAI221_X1
* cell instance $10329 m0 *1 39.14,159.6
X$10329 11813 10797 12017 112 113 11814 MUX2_X1
* cell instance $10332 r0 *1 33.44,159.6
X$10332 10967 10547 112 113 12098 NOR2_X1
* cell instance $10333 r0 *1 34.01,159.6
X$10333 10454 10230 112 113 12101 NOR2_X1
* cell instance $10334 r0 *1 34.58,159.6
X$10334 12099 11058 12098 112 113 11945 MUX2_X1
* cell instance $10335 r0 *1 35.91,159.6
X$10335 10454 10319 112 113 12015 NOR2_X1
* cell instance $10336 r0 *1 36.48,159.6
X$10336 11868 11944 10741 112 11822 113 AOI21_X2
* cell instance $10338 r0 *1 38.19,159.6
X$10338 11393 11719 11944 11559 113 112 11249 OAI22_X1
* cell instance $10339 r0 *1 39.14,159.6
X$10339 10967 10454 112 113 12016 NAND2_X2
* cell instance $10341 r0 *1 40.47,159.6
X$10341 10225 11481 113 112 11560 AND2_X1
* cell instance $10342 m0 *1 42.18,159.6
X$10342 11951 11882 11814 112 113 11180 MUX2_X1
* cell instance $10343 m0 *1 40.85,159.6
X$10343 10512 10677 11250 112 11869 113 AOI21_X2
* cell instance $10344 m0 *1 43.51,159.6
X$10344 11873 11815 113 112 11951 AND2_X1
* cell instance $10346 m0 *1 44.46,159.6
X$10346 10315 10554 11092 10458 112 113 11721 AOI22_X1
* cell instance $10347 m0 *1 45.41,159.6
X$10347 11716 11719 11721 113 12110 112 OAI21_X1
* cell instance $10348 m0 *1 46.17,159.6
X$10348 10807 10457 112 113 11091 NAND2_X1
* cell instance $10349 m0 *1 46.74,159.6
X$10349 10463 10320 112 113 11817 NOR2_X2
* cell instance $10350 m0 *1 47.69,159.6
X$10350 10463 113 11720 112 BUF_X4
* cell instance $10351 m0 *1 49.02,159.6
X$10351 11058 10630 112 113 11875 NAND2_X2
* cell instance $10352 m0 *1 49.97,159.6
X$10352 12113 11956 11876 113 11645 112 OAI21_X1
* cell instance $10354 r0 *1 41.23,159.6
X$10354 10450 11720 11479 113 12105 112 OAI21_X1
* cell instance $10356 r0 *1 42.18,159.6
X$10356 11720 12106 10742 112 11872 113 AOI21_X1
* cell instance $10357 r0 *1 42.94,159.6
X$10357 10741 11489 11872 11251 12179 113 112 11873 OAI221_X1
* cell instance $10358 r0 *1 44.08,159.6
X$10358 12107 11945 11874 113 11500 112 OAI21_X1
* cell instance $10359 r0 *1 44.84,159.6
X$10359 12108 11562 12019 12110 113 112 12109 OAI22_X1
* cell instance $10360 r0 *1 45.79,159.6
X$10360 10322 11871 10548 112 12108 113 AOI21_X1
* cell instance $10362 r0 *1 46.74,159.6
X$10362 10682 10557 112 113 12111 NAND2_X1
* cell instance $10363 r0 *1 47.31,159.6
X$10363 11641 10548 11817 10969 10512 113 112 12113 OAI221_X1
* cell instance $10364 r0 *1 48.45,159.6
X$10364 11476 10317 112 113 11652 NAND2_X1
* cell instance $10365 r0 *1 49.02,159.6
X$10365 10794 113 11725 112 BUF_X4
* cell instance $10366 r0 *1 50.35,159.6
X$10366 10167 10618 10741 112 113 12114 NAND3_X2
* cell instance $10367 m0 *1 51.87,159.6
X$10367 11957 11565 10798 10983 11722 113 112 11723 OAI221_X1
* cell instance $10368 m0 *1 51.11,159.6
X$10368 10967 10390 112 113 11957 OR2_X1
* cell instance $10369 m0 *1 53.01,159.6
X$10369 11723 11821 113 112 11959 AND2_X2
* cell instance $10370 m0 *1 53.96,159.6
X$10370 10390 11197 11720 10635 11822 11961 113 112 AOI221_X2
* cell instance $10371 m0 *1 56.05,159.6
X$10371 11962 10976 11724 11398 11825 113 112 11566 OAI221_X1
* cell instance $10372 m0 *1 57.19,159.6
X$10372 11725 10553 11944 112 113 11726 MUX2_X1
* cell instance $10373 m0 *1 58.52,159.6
X$10373 11568 11727 11880 11726 112 113 11965 AOI22_X1
* cell instance $10374 m0 *1 59.47,159.6
X$10374 10315 11641 112 113 11727 NAND2_X1
* cell instance $10375 m0 *1 60.04,159.6
X$10375 11399 10983 112 113 11568 NOR2_X1
* cell instance $10376 m0 *1 60.61,159.6
X$10376 11197 11729 11967 11882 11819 11971 113 112 AOI221_X2
* cell instance $10378 r0 *1 51.68,159.6
X$10378 11563 12117 12183 12020 113 12115 112 NOR4_X2
* cell instance $10379 r0 *1 53.39,159.6
X$10379 11399 10450 10409 112 11877 113 AOI21_X1
* cell instance $10380 r0 *1 54.15,159.6
X$10380 10450 11251 10549 113 12021 112 OAI21_X1
* cell instance $10381 r0 *1 54.91,159.6
X$10381 11058 11878 10454 11251 113 112 12120 OAI22_X1
* cell instance $10382 r0 *1 55.86,159.6
X$10382 10624 112 113 12122 BUF_X1
* cell instance $10383 r0 *1 56.43,159.6
X$10383 12022 11968 11961 113 11396 112 OAI21_X1
* cell instance $10384 r0 *1 57.19,159.6
X$10384 10326 10454 112 113 11878 NAND2_X1
* cell instance $10385 r0 *1 57.76,159.6
X$10385 11725 10406 10553 10975 12120 112 113 11879 AOI221_X1
* cell instance $10386 r0 *1 58.9,159.6
X$10386 11874 11254 112 113 11881 NAND2_X1
* cell instance $10387 r0 *1 59.47,159.6
X$10387 11881 11879 11728 112 113 12123 OR3_X1
* cell instance $10389 r0 *1 60.8,159.6
X$10389 12021 10800 112 113 11970 NAND2_X1
* cell instance $10391 r0 *1 61.75,159.6
X$10391 12024 10976 11882 113 12025 112 OAI21_X1
* cell instance $10395 m0 *1 63.08,159.6
X$10395 11730 11828 113 112 11968 AND2_X1
* cell instance $10396 r0 *1 63.08,159.6
X$10396 10685 10739 112 113 11874 NOR2_X2
* cell instance $10397 r0 *1 64.03,159.6
X$10397 11970 12025 11874 12019 112 113 11883 NAND4_X1
* cell instance $10398 m0 *1 64.41,159.6
X$10398 11724 11971 12189 113 11832 112 OAI21_X1
* cell instance $10404 m0 *1 67.26,159.6
X$10404 112 16905 11834 11884 11099 113 DFF_X1
* cell instance $10409 m0 *1 72.96,159.6
X$10409 112 11734 113 11885 BUF_X8
* cell instance $10412 m0 *1 76.38,159.6
X$10412 11068 112 113 11885 INV_X2
* cell instance $10413 m0 *1 76.95,159.6
X$10413 11513 11885 11209 112 113 11976 MUX2_X1
* cell instance $10414 m0 *1 78.28,159.6
X$10414 11732 112 113 11581 CLKBUF_X3
* cell instance $10416 r0 *1 67.26,159.6
X$10416 8133 112 113 10234 CLKBUF_X3
* cell instance $10420 r0 *1 68.21,159.6
X$10420 10234 112 113 17175 INV_X2
* cell instance $10424 r0 *1 71.25,159.6
X$10424 12034 11573 11885 112 113 12127 MUX2_X1
* cell instance $10425 r0 *1 72.58,159.6
X$10425 8819 10109 113 11974 112 XOR2_X2
* cell instance $10428 r0 *1 75.24,159.6
X$10428 11403 12028 11573 112 11975 113 AOI21_X1
* cell instance $10430 r0 *1 76.38,159.6
X$10430 11403 112 113 11521 INV_X4
* cell instance $10431 r0 *1 77.33,159.6
X$10431 10531 112 113 12129 BUF_X1
* cell instance $10432 r0 *1 77.9,159.6
X$10432 12130 11581 12128 112 11979 113 AOI21_X1
* cell instance $10433 r0 *1 78.66,159.6
X$10433 11975 12190 10810 12029 11669 12130 113 112 AOI221_X2
* cell instance $10434 m0 *1 79.8,159.6
X$10434 10810 113 11732 112 BUF_X4
* cell instance $10436 m0 *1 81.13,159.6
X$10436 11737 10531 11976 11735 11980 11978 113 112 AOI221_X2
* cell instance $10438 r0 *1 80.75,159.6
X$10438 11736 113 12133 112 BUF_X4
* cell instance $10440 r0 *1 82.46,159.6
X$10440 11836 12135 11979 112 113 12134 MUX2_X1
* cell instance $10441 m0 *1 85.69,159.6
X$10441 11068 11661 11411 113 11737 112 OAI21_X1
* cell instance $10442 m0 *1 83.6,159.6
X$10442 8864 10922 11981 11403 11359 12678 113 112 AOI221_X2
* cell instance $10444 m0 *1 86.64,159.6
X$10444 11735 10692 10812 113 112 11886 OAI21_X2
* cell instance $10446 r0 *1 83.79,159.6
X$10446 10810 112 113 12031 INV_X1
* cell instance $10447 r0 *1 84.17,159.6
X$10447 11887 11736 12031 11574 11572 12038 113 112 AOI221_X2
* cell instance $10450 r0 *1 87.4,159.6
X$10450 11844 11973 11887 113 12138 112 OAI21_X1
* cell instance $10451 r0 *1 88.16,159.6
X$10451 11886 11515 11888 112 113 12033 NAND3_X1
* cell instance $10452 m0 *1 89.11,159.6
X$10452 11889 11740 11581 113 11741 112 OAI21_X1
* cell instance $10453 m0 *1 88.35,159.6
X$10453 11671 11982 11888 112 113 11889 NOR3_X1
* cell instance $10454 m0 *1 89.87,159.6
X$10454 11744 11741 11840 113 112 11984 AND3_X1
* cell instance $10455 m0 *1 90.82,159.6
X$10455 11579 11580 11743 112 113 11840 NAND3_X1
* cell instance $10456 m0 *1 91.58,159.6
X$10456 11517 11212 11583 113 11890 112 OAI21_X1
* cell instance $10460 r0 *1 89.3,159.6
X$10460 10692 11578 12028 113 11887 112 OAI21_X1
* cell instance $10461 r0 *1 90.06,159.6
X$10461 11572 10531 112 113 11982 NOR2_X1
* cell instance $10464 r0 *1 91.2,159.6
X$10464 10692 10812 11360 113 12142 112 NOR3_X2
* cell instance $10465 r0 *1 92.53,159.6
X$10465 11732 11890 12143 112 11989 113 AOI21_X1
* cell instance $10467 r0 *1 93.67,159.6
X$10467 11070 12034 11973 112 12145 113 AOI21_X1
* cell instance $10468 m0 *1 94.43,159.6
X$10468 11988 11891 11745 11263 11676 113 112 11845 OAI221_X1
* cell instance $10470 m0 *1 95.57,159.6
X$10470 11884 11893 11990 113 11992 112 OAI21_X1
* cell instance $10472 r0 *1 94.43,159.6
X$10472 12146 11884 12145 112 11891 113 AOI21_X1
* cell instance $10474 r0 *1 95.57,159.6
X$10474 11892 12036 11888 112 113 11990 NAND3_X1
* cell instance $10475 r0 *1 96.33,159.6
X$10475 11989 11663 12147 112 11994 113 AOI21_X1
* cell instance $10476 m0 *1 96.9,159.6
X$10476 11732 112 113 11663 CLKBUF_X3
* cell instance $10478 m0 *1 97.85,159.6
X$10478 11743 11992 11894 9086 10659 113 112 12149 OAI221_X1
* cell instance $10479 m0 *1 98.99,159.6
X$10479 9086 10659 11995 112 113 NOR2_X4
* cell instance $10482 m0 *1 108.3,159.6
X$10482 10240 10305 11746 112 11850 113 AOI21_X1
* cell instance $10483 m0 *1 109.06,159.6
X$10483 12001 11417 11851 9734 112 113 11998 NAND4_X1
* cell instance $10485 r0 *1 97.09,159.6
X$10485 11663 12034 11888 112 11993 113 AOI21_X1
* cell instance $10486 r0 *1 97.85,159.6
X$10486 11884 12037 11993 113 11894 112 OAI21_X1
* cell instance $10488 r0 *1 98.99,159.6
X$10488 11895 12039 10120 12477 11994 12040 113 112 AOI221_X2
* cell instance $10490 r0 *1 107.16,159.6
X$10490 9980 10127 112 113 12041 NOR2_X1
* cell instance $10492 r0 *1 107.92,159.6
X$10492 12041 11998 12153 10664 112 113 12042 NAND4_X1
* cell instance $10493 r0 *1 108.87,159.6
X$10493 12152 11685 10200 113 12278 112 OAI21_X1
* cell instance $10496 r0 *1 110.2,159.6
X$10496 11746 10305 112 113 11896 NAND2_X1
* cell instance $10497 m0 *1 111.15,159.6
X$10497 10343 10573 10213 112 113 11746 MUX2_X1
* cell instance $10498 m0 *1 110.39,159.6
X$10498 10202 11747 11713 112 113 12155 NAND3_X1
* cell instance $10499 m0 *1 112.48,159.6
X$10499 10466 10536 112 113 12004 NOR2_X1
* cell instance $10500 m0 *1 113.05,159.6
X$10500 10198 10125 112 113 11747 NAND2_X1
* cell instance $10501 m0 *1 113.62,159.6
X$10501 12004 11418 10243 112 113 11897 NOR3_X1
* cell instance $10503 m0 *1 115.9,159.6
X$10503 10202 10067 11753 112 113 11856 NAND3_X1
* cell instance $10504 m0 *1 116.66,159.6
X$10504 10245 10818 11856 113 11857 112 OAI21_X1
* cell instance $10506 r0 *1 110.77,159.6
X$10506 11896 12155 11417 112 113 12157 NAND3_X1
* cell instance $10509 r0 *1 112.48,159.6
X$10509 10243 9971 112 113 12158 NOR2_X1
* cell instance $10511 r0 *1 113.24,159.6
X$10511 12160 12044 12158 10466 11266 113 112 12043 OAI221_X1
* cell instance $10513 r0 *1 114.57,159.6
X$10513 12160 10472 11753 112 10069 113 AOI21_X1
* cell instance $10514 r0 *1 115.33,159.6
X$10514 9826 10822 10573 113 12160 112 OAI21_X1
* cell instance $10516 r0 *1 116.28,159.6
X$10516 11590 10573 12045 112 113 12165 MUX2_X1
* cell instance $10517 r0 *1 117.61,159.6
X$10517 10818 10245 12165 112 113 12169 MUX2_X1
* cell instance $10518 m0 *1 117.99,159.6
X$10518 10257 11748 112 113 11268 NOR2_X1
* cell instance $10521 m0 *1 120.08,159.6
X$10521 10937 11268 11858 113 12331 112 OAI21_X1
* cell instance $10523 m0 *1 121.03,159.6
X$10523 9980 9971 112 113 11749 NOR2_X1
* cell instance $10525 r0 *1 118.94,159.6
X$10525 12330 10240 10200 12047 12046 113 112 12153 OAI221_X1
* cell instance $10526 r0 *1 120.08,159.6
X$10526 10441 10466 9962 113 12046 112 OAI21_X1
* cell instance $10528 r0 *1 121.03,159.6
X$10528 12009 11903 11749 113 11109 112 OAI21_X1
* cell instance $10530 m0 *1 124.07,159.6
X$10530 11748 11270 10257 112 12010 113 AOI21_X1
* cell instance $10531 m0 *1 121.98,159.6
X$10531 9734 12010 12012 10662 11751 11750 112 113 OAI221_X2
* cell instance $10533 r0 *1 122.55,159.6
X$10533 12171 10127 12169 113 112 12011 OAI21_X2
* cell instance $10534 r0 *1 123.88,159.6
X$10534 12170 9734 12048 112 12012 113 AOI21_X1
* cell instance $10539 r0 *1 124.83,159.6
X$10539 11898 12014 9941 12013 12173 12171 113 112 AOI221_X2
* cell instance $10540 m0 *1 126.16,159.6
X$10540 9979 10343 112 113 11898 NAND2_X1
* cell instance $10541 m0 *1 125.21,159.6
X$10541 10349 9942 11267 113 112 12014 AND3_X1
* cell instance $10544 m0 *1 127.3,159.6
X$10544 11426 10536 11753 112 11754 113 AOI21_X1
* cell instance $10546 m0 *1 128.06,159.6
X$10546 10574 11754 10536 11899 113 112 11864 OAI22_X1
* cell instance $10549 m0 *1 129.96,159.6
X$10549 11389 11713 12005 112 12008 113 AOI21_X1
* cell instance $10551 m0 *1 130.91,159.6
X$10551 11425 12008 11080 11857 9701 11901 112 113 OAI221_X2
* cell instance $10552 m0 *1 133,159.6
X$10552 11757 11748 9974 10476 11756 112 113 11865 AOI221_X1
* cell instance $10553 m0 *1 134.14,159.6
X$10553 10705 11757 112 113 12007 NOR2_X1
* cell instance $10554 m0 *1 134.71,159.6
X$10554 9982 10257 113 112 12006 AND2_X1
* cell instance $10557 r0 *1 127.3,159.6
X$10557 10574 11898 11899 112 12047 113 AOI21_X2
* cell instance $10558 r0 *1 128.63,159.6
X$10558 11900 10250 112 113 12173 NOR2_X1
* cell instance $10562 r0 *1 130.34,159.6
X$10562 12293 11901 12172 12174 113 112 10190 OAI22_X2
* cell instance $10564 r0 *1 133.57,159.6
X$10564 11425 12006 12007 11080 11902 12047 112 113 11903 OAI33_X1
* cell instance $10565 r0 *1 134.9,159.6
X$10565 11900 11592 11110 112 113 11902 NOR3_X1
* cell instance $10566 r0 *1 135.66,159.6
X$10566 112 10441 10347 10346 11900 113 NOR3_X4
* cell instance $10567 m0 *1 137.37,159.6
X$10567 9733 113 10573 112 BUF_X4
* cell instance $10568 m0 *1 136.61,159.6
X$10568 11748 10257 112 113 10705 OR2_X1
* cell instance $10569 m0 *1 138.7,159.6
X$10569 10137 113 11001 112 BUF_X4
* cell instance $10572 m0 *1 140.98,159.6
X$10572 112 11748 10137 10210 10135 113 AOI21_X4
* cell instance $10577 r0 *1 139.46,159.6
X$10577 12052 10137 12005 112 113 NOR2_X4
* cell instance $10578 r0 *1 141.17,159.6
X$10578 112 12052 10776 113 BUF_X16
* cell instance $10579 m0 *1 144.78,159.6
X$10579 6209 112 113 12003 BUF_X1
* cell instance $10582 m0 *1 145.92,159.6
X$10582 11758 11759 12003 113 112 12002 MUX2_X2
* cell instance $10587 m0 *1 152.95,159.6
X$10587 11761 12056 11859 12000 11003 12166 112 113 OAI221_X2
* cell instance $10588 m0 *1 155.04,159.6
X$10588 11999 11123 112 113 12000 NOR2_X1
* cell instance $10590 r0 *1 145.92,159.6
X$10590 112 11760 12054 12168 11904 113 DFF_X1
* cell instance $10591 r0 *1 149.15,159.6
X$10591 8933 12054 113 112 12167 XNOR2_X1
* cell instance $10594 r0 *1 151.43,159.6
X$10594 11905 12164 12162 11682 12166 10052 113 112 AOI221_X2
* cell instance $10595 r0 *1 153.52,159.6
X$10595 112 12056 12613 11862 12161 113 NOR3_X4
* cell instance $10596 m0 *1 157.32,159.6
X$10596 11123 11996 11281 112 11907 113 AOI21_X1
* cell instance $10597 m0 *1 155.99,159.6
X$10597 11906 11283 11997 112 113 11859 MUX2_X1
* cell instance $10599 r0 *1 156.18,159.6
X$10599 12163 11906 11129 112 113 11999 NOR3_X1
* cell instance $10600 r0 *1 156.94,159.6
X$10600 12159 12058 11124 12161 113 12162 112 NOR4_X2
* cell instance $10601 m0 *1 158.65,159.6
X$10601 11448 11527 11908 11432 11991 113 112 11910 OAI221_X1
* cell instance $10603 m0 *1 159.79,159.6
X$10603 11693 11602 11437 112 113 11996 MUX2_X1
* cell instance $10604 m0 *1 161.12,159.6
X$10604 11765 12062 11693 11525 113 112 11766 OAI22_X1
* cell instance $10605 m0 *1 162.07,159.6
X$10605 11767 11770 10833 11768 11769 113 112 11439 OAI221_X1
* cell instance $10606 m0 *1 163.21,159.6
X$10606 11912 11775 11778 11525 113 112 11767 OAI22_X1
* cell instance $10608 r0 *1 158.65,159.6
X$10608 11910 11537 11909 112 12159 113 AOI21_X1
* cell instance $10610 r0 *1 159.6,159.6
X$10610 12059 11911 11918 112 11997 113 AOI21_X1
* cell instance $10611 r0 *1 160.36,159.6
X$10611 11446 12154 12061 112 12059 113 AOI21_X1
* cell instance $10613 r0 *1 161.31,159.6
X$10613 11126 10834 112 113 12056 NAND2_X2
* cell instance $10616 r0 *1 163.21,159.6
X$10616 12068 11913 112 113 12154 NAND2_X1
* cell instance $10617 r0 *1 163.78,159.6
X$10617 11444 11522 112 113 11909 NAND2_X1
* cell instance $10619 m0 *1 165.68,159.6
X$10619 11523 11208 112 113 11441 NAND2_X1
* cell instance $10620 m0 *1 164.54,159.6
X$10620 11605 11854 11128 11770 12064 113 112 11987 OAI221_X1
* cell instance $10622 m0 *1 166.44,159.6
X$10622 11129 11441 11986 112 12065 113 AOI21_X1
* cell instance $10624 m0 *1 167.39,159.6
X$10624 11985 11852 112 113 11854 NAND2_X1
* cell instance $10625 m0 *1 167.96,159.6
X$10625 11688 11972 11287 10834 112 113 11852 NAND4_X1
* cell instance $10628 m0 *1 170.62,159.6
X$10628 11531 11447 11449 11915 11775 11234 112 113 OAI221_X2
* cell instance $10630 m0 *1 172.9,159.6
X$10630 11523 11450 112 113 11775 NAND2_X1
* cell instance $10631 m0 *1 173.47,159.6
X$10631 11519 11450 112 113 12061 NAND2_X1
* cell instance $10635 r0 *1 165.68,159.6
X$10635 11987 11907 12065 112 11983 113 AOI21_X1
* cell instance $10636 r0 *1 166.44,159.6
X$10636 11433 11914 11919 112 11986 113 AOI21_X1
* cell instance $10638 r0 *1 167.39,159.6
X$10638 11913 112 113 12067 INV_X1
* cell instance $10640 r0 *1 167.96,159.6
X$10640 12067 11432 112 113 12069 OR2_X1
* cell instance $10642 r0 *1 168.91,159.6
X$10642 10836 12150 11601 112 11985 113 AOI21_X1
* cell instance $10643 r0 *1 169.67,159.6
X$10643 12068 11916 11534 113 112 12070 OAI21_X4
* cell instance $10644 r0 *1 172.14,159.6
X$10644 11916 112 113 11285 BUF_X1
* cell instance $10646 r0 *1 172.9,159.6
X$10646 11917 12286 11921 113 12071 112 OAI21_X1
* cell instance $10648 r0 *1 174.04,159.6
X$10648 11291 10713 112 113 11908 NOR2_X2
* cell instance $10649 m0 *1 176.51,159.6
X$10649 11291 10713 112 113 11768 NAND2_X2
* cell instance $10650 m0 *1 174.42,159.6
X$10650 11284 11918 11291 11779 11919 11776 113 112 AOI221_X2
* cell instance $10651 m0 *1 177.46,159.6
X$10651 11977 112 113 11293 INV_X4
* cell instance $10652 m0 *1 178.41,159.6
X$10652 11523 11780 11784 112 11779 113 AOI21_X2
* cell instance $10653 m0 *1 179.74,159.6
X$10653 11921 11672 11778 11781 113 112 11920 OAI22_X1
* cell instance $10655 r0 *1 174.99,159.6
X$10655 13039 12072 11607 112 11290 113 AOI21_X1
* cell instance $10656 r0 *1 175.75,159.6
X$10656 11292 11842 112 113 11918 NOR2_X1
* cell instance $10658 r0 *1 176.7,159.6
X$10658 11213 11855 11920 112 11774 113 AOI21_X1
* cell instance $10659 r0 *1 177.46,159.6
X$10659 11784 11780 11917 11919 12219 112 113 12141 AOI221_X1
* cell instance $10661 r0 *1 178.98,159.6
X$10661 11126 11906 12141 11130 11781 12077 112 113 12074 OAI33_X1
* cell instance $10665 r0 *1 180.31,159.6
X$10665 11125 11003 112 113 12139 NAND2_X1
* cell instance $10666 r0 *1 180.88,159.6
X$10666 11610 112 113 11921 CLKBUF_X3
* cell instance $10667 m0 *1 182.4,159.6
X$10667 11610 112 113 11367 CLKBUF_X3
* cell instance $10668 m0 *1 181.07,159.6
X$10668 11523 113 11289 112 BUF_X4
* cell instance $10671 r0 *1 182.02,159.6
X$10671 11523 113 12068 112 BUF_X4
* cell instance $10672 r0 *1 183.35,159.6
X$10672 12224 11782 11519 112 12075 113 AOI21_X1
* cell instance $10673 m0 *1 185.06,159.6
X$10673 11367 11291 112 113 11781 NAND2_X2
* cell instance $10674 m0 *1 183.73,159.6
X$10674 11782 113 11526 112 BUF_X4
* cell instance $10675 m0 *1 186.01,159.6
X$10675 11783 112 113 11432 CLKBUF_X3
* cell instance $10676 m0 *1 186.96,159.6
X$10676 11611 112 113 12132 BUF_X1
* cell instance $10678 r0 *1 184.11,159.6
X$10678 11922 11014 11780 11784 11912 113 112 AOI211_X2
* cell instance $10679 r0 *1 185.82,159.6
X$10679 11783 11915 112 113 12076 NOR2_X1
* cell instance $10680 r0 *1 186.39,159.6
X$10680 12131 12079 112 113 12078 NAND2_X1
* cell instance $10682 r0 *1 187.34,159.6
X$10682 11519 11969 11922 113 112 11972 OAI21_X4
* cell instance $10683 m0 *1 189.62,159.6
X$10683 8933 8516 112 113 11837 XNOR2_X2
* cell instance $10684 m0 *1 187.91,159.6
X$10684 11453 11294 11610 112 113 NOR2_X4
* cell instance $10687 r0 *1 189.81,159.6
X$10687 11014 11923 12080 112 113 NOR2_X4
* cell instance $10688 r0 *1 191.52,159.6
X$10688 11014 112 113 11969 BUF_X1
* cell instance $10691 m0 *1 193.42,159.6
X$10691 112 16799 11835 11662 10847 113 DFF_X1
* cell instance $10694 r0 *1 196.84,159.6
X$10694 112 12226 11353 11785 11786 113 AOI21_X4
* cell instance $10696 m0 *1 197.03,159.6
X$10696 10515 112 113 11299 INV_X4
* cell instance $10698 m0 *1 198.93,159.6
X$10698 11299 113 11656 112 BUF_X4
* cell instance $10699 m0 *1 200.26,159.6
X$10699 11016 10756 112 113 11613 NOR2_X2
* cell instance $10700 m0 *1 201.21,159.6
X$10700 11613 11043 11616 113 11924 112 OAI21_X1
* cell instance $10702 m0 *1 202.73,159.6
X$10702 11151 11511 10637 11966 11017 11925 113 112 AOI221_X2
* cell instance $10705 m0 *1 205.77,159.6
X$10705 112 11926 11787 11616 11484 11150 11927 11304 113 OAI222_X2
* cell instance $10706 m0 *1 208.43,159.6
X$10706 11964 11790 10592 112 11829 113 AOI21_X1
* cell instance $10708 m0 *1 209.95,159.6
X$10708 112 11629 10853 11929 11930 113 AOI21_X4
* cell instance $10709 m0 *1 212.42,159.6
X$10709 11929 11930 11958 112 113 11306 NAND3_X2
* cell instance $10710 m0 *1 213.75,159.6
X$10710 11460 11346 112 113 11789 NAND2_X1
* cell instance $10711 m0 *1 214.32,159.6
X$10711 11960 10884 113 112 11024 AND2_X1
* cell instance $10712 m0 *1 215.08,159.6
X$10712 11053 11788 11790 113 112 11933 OAI21_X4
* cell instance $10713 m0 *1 217.55,159.6
X$10713 11463 11629 112 113 11791 NOR2_X2
* cell instance $10715 r0 *1 199.31,159.6
X$10715 112 11964 113 11300 BUF_X8
* cell instance $10716 r0 *1 201.78,159.6
X$10716 11786 10515 11785 112 11926 113 NAND3_X4
* cell instance $10717 r0 *1 204.25,159.6
X$10717 12268 11925 10594 10637 12126 11615 113 112 AOI221_X2
* cell instance $10718 r0 *1 206.34,159.6
X$10718 12125 10399 12124 112 113 11831 MUX2_X1
* cell instance $10719 r0 *1 207.67,159.6
X$10719 11926 11301 112 113 12081 NAND2_X1
* cell instance $10722 r0 *1 209.38,159.6
X$10722 11964 112 113 11788 BUF_X1
* cell instance $10724 r0 *1 210.14,159.6
X$10724 11624 12081 11462 113 11963 112 OAI21_X1
* cell instance $10726 r0 *1 211.28,159.6
X$10726 11929 11930 11787 112 113 10858 NAND3_X2
* cell instance $10727 r0 *1 212.61,159.6
X$10727 11930 11353 11929 112 10720 113 NAND3_X4
* cell instance $10728 r0 *1 215.08,159.6
X$10728 9768 10399 112 113 12085 NOR2_X1
* cell instance $10730 r0 *1 216.03,159.6
X$10730 12119 11928 11931 112 10750 113 AOI21_X1
* cell instance $10732 r0 *1 217.17,159.6
X$10732 112 11933 12086 11301 11468 12116 113 OAI22_X4
* cell instance $10733 m0 *1 219.64,159.6
X$10733 11792 11954 11310 113 11931 112 OAI21_X1
* cell instance $10734 m0 *1 218.88,159.6
X$10734 11792 11625 11620 112 11934 113 AOI21_X1
* cell instance $10736 m0 *1 220.59,159.6
X$10736 11785 11786 11953 112 113 11023 NAND3_X2
* cell instance $10737 m0 *1 221.92,159.6
X$10737 11793 11310 11794 113 11818 112 OAI21_X1
* cell instance $10738 m0 *1 222.68,159.6
X$10738 11952 11794 11935 113 112 11493 OAI21_X2
* cell instance $10739 m0 *1 224.01,159.6
X$10739 11150 11629 10722 10860 11797 112 113 11938 AOI221_X1
* cell instance $10740 m0 *1 225.15,159.6
X$10740 11938 11794 11796 112 11809 113 AOI21_X1
* cell instance $10743 m0 *1 226.86,159.6
X$10743 10372 11799 10720 112 11800 113 AOI21_X1
* cell instance $10745 m0 *1 227.81,159.6
X$10745 11800 11950 112 113 11801 NOR2_X1
* cell instance $10746 m0 *1 228.38,159.6
X$10746 11350 11949 11926 112 11816 113 AOI21_X1
* cell instance $10748 m0 *1 229.33,159.6
X$10748 11023 11799 11030 112 113 11946 NAND3_X1
* cell instance $10750 m0 *1 230.28,159.6
X$10750 11803 11946 11802 112 11474 113 AOI21_X1
* cell instance $10751 m0 *1 231.04,159.6
X$10751 11804 10727 11809 112 11806 113 AOI21_X1
* cell instance $10753 m0 *1 231.99,159.6
X$10753 10856 112 113 11794 CLKBUF_X3
* cell instance $10754 m0 *1 232.94,159.6
X$10754 112 16847 11943 9838 10501 113 DFF_X1
* cell instance $10755 m0 *1 236.17,159.6
X$10755 112 11939 10501 17232 10757 113 DFF_X2
* cell instance $10757 r0 *1 220.4,159.6
X$10757 11929 11930 11484 112 113 11937 NAND3_X2
* cell instance $10758 r0 *1 221.73,159.6
X$10758 10491 11934 12112 11936 112 113 11935 AOI22_X1
* cell instance $10759 r0 *1 222.68,159.6
X$10759 11950 10491 112 113 11936 NOR2_X1
* cell instance $10760 r0 *1 223.25,159.6
X$10760 11314 11628 11795 11791 10884 113 112 11796 OAI221_X1
* cell instance $10761 r0 *1 224.39,159.6
X$10761 11937 11026 112 113 11797 NAND2_X1
* cell instance $10762 r0 *1 224.96,159.6
X$10762 11021 11937 10883 112 11950 113 AOI21_X1
* cell instance $10765 r0 *1 226.67,159.6
X$10765 10372 12089 11338 11314 113 112 12090 OAI22_X1
* cell instance $10766 r0 *1 227.62,159.6
X$10766 12090 12104 12085 11803 11801 113 112 10876 OAI221_X1
* cell instance $10767 r0 *1 228.76,159.6
X$10767 11161 10720 12088 113 12104 112 OAI21_X1
* cell instance $10768 r0 *1 229.52,159.6
X$10768 12103 11308 11631 112 11637 113 AOI21_X1
* cell instance $10770 r0 *1 230.47,159.6
X$10770 10720 11461 12086 12102 112 113 12093 NAND4_X1
* cell instance $10773 r0 *1 231.99,159.6
X$10773 11638 11023 11631 112 12094 113 AOI21_X1
* cell instance $10775 r0 *1 235.79,159.6
X$10775 11940 112 113 9770 BUF_X1
* cell instance $10779 r0 *1 236.36,159.6
X$10779 10757 4939 12096 112 113 11939 MUX2_X1
* cell instance $10780 r0 *1 237.69,159.6
X$10780 11943 112 113 11941 BUF_X1
* cell instance $10781 r0 *1 238.26,159.6
X$10781 9236 112 113 11942 BUF_X1
* cell instance $10791 r0 *1 10.64,145.6
X$10791 10543 112 113 9863 BUF_X1
* cell instance $10796 m0 *1 13.11,145.6
X$10796 10311 112 113 10392 BUF_X1
* cell instance $10802 r0 *1 14.82,145.6
X$10802 10544 112 113 10615 BUF_X1
* cell instance $10805 m0 *1 15.58,145.6
X$10805 10499 112 113 10448 BUF_X1
* cell instance $10807 m0 *1 18.24,145.6
X$10807 10312 112 113 10382 BUF_X1
* cell instance $10811 m0 *1 19.38,145.6
X$10811 112 10500 10313 17214 10449 113 DFF_X2
* cell instance $10813 m0 *1 22.99,145.6
X$10813 112 16787 10499 10327 10313 113 DFF_X1
* cell instance $10817 r0 *1 19.19,145.6
X$10817 10449 8585 10614 112 113 10500 MUX2_X1
* cell instance $10820 r0 *1 23.75,145.6
X$10820 6050 112 113 10313 CLKBUF_X3
* cell instance $10821 r0 *1 24.7,145.6
X$10821 10313 112 113 17186 INV_X2
* cell instance $10824 r0 *1 32.87,145.6
X$10824 10545 112 113 10617 BUF_X2
* cell instance $10825 r0 *1 33.63,145.6
X$10825 10316 112 113 10507 BUF_X2
* cell instance $10826 m0 *1 35.53,145.6
X$10826 10315 10314 16566 113 112 10316 HA_X1
* cell instance $10827 m0 *1 34.2,145.6
X$10827 10454 113 10450 112 BUF_X4
* cell instance $10828 m0 *1 37.43,145.6
X$10828 10104 113 10315 112 BUF_X4
* cell instance $10829 m0 *1 38.76,145.6
X$10829 112 10511 113 10280 BUF_X8
* cell instance $10830 m0 *1 41.23,145.6
X$10830 10316 112 113 10393 BUF_X1
* cell instance $10831 m0 *1 41.8,145.6
X$10831 10107 10509 112 10622 113 OR2_X4
* cell instance $10832 m0 *1 43.51,145.6
X$10832 9866 10454 9950 112 10549 113 NAND3_X4
* cell instance $10834 m0 *1 46.74,145.6
X$10834 9950 9866 10452 112 113 10317 NAND3_X2
* cell instance $10835 m0 *1 48.07,145.6
X$10835 10228 10319 10226 112 10456 113 AOI21_X2
* cell instance $10836 m0 *1 49.4,145.6
X$10836 10511 113 10286 112 BUF_X4
* cell instance $10837 m0 *1 50.73,145.6
X$10837 10105 10458 10320 10319 10321 112 113 10749 AOI221_X1
* cell instance $10838 m0 *1 51.87,145.6
X$10838 10322 10402 10459 113 10403 112 OAI21_X1
* cell instance $10839 m0 *1 52.63,145.6
X$10839 10457 10323 10450 10406 112 113 10402 AOI22_X1
* cell instance $10840 m0 *1 53.58,145.6
X$10840 10229 113 10460 112 BUF_X4
* cell instance $10842 m0 *1 55.1,145.6
X$10842 10404 10403 10408 112 113 10410 NAND3_X2
* cell instance $10843 m0 *1 56.43,145.6
X$10843 10032 113 10454 112 BUF_X4
* cell instance $10845 r0 *1 34.39,145.6
X$10845 10315 10314 10546 113 112 10619 HA_X1
* cell instance $10846 r0 *1 36.29,145.6
X$10846 10617 10451 10453 112 10618 113 NAND3_X4
* cell instance $10847 r0 *1 38.76,145.6
X$10847 10107 10619 112 113 10628 NAND2_X1
* cell instance $10848 r0 *1 39.33,145.6
X$10848 10451 10104 10453 112 10548 113 NAND3_X4
* cell instance $10849 r0 *1 41.8,145.6
X$10849 9866 113 10451 112 BUF_X4
* cell instance $10850 r0 *1 43.13,145.6
X$10850 112 10624 113 10169 BUF_X8
* cell instance $10852 r0 *1 45.79,145.6
X$10852 10230 113 10322 112 BUF_X4
* cell instance $10853 r0 *1 47.12,145.6
X$10853 10551 10455 10553 10512 10552 10629 113 112 AOI221_X2
* cell instance $10854 r0 *1 49.21,145.6
X$10854 10321 112 113 10554 CLKBUF_X3
* cell instance $10855 r0 *1 50.16,145.6
X$10855 10326 10400 10107 112 10513 113 AOI21_X2
* cell instance $10856 r0 *1 51.49,145.6
X$10856 10324 10320 112 113 10635 NOR2_X2
* cell instance $10857 r0 *1 52.44,145.6
X$10857 10326 113 10512 112 BUF_X4
* cell instance $10858 r0 *1 53.77,145.6
X$10858 10228 10032 112 113 10323 NOR2_X1
* cell instance $10859 r0 *1 54.34,145.6
X$10859 10107 10639 10553 10230 10108 10519 113 112 AOI221_X2
* cell instance $10860 r0 *1 56.43,145.6
X$10860 10326 113 10225 112 BUF_X4
* cell instance $10861 r0 *1 57.76,145.6
X$10861 10226 10326 112 113 10556 NAND2_X2
* cell instance $10862 m0 *1 60.61,145.6
X$10862 112 10409 10228 9950 9866 113 AOI21_X4
* cell instance $10863 m0 *1 58.14,145.6
X$10863 112 10458 10326 9950 9866 113 AOI21_X4
* cell instance $10864 m0 *1 63.08,145.6
X$10864 112 10328 8403 10449 10462 113 NOR3_X4
* cell instance $10866 r0 *1 58.71,145.6
X$10866 10167 10618 113 112 10683 AND2_X1
* cell instance $10871 r0 *1 62.32,145.6
X$10871 112 10523 10462 10558 10557 113 NOR3_X4
* cell instance $10872 r0 *1 64.98,145.6
X$10872 10328 3639 10449 113 112 10558 AND3_X1
* cell instance $10874 m0 *1 67.83,145.6
X$10874 10329 112 113 9203 BUF_X2
* cell instance $10875 m0 *1 66.12,145.6
X$10875 10413 10414 9622 113 112 10523 MUX2_X2
* cell instance $10877 r0 *1 66.31,145.6
X$10877 10654 10643 9865 112 113 NOR2_X4
* cell instance $10881 r0 *1 68.02,145.6
X$10881 10643 112 113 10559 INV_X1
* cell instance $10885 m0 *1 68.97,145.6
X$10885 9048 8729 113 10463 112 XOR2_X2
* cell instance $10886 m0 *1 71.44,145.6
X$10886 8855 8620 112 113 10330 XOR2_X1
* cell instance $10887 m0 *1 72.58,145.6
X$10887 10330 2861 10175 112 113 10417 NOR3_X1
* cell instance $10888 m0 *1 73.34,145.6
X$10888 10526 8769 10417 112 113 10332 MUX2_X1
* cell instance $10889 m0 *1 74.67,145.6
X$10889 9953 7738 10109 112 113 10333 NAND3_X1
* cell instance $10890 m0 *1 75.43,145.6
X$10890 7738 10175 112 113 10646 NAND2_X1
* cell instance $10892 r0 *1 68.97,145.6
X$10892 8729 9048 112 113 10645 XNOR2_X2
* cell instance $10896 r0 *1 72.96,145.6
X$10896 10330 2861 10109 112 113 10526 NOR3_X1
* cell instance $10900 r0 *1 75.05,145.6
X$10900 10333 9953 10646 113 112 10561 OAI21_X2
* cell instance $10902 m0 *1 76.57,145.6
X$10902 8762 10562 113 9774 112 XOR2_X2
* cell instance $10904 m0 *1 78.28,145.6
X$10904 8624 9869 113 10464 112 XOR2_X2
* cell instance $10908 r0 *1 77.9,145.6
X$10908 9869 8624 112 113 10687 XNOR2_X2
* cell instance $10909 r0 *1 79.8,145.6
X$10909 10464 5231 10649 10768 112 113 10648 AOI211_X4
* cell instance $10910 r0 *1 81.89,145.6
X$10910 10295 7362 112 113 10649 NOR2_X1
* cell instance $10912 m0 *1 83.22,145.6
X$10912 8857 10528 113 10327 112 XOR2_X2
* cell instance $10913 m0 *1 82.65,145.6
X$10913 8403 9419 112 113 10650 NAND2_X1
* cell instance $10914 m0 *1 84.93,145.6
X$10914 7650 9419 112 113 10651 NOR2_X1
* cell instance $10917 m0 *1 86.45,145.6
X$10917 3989 10392 113 112 10334 AND2_X2
* cell instance $10918 m0 *1 87.4,145.6
X$10918 10334 9379 112 10531 113 OR2_X4
* cell instance $10921 r0 *1 82.84,145.6
X$10921 10650 9170 10564 112 113 10560 MUX2_X1
* cell instance $10922 r0 *1 84.17,145.6
X$10922 9419 112 113 10530 INV_X1
* cell instance $10923 r0 *1 84.55,145.6
X$10923 10653 10651 9170 113 112 10654 MUX2_X2
* cell instance $10924 r0 *1 86.26,145.6
X$10924 7650 10530 112 113 10653 NOR2_X1
* cell instance $10927 r0 *1 87.78,145.6
X$10927 9379 112 113 10655 BUF_X1
* cell instance $10929 r0 *1 88.54,145.6
X$10929 9379 112 113 10565 BUF_X1
* cell instance $10933 r0 *1 90.44,145.6
X$10933 9208 112 113 10528 BUF_X1
* cell instance $10936 r0 *1 92.15,145.6
X$10936 112 17028 10532 10658 9870 113 DFF_X1
* cell instance $10938 m0 *1 92.53,145.6
X$10938 7994 113 10566 112 BUF_X4
* cell instance $10940 m0 *1 95.19,145.6
X$10940 10532 113 9088 112 BUF_X4
* cell instance $10944 m0 *1 101.08,145.6
X$10944 112 16748 10117 10535 9870 113 DFF_X1
* cell instance $10947 r0 *1 95.38,145.6
X$10947 9088 112 113 9208 BUF_X1
* cell instance $10948 r0 *1 95.95,145.6
X$10948 112 8196 113 10537 BUF_X8
* cell instance $10949 r0 *1 98.42,145.6
X$10949 8133 112 113 9870 CLKBUF_X3
* cell instance $10950 r0 *1 99.37,145.6
X$10950 8862 10382 113 112 10659 AND2_X1
* cell instance $10951 r0 *1 100.13,145.6
X$10951 9870 112 113 17190 INV_X2
* cell instance $10954 r0 *1 101.84,145.6
X$10954 112 17017 10537 11848 10465 113 DFF_X1
* cell instance $10957 r0 *1 106.02,145.6
X$10957 9973 10121 112 113 10468 NOR2_X1
* cell instance $10958 m0 *1 106.4,145.6
X$10958 10310 10538 10568 10337 112 113 10336 NAND4_X1
* cell instance $10960 m0 *1 107.35,145.6
X$10960 10466 10340 112 113 10467 NOR2_X1
* cell instance $10962 m0 *1 108.68,145.6
X$10962 10541 10339 9973 112 113 10338 NOR3_X1
* cell instance $10963 m0 *1 109.44,145.6
X$10963 10340 10466 9964 113 10341 112 OAI21_X1
* cell instance $10964 m0 *1 110.2,145.6
X$10964 10341 10542 10474 113 10436 112 OAI21_X1
* cell instance $10965 m0 *1 110.96,145.6
X$10965 9934 10202 10067 112 10542 113 AOI21_X1
* cell instance $10968 r0 *1 106.97,145.6
X$10968 10540 10467 10468 113 10538 112 OAI21_X1
* cell instance $10972 r0 *1 109.06,145.6
X$10972 10342 10661 9967 112 10541 113 AOI21_X1
* cell instance $10973 r0 *1 109.82,145.6
X$10973 10470 9935 10662 112 9968 113 AOI21_X1
* cell instance $10976 r0 *1 111.15,145.6
X$10976 9965 10536 10539 112 10569 113 AOI21_X1
* cell instance $10977 r0 *1 111.91,145.6
X$10977 10539 10663 10471 112 10665 113 AOI21_X1
* cell instance $10978 m0 *1 112.29,145.6
X$10978 10343 112 113 10247 INV_X4
* cell instance $10980 m0 *1 113.24,145.6
X$10980 10345 9941 9936 10438 113 10539 112 NOR4_X2
* cell instance $10981 m0 *1 114.95,145.6
X$10981 10347 10349 10344 10346 113 10438 112 NOR4_X2
* cell instance $10983 m0 *1 116.85,145.6
X$10983 10348 10349 9732 10440 10339 113 112 AOI211_X2
* cell instance $10987 m0 *1 121.03,145.6
X$10987 10346 10347 10084 113 9970 112 NOR3_X2
* cell instance $10991 r0 *1 112.67,145.6
X$10991 10343 112 113 10344 BUF_X1
* cell instance $10995 r0 *1 115.33,145.6
X$10995 10349 10472 112 113 10067 NAND2_X2
* cell instance $10996 r0 *1 116.28,145.6
X$10996 10346 10347 10247 113 10572 112 OAI21_X1
* cell instance $10998 r0 *1 117.8,145.6
X$10998 10572 9967 10574 112 113 10668 NAND3_X1
* cell instance $10999 r0 *1 118.56,145.6
X$10999 9734 10473 10472 10466 113 112 10575 OAI22_X1
* cell instance $11001 r0 *1 120.27,145.6
X$11001 10068 10576 10668 113 10669 112 OAI21_X1
* cell instance $11002 r0 *1 121.03,145.6
X$11002 10132 10536 10245 112 10576 113 AOI21_X1
* cell instance $11004 r0 *1 122.17,145.6
X$11004 10446 9970 10574 112 113 10674 NOR3_X1
* cell instance $11005 r0 *1 122.93,145.6
X$11005 10674 10534 9962 113 10577 112 OAI21_X1
* cell instance $11006 r0 *1 123.69,145.6
X$11006 10673 10581 9873 112 113 10534 NOR3_X1
* cell instance $11010 r0 *1 124.45,145.6
X$11010 10346 10347 10777 112 113 10673 NOR3_X1
* cell instance $11011 m0 *1 125.21,145.6
X$11011 10130 10349 112 113 10445 NAND2_X2
* cell instance $11016 r0 *1 125.97,145.6
X$11016 10574 10578 10533 113 10309 112 OAI21_X1
* cell instance $11017 r0 *1 126.73,145.6
X$11017 10132 10444 10476 113 10579 112 OAI21_X1
* cell instance $11019 m0 *1 127.3,145.6
X$11019 10446 10340 10440 112 10475 113 AOI21_X2
* cell instance $11020 m0 *1 128.82,145.6
X$11020 10252 113 10474 112 BUF_X4
* cell instance $11021 m0 *1 130.15,145.6
X$11021 10252 113 10250 112 BUF_X4
* cell instance $11024 r0 *1 127.68,145.6
X$11024 10580 10132 10702 113 10533 112 OAI21_X1
* cell instance $11027 r0 *1 130.15,145.6
X$11027 10252 9733 10077 112 10477 113 AOI21_X1
* cell instance $11028 r0 *1 130.91,145.6
X$11028 10477 10666 9974 10250 10582 112 113 10351 AOI221_X1
* cell instance $11029 m0 *1 132.62,145.6
X$11029 10355 10254 10304 112 113 10194 NAND3_X2
* cell instance $11030 m0 *1 131.86,145.6
X$11030 10352 10440 10134 113 10353 112 OAI21_X1
* cell instance $11032 r0 *1 132.05,145.6
X$11032 10529 10349 10667 112 10582 113 AOI21_X1
* cell instance $11034 r0 *1 133,145.6
X$11034 10132 10077 9733 112 113 10529 NOR3_X1
* cell instance $11036 r0 *1 133.95,145.6
X$11036 10476 10663 10478 113 112 10255 AND3_X2
* cell instance $11038 m0 *1 134.33,145.6
X$11038 10346 10347 10256 113 10478 112 OAI21_X1
* cell instance $11039 r0 *1 135.09,145.6
X$11039 10472 112 113 10352 INV_X1
* cell instance $11041 m0 *1 135.66,145.6
X$11041 10210 10135 112 10130 113 NAND2_X4
* cell instance $11043 m0 *1 137.37,145.6
X$11043 10135 113 10254 112 BUF_X4
* cell instance $11048 r0 *1 135.66,145.6
X$11048 10136 113 10347 112 BUF_X4
* cell instance $11049 r0 *1 136.99,145.6
X$11049 10254 9733 10355 112 10473 113 NAND3_X4
* cell instance $11053 r0 *1 143.45,145.6
X$11053 10437 7738 112 113 10527 NAND2_X1
* cell instance $11054 r0 *1 144.02,145.6
X$11054 112 10479 10527 8388 10660 10356 113 OAI211_X4
* cell instance $11055 m0 *1 144.59,145.6
X$11055 10437 3635 112 113 10525 NOR2_X1
* cell instance $11057 m0 *1 145.16,145.6
X$11057 10356 3784 10525 10479 112 113 10524 AOI211_X4
* cell instance $11061 r0 *1 147.63,145.6
X$11061 10583 3639 9509 112 113 10657 NAND3_X2
* cell instance $11062 m0 *1 148.58,145.6
X$11062 9850 112 113 17201 INV_X1
* cell instance $11064 m0 *1 148.96,145.6
X$11064 112 10657 10358 9881 9880 10522 113 AND4_X4
* cell instance $11066 m0 *1 151.62,145.6
X$11066 112 16729 10434 10521 9850 113 DFF_X1
* cell instance $11067 m0 *1 154.85,145.6
X$11067 10434 113 6821 112 BUF_X4
* cell instance $11068 m0 *1 156.18,145.6
X$11068 112 16913 10431 10360 9036 113 DFF_X1
* cell instance $11069 m0 *1 159.41,145.6
X$11069 10429 9986 10520 112 10432 113 AOI21_X2
* cell instance $11070 m0 *1 160.74,145.6
X$11070 10431 112 113 10415 CLKBUF_X3
* cell instance $11071 m0 *1 161.69,145.6
X$11071 112 10427 10428 10430 10586 113 DFF_X1
* cell instance $11073 m0 *1 165.11,145.6
X$11073 8059 112 113 10298 INV_X1
* cell instance $11076 m0 *1 166.44,145.6
X$11076 10518 10427 10426 113 112 10425 OAI21_X2
* cell instance $11077 m0 *1 167.77,145.6
X$11077 6503 8059 112 113 10426 NAND2_X1
* cell instance $11079 m0 *1 168.53,145.6
X$11079 7114 8059 112 113 10361 NOR2_X1
* cell instance $11081 r0 *1 148.96,145.6
X$11081 112 10358 10657 9880 9881 10584 113 NAND4_X4
* cell instance $11082 r0 *1 152.38,145.6
X$11082 10505 3783 10656 112 113 10521 MUX2_X1
* cell instance $11084 r0 *1 154.47,145.6
X$11084 10415 10585 113 112 10652 XNOR2_X1
* cell instance $11085 r0 *1 155.61,145.6
X$11085 10276 6211 10652 112 113 10360 MUX2_X1
* cell instance $11088 r0 *1 158.08,145.6
X$11088 3678 113 8317 112 BUF_X4
* cell instance $11091 r0 *1 160.55,145.6
X$11091 112 3874 10075 113 BUF_X16
* cell instance $11094 r0 *1 166.44,145.6
X$11094 10588 9765 113 11125 112 XOR2_X2
* cell instance $11096 r0 *1 168.53,145.6
X$11096 10361 10261 112 113 10517 NAND2_X1
* cell instance $11097 r0 *1 169.1,145.6
X$11097 112 10480 10481 10425 10515 113 NOR3_X4
* cell instance $11098 m0 *1 170.81,145.6
X$11098 10362 10195 10422 112 10481 113 AOI21_X2
* cell instance $11099 m0 *1 169.48,145.6
X$11099 10424 10517 10296 112 10480 113 AOI21_X2
* cell instance $11100 m0 *1 172.14,145.6
X$11100 9991 112 113 9891 BUF_X1
* cell instance $11101 m0 *1 172.71,145.6
X$11101 10361 10141 112 113 10422 NAND2_X1
* cell instance $11104 m0 *1 174.23,145.6
X$11104 112 10421 10263 10363 10516 113 NOR3_X4
* cell instance $11108 m0 *1 179.36,145.6
X$11108 9822 9431 113 112 10483 XNOR2_X1
* cell instance $11111 m0 *1 182.78,145.6
X$11111 112 9431 113 10419 BUF_X8
* cell instance $11115 m0 *1 192.28,145.6
X$11115 10514 10365 113 112 10366 XNOR2_X1
* cell instance $11122 r0 *1 179.17,145.6
X$11122 10483 10482 112 113 10140 XNOR2_X2
* cell instance $11129 r0 *1 189.05,145.6
X$11129 8220 10484 113 10278 112 XOR2_X2
* cell instance $11132 r0 *1 192.47,145.6
X$11132 5321 6555 113 112 10642 XNOR2_X1
* cell instance $11133 r0 *1 193.61,145.6
X$11133 10716 5995 10385 112 113 10641 MUX2_X1
* cell instance $11134 m0 *1 195.13,145.6
X$11134 10411 10366 10412 112 113 10487 MUX2_X1
* cell instance $11135 m0 *1 194.56,145.6
X$11135 10075 7675 112 113 10510 NAND2_X1
* cell instance $11137 r0 *1 194.94,145.6
X$11137 3937 10486 112 113 10485 NAND2_X1
* cell instance $11138 r0 *1 195.51,145.6
X$11138 10485 10510 10366 113 112 11298 MUX2_X2
* cell instance $11139 m0 *1 198.55,145.6
X$11139 7675 112 113 10486 INV_X1
* cell instance $11140 m0 *1 196.84,145.6
X$11140 5762 10367 113 10157 112 XOR2_X2
* cell instance $11143 r0 *1 197.41,145.6
X$11143 10377 7650 10486 112 113 10717 NAND3_X2
* cell instance $11144 r0 *1 198.74,145.6
X$11144 10486 6773 10377 112 113 10591 OR3_X2
* cell instance $11145 m0 *1 199.5,145.6
X$11145 10407 10370 10369 113 112 10405 OAI21_X4
* cell instance $11149 r0 *1 201.4,145.6
X$11149 10371 10405 112 113 10755 OR2_X2
* cell instance $11151 m0 *1 202.35,145.6
X$11151 10405 10371 10592 112 113 NOR2_X4
* cell instance $11152 r0 *1 202.35,145.6
X$11152 10405 10371 10853 113 10638 112 NOR3_X2
* cell instance $11154 m0 *1 204.63,145.6
X$11154 9328 8348 113 10637 112 XOR2_X2
* cell instance $11160 r0 *1 205.96,145.6
X$11160 10637 113 10608 112 BUF_X4
* cell instance $11164 r0 *1 208.62,145.6
X$11164 10592 113 10593 112 BUF_X4
* cell instance $11165 r0 *1 209.95,145.6
X$11165 10593 113 10492 112 BUF_X4
* cell instance $11167 m0 *1 211.28,145.6
X$11167 10399 113 10373 112 BUF_X4
* cell instance $11168 m0 *1 212.8,145.6
X$11168 10006 112 113 10488 CLKBUF_X3
* cell instance $11169 m0 *1 213.75,145.6
X$11169 9768 112 113 10489 CLKBUF_X3
* cell instance $11171 m0 *1 214.89,145.6
X$11171 10489 10373 112 113 10598 NAND2_X1
* cell instance $11173 m0 *1 215.65,145.6
X$11173 10374 10490 10508 10375 10156 113 112 AOI211_X2
* cell instance $11176 r0 *1 211.66,145.6
X$11176 10488 112 113 10606 CLKBUF_X3
* cell instance $11177 r0 *1 212.61,145.6
X$11177 10006 113 10595 112 BUF_X4
* cell instance $11178 r0 *1 213.94,145.6
X$11178 10632 10597 10633 10634 10504 10491 112 113 10397 OAI33_X1
* cell instance $11180 r0 *1 215.46,145.6
X$11180 10631 10604 10491 113 10632 112 OAI21_X1
* cell instance $11182 r0 *1 216.41,145.6
X$11182 10627 10750 10601 113 112 10374 OAI21_X2
* cell instance $11183 r0 *1 217.74,145.6
X$11183 10491 10603 112 113 10601 NAND2_X1
* cell instance $11184 m0 *1 217.93,145.6
X$11184 112 10623 10501 17218 9990 113 DFF_X2
* cell instance $11186 m0 *1 221.54,145.6
X$11186 112 10506 10376 17237 10370 113 DFF_X2
* cell instance $11187 m0 *1 225.15,145.6
X$11187 112 10503 10376 17228 10377 113 DFF_X2
* cell instance $11188 m0 *1 228.76,145.6
X$11188 10377 9209 10616 112 113 10503 MUX2_X1
* cell instance $11189 m0 *1 230.09,145.6
X$11189 10502 112 113 9822 BUF_X2
* cell instance $11192 r0 *1 218.31,145.6
X$11192 10604 112 113 10508 INV_X1
* cell instance $11195 r0 *1 220.97,145.6
X$11195 10594 113 10626 112 BUF_X4
* cell instance $11196 r0 *1 222.3,145.6
X$11196 9768 112 113 10607 INV_X2
* cell instance $11197 r0 *1 222.87,145.6
X$11197 10492 10373 112 113 10493 NAND2_X1
* cell instance $11198 r0 *1 223.44,145.6
X$11198 10738 10493 10489 10620 10609 113 112 10621 OAI221_X1
* cell instance $11200 r0 *1 224.77,145.6
X$11200 10621 10608 10494 112 10504 113 AOI21_X1
* cell instance $11203 r0 *1 230.09,145.6
X$11203 112 16941 10502 10611 10376 113 DFF_X1
* cell instance $11205 m0 *1 232.75,145.6
X$11205 112 16828 10495 10391 10158 113 DFF_X1
* cell instance $11210 m0 *1 236.55,145.6
X$11210 10011 112 113 10497 BUF_X1
* cell instance $11213 m0 *1 238.64,145.6
X$11213 10273 112 113 10385 BUF_X1
* cell instance $11232 m0 *1 11.78,140
X$11232 9862 112 113 9902 BUF_X1
* cell instance $11233 m0 *1 12.35,140
X$11233 9858 112 113 8940 BUF_X1
* cell instance $11238 r0 *1 10.45,140
X$11238 10016 112 113 9709 BUF_X1
* cell instance $11245 m0 *1 14.06,140
X$11245 9861 112 113 10017 BUF_X1
* cell instance $11246 r0 *1 14.25,140
X$11246 112 16959 10016 9868 9946 113 DFF_X1
* cell instance $11247 m0 *1 15.58,140
X$11247 9906 112 113 9860 BUF_X1
* cell instance $11248 m0 *1 15.01,140
X$11248 9945 112 113 9200 BUF_X1
* cell instance $11252 m0 *1 20.14,140
X$11252 9864 8585 9863 112 113 10019 MUX2_X1
* cell instance $11253 m0 *1 21.47,140
X$11253 112 10019 9946 17242 9864 113 DFF_X2
* cell instance $11255 r0 *1 17.48,140
X$11255 112 16957 10018 10040 9946 113 DFF_X1
* cell instance $11256 r0 *1 20.71,140
X$11256 112 16958 10162 9908 9946 113 DFF_X1
* cell instance $11259 m0 *1 25.65,140
X$11259 112 9947 9399 9716 10020 113 DFF_X2
* cell instance $11267 r0 *1 25.65,140
X$11267 10020 8585 10277 112 113 9947 MUX2_X1
* cell instance $11272 r0 *1 35.53,140
X$11272 10165 113 9909 112 BUF_X4
* cell instance $11276 r0 *1 40.85,140
X$11276 112 10026 113 9949 BUF_X8
* cell instance $11278 r0 *1 43.7,140
X$11278 112 9867 113 10103 BUF_X8
* cell instance $11282 r0 *1 48.64,140
X$11282 9909 9867 10026 113 112 10167 OAI21_X4
* cell instance $11283 m0 *1 50.35,140
X$11283 112 16779 10031 10029 9399 113 DFF_X1
* cell instance $11285 m0 *1 53.58,140
X$11285 10031 112 113 8650 CLKBUF_X3
* cell instance $11287 r0 *1 51.11,140
X$11287 10103 9949 10228 112 113 10321 NOR3_X1
* cell instance $11289 r0 *1 52.06,140
X$11289 9950 9866 10323 10106 10030 10324 113 112 AOI221_X2
* cell instance $11290 r0 *1 54.15,140
X$11290 9948 9865 10107 112 10461 113 AOI21_X1
* cell instance $11292 m0 *1 54.91,140
X$11292 10032 9950 9866 112 9948 113 AOI21_X2
* cell instance $11293 m0 *1 57,140
X$11293 9951 112 113 10032 INV_X2
* cell instance $11296 r0 *1 55.29,140
X$11296 9909 113 9952 112 BUF_X4
* cell instance $11297 r0 *1 56.62,140
X$11297 9948 112 113 10108 CLKBUF_X3
* cell instance $11299 r0 *1 57.76,140
X$11299 112 10104 113 9951 BUF_X8
* cell instance $11301 m0 *1 57.95,140
X$11301 8650 9419 113 9908 112 XOR2_X2
* cell instance $11302 m0 *1 60.42,140
X$11302 9952 9910 10169 112 113 10033 MUX2_X1
* cell instance $11303 m0 *1 61.75,140
X$11303 9793 10170 10026 9867 113 112 10036 OAI22_X1
* cell instance $11305 m0 *1 62.89,140
X$11305 112 9949 113 9802 BUF_X8
* cell instance $11306 m0 *1 65.36,140
X$11306 10169 9681 9718 113 10035 112 OAI21_X1
* cell instance $11307 m0 *1 66.12,140
X$11307 9912 10042 113 112 10041 AND2_X1
* cell instance $11309 m0 *1 67.07,140
X$11309 9864 3527 9719 112 113 10042 NAND3_X2
* cell instance $11312 r0 *1 60.42,140
X$11312 3639 10033 112 113 10034 NAND2_X2
* cell instance $11313 r0 *1 61.37,140
X$11313 112 10039 10036 10034 10035 113 AOI21_X4
* cell instance $11315 r0 *1 64.03,140
X$11315 9955 113 9866 112 BUF_X4
* cell instance $11318 r0 *1 65.93,140
X$11318 10042 9912 112 10103 113 NAND2_X4
* cell instance $11320 r0 *1 67.83,140
X$11320 9081 8734 113 10040 112 XOR2_X2
* cell instance $11324 m0 *1 68.97,140
X$11324 10235 112 113 8402 CLKBUF_X3
* cell instance $11328 m0 *1 72.2,140
X$11328 9953 4948 9902 112 113 10045 MUX2_X1
* cell instance $11331 r0 *1 69.92,140
X$11331 112 17080 9953 10045 8941 113 DFF_X1
* cell instance $11332 r0 *1 73.15,140
X$11332 8855 8620 113 112 10110 XNOR2_X1
* cell instance $11333 m0 *1 74.48,140
X$11333 9081 9916 112 113 10047 XNOR2_X2
* cell instance $11334 m0 *1 73.91,140
X$11334 8941 112 113 17158 INV_X2
* cell instance $11336 m0 *1 76.57,140
X$11336 4508 9719 112 113 9954 NAND2_X1
* cell instance $11337 m0 *1 77.14,140
X$11337 9954 9917 9920 112 113 9955 MUX2_X1
* cell instance $11338 m0 *1 78.47,140
X$11338 4508 8036 112 113 9920 NAND2_X1
* cell instance $11339 m0 *1 79.04,140
X$11339 8626 7645 113 112 10048 XNOR2_X1
* cell instance $11342 m0 *1 81.89,140
X$11342 9924 9956 113 9868 112 XOR2_X2
* cell instance $11345 r0 *1 74.67,140
X$11345 10047 9565 112 113 10237 XNOR2_X2
* cell instance $11346 r0 *1 76.57,140
X$11346 10047 8984 112 113 9958 XNOR2_X2
* cell instance $11347 r0 *1 78.47,140
X$11347 9081 10048 112 113 9869 XNOR2_X2
* cell instance $11350 r0 *1 81.51,140
X$11350 3527 10111 112 113 10239 NOR2_X1
* cell instance $11351 r0 *1 82.08,140
X$11351 9956 112 113 10111 INV_X1
* cell instance $11352 r0 *1 82.46,140
X$11352 3465 10111 112 113 10049 NAND2_X1
* cell instance $11353 r0 *1 83.03,140
X$11353 9957 10049 9724 113 112 10050 MUX2_X2
* cell instance $11354 m0 *1 84.55,140
X$11354 9084 112 113 9924 BUF_X1
* cell instance $11355 m0 *1 83.98,140
X$11355 3465 10181 112 113 9957 NAND2_X1
* cell instance $11357 m0 *1 85.31,140
X$11357 9495 9373 10183 112 113 9951 OR3_X2
* cell instance $11358 m0 *1 86.45,140
X$11358 3989 10017 113 112 10053 AND2_X1
* cell instance $11362 r0 *1 85.69,140
X$11362 112 10052 9175 17265 9084 113 DFF_X2
* cell instance $11363 m0 *1 87.78,140
X$11363 112 10810 10053 6509 9286 113 AOI21_X4
* cell instance $11367 r0 *1 89.3,140
X$11367 7516 9208 112 113 10114 NAND2_X1
* cell instance $11369 r0 *1 90.25,140
X$11369 9208 112 113 10185 INV_X1
* cell instance $11372 r0 *1 91.2,140
X$11372 9960 112 113 10116 INV_X1
* cell instance $11373 m0 *1 92.15,140
X$11373 9629 3882 112 113 9959 NAND2_X1
* cell instance $11374 m0 *1 91.39,140
X$11374 4161 9629 112 113 10055 OR2_X1
* cell instance $11377 m0 *1 94.43,140
X$11377 112 16749 9818 9927 9870 113 DFF_X1
* cell instance $11381 r0 *1 91.58,140
X$11381 112 9960 10055 8388 10187 9958 113 OAI211_X4
* cell instance $11384 m0 *1 100.32,140
X$11384 8996 3928 9781 113 112 10120 OAI21_X4
* cell instance $11385 m0 *1 102.98,140
X$11385 112 16733 9926 9872 8992 113 DFF_X1
* cell instance $11389 r0 *1 101.27,140
X$11389 10119 113 8319 112 BUF_X4
* cell instance $11391 r0 *1 105.64,140
X$11391 10190 9971 10056 112 113 9820 MUX2_X1
* cell instance $11392 r0 *1 106.97,140
X$11392 10057 10194 112 113 10058 NAND2_X1
* cell instance $11393 m0 *1 107.54,140
X$11393 9873 10058 9963 113 9961 112 OAI21_X1
* cell instance $11395 m0 *1 108.3,140
X$11395 9701 10060 9932 112 10063 113 AOI21_X1
* cell instance $11396 m0 *1 109.06,140
X$11396 9941 9873 112 113 9825 NOR2_X1
* cell instance $11397 m0 *1 109.63,140
X$11397 9934 9969 112 113 10066 OR2_X1
* cell instance $11398 m0 *1 110.39,140
X$11398 9968 10066 10197 113 9932 112 OAI21_X1
* cell instance $11401 m0 *1 113.43,140
X$11401 9969 9964 112 113 9874 NOR2_X1
* cell instance $11402 m0 *1 114,140
X$11402 9874 9476 112 113 10070 NAND2_X1
* cell instance $11405 r0 *1 107.54,140
X$11405 9961 9962 9980 112 113 10061 NOR3_X1
* cell instance $11406 r0 *1 108.3,140
X$11406 9965 9964 112 113 10124 NOR2_X1
* cell instance $11407 r0 *1 108.87,140
X$11407 10062 10196 10061 9966 10063 10064 112 113 10056 OAI33_X1
* cell instance $11408 r0 *1 110.2,140
X$11408 9965 9967 10065 112 113 9963 NAND3_X1
* cell instance $11410 r0 *1 111.15,140
X$11410 9936 113 10200 112 BUF_X4
* cell instance $11411 r0 *1 112.48,140
X$11411 10067 9941 9934 10065 9707 113 112 10197 OAI221_X1
* cell instance $11413 r0 *1 113.81,140
X$11413 9707 9970 112 113 10201 NOR2_X1
* cell instance $11414 r0 *1 114.38,140
X$11414 10070 10069 9966 10068 10126 113 112 10196 OAI221_X1
* cell instance $11415 r0 *1 115.52,140
X$11415 9964 112 113 9962 CLKBUF_X3
* cell instance $11417 m0 *1 115.71,140
X$11417 9593 113 9971 112 BUF_X4
* cell instance $11419 m0 *1 117.99,140
X$11419 9974 112 113 9973 CLKBUF_X3
* cell instance $11420 m0 *1 118.94,140
X$11420 9876 113 9941 112 BUF_X4
* cell instance $11421 m0 *1 120.27,140
X$11421 9632 9593 112 113 9943 NOR2_X2
* cell instance $11423 m0 *1 121.41,140
X$11423 10074 9873 112 113 9975 NOR2_X1
* cell instance $11427 m0 *1 125.97,140
X$11427 10080 9943 9978 10207 10081 9872 113 112 AOI221_X2
* cell instance $11428 m0 *1 128.06,140
X$11428 9732 9979 10084 113 9944 112 OAI21_X1
* cell instance $11431 r0 *1 116.66,140
X$11431 9632 9936 112 113 10072 NOR2_X2
* cell instance $11434 r0 *1 118.56,140
X$11434 9972 9973 9632 113 10204 112 OAI21_X1
* cell instance $11435 r0 *1 119.32,140
X$11435 10204 9962 10309 112 10064 113 AOI21_X1
* cell instance $11437 r0 *1 120.27,140
X$11437 9974 113 9964 112 BUF_X4
* cell instance $11438 r0 *1 121.6,140
X$11438 10131 9973 9632 112 113 10126 NAND3_X1
* cell instance $11439 r0 *1 122.36,140
X$11439 10132 10077 112 113 10128 NOR2_X1
* cell instance $11440 r0 *1 122.93,140
X$11440 9971 10128 9975 112 10082 113 AOI21_X1
* cell instance $11441 r0 *1 123.69,140
X$11441 10132 9970 9827 113 10129 112 OAI21_X1
* cell instance $11445 r0 *1 124.45,140
X$11445 10129 10248 9942 112 113 9976 NAND3_X1
* cell instance $11447 r0 *1 125.59,140
X$11447 10078 9976 9973 112 113 9977 NAND3_X1
* cell instance $11449 r0 *1 126.54,140
X$11449 10072 9977 10308 113 112 9978 AND3_X2
* cell instance $11451 r0 *1 127.87,140
X$11451 9980 10082 10251 112 10081 113 AOI21_X1
* cell instance $11453 m0 *1 130.53,140
X$11453 9840 9735 9476 9944 10088 10087 113 112 AOI221_X2
* cell instance $11454 m0 *1 129.2,140
X$11454 9476 113 9980 112 BUF_X4
* cell instance $11455 m0 *1 132.62,140
X$11455 8539 112 113 9211 CLKBUF_X3
* cell instance $11456 m0 *1 133.57,140
X$11456 10257 9982 112 113 10088 NAND2_X1
* cell instance $11462 r0 *1 130.53,140
X$11462 10134 9940 9981 9979 10213 10062 113 112 AOI221_X2
* cell instance $11463 r0 *1 132.62,140
X$11463 9211 112 113 17173 INV_X2
* cell instance $11464 r0 *1 133.19,140
X$11464 9981 10132 10255 10215 113 10209 112 NOR4_X2
* cell instance $11465 m0 *1 134.71,140
X$11465 9632 113 9701 112 BUF_X4
* cell instance $11468 m0 *1 137.56,140
X$11468 9983 112 113 10097 BUF_X1
* cell instance $11470 m0 *1 138.32,140
X$11470 112 9983 10098 113 BUF_X16
* cell instance $11472 r0 *1 134.9,140
X$11472 9974 9476 112 113 9981 NAND2_X1
* cell instance $11473 r0 *1 135.47,140
X$11473 112 9982 10136 10096 10077 113 NOR3_X4
* cell instance $11475 r0 *1 138.51,140
X$11475 112 10348 9983 10210 10135 113 AOI21_X4
* cell instance $11476 r0 *1 140.98,140
X$11476 9983 112 113 9982 INV_X4
* cell instance $11478 r0 *1 142.31,140
X$11478 112 10210 113 10095 BUF_X8
* cell instance $11479 m0 *1 144.59,140
X$11479 9877 9845 113 112 10095 AND2_X1
* cell instance $11480 m0 *1 143.45,140
X$11480 9738 3635 9739 112 113 9877 OR3_X2
* cell instance $11481 m0 *1 145.35,140
X$11481 3678 9738 112 113 10094 NAND2_X1
* cell instance $11483 m0 *1 146.11,140
X$11483 10090 9878 10092 112 113 10091 MUX2_X1
* cell instance $11486 r0 *1 144.78,140
X$11486 10093 9878 10094 112 113 10208 MUX2_X1
* cell instance $11487 r0 *1 146.11,140
X$11487 10091 113 10136 112 BUF_X4
* cell instance $11489 r0 *1 147.82,140
X$11489 10085 9306 10089 112 113 10206 MUX2_X1
* cell instance $11490 m0 *1 148.96,140
X$11490 3780 7819 112 113 10086 NAND2_X1
* cell instance $11491 m0 *1 148.58,140
X$11491 7819 112 113 9879 INV_X1
* cell instance $11492 m0 *1 149.53,140
X$11492 9692 9511 112 113 9741 NAND2_X1
* cell instance $11493 m0 *1 150.1,140
X$11493 10138 9984 10086 113 112 9882 OAI21_X2
* cell instance $11496 r0 *1 149.34,140
X$11496 9984 5395 9879 112 113 10138 NAND3_X2
* cell instance $11500 m0 *1 199.88,86.8
X$11500 5308 3947 5445 112 113 5418 MUX2_X1
* cell instance $11502 m0 *1 203.49,86.8
X$11502 112 16774 5318 5453 5068 113 DFF_X1
* cell instance $11503 m0 *1 206.72,86.8
X$11503 5318 4948 5448 112 113 5453 MUX2_X1
* cell instance $11504 m0 *1 208.05,86.8
X$11504 5419 5309 112 113 5314 XOR2_X1
* cell instance $11505 m0 *1 209.19,86.8
X$11505 112 16773 5452 5899 5068 113 DFF_X1
* cell instance $11506 m0 *1 212.42,86.8
X$11506 5452 112 113 5309 BUF_X2
* cell instance $11507 m0 *1 213.18,86.8
X$11507 5424 5425 16492 113 112 5422 HA_X1
* cell instance $11508 m0 *1 215.08,86.8
X$11508 5422 113 5423 112 BUF_X4
* cell instance $11511 r0 *1 200.07,86.8
X$11511 112 16998 5308 5418 5068 113 DFF_X1
* cell instance $11514 r0 *1 203.87,86.8
X$11514 112 17074 5559 5571 5068 113 DFF_X1
* cell instance $11515 r0 *1 207.1,86.8
X$11515 5419 5195 112 113 5569 XNOR2_X2
* cell instance $11516 r0 *1 209,86.8
X$11516 5195 5419 113 5420 112 XOR2_X2
* cell instance $11518 r0 *1 211.09,86.8
X$11518 5421 112 113 5561 INV_X4
* cell instance $11520 r0 *1 212.8,86.8
X$11520 5422 5450 112 113 5685 OR2_X1
* cell instance $11521 r0 *1 213.56,86.8
X$11521 112 5565 113 5422 BUF_X8
* cell instance $11523 r0 *1 216.41,86.8
X$11523 5424 5564 16615 113 112 5450 HA_X1
* cell instance $11524 m0 *1 216.98,86.8
X$11524 5449 5193 112 113 5313 XOR2_X1
* cell instance $11526 m0 *1 218.12,86.8
X$11526 5424 5425 5451 113 112 5426 HA_X1
* cell instance $11529 m0 *1 223.25,86.8
X$11529 112 16834 5435 5314 5429 113 DFF_X1
* cell instance $11532 m0 *1 229.71,86.8
X$11532 112 16735 5436 5313 4836 113 DFF_X1
* cell instance $11535 m0 *1 233.89,86.8
X$11535 5437 4939 5312 112 113 5428 MUX2_X1
* cell instance $11538 r0 *1 218.31,86.8
X$11538 5451 113 5653 112 BUF_X4
* cell instance $11539 r0 *1 219.64,86.8
X$11539 5426 112 113 6004 BUF_X2
* cell instance $11541 r0 *1 220.59,86.8
X$11541 5427 5564 16618 113 112 5657 HA_X1
* cell instance $11543 r0 *1 222.87,86.8
X$11543 5427 5425 16612 113 112 5199 HA_X1
* cell instance $11545 r0 *1 225.15,86.8
X$11545 5661 113 5427 112 BUF_X4
* cell instance $11547 r0 *1 226.86,86.8
X$11547 5427 5425 16616 113 112 5772 HA_X1
* cell instance $11549 r0 *1 228.95,86.8
X$11549 5446 5565 112 113 5568 NAND2_X1
* cell instance $11552 r0 *1 230.09,86.8
X$11552 112 17004 5438 5444 4836 113 DFF_X1
* cell instance $11553 r0 *1 233.32,86.8
X$11553 112 17048 5437 5428 5429 113 DFF_X1
* cell instance $11557 r0 *1 236.55,86.8
X$11557 5438 112 113 5430 BUF_X1
* cell instance $11559 m0 *1 237.12,86.8
X$11559 5435 112 113 5310 BUF_X1
* cell instance $11560 m0 *1 237.88,86.8
X$11560 5436 112 113 5432 BUF_X1
* cell instance $11562 m0 *1 238.64,86.8
X$11562 5431 112 113 5312 BUF_X1
* cell instance $11577 m0 *1 143.07,42
X$11577 735 926 1558 113 112 1663 OAI21_X2
* cell instance $11578 m0 *1 144.59,42
X$11578 660 926 721 589 112 113 1709 AOI22_X1
* cell instance $11579 m0 *1 145.54,42
X$11579 1627 1630 1500 112 1408 113 AOI21_X1
* cell instance $11580 m0 *1 146.3,42
X$11580 663 1368 1788 113 1499 112 OAI21_X1
* cell instance $11582 m0 *1 147.25,42
X$11582 1459 1558 591 112 113 1369 NOR3_X1
* cell instance $11583 m0 *1 148.01,42
X$11583 1559 1296 928 1560 112 113 1700 NAND4_X1
* cell instance $11584 m0 *1 148.96,42
X$11584 1625 1626 1561 112 1699 113 AOI21_X1
* cell instance $11585 m0 *1 149.72,42
X$11585 1289 1365 113 112 1626 AND2_X1
* cell instance $11586 m0 *1 150.48,42
X$11586 1455 1443 112 113 1561 NAND2_X1
* cell instance $11591 m0 *1 156.56,42
X$11591 112 16813 1698 1624 199 113 DFF_X1
* cell instance $11594 m0 *1 141.55,42
X$11594 1711 1177 1099 587 730 113 112 1703 OAI221_X1
* cell instance $11598 r0 *1 141.55,42
X$11598 1713 663 112 113 1661 NAND2_X1
* cell instance $11600 r0 *1 142.31,42
X$11600 1290 1661 1285 112 1662 113 AOI21_X1
* cell instance $11601 r0 *1 143.07,42
X$11601 1662 1792 112 113 1630 NOR2_X1
* cell instance $11603 r0 *1 143.83,42
X$11603 959 1021 1663 112 1790 113 AOI21_X2
* cell instance $11604 r0 *1 145.16,42
X$11604 1561 1789 855 1289 1709 112 113 1842 AOI221_X1
* cell instance $11605 r0 *1 146.3,42
X$11605 1509 1459 112 113 1786 NOR2_X1
* cell instance $11607 r0 *1 147.06,42
X$11607 1099 1699 1703 113 1784 112 OAI21_X1
* cell instance $11609 r0 *1 148.2,42
X$11609 1716 792 1561 632 1251 113 112 1785 OAI221_X1
* cell instance $11612 r0 *1 152.76,42
X$11612 1698 113 2764 112 BUF_X4
* cell instance $11615 m0 *1 161.12,42
X$11615 1622 1600 638 112 113 1697 OR3_X2
* cell instance $11617 m0 *1 162.26,42
X$11617 1696 1692 440 327 112 113 1623 NOR4_X1
* cell instance $11618 m0 *1 163.21,42
X$11618 1372 1621 1695 113 1696 112 OAI21_X1
* cell instance $11619 m0 *1 163.97,42
X$11619 478 600 817 113 1621 112 OAI21_X1
* cell instance $11620 m0 *1 164.73,42
X$11620 329 238 426 112 1694 113 AOI21_X1
* cell instance $11622 m0 *1 166.25,42
X$11622 357 862 424 113 1691 112 OAI21_X1
* cell instance $11623 m0 *1 167.01,42
X$11623 320 630 295 113 1664 112 OAI21_X1
* cell instance $11624 m0 *1 167.77,42
X$11624 1682 1564 1563 817 1606 1610 113 112 AOI221_X2
* cell instance $11625 m0 *1 169.86,42
X$11625 1686 1300 327 1602 1607 112 113 OAI211_X2
* cell instance $11629 r0 *1 161.88,42
X$11629 283 113 327 112 BUF_X4
* cell instance $11632 r0 *1 164.35,42
X$11632 1694 824 1756 113 1695 112 OAI21_X1
* cell instance $11634 r0 *1 165.3,42
X$11634 974 1664 1682 1167 1691 113 112 1884 OAI221_X1
* cell instance $11636 r0 *1 166.82,42
X$11636 1691 1665 1664 741 1565 1686 112 113 OAI221_X2
* cell instance $11639 r0 *1 169.48,42
X$11639 403 326 1756 557 818 113 112 1758 OAI221_X1
* cell instance $11641 r0 *1 171.38,42
X$11641 630 566 112 113 1665 NOR2_X1
* cell instance $11642 r0 *1 171.95,42
X$11642 1684 1070 1757 566 838 1489 113 112 AOI221_X2
* cell instance $11644 m0 *1 173.47,42
X$11644 1218 984 112 113 974 NOR2_X2
* cell instance $11646 r0 *1 174.42,42
X$11646 437 1309 282 112 113 1684 MUX2_X1
* cell instance $11647 m0 *1 175.56,42
X$11647 440 1221 1682 112 1602 113 AOI21_X1
* cell instance $11648 m0 *1 174.8,42
X$11648 437 112 113 1666 BUF_X2
* cell instance $11649 m0 *1 176.32,42
X$11649 282 862 295 113 1683 112 OAI21_X1
* cell instance $11650 m0 *1 177.08,42
X$11650 1303 1232 113 112 1596 AND2_X1
* cell instance $11652 m0 *1 178.03,42
X$11652 826 1140 1596 478 838 1681 113 112 AOI221_X2
* cell instance $11654 m0 *1 180.31,42
X$11654 1566 1060 112 113 431 NAND2_X1
* cell instance $11656 r0 *1 175.75,42
X$11656 543 1760 1665 1683 113 112 1779 OAI22_X1
* cell instance $11658 r0 *1 177.08,42
X$11658 1667 565 741 112 113 NOR2_X4
* cell instance $11659 r0 *1 178.79,42
X$11659 1776 1463 327 1679 1778 1600 113 112 AOI221_X2
* cell instance $11663 r0 *1 180.88,42
X$11663 1757 112 113 1775 INV_X1
* cell instance $11664 r0 *1 181.26,42
X$11664 1567 1678 438 1775 1668 1679 113 112 AOI221_X2
* cell instance $11665 m0 *1 181.83,42
X$11665 289 1218 1307 113 1568 112 OAI21_X1
* cell instance $11666 m0 *1 181.26,42
X$11666 1080 1373 112 113 1678 NOR2_X1
* cell instance $11667 m0 *1 182.59,42
X$11667 1568 352 818 753 113 112 1668 OAI22_X1
* cell instance $11668 m0 *1 183.54,42
X$11668 1566 113 440 112 BUF_X4
* cell instance $11669 m0 *1 184.87,42
X$11669 1667 1462 893 113 690 112 NOR3_X2
* cell instance $11671 m0 *1 186.39,42
X$11671 1669 113 1307 112 BUF_X4
* cell instance $11672 m0 *1 187.72,42
X$11672 1580 975 630 112 1675 113 AOI21_X1
* cell instance $11675 r0 *1 183.35,42
X$11675 677 1139 112 113 998 NAND2_X2
* cell instance $11676 r0 *1 184.3,42
X$11676 1467 1223 112 113 352 NOR2_X2
* cell instance $11679 r0 *1 185.82,42
X$11679 1303 1307 112 326 113 NAND2_X4
* cell instance $11680 r0 *1 187.53,42
X$11680 1667 113 1309 112 BUF_X4
* cell instance $11681 r0 *1 188.86,42
X$11681 1307 113 1070 112 BUF_X4
* cell instance $11682 m0 *1 189.81,42
X$11682 1214 112 113 975 INV_X2
* cell instance $11685 m0 *1 193.42,42
X$11685 1468 1570 1060 112 113 1569 NAND3_X1
* cell instance $11695 r0 *1 190.19,42
X$11695 1309 1669 112 113 1215 NAND2_X2
* cell instance $11696 r0 *1 191.14,42
X$11696 1674 113 1060 112 BUF_X4
* cell instance $11698 r0 *1 193.23,42
X$11698 112 403 113 1223 BUF_X8
* cell instance $11699 r0 *1 195.7,42
X$11699 1218 113 606 112 BUF_X4
* cell instance $11713 m0 *1 100.13,39.2
X$11713 794 579 112 113 1278 NAND2_X1
* cell instance $11714 m0 *1 100.89,39.2
X$11714 551 112 113 1361 CLKBUF_X3
* cell instance $11715 m0 *1 101.84,39.2
X$11715 1238 719 1360 113 1498 112 OAI21_X1
* cell instance $11717 m0 *1 103.36,39.2
X$11717 524 798 519 112 113 1434 MUX2_X1
* cell instance $11718 m0 *1 104.69,39.2
X$11718 1435 1361 1168 1501 1200 1436 113 112 AOI221_X2
* cell instance $11720 m0 *1 106.97,39.2
X$11720 696 579 1362 112 113 1437 MUX2_X1
* cell instance $11721 m0 *1 108.3,39.2
X$11721 951 1361 1246 112 113 1438 MUX2_X1
* cell instance $11725 r0 *1 100.13,39.2
X$11725 765 112 113 1538 INV_X1
* cell instance $11727 r0 *1 100.89,39.2
X$11727 833 997 413 112 113 1612 MUX2_X1
* cell instance $11728 r0 *1 102.22,39.2
X$11728 309 911 112 113 1433 NOR2_X2
* cell instance $11729 r0 *1 103.17,39.2
X$11729 1530 1433 717 691 1434 1540 113 112 AOI221_X2
* cell instance $11730 r0 *1 105.26,39.2
X$11730 1435 1033 1540 112 113 1616 MUX2_X1
* cell instance $11731 r0 *1 106.59,39.2
X$11731 1616 1615 112 113 1617 NOR2_X1
* cell instance $11733 r0 *1 107.35,39.2
X$11733 1362 1038 112 113 1542 NOR2_X1
* cell instance $11734 r0 *1 107.92,39.2
X$11734 1619 520 1173 112 113 1435 MUX2_X1
* cell instance $11738 r0 *1 113.24,39.2
X$11738 1440 113 854 112 BUF_X4
* cell instance $11740 m0 *1 114.57,39.2
X$11740 1506 113 1363 112 BUF_X4
* cell instance $11742 r0 *1 114.57,39.2
X$11742 1363 1440 1439 113 112 1282 OAI21_X4
* cell instance $11744 m0 *1 117.04,39.2
X$11744 1439 113 805 112 BUF_X4
* cell instance $11745 r0 *1 117.04,39.2
X$11745 112 1363 1439 1440 1451 113 NOR3_X4
* cell instance $11746 m0 *1 118.94,39.2
X$11746 1261 112 113 1364 BUF_X2
* cell instance $11748 m0 *1 119.7,39.2
X$11748 705 727 723 112 1507 113 AOI21_X1
* cell instance $11750 m0 *1 120.65,39.2
X$11750 724 934 725 112 1444 113 NAND3_X4
* cell instance $11751 m0 *1 123.12,39.2
X$11751 884 1444 584 112 113 1335 NAND3_X1
* cell instance $11752 m0 *1 123.88,39.2
X$11752 651 112 113 1441 INV_X4
* cell instance $11754 r0 *1 119.7,39.2
X$11754 1896 113 725 112 BUF_X4
* cell instance $11757 r0 *1 121.6,39.2
X$11757 880 1628 1548 112 1546 113 AOI21_X1
* cell instance $11758 r0 *1 122.36,39.2
X$11758 585 1443 845 113 1336 112 OAI21_X1
* cell instance $11760 r0 *1 123.31,39.2
X$11760 112 883 1441 725 724 113 AOI21_X4
* cell instance $11764 m0 *1 125.4,39.2
X$11764 1261 854 805 113 112 1365 OAI21_X2
* cell instance $11766 m0 *1 126.73,39.2
X$11766 584 1125 1365 112 1442 113 AOI21_X1
* cell instance $11768 r0 *1 125.78,39.2
X$11768 883 1451 584 112 113 1631 NOR3_X1
* cell instance $11770 r0 *1 126.73,39.2
X$11770 112 1286 1439 1440 1509 113 NOR3_X4
* cell instance $11771 m0 *1 128.82,39.2
X$11771 1023 582 112 113 1632 NAND2_X1
* cell instance $11772 m0 *1 127.87,39.2
X$11772 1098 571 112 113 1285 NAND2_X2
* cell instance $11773 m0 *1 129.39,39.2
X$11773 1509 926 736 113 1414 112 OAI21_X1
* cell instance $11776 m0 *1 131.1,39.2
X$11776 728 848 1024 112 113 1554 NAND3_X1
* cell instance $11777 m0 *1 131.86,39.2
X$11777 1287 1286 1023 112 1555 113 AOI21_X1
* cell instance $11778 m0 *1 132.62,39.2
X$11778 1363 113 733 112 BUF_X4
* cell instance $11779 m0 *1 133.95,39.2
X$11779 791 1024 112 113 1447 NAND2_X2
* cell instance $11781 m0 *1 135.66,39.2
X$11781 1447 727 112 113 1450 NOR2_X2
* cell instance $11782 m0 *1 136.61,39.2
X$11782 1450 1505 1445 113 1100 112 OAI21_X1
* cell instance $11784 r0 *1 129.39,39.2
X$11784 1449 707 112 113 1551 NAND2_X1
* cell instance $11786 r0 *1 130.15,39.2
X$11786 930 858 1413 1508 1553 1635 112 113 OAI221_X2
* cell instance $11787 r0 *1 132.24,39.2
X$11787 584 1552 1025 113 112 1446 AND3_X1
* cell instance $11789 r0 *1 133.38,39.2
X$11789 1446 1445 1448 112 1556 113 AOI21_X1
* cell instance $11791 r0 *1 134.52,39.2
X$11791 660 1443 1444 113 1448 112 OAI21_X1
* cell instance $11792 r0 *1 135.28,39.2
X$11792 1660 1452 1289 1448 113 112 1634 OAI22_X1
* cell instance $11793 r0 *1 136.23,39.2
X$11793 1447 659 735 113 1637 112 OAI21_X1
* cell instance $11795 r0 *1 137.18,39.2
X$11795 1450 1451 1289 112 113 1053 NOR3_X1
* cell instance $11796 m0 *1 137.94,39.2
X$11796 1505 1288 1411 1366 1099 1412 112 113 OAI221_X2
* cell instance $11798 m0 *1 140.03,39.2
X$11798 1504 112 113 660 INV_X8
* cell instance $11799 m0 *1 141.74,39.2
X$11799 1503 1256 1181 1410 113 112 1502 AND4_X2
* cell instance $11801 r0 *1 137.94,39.2
X$11801 1340 731 112 113 1452 NOR2_X1
* cell instance $11802 r0 *1 138.51,39.2
X$11802 1637 1452 1409 1182 1557 113 112 1633 OAI221_X1
* cell instance $11803 r0 *1 139.65,39.2
X$11803 927 1444 112 113 1557 NAND2_X1
* cell instance $11804 r0 *1 140.22,39.2
X$11804 1449 1444 112 1209 113 NAND2_X4
* cell instance $11805 r0 *1 141.93,39.2
X$11805 1454 1285 858 591 1209 1453 113 112 AOI221_X2
* cell instance $11806 m0 *1 144.21,39.2
X$11806 1367 1130 1292 928 1499 113 112 1500 OAI221_X1
* cell instance $11807 m0 *1 143.45,39.2
X$11807 1182 927 1409 113 1367 112 OAI21_X1
* cell instance $11810 r0 *1 144.21,39.2
X$11810 112 660 864 113 BUF_X16
* cell instance $11811 m0 *1 147.06,39.2
X$11811 532 810 1025 113 1368 112 OAI21_X1
* cell instance $11812 m0 *1 145.73,39.2
X$11812 934 728 848 112 1459 113 AOI21_X2
* cell instance $11813 m0 *1 147.82,39.2
X$11813 1211 572 1455 112 1456 113 AOI21_X1
* cell instance $11814 m0 *1 148.58,39.2
X$11814 1456 734 1409 113 1295 112 OAI21_X1
* cell instance $11815 m0 *1 149.34,39.2
X$11815 1458 663 1297 112 1457 113 AOI21_X1
* cell instance $11816 m0 *1 150.1,39.2
X$11816 1451 1211 1289 112 113 1625 NOR3_X1
* cell instance $11820 r0 *1 148.96,39.2
X$11820 925 1496 1018 704 1457 113 112 1559 OAI221_X1
* cell instance $11821 r0 *1 150.1,39.2
X$11821 1509 1459 1182 112 113 1458 NOR3_X1
* cell instance $11825 m0 *1 160.55,39.2
X$11825 1489 1494 989 738 112 113 1493 NOR4_X1
* cell instance $11827 m0 *1 161.5,39.2
X$11827 1370 1402 112 113 1494 NOR2_X1
* cell instance $11830 r0 *1 160.93,39.2
X$11830 1403 1620 1623 1493 113 1624 112 OR4_X2
* cell instance $11831 r0 *1 162.26,39.2
X$11831 1471 1460 1371 112 113 1622 NOR3_X1
* cell instance $11832 m0 *1 163.21,39.2
X$11832 1396 1400 1460 296 1401 112 113 1620 AOI221_X1
* cell instance $11833 m0 *1 162.45,39.2
X$11833 543 916 1399 112 1402 113 AOI21_X1
* cell instance $11835 m0 *1 164.54,39.2
X$11835 238 600 817 113 1370 112 OAI21_X1
* cell instance $11839 r0 *1 163.97,39.2
X$11839 1562 1135 1461 113 1618 112 OAI21_X1
* cell instance $11840 r0 *1 164.73,39.2
X$11840 329 600 817 113 1562 112 OAI21_X1
* cell instance $11843 m0 *1 165.68,39.2
X$11843 677 389 112 113 1614 NOR2_X1
* cell instance $11845 r0 *1 165.87,39.2
X$11845 1614 974 295 112 113 1611 NOR3_X1
* cell instance $11846 r0 *1 166.63,39.2
X$11846 1611 1490 112 113 1564 NOR2_X2
* cell instance $11847 r0 *1 167.58,39.2
X$11847 894 542 1070 113 1490 112 NOR3_X2
* cell instance $11848 m0 *1 168.72,39.2
X$11848 438 425 112 113 1461 NOR2_X1
* cell instance $11849 m0 *1 168.15,39.2
X$11849 515 296 112 113 1565 NOR2_X1
* cell instance $11852 m0 *1 171,39.2
X$11852 1486 235 112 113 1396 NOR2_X1
* cell instance $11854 r0 *1 168.91,39.2
X$11854 1388 1461 1610 1000 1607 1609 113 112 AOI221_X2
* cell instance $11856 r0 *1 171.38,39.2
X$11856 1301 295 1604 112 113 1606 MUX2_X1
* cell instance $11857 m0 *1 172.14,39.2
X$11857 358 430 112 113 1232 NOR2_X2
* cell instance $11862 r0 *1 173.28,39.2
X$11862 1373 352 112 113 1604 NOR2_X1
* cell instance $11863 m0 *1 174.04,39.2
X$11863 1669 1374 112 113 1395 NAND2_X1
* cell instance $11864 m0 *1 173.47,39.2
X$11864 1309 430 112 113 1373 NOR2_X1
* cell instance $11865 m0 *1 174.61,39.2
X$11865 1395 1467 1376 1163 485 112 113 1486 AOI221_X1
* cell instance $11868 m0 *1 178.03,39.2
X$11868 437 112 113 1163 INV_X8
* cell instance $11869 m0 *1 179.74,39.2
X$11869 380 1375 1475 113 1463 112 OAI21_X1
* cell instance $11871 m0 *1 180.69,39.2
X$11871 1574 112 113 673 BUF_X2
* cell instance $11872 m0 *1 181.45,39.2
X$11872 497 973 1069 112 1484 113 AOI21_X2
* cell instance $11874 r0 *1 173.85,39.2
X$11874 430 112 113 1374 BUF_X1
* cell instance $11877 r0 *1 174.99,39.2
X$11877 1393 1309 1599 112 113 1372 MUX2_X1
* cell instance $11878 r0 *1 176.32,39.2
X$11878 1462 893 112 113 1599 NOR2_X1
* cell instance $11879 r0 *1 176.89,39.2
X$11879 1462 1163 112 113 1393 NOR2_X1
* cell instance $11881 r0 *1 178.22,39.2
X$11881 1163 1309 1139 112 113 1164 MUX2_X1
* cell instance $11883 r0 *1 179.74,39.2
X$11883 1214 113 478 112 BUF_X4
* cell instance $11888 r0 *1 181.26,39.2
X$11888 479 1462 777 112 113 1069 MUX2_X1
* cell instance $11889 r0 *1 182.59,39.2
X$11889 676 748 112 113 1567 NAND2_X1
* cell instance $11891 m0 *1 183.16,39.2
X$11891 1376 1317 112 113 515 NAND2_X2
* cell instance $11892 r0 *1 183.16,39.2
X$11892 358 1223 112 113 748 NAND2_X1
* cell instance $11894 r0 *1 183.92,39.2
X$11894 1583 1484 281 112 113 1464 NOR3_X1
* cell instance $11895 m0 *1 185.82,39.2
X$11895 610 1155 325 485 112 113 1466 AOI22_X1
* cell instance $11896 m0 *1 184.49,39.2
X$11896 1482 296 828 112 113 1388 MUX2_X1
* cell instance $11898 r0 *1 184.68,39.2
X$11898 1389 838 690 975 826 112 113 1465 AOI221_X1
* cell instance $11899 r0 *1 185.82,39.2
X$11899 1465 240 1466 112 113 1482 MUX2_X1
* cell instance $11900 r0 *1 187.15,39.2
X$11900 838 403 544 1070 1581 1583 113 112 AOI221_X2
* cell instance $11901 m0 *1 188.86,39.2
X$11901 983 1308 112 113 1227 NOR2_X2
* cell instance $11902 m0 *1 187.15,39.2
X$11902 1467 1140 542 112 113 NOR2_X4
* cell instance $11904 r0 *1 189.24,39.2
X$11904 1305 1467 893 112 113 1581 MUX2_X1
* cell instance $11905 m0 *1 192.28,39.2
X$11905 1376 1309 322 113 112 1377 AND3_X1
* cell instance $11906 m0 *1 190.19,39.2
X$11906 1384 1141 1674 903 1377 1475 113 112 AOI221_X2
* cell instance $11907 m0 *1 193.23,39.2
X$11907 606 497 610 241 112 113 1468 NAND4_X1
* cell instance $11909 r0 *1 190.57,39.2
X$11909 1376 113 544 112 BUF_X4
* cell instance $11910 r0 *1 191.9,39.2
X$11910 400 544 1070 975 112 113 1570 NAND4_X1
* cell instance $11913 r0 *1 193.42,39.2
X$11913 1469 329 1569 238 1382 1471 113 112 AOI221_X2
* cell instance $11914 m0 *1 195.32,39.2
X$11914 238 1378 1379 113 1469 112 OAI21_X1
* cell instance $11915 m0 *1 194.56,39.2
X$11915 403 1380 1378 112 1381 113 AOI21_X1
* cell instance $11917 m0 *1 196.27,39.2
X$11917 400 497 112 113 1379 NAND2_X1
* cell instance $11926 r0 *1 195.51,39.2
X$11926 1467 113 400 112 BUF_X4
* cell instance $11939 m0 *1 20.71,123.2
X$11939 112 16902 8683 6741 8232 113 DFF_X1
* cell instance $11940 m0 *1 24.13,123.2
X$11940 8236 7635 7619 112 8551 113 AOI21_X1
* cell instance $11941 m0 *1 24.89,123.2
X$11941 8012 8305 7623 112 113 8603 NOR3_X1
* cell instance $11942 m0 *1 25.65,123.2
X$11942 8551 7701 7848 112 113 8177 NOR3_X1
* cell instance $11943 m0 *1 26.41,123.2
X$11943 7620 8417 112 113 8746 OR2_X1
* cell instance $11944 m0 *1 27.17,123.2
X$11944 7176 7706 8557 112 8476 113 AOI21_X1
* cell instance $11945 m0 *1 27.93,123.2
X$11945 8551 7293 8553 112 8692 113 AOI21_X1
* cell instance $11946 m0 *1 28.69,123.2
X$11946 112 8556 8603 8637 8554 113 AOI21_X4
* cell instance $11947 m0 *1 31.16,123.2
X$11947 7706 7441 7630 8554 8692 113 112 8689 OAI221_X1
* cell instance $11949 m0 *1 32.49,123.2
X$11949 8308 113 8478 112 BUF_X4
* cell instance $11951 m0 *1 34.01,123.2
X$11951 112 8607 8552 6853 6798 113 AOI21_X4
* cell instance $11952 m0 *1 36.48,123.2
X$11952 8604 8186 8556 113 112 8695 OAI21_X4
* cell instance $11953 m0 *1 38.95,123.2
X$11953 8557 7883 8182 7800 7495 113 112 8421 OAI221_X1
* cell instance $11954 m0 *1 40.09,123.2
X$11954 8552 8418 112 113 8696 NOR2_X1
* cell instance $11955 m0 *1 40.66,123.2
X$11955 6902 7710 8607 7403 8182 8563 112 113 OAI221_X2
* cell instance $11956 m0 *1 42.75,123.2
X$11956 7445 7225 112 113 8558 NOR2_X2
* cell instance $11958 m0 *1 43.89,123.2
X$11958 7795 8247 7847 112 113 8641 NAND3_X1
* cell instance $11959 m0 *1 44.65,123.2
X$11959 7178 8262 7619 7635 112 113 8613 AOI22_X1
* cell instance $11960 m0 *1 45.6,123.2
X$11960 112 7217 7393 8699 8417 7226 113 AOI22_X4
* cell instance $11961 m0 *1 48.83,123.2
X$11961 8420 7889 8700 113 9078 112 NOR3_X2
* cell instance $11962 m0 *1 50.16,123.2
X$11962 8020 8426 112 113 7889 NAND2_X1
* cell instance $11963 m0 *1 50.73,123.2
X$11963 7507 113 8491 112 BUF_X4
* cell instance $11964 m0 *1 52.06,123.2
X$11964 8262 6902 112 113 8642 NAND2_X1
* cell instance $11965 m0 *1 52.63,123.2
X$11965 8563 8561 8567 113 112 8564 OAI21_X2
* cell instance $11967 m0 *1 54.15,123.2
X$11967 8256 7072 7403 113 8617 112 OAI21_X1
* cell instance $11972 m0 *1 14.82,123.2
X$11972 8600 112 113 8633 BUF_X1
* cell instance $11982 r0 *1 12.92,123.2
X$11982 8634 112 113 6586 BUF_X2
* cell instance $11984 m0 *1 16.72,123.2
X$11984 8683 112 113 8631 BUF_X1
* cell instance $11988 m0 *1 17.67,123.2
X$11988 8632 112 113 6961 BUF_X1
* cell instance $11991 m0 *1 19.38,123.2
X$11991 6050 112 113 8232 CLKBUF_X3
* cell instance $11995 r0 *1 23.94,123.2
X$11995 7635 7619 7637 112 113 8684 NAND3_X1
* cell instance $11999 r0 *1 26.03,123.2
X$11999 8684 6968 8383 112 113 8801 NAND3_X1
* cell instance $12000 r0 *1 26.79,123.2
X$12000 7636 7880 6968 112 8635 113 AOI21_X1
* cell instance $12001 r0 *1 27.55,123.2
X$12001 8253 7625 7588 7887 8909 112 113 OAI211_X2
* cell instance $12002 r0 *1 29.26,123.2
X$12002 8178 8689 112 113 8636 NAND2_X1
* cell instance $12003 r0 *1 29.83,123.2
X$12003 7445 7394 8253 112 8690 113 AOI21_X1
* cell instance $12004 r0 *1 30.59,123.2
X$12004 7176 8640 7622 113 8803 112 OAI21_X1
* cell instance $12005 r0 *1 31.35,123.2
X$12005 7636 7795 6968 112 8748 113 AOI21_X1
* cell instance $12006 r0 *1 32.11,123.2
X$12006 8640 7884 7887 112 8639 113 AOI21_X1
* cell instance $12007 r0 *1 32.87,123.2
X$12007 7881 7637 7887 112 8693 113 AOI21_X1
* cell instance $12008 r0 *1 33.63,123.2
X$12008 7445 112 113 8557 CLKBUF_X3
* cell instance $12009 r0 *1 34.58,123.2
X$12009 8379 7635 7619 112 8640 113 AOI21_X2
* cell instance $12010 r0 *1 35.91,123.2
X$12010 112 8601 7302 7965 8309 113 NOR3_X4
* cell instance $12011 r0 *1 38.57,123.2
X$12011 7493 8695 8560 113 112 8807 OAI21_X4
* cell instance $12012 r0 *1 41.04,123.2
X$12012 112 7306 113 7216 BUF_X8
* cell instance $12014 r0 *1 43.7,123.2
X$12014 8183 8756 112 113 7493 NOR2_X2
* cell instance $12015 r0 *1 44.65,123.2
X$12015 8699 6902 8811 113 112 8559 OAI21_X4
* cell instance $12016 r0 *1 47.12,123.2
X$12016 8562 7181 7180 112 8754 113 AOI21_X2
* cell instance $12019 r0 *1 49.02,123.2
X$12019 8392 8702 8644 8813 8391 8703 113 112 AOI221_X2
* cell instance $12020 r0 *1 51.11,123.2
X$12020 8491 8553 7703 7443 7710 113 112 8423 OAI221_X1
* cell instance $12021 r0 *1 52.25,123.2
X$12021 8262 7503 112 113 8561 NAND2_X2
* cell instance $12023 r0 *1 53.58,123.2
X$12023 7800 7890 7795 113 8815 112 OAI21_X1
* cell instance $12024 r0 *1 54.34,123.2
X$12024 8383 8024 8803 113 8814 112 OAI21_X1
* cell instance $12025 r0 *1 55.1,123.2
X$12025 7965 7181 8617 113 8852 112 OAI21_X1
* cell instance $12026 m0 *1 56.24,123.2
X$12026 8643 8619 8566 7621 8709 8644 113 112 AOI221_X2
* cell instance $12027 m0 *1 55.29,123.2
X$12027 8262 7802 112 113 8562 NAND2_X2
* cell instance $12030 m0 *1 60.04,123.2
X$12030 8495 113 7503 112 BUF_X4
* cell instance $12031 m0 *1 61.37,123.2
X$12031 8196 6382 113 6741 112 XOR2_X2
* cell instance $12034 r0 *1 56.05,123.2
X$12034 7180 113 8253 112 BUF_X4
* cell instance $12035 r0 *1 57.38,123.2
X$12035 8815 7636 112 113 8643 NAND2_X1
* cell instance $12037 r0 *1 58.14,123.2
X$12037 8645 113 7882 112 BUF_X4
* cell instance $12038 r0 *1 59.47,123.2
X$12038 8645 8495 112 113 8185 NAND2_X2
* cell instance $12040 m0 *1 63.65,123.2
X$12040 8711 6860 113 8426 112 XOR2_X2
* cell instance $12043 m0 *1 65.55,123.2
X$12043 112 16816 8713 8621 6855 113 DFF_X1
* cell instance $12048 r0 *1 63.65,123.2
X$12048 6860 8711 112 113 8756 XNOR2_X2
* cell instance $12052 r0 *1 67.64,123.2
X$12052 8853 8714 8317 113 112 8711 MUX2_X2
* cell instance $12056 r0 *1 69.35,123.2
X$12056 5954 8817 113 112 8714 XNOR2_X1
* cell instance $12057 r0 *1 70.49,123.2
X$12057 8713 113 8818 112 BUF_X4
* cell instance $12058 m0 *1 71.63,123.2
X$12058 8620 8570 113 112 8569 XNOR2_X1
* cell instance $12061 m0 *1 72.96,123.2
X$12061 4365 8571 112 113 8121 XNOR2_X2
* cell instance $12062 m0 *1 74.86,123.2
X$12062 5473 7598 113 8647 112 XOR2_X2
* cell instance $12065 m0 *1 77.52,123.2
X$12065 8648 8623 112 113 8624 XNOR2_X2
* cell instance $12068 m0 *1 86.26,123.2
X$12068 8432 8626 112 113 7812 XNOR2_X2
* cell instance $12069 m0 *1 88.16,123.2
X$12069 8267 7516 8433 112 113 8725 OR3_X1
* cell instance $12071 r0 *1 71.82,123.2
X$12071 8571 8570 113 112 8817 XNOR2_X1
* cell instance $12072 r0 *1 72.96,123.2
X$12072 8620 8819 112 113 8571 XNOR2_X2
* cell instance $12075 r0 *1 75.81,123.2
X$12075 8646 8820 113 112 8123 XNOR2_X1
* cell instance $12076 r0 *1 76.95,123.2
X$12076 8622 8761 113 112 8648 XNOR2_X1
* cell instance $12077 r0 *1 78.09,123.2
X$12077 8716 8719 112 113 8271 XNOR2_X2
* cell instance $12078 r0 *1 79.99,123.2
X$12078 8721 8822 112 113 8719 XNOR2_X2
* cell instance $12079 r0 *1 81.89,123.2
X$12079 8649 8431 112 113 8721 XNOR2_X2
* cell instance $12080 r0 *1 83.79,123.2
X$12080 8650 8723 113 112 8651 XNOR2_X1
* cell instance $12083 r0 *1 85.5,123.2
X$12083 7898 8431 112 113 8723 XNOR2_X2
* cell instance $12087 r0 *1 88.73,123.2
X$12087 8764 8577 8267 112 113 8824 NAND3_X1
* cell instance $12088 r0 *1 89.49,123.2
X$12088 8433 112 113 8764 BUF_X1
* cell instance $12090 m0 *1 89.49,123.2
X$12090 8572 8824 8725 112 8322 113 AOI21_X2
* cell instance $12091 m0 *1 91.58,123.2
X$12091 8726 194 8627 112 113 8509 MUX2_X1
* cell instance $12098 r0 *1 92.34,123.2
X$12098 112 8768 8766 8859 8767 8645 113 NAND4_X4
* cell instance $12099 r0 *1 95.76,123.2
X$12099 5395 5273 112 113 8770 NOR2_X1
* cell instance $12101 r0 *1 96.52,123.2
X$12101 8195 8819 113 112 8771 XNOR2_X1
* cell instance $12102 r0 *1 97.66,123.2
X$12102 112 8728 8829 8727 8519 113 DFF_X1
* cell instance $12103 m0 *1 99.18,123.2
X$12103 5708 8204 8574 113 112 8727 AND3_X1
* cell instance $12104 m0 *1 98.61,123.2
X$12104 8573 8862 112 113 8435 NOR2_X1
* cell instance $12105 m0 *1 100.13,123.2
X$12105 8731 8440 113 112 8730 XNOR2_X1
* cell instance $12106 m0 *1 101.27,123.2
X$12106 3774 8728 113 4211 112 XOR2_X2
* cell instance $12107 m0 *1 102.98,123.2
X$12107 112 8732 8830 8576 8519 113 DFF_X1
* cell instance $12109 m0 *1 106.97,123.2
X$12109 8732 3432 112 113 5785 XNOR2_X2
* cell instance $12111 r0 *1 100.89,123.2
X$12111 8729 8829 113 112 8731 XNOR2_X1
* cell instance $12112 r0 *1 102.03,123.2
X$12112 8575 112 113 8832 INV_X1
* cell instance $12113 r0 *1 102.41,123.2
X$12113 112 8718 7510 113 BUF_X16
* cell instance $12114 r0 *1 107.16,123.2
X$12114 3432 8833 113 112 8954 XNOR2_X1
* cell instance $12115 r0 *1 108.3,123.2
X$12115 8734 8830 113 112 8955 XNOR2_X1
* cell instance $12116 m0 *1 110.2,123.2
X$12116 8519 112 113 16468 CLKBUF_X1
* cell instance $12117 m0 *1 109.25,123.2
X$12117 4279 112 113 8519 CLKBUF_X3
* cell instance $12121 r0 *1 109.44,123.2
X$12121 8697 6244 112 113 8836 NOR2_X1
* cell instance $12122 r0 *1 110.01,123.2
X$12122 9007 8738 113 130 112 XOR2_X2
* cell instance $12123 r0 *1 111.72,123.2
X$12123 8836 3776 6879 112 8772 113 AOI21_X1
* cell instance $12125 m0 *1 115.14,123.2
X$12125 112 8740 8414 8739 8519 113 DFF_X1
* cell instance $12126 m0 *1 113.43,123.2
X$12126 8439 8740 113 6879 112 XOR2_X2
* cell instance $12135 r0 *1 116.85,123.2
X$12135 7238 8321 8653 8652 112 113 8837 OR4_X1
* cell instance $12138 r0 *1 118.56,123.2
X$12138 8654 8656 8267 5122 112 113 8774 NAND4_X1
* cell instance $12139 r0 *1 119.51,123.2
X$12139 8654 8655 113 112 8775 AND2_X1
* cell instance $12140 r0 *1 120.27,123.2
X$12140 8655 8656 8657 8659 112 113 8776 NAND4_X1
* cell instance $12141 r0 *1 121.22,123.2
X$12141 8657 8659 8321 8329 112 113 8831 NOR4_X1
* cell instance $12143 r0 *1 122.93,123.2
X$12143 8657 8653 113 112 8778 XNOR2_X1
* cell instance $12149 r0 *1 126.35,123.2
X$12149 8966 3776 8778 112 8777 113 AOI21_X1
* cell instance $12150 r0 *1 127.11,123.2
X$12150 7539 8778 113 112 8827 XNOR2_X1
* cell instance $12151 r0 *1 128.25,123.2
X$12151 2816 112 113 1747 CLKBUF_X3
* cell instance $12152 r0 *1 129.2,123.2
X$12152 8828 8658 112 113 8652 NAND2_X1
* cell instance $12155 r0 *1 130.15,123.2
X$12155 8743 6211 8827 112 113 8779 MUX2_X1
* cell instance $12156 r0 *1 131.48,123.2
X$12156 8658 113 7539 112 BUF_X4
* cell instance $12158 m0 *1 134.9,123.2
X$12158 112 16731 8578 8579 8298 113 DFF_X1
* cell instance $12160 m0 *1 138.13,123.2
X$12160 8578 5550 4163 113 112 8744 MUX2_X2
* cell instance $12165 r0 *1 137.56,123.2
X$12165 112 7751 7212 113 BUF_X32
* cell instance $12166 m0 *1 142.31,123.2
X$12166 112 8339 8661 8580 6789 113 NOR3_X4
* cell instance $12167 m0 *1 140.98,123.2
X$12167 7662 113 6254 112 BUF_X4
* cell instance $12168 m0 *1 144.97,123.2
X$12168 8661 113 6922 112 BUF_X4
* cell instance $12170 m0 *1 146.49,123.2
X$12170 8582 7922 7026 113 8211 112 OAI21_X1
* cell instance $12171 m0 *1 147.25,123.2
X$12171 112 7915 6922 6920 6793 113 NOR3_X4
* cell instance $12172 m0 *1 149.91,123.2
X$12172 7910 8283 7872 112 6541 113 NAND3_X4
* cell instance $12173 m0 *1 152.38,123.2
X$12173 8338 113 7910 112 BUF_X4
* cell instance $12175 m0 *1 153.9,123.2
X$12175 8663 8050 6195 112 113 8742 NAND3_X1
* cell instance $12176 m0 *1 154.66,123.2
X$12176 8584 6254 8399 112 113 8664 MUX2_X1
* cell instance $12178 m0 *1 156.18,123.2
X$12178 8581 7667 5979 112 113 NOR2_X4
* cell instance $12180 m0 *1 158.08,123.2
X$12180 112 6470 6407 8443 8338 113 AOI21_X4
* cell instance $12182 m0 *1 160.74,123.2
X$12182 112 6929 8173 8736 6205 8583 8393 7255 113 AOI222_X2
* cell instance $12184 r0 *1 146.87,123.2
X$12184 5982 6367 16718 113 112 8823 HA_X1
* cell instance $12185 r0 *1 148.77,123.2
X$12185 8582 7872 7910 112 7414 113 AOI21_X2
* cell instance $12186 r0 *1 150.1,123.2
X$12186 8443 113 7872 112 BUF_X4
* cell instance $12187 r0 *1 151.43,123.2
X$12187 8823 7115 8444 113 8542 112 OAI21_X1
* cell instance $12188 r0 *1 152.19,123.2
X$12188 8781 8662 5979 8050 112 113 8816 NAND4_X1
* cell instance $12189 r0 *1 153.14,123.2
X$12189 6894 6352 7530 113 8662 112 OAI21_X1
* cell instance $12190 r0 *1 153.9,123.2
X$12190 7026 7604 112 113 8444 NAND2_X1
* cell instance $12191 r0 *1 154.47,123.2
X$12191 7607 8050 112 113 8741 NAND2_X1
* cell instance $12193 r0 *1 155.23,123.2
X$12193 8664 8742 8741 8736 8816 7789 112 113 OAI221_X2
* cell instance $12194 r0 *1 157.32,123.2
X$12194 8581 113 7827 112 BUF_X4
* cell instance $12195 r0 *1 158.65,123.2
X$12195 7910 8783 7872 112 7121 113 NAND3_X4
* cell instance $12196 r0 *1 161.12,123.2
X$12196 7416 7828 8782 112 8737 113 AOI21_X1
* cell instance $12197 r0 *1 161.88,123.2
X$12197 8735 113 7919 112 BUF_X4
* cell instance $12199 r0 *1 163.59,123.2
X$12199 7922 7533 8733 6205 7923 6261 112 113 8876 OAI33_X1
* cell instance $12201 m0 *1 163.78,123.2
X$12201 112 8536 7030 113 INV_X16
* cell instance $12202 r0 *1 164.92,123.2
X$12202 6352 8161 112 113 7142 NAND2_X2
* cell instance $12203 r0 *1 165.87,123.2
X$12203 6267 8283 8161 112 113 8665 MUX2_X1
* cell instance $12205 m0 *1 169.48,123.2
X$12205 8217 8450 6156 112 113 NOR2_X4
* cell instance $12206 m0 *1 167.39,123.2
X$12206 8724 7828 8618 6402 8166 8045 113 112 AOI221_X2
* cell instance $12207 m0 *1 171.19,123.2
X$12207 7667 113 6074 112 BUF_X4
* cell instance $12209 r0 *1 167.39,123.2
X$12209 112 6159 113 7915 BUF_X8
* cell instance $12210 r0 *1 169.86,123.2
X$12210 8217 113 6701 112 BUF_X4
* cell instance $12211 r0 *1 171.19,123.2
X$12211 7922 112 113 6934 CLKBUF_X3
* cell instance $12213 r0 *1 172.33,123.2
X$12213 112 8540 113 8666 BUF_X8
* cell instance $12214 m0 *1 173.09,123.2
X$12214 3932 8616 112 113 8219 XNOR2_X2
* cell instance $12216 m0 *1 174.99,123.2
X$12216 8450 113 7667 112 BUF_X4
* cell instance $12217 m0 *1 176.32,123.2
X$12217 112 8451 8667 8722 8298 113 DFF_X1
* cell instance $12218 m0 *1 179.55,123.2
X$12218 8667 8585 8685 112 113 8722 MUX2_X1
* cell instance $12219 m0 *1 180.88,123.2
X$12219 7604 7827 8540 112 113 8668 NAND3_X1
* cell instance $12220 m0 *1 181.64,123.2
X$12220 8052 6080 6407 113 8453 112 OAI21_X1
* cell instance $12223 m0 *1 183.35,123.2
X$12223 112 8586 8614 8717 8670 113 NOR3_X4
* cell instance $12226 m0 *1 188.29,123.2
X$12226 112 2861 113 7650 BUF_X8
* cell instance $12228 m0 *1 192.28,123.2
X$12228 112 8669 8671 8715 6705 113 DFF_X1
* cell instance $12229 m0 *1 195.51,123.2
X$12229 8671 3947 6846 112 113 8715 MUX2_X1
* cell instance $12230 m0 *1 196.84,123.2
X$12230 7974 8587 8611 113 8612 112 OAI21_X1
* cell instance $12231 m0 *1 197.6,123.2
X$12231 112 16882 8712 8612 8221 113 DFF_X1
* cell instance $12232 m0 *1 200.83,123.2
X$12232 8712 112 113 5419 CLKBUF_X3
* cell instance $12234 m0 *1 201.97,123.2
X$12234 8686 8295 8809 112 113 8673 MUX2_X1
* cell instance $12238 m0 *1 212.61,123.2
X$12238 7832 5562 112 113 8674 NAND2_X1
* cell instance $12240 r0 *1 174.8,123.2
X$12240 112 7751 7593 113 INV_X16
* cell instance $12241 r0 *1 178.03,123.2
X$12241 112 6138 113 7593 BUF_X8
* cell instance $12245 r0 *1 180.5,123.2
X$12245 7539 112 113 8659 INV_X1
* cell instance $12248 r0 *1 181.45,123.2
X$12248 8669 8718 8659 112 113 8720 NAND3_X1
* cell instance $12249 r0 *1 182.21,123.2
X$12249 8720 8669 8812 113 112 7757 OAI21_X2
* cell instance $12250 r0 *1 183.54,123.2
X$12250 112 8434 113 7516 BUF_X8
* cell instance $12253 r0 *1 187.15,123.2
X$12253 5065 112 113 8810 BUF_X1
* cell instance $12259 r0 *1 193.61,123.2
X$12259 112 4676 113 7650 BUF_X8
* cell instance $12260 r0 *1 196.08,123.2
X$12260 8440 4211 113 112 8587 XNOR2_X1
* cell instance $12264 r0 *1 199.69,123.2
X$12264 8672 4211 113 112 8809 XNOR2_X1
* cell instance $12265 r0 *1 200.83,123.2
X$12265 5419 8672 112 113 8440 XNOR2_X2
* cell instance $12266 r0 *1 202.73,123.2
X$12266 112 17077 8710 8673 7043 113 DFF_X1
* cell instance $12267 r0 *1 205.96,123.2
X$12267 8710 112 113 8672 CLKBUF_X3
* cell instance $12268 r0 *1 206.91,123.2
X$12268 6333 8885 112 113 8708 XOR2_X1
* cell instance $12270 r0 *1 208.24,123.2
X$12270 8707 4389 8708 112 113 8787 MUX2_X1
* cell instance $12273 r0 *1 211.85,123.2
X$12273 7340 7832 112 113 8675 NAND2_X1
* cell instance $12275 r0 *1 212.61,123.2
X$12275 8063 8674 7163 6429 8706 6876 113 112 AOI221_X2
* cell instance $12276 m0 *1 214.7,123.2
X$12276 6429 6714 112 113 8588 NOR2_X1
* cell instance $12277 m0 *1 213.56,123.2
X$12277 8223 8924 8705 6425 8608 113 112 8609 OAI221_X1
* cell instance $12278 m0 *1 215.27,123.2
X$12278 8704 6723 6331 112 113 8705 NOR3_X1
* cell instance $12280 m0 *1 216.22,123.2
X$12280 8061 7170 8091 8676 7563 112 113 8704 AOI221_X1
* cell instance $12282 m0 *1 218.88,123.2
X$12282 7325 8589 7833 8698 6831 7079 112 113 OAI221_X2
* cell instance $12283 m0 *1 220.97,123.2
X$12283 6714 7689 6032 113 8589 112 OAI21_X1
* cell instance $12286 m0 *1 223.44,123.2
X$12286 8460 6562 8589 112 8591 113 AOI21_X1
* cell instance $12288 r0 *1 214.7,123.2
X$12288 5873 5871 8675 113 8706 112 OAI21_X1
* cell instance $12291 r0 *1 216.6,123.2
X$12291 7563 8925 112 113 8111 NOR2_X1
* cell instance $12292 r0 *1 217.17,123.2
X$12292 6714 7563 6028 113 8806 112 OAI21_X1
* cell instance $12293 r0 *1 217.93,123.2
X$12293 6028 6838 112 113 8677 NAND2_X1
* cell instance $12294 r0 *1 218.5,123.2
X$12294 8677 8063 113 112 8701 AND2_X1
* cell instance $12296 r0 *1 219.64,123.2
X$12296 5769 6436 6715 113 8788 112 OAI21_X1
* cell instance $12297 r0 *1 220.4,123.2
X$12297 5878 6561 112 113 8921 NAND2_X1
* cell instance $12298 r0 *1 220.97,123.2
X$12298 112 6838 113 5873 BUF_X8
* cell instance $12299 r0 *1 223.44,123.2
X$12299 8590 8790 112 113 8789 OR2_X1
* cell instance $12300 r0 *1 224.2,123.2
X$12300 5564 6717 7838 113 8790 112 OAI21_X1
* cell instance $12301 m0 *1 224.77,123.2
X$12301 7689 6714 112 113 8678 NAND2_X1
* cell instance $12303 m0 *1 225.34,123.2
X$12303 8694 8591 6331 7448 113 112 8241 OAI22_X1
* cell instance $12305 m0 *1 226.48,123.2
X$12305 8678 6591 6562 112 113 8593 NAND3_X1
* cell instance $12306 m0 *1 227.24,123.2
X$12306 6440 6032 7051 112 113 8679 NAND3_X1
* cell instance $12310 r0 *1 225.15,123.2
X$12310 6838 6717 6027 113 8791 112 OAI21_X1
* cell instance $12312 r0 *1 227.43,123.2
X$12312 5871 5873 112 113 8463 NOR2_X1
* cell instance $12313 r0 *1 228,123.2
X$12313 5769 7563 5662 112 113 8792 MUX2_X1
* cell instance $12314 m0 *1 229.9,123.2
X$12314 6733 5564 112 113 8483 NAND2_X1
* cell instance $12315 m0 *1 229.14,123.2
X$12315 8602 8691 6019 112 113 8359 NAND3_X1
* cell instance $12316 m0 *1 230.47,123.2
X$12316 6283 8458 6562 7440 8691 112 113 OAI211_X2
* cell instance $12317 m0 *1 232.18,123.2
X$12317 6429 112 113 6733 CLKBUF_X3
* cell instance $12319 r0 *1 229.33,123.2
X$12319 7838 113 6432 112 BUF_X4
* cell instance $12320 r0 *1 230.66,123.2
X$12320 7832 112 113 5878 CLKBUF_X3
* cell instance $12321 r0 *1 231.61,123.2
X$12321 7832 113 5871 112 BUF_X4
* cell instance $12322 r0 *1 232.94,123.2
X$12322 5878 112 113 7051 CLKBUF_X3
* cell instance $12324 m0 *1 233.51,123.2
X$12324 6028 113 7325 112 BUF_X4
* cell instance $12325 r0 *1 233.89,123.2
X$12325 5871 113 6028 112 BUF_X4
* cell instance $12327 m0 *1 235.22,123.2
X$12327 8680 112 113 8686 BUF_X1
* cell instance $12328 m0 *1 236.55,123.2
X$12328 8797 112 113 8687 BUF_X1
* cell instance $12331 r0 *1 235.22,123.2
X$12331 8795 112 113 8707 BUF_X1
* cell instance $12336 m0 *1 238.45,123.2
X$12336 8681 112 113 8685 BUF_X1
* cell instance $12339 m0 *1 239.21,123.2
X$12339 9531 112 113 8597 BUF_X1
* cell instance $12342 r0 *1 239.21,123.2
X$12342 8905 112 113 8682 BUF_X1
* cell instance $12345 m0 *1 171,56
X$12345 2469 113 2683 112 BUF_X4
* cell instance $12346 m0 *1 172.52,56
X$12346 2749 2475 2643 112 113 2687 OR3_X1
* cell instance $12347 m0 *1 173.47,56
X$12347 2577 113 2640 112 BUF_X4
* cell instance $12349 m0 *1 174.99,56
X$12349 2360 2746 2755 2642 112 113 2744 AOI22_X1
* cell instance $12350 m0 *1 175.94,56
X$12350 2403 112 113 2685 CLKBUF_X3
* cell instance $12351 m0 *1 176.89,56
X$12351 2410 2685 2574 112 113 3013 MUX2_X1
* cell instance $12354 m0 *1 179.93,56
X$12354 2742 113 1140 112 BUF_X4
* cell instance $12357 m0 *1 183.54,56
X$12357 2741 2578 112 113 2740 NAND2_X1
* cell instance $12358 m0 *1 184.11,56
X$12358 2365 2362 112 113 2858 NAND2_X1
* cell instance $12359 m0 *1 184.68,56
X$12359 2741 2362 112 113 2808 NAND2_X1
* cell instance $12360 m0 *1 185.25,56
X$12360 2507 112 113 1223 BUF_X1
* cell instance $12361 m0 *1 185.82,56
X$12361 2740 2690 2367 112 113 2368 MUX2_X1
* cell instance $12363 r0 *1 171,56
X$12363 2913 2634 2914 113 2870 112 OAI21_X1
* cell instance $12364 r0 *1 171.76,56
X$12364 2465 2869 2687 113 2802 112 OAI21_X1
* cell instance $12366 r0 *1 172.71,56
X$12366 2688 2802 113 112 2915 AND2_X1
* cell instance $12367 r0 *1 173.47,56
X$12367 2360 2680 113 112 2866 XNOR2_X1
* cell instance $12368 r0 *1 174.61,56
X$12368 3083 2464 2805 112 113 2971 MUX2_X1
* cell instance $12369 r0 *1 175.94,56
X$12369 2517 112 113 2805 INV_X1
* cell instance $12371 r0 *1 176.51,56
X$12371 2805 2804 2410 112 113 2970 MUX2_X1
* cell instance $12372 r0 *1 177.84,56
X$12372 2916 2801 2863 112 2864 113 AOI21_X1
* cell instance $12373 r0 *1 178.6,56
X$12373 2860 2744 2918 112 113 2863 NAND3_X1
* cell instance $12374 r0 *1 179.36,56
X$12374 2680 2577 112 113 2961 NOR2_X1
* cell instance $12379 r0 *1 180.69,56
X$12379 2859 2807 112 113 438 XNOR2_X2
* cell instance $12380 r0 *1 182.59,56
X$12380 2807 2859 113 1566 112 XOR2_X2
* cell instance $12383 r0 *1 184.87,56
X$12383 2858 2808 2690 113 112 1854 MUX2_X2
* cell instance $12386 r0 *1 187.15,56
X$12386 2578 2691 112 113 2739 NAND2_X2
* cell instance $12387 m0 *1 187.72,56
X$12387 2738 2739 2580 2855 113 112 2579 OAI22_X2
* cell instance $12390 m0 *1 189.62,56
X$12390 2738 1305 2691 113 2477 112 NOR3_X2
* cell instance $12395 r0 *1 188.1,56
X$12395 2579 112 113 2509 INV_X2
* cell instance $12396 r0 *1 188.67,56
X$12396 2366 2692 112 113 2855 NAND2_X1
* cell instance $12397 r0 *1 189.24,56
X$12397 2691 112 113 2692 INV_X1
* cell instance $12398 r0 *1 189.62,56
X$12398 2849 2848 113 1317 112 XOR2_X2
* cell instance $12399 r0 *1 191.33,56
X$12399 2848 2849 112 113 283 XNOR2_X2
* cell instance $12400 r0 *1 193.23,56
X$12400 2809 2847 112 113 1376 XNOR2_X2
* cell instance $12401 r0 *1 195.13,56
X$12401 2847 2809 113 983 112 XOR2_X2
* cell instance $12402 m0 *1 196.84,56
X$12402 112 2627 1856 2036 2486 113 NOR3_X4
* cell instance $12405 m0 *1 201.02,56
X$12405 1765 2478 2625 113 2736 112 OAI21_X1
* cell instance $12406 m0 *1 201.78,56
X$12406 2248 2484 112 113 2693 NAND2_X1
* cell instance $12407 m0 *1 202.35,56
X$12407 2731 112 113 2581 INV_X2
* cell instance $12409 m0 *1 203.68,56
X$12409 2627 1858 112 113 2583 NOR2_X1
* cell instance $12410 m0 *1 204.25,56
X$12410 2583 2581 112 113 2694 NAND2_X1
* cell instance $12412 m0 *1 205.01,56
X$12412 2695 2048 2037 113 2582 112 OAI21_X1
* cell instance $12413 m0 *1 205.77,56
X$12413 2164 2252 112 113 2696 NOR2_X2
* cell instance $12414 m0 *1 206.72,56
X$12414 112 2147 2622 2697 2153 2143 113 AOI22_X4
* cell instance $12415 m0 *1 209.95,56
X$12415 2252 1859 112 113 2725 NOR2_X2
* cell instance $12416 m0 *1 210.9,56
X$12416 2617 2141 2153 112 2698 113 AOI21_X2
* cell instance $12417 m0 *1 212.23,56
X$12417 2037 2138 112 113 2585 NAND2_X2
* cell instance $12418 m0 *1 213.18,56
X$12418 2398 2155 2583 112 2719 113 AOI21_X1
* cell instance $12419 m0 *1 213.94,56
X$12419 2699 1866 2720 112 2721 113 AOI21_X1
* cell instance $12420 m0 *1 214.7,56
X$12420 2369 2264 113 112 2699 AND2_X1
* cell instance $12424 r0 *1 197.03,56
X$12424 2482 113 2846 112 BUF_X4
* cell instance $12426 r0 *1 198.55,56
X$12426 2480 2736 2486 2731 112 113 3016 AOI22_X2
* cell instance $12427 r0 *1 200.26,56
X$12427 2810 2844 2582 113 3161 112 OAI21_X1
* cell instance $12429 r0 *1 201.21,56
X$12429 1864 2252 2396 113 2844 112 OAI21_X1
* cell instance $12431 r0 *1 202.35,56
X$12431 2693 2721 2956 2253 2607 113 112 2843 OAI221_X1
* cell instance $12433 r0 *1 203.87,56
X$12433 2696 2694 2248 2252 2812 2842 113 112 AOI221_X2
* cell instance $12434 r0 *1 205.96,56
X$12434 1859 2037 2727 113 2812 112 OAI21_X1
* cell instance $12435 r0 *1 206.72,56
X$12435 2037 2258 112 113 2727 NAND2_X1
* cell instance $12436 r0 *1 207.29,56
X$12436 2255 2697 2584 2137 2725 2924 113 112 AOI221_X2
* cell instance $12437 r0 *1 209.38,56
X$12437 2148 2486 2715 2145 1870 112 113 2813 AOI221_X1
* cell instance $12439 r0 *1 210.9,56
X$12439 2255 2837 2693 2258 2147 2838 112 113 OAI221_X2
* cell instance $12440 r0 *1 212.99,56
X$12440 2480 1858 112 113 2701 NAND2_X2
* cell instance $12442 r0 *1 214.13,56
X$12442 2396 2259 2719 1866 2701 3024 112 113 OAI221_X2
* cell instance $12443 r0 *1 216.22,56
X$12443 2264 3048 2700 112 113 NOR2_X4
* cell instance $12445 m0 *1 216.6,56
X$12445 2699 2700 2626 112 113 2835 NOR3_X1
* cell instance $12446 m0 *1 217.55,56
X$12446 1860 2495 2264 1943 2498 2614 112 113 OAI221_X2
* cell instance $12447 m0 *1 219.64,56
X$12447 2047 1860 2147 112 3026 113 AOI21_X1
* cell instance $12448 m0 *1 220.4,56
X$12448 2585 2701 113 112 2137 AND2_X1
* cell instance $12450 r0 *1 217.93,56
X$12450 2835 2164 2491 113 2833 112 NOR3_X2
* cell instance $12452 r0 *1 219.45,56
X$12452 112 1860 2585 2156 2815 2282 113 OAI22_X4
* cell instance $12454 m0 *1 221.54,56
X$12454 2700 2701 2379 2597 2588 2702 113 112 AOI221_X2
* cell instance $12455 r0 *1 222.68,56
X$12455 2258 2498 2585 113 2941 112 OAI21_X1
* cell instance $12456 r0 *1 223.44,56
X$12456 2814 2374 112 113 2715 NAND2_X1
* cell instance $12458 m0 *1 224.01,56
X$12458 2703 2589 112 113 2714 NAND2_X1
* cell instance $12459 r0 *1 224.01,56
X$12459 2398 2371 1862 113 2832 112 OAI21_X1
* cell instance $12461 r0 *1 224.96,56
X$12461 2141 2253 2714 113 2829 112 OAI21_X1
* cell instance $12462 m0 *1 225.15,56
X$12462 2591 2589 2590 112 2712 113 AOI21_X1
* cell instance $12465 m0 *1 226.1,56
X$12465 2591 2705 2144 112 2827 113 AOI21_X1
* cell instance $12467 m0 *1 227.62,56
X$12467 2498 2625 2704 113 112 2593 AND3_X1
* cell instance $12468 m0 *1 228.57,56
X$12468 2710 2587 112 113 2601 NOR2_X1
* cell instance $12470 m0 *1 229.9,56
X$12470 2704 2157 112 113 2822 NAND2_X1
* cell instance $12471 m0 *1 230.47,56
X$12471 2264 113 2588 112 BUF_X4
* cell instance $12472 m0 *1 231.8,56
X$12472 2707 112 113 2597 INV_X1
* cell instance $12473 m0 *1 232.18,56
X$12473 2587 1870 2588 112 2706 113 AOI21_X1
* cell instance $12474 m0 *1 232.94,56
X$12474 2705 113 2596 112 BUF_X4
* cell instance $12482 r0 *1 226.86,56
X$12482 2145 112 113 2720 CLKBUF_X3
* cell instance $12485 r0 *1 228.76,56
X$12485 2148 2264 112 113 2710 NOR2_X1
* cell instance $12486 r0 *1 229.33,56
X$12486 2710 2626 2822 112 113 2823 MUX2_X1
* cell instance $12488 r0 *1 231.04,56
X$12488 2626 113 2705 112 BUF_X4
* cell instance $12490 r0 *1 232.56,56
X$12490 2399 2818 2706 112 2934 113 AOI21_X1
* cell instance $12491 r0 *1 233.32,56
X$12491 2148 2382 112 113 2818 NAND2_X1
* cell instance $12502 m0 *1 223.25,126
X$12502 8789 7942 7448 112 113 8804 NAND3_X1
* cell instance $12503 m0 *1 224.2,126
X$12503 6878 8804 7448 8893 7680 112 113 OAI211_X2
* cell instance $12504 m0 *1 225.91,126
X$12504 6733 7448 8894 112 113 8592 NAND3_X1
* cell instance $12506 m0 *1 226.86,126
X$12506 8463 6733 112 113 8918 NOR2_X1
* cell instance $12507 m0 *1 227.43,126
X$12507 7325 8792 8679 113 8802 112 OAI21_X1
* cell instance $12509 m0 *1 228.38,126
X$12509 6831 8802 8793 113 8608 112 OAI21_X1
* cell instance $12512 r0 *1 223.25,126
X$12512 8891 7048 7838 113 8892 112 OAI21_X1
* cell instance $12513 r0 *1 224.01,126
X$12513 8892 8675 8918 112 7959 113 AOI21_X1
* cell instance $12515 r0 *1 224.96,126
X$12515 8791 6831 9125 112 113 8893 MUX2_X1
* cell instance $12517 r0 *1 227.81,126
X$12517 9012 112 113 8894 INV_X1
* cell instance $12519 r0 *1 228.57,126
X$12519 7838 8894 7048 112 8895 113 AOI21_X1
* cell instance $12521 r0 *1 229.52,126
X$12521 7048 8896 8895 113 8793 112 OAI21_X1
* cell instance $12522 r0 *1 230.28,126
X$12522 5425 7051 7095 113 8896 112 OAI21_X1
* cell instance $12523 m0 *1 230.47,126
X$12523 7563 112 113 7048 CLKBUF_X3
* cell instance $12525 m0 *1 231.42,126
X$12525 8796 112 113 9019 BUF_X1
* cell instance $12528 r0 *1 231.23,126
X$12528 6562 5564 16709 113 112 7944 HA_X1
* cell instance $12530 m0 *1 232.37,126
X$12530 8900 112 113 9123 BUF_X1
* cell instance $12532 r0 *1 233.13,126
X$12532 8897 112 113 8910 BUF_X1
* cell instance $12533 r0 *1 233.7,126
X$12533 8898 112 113 9016 BUF_X1
* cell instance $12534 m0 *1 234.27,126
X$12534 112 16858 8362 8908 8794 113 DFF_X1
* cell instance $12542 r0 *1 235.98,126
X$12542 112 17050 8904 8786 8794 113 DFF_X1
* cell instance $12543 m0 *1 238.07,126
X$12543 8899 112 113 8906 BUF_X1
* cell instance $12547 r0 *1 239.21,126
X$12547 8904 112 113 9014 BUF_X1
* cell instance $12551 m0 *1 140.98,240.8
X$12551 16402 112 113 13610 BUF_X1
* cell instance $12552 m0 *1 141.74,240.8
X$12552 16403 112 113 14491 BUF_X1
* cell instance $12553 m0 *1 142.31,240.8
X$12553 16363 112 113 16404 BUF_X1
* cell instance $12554 m0 *1 142.88,240.8
X$12554 16456 112 113 9609 CLKBUF_X2
* cell instance $12555 m0 *1 143.64,240.8
X$12555 16406 112 113 13612 BUF_X1
* cell instance $12556 m0 *1 144.21,240.8
X$12556 16427 112 113 14074 BUF_X1
* cell instance $12557 m0 *1 144.78,240.8
X$12557 16445 112 113 13323 BUF_X1
* cell instance $12558 m0 *1 145.35,240.8
X$12558 16385 112 113 16444 BUF_X1
* cell instance $12561 m0 *1 199.12,190.4
X$12561 13909 14030 14029 113 14073 112 OAI21_X1
* cell instance $12562 m0 *1 200.07,190.4
X$12562 14244 14145 13776 14034 14143 13862 113 112 AOI221_X2
* cell instance $12563 m0 *1 202.16,190.4
X$12563 14111 14033 14028 112 14112 113 AOI21_X1
* cell instance $12564 m0 *1 202.92,190.4
X$12564 14034 14112 14114 113 112 13781 AND3_X1
* cell instance $12565 m0 *1 203.87,190.4
X$12565 14202 13915 112 113 13970 NOR2_X2
* cell instance $12567 m0 *1 205.01,190.4
X$12567 13702 14038 112 113 14034 NOR2_X2
* cell instance $12568 m0 *1 205.96,190.4
X$12568 14116 14027 14033 112 113 14035 NAND3_X1
* cell instance $12570 m0 *1 206.91,190.4
X$12570 14037 14118 14034 13919 14113 113 112 14119 OAI221_X1
* cell instance $12571 m0 *1 208.05,190.4
X$12571 13984 14034 14120 112 14057 113 AOI21_X1
* cell instance $12573 m0 *1 210.33,190.4
X$12573 13909 13911 14037 112 14129 113 AOI21_X1
* cell instance $12576 m0 *1 213.37,190.4
X$12576 14038 112 113 14122 CLKBUF_X3
* cell instance $12577 m0 *1 214.32,190.4
X$12577 14128 14033 112 113 14041 NOR2_X1
* cell instance $12579 m0 *1 215.08,190.4
X$12579 14041 14123 13978 113 13917 112 OAI21_X1
* cell instance $12581 m0 *1 216.03,190.4
X$12581 14069 14129 14124 13922 13918 113 112 14042 OAI221_X1
* cell instance $12589 m0 *1 194.37,190.4
X$12589 13967 13836 13709 13835 14108 112 113 14255 AOI221_X1
* cell instance $12590 m0 *1 196.27,190.4
X$12590 14027 14028 14029 112 113 14110 NAND3_X1
* cell instance $12591 m0 *1 197.03,190.4
X$12591 14029 112 113 14033 CLKBUF_X3
* cell instance $12592 m0 *1 197.98,190.4
X$12592 14030 14198 13901 112 14144 113 AOI21_X1
* cell instance $12594 r0 *1 194.37,190.4
X$12594 14071 13770 13639 113 14256 112 OAI21_X1
* cell instance $12595 r0 *1 195.13,190.4
X$12595 14255 14109 14251 13776 112 113 13767 NOR4_X1
* cell instance $12596 r0 *1 196.08,190.4
X$12596 14197 14249 14110 112 14251 113 AOI21_X1
* cell instance $12597 r0 *1 196.84,190.4
X$12597 14076 14200 14245 13836 112 113 14249 AOI22_X1
* cell instance $12598 r0 *1 197.79,190.4
X$12598 112 14198 14200 14199 13836 13901 113 AOI22_X4
* cell instance $12599 r0 *1 201.02,190.4
X$12599 14199 14202 14144 113 112 14201 OAI21_X2
* cell instance $12600 r0 *1 202.35,190.4
X$12600 14070 14114 14073 112 14141 113 AOI21_X1
* cell instance $12601 r0 *1 203.11,190.4
X$12601 14028 14113 14069 112 113 13908 NAND3_X1
* cell instance $12602 r0 *1 203.87,190.4
X$12602 13970 14113 13911 14037 14203 113 112 14219 OAI221_X1
* cell instance $12603 r0 *1 205.01,190.4
X$12603 13966 13898 14115 112 113 14116 NAND3_X2
* cell instance $12604 r0 *1 206.34,190.4
X$12604 14434 14070 14117 112 113 14224 OR3_X2
* cell instance $12605 r0 *1 207.48,190.4
X$12605 14134 14120 14029 112 113 14117 NOR3_X1
* cell instance $12606 r0 *1 208.24,190.4
X$12606 14076 14206 112 113 14120 NOR2_X1
* cell instance $12607 r0 *1 208.81,190.4
X$12607 13716 14207 14224 14119 113 112 13923 AND4_X2
* cell instance $12608 r0 *1 210.14,190.4
X$12608 14057 14220 14221 112 113 14222 NAND3_X1
* cell instance $12609 r0 *1 210.9,190.4
X$12609 14121 13975 13978 113 14221 112 OAI21_X1
* cell instance $12610 r0 *1 211.66,190.4
X$12610 14033 14121 13975 113 14220 112 OAI21_X1
* cell instance $12611 r0 *1 212.42,190.4
X$12611 14122 13770 13979 113 14211 112 OAI21_X1
* cell instance $12613 r0 *1 213.37,190.4
X$12613 14214 14217 14219 113 13779 112 OAI21_X1
* cell instance $12614 r0 *1 214.13,190.4
X$12614 14209 13918 14122 113 14217 112 OAI21_X1
* cell instance $12617 r0 *1 215.46,190.4
X$12617 13837 13973 14116 113 14215 112 OAI21_X1
* cell instance $12618 r0 *1 216.22,190.4
X$12618 14122 112 113 14125 CLKBUF_X3
* cell instance $12619 r0 *1 217.17,190.4
X$12619 14042 13978 14211 112 14126 113 AOI21_X1
* cell instance $12630 r0 *1 114.57,11.2
X$12630 112 17031 181 137 150 113 DFF_X1
* cell instance $12631 r0 *1 118.37,11.2
X$12631 112 17041 140 139 150 113 DFF_X1
* cell instance $12635 m0 *1 10.26,109.2
X$12635 7387 112 113 3828 CLKBUF_X2
* cell instance $12645 m0 *1 15.01,109.2
X$12645 112 7215 7061 6908 7290 113 DFF_X2
* cell instance $12646 m0 *1 14.44,109.2
X$12646 7214 112 113 7388 BUF_X1
* cell instance $12649 r0 *1 15.2,109.2
X$12649 7389 6899 7388 112 113 7566 MUX2_X1
* cell instance $12652 r0 *1 18.24,109.2
X$12652 7567 6899 7060 112 113 7486 MUX2_X1
* cell instance $12653 m0 *1 19.19,109.2
X$12653 112 7291 7061 6907 7292 113 DFF_X2
* cell instance $12657 r0 *1 19.57,109.2
X$12657 6050 112 113 7061 CLKBUF_X3
* cell instance $12661 r0 *1 24.13,109.2
X$12661 7229 113 7487 112 BUF_X4
* cell instance $12662 m0 *1 26.03,109.2
X$12662 7229 6904 7003 113 112 7441 OAI21_X4
* cell instance $12663 m0 *1 24.7,109.2
X$12663 7295 113 7293 112 BUF_X4
* cell instance $12664 m0 *1 28.5,109.2
X$12664 7003 113 7296 112 BUF_X4
* cell instance $12666 m0 *1 30.02,109.2
X$12666 6901 6796 16569 113 112 7392 HA_X1
* cell instance $12667 m0 *1 31.92,109.2
X$12667 112 7216 7393 113 BUF_X16
* cell instance $12668 m0 *1 36.67,109.2
X$12668 7312 112 113 7443 INV_X1
* cell instance $12669 m0 *1 37.05,109.2
X$12669 112 7395 113 6962 BUF_X8
* cell instance $12671 r0 *1 25.46,109.2
X$12671 7002 6902 16686 113 112 7390 HA_X1
* cell instance $12672 r0 *1 27.36,109.2
X$12672 7390 113 7488 112 BUF_X4
* cell instance $12673 r0 *1 28.69,109.2
X$12673 7390 6904 7003 113 112 7402 OAI21_X4
* cell instance $12675 r0 *1 31.35,109.2
X$12675 7176 7443 7220 112 7442 113 AOI21_X1
* cell instance $12676 r0 *1 32.11,109.2
X$12676 7393 7222 7401 113 7494 112 OAI21_X1
* cell instance $12677 r0 *1 32.87,109.2
X$12677 7442 7224 7573 112 113 7575 MUX2_X1
* cell instance $12678 r0 *1 34.2,109.2
X$12678 7220 113 7222 112 BUF_X4
* cell instance $12679 r0 *1 35.53,109.2
X$12679 7394 7229 7392 112 113 6963 MUX2_X1
* cell instance $12680 r0 *1 36.86,109.2
X$12680 6962 112 113 7177 BUF_X1
* cell instance $12681 r0 *1 37.43,109.2
X$12681 7391 7296 7395 7312 113 112 7401 OAI22_X2
* cell instance $12682 r0 *1 39.14,109.2
X$12682 112 7496 7003 6904 7444 113 NOR3_X4
* cell instance $12683 m0 *1 41.23,109.2
X$12683 7299 7302 112 113 7308 OR2_X2
* cell instance $12684 m0 *1 39.9,109.2
X$12684 7008 7445 7006 112 113 7396 MUX2_X1
* cell instance $12685 m0 *1 42.18,109.2
X$12685 7219 7220 7125 112 7397 113 AOI21_X2
* cell instance $12686 m0 *1 43.51,109.2
X$12686 7303 7224 7307 112 113 7398 MUX2_X1
* cell instance $12687 m0 *1 44.84,109.2
X$12687 7226 6965 7399 113 7221 112 OAI21_X1
* cell instance $12688 m0 *1 45.6,109.2
X$12688 7218 7222 7126 112 7400 113 AOI21_X1
* cell instance $12689 m0 *1 46.36,109.2
X$12689 7225 7220 7401 113 7303 112 OAI21_X1
* cell instance $12691 m0 *1 47.31,109.2
X$12691 7179 7310 112 113 7223 NOR2_X2
* cell instance $12693 m0 *1 48.45,109.2
X$12693 7225 7128 6968 113 7450 112 OAI21_X1
* cell instance $12695 r0 *1 41.8,109.2
X$12695 112 7302 7293 7797 7642 113 AOI21_X4
* cell instance $12697 r0 *1 44.65,109.2
X$12697 7398 7497 7400 112 113 7584 MUX2_X1
* cell instance $12699 r0 *1 46.17,109.2
X$12699 7190 112 113 7225 INV_X4
* cell instance $12700 r0 *1 47.12,109.2
X$12700 7225 7487 6968 113 7586 112 OAI21_X1
* cell instance $12701 r0 *1 47.88,109.2
X$12701 7450 7180 7308 112 113 7587 MUX2_X1
* cell instance $12702 r0 *1 49.21,109.2
X$12702 7402 7399 112 113 7307 NAND2_X1
* cell instance $12704 m0 *1 49.59,109.2
X$12704 7229 7225 112 113 6966 NAND2_X2
* cell instance $12705 m0 *1 50.73,109.2
X$12705 112 7007 7004 7005 7228 113 NOR3_X4
* cell instance $12706 m0 *1 53.39,109.2
X$12706 7011 113 6965 112 BUF_X4
* cell instance $12707 m0 *1 54.72,109.2
X$12707 7179 113 7224 112 BUF_X4
* cell instance $12711 r0 *1 50.73,109.2
X$12711 7228 7443 7219 7224 7076 7638 113 112 AOI221_X2
* cell instance $12712 r0 *1 52.82,109.2
X$12712 7501 7402 112 113 7502 OR2_X1
* cell instance $12713 r0 *1 53.58,109.2
X$12713 7128 112 113 7445 CLKBUF_X3
* cell instance $12715 r0 *1 54.72,109.2
X$12715 7503 112 113 7501 CLKBUF_X3
* cell instance $12716 r0 *1 55.67,109.2
X$12716 7012 113 7496 112 BUF_X4
* cell instance $12717 m0 *1 56.62,109.2
X$12717 7404 113 7229 112 BUF_X4
* cell instance $12719 m0 *1 57.95,109.2
X$12719 7129 113 7315 112 BUF_X4
* cell instance $12721 m0 *1 59.47,109.2
X$12721 7007 113 7179 112 BUF_X4
* cell instance $12724 m0 *1 63.08,109.2
X$12724 112 16843 7317 3866 6855 113 DFF_X1
* cell instance $12725 m0 *1 66.31,109.2
X$12725 6384 112 113 5828 INV_X4
* cell instance $12727 r0 *1 57,109.2
X$12727 7403 7313 7402 113 7506 112 OAI21_X1
* cell instance $12728 r0 *1 57.76,109.2
X$12728 7404 112 113 7069 BUF_X1
* cell instance $12730 r0 *1 58.52,109.2
X$12730 7642 7007 7405 112 7710 113 NAND3_X4
* cell instance $12733 r0 *1 62.89,109.2
X$12733 7508 7406 112 7004 113 NAND2_X4
* cell instance $12734 r0 *1 64.6,109.2
X$12734 7509 5170 5955 112 113 7406 NAND3_X2
* cell instance $12736 r0 *1 66.12,109.2
X$12736 5170 5955 112 113 7727 NOR2_X1
* cell instance $12739 r0 *1 67.26,109.2
X$12739 7317 113 7407 112 BUF_X4
* cell instance $12740 m0 *1 68.21,109.2
X$12740 7014 6862 112 113 7319 NAND2_X1
* cell instance $12741 m0 *1 67.64,109.2
X$12741 7318 6862 112 113 7013 NOR2_X1
* cell instance $12742 m0 *1 68.78,109.2
X$12742 5250 4031 112 113 7318 NAND2_X1
* cell instance $12743 m0 *1 69.35,109.2
X$12743 6513 113 6075 112 BUF_X4
* cell instance $12744 m0 *1 70.68,109.2
X$12744 112 5528 113 7320 BUF_X8
* cell instance $12745 m0 *1 73.15,109.2
X$12745 112 6077 7231 7320 4634 113 NOR3_X4
* cell instance $12746 m0 *1 75.81,109.2
X$12746 112 5621 113 7231 BUF_X8
* cell instance $12747 m0 *1 78.28,109.2
X$12747 7234 7232 4732 112 113 NOR2_X4
* cell instance $12748 m0 *1 79.99,109.2
X$12748 4732 113 5090 112 BUF_X4
* cell instance $12749 m0 *1 81.32,109.2
X$12749 7234 7232 5714 113 6468 112 NOR3_X2
* cell instance $12750 m0 *1 82.65,109.2
X$12750 7323 112 113 6056 CLKBUF_X3
* cell instance $12752 m0 *1 83.79,109.2
X$12752 5714 7513 7459 113 112 4805 OAI21_X4
* cell instance $12753 m0 *1 86.26,109.2
X$12753 3575 7235 112 113 4643 XNOR2_X2
* cell instance $12755 m0 *1 88.92,109.2
X$12755 112 6138 5043 113 BUF_X16
* cell instance $12757 m0 *1 94.43,109.2
X$12757 6908 7516 7236 112 113 7464 NAND3_X1
* cell instance $12760 m0 *1 96.14,109.2
X$12760 7203 112 113 7236 INV_X1
* cell instance $12765 r0 *1 68.59,109.2
X$12765 112 16963 7454 3240 7732 113 DFF_X1
* cell instance $12766 r0 *1 71.82,109.2
X$12766 112 7598 113 7454 BUF_X8
* cell instance $12768 r0 *1 74.48,109.2
X$12768 3438 7511 112 113 7455 NAND2_X1
* cell instance $12769 r0 *1 75.05,109.2
X$12769 7510 4031 112 113 7601 NOR2_X1
* cell instance $12770 r0 *1 75.62,109.2
X$12770 7599 7455 7512 113 112 6514 MUX2_X2
* cell instance $12772 r0 *1 77.52,109.2
X$12772 7598 3575 113 5884 112 XOR2_X2
* cell instance $12774 r0 *1 79.61,109.2
X$12774 7232 7234 112 113 7323 OR2_X1
* cell instance $12775 r0 *1 80.37,109.2
X$12775 6673 7234 7232 112 113 5091 OR3_X4
* cell instance $12779 r0 *1 83.79,109.2
X$12779 7513 7459 6122 112 113 NOR2_X4
* cell instance $12780 r0 *1 85.5,109.2
X$12780 7460 6907 7515 113 112 7459 OAI21_X4
* cell instance $12782 r0 *1 88.35,109.2
X$12782 6907 5395 5103 112 113 7460 NAND3_X2
* cell instance $12786 r0 *1 91.01,109.2
X$12786 4161 4031 112 113 7599 NAND2_X1
* cell instance $12789 r0 *1 92.72,109.2
X$12789 112 6775 113 7518 BUF_X8
* cell instance $12790 r0 *1 95.19,109.2
X$12790 112 5250 4678 113 BUF_X16
* cell instance $12792 m0 *1 96.9,109.2
X$12792 112 161 7238 113 BUF_X32
* cell instance $12793 m0 *1 106.97,109.2
X$12793 7238 112 113 6395 INV_X8
* cell instance $12794 m0 *1 108.68,109.2
X$12794 7203 7238 112 113 7133 NOR2_X1
* cell instance $12796 r0 *1 99.94,109.2
X$12796 112 17052 7747 3329 7019 113 DFF_X1
* cell instance $12801 r0 *1 106.02,109.2
X$12801 7237 6395 112 113 7517 NAND2_X1
* cell instance $12802 r0 *1 106.59,109.2
X$12802 7469 6395 112 113 7608 NAND2_X1
* cell instance $12804 m0 *1 110.2,109.2
X$12804 6916 112 113 7241 INV_X1
* cell instance $12805 m0 *1 109.63,109.2
X$12805 6916 7239 112 113 7135 NOR2_X1
* cell instance $12806 m0 *1 110.58,109.2
X$12806 6916 7239 112 113 7472 NAND2_X1
* cell instance $12807 m0 *1 111.15,109.2
X$12807 6916 7245 7236 7244 112 113 7242 NOR4_X1
* cell instance $12809 m0 *1 112.29,109.2
X$12809 7241 7239 7236 7244 112 113 7243 NOR4_X1
* cell instance $12811 m0 *1 113.43,109.2
X$12811 7241 7021 113 112 7247 XNOR2_X1
* cell instance $12814 m0 *1 117.8,109.2
X$12814 7333 5854 112 113 7330 XNOR2_X2
* cell instance $12819 m0 *1 125.21,109.2
X$12819 7245 7247 113 112 7248 XNOR2_X1
* cell instance $12821 m0 *1 126.54,109.2
X$12821 112 16760 7480 7336 7335 113 DFF_X1
* cell instance $12823 m0 *1 129.96,109.2
X$12823 7249 4922 113 7337 112 XOR2_X2
* cell instance $12825 m0 *1 131.86,109.2
X$12825 5237 6532 113 7614 112 XOR2_X2
* cell instance $12829 r0 *1 110.77,109.2
X$12829 7238 7236 7021 7472 113 7240 112 OR4_X2
* cell instance $12832 r0 *1 112.67,109.2
X$12832 7473 7243 7021 113 7101 112 OAI21_X1
* cell instance $12833 r0 *1 113.43,109.2
X$12833 7472 7203 7244 112 113 7473 NOR3_X1
* cell instance $12835 r0 *1 115.71,109.2
X$12835 7407 7410 112 113 7333 XNOR2_X2
* cell instance $12836 r0 *1 117.61,109.2
X$12836 112 7409 7410 7474 6680 113 DFF_X1
* cell instance $12837 r0 *1 120.84,109.2
X$12837 4922 7410 112 113 7520 XOR2_X1
* cell instance $12840 r0 *1 123.69,109.2
X$12840 7754 112 113 4922 CLKBUF_X3
* cell instance $12844 r0 *1 124.64,109.2
X$12844 7477 4389 7247 112 113 7478 MUX2_X1
* cell instance $12845 r0 *1 125.97,109.2
X$12845 112 17005 7479 7478 7335 113 DFF_X1
* cell instance $12847 r0 *1 129.39,109.2
X$12847 7411 6919 112 113 7615 NAND2_X1
* cell instance $12849 r0 *1 130.15,109.2
X$12849 7479 113 7022 112 BUF_X4
* cell instance $12850 r0 *1 131.48,109.2
X$12850 7480 113 7239 112 BUF_X4
* cell instance $12851 r0 *1 132.81,109.2
X$12851 6107 7614 113 112 7521 XNOR2_X1
* cell instance $12853 m0 *1 133.95,109.2
X$12853 3375 6398 113 112 7250 XNOR2_X1
* cell instance $12855 r0 *1 133.95,109.2
X$12855 6107 7614 112 113 7613 XOR2_X1
* cell instance $12856 r0 *1 135.09,109.2
X$12856 112 4320 113 3873 BUF_X8
* cell instance $12858 m0 *1 136.23,109.2
X$12858 3375 6990 113 112 7612 XNOR2_X1
* cell instance $12861 m0 *1 141.36,109.2
X$12861 6924 6367 112 113 7412 NOR2_X1
* cell instance $12863 r0 *1 137.56,109.2
X$12863 112 16950 7765 7611 5919 113 DFF_X1
* cell instance $12864 r0 *1 140.79,109.2
X$12864 5913 7484 7609 7610 7412 7413 112 113 7341 OAI33_X1
* cell instance $12865 r0 *1 142.12,109.2
X$12865 6196 5913 112 113 7413 NAND2_X1
* cell instance $12866 m0 *1 143.07,109.2
X$12866 7344 7343 7252 7346 113 7338 112 NOR4_X2
* cell instance $12867 m0 *1 142.31,109.2
X$12867 7341 7251 7342 113 7343 112 OAI21_X1
* cell instance $12868 m0 *1 144.78,109.2
X$12868 7415 7348 6406 112 113 7485 NOR3_X1
* cell instance $12870 m0 *1 145.73,109.2
X$12870 7254 6536 6260 112 113 7347 NAND3_X1
* cell instance $12871 m0 *1 146.49,109.2
X$12871 6691 7253 6260 113 7353 112 OAI21_X1
* cell instance $12874 r0 *1 143.07,109.2
X$12874 7414 5982 112 113 7610 NOR2_X1
* cell instance $12876 r0 *1 143.83,109.2
X$12876 7485 7525 6257 113 6810 112 OAI21_X1
* cell instance $12878 r0 *1 144.78,109.2
X$12878 6811 7416 7414 113 112 6101 OAI21_X2
* cell instance $12880 r0 *1 146.3,109.2
X$12880 7416 7417 6254 112 113 7484 NOR3_X1
* cell instance $12882 r0 *1 147.25,109.2
X$12882 7527 7418 6548 112 113 7483 NOR3_X1
* cell instance $12883 m0 *1 147.82,109.2
X$12883 6260 6812 5985 112 7418 113 AOI21_X1
* cell instance $12885 m0 *1 148.58,109.2
X$12885 5988 5851 112 113 7141 NOR2_X2
* cell instance $12888 r0 *1 148.39,109.2
X$12888 7526 7483 7607 112 7482 113 AOI21_X1
* cell instance $12890 r0 *1 149.53,109.2
X$12890 7527 6701 6074 6205 7255 112 113 7481 AOI221_X1
* cell instance $12892 m0 *1 149.91,109.2
X$12892 5982 7254 6402 7528 112 113 6483 AOI22_X1
* cell instance $12894 r0 *1 150.86,109.2
X$12894 6257 7419 7481 113 7529 112 OAI21_X1
* cell instance $12896 m0 *1 151.24,109.2
X$12896 7255 6255 6256 112 7419 113 AOI21_X1
* cell instance $12897 m0 *1 152.19,109.2
X$12897 7420 7353 5846 6094 112 113 7356 NAND4_X1
* cell instance $12899 r0 *1 151.62,109.2
X$12899 6485 7530 112 113 7527 NOR2_X1
* cell instance $12900 r0 *1 152.19,109.2
X$12900 7115 6349 112 113 7417 NOR2_X1
* cell instance $12901 r0 *1 152.76,109.2
X$12901 6929 6349 112 113 7420 NAND2_X1
* cell instance $12904 m0 *1 153.52,109.2
X$12904 6202 7109 7416 7255 7530 7359 113 112 AOI221_X2
* cell instance $12906 m0 *1 156.56,109.2
X$12906 6929 6159 7255 112 7143 113 AOI21_X1
* cell instance $12907 m0 *1 157.32,109.2
X$12907 6148 112 113 7421 INV_X1
* cell instance $12910 r0 *1 153.52,109.2
X$12910 6658 6932 7115 112 7783 113 AOI21_X1
* cell instance $12913 r0 *1 156.56,109.2
X$12913 7533 7421 7109 7470 6793 6476 113 112 AOI221_X2
* cell instance $12915 m0 *1 159.03,109.2
X$12915 6094 5848 112 113 7422 NOR2_X1
* cell instance $12917 m0 *1 159.6,109.2
X$12917 112 8173 6256 113 BUF_X16
* cell instance $12918 m0 *1 164.35,109.2
X$12918 7117 6811 6159 113 7378 112 OAI21_X1
* cell instance $12919 m0 *1 165.11,109.2
X$12919 7119 7109 7470 112 113 7261 MUX2_X1
* cell instance $12920 m0 *1 166.44,109.2
X$12920 5846 7200 7379 113 7382 112 OAI21_X1
* cell instance $12922 r0 *1 159.41,109.2
X$12922 7533 7470 112 113 7028 NAND2_X1
* cell instance $12923 r0 *1 159.98,109.2
X$12923 7603 7789 7476 7602 5915 113 112 AOI211_X2
* cell instance $12925 r0 *1 162.07,109.2
X$12925 6081 7030 7255 112 7475 113 AOI21_X1
* cell instance $12926 r0 *1 162.83,109.2
X$12926 5851 7373 7422 112 7476 113 AOI21_X1
* cell instance $12927 r0 *1 163.59,109.2
X$12927 6781 7475 6101 112 7423 113 AOI21_X1
* cell instance $12928 r0 *1 164.35,109.2
X$12928 7533 7470 112 113 7117 NOR2_X1
* cell instance $12929 r0 *1 164.92,109.2
X$12929 7423 7468 6094 7471 112 113 7595 AOI22_X1
* cell instance $12930 r0 *1 165.87,109.2
X$12930 112 7593 6064 113 BUF_X16
* cell instance $12931 m0 *1 167.77,109.2
X$12931 7666 5848 7595 112 113 6549 MUX2_X1
* cell instance $12933 m0 *1 169.1,109.2
X$12933 7385 7386 6406 112 113 7381 NAND3_X1
* cell instance $12934 m0 *1 169.86,109.2
X$12934 5982 6255 7384 113 112 7262 HA_X1
* cell instance $12935 m0 *1 171.76,109.2
X$12935 7467 6924 6701 113 7149 112 OAI21_X1
* cell instance $12936 m0 *1 172.52,109.2
X$12936 7384 6537 113 112 7466 AND2_X1
* cell instance $12939 m0 *1 174.99,109.2
X$12939 7264 7212 7245 112 113 7383 NAND3_X1
* cell instance $12940 m0 *1 175.75,109.2
X$12940 7383 7264 7263 113 112 7377 OAI21_X2
* cell instance $12942 r0 *1 170.62,109.2
X$12942 7535 7466 6195 113 7468 112 OAI21_X1
* cell instance $12943 r0 *1 171.38,109.2
X$12943 7149 6142 7536 112 7594 113 AOI21_X1
* cell instance $12945 m0 *1 177.65,109.2
X$12945 112 7265 7267 7377 7268 113 NOR3_X4
* cell instance $12947 m0 *1 180.31,109.2
X$12947 112 2921 113 7268 BUF_X8
* cell instance $12948 m0 *1 182.78,109.2
X$12948 6186 7369 113 7590 112 XOR2_X2
* cell instance $12950 m0 *1 184.68,109.2
X$12950 5792 7270 113 7424 112 XOR2_X2
* cell instance $12951 m0 *1 186.39,109.2
X$12951 6944 7461 112 113 7364 XOR2_X1
* cell instance $12952 m0 *1 187.53,109.2
X$12952 7361 7366 112 113 7272 XNOR2_X2
* cell instance $12953 m0 *1 189.43,109.2
X$12953 7364 6940 113 112 7361 XNOR2_X1
* cell instance $12955 m0 *1 190.76,109.2
X$12955 5399 7039 112 113 7355 NAND2_X1
* cell instance $12956 m0 *1 191.33,109.2
X$12956 7154 7355 7425 113 7153 112 OAI21_X1
* cell instance $12957 m0 *1 192.09,109.2
X$12957 7040 6945 112 113 7358 NAND2_X1
* cell instance $12958 m0 *1 192.66,109.2
X$12958 7039 112 113 7155 BUF_X1
* cell instance $12959 m0 *1 193.23,109.2
X$12959 112 7264 7271 7351 6705 113 DFF_X1
* cell instance $12960 m0 *1 196.46,109.2
X$12960 7271 3947 7294 112 113 7351 MUX2_X1
* cell instance $12967 r0 *1 180.5,109.2
X$12967 7376 113 7465 112 BUF_X4
* cell instance $12968 r0 *1 181.83,109.2
X$12968 7465 112 113 7367 BUF_X2
* cell instance $12969 r0 *1 182.59,109.2
X$12969 6186 6164 112 113 7591 XNOR2_X2
* cell instance $12970 r0 *1 184.49,109.2
X$12970 7424 7462 113 7463 112 XOR2_X2
* cell instance $12972 r0 *1 186.58,109.2
X$12972 5761 7539 113 6177 112 XOR2_X2
* cell instance $12973 r0 *1 188.29,109.2
X$12973 7461 112 113 7462 BUF_X1
* cell instance $12976 r0 *1 189.43,109.2
X$12976 7156 112 113 7541 INV_X1
* cell instance $12978 r0 *1 190.19,109.2
X$12978 5179 7156 112 113 7542 NAND2_X1
* cell instance $12980 r0 *1 191.14,109.2
X$12980 7154 7516 7589 112 113 7425 NAND3_X1
* cell instance $12981 r0 *1 191.9,109.2
X$12981 7039 112 113 7589 INV_X1
* cell instance $12984 r0 *1 193.99,109.2
X$12984 7543 113 6940 112 BUF_X4
* cell instance $12986 m0 *1 198.36,109.2
X$12986 5250 6946 112 113 7457 NOR2_X1
* cell instance $12988 m0 *1 198.93,109.2
X$12988 3465 6946 112 113 7350 NAND2_X1
* cell instance $12989 m0 *1 199.5,109.2
X$12989 7158 7350 7272 113 112 7273 MUX2_X2
* cell instance $12990 m0 *1 201.21,109.2
X$12990 7426 112 113 6946 INV_X1
* cell instance $12993 m0 *1 202.54,109.2
X$12993 112 7340 7160 7273 7045 113 AOI21_X4
* cell instance $12995 m0 *1 205.2,109.2
X$12995 7045 112 113 7427 INV_X1
* cell instance $12998 r0 *1 198.36,109.2
X$12998 7100 112 113 7545 BUF_X1
* cell instance $12999 r0 *1 198.93,109.2
X$12999 5250 7545 112 113 7456 NOR2_X1
* cell instance $13000 r0 *1 199.5,109.2
X$13000 7457 7456 7272 113 112 7546 MUX2_X2
* cell instance $13003 r0 *1 202.35,109.2
X$13003 7546 7427 7547 112 113 NOR2_X4
* cell instance $13004 r0 *1 204.06,109.2
X$13004 7426 113 7100 112 BUF_X4
* cell instance $13005 r0 *1 205.39,109.2
X$13005 5661 7546 7427 113 112 7452 OAI21_X2
* cell instance $13007 m0 *1 207.86,109.2
X$13007 6001 5569 112 113 7428 NAND2_X1
* cell instance $13008 m0 *1 206.72,109.2
X$13008 7339 7453 7428 6745 7046 112 113 7328 AOI221_X1
* cell instance $13010 m0 *1 208.62,109.2
X$13010 7429 7275 5569 7430 7331 6947 113 112 AOI221_X2
* cell instance $13011 m0 *1 210.71,109.2
X$13011 5867 5661 112 113 7170 NAND2_X2
* cell instance $13014 r0 *1 208.24,109.2
X$13014 6278 7452 112 113 7453 OR2_X1
* cell instance $13015 r0 *1 209,109.2
X$13015 7548 112 113 7429 INV_X1
* cell instance $13017 r0 *1 209.57,109.2
X$13017 6564 6002 5767 5565 6175 7430 112 113 OAI221_X2
* cell instance $13018 r0 *1 211.66,109.2
X$13018 6280 6002 6426 5864 112 113 7549 AOI22_X1
* cell instance $13020 m0 *1 214.89,109.2
X$13020 7052 7184 7328 112 113 7451 OR3_X1
* cell instance $13021 m0 *1 212.8,109.2
X$13021 5864 6852 7431 6167 6750 7331 113 112 AOI221_X2
* cell instance $13022 m0 *1 215.84,109.2
X$13022 7165 7449 6829 7327 113 112 7432 OAI22_X1
* cell instance $13024 m0 *1 217.55,109.2
X$13024 6838 6429 5872 112 113 7326 MUX2_X1
* cell instance $13025 m0 *1 218.88,109.2
X$13025 7161 113 6557 112 BUF_X4
* cell instance $13026 m0 *1 220.21,109.2
X$13026 6718 7325 7326 112 7449 113 AOI21_X1
* cell instance $13028 m0 *1 221.16,109.2
X$13028 7446 6560 7070 7277 112 113 7322 AOI22_X1
* cell instance $13029 m0 *1 222.11,109.2
X$13029 7169 5869 7278 113 7277 112 OAI21_X1
* cell instance $13030 m0 *1 222.87,109.2
X$13030 5867 5661 112 113 7280 NOR2_X2
* cell instance $13031 m0 *1 223.82,109.2
X$13031 7070 7314 6723 6836 112 113 7279 AOI22_X1
* cell instance $13032 m0 *1 224.77,109.2
X$13032 5877 5425 7280 112 7316 113 AOI21_X1
* cell instance $13036 m0 *1 228,109.2
X$13036 7169 7053 7309 6838 6717 113 112 8094 OAI221_X1
* cell instance $13037 m0 *1 229.14,109.2
X$13037 5864 5769 112 113 7309 NAND2_X1
* cell instance $13039 m0 *1 229.9,109.2
X$13039 7297 7435 112 113 7054 NOR2_X1
* cell instance $13040 m0 *1 230.47,109.2
X$13040 5662 7053 5869 6750 113 112 7282 OAI22_X2
* cell instance $13041 m0 *1 232.18,109.2
X$13041 6293 6717 5869 113 7438 112 OAI21_X1
* cell instance $13043 m0 *1 233.13,109.2
X$13043 6293 7283 6436 112 7439 113 AOI21_X1
* cell instance $13044 m0 *1 233.89,109.2
X$13044 6293 6733 5895 113 7285 112 OAI21_X1
* cell instance $13047 r0 *1 214.51,109.2
X$13047 6175 5565 5770 112 7551 113 AOI21_X1
* cell instance $13049 r0 *1 215.65,109.2
X$13049 6026 6328 6745 112 7730 113 AOI21_X2
* cell instance $13050 r0 *1 216.98,109.2
X$13050 7432 7451 112 113 7579 OR2_X1
* cell instance $13051 r0 *1 217.74,109.2
X$13051 5770 7452 112 113 7433 OR2_X1
* cell instance $13052 r0 *1 218.5,109.2
X$13052 5662 6434 6032 113 7581 112 OAI21_X1
* cell instance $13053 r0 *1 219.26,109.2
X$13053 6001 5198 112 113 7434 NAND2_X1
* cell instance $13055 r0 *1 220.02,109.2
X$13055 7434 6005 5878 6838 7276 112 113 7447 AOI221_X1
* cell instance $13056 r0 *1 221.16,109.2
X$13056 6723 6425 112 113 7553 NOR2_X1
* cell instance $13057 r0 *1 221.73,109.2
X$13057 7447 7580 7553 6434 6831 113 112 7554 OAI221_X1
* cell instance $13058 r0 *1 222.87,109.2
X$13058 7279 7554 6834 112 113 7555 NAND3_X1
* cell instance $13059 r0 *1 223.63,109.2
X$13059 6720 6005 5872 112 7578 113 AOI21_X1
* cell instance $13060 r0 *1 224.39,109.2
X$13060 6743 7431 6720 112 113 7577 NOR3_X1
* cell instance $13062 r0 *1 225.53,109.2
X$13062 6023 5662 6005 112 6865 113 AOI21_X1
* cell instance $13063 r0 *1 226.29,109.2
X$13063 5871 5872 5770 112 7712 113 AOI21_X1
* cell instance $13065 r0 *1 227.43,109.2
X$13065 7281 7052 6432 112 113 7686 NOR3_X1
* cell instance $13067 r0 *1 228.38,109.2
X$13067 5878 7574 7309 7095 7563 113 112 7055 OAI221_X1
* cell instance $13069 r0 *1 229.9,109.2
X$13069 7557 6573 7435 6432 7282 7570 113 112 AOI221_X2
* cell instance $13072 r0 *1 232.56,109.2
X$13072 7165 6028 7440 112 7560 113 AOI21_X1
* cell instance $13073 r0 *1 233.32,109.2
X$13073 7437 7436 112 113 6848 NOR2_X1
* cell instance $13074 r0 *1 233.89,109.2
X$13074 5425 7438 7562 7285 7325 112 113 7437 AOI221_X1
* cell instance $13075 r0 *1 235.03,109.2
X$13075 5770 113 7563 112 BUF_X4
* cell instance $13076 m0 *1 235.22,109.2
X$13076 7288 112 113 7294 BUF_X1
* cell instance $13082 m0 *1 236.36,109.2
X$13082 7289 112 113 7213 CLKBUF_X2
* cell instance $13089 r0 *1 238.07,109.2
X$13089 7565 112 113 7477 CLKBUF_X2
* cell instance $13090 r0 *1 238.83,109.2
X$13090 7564 112 113 7151 BUF_X1
* cell instance $13092 m0 *1 13.11,112
X$13092 7617 112 113 6608 CLKBUF_X2
* cell instance $13095 m0 *1 14.63,112
X$13095 112 7566 7061 17213 7389 113 DFF_X2
* cell instance $13098 r0 *1 13.11,112
X$13098 7695 112 113 7618 BUF_X1
* cell instance $13102 r0 *1 17.29,112
X$13102 112 17100 7695 6856 7061 113 DFF_X1
* cell instance $13104 m0 *1 18.62,112
X$13104 112 7486 7061 6857 7567 113 DFF_X2
* cell instance $13107 m0 *1 24.7,112
X$13107 7697 224 112 113 7568 NOR2_X1
* cell instance $13108 m0 *1 25.27,112
X$13108 112 7698 7003 6904 7620 113 NOR3_X4
* cell instance $13109 m0 *1 27.93,112
X$13109 112 7009 7003 6904 7701 113 NOR3_X4
* cell instance $13113 r0 *1 23.75,112
X$13113 7390 112 113 7300 INV_X2
* cell instance $13114 r0 *1 24.32,112
X$13114 7305 7636 112 113 7571 NOR2_X1
* cell instance $13115 r0 *1 24.89,112
X$13115 112 7305 7009 7635 7619 113 AOI21_X4
* cell instance $13117 r0 *1 27.74,112
X$13117 6853 6965 7625 113 7573 112 OAI21_X1
* cell instance $13118 r0 *1 28.5,112
X$13118 7487 113 7636 112 BUF_X4
* cell instance $13119 r0 *1 29.83,112
X$13119 7392 113 7793 112 BUF_X4
* cell instance $13120 m0 *1 33.06,112
X$13120 7575 7572 7491 112 113 7794 MUX2_X1
* cell instance $13121 m0 *1 30.97,112
X$13121 7571 7621 7489 112 113 7490 OR3_X4
* cell instance $13122 m0 *1 34.39,112
X$13122 7493 7703 112 113 7624 NAND2_X1
* cell instance $13123 m0 *1 34.96,112
X$13123 7623 7494 7846 113 7576 112 OAI21_X1
* cell instance $13124 m0 *1 35.72,112
X$13124 7073 7487 7704 112 113 7626 MUX2_X1
* cell instance $13126 m0 *1 37.24,112
X$13126 7007 6904 7003 113 112 7495 OAI21_X4
* cell instance $13127 m0 *1 39.71,112
X$13127 7620 7706 7445 112 7629 113 AOI21_X1
* cell instance $13128 m0 *1 40.47,112
X$13128 7218 7127 7128 112 7704 113 AOI21_X1
* cell instance $13129 m0 *1 41.23,112
X$13129 112 7632 113 7708 BUF_X8
* cell instance $13130 m0 *1 43.7,112
X$13130 7229 7009 112 113 7582 NAND2_X2
* cell instance $13131 m0 *1 44.65,112
X$13131 7635 7619 7008 112 113 7399 NAND3_X1
* cell instance $13132 m0 *1 45.41,112
X$13132 7225 7710 7441 6967 113 112 7583 OAI22_X2
* cell instance $13133 m0 *1 47.12,112
X$13133 7583 7503 7300 7586 7713 113 112 AOI211_X2
* cell instance $13135 m0 *1 49.02,112
X$13135 7503 7065 7217 112 7716 113 AOI21_X1
* cell instance $13136 m0 *1 49.78,112
X$13136 7715 7716 7497 7587 7501 7718 113 112 AOI221_X2
* cell instance $13137 m0 *1 51.87,112
X$13137 6798 7501 7312 112 113 7639 NAND3_X1
* cell instance $13138 m0 *1 52.63,112
X$13138 6798 7501 7403 7640 112 113 7720 NAND4_X1
* cell instance $13139 m0 *1 53.58,112
X$13139 7717 7502 7720 7641 112 113 7500 NAND4_X1
* cell instance $13141 r0 *1 31.16,112
X$13141 7229 113 7622 112 BUF_X4
* cell instance $13142 r0 *1 32.49,112
X$13142 7392 113 7698 112 BUF_X4
* cell instance $13143 r0 *1 33.82,112
X$13143 7402 7622 7795 112 113 7489 AND3_X4
* cell instance $13144 r0 *1 35.91,112
X$13144 7492 7071 7621 7628 7626 7627 113 112 AOI221_X2
* cell instance $13145 r0 *1 38,112
X$13145 7392 112 113 7800 INV_X4
* cell instance $13147 r0 *1 39.14,112
X$13147 7065 7220 7402 113 7960 112 OAI21_X1
* cell instance $13148 r0 *1 39.9,112
X$13148 7300 7495 7628 7707 7629 113 112 7631 OAI221_X1
* cell instance $13149 r0 *1 41.04,112
X$13149 7630 7396 7631 113 7798 112 OAI21_X1
* cell instance $13150 r0 *1 41.8,112
X$13150 112 7633 113 7642 BUF_X8
* cell instance $13151 r0 *1 44.27,112
X$13151 7179 7625 7709 112 7634 113 AOI21_X1
* cell instance $13152 r0 *1 45.03,112
X$13152 7636 7221 7499 7637 112 113 7850 AOI22_X2
* cell instance $13153 r0 *1 46.74,112
X$13153 7305 7503 112 113 7719 NAND2_X1
* cell instance $13158 r0 *1 50.16,112
X$13158 7501 7622 7588 113 7717 112 OAI21_X1
* cell instance $13159 r0 *1 50.92,112
X$13159 7403 7501 7719 113 7851 112 OAI21_X1
* cell instance $13160 r0 *1 51.68,112
X$13160 7500 7721 7638 7713 113 112 7852 OAI22_X1
* cell instance $13161 r0 *1 52.63,112
X$13161 7065 112 113 7640 INV_X1
* cell instance $13162 r0 *1 53.01,112
X$13162 7707 7639 7890 112 7721 113 AOI21_X1
* cell instance $13163 r0 *1 53.77,112
X$13163 112 7072 7800 7708 7642 113 AOI21_X4
* cell instance $13164 m0 *1 55.67,112
X$13164 7636 7504 7582 113 7505 112 OAI21_X1
* cell instance $13165 m0 *1 54.91,112
X$13165 7226 6965 6969 113 7504 112 OAI21_X1
* cell instance $13167 m0 *1 56.62,112
X$13167 7179 113 7403 112 BUF_X4
* cell instance $13168 m0 *1 57.95,112
X$13168 112 6853 113 7012 BUF_X8
* cell instance $13169 m0 *1 60.42,112
X$13169 7507 7007 6910 112 113 7977 MUX2_X1
* cell instance $13170 m0 *1 61.75,112
X$13170 7724 113 7642 112 BUF_X4
* cell instance $13171 m0 *1 63.08,112
X$13171 7406 7508 113 112 7724 AND2_X1
* cell instance $13172 m0 *1 63.84,112
X$13172 5955 7509 112 113 7508 OR2_X1
* cell instance $13173 m0 *1 64.6,112
X$13173 5955 7509 113 112 7726 AND2_X1
* cell instance $13175 r0 *1 56.24,112
X$13175 7505 7628 7506 112 113 7801 MUX2_X1
* cell instance $13177 r0 *1 57.76,112
X$13177 7129 113 7588 112 BUF_X4
* cell instance $13178 r0 *1 59.09,112
X$13178 112 7499 7859 7708 7642 113 AOI21_X4
* cell instance $13180 r0 *1 61.94,112
X$13180 7643 112 113 7708 BUF_X2
* cell instance $13181 r0 *1 62.7,112
X$13181 7643 7642 112 113 7803 NAND2_X1
* cell instance $13183 r0 *1 64.03,112
X$13183 6855 112 113 17176 INV_X2
* cell instance $13184 r0 *1 64.6,112
X$13184 6050 112 113 6855 CLKBUF_X3
* cell instance $13185 r0 *1 65.55,112
X$13185 7509 5955 112 113 7644 NAND2_X1
* cell instance $13186 m0 *1 65.93,112
X$13186 7726 7727 7597 113 112 7005 MUX2_X2
* cell instance $13192 r0 *1 66.12,112
X$13192 7644 7731 7597 113 112 7643 MUX2_X2
* cell instance $13193 r0 *1 67.83,112
X$13193 7645 5955 113 6856 112 XOR2_X2
* cell instance $13199 r0 *1 70.11,112
X$13199 5955 2861 112 113 7731 OR2_X1
* cell instance $13202 r0 *1 71.82,112
X$13202 6960 3672 3363 112 113 7733 NAND3_X1
* cell instance $13203 r0 *1 72.58,112
X$13203 7733 6960 7804 113 112 7647 OAI21_X2
* cell instance $13205 m0 *1 73.34,112
X$13205 6077 112 113 7085 INV_X4
* cell instance $13206 m0 *1 74.48,112
X$13206 7510 7511 112 113 7600 NOR2_X1
* cell instance $13207 m0 *1 75.05,112
X$13207 4031 112 113 7511 INV_X1
* cell instance $13209 m0 *1 75.62,112
X$13209 7600 7601 7512 113 112 7231 MUX2_X2
* cell instance $13211 m0 *1 78.09,112
X$13211 3572 112 113 7734 INV_X1
* cell instance $13212 m0 *1 78.47,112
X$13212 7648 3572 112 113 7649 NOR2_X1
* cell instance $13214 m0 *1 79.23,112
X$13214 7736 7389 7737 113 112 7234 OAI21_X4
* cell instance $13216 m0 *1 83.22,112
X$13216 7514 112 113 7513 BUF_X1
* cell instance $13217 m0 *1 83.79,112
X$13217 7514 7459 5096 112 113 NOR2_X4
* cell instance $13218 m0 *1 85.5,112
X$13218 6384 7514 7459 113 112 6126 OAI21_X2
* cell instance $13219 m0 *1 86.83,112
X$13219 5250 7651 112 113 7515 NAND2_X1
* cell instance $13224 r0 *1 76.19,112
X$13224 7806 7646 7647 112 113 6673 OR3_X2
* cell instance $13225 r0 *1 77.33,112
X$13225 7648 7734 112 113 7807 NOR2_X1
* cell instance $13226 r0 *1 77.9,112
X$13226 7807 7649 8123 113 112 7232 MUX2_X2
* cell instance $13227 r0 *1 79.61,112
X$13227 7389 7738 7734 112 113 7736 NAND3_X2
* cell instance $13230 r0 *1 81.51,112
X$13230 7984 7739 113 6014 112 XOR2_X2
* cell instance $13231 r0 *1 83.22,112
X$13231 6516 112 113 7739 BUF_X1
* cell instance $13232 r0 *1 83.79,112
X$13232 3527 6516 112 113 7808 NAND2_X1
* cell instance $13234 r0 *1 84.55,112
X$13234 7740 7742 8406 113 112 7514 MUX2_X2
* cell instance $13235 r0 *1 86.26,112
X$13235 7650 5103 112 113 7742 NOR2_X1
* cell instance $13236 r0 *1 86.83,112
X$13236 7650 7651 112 113 7740 NOR2_X1
* cell instance $13237 r0 *1 87.4,112
X$13237 5103 112 113 7651 INV_X1
* cell instance $13239 r0 *1 87.97,112
X$13239 112 7811 7743 7606 7652 113 NOR3_X4
* cell instance $13241 m0 *1 89.3,112
X$13241 3882 3572 112 113 7737 NAND2_X1
* cell instance $13243 r0 *1 90.63,112
X$13243 112 6384 113 7652 BUF_X8
* cell instance $13245 m0 *1 94.62,112
X$13245 6775 113 3571 112 BUF_X4
* cell instance $13246 m0 *1 93.29,112
X$13246 7464 6908 7744 113 112 7606 OAI21_X2
* cell instance $13247 m0 *1 95.95,112
X$13247 112 3635 113 5043 BUF_X8
* cell instance $13248 m0 *1 98.42,112
X$13248 112 5231 113 6773 BUF_X8
* cell instance $13250 m0 *1 101.08,112
X$13250 3460 3646 113 7868 112 XOR2_X2
* cell instance $13254 m0 *1 105.26,112
X$13254 7608 7517 7653 113 112 7654 MUX2_X2
* cell instance $13255 m0 *1 106.97,112
X$13255 112 7751 113 7747 BUF_X8
* cell instance $13256 m0 *1 109.44,112
X$13256 5399 7203 112 113 7744 NAND2_X1
* cell instance $13259 r0 *1 93.29,112
X$13259 5708 7814 113 112 7988 AND2_X1
* cell instance $13260 r0 *1 94.05,112
X$13260 112 3882 113 5395 BUF_X8
* cell instance $13261 r0 *1 96.52,112
X$13261 112 16942 7992 7745 7019 113 DFF_X1
* cell instance $13263 r0 *1 100.51,112
X$13263 3646 3460 112 113 7816 XNOR2_X2
* cell instance $13267 r0 *1 106.02,112
X$13267 7237 7750 112 113 7818 NOR2_X1
* cell instance $13270 r0 *1 107.16,112
X$13270 7469 7750 112 113 7995 NOR2_X1
* cell instance $13271 r0 *1 107.73,112
X$13271 7869 7469 112 113 4814 XNOR2_X2
* cell instance $13272 r0 *1 109.63,112
X$13272 112 7751 7518 113 BUF_X16
* cell instance $13273 m0 *1 111.34,112
X$13273 112 7238 7244 113 BUF_X16
* cell instance $13275 m0 *1 116.09,112
X$13275 112 5401 113 7518 BUF_X8
* cell instance $13276 m0 *1 118.56,112
X$13276 7519 7656 7820 113 112 6740 MUX2_X2
* cell instance $13280 r0 *1 117.61,112
X$13280 7655 7408 112 113 7871 NOR2_X1
* cell instance $13281 r0 *1 118.18,112
X$13281 7655 6509 112 113 7656 NAND2_X1
* cell instance $13282 r0 *1 118.75,112
X$13282 7906 5993 112 113 7820 XNOR2_X2
* cell instance $13284 m0 *1 121.98,112
X$13284 112 16852 7754 7616 7335 113 DFF_X1
* cell instance $13285 m0 *1 120.65,112
X$13285 7753 4209 7520 112 113 7616 MUX2_X1
* cell instance $13287 m0 *1 126.73,112
X$13287 5399 7658 112 113 7411 NOR2_X1
* cell instance $13288 m0 *1 127.3,112
X$13288 112 5637 7516 113 BUF_X16
* cell instance $13290 m0 *1 132.24,112
X$13290 7140 5231 7658 112 113 7522 NAND3_X1
* cell instance $13291 m0 *1 133,112
X$13291 7521 7522 7615 112 7761 113 AOI21_X2
* cell instance $13292 m0 *1 134.33,112
X$13292 112 2763 113 7763 BUF_X8
* cell instance $13293 m0 *1 136.8,112
X$13293 7765 112 113 5237 CLKBUF_X3
* cell instance $13298 r0 *1 121.98,112
X$13298 6983 113 4209 112 BUF_X4
* cell instance $13299 r0 *1 123.31,112
X$13299 6983 113 5708 112 BUF_X4
* cell instance $13304 r0 *1 125.4,112
X$13304 2809 7821 113 112 7657 XNOR2_X1
* cell instance $13305 r0 *1 126.54,112
X$13305 7335 112 113 16474 CLKBUF_X1
* cell instance $13307 r0 *1 128.63,112
X$13307 6983 113 6211 112 BUF_X4
* cell instance $13310 r0 *1 130.34,112
X$13310 7411 7140 112 113 7758 NAND2_X1
* cell instance $13311 r0 *1 130.91,112
X$13311 6919 3635 7658 112 113 7759 NAND3_X1
* cell instance $13312 r0 *1 131.67,112
X$13312 7613 7758 7759 112 7875 113 AOI21_X2
* cell instance $13314 r0 *1 133.38,112
X$13314 112 7822 7761 7875 7763 113 NOR3_X4
* cell instance $13316 r0 *1 136.8,112
X$13316 112 3874 3937 113 BUF_X16
* cell instance $13318 m0 *1 141.17,112
X$13318 8660 7141 7523 7766 6893 112 113 7611 AOI221_X1
* cell instance $13320 r0 *1 142.31,112
X$13320 6254 7824 6097 112 7874 113 AOI21_X1
* cell instance $13321 m0 *1 143.26,112
X$13321 6142 7524 6097 112 7415 113 AOI21_X1
* cell instance $13322 m0 *1 142.69,112
X$13322 7659 6142 112 113 7609 NOR2_X1
* cell instance $13323 m0 *1 144.02,112
X$13323 6145 112 113 7766 INV_X1
* cell instance $13325 m0 *1 144.59,112
X$13325 6789 6811 112 113 7660 NOR2_X1
* cell instance $13327 r0 *1 143.07,112
X$13327 7769 7661 6074 7824 7660 7525 113 112 AOI221_X2
* cell instance $13328 r0 *1 145.16,112
X$13328 6201 7662 112 113 7661 NOR2_X1
* cell instance $13329 m0 *1 145.73,112
X$13329 6641 6410 112 113 7769 NAND2_X1
* cell instance $13331 m0 *1 146.3,112
X$13331 6812 7524 112 113 7774 NAND2_X1
* cell instance $13332 m0 *1 146.87,112
X$13332 7772 113 7253 112 BUF_X4
* cell instance $13333 m0 *1 148.2,112
X$13333 7774 6811 7773 112 113 7605 MUX2_X1
* cell instance $13336 r0 *1 146.11,112
X$13336 7416 7772 112 7773 113 OR2_X4
* cell instance $13339 r0 *1 148.39,112
X$13339 7141 112 113 7526 INV_X1
* cell instance $13340 r0 *1 148.77,112
X$13340 7779 7825 6254 6256 6081 7780 113 112 AOI221_X2
* cell instance $13341 m0 *1 152,112
X$13341 7531 7530 7115 112 7663 113 AOI21_X1
* cell instance $13342 m0 *1 149.91,112
X$13342 7870 7776 7529 7780 7482 6204 112 113 OAI221_X2
* cell instance $13344 m0 *1 152.95,112
X$13344 7663 6811 7783 112 113 7782 MUX2_X1
* cell instance $13346 r0 *1 150.86,112
X$13346 6410 6153 112 113 7779 NAND2_X1
* cell instance $13349 r0 *1 153.33,112
X$13349 7605 6195 7782 112 113 7784 MUX2_X1
* cell instance $13350 r0 *1 154.66,112
X$13350 7381 6406 7784 113 112 6093 OAI21_X2
* cell instance $13351 m0 *1 154.85,112
X$13351 7531 7467 7604 112 6202 113 AOI21_X2
* cell instance $13354 m0 *1 157.7,112
X$13354 7416 7467 112 6196 113 NAND2_X4
* cell instance $13355 m0 *1 159.41,112
X$13355 7532 7788 112 113 7790 OR2_X1
* cell instance $13356 m0 *1 160.17,112
X$13356 7792 7790 7382 6650 112 113 7602 AOI22_X2
* cell instance $13358 m0 *1 162.07,112
X$13358 7380 6646 6349 5981 112 113 7788 AOI22_X1
* cell instance $13360 r0 *1 155.99,112
X$13360 7109 6201 6407 7115 113 112 7664 OAI22_X1
* cell instance $13361 r0 *1 156.94,112
X$13361 6267 112 113 6353 BUF_X2
* cell instance $13363 r0 *1 158.08,112
X$13363 7787 7785 7786 5988 113 7792 112 NOR4_X2
* cell instance $13364 r0 *1 159.79,112
X$13364 7255 6545 7826 6929 7030 7776 113 112 AOI221_X2
* cell instance $13365 r0 *1 161.88,112
X$13365 112 6367 6402 113 BUF_X16
* cell instance $13367 m0 *1 163.4,112
X$13367 6647 7596 6547 112 113 7665 MUX2_X1
* cell instance $13368 m0 *1 164.92,112
X$13368 7767 7770 6816 7781 7378 6078 113 112 AOI221_X2
* cell instance $13370 r0 *1 166.63,112
X$13370 6545 7596 6641 112 113 7829 MUX2_X1
* cell instance $13371 m0 *1 168.34,112
X$13371 7777 112 113 7775 BUF_X2
* cell instance $13372 m0 *1 167.39,112
X$13372 6641 7604 112 113 6646 NOR2_X2
* cell instance $13373 m0 *1 169.1,112
X$13373 7533 112 113 6537 CLKBUF_X3
* cell instance $13374 m0 *1 170.05,112
X$13374 6407 7604 6545 112 113 7536 MUX2_X1
* cell instance $13375 m0 *1 171.38,112
X$13375 7667 7665 6410 112 7770 113 AOI21_X1
* cell instance $13376 m0 *1 172.14,112
X$13376 6142 6081 113 112 7768 XNOR2_X1
* cell instance $13379 m0 *1 175.56,112
X$13379 7751 7239 112 113 7537 NOR2_X1
* cell instance $13380 m0 *1 176.13,112
X$13380 7114 7239 112 113 7263 NAND2_X1
* cell instance $13381 m0 *1 176.7,112
X$13381 7537 7266 112 113 7668 NAND2_X1
* cell instance $13382 m0 *1 177.27,112
X$13382 7266 7593 7239 112 113 7592 NAND3_X1
* cell instance $13383 m0 *1 178.03,112
X$13383 7537 7669 112 113 7764 NAND2_X1
* cell instance $13384 m0 *1 178.6,112
X$13384 7760 7764 7592 112 7267 113 AOI21_X2
* cell instance $13386 m0 *1 180.69,112
X$13386 7540 7671 112 113 7670 NAND2_X1
* cell instance $13387 m0 *1 181.26,112
X$13387 5761 7591 113 112 7760 XNOR2_X1
* cell instance $13388 m0 *1 182.4,112
X$13388 7368 112 113 7669 BUF_X1
* cell instance $13390 r0 *1 167.96,112
X$13390 6256 7778 6781 113 8160 112 OAI21_X1
* cell instance $13392 r0 *1 168.91,112
X$13392 7667 113 5913 112 BUF_X4
* cell instance $13394 r0 *1 170.43,112
X$13394 7530 7768 5991 6402 7862 113 112 7386 OAI221_X1
* cell instance $13395 r0 *1 171.57,112
X$13395 6894 6081 6251 112 7771 113 AOI21_X1
* cell instance $13397 r0 *1 172.52,112
X$13397 6139 6255 16696 113 112 7863 HA_X1
* cell instance $13398 r0 *1 174.42,112
X$13398 6410 7829 112 113 7767 OR2_X1
* cell instance $13401 r0 *1 176.89,112
X$13401 7762 7861 7668 112 7265 113 AOI21_X2
* cell instance $13402 r0 *1 178.22,112
X$13402 7669 7593 7239 112 113 7861 NAND3_X1
* cell instance $13403 r0 *1 178.98,112
X$13403 5792 7239 113 7696 112 XOR2_X2
* cell instance $13407 r0 *1 180.69,112
X$13407 5761 7671 113 112 7762 XNOR2_X1
* cell instance $13409 r0 *1 182.21,112
X$13409 7591 6773 7539 112 113 7858 NAND3_X1
* cell instance $13410 r0 *1 182.97,112
X$13410 7671 7362 7539 112 113 7538 NAND3_X1
* cell instance $13411 m0 *1 184.68,112
X$13411 7461 7424 113 112 7672 XNOR2_X1
* cell instance $13412 m0 *1 183.35,112
X$13412 7463 7755 7538 112 7756 113 AOI21_X2
* cell instance $13413 m0 *1 185.82,112
X$13413 5179 7539 112 113 7540 NOR2_X1
* cell instance $13414 m0 *1 186.39,112
X$13414 7540 7591 112 113 7755 NAND2_X1
* cell instance $13415 m0 *1 186.96,112
X$13415 7518 7156 112 113 7673 NOR2_X1
* cell instance $13417 m0 *1 189.05,112
X$13417 7159 5179 7541 112 113 7752 NAND3_X1
* cell instance $13418 m0 *1 189.81,112
X$13418 7752 7159 7542 113 112 7674 OAI21_X2
* cell instance $13421 r0 *1 183.73,112
X$13421 112 7857 7756 7757 2175 113 NOR3_X4
* cell instance $13422 r0 *1 186.39,112
X$13422 5792 5761 112 113 7854 XNOR2_X2
* cell instance $13424 r0 *1 188.48,112
X$13424 112 7927 7855 7674 5421 113 NOR3_X4
* cell instance $13427 m0 *1 196.27,112
X$13427 112 16912 7746 7544 7043 113 DFF_X1
* cell instance $13428 m0 *1 193.04,112
X$13428 112 16871 7543 7723 6705 113 DFF_X1
* cell instance $13430 m0 *1 202.54,112
X$13430 112 16746 6709 7722 7043 113 DFF_X1
* cell instance $13432 m0 *1 206.53,112
X$13432 7547 112 113 7161 BUF_X1
* cell instance $13433 m0 *1 207.1,112
X$13433 5565 6167 7452 112 113 7585 MUX2_X1
* cell instance $13435 r0 *1 193.42,112
X$13435 401 112 113 6705 CLKBUF_X3
* cell instance $13436 r0 *1 194.37,112
X$13436 6705 112 113 16476 CLKBUF_X1
* cell instance $13437 r0 *1 194.94,112
X$13437 7675 4814 113 112 7749 XNOR2_X1
* cell instance $13438 r0 *1 196.08,112
X$13438 7700 4389 7749 112 113 7544 MUX2_X1
* cell instance $13441 r0 *1 199.31,112
X$13441 7746 112 113 7675 CLKBUF_X3
* cell instance $13444 r0 *1 206.53,112
X$13444 7547 112 113 7831 INV_X2
* cell instance $13445 r0 *1 207.1,112
X$13445 7340 5865 112 113 6839 NAND2_X2
* cell instance $13447 r0 *1 208.43,112
X$13447 6053 6852 6166 6278 7741 7735 113 112 AOI221_X2
* cell instance $13448 m0 *1 209.76,112
X$13448 6166 6823 112 113 7431 NAND2_X2
* cell instance $13449 m0 *1 208.81,112
X$13449 6001 6823 112 113 7548 NAND2_X2
* cell instance $13451 r0 *1 210.52,112
X$13451 5782 5865 7340 112 7741 113 AOI21_X2
* cell instance $13452 m0 *1 211.28,112
X$13452 7428 7549 7585 7550 6834 7569 112 113 OAI221_X2
* cell instance $13455 m0 *1 213.56,112
X$13455 6710 5780 5871 112 113 7550 NAND3_X1
* cell instance $13457 m0 *1 214.51,112
X$13457 7725 7551 5780 6171 7730 7728 113 112 AOI221_X2
* cell instance $13459 m0 *1 216.79,112
X$13459 5864 5424 5780 6287 7581 8065 113 112 AOI221_X2
* cell instance $13462 r0 *1 211.85,112
X$13462 7735 7681 7430 112 7843 113 AOI21_X2
* cell instance $13463 r0 *1 213.18,112
X$13463 6425 6460 112 113 6834 NOR2_X2
* cell instance $13464 r0 *1 214.13,112
X$13464 6167 7452 113 112 7835 AND2_X1
* cell instance $13466 r0 *1 215.27,112
X$13466 7676 7052 6723 112 113 7729 NOR3_X1
* cell instance $13468 r0 *1 216.22,112
X$13468 7729 7677 7304 7849 112 113 7167 AOI22_X1
* cell instance $13469 r0 *1 217.17,112
X$13469 7452 6005 112 113 7725 NAND2_X1
* cell instance $13473 r0 *1 219.83,112
X$13473 112 7678 7679 6951 7844 7723 113 NOR4_X4
* cell instance $13474 m0 *1 220.21,112
X$13474 7052 7322 7552 112 7679 113 AOI21_X1
* cell instance $13478 m0 *1 223.25,112
X$13478 7555 7680 7579 7714 112 113 7722 NAND4_X1
* cell instance $13479 m0 *1 224.2,112
X$13479 6425 6460 112 113 7435 NAND2_X2
* cell instance $13482 r0 *1 223.25,112
X$13482 7298 6561 5864 112 7681 113 AOI21_X2
* cell instance $13483 r0 *1 224.58,112
X$13483 7711 7682 7683 113 7714 112 OAI21_X1
* cell instance $13484 r0 *1 225.34,112
X$13484 6835 6331 112 113 7683 NOR2_X1
* cell instance $13486 r0 *1 226.1,112
X$13486 7684 6289 6174 7681 7685 112 113 7711 AOI221_X1
* cell instance $13487 m0 *1 227.24,112
X$13487 5425 5783 7689 113 7685 112 OAI21_X1
* cell instance $13488 m0 *1 226.29,112
X$13488 6839 7712 6028 7574 112 113 7684 AOI22_X1
* cell instance $13489 m0 *1 228,112
X$13489 6721 7705 6717 6714 7557 7556 112 113 OAI221_X2
* cell instance $13490 m0 *1 230.09,112
X$13490 6745 5565 112 113 7558 NAND2_X1
* cell instance $13492 m0 *1 230.85,112
X$13492 7558 5870 113 112 7705 AND2_X1
* cell instance $13496 r0 *1 227.81,112
X$13496 6723 7843 7435 7556 7687 7844 113 112 AOI221_X2
* cell instance $13497 r0 *1 229.9,112
X$13497 6174 7688 6432 112 7687 113 AOI21_X1
* cell instance $13498 r0 *1 230.66,112
X$13498 6838 5864 7944 7689 112 113 7688 AOI22_X1
* cell instance $13499 r0 *1 231.61,112
X$13499 6005 6827 112 113 7690 NAND2_X1
* cell instance $13500 m0 *1 232.75,112
X$13500 7559 7560 7569 7439 6825 112 113 7436 AOI221_X1
* cell instance $13501 m0 *1 231.99,112
X$13501 6440 7690 6171 112 113 7559 NAND3_X1
* cell instance $13502 m0 *1 233.89,112
X$13502 5783 6005 6293 112 113 7561 NAND3_X1
* cell instance $13504 m0 *1 234.84,112
X$13504 6557 5770 112 113 7440 XNOR2_X2
* cell instance $13507 r0 *1 232.94,112
X$13507 6313 6003 112 113 7702 NAND2_X1
* cell instance $13508 r0 *1 233.51,112
X$13508 7561 6878 7702 7838 112 113 7562 NAND4_X1
* cell instance $13509 r0 *1 234.46,112
X$13509 7692 112 113 7700 BUF_X1
* cell instance $13511 r0 *1 235.79,112
X$13511 7693 112 113 7699 BUF_X1
* cell instance $13516 r0 *1 236.55,112
X$13516 112 16984 7691 7696 6437 113 DFF_X1
* cell instance $13517 m0 *1 237.31,112
X$13517 4841 112 113 6437 CLKBUF_X3
* cell instance $13519 m0 *1 238.26,112
X$13519 6437 112 113 17198 INV_X1
* cell instance $13521 m0 *1 239.21,112
X$13521 7691 112 113 7694 BUF_X1
* cell instance $13525 m0 *1 16.53,128.8
X$13525 9063 112 113 8697 CLKBUF_X2
* cell instance $13530 m0 *1 25.08,128.8
X$13530 8552 7701 7623 113 9065 112 OAI21_X1
* cell instance $13531 m0 *1 25.84,128.8
X$13531 8552 8110 8553 112 9066 113 AOI21_X1
* cell instance $13533 m0 *1 26.79,128.8
X$13533 8176 9066 9018 113 9017 112 OAI21_X1
* cell instance $13535 m0 *1 27.74,128.8
X$13535 7218 8552 8253 112 113 9067 NOR3_X1
* cell instance $13536 m0 *1 28.5,128.8
X$13536 8635 9067 7497 112 113 9024 NOR3_X1
* cell instance $13538 m0 *1 29.45,128.8
X$13538 8554 8843 9020 113 9068 112 OAI21_X1
* cell instance $13539 m0 *1 30.21,128.8
X$13539 8844 7887 7882 113 9023 112 OAI21_X1
* cell instance $13540 m0 *1 30.97,128.8
X$13540 9023 6966 8690 112 9069 113 AOI21_X1
* cell instance $13541 m0 *1 31.73,128.8
X$13541 9069 9024 8014 113 9025 112 OAI21_X1
* cell instance $13543 m0 *1 32.68,128.8
X$13543 8566 9127 8636 112 8915 113 AOI21_X1
* cell instance $13546 m0 *1 34.39,128.8
X$13546 7706 8550 8846 7623 8639 113 112 9032 OAI221_X1
* cell instance $13547 m0 *1 35.53,128.8
X$13547 9133 7887 8182 113 9135 112 OAI21_X1
* cell instance $13548 m0 *1 36.29,128.8
X$13548 9135 9136 8971 113 8917 112 OAI21_X1
* cell instance $13549 m0 *1 37.05,128.8
X$13549 8973 7886 7222 112 113 9136 NOR3_X1
* cell instance $13550 m0 *1 37.81,128.8
X$13550 7224 7300 112 113 8973 NOR2_X1
* cell instance $13551 m0 *1 38.38,128.8
X$13551 8419 8847 8242 112 113 8488 NAND3_X1
* cell instance $13552 m0 *1 39.14,128.8
X$13552 9257 8185 8020 113 8979 112 OAI21_X1
* cell instance $13553 m0 *1 39.9,128.8
X$13553 8638 8811 7228 6902 112 113 9140 AOI22_X2
* cell instance $13555 m0 *1 41.8,128.8
X$13555 8974 6965 112 113 8975 NOR2_X1
* cell instance $13556 m0 *1 42.37,128.8
X$13556 8975 6966 8186 9073 7887 112 113 9143 AOI221_X1
* cell instance $13557 m0 *1 43.51,128.8
X$13557 8979 8976 8978 112 9145 113 AOI21_X1
* cell instance $13558 m0 *1 44.27,128.8
X$13558 8426 9147 9145 112 9148 113 AOI21_X1
* cell instance $13559 m0 *1 45.03,128.8
X$13559 9038 8113 8849 8242 9076 9075 113 112 AOI221_X2
* cell instance $13560 m0 *1 47.12,128.8
X$13560 7641 7228 8110 7880 113 112 9076 OAI22_X1
* cell instance $13562 m0 *1 48.26,128.8
X$13562 112 8092 9148 9040 9041 8251 113 AOI22_X4
* cell instance $13563 m0 *1 51.49,128.8
X$13563 9039 9154 8756 9043 8980 9041 113 112 AOI221_X2
* cell instance $13564 m0 *1 53.58,128.8
X$13564 8183 8426 112 113 8971 NOR2_X2
* cell instance $13565 m0 *1 54.53,128.8
X$13565 7621 8914 8982 8981 7965 113 112 9079 OAI221_X1
* cell instance $13566 m0 *1 55.67,128.8
X$13566 9197 8848 8852 112 9157 113 AOI21_X2
* cell instance $13567 m0 *1 57,128.8
X$13567 8426 8846 8565 112 9158 113 AOI21_X1
* cell instance $13568 m0 *1 57.76,128.8
X$13568 7886 112 113 9080 INV_X1
* cell instance $13570 m0 *1 59.66,128.8
X$13570 9046 6382 113 8020 112 XOR2_X2
* cell instance $13571 m0 *1 61.37,128.8
X$13571 6382 9046 112 113 8183 XNOR2_X2
* cell instance $13580 r0 *1 11.4,128.8
X$13580 9180 112 113 9113 BUF_X1
* cell instance $13584 r0 *1 11.97,128.8
X$13584 9182 112 113 9117 BUF_X1
* cell instance $13587 m0 *1 13.68,128.8
X$13587 8969 112 113 9114 BUF_X2
* cell instance $13590 r0 *1 14.44,128.8
X$13590 9183 6899 9440 112 113 9115 MUX2_X1
* cell instance $13591 r0 *1 15.77,128.8
X$13591 112 16962 9183 9115 8903 113 DFF_X1
* cell instance $13593 r0 *1 19.19,128.8
X$13593 9119 8585 9117 112 113 9118 MUX2_X1
* cell instance $13596 r0 *1 21.09,128.8
X$13596 112 9118 9399 9090 9119 113 DFF_X2
* cell instance $13598 r0 *1 25.08,128.8
X$13598 8554 9064 9065 113 9184 112 OAI21_X1
* cell instance $13599 r0 *1 25.84,128.8
X$13599 9184 8848 8846 8842 112 113 9239 AOI22_X2
* cell instance $13601 r0 *1 27.74,128.8
X$13601 7218 8552 8253 113 9340 112 OAI21_X1
* cell instance $13603 r0 *1 28.69,128.8
X$13603 6902 8550 8846 8554 9066 113 112 9186 OAI221_X1
* cell instance $13606 r0 *1 30.97,128.8
X$13606 8550 7495 112 113 9244 NAND2_X1
* cell instance $13610 r0 *1 32.87,128.8
X$13610 9071 8418 7707 113 9070 112 OAI21_X1
* cell instance $13611 r0 *1 33.63,128.8
X$13611 8014 9185 9025 113 9249 112 OAI21_X1
* cell instance $13614 r0 *1 35.34,128.8
X$13614 7847 8693 8182 7306 7441 113 112 9139 OAI221_X1
* cell instance $13617 r0 *1 37.05,128.8
X$13617 9137 8383 9072 112 9190 113 AOI21_X1
* cell instance $13618 r0 *1 37.81,128.8
X$13618 9139 9032 8020 112 113 9146 NAND3_X1
* cell instance $13619 r0 *1 38.57,128.8
X$13619 9037 7847 112 113 9259 NOR2_X1
* cell instance $13621 r0 *1 39.52,128.8
X$13621 7620 7884 7220 112 9191 113 AOI21_X1
* cell instance $13624 r0 *1 40.85,128.8
X$13624 7008 8811 9291 7710 9260 113 112 9144 OAI221_X1
* cell instance $13625 r0 *1 41.99,128.8
X$13625 7293 112 113 9260 INV_X1
* cell instance $13627 r0 *1 42.56,128.8
X$13627 9143 8848 9144 112 9147 113 AOI21_X1
* cell instance $13629 r0 *1 44.08,128.8
X$13629 8977 9262 8756 9146 9263 113 112 9074 OAI221_X1
* cell instance $13630 r0 *1 45.22,128.8
X$13630 8554 8245 7880 112 9193 113 AOI21_X1
* cell instance $13632 r0 *1 46.36,128.8
X$13632 8422 9192 9075 9017 112 113 9264 AOI22_X1
* cell instance $13634 r0 *1 47.5,128.8
X$13634 8422 9075 8562 113 9194 112 OAI21_X1
* cell instance $13636 r0 *1 48.45,128.8
X$13636 8020 7628 112 113 9154 NOR2_X1
* cell instance $13637 r0 *1 49.02,128.8
X$13637 8757 7224 8379 112 113 9077 NOR3_X1
* cell instance $13639 r0 *1 49.97,128.8
X$13639 7965 8387 8245 112 9195 113 AOI21_X1
* cell instance $13640 r0 *1 50.73,128.8
X$13640 7226 8757 8613 113 8932 112 OAI21_X1
* cell instance $13641 r0 *1 51.49,128.8
X$13641 8557 9297 9079 113 9043 112 OAI21_X1
* cell instance $13642 r0 *1 52.25,128.8
X$13642 8850 9155 9078 9249 8971 9156 113 112 AOI221_X2
* cell instance $13643 r0 *1 54.34,128.8
X$13643 9077 7222 7501 112 113 9268 NOR3_X1
* cell instance $13644 r0 *1 55.1,128.8
X$13644 8615 8253 112 113 9196 NAND2_X1
* cell instance $13646 r0 *1 55.86,128.8
X$13646 8020 9157 9158 112 9155 113 AOI21_X2
* cell instance $13647 r0 *1 57.19,128.8
X$13647 7582 8914 7882 7628 6798 112 113 9269 AOI221_X1
* cell instance $13648 r0 *1 58.33,128.8
X$13648 7572 9080 8315 113 9199 112 OAI21_X1
* cell instance $13652 m0 *1 64.6,128.8
X$13652 8983 316 9113 112 113 9047 MUX2_X1
* cell instance $13654 m0 *1 65.93,128.8
X$13654 112 16761 8983 9047 9201 113 DFF_X1
* cell instance $13657 m0 *1 70.87,128.8
X$13657 5371 8402 112 113 9163 XNOR2_X2
* cell instance $13658 m0 *1 72.77,128.8
X$13658 7510 9275 113 112 8854 AND2_X1
* cell instance $13660 m0 *1 75.05,128.8
X$13660 8762 4365 113 112 9164 XNOR2_X1
* cell instance $13661 m0 *1 76.19,128.8
X$13661 8985 9164 112 113 8984 XNOR2_X2
* cell instance $13662 m0 *1 78.09,128.8
X$13662 9082 9167 112 113 8716 XNOR2_X2
* cell instance $13663 m0 *1 79.99,128.8
X$13663 8432 9165 112 113 9277 XNOR2_X2
* cell instance $13664 m0 *1 81.89,128.8
X$13664 8763 8986 112 113 9083 XNOR2_X2
* cell instance $13665 m0 *1 83.79,128.8
X$13665 8987 9169 112 113 9170 XNOR2_X2
* cell instance $13668 m0 *1 86.64,128.8
X$13668 8989 113 8433 112 BUF_X4
* cell instance $13669 m0 *1 87.97,128.8
X$13669 9085 8858 112 113 9056 XOR2_X1
* cell instance $13670 m0 *1 89.11,128.8
X$13670 112 9174 9053 9171 9051 113 AOI21_X4
* cell instance $13671 m0 *1 91.58,128.8
X$13671 9057 9174 9055 112 113 8258 OR3_X4
* cell instance $13672 m0 *1 93.67,128.8
X$13672 9172 113 8431 112 BUF_X4
* cell instance $13673 m0 *1 95,128.8
X$13673 8195 8819 112 113 8860 XOR2_X1
* cell instance $13674 m0 *1 96.14,128.8
X$13674 9061 8990 9176 113 9057 112 OAI21_X1
* cell instance $13675 m0 *1 96.9,128.8
X$13675 9061 3780 9060 112 113 9176 NAND3_X1
* cell instance $13676 m0 *1 97.66,128.8
X$13676 224 3434 113 112 9062 AND2_X1
* cell instance $13677 m0 *1 98.42,128.8
X$13677 9062 8991 9058 113 112 9086 MUX2_X2
* cell instance $13680 m0 *1 102.41,128.8
X$13680 8994 8993 113 112 8995 XNOR2_X1
* cell instance $13681 m0 *1 103.55,128.8
X$13681 8995 9009 113 112 9058 XNOR2_X1
* cell instance $13683 m0 *1 107.73,128.8
X$13683 112 8870 5023 113 BUF_X32
* cell instance $13686 r0 *1 64.41,128.8
X$13686 8853 316 9200 112 113 9365 MUX2_X1
* cell instance $13690 r0 *1 67.07,128.8
X$13690 9183 9202 3465 113 112 9046 MUX2_X2
* cell instance $13695 r0 *1 68.97,128.8
X$13695 5954 9203 113 112 9162 XNOR2_X1
* cell instance $13696 r0 *1 70.11,128.8
X$13696 9081 9273 113 112 8316 XNOR2_X1
* cell instance $13697 r0 *1 71.25,128.8
X$13697 9160 9298 113 112 9273 XNOR2_X1
* cell instance $13698 r0 *1 72.39,128.8
X$13698 9160 9162 113 112 9204 XNOR2_X1
* cell instance $13700 r0 *1 73.91,128.8
X$13700 9099 113 4948 112 BUF_X4
* cell instance $13701 r0 *1 75.24,128.8
X$13701 7645 9205 113 112 8646 XNOR2_X1
* cell instance $13705 r0 *1 77.71,128.8
X$13705 7598 9081 112 113 9206 XNOR2_X2
* cell instance $13707 r0 *1 79.8,128.8
X$13707 9082 112 113 9160 BUF_X1
* cell instance $13708 r0 *1 80.37,128.8
X$13708 8986 112 113 9165 BUF_X1
* cell instance $13709 r0 *1 80.94,128.8
X$13709 9168 8650 112 113 9167 XNOR2_X2
* cell instance $13711 r0 *1 83.22,128.8
X$13711 9206 8989 112 113 9169 XNOR2_X2
* cell instance $13712 r0 *1 85.12,128.8
X$13712 9084 8038 112 113 8989 XNOR2_X2
* cell instance $13715 r0 *1 87.59,128.8
X$13715 8761 8196 112 113 9082 XNOR2_X2
* cell instance $13716 r0 *1 89.49,128.8
X$13716 9085 112 113 9050 BUF_X2
* cell instance $13717 r0 *1 90.25,128.8
X$13717 9082 112 113 8948 BUF_X1
* cell instance $13719 r0 *1 91.01,128.8
X$13719 9056 9173 9054 112 9055 113 AOI21_X1
* cell instance $13723 r0 *1 93.86,128.8
X$13723 112 17033 9172 9285 9175 113 DFF_X1
* cell instance $13724 r0 *1 97.09,128.8
X$13724 8862 113 9099 112 BUF_X4
* cell instance $13725 r0 *1 98.42,128.8
X$13725 9099 113 5995 112 BUF_X4
* cell instance $13728 r0 *1 100.32,128.8
X$13728 9087 7816 112 113 4888 XNOR2_X2
* cell instance $13731 r0 *1 106.02,128.8
X$13731 5179 9088 112 113 9304 NOR2_X1
* cell instance $13734 r0 *1 107.16,128.8
X$13734 112 4508 113 7362 BUF_X8
* cell instance $13735 r0 *1 109.63,128.8
X$13735 9088 9089 112 113 9283 XNOR2_X2
* cell instance $13736 r0 *1 111.53,128.8
X$13736 4598 5120 112 113 9284 NOR2_X1
* cell instance $13737 r0 *1 112.1,128.8
X$13737 5122 4598 113 112 9282 AND2_X1
* cell instance $13738 r0 *1 112.86,128.8
X$13738 9281 9090 9179 113 112 9280 OAI21_X2
* cell instance $13739 r0 *1 114.19,128.8
X$13739 9090 5637 9095 112 113 9281 NAND3_X1
* cell instance $13740 r0 *1 114.95,128.8
X$13740 5637 9091 112 113 9179 NAND2_X1
* cell instance $13742 r0 *1 116.28,128.8
X$13742 112 6239 113 8329 BUF_X8
* cell instance $13746 m0 *1 120.46,128.8
X$13746 9091 7238 112 113 9093 NOR2_X1
* cell instance $13749 r0 *1 121.22,128.8
X$13749 9091 112 113 9095 INV_X1
* cell instance $13751 m0 *1 123.12,128.8
X$13751 8997 7107 6370 112 9092 113 AOI21_X1
* cell instance $13753 m0 *1 123.88,128.8
X$13753 9052 6244 112 113 8997 NOR2_X1
* cell instance $13757 r0 *1 123.12,128.8
X$13757 112 17127 9178 9092 9211 113 DFF_X1
* cell instance $13761 r0 *1 126.35,128.8
X$13761 9178 113 7819 112 BUF_X4
* cell instance $13764 r0 *1 128.25,128.8
X$13764 9177 9093 113 112 9214 AND2_X1
* cell instance $13765 m0 *1 128.82,128.8
X$13765 8999 8454 112 113 9177 NOR2_X1
* cell instance $13768 m0 *1 130.15,128.8
X$13768 9093 9094 8999 9000 112 113 8998 NAND4_X1
* cell instance $13771 m0 *1 134.33,128.8
X$13771 8780 112 113 16466 CLKBUF_X1
* cell instance $13772 m0 *1 134.9,128.8
X$13772 8454 112 113 9000 INV_X1
* cell instance $13773 m0 *1 135.28,128.8
X$13773 9097 8329 112 113 9096 NOR2_X1
* cell instance $13776 r0 *1 129.01,128.8
X$13776 9177 9094 9091 5122 112 113 9212 NAND4_X1
* cell instance $13778 r0 *1 130.15,128.8
X$13778 9093 9094 9391 8454 112 113 9276 NAND4_X1
* cell instance $13780 r0 *1 131.29,128.8
X$13780 8999 9000 9095 8329 112 113 9213 NOR4_X1
* cell instance $13782 r0 *1 132.43,128.8
X$13782 9217 8008 113 9094 112 XOR2_X2
* cell instance $13784 r0 *1 134.33,128.8
X$13784 8539 112 113 8780 CLKBUF_X3
* cell instance $13785 r0 *1 135.28,128.8
X$13785 5122 9097 113 112 9274 AND2_X1
* cell instance $13787 r0 *1 136.42,128.8
X$13787 112 9001 9098 9166 8780 113 DFF_X1
* cell instance $13789 m0 *1 137.75,128.8
X$13789 9001 8870 9000 112 113 9049 NAND3_X1
* cell instance $13790 m0 *1 139.08,128.8
X$13790 9049 9001 9002 113 112 8717 OAI21_X2
* cell instance $13794 m0 *1 142.69,128.8
X$13794 8580 8661 8280 112 113 NOR2_X4
* cell instance $13797 m0 *1 145.35,128.8
X$13797 112 6495 6653 8443 8338 113 AOI21_X4
* cell instance $13799 r0 *1 139.65,128.8
X$13799 9098 5995 9270 112 113 9166 MUX2_X1
* cell instance $13800 r0 *1 140.98,128.8
X$13800 8878 7510 6625 112 113 9271 NAND3_X2
* cell instance $13802 r0 *1 142.5,128.8
X$13802 6625 8878 112 113 9218 OR2_X1
* cell instance $13803 r0 *1 143.26,128.8
X$13803 9099 113 316 112 BUF_X4
* cell instance $13806 r0 *1 148.01,128.8
X$13806 7915 8580 8661 113 112 5985 OAI21_X4
* cell instance $13807 m0 *1 148.58,128.8
X$13807 9161 8283 7352 112 113 9159 MUX2_X1
* cell instance $13808 m0 *1 148.2,128.8
X$13808 8339 112 113 8582 INV_X1
* cell instance $13809 m0 *1 149.91,128.8
X$13809 6495 8735 8280 112 9161 113 AOI21_X1
* cell instance $13811 r0 *1 150.48,128.8
X$13811 9159 8581 9150 112 113 9100 MUX2_X1
* cell instance $13812 m0 *1 153.14,128.8
X$13812 6478 7205 9003 9042 7024 9045 113 112 AOI221_X2
* cell instance $13813 m0 *1 151.05,128.8
X$13813 9100 6080 8872 9045 7607 8660 113 112 AOI221_X2
* cell instance $13817 r0 *1 152.76,128.8
X$13817 6199 8283 8735 112 113 9003 NOR3_X1
* cell instance $13819 r0 *1 153.9,128.8
X$13819 8544 7915 112 113 9371 NOR2_X1
* cell instance $13820 r0 *1 154.47,128.8
X$13820 9461 7828 112 113 9152 NOR2_X1
* cell instance $13821 r0 *1 155.04,128.8
X$13821 8580 8661 8341 113 9044 112 NOR3_X2
* cell instance $13822 m0 *1 156.56,128.8
X$13822 9044 113 6894 112 BUF_X4
* cell instance $13823 m0 *1 155.61,128.8
X$13823 9044 8874 112 113 6926 NOR2_X2
* cell instance $13824 m0 *1 157.89,128.8
X$13824 112 6199 9153 8443 8338 113 AOI21_X4
* cell instance $13825 m0 *1 160.36,128.8
X$13825 8581 8283 7667 7996 6894 9101 113 112 AOI221_X2
* cell instance $13826 m0 *1 162.45,128.8
X$13826 112 7114 113 7751 BUF_X8
* cell instance $13827 m0 *1 164.92,128.8
X$13827 9261 7533 7917 7866 7667 7990 112 113 OAI221_X2
* cell instance $13828 m0 *1 167.01,128.8
X$13828 8735 113 8158 112 BUF_X4
* cell instance $13829 m0 *1 168.34,128.8
X$13829 8783 6367 7596 112 113 9149 MUX2_X1
* cell instance $13830 m0 *1 169.67,128.8
X$13830 9142 8052 9149 112 9150 113 AOI21_X1
* cell instance $13832 m0 *1 170.62,128.8
X$13832 9099 113 8585 112 BUF_X4
* cell instance $13833 m0 *1 171.95,128.8
X$13833 9005 9103 113 8666 112 AND2_X4
* cell instance $13834 m0 *1 173.66,128.8
X$13834 7863 8280 113 112 9142 AND2_X1
* cell instance $13836 r0 *1 156.37,128.8
X$13836 8341 113 8283 112 BUF_X4
* cell instance $13838 r0 *1 158.08,128.8
X$13838 112 8782 8341 8443 8338 113 AOI21_X4
* cell instance $13839 r0 *1 160.55,128.8
X$13839 9151 9101 7911 6074 9102 7603 113 112 AOI221_X2
* cell instance $13840 r0 *1 162.64,128.8
X$13840 9220 6367 112 113 7375 NOR2_X1
* cell instance $13841 r0 *1 163.21,128.8
X$13841 6367 113 6205 112 BUF_X4
* cell instance $13842 r0 *1 164.54,128.8
X$13842 7922 7915 8217 9005 9141 8946 113 112 AOI221_X2
* cell instance $13843 r0 *1 166.63,128.8
X$13843 112 6641 8783 9004 9005 113 AOI21_X4
* cell instance $13844 r0 *1 169.1,128.8
X$13844 9152 9371 6205 113 9151 112 OAI21_X1
* cell instance $13846 r0 *1 170.24,128.8
X$13846 112 8282 6367 113 INV_X32
* cell instance $13848 m0 *1 174.8,128.8
X$13848 9104 9034 4163 113 112 8155 MUX2_X2
* cell instance $13849 r0 *1 176.51,128.8
X$13849 9099 113 4939 112 BUF_X4
* cell instance $13850 m0 *1 179.36,128.8
X$13850 112 16745 9104 9006 9036 113 DFF_X1
* cell instance $13851 m0 *1 176.89,128.8
X$13851 112 7650 113 6775 BUF_X8
* cell instance $13853 r0 *1 177.84,128.8
X$13853 9221 5043 7020 112 113 9451 NAND3_X1
* cell instance $13854 r0 *1 178.6,128.8
X$13854 9258 112 113 9141 BUF_X1
* cell instance $13856 r0 *1 179.36,128.8
X$13856 9104 8785 9129 112 113 9006 MUX2_X1
* cell instance $13860 r0 *1 180.69,128.8
X$13860 7751 9217 112 113 9253 NOR2_X1
* cell instance $13863 r0 *1 182.97,128.8
X$13863 9222 9252 113 112 9138 XNOR2_X1
* cell instance $13864 m0 *1 183.16,128.8
X$13864 9035 9138 8317 113 112 7920 MUX2_X2
* cell instance $13869 r0 *1 184.49,128.8
X$13869 9131 9251 112 113 9105 XNOR2_X2
* cell instance $13870 m0 *1 187.15,128.8
X$13870 3304 9007 113 112 9033 XNOR2_X1
* cell instance $13871 m0 *1 186.01,128.8
X$13871 9105 9033 113 112 9034 XNOR2_X1
* cell instance $13875 r0 *1 186.96,128.8
X$13875 5315 9007 112 113 9225 XNOR2_X2
* cell instance $13876 m0 *1 188.86,128.8
X$13876 401 112 113 8880 CLKBUF_X3
* cell instance $13878 m0 *1 189.81,128.8
X$13878 112 16736 9106 9008 8880 113 DFF_X1
* cell instance $13879 m0 *1 193.04,128.8
X$13879 9106 112 113 7039 BUF_X1
* cell instance $13882 r0 *1 189.05,128.8
X$13882 9216 112 113 9134 BUF_X1
* cell instance $13883 r0 *1 189.62,128.8
X$13883 7974 9132 9130 113 9008 112 OAI21_X1
* cell instance $13884 r0 *1 190.38,128.8
X$13884 9134 5294 113 112 9132 XNOR2_X1
* cell instance $13886 r0 *1 191.9,128.8
X$13886 9357 9246 113 112 9031 XNOR2_X1
* cell instance $13889 m0 *1 197.22,128.8
X$13889 8882 8785 9015 112 113 9030 MUX2_X1
* cell instance $13890 m0 *1 193.99,128.8
X$13890 112 16727 8882 9030 8880 113 DFF_X1
* cell instance $13891 m0 *1 198.55,128.8
X$13891 9009 3841 113 112 9029 XNOR2_X1
* cell instance $13894 m0 *1 200.64,128.8
X$13894 7974 9029 9010 113 9107 112 OAI21_X1
* cell instance $13895 m0 *1 201.4,128.8
X$13895 5449 9108 112 113 9009 XNOR2_X2
* cell instance $13896 m0 *1 203.3,128.8
X$13896 9011 112 113 5449 CLKBUF_X3
* cell instance $13899 m0 *1 208.05,128.8
X$13899 9108 3841 113 112 9026 XNOR2_X1
* cell instance $13900 m0 *1 209.19,128.8
X$13900 9027 112 113 8884 BUF_X2
* cell instance $13904 r0 *1 194.37,128.8
X$13904 9110 9131 113 112 9246 XNOR2_X1
* cell instance $13908 r0 *1 197.6,128.8
X$13908 9242 7974 112 113 9130 NAND2_X1
* cell instance $13911 r0 *1 200.45,128.8
X$13911 112 17075 9011 9107 8887 113 DFF_X1
* cell instance $13912 r0 *1 203.68,128.8
X$13912 9128 7930 9120 112 113 9228 MUX2_X1
* cell instance $13915 r0 *1 205.96,128.8
X$13915 4841 112 113 8887 CLKBUF_X3
* cell instance $13918 r0 *1 208.62,128.8
X$13918 9240 8672 113 9122 112 XOR2_X2
* cell instance $13921 m0 *1 211.09,128.8
X$13921 9123 4389 9026 112 113 9109 MUX2_X1
* cell instance $13923 m0 *1 213.37,128.8
X$13923 5316 112 113 9110 CLKBUF_X3
* cell instance $13926 m0 *1 216.6,128.8
X$13926 7325 5564 16546 113 112 9021 HA_X1
* cell instance $13928 m0 *1 219.26,128.8
X$13928 6436 9022 113 112 8890 XNOR2_X1
* cell instance $13935 r0 *1 211.66,128.8
X$13935 112 16970 9126 9109 9238 113 DFF_X1
* cell instance $13936 r0 *1 214.89,128.8
X$13936 9126 112 113 9108 BUF_X2
* cell instance $13940 r0 *1 216.98,128.8
X$13940 8348 9237 112 113 9121 XOR2_X1
* cell instance $13943 r0 *1 220.4,128.8
X$13943 112 16997 9035 9124 9229 113 DFF_X1
* cell instance $13944 r0 *1 223.63,128.8
X$13944 9035 8785 9441 112 113 9124 MUX2_X1
* cell instance $13945 r0 *1 224.96,128.8
X$13945 112 17067 9236 8883 9229 113 DFF_X1
* cell instance $13946 m0 *1 226.29,128.8
X$13946 7325 5425 16526 113 112 9012 HA_X1
* cell instance $13948 m0 *1 228.19,128.8
X$13948 112 16772 8905 9122 8794 113 DFF_X1
* cell instance $13949 m0 *1 231.42,128.8
X$13949 112 16803 8596 9121 8794 113 DFF_X1
* cell instance $13950 m0 *1 234.65,128.8
X$13950 9013 112 113 9120 BUF_X1
* cell instance $13956 r0 *1 234.46,128.8
X$13956 4841 112 113 8794 CLKBUF_X3
* cell instance $13957 r0 *1 235.41,128.8
X$13957 8794 112 113 16477 CLKBUF_X1
* cell instance $13963 r0 *1 237.69,128.8
X$13963 9231 112 113 9338 BUF_X1
* cell instance $13964 m0 *1 238.07,128.8
X$13964 9112 112 113 9015 BUF_X1
* cell instance $13969 r0 *1 238.45,128.8
X$13969 9111 112 113 9116 BUF_X1
* cell instance $13974 m0 *1 116.09,56
X$13974 112 530 2670 2762 1921 113 NOR3_X4
* cell instance $13975 r0 *1 116.09,56
X$13975 2671 112 113 2240 INV_X2
* cell instance $13976 r0 *1 116.66,56
X$13976 1919 112 113 952 CLKBUF_X3
* cell instance $13978 r0 *1 118.37,56
X$13978 112 1440 113 2762 BUF_X8
* cell instance $13980 m0 *1 119.13,56
X$13980 112 2673 2670 2762 1210 113 NOR3_X4
* cell instance $13981 r0 *1 120.84,56
X$13981 1919 934 112 113 2790 NAND2_X1
* cell instance $13984 r0 *1 121.98,56
X$13984 2867 2672 2791 112 113 2648 NOR3_X1
* cell instance $13986 m0 *1 122.17,56
X$13986 651 112 113 2673 BUF_X2
* cell instance $13987 m0 *1 123.12,56
X$13987 2533 1259 1048 112 2868 113 AOI21_X1
* cell instance $13988 m0 *1 123.88,56
X$13988 2309 112 113 1334 BUF_X1
* cell instance $13990 m0 *1 124.64,56
X$13990 1445 1012 2557 112 2672 113 AOI21_X1
* cell instance $13991 m0 *1 125.4,56
X$13991 1098 1204 112 113 2557 NAND2_X1
* cell instance $13992 m0 *1 125.97,56
X$13992 1126 113 1445 112 BUF_X4
* cell instance $13994 r0 *1 122.74,56
X$13994 2671 2762 1439 113 112 730 OAI21_X4
* cell instance $13998 r0 *1 125.21,56
X$13998 776 113 528 112 BUF_X4
* cell instance $13999 r0 *1 126.54,56
X$13999 1543 1440 1439 113 112 1340 OAI21_X4
* cell instance $14000 m0 *1 128.44,56
X$14000 802 2214 2346 112 113 NOR2_X4
* cell instance $14001 m0 *1 127.68,56
X$14001 2558 802 1921 112 2651 113 AOI21_X1
* cell instance $14002 m0 *1 130.15,56
X$14002 1547 2768 2652 2676 2244 112 113 3176 AOI221_X1
* cell instance $14003 m0 *1 131.29,56
X$14003 1051 1182 112 113 2674 NAND2_X1
* cell instance $14004 m0 *1 131.86,56
X$14004 587 810 2557 113 2675 112 OAI21_X1
* cell instance $14005 m0 *1 132.62,56
X$14005 1051 632 112 113 2875 NAND2_X1
* cell instance $14008 r0 *1 129.2,56
X$14008 2121 2982 2874 112 2768 113 AOI21_X1
* cell instance $14012 r0 *1 131.86,56
X$14012 2674 2868 928 2675 2875 113 112 2876 OAI221_X1
* cell instance $14015 r0 *1 133.57,56
X$14015 1047 706 2877 113 112 2792 AND3_X1
* cell instance $14016 m0 *1 133.76,56
X$14016 528 1752 112 113 2676 NOR2_X1
* cell instance $14019 m0 *1 135.09,56
X$14019 2352 589 2347 113 2559 112 OAI21_X1
* cell instance $14021 m0 *1 136.04,56
X$14021 1983 2346 810 113 2771 112 OAI21_X1
* cell instance $14022 m0 *1 136.8,56
X$14022 2650 2771 2676 112 113 2772 NAND3_X1
* cell instance $14024 m0 *1 137.75,56
X$14024 2772 1292 2071 112 113 2459 NAND3_X1
* cell instance $14028 r0 *1 134.71,56
X$14028 1204 1109 2347 113 112 2793 OAI21_X2
* cell instance $14029 r0 *1 136.04,56
X$14029 1027 112 113 1047 CLKBUF_X3
* cell instance $14032 r0 *1 137.56,56
X$14032 845 1340 1983 113 112 2879 AND3_X1
* cell instance $14033 r0 *1 138.51,56
X$14033 858 2558 2879 2793 1348 1027 112 113 2880 OAI33_X1
* cell instance $14034 m0 *1 139.84,56
X$14034 2117 1017 112 113 2560 NOR2_X1
* cell instance $14037 m0 *1 140.6,56
X$14037 2560 2677 2352 1017 112 113 2770 AOI22_X1
* cell instance $14039 m0 *1 141.74,56
X$14039 2562 2561 2676 113 2649 112 OAI21_X1
* cell instance $14041 m0 *1 142.69,56
X$14041 2769 2770 2563 811 113 112 2767 OAI22_X1
* cell instance $14044 r0 *1 139.84,56
X$14044 2351 1292 1051 1343 2793 113 112 2877 OAI221_X1
* cell instance $14046 r0 *1 141.17,56
X$14046 2121 113 1051 112 BUF_X4
* cell instance $14047 r0 *1 142.5,56
X$14047 1292 1047 2071 1784 112 113 2987 NAND4_X1
* cell instance $14049 r0 *1 143.64,56
X$14049 1790 2880 2461 1051 113 2881 112 OR4_X2
* cell instance $14050 m0 *1 145.73,56
X$14050 2767 1843 2564 113 2766 112 OAI21_X1
* cell instance $14051 m0 *1 144.78,56
X$14051 1443 112 113 1017 CLKBUF_X3
* cell instance $14052 m0 *1 146.49,56
X$14052 928 2071 112 113 2564 NOR2_X1
* cell instance $14053 m0 *1 147.06,56
X$14053 2565 2521 928 1099 112 113 2765 NAND4_X1
* cell instance $14054 m0 *1 148.01,56
X$14054 1445 113 1182 112 BUF_X4
* cell instance $14058 m0 *1 151.81,56
X$14058 2463 113 2643 112 BUF_X4
* cell instance $14059 m0 *1 153.14,56
X$14059 2566 113 2512 112 BUF_X4
* cell instance $14061 m0 *1 154.66,56
X$14061 2463 2678 113 112 2567 AND2_X1
* cell instance $14062 m0 *1 155.42,56
X$14062 2763 112 113 2761 BUF_X1
* cell instance $14063 m0 *1 155.99,56
X$14063 2909 2760 112 113 2678 NAND2_X1
* cell instance $14064 m0 *1 156.56,56
X$14064 2410 2468 2761 113 112 2679 MUX2_X2
* cell instance $14065 m0 *1 158.27,56
X$14065 2758 2646 2404 2679 2577 2511 112 113 OAI221_X2
* cell instance $14066 m0 *1 160.36,56
X$14066 2757 2354 2645 113 2411 112 OAI21_X1
* cell instance $14067 m0 *1 161.12,56
X$14067 2681 2358 2569 112 2759 113 AOI21_X1
* cell instance $14068 m0 *1 161.88,56
X$14068 2641 2758 2680 112 2644 113 AOI21_X1
* cell instance $14070 r0 *1 144.97,56
X$14070 2649 2881 2071 2765 112 2882 113 NAND4_X2
* cell instance $14071 r0 *1 146.68,56
X$14071 2766 1700 2882 112 113 2883 NAND3_X1
* cell instance $14075 r0 *1 152.19,56
X$14075 2463 113 2403 112 BUF_X4
* cell instance $14076 r0 *1 153.52,56
X$14076 2763 112 113 2909 INV_X8
* cell instance $14077 r0 *1 155.23,56
X$14077 112 2354 113 2885 BUF_X8
* cell instance $14078 r0 *1 157.7,56
X$14078 2797 2464 112 2794 113 OR2_X4
* cell instance $14079 r0 *1 159.41,56
X$14079 3006 3007 112 113 2884 NAND2_X1
* cell instance $14080 r0 *1 159.98,56
X$14080 2795 2796 2680 2569 2572 112 113 2799 AOI221_X1
* cell instance $14081 r0 *1 161.12,56
X$14081 2679 2403 112 113 2980 NOR2_X1
* cell instance $14082 r0 *1 161.69,56
X$14082 2468 113 2878 112 BUF_X4
* cell instance $14083 r0 *1 163.02,56
X$14083 2468 113 2471 112 BUF_X4
* cell instance $14085 m0 *1 163.02,56
X$14085 2756 2682 2871 112 2359 113 AOI21_X1
* cell instance $14086 m0 *1 165.11,56
X$14086 2637 2571 2684 113 2575 112 OAI21_X1
* cell instance $14087 m0 *1 164.16,56
X$14087 2755 2642 2513 2685 112 113 2573 AOI22_X1
* cell instance $14089 r0 *1 164.35,56
X$14089 2472 2515 2358 2683 113 112 2873 OAI22_X1
* cell instance $14090 r0 *1 165.3,56
X$14090 2513 2467 2798 112 113 2745 MUX2_X1
* cell instance $14091 m0 *1 167.2,56
X$14091 2405 113 2680 112 BUF_X4
* cell instance $14092 m0 *1 166.25,56
X$14092 2405 112 113 2684 CLKBUF_X3
* cell instance $14093 m0 *1 168.53,56
X$14093 2512 113 2469 112 BUF_X4
* cell instance $14094 m0 *1 169.86,56
X$14094 2683 2474 2576 112 2686 113 AOI21_X1
* cell instance $14096 r0 *1 166.63,56
X$14096 112 2517 113 2473 BUF_X8
* cell instance $14097 r0 *1 169.1,56
X$14097 2473 112 113 2872 BUF_X2
* cell instance $14098 r0 *1 169.86,56
X$14098 2576 2411 2686 113 2800 112 OAI21_X1
* cell instance $14101 m0 *1 57.57,70
X$14101 3663 3816 2891 3815 3921 113 112 3868 OAI221_X1
* cell instance $14102 r0 *1 57.57,70
X$14102 3868 3920 1865 113 3981 112 OAI21_X1
* cell instance $14104 r0 *1 58.52,70
X$14104 2606 3981 1865 3664 113 112 4250 OAI22_X1
* cell instance $14105 m0 *1 59.28,70
X$14105 3723 2096 2217 112 113 3921 NOR3_X1
* cell instance $14109 m0 *1 60.61,70
X$14109 3818 1898 3457 113 3815 112 OAI21_X1
* cell instance $14112 m0 *1 62.13,70
X$14112 2217 1146 16518 113 112 3769 HA_X1
* cell instance $14113 m0 *1 61.75,70
X$14113 3769 112 113 3818 INV_X1
* cell instance $14114 m0 *1 64.03,70
X$14114 3769 1898 2312 113 3721 112 OAI21_X1
* cell instance $14116 m0 *1 65.36,70
X$14116 3822 3770 3722 3821 112 113 3817 NAND4_X1
* cell instance $14118 m0 *1 66.31,70
X$14118 1727 1113 1952 112 113 3821 NAND3_X1
* cell instance $14121 m0 *1 67.64,70
X$14121 1113 1953 2217 3619 3568 113 112 3822 OAI221_X1
* cell instance $14123 m0 *1 68.78,70
X$14123 3619 3568 1729 113 3723 112 OAI21_X1
* cell instance $14125 m0 *1 70.3,70
X$14125 1729 113 1113 112 BUF_X4
* cell instance $14126 m0 *1 71.63,70
X$14126 1953 113 1727 112 BUF_X4
* cell instance $14137 m0 *1 77.33,70
X$14137 3619 112 113 3771 BUF_X1
* cell instance $14141 m0 *1 84.74,70
X$14141 3985 113 3986 112 BUF_X4
* cell instance $14143 m0 *1 86.26,70
X$14143 3925 113 1729 112 BUF_X4
* cell instance $14145 r0 *1 77.33,70
X$14145 3922 113 4253 112 BUF_X4
* cell instance $14146 r0 *1 78.66,70
X$14146 3922 3984 3871 112 3869 113 AOI21_X1
* cell instance $14147 r0 *1 79.42,70
X$14147 4083 3869 4084 3870 4195 113 112 4028 OAI221_X1
* cell instance $14148 r0 *1 80.56,70
X$14148 4026 3871 3985 113 4730 112 OAI21_X1
* cell instance $14150 r0 *1 81.7,70
X$14150 3725 3872 113 3924 112 XOR2_X2
* cell instance $14151 r0 *1 83.41,70
X$14151 112 3874 3926 113 BUF_X32
* cell instance $14152 m0 *1 88.54,70
X$14152 3873 3248 112 113 3823 NAND2_X1
* cell instance $14153 m0 *1 87.97,70
X$14153 3772 112 113 3872 BUF_X1
* cell instance $14157 m0 *1 91.58,70
X$14157 3826 112 113 3875 CLKBUF_X3
* cell instance $14161 m0 *1 93.86,70
X$14161 3827 113 4031 112 BUF_X4
* cell instance $14164 m0 *1 95.76,70
X$14164 3635 113 3678 112 BUF_X4
* cell instance $14166 m0 *1 97.09,70
X$14166 112 3829 3669 3927 4203 113 DFF_X1
* cell instance $14167 m0 *1 100.32,70
X$14167 3773 3928 120 113 112 1485 OAI21_X2
* cell instance $14168 m0 *1 101.65,70
X$14168 3330 3679 113 3774 112 XOR2_X2
* cell instance $14171 r0 *1 98.99,70
X$14171 3875 4034 113 112 3876 XNOR2_X1
* cell instance $14173 r0 *1 100.32,70
X$14173 3876 3928 112 113 3773 NAND2_X1
* cell instance $14174 r0 *1 100.89,70
X$14174 4036 4037 113 112 4034 XNOR2_X1
* cell instance $14175 r0 *1 102.03,70
X$14175 3635 113 3784 112 BUF_X4
* cell instance $14177 m0 *1 103.93,70
X$14177 3335 113 3776 112 BUF_X4
* cell instance $14179 m0 *1 105.26,70
X$14179 4269 3831 113 166 112 XOR2_X2
* cell instance $14182 m0 *1 107.92,70
X$14182 3932 3578 113 3461 112 XOR2_X2
* cell instance $14184 m0 *1 109.82,70
X$14184 112 3877 3878 3990 1517 113 NOR3_X4
* cell instance $14186 m0 *1 112.67,70
X$14186 3671 113 3932 112 BUF_X4
* cell instance $14187 m0 *1 114,70
X$14187 3577 3776 3777 112 3673 113 AOI21_X1
* cell instance $14189 m0 *1 114.95,70
X$14189 303 3530 112 113 3935 NOR2_X1
* cell instance $14192 m0 *1 116.47,70
X$14192 3674 113 3733 112 BUF_X4
* cell instance $14196 r0 *1 107.54,70
X$14196 3335 112 113 3775 CLKBUF_X3
* cell instance $14197 r0 *1 108.49,70
X$14197 254 3672 3578 112 113 3934 NAND3_X1
* cell instance $14198 r0 *1 109.25,70
X$14198 3934 3933 112 113 3990 NAND2_X2
* cell instance $14199 r0 *1 110.2,70
X$14199 3990 3878 3877 112 113 2290 OR3_X4
* cell instance $14201 r0 *1 113.81,70
X$14201 3935 3776 3287 112 4041 113 AOI21_X1
* cell instance $14203 r0 *1 115.33,70
X$14203 4098 3578 113 259 112 XOR2_X2
* cell instance $14204 r0 *1 117.04,70
X$14204 112 3877 3993 4045 4046 113 AOI21_X4
* cell instance $14206 m0 *1 118.18,70
X$14206 3015 3578 112 113 4099 NOR2_X1
* cell instance $14208 r0 *1 119.51,70
X$14208 3991 4047 112 113 3878 NAND2_X2
* cell instance $14209 m0 *1 120.08,70
X$14209 3541 112 113 3778 INV_X1
* cell instance $14211 m0 *1 120.46,70
X$14211 3778 3937 278 112 113 3779 OR3_X2
* cell instance $14212 m0 *1 121.6,70
X$14212 278 3780 3778 112 113 3741 NAND3_X2
* cell instance $14213 m0 *1 122.93,70
X$14213 112 3781 3833 3832 708 113 NOR3_X4
* cell instance $14215 m0 *1 125.78,70
X$14215 3781 3833 3832 112 113 3677 OR3_X1
* cell instance $14220 r0 *1 121.03,70
X$14220 3780 3679 112 113 3938 NOR2_X1
* cell instance $14221 r0 *1 121.6,70
X$14221 3938 3879 112 113 3943 NAND2_X1
* cell instance $14222 r0 *1 122.17,70
X$14222 3938 3880 112 113 3939 NAND2_X1
* cell instance $14223 r0 *1 122.74,70
X$14223 3879 3678 3679 112 113 3940 NAND3_X1
* cell instance $14224 r0 *1 123.5,70
X$14224 4050 3939 3940 112 3781 113 AOI21_X2
* cell instance $14228 r0 *1 124.83,70
X$14228 3880 3784 3679 112 113 3942 NAND3_X1
* cell instance $14229 r0 *1 125.59,70
X$14229 3992 3942 3943 112 3833 113 AOI21_X2
* cell instance $14232 r0 *1 127.49,70
X$14232 4052 3946 112 113 3832 NAND2_X1
* cell instance $14234 m0 *1 127.87,70
X$14234 3782 3945 113 313 112 XOR2_X2
* cell instance $14236 r0 *1 128.06,70
X$14236 3679 4054 421 112 113 3946 OR3_X1
* cell instance $14237 r0 *1 129.01,70
X$14237 421 3882 3679 112 113 4052 NAND3_X1
* cell instance $14241 r0 *1 131.67,70
X$14241 112 17043 4059 692 4057 113 DFF_X1
* cell instance $14242 m0 *1 136.61,70
X$14242 3736 3680 113 112 3949 XNOR2_X1
* cell instance $14243 m0 *1 133,70
X$14243 112 3108 4057 17239 3881 113 DFF_X2
* cell instance $14245 m0 *1 137.94,70
X$14245 3838 3775 4211 112 3837 113 AOI21_X1
* cell instance $14247 m0 *1 138.89,70
X$14247 163 3783 112 113 3951 NOR2_X1
* cell instance $14249 m0 *1 139.65,70
X$14249 128 3783 112 113 3838 NOR2_X1
* cell instance $14251 m0 *1 140.41,70
X$14251 3840 112 113 3679 CLKBUF_X3
* cell instance $14253 r0 *1 134.9,70
X$14253 3881 4322 113 206 112 XOR2_X2
* cell instance $14254 r0 *1 136.61,70
X$14254 737 3949 112 113 3993 XNOR2_X2
* cell instance $14255 r0 *1 138.51,70
X$14255 3951 3775 3952 112 3950 113 AOI21_X1
* cell instance $14258 m0 *1 141.74,70
X$14258 3681 3775 3841 112 3582 113 AOI21_X1
* cell instance $14259 m0 *1 143.26,70
X$14259 3784 3581 112 113 3956 NAND2_X1
* cell instance $14260 m0 *1 143.83,70
X$14260 3956 3883 3842 112 113 3111 MUX2_X1
* cell instance $14261 m0 *1 145.16,70
X$14261 3784 3682 112 113 3842 NAND2_X1
* cell instance $14263 m0 *1 147.25,70
X$14263 3594 3887 2568 112 3960 113 AOI21_X1
* cell instance $14264 m0 *1 148.01,70
X$14264 3785 112 113 2357 INV_X8
* cell instance $14266 m0 *1 149.91,70
X$14266 3110 3111 112 113 3889 NAND2_X1
* cell instance $14267 m0 *1 150.48,70
X$14267 3845 2566 3005 3591 112 113 3683 AOI22_X2
* cell instance $14269 m0 *1 152.38,70
X$14269 3849 2912 3648 3786 2574 3962 113 112 AOI221_X2
* cell instance $14271 m0 *1 154.66,70
X$14271 2357 113 3590 112 BUF_X4
* cell instance $14272 m0 *1 155.99,70
X$14272 3689 3686 3688 3687 2404 3850 112 113 OAI221_X2
* cell instance $14273 m0 *1 158.08,70
X$14273 112 2912 113 3787 BUF_X8
* cell instance $14274 m0 *1 160.55,70
X$14274 3753 3850 3479 2757 3690 3846 113 112 AOI221_X2
* cell instance $14275 m0 *1 162.64,70
X$14275 2680 3689 112 113 3592 NAND2_X1
* cell instance $14280 r0 *1 142.88,70
X$14280 347 3882 3579 112 113 3955 NAND3_X1
* cell instance $14282 r0 *1 143.83,70
X$14282 3955 347 3884 113 112 3888 OAI21_X2
* cell instance $14283 r0 *1 145.16,70
X$14283 3885 2861 3886 112 113 3995 NOR3_X1
* cell instance $14284 r0 *1 145.92,70
X$14284 3885 2861 3579 112 113 3996 NOR3_X1
* cell instance $14286 r0 *1 147.06,70
X$14286 3997 3998 3888 112 113 3584 OR3_X2
* cell instance $14287 r0 *1 148.2,70
X$14287 3785 112 113 3890 BUF_X1
* cell instance $14289 r0 *1 148.96,70
X$14289 3959 2357 112 113 2647 NAND2_X2
* cell instance $14290 r0 *1 149.91,70
X$14290 2763 112 113 3959 BUF_X1
* cell instance $14294 r0 *1 152.95,70
X$14294 3890 112 113 3845 BUF_X1
* cell instance $14295 r0 *1 153.52,70
X$14295 4061 4042 3961 112 3999 113 AOI21_X1
* cell instance $14296 r0 *1 154.28,70
X$14296 2647 3963 2568 2518 2643 3964 113 112 AOI221_X2
* cell instance $14297 r0 *1 156.37,70
X$14297 3005 3591 112 113 2914 NAND2_X2
* cell instance $14299 r0 *1 157.7,70
X$14299 112 3591 2634 113 BUF_X16
* cell instance $14300 r0 *1 162.45,70
X$14300 112 3887 3270 3292 2976 113 NOR3_X4
* cell instance $14301 m0 *1 165.11,70
X$14301 2405 3005 112 113 3966 NOR2_X2
* cell instance $14302 m0 *1 164.35,70
X$14302 3297 2912 3085 112 3968 113 AOI21_X1
* cell instance $14303 m0 *1 166.06,70
X$14303 3788 2683 4000 112 3848 113 AOI21_X1
* cell instance $14306 r0 *1 165.11,70
X$14306 2684 4056 3891 113 3967 112 OAI21_X1
* cell instance $14307 r0 *1 165.87,70
X$14307 3452 2918 3967 113 112 3965 OAI21_X2
* cell instance $14308 r0 *1 167.2,70
X$14308 3968 2974 4001 113 4053 112 OAI21_X1
* cell instance $14309 r0 *1 167.96,70
X$14309 2916 3848 2575 113 4044 112 OAI21_X1
* cell instance $14310 m0 *1 170.43,70
X$14310 3348 3694 3482 112 3892 113 AOI21_X1
* cell instance $14311 m0 *1 167.96,70
X$14311 3113 3887 3201 112 3385 113 NAND3_X4
* cell instance $14312 m0 *1 171.19,70
X$14312 3962 3692 3077 113 3843 112 OAI21_X1
* cell instance $14313 m0 *1 171.95,70
X$14313 3206 2918 112 113 4166 NOR2_X1
* cell instance $14315 m0 *1 172.71,70
X$14315 3449 4006 3843 3839 113 112 3958 AND4_X2
* cell instance $14317 r0 *1 168.72,70
X$14317 2642 2410 112 113 4002 NAND2_X1
* cell instance $14318 r0 *1 169.29,70
X$14318 3846 3759 3893 113 4049 112 OAI21_X1
* cell instance $14319 r0 *1 170.05,70
X$14319 2797 2685 112 113 4003 NAND2_X1
* cell instance $14320 r0 *1 170.62,70
X$14320 3005 3887 112 113 3659 NOR2_X1
* cell instance $14321 r0 *1 171.19,70
X$14321 3114 4002 112 113 3954 NAND2_X1
* cell instance $14323 r0 *1 171.95,70
X$14323 3965 3893 3790 4044 3077 3894 113 112 AOI221_X2
* cell instance $14324 r0 *1 174.04,70
X$14324 2471 2746 4042 2642 112 113 3695 AOI22_X1
* cell instance $14325 m0 *1 175.18,70
X$14325 3792 3696 3082 2918 3656 113 112 3839 OAI221_X1
* cell instance $14326 m0 *1 174.42,70
X$14326 2360 3791 3482 112 3792 113 AOI21_X1
* cell instance $14328 r0 *1 174.99,70
X$14328 3385 2517 3594 113 112 4004 OAI21_X2
* cell instance $14329 r0 *1 176.32,70
X$14329 2689 2576 3895 113 4162 112 OAI21_X1
* cell instance $14330 m0 *1 176.89,70
X$14330 3836 3761 3757 112 3957 113 AOI21_X2
* cell instance $14332 m0 *1 178.22,70
X$14332 3299 3957 3835 3557 3210 3793 112 113 OAI221_X2
* cell instance $14335 r0 *1 177.84,70
X$14335 112 2963 3294 3112 3836 113 NOR3_X4
* cell instance $14339 r0 *1 180.5,70
X$14339 3299 3954 3836 3588 3953 4113 112 113 3443 OAI33_X1
* cell instance $14340 m0 *1 180.88,70
X$14340 3699 3794 3087 113 3554 112 NOR3_X2
* cell instance $14343 m0 *1 183.73,70
X$14343 112 16888 3795 3701 3264 113 DFF_X1
* cell instance $14348 r0 *1 181.83,70
X$14348 3698 3895 3385 112 3953 113 AOI21_X1
* cell instance $14353 r0 *1 186.96,70
X$14353 3795 112 113 5414 BUF_X2
* cell instance $14357 r0 *1 190.38,70
X$14357 112 17065 3796 3948 3264 113 DFF_X1
* cell instance $14358 m0 *1 193.61,70
X$14358 3796 112 113 2691 BUF_X1
* cell instance $14359 m0 *1 192.66,70
X$14359 3702 112 113 5213 CLKBUF_X3
* cell instance $14361 r0 *1 193.61,70
X$14361 2691 3947 4035 112 113 3948 MUX2_X1
* cell instance $14362 m0 *1 194.75,70
X$14362 3831 3896 112 113 2377 XNOR2_X2
* cell instance $14366 r0 *1 194.94,70
X$14366 3896 3831 113 2379 112 XOR2_X2
* cell instance $14368 m0 *1 202.54,70
X$14368 3704 2627 3705 112 3222 113 NAND3_X4
* cell instance $14369 m0 *1 200.07,70
X$14369 2479 2038 2481 112 3901 113 NAND3_X4
* cell instance $14370 m0 *1 205.01,70
X$14370 2038 112 113 3071 INV_X8
* cell instance $14371 m0 *1 206.72,70
X$14371 1858 2811 2484 112 3897 113 AOI21_X1
* cell instance $14372 m0 *1 207.48,70
X$14372 2377 113 2927 112 BUF_X4
* cell instance $14373 m0 *1 208.81,70
X$14373 2282 3705 3704 112 3898 113 AOI21_X2
* cell instance $14374 m0 *1 210.14,70
X$14374 2725 3899 2498 112 113 3801 NOR3_X1
* cell instance $14375 m0 *1 210.9,70
X$14375 2503 3543 2484 112 113 3936 NOR3_X1
* cell instance $14377 m0 *1 211.85,70
X$14377 2626 2138 3897 3602 2381 3830 112 113 OAI221_X2
* cell instance $14381 r0 *1 203.3,70
X$14381 2044 4117 2626 112 113 3944 NOR3_X1
* cell instance $14383 r0 *1 204.44,70
X$14383 3944 3941 112 113 3929 OR2_X1
* cell instance $14385 r0 *1 205.58,70
X$14385 2048 3898 2156 112 113 3941 NOR3_X1
* cell instance $14389 r0 *1 208.81,70
X$14389 2047 2156 3898 112 113 4030 NOR3_X1
* cell instance $14391 r0 *1 209.95,70
X$14391 3027 3898 2044 112 113 3930 OR3_X1
* cell instance $14392 r0 *1 210.9,70
X$14392 2377 3936 4030 112 113 3900 NOR3_X1
* cell instance $14393 r0 *1 211.66,70
X$14393 2720 1864 112 113 3931 NAND2_X1
* cell instance $14394 r0 *1 212.23,70
X$14394 3900 2377 2618 112 3797 113 AOI21_X2
* cell instance $14396 r0 *1 213.75,70
X$14396 3931 3901 2950 112 113 3903 NAND3_X1
* cell instance $14398 m0 *1 214.32,70
X$14398 3830 2838 3800 2155 3912 4356 113 112 AOI221_X2
* cell instance $14399 m0 *1 217.17,70
X$14399 2251 2379 112 113 3799 NOR2_X1
* cell instance $14401 r0 *1 214.51,70
X$14401 3930 3903 3129 112 113 3902 NAND3_X1
* cell instance $14405 r0 *1 216.6,70
X$14405 3929 3799 2833 3797 2595 3923 113 112 AOI221_X2
* cell instance $14406 m0 *1 218.88,70
X$14406 3130 3801 3612 2595 3824 3825 112 113 3802 OAI33_X1
* cell instance $14407 m0 *1 218.12,70
X$14407 3494 2503 2146 112 113 3824 NOR3_X1
* cell instance $14408 m0 *1 220.21,70
X$14408 3802 3706 3799 112 113 3904 OR3_X1
* cell instance $14411 m0 *1 222.11,70
X$14411 3804 3620 112 113 3803 NOR2_X1
* cell instance $14413 m0 *1 222.87,70
X$14413 2398 1940 2260 112 3918 113 AOI21_X1
* cell instance $14414 m0 *1 223.63,70
X$14414 2705 1940 112 113 3805 NAND2_X1
* cell instance $14416 m0 *1 224.96,70
X$14416 3503 3065 3147 112 113 4134 NOR3_X1
* cell instance $14419 r0 *1 218.88,70
X$14419 4010 3433 113 112 4017 AND2_X1
* cell instance $14420 r0 *1 219.64,70
X$14420 2259 2588 3901 113 4020 112 OAI21_X1
* cell instance $14421 r0 *1 220.4,70
X$14421 2588 1864 112 113 4140 NOR2_X1
* cell instance $14422 r0 *1 220.97,70
X$14422 112 3923 4119 4018 3904 3803 3502 3237 113 AOI222_X2
* cell instance $14424 r0 *1 223.82,70
X$14424 3805 2044 112 113 4011 NOR2_X1
* cell instance $14427 r0 *1 225.34,70
X$14427 3809 3129 4349 3221 3707 4121 112 113 OAI221_X2
* cell instance $14428 m0 *1 226.29,70
X$14428 3819 3915 3221 112 113 3804 NOR3_X1
* cell instance $14431 m0 *1 227.24,70
X$14431 2398 3543 2587 2607 112 113 3915 NOR4_X1
* cell instance $14434 r0 *1 227.81,70
X$14434 2828 3709 3908 113 4238 112 OAI21_X1
* cell instance $14437 m0 *1 228.57,70
X$14437 3711 3720 112 113 3912 NAND2_X1
* cell instance $14438 r0 *1 229.33,70
X$14438 112 3612 2626 3901 2157 113 AOI21_X4
* cell instance $14440 m0 *1 229.52,70
X$14440 3720 3710 3806 113 3401 112 OAI21_X1
* cell instance $14441 m0 *1 230.47,70
X$14441 3234 3034 112 113 3806 NOR2_X1
* cell instance $14443 m0 *1 231.61,70
X$14443 1940 2377 2587 112 3910 113 AOI21_X1
* cell instance $14446 r0 *1 231.8,70
X$14446 2379 113 3130 112 BUF_X4
* cell instance $14447 m0 *1 232.94,70
X$14447 3905 3400 3808 2828 3907 3809 112 113 OAI221_X2
* cell instance $14453 r0 *1 233.13,70
X$14453 4013 3910 2828 113 3907 112 OAI21_X1
* cell instance $14454 r0 *1 233.89,70
X$14454 3807 3130 112 113 4013 NOR2_X1
* cell instance $14455 r0 *1 234.46,70
X$14455 2588 3906 112 113 3908 NAND2_X1
* cell instance $14474 r0 *1 15.01,92.4
X$14474 6015 112 113 5941 BUF_X1
* cell instance $14476 m0 *1 15.2,92.4
X$14476 5604 112 113 6297 BUF_X1
* cell instance $14479 r0 *1 16.34,92.4
X$14479 112 17133 6015 5908 5133 113 DFF_X1
* cell instance $14480 m0 *1 17.1,92.4
X$14480 112 16757 5567 5884 5133 113 DFF_X1
* cell instance $14487 r0 *1 20.9,92.4
X$14487 112 5137 3661 113 BUF_X16
* cell instance $14488 m0 *1 22.42,92.4
X$14488 5886 5515 4840 112 113 5134 MUX2_X1
* cell instance $14492 m0 *1 26.22,92.4
X$14492 4840 5886 112 113 4346 NAND2_X1
* cell instance $14493 m0 *1 24.89,92.4
X$14493 5516 113 4614 112 BUF_X4
* cell instance $14495 r0 *1 25.65,92.4
X$14495 5256 113 4182 112 BUF_X4
* cell instance $14498 m0 *1 27.17,92.4
X$14498 4181 3973 5256 112 113 5887 NAND3_X1
* cell instance $14499 r0 *1 27.17,92.4
X$14499 5605 112 113 4412 CLKBUF_X3
* cell instance $14500 r0 *1 28.12,92.4
X$14500 4346 4181 4610 112 113 6018 NOR3_X1
* cell instance $14501 m0 *1 28.5,92.4
X$14501 3851 5887 4619 112 5889 113 AOI21_X1
* cell instance $14503 m0 *1 29.26,92.4
X$14503 5605 113 4065 112 BUF_X4
* cell instance $14505 m0 *1 30.78,92.4
X$14505 5892 4840 5891 112 113 6020 MUX2_X1
* cell instance $14507 m0 *1 32.3,92.4
X$14507 4614 4354 5137 112 113 5786 MUX2_X1
* cell instance $14508 m0 *1 33.63,92.4
X$14508 5678 4520 4181 4411 4616 113 112 5894 OAI221_X1
* cell instance $14511 m0 *1 35.72,92.4
X$14511 4412 5735 5821 113 112 5896 AND3_X1
* cell instance $14512 m0 *1 36.67,92.4
X$14512 5896 4074 5786 112 4468 113 AOI21_X1
* cell instance $14515 m0 *1 38.38,92.4
X$14515 4294 4347 3715 113 5821 112 OAI21_X1
* cell instance $14516 m0 *1 39.14,92.4
X$14516 5678 3973 5610 112 113 5824 MUX2_X1
* cell instance $14518 m0 *1 40.66,92.4
X$14518 6030 112 113 5368 INV_X4
* cell instance $14519 m0 *1 41.61,92.4
X$14519 5611 4783 4475 113 5823 112 NOR3_X2
* cell instance $14520 m0 *1 42.94,92.4
X$14520 4526 5824 5825 113 5341 112 OAI21_X1
* cell instance $14521 m0 *1 43.7,92.4
X$14521 5612 113 4298 112 BUF_X4
* cell instance $14522 m0 *1 45.03,92.4
X$14522 5826 113 4294 112 BUF_X4
* cell instance $14523 m0 *1 46.36,92.4
X$14523 5686 113 4300 112 BUF_X4
* cell instance $14524 m0 *1 47.69,92.4
X$14524 4298 4300 4072 112 113 5734 NAND3_X1
* cell instance $14525 m0 *1 48.45,92.4
X$14525 5686 5439 5612 112 4192 113 NAND3_X4
* cell instance $14528 r0 *1 29.07,92.4
X$14528 6018 5889 112 113 6022 NOR2_X1
* cell instance $14530 r0 *1 29.83,92.4
X$14530 5820 4181 5610 112 113 5061 MUX2_X1
* cell instance $14532 r0 *1 31.54,92.4
X$14532 4181 6020 5894 113 6021 112 OAI21_X1
* cell instance $14534 r0 *1 32.68,92.4
X$14534 5516 5454 5735 113 5891 112 OAI21_X1
* cell instance $14536 r0 *1 33.82,92.4
X$14536 3851 4354 5735 113 6025 112 OAI21_X1
* cell instance $14539 r0 *1 35.15,92.4
X$14539 5364 5945 4182 112 113 5944 NAND3_X1
* cell instance $14540 r0 *1 35.91,92.4
X$14540 5822 4892 5682 112 4129 113 AOI21_X1
* cell instance $14541 r0 *1 36.67,92.4
X$14541 3976 5821 5364 112 6117 113 AOI21_X1
* cell instance $14542 r0 *1 37.43,92.4
X$14542 6029 5822 5262 113 4615 112 OAI21_X1
* cell instance $14543 r0 *1 38.19,92.4
X$14543 4062 4354 4192 113 6031 112 OAI21_X1
* cell instance $14544 r0 *1 38.95,92.4
X$14544 5945 3563 4411 113 112 4071 OAI21_X4
* cell instance $14545 r0 *1 41.42,92.4
X$14545 5516 4411 5732 113 5950 112 OAI21_X1
* cell instance $14547 r0 *1 42.37,92.4
X$14547 5823 4074 5824 112 6038 113 AOI21_X1
* cell instance $14548 r0 *1 43.13,92.4
X$14548 4702 6034 5256 112 113 5822 NOR3_X1
* cell instance $14549 r0 *1 43.89,92.4
X$14549 112 5951 5439 4298 4300 113 AOI21_X4
* cell instance $14550 r0 *1 46.36,92.4
X$14550 4298 4300 3916 112 113 5952 NAND3_X1
* cell instance $14552 r0 *1 47.5,92.4
X$14552 5953 113 4347 112 BUF_X4
* cell instance $14554 r0 *1 49.21,92.4
X$14554 5826 5953 3916 113 5732 112 OAI21_X1
* cell instance $14557 r0 *1 50.92,92.4
X$14557 3762 3866 6039 112 5903 113 AOI21_X1
* cell instance $14558 m0 *1 52.63,92.4
X$14558 4067 4241 5737 113 5827 112 OAI21_X1
* cell instance $14559 m0 *1 51.3,92.4
X$14559 5892 4074 5906 112 113 5617 MUX2_X1
* cell instance $14560 m0 *1 53.39,92.4
X$14560 4897 4067 4074 112 113 5737 NAND3_X1
* cell instance $14564 r0 *1 52.25,92.4
X$14564 3866 5736 5827 4024 5903 113 112 6042 OAI221_X1
* cell instance $14566 r0 *1 53.77,92.4
X$14566 4137 3715 112 113 6044 NAND2_X1
* cell instance $14567 r0 *1 54.34,92.4
X$14567 5226 6042 6044 112 4478 113 AOI21_X1
* cell instance $14569 m0 *1 54.53,92.4
X$14569 4072 4613 5735 113 5906 112 OAI21_X1
* cell instance $14570 m0 *1 55.48,92.4
X$14570 5612 5686 4290 112 113 5735 NAND3_X2
* cell instance $14572 m0 *1 58.33,92.4
X$14572 112 16743 6049 4613 4795 113 DFF_X1
* cell instance $14576 r0 *1 55.1,92.4
X$14576 5328 3865 112 113 6046 NOR2_X1
* cell instance $14580 r0 *1 58.33,92.4
X$14580 4795 112 113 17172 INV_X2
* cell instance $14581 r0 *1 58.9,92.4
X$14581 112 17118 6051 4024 4795 113 DFF_X1
* cell instance $14584 r0 *1 63.08,92.4
X$14584 6049 113 5955 112 BUF_X4
* cell instance $14585 m0 *1 64.41,92.4
X$14585 4432 4541 16489 113 112 5619 HA_X1
* cell instance $14589 m0 *1 68.59,92.4
X$14589 5804 3922 5811 112 5911 113 AOI21_X1
* cell instance $14591 m0 *1 70.11,92.4
X$14591 5828 5914 112 113 5830 NAND2_X1
* cell instance $14592 m0 *1 70.68,92.4
X$14592 5829 4633 4085 112 113 5531 NAND3_X1
* cell instance $14593 m0 *1 71.44,92.4
X$14593 5374 5088 5739 5014 5812 5918 113 112 AOI221_X2
* cell instance $14594 m0 *1 73.53,92.4
X$14594 4194 112 113 5923 INV_X2
* cell instance $14595 m0 *1 74.1,92.4
X$14595 5528 5621 5714 113 5533 112 NOR3_X2
* cell instance $14596 m0 *1 75.43,92.4
X$14596 4253 5701 5484 4425 4424 5831 112 113 OAI221_X2
* cell instance $14597 m0 *1 77.52,92.4
X$14597 5819 5960 5745 4800 5927 5924 113 112 AOI221_X2
* cell instance $14598 m0 *1 79.61,92.4
X$14598 6068 4196 5600 112 5927 113 AOI21_X2
* cell instance $14599 m0 *1 80.94,92.4
X$14599 5540 5926 112 113 4306 NOR2_X2
* cell instance $14600 m0 *1 81.89,92.4
X$14600 6072 4530 4308 112 5272 113 AOI21_X2
* cell instance $14602 m0 *1 83.41,92.4
X$14602 5739 5930 5738 112 113 5740 OR3_X4
* cell instance $14603 m0 *1 85.5,92.4
X$14603 112 5740 5817 5963 5243 5808 113 AND4_X4
* cell instance $14604 m0 *1 87.97,92.4
X$14604 5624 5741 5743 4253 5382 5834 113 112 AOI221_X2
* cell instance $14605 m0 *1 90.06,92.4
X$14605 5282 5818 5742 112 5833 113 AOI21_X1
* cell instance $14606 m0 *1 90.82,92.4
X$14606 5744 4904 112 113 5745 NAND2_X1
* cell instance $14608 r0 *1 64.41,92.4
X$14608 5954 3875 113 5908 112 XOR2_X2
* cell instance $14610 r0 *1 66.5,92.4
X$14610 4634 4085 112 113 6055 NAND2_X1
* cell instance $14611 r0 *1 67.07,92.4
X$14611 4629 5956 112 113 6054 NOR2_X1
* cell instance $14612 r0 *1 67.64,92.4
X$14612 5096 112 113 4085 INV_X4
* cell instance $14617 r0 *1 68.78,92.4
X$14617 5828 112 113 4305 CLKBUF_X3
* cell instance $14618 r0 *1 69.73,92.4
X$14618 6055 5529 5706 5695 112 113 5697 AOI22_X1
* cell instance $14619 r0 *1 70.68,92.4
X$14619 4530 4305 5830 113 6057 112 OAI21_X1
* cell instance $14620 r0 *1 71.44,92.4
X$14620 5957 4976 5832 112 5811 113 AOI21_X1
* cell instance $14621 r0 *1 72.2,92.4
X$14621 4366 4305 4026 112 113 6059 NAND3_X1
* cell instance $14622 r0 *1 72.96,92.4
X$14622 5959 3871 6059 113 5961 112 OAI21_X1
* cell instance $14624 r0 *1 73.91,92.4
X$14624 4636 4976 112 4981 113 NAND2_X4
* cell instance $14625 r0 *1 75.62,92.4
X$14625 5831 5958 5377 4734 6065 5925 113 112 AOI221_X2
* cell instance $14626 r0 *1 77.71,92.4
X$14626 112 5101 5833 5925 5924 5918 113 OR4_X4
* cell instance $14628 r0 *1 80.56,92.4
X$14628 112 5741 4480 5094 5832 113 AOI21_X4
* cell instance $14629 r0 *1 83.03,92.4
X$14629 4088 3988 5475 113 5536 112 OAI21_X1
* cell instance $14630 r0 *1 83.79,92.4
X$14630 112 4089 113 6077 BUF_X8
* cell instance $14631 r0 *1 86.26,92.4
X$14631 4489 4482 4629 5090 4368 6085 113 112 AOI221_X2
* cell instance $14633 r0 *1 88.73,92.4
X$14633 4803 6084 6085 113 5742 112 OAI21_X1
* cell instance $14634 r0 *1 89.49,92.4
X$14634 4199 4738 4497 4157 5538 113 112 6091 OAI221_X1
* cell instance $14636 r0 *1 91.01,92.4
X$14636 3987 4308 112 113 5968 NAND2_X1
* cell instance $14637 r0 *1 91.58,92.4
X$14637 5011 4978 3987 112 5967 113 AOI21_X1
* cell instance $14638 m0 *1 91.96,92.4
X$14638 5744 4148 112 113 5739 NAND2_X2
* cell instance $14640 m0 *1 92.91,92.4
X$14640 5533 5159 4899 113 5746 112 NOR3_X2
* cell instance $14641 m0 *1 94.24,92.4
X$14641 5814 5388 4871 5940 5813 113 112 5937 OAI221_X1
* cell instance $14644 r0 *1 92.53,92.4
X$14644 5743 112 113 4497 CLKBUF_X3
* cell instance $14645 r0 *1 93.48,92.4
X$14645 3983 4738 4800 113 5940 112 OAI21_X1
* cell instance $14648 m0 *1 95.95,92.4
X$14648 5746 4157 5938 112 5936 113 AOI21_X1
* cell instance $14650 m0 *1 96.71,92.4
X$14650 5926 4433 4637 112 5938 113 AOI21_X1
* cell instance $14651 m0 *1 97.47,92.4
X$14651 5939 5730 5739 113 5747 112 NOR3_X2
* cell instance $14655 r0 *1 97.09,92.4
X$14655 4800 6088 4883 112 5969 113 AOI21_X1
* cell instance $14656 r0 *1 97.85,92.4
X$14656 4431 5970 5937 112 5110 113 AOI21_X1
* cell instance $14657 r0 *1 98.61,92.4
X$14657 4308 4425 4538 112 5835 113 AOI21_X1
* cell instance $14658 m0 *1 99.94,92.4
X$14658 5834 4497 5936 112 5749 113 AOI21_X1
* cell instance $14659 m0 *1 99.18,92.4
X$14659 4809 5749 5836 113 5750 112 OAI21_X1
* cell instance $14663 r0 *1 99.37,92.4
X$14663 5835 5957 4734 113 5748 112 OAI21_X1
* cell instance $14665 m0 *1 103.55,92.4
X$14665 112 16889 5934 5808 5751 113 DFF_X1
* cell instance $14669 m0 *1 107.73,92.4
X$14669 5934 112 113 3436 CLKBUF_X3
* cell instance $14672 r0 *1 106.97,92.4
X$14672 112 5933 5633 6109 5751 113 DFF_X1
* cell instance $14673 m0 *1 109.25,92.4
X$14673 5932 5807 112 113 5805 XNOR2_X2
* cell instance $14675 m0 *1 111.15,92.4
X$14675 3579 6215 112 113 5932 XNOR2_X2
* cell instance $14678 r0 *1 110.2,92.4
X$14678 5933 5932 113 112 5752 XNOR2_X1
* cell instance $14680 m0 *1 114.38,92.4
X$14680 112 5399 113 5179 BUF_X8
* cell instance $14683 m0 *1 117.04,92.4
X$14683 222 3335 5931 112 113 5636 MUX2_X1
* cell instance $14684 m0 *1 118.37,92.4
X$14684 112 5179 5177 113 BUF_X16
* cell instance $14685 m0 *1 123.12,92.4
X$14685 5838 5839 5803 112 113 3925 OR3_X2
* cell instance $14686 m0 *1 124.26,92.4
X$14686 5754 5928 5634 112 113 5840 NAND3_X1
* cell instance $14687 m0 *1 125.02,92.4
X$14687 4545 5802 113 112 5842 XNOR2_X1
* cell instance $14689 m0 *1 126.35,92.4
X$14689 5843 112 113 5802 BUF_X1
* cell instance $14690 m0 *1 126.92,92.4
X$14690 4510 3747 112 113 5977 XNOR2_X2
* cell instance $14694 r0 *1 114.95,92.4
X$14694 4919 5972 112 113 5392 XOR2_X1
* cell instance $14695 r0 *1 116.09,92.4
X$14695 3573 5973 112 113 5931 XOR2_X1
* cell instance $14698 r0 *1 119.13,92.4
X$14698 112 17094 5974 6114 4652 113 DFF_X1
* cell instance $14700 r0 *1 122.74,92.4
X$14700 6111 5754 112 113 5841 NAND2_X1
* cell instance $14701 r0 *1 123.31,92.4
X$14701 5842 6112 5840 112 5838 113 AOI21_X1
* cell instance $14706 r0 *1 124.26,92.4
X$14706 5929 5975 5841 112 5839 113 AOI21_X1
* cell instance $14708 r0 *1 125.21,92.4
X$14708 4545 5843 112 113 5929 XOR2_X1
* cell instance $14709 r0 *1 126.35,92.4
X$14709 6111 5976 112 113 6112 NAND2_X1
* cell instance $14710 r0 *1 126.92,92.4
X$14710 5843 112 113 5755 BUF_X1
* cell instance $14713 r0 *1 128.44,92.4
X$14713 5977 112 113 5976 BUF_X1
* cell instance $14716 m0 *1 129.2,92.4
X$14716 112 5241 113 3747 BUF_X8
* cell instance $14717 m0 *1 131.86,92.4
X$14717 5638 4545 112 113 5801 XNOR2_X2
* cell instance $14719 m0 *1 133.95,92.4
X$14719 4545 5638 113 5922 112 XOR2_X2
* cell instance $14721 m0 *1 135.85,92.4
X$14721 3881 5798 112 113 5920 XOR2_X1
* cell instance $14722 m0 *1 136.99,92.4
X$14722 3881 5756 113 112 5921 XNOR2_X1
* cell instance $14723 m0 *1 138.13,92.4
X$14723 5756 112 113 5798 BUF_X2
* cell instance $14724 m0 *1 138.89,92.4
X$14724 112 4510 113 5917 BUF_X8
* cell instance $14725 m0 *1 141.36,92.4
X$14725 112 16740 5917 5915 5919 113 DFF_X1
* cell instance $14731 m0 *1 156.18,92.4
X$14731 5916 5851 5849 112 113 5795 MUX2_X1
* cell instance $14737 r0 *1 130.15,92.4
X$14737 6107 5638 113 5844 112 XOR2_X2
* cell instance $14740 r0 *1 133.76,92.4
X$14740 5587 3470 112 113 6105 XNOR2_X2
* cell instance $14741 r0 *1 135.66,92.4
X$14741 5756 5843 112 113 5978 XNOR2_X2
* cell instance $14744 r0 *1 138.13,92.4
X$14744 6103 113 5638 112 BUF_X4
* cell instance $14748 r0 *1 148.96,92.4
X$14748 5846 6099 5982 5983 5845 112 113 OAI211_X2
* cell instance $14749 r0 *1 150.67,92.4
X$14749 5912 6095 6204 6145 6093 113 112 5796 OAI221_X1
* cell instance $14750 r0 *1 151.81,92.4
X$14750 6094 6092 6096 112 6095 113 AOI21_X1
* cell instance $14753 r0 *1 154.47,92.4
X$14753 5846 5982 112 113 5847 NAND2_X1
* cell instance $14754 r0 *1 155.04,92.4
X$14754 5986 5847 5848 5846 6149 113 112 6092 OAI221_X1
* cell instance $14756 r0 *1 156.94,92.4
X$14756 6090 6089 5988 6083 112 113 5849 AOI22_X1
* cell instance $14758 r0 *1 159.41,92.4
X$14758 6086 5990 5852 5850 6082 113 112 6083 OAI221_X1
* cell instance $14761 r0 *1 165.11,92.4
X$14761 6076 6078 5851 113 5912 112 OAI21_X1
* cell instance $14762 m0 *1 165.68,92.4
X$14762 112 5694 5758 17230 5853 113 DFF_X2
* cell instance $14765 m0 *1 172.33,92.4
X$14765 112 16937 5910 5759 5758 113 DFF_X1
* cell instance $14766 m0 *1 175.56,92.4
X$14766 5910 113 4659 112 BUF_X4
* cell instance $14769 m0 *1 177.84,92.4
X$14769 5793 5854 113 160 112 XOR2_X2
* cell instance $14774 r0 *1 167.96,92.4
X$14774 5994 5993 113 202 112 XOR2_X2
* cell instance $14777 r0 *1 177.27,92.4
X$14777 5855 5179 6070 112 113 6071 NAND3_X1
* cell instance $14778 r0 *1 178.03,92.4
X$14778 5855 5909 6071 113 6191 112 OAI21_X1
* cell instance $14779 r0 *1 178.79,92.4
X$14779 5401 5993 112 113 5909 NAND2_X1
* cell instance $14780 r0 *1 179.36,92.4
X$14780 112 5855 5856 5907 5758 113 DFF_X1
* cell instance $14782 m0 *1 179.93,92.4
X$14782 5760 112 113 5793 BUF_X1
* cell instance $14784 m0 *1 181.45,92.4
X$14784 6418 5854 113 2363 112 XOR2_X2
* cell instance $14790 r0 *1 182.59,92.4
X$14790 5856 5995 5883 112 113 5907 MUX2_X1
* cell instance $14793 m0 *1 184.3,92.4
X$14793 5761 5791 113 112 5646 XNOR2_X1
* cell instance $14794 r0 *1 184.68,92.4
X$14794 5858 6273 113 112 6069 XNOR2_X1
* cell instance $14797 m0 *1 185.82,92.4
X$14797 5762 3442 113 112 5791 XNOR2_X1
* cell instance $14798 m0 *1 187.15,92.4
X$14798 5762 5858 112 113 5789 XOR2_X1
* cell instance $14799 m0 *1 188.29,92.4
X$14799 5792 5762 113 112 5788 XNOR2_X1
* cell instance $14800 m0 *1 189.43,92.4
X$14800 5414 2919 113 5778 112 XOR2_X2
* cell instance $14801 m0 *1 191.14,92.4
X$14801 5457 5788 113 112 6062 XNOR2_X1
* cell instance $14806 r0 *1 187.91,92.4
X$14806 6164 5414 113 112 6066 XNOR2_X1
* cell instance $14808 r0 *1 189.81,92.4
X$14808 401 112 113 16724 INV_X4
* cell instance $14810 r0 *1 190.95,92.4
X$14810 5857 6062 112 113 5902 XNOR2_X2
* cell instance $14812 m0 *1 195.32,92.4
X$14812 5457 5764 113 112 6060 XNOR2_X1
* cell instance $14813 m0 *1 193.42,92.4
X$14813 3436 5309 112 113 5763 XNOR2_X2
* cell instance $14817 r0 *1 193.99,92.4
X$14817 5858 5305 113 112 6061 XNOR2_X1
* cell instance $14820 r0 *1 195.7,92.4
X$14820 6183 6060 113 112 5901 XNOR2_X1
* cell instance $14821 r0 *1 196.84,92.4
X$14821 6273 5762 113 5859 112 XOR2_X2
* cell instance $14822 m0 *1 198.93,92.4
X$14822 3438 5650 112 113 5860 NAND2_X1
* cell instance $14823 m0 *1 197.6,92.4
X$14823 5905 5902 5904 112 113 5900 MUX2_X1
* cell instance $14825 m0 *1 199.69,92.4
X$14825 3438 5649 112 113 6058 NAND2_X1
* cell instance $14826 m0 *1 200.26,92.4
X$14826 5650 3873 5651 112 113 5784 OR3_X2
* cell instance $14829 r0 *1 198.74,92.4
X$14829 5860 6058 5902 113 112 5862 MUX2_X2
* cell instance $14830 r0 *1 200.45,92.4
X$14830 5437 5901 5231 113 112 5998 MUX2_X2
* cell instance $14832 m0 *1 201.78,92.4
X$14832 5858 5649 113 5675 112 XOR2_X2
* cell instance $14835 r0 *1 203.3,92.4
X$14835 5998 5449 113 6166 112 XOR2_X2
* cell instance $14836 m0 *1 205.2,92.4
X$14836 5900 113 5652 112 BUF_X4
* cell instance $14837 m0 *1 203.87,92.4
X$14837 5766 113 5861 112 BUF_X4
* cell instance $14838 m0 *1 206.53,92.4
X$14838 5421 5563 5652 113 112 5863 OAI21_X2
* cell instance $14840 r0 *1 205.01,92.4
X$14840 5861 5862 112 5865 113 NAND2_X4
* cell instance $14841 r0 *1 206.72,92.4
X$14841 112 5999 113 5861 BUF_X8
* cell instance $14842 m0 *1 208.43,92.4
X$14842 5560 113 5767 112 BUF_X4
* cell instance $14844 m0 *1 209.76,92.4
X$14844 5865 113 5446 112 BUF_X4
* cell instance $14845 m0 *1 211.09,92.4
X$14845 112 5561 5652 5563 5677 113 NOR3_X4
* cell instance $14847 m0 *1 213.94,92.4
X$14847 5767 113 5770 112 BUF_X4
* cell instance $14849 r0 *1 209.19,92.4
X$14849 5861 5862 5562 112 113 6052 NAND3_X2
* cell instance $14851 r0 *1 210.71,92.4
X$14851 5862 113 5875 112 BUF_X4
* cell instance $14852 r0 *1 212.04,92.4
X$14852 5653 5865 5895 113 6330 112 OAI21_X1
* cell instance $14853 r0 *1 212.8,92.4
X$14853 5561 113 5867 112 BUF_X4
* cell instance $14854 r0 *1 214.13,92.4
X$14854 5875 5867 5999 112 5869 113 NAND3_X4
* cell instance $14856 m0 *1 215.65,92.4
X$14856 5897 5871 112 113 5898 NAND2_X1
* cell instance $14857 r0 *1 216.6,92.4
X$14857 6003 5869 5870 112 6000 113 AOI21_X1
* cell instance $14859 m0 *1 216.6,92.4
X$14859 5658 5769 5446 112 5897 113 AOI21_X1
* cell instance $14861 m0 *1 218.69,92.4
X$14861 112 5653 5873 113 BUF_X16
* cell instance $14862 m0 *1 217.74,92.4
X$14862 5450 5565 112 113 5872 NOR2_X2
* cell instance $14864 r0 *1 218.12,92.4
X$14864 6040 6003 112 113 6037 NAND2_X1
* cell instance $14865 r0 *1 218.69,92.4
X$14865 5424 5781 6002 113 6040 112 OAI21_X1
* cell instance $14866 r0 *1 219.45,92.4
X$14866 5653 112 113 5771 INV_X4
* cell instance $14867 r0 *1 220.4,92.4
X$14867 6035 5871 5877 5866 5873 6036 113 112 AOI221_X2
* cell instance $14868 r0 *1 222.49,92.4
X$14868 112 6026 5873 5999 5875 113 AOI21_X4
* cell instance $14869 m0 *1 226.29,92.4
X$14869 5660 5659 5769 112 113 5893 NOR3_X1
* cell instance $14870 m0 *1 223.82,92.4
X$14870 5771 5660 5659 113 112 6032 OAI21_X4
* cell instance $14871 m0 *1 227.05,92.4
X$14871 5893 6026 5878 113 5890 112 OAI21_X1
* cell instance $14873 r0 *1 224.96,92.4
X$14873 112 5661 5659 5660 6313 113 NOR3_X4
* cell instance $14875 r0 *1 227.81,92.4
X$14875 5659 5660 5872 113 6009 112 OAI21_X1
* cell instance $14876 m0 *1 228.95,92.4
X$14876 5772 112 113 5769 CLKBUF_X3
* cell instance $14877 m0 *1 228.19,92.4
X$14877 5770 5780 5771 112 113 5888 NAND3_X1
* cell instance $14880 r0 *1 228.95,92.4
X$14880 5780 5890 5779 112 6010 113 AOI21_X1
* cell instance $14881 r0 *1 229.71,92.4
X$14881 5878 5888 5568 112 6024 113 AOI21_X1
* cell instance $14882 m0 *1 233.51,92.4
X$14882 112 16805 5882 5885 5429 113 DFF_X1
* cell instance $14883 m0 *1 230.28,92.4
X$14883 112 16738 5777 5778 5429 113 DFF_X1
* cell instance $14887 r0 *1 230.85,92.4
X$14887 5427 5564 16671 113 112 6011 HA_X1
* cell instance $14891 r0 *1 234.08,92.4
X$14891 4841 112 113 5429 CLKBUF_X3
* cell instance $14898 r0 *1 237.12,92.4
X$14898 6012 112 113 6016 BUF_X1
* cell instance $14901 r0 *1 238.26,92.4
X$14901 5879 112 113 5883 BUF_X1
* cell instance $14902 m0 *1 239.21,92.4
X$14902 5882 112 113 5880 BUF_X1
* cell instance $14903 m0 *1 238.64,92.4
X$14903 5777 112 113 5881 BUF_X1
* cell instance $14913 r0 *1 10.26,120.4
X$14913 8546 112 113 6486 BUF_X2
* cell instance $14919 r0 *1 12.16,120.4
X$14919 8471 112 113 8548 BUF_X1
* cell instance $14921 r0 *1 13.11,120.4
X$14921 8470 112 113 8549 BUF_X1
* cell instance $14924 r0 *1 14.25,120.4
X$14924 8547 112 113 7697 BUF_X1
* cell instance $14925 m0 *1 14.63,120.4
X$14925 8304 112 113 8472 BUF_X1
* cell instance $14928 m0 *1 16.72,120.4
X$14928 8472 112 113 6584 INV_X1
* cell instance $14930 m0 *1 17.86,120.4
X$14930 112 16930 8600 6581 8232 113 DFF_X1
* cell instance $14934 r0 *1 14.82,120.4
X$14934 112 17107 8471 8398 8232 113 DFF_X1
* cell instance $14935 r0 *1 18.05,120.4
X$14935 112 17102 8470 6903 8232 113 DFF_X1
* cell instance $14936 r0 *1 21.28,120.4
X$14936 8232 112 113 17169 INV_X2
* cell instance $14938 r0 *1 22.61,120.4
X$14938 8236 112 113 8638 BUF_X2
* cell instance $14939 r0 *1 23.37,120.4
X$14939 8416 7881 8383 113 8373 112 OAI21_X1
* cell instance $14941 m0 *1 23.75,120.4
X$14941 7633 7229 7632 112 8550 113 NAND3_X4
* cell instance $14942 r0 *1 24.13,120.4
X$14942 112 8552 7216 7632 7633 113 AOI21_X4
* cell instance $14943 m0 *1 29.26,120.4
X$14943 112 8306 7970 8374 8555 113 NOR3_X4
* cell instance $14944 m0 *1 26.6,120.4
X$14944 112 7707 8305 8478 8015 113 NOR3_X4
* cell instance $14945 m0 *1 31.92,120.4
X$14945 8383 8308 8417 113 112 8479 OAI21_X4
* cell instance $14946 m0 *1 34.39,120.4
X$14946 112 7296 8379 7391 8308 113 NOR3_X4
* cell instance $14947 m0 *1 37.05,120.4
X$14947 7707 7302 7444 112 113 8419 OR3_X1
* cell instance $14948 m0 *1 38,120.4
X$14948 7793 7391 7296 113 112 8245 OAI21_X2
* cell instance $14950 m0 *1 39.52,120.4
X$14950 7224 112 113 7965 CLKBUF_X3
* cell instance $14951 m0 *1 40.47,120.4
X$14951 7302 7637 7011 112 8751 113 AOI21_X2
* cell instance $14952 m0 *1 41.8,120.4
X$14952 6910 7632 7633 112 8417 113 AOI21_X2
* cell instance $14953 m0 *1 43.13,120.4
X$14953 8191 7394 112 113 8180 NAND2_X1
* cell instance $14954 m0 *1 43.7,120.4
X$14954 8248 8250 8186 113 8420 112 NOR3_X2
* cell instance $14955 m0 *1 45.03,120.4
X$14955 8421 8488 112 113 8560 NAND2_X1
* cell instance $14956 m0 *1 45.6,120.4
X$14956 8386 7703 7584 113 112 8391 OAI21_X2
* cell instance $14957 m0 *1 46.93,120.4
X$14957 7635 7619 8184 112 113 8387 NAND3_X2
* cell instance $14958 m0 *1 48.26,120.4
X$14958 8312 8311 8313 7715 8490 8422 113 112 AOI221_X2
* cell instance $14959 m0 *1 50.35,120.4
X$14959 112 6967 7296 7391 5947 113 NOR3_X4
* cell instance $14960 m0 *1 53.01,120.4
X$14960 8423 8189 8016 112 113 8392 NAND3_X1
* cell instance $14961 m0 *1 53.77,120.4
X$14961 8424 8383 112 113 8105 NOR2_X1
* cell instance $14962 m0 *1 54.34,120.4
X$14962 7002 6965 113 112 8424 XNOR2_X1
* cell instance $14963 m0 *1 55.48,120.4
X$14963 8256 7588 8191 112 8493 113 AOI21_X1
* cell instance $14966 r0 *1 26.98,120.4
X$14966 7312 7887 7965 113 8477 112 OAI21_X1
* cell instance $14967 r0 *1 27.74,120.4
X$14967 8308 112 113 8601 BUF_X2
* cell instance $14968 r0 *1 28.5,120.4
X$14968 8371 8479 8014 112 113 8604 NAND3_X2
* cell instance $14969 r0 *1 29.83,120.4
X$14969 112 8637 8478 7588 7445 113 AOI21_X4
* cell instance $14971 r0 *1 32.68,120.4
X$14971 112 8479 7630 8418 8238 8477 113 OAI211_X4
* cell instance $14972 r0 *1 35.91,120.4
X$14972 7216 112 113 8379 INV_X8
* cell instance $14973 r0 *1 37.62,120.4
X$14973 8191 7588 112 113 8418 NOR2_X2
* cell instance $14975 r0 *1 38.76,120.4
X$14975 7394 7220 8247 113 8485 112 OAI21_X1
* cell instance $14976 r0 *1 39.52,120.4
X$14976 112 7706 113 7127 BUF_X8
* cell instance $14977 r0 *1 41.99,120.4
X$14977 7075 112 113 7884 BUF_X2
* cell instance $14978 r0 *1 42.75,120.4
X$14978 7622 8485 7499 7008 112 113 8489 AOI22_X2
* cell instance $14980 r0 *1 44.65,120.4
X$14980 112 8559 8185 8489 8561 8562 7850 8700 113 OAI222_X2
* cell instance $14981 r0 *1 47.31,120.4
X$14981 7443 8191 6968 113 8615 112 OAI21_X1
* cell instance $14982 r0 *1 48.07,120.4
X$14982 112 6910 7641 113 BUF_X16
* cell instance $14983 r0 *1 52.82,120.4
X$14983 8184 7011 7127 112 113 8188 MUX2_X1
* cell instance $14984 r0 *1 54.15,120.4
X$14984 7848 8387 7641 7228 112 113 8190 AOI22_X1
* cell instance $14985 r0 *1 55.1,120.4
X$14985 8108 7965 8424 112 8565 113 AOI21_X1
* cell instance $14987 r0 *1 56.24,120.4
X$14987 8566 7971 8492 8314 8425 113 112 8621 OAI221_X1
* cell instance $14989 m0 *1 56.62,120.4
X$14989 8395 8394 8426 113 8425 112 OAI21_X1
* cell instance $14990 m0 *1 58.9,120.4
X$14990 7802 7011 7710 113 8427 112 OAI21_X1
* cell instance $14993 r0 *1 57.38,120.4
X$14993 8108 7965 8493 112 8567 113 AOI21_X1
* cell instance $14994 r0 *1 58.14,120.4
X$14994 7011 7503 112 113 8315 NOR2_X1
* cell instance $14995 r0 *1 58.71,120.4
X$14995 8427 8491 8262 8495 7179 8619 113 112 AOI221_X2
* cell instance $14996 m0 *1 60.99,120.4
X$14996 7188 8428 112 113 8495 XNOR2_X2
* cell instance $15001 m0 *1 63.27,120.4
X$15001 8428 7188 113 7802 112 XOR2_X2
* cell instance $15004 m0 *1 68.97,120.4
X$15004 8195 7188 113 6581 112 XOR2_X2
* cell instance $15008 r0 *1 64.41,120.4
X$15008 8568 6860 113 8398 112 XOR2_X2
* cell instance $15009 r0 *1 66.12,120.4
X$15009 8620 5273 113 6903 112 XOR2_X2
* cell instance $15015 r0 *1 70.11,120.4
X$15015 5371 8568 113 112 8429 XNOR2_X1
* cell instance $15016 m0 *1 71.25,120.4
X$15016 8175 8430 8403 113 112 7233 MUX2_X2
* cell instance $15020 r0 *1 71.25,120.4
X$15020 8429 8569 113 112 8430 XNOR2_X1
* cell instance $15024 r0 *1 74.86,120.4
X$15024 7645 8622 112 113 8499 XOR2_X1
* cell instance $15025 m0 *1 75.05,120.4
X$15025 7230 8499 113 112 8031 XNOR2_X1
* cell instance $15027 m0 *1 76.19,120.4
X$15027 112 3438 113 5231 BUF_X8
* cell instance $15028 m0 *1 78.66,120.4
X$15028 8319 8762 112 113 8318 XNOR2_X2
* cell instance $15031 r0 *1 77.52,120.4
X$15031 8432 5473 113 112 8623 XNOR2_X1
* cell instance $15035 m0 *1 82.84,120.4
X$15035 8433 8034 112 113 8505 XNOR2_X2
* cell instance $15036 m0 *1 80.94,120.4
X$15036 7598 8196 112 113 8034 XNOR2_X2
* cell instance $15037 m0 *1 84.74,120.4
X$15037 8651 8505 112 113 8406 XNOR2_X2
* cell instance $15040 r0 *1 81.51,120.4
X$15040 8431 8625 113 112 8502 XNOR2_X1
* cell instance $15041 r0 *1 82.65,120.4
X$15041 8431 8625 112 113 8405 XOR2_X1
* cell instance $15045 r0 *1 86.26,120.4
X$15045 8626 8432 113 7813 112 XOR2_X2
* cell instance $15046 m0 *1 87.21,120.4
X$15046 8433 4508 8321 112 113 8320 NAND3_X1
* cell instance $15048 m0 *1 87.97,120.4
X$15048 8321 5177 8433 112 113 8278 OR3_X1
* cell instance $15049 m0 *1 88.92,120.4
X$15049 112 8323 8322 8279 7404 113 NOR3_X4
* cell instance $15050 m0 *1 91.58,120.4
X$15050 8324 8434 8321 112 113 8407 NAND3_X1
* cell instance $15051 m0 *1 92.34,120.4
X$15051 8407 8324 8325 113 112 8323 OAI21_X2
* cell instance $15055 r0 *1 87.97,120.4
X$15055 7230 7813 113 112 8572 XNOR2_X1
* cell instance $15058 r0 *1 90.25,120.4
X$15058 112 8324 8726 8509 7732 113 DFF_X1
* cell instance $15060 r0 *1 93.67,120.4
X$15060 8434 8267 112 113 8325 NAND2_X1
* cell instance $15063 r0 *1 94.81,120.4
X$15063 112 8435 7732 17243 8202 113 DFF_X2
* cell instance $15064 m0 *1 98.04,120.4
X$15064 8201 8202 113 8327 112 XOR2_X2
* cell instance $15067 r0 *1 98.42,120.4
X$15067 8202 8201 113 112 8573 XNOR2_X1
* cell instance $15068 r0 *1 99.56,120.4
X$15068 8327 7901 113 112 8574 XNOR2_X1
* cell instance $15069 m0 *1 101.08,120.4
X$15069 7974 8411 8512 112 8436 113 AOI21_X1
* cell instance $15070 m0 *1 100.13,120.4
X$15070 8200 8327 7901 112 113 8512 OR3_X1
* cell instance $15073 r0 *1 101.08,120.4
X$15073 7930 8573 7902 112 8575 113 AOI21_X1
* cell instance $15074 r0 *1 101.84,120.4
X$15074 7901 8435 113 112 8437 AND2_X1
* cell instance $15075 m0 *1 102.98,120.4
X$15075 7901 8327 7902 112 113 8411 NAND3_X1
* cell instance $15076 m0 *1 102.22,120.4
X$15076 8206 8437 113 112 8413 AND2_X1
* cell instance $15079 r0 *1 102.6,120.4
X$15079 7867 8437 113 112 8576 AND2_X1
* cell instance $15082 m0 *1 107.16,120.4
X$15082 112 8515 8629 8413 8519 113 DFF_X1
* cell instance $15084 m0 *1 111.34,120.4
X$15084 8438 3337 113 112 8630 XNOR2_X1
* cell instance $15085 m0 *1 112.48,120.4
X$15085 8515 3337 112 113 3952 XNOR2_X2
* cell instance $15089 r0 *1 110.39,120.4
X$15089 8865 8629 113 112 8438 XNOR2_X1
* cell instance $15091 r0 *1 111.72,120.4
X$15091 7748 8630 113 112 8835 XNOR2_X1
* cell instance $15095 r0 *1 114.19,120.4
X$15095 8738 3945 113 8439 112 XOR2_X2
* cell instance $15096 m0 *1 115.9,120.4
X$15096 2848 8414 113 112 8415 XNOR2_X1
* cell instance $15097 m0 *1 114.76,120.4
X$15097 8439 8415 113 112 6981 XNOR2_X1
* cell instance $15101 m0 *1 117.42,120.4
X$15101 3945 8414 112 113 8517 XOR2_X1
* cell instance $15103 m0 *1 120.84,120.4
X$15103 112 8329 7408 113 BUF_X16
* cell instance $15104 m0 *1 125.59,120.4
X$15104 8526 3776 7821 112 8412 113 AOI21_X1
* cell instance $15106 m0 *1 127.87,120.4
X$15106 8527 112 113 8153 CLKBUF_X3
* cell instance $15107 m0 *1 128.82,120.4
X$15107 8529 4209 8528 112 113 8296 MUX2_X1
* cell instance $15111 r0 *1 117.61,120.4
X$15111 8518 4209 8517 112 113 8520 MUX2_X1
* cell instance $15112 r0 *1 118.94,120.4
X$15112 112 17061 8521 8520 8519 113 DFF_X1
* cell instance $15113 r0 *1 122.17,120.4
X$15113 8521 113 3945 112 BUF_X4
* cell instance $15120 r0 *1 125.97,120.4
X$15120 8523 6244 112 113 8526 NOR2_X1
* cell instance $15125 m0 *1 131.48,120.4
X$15125 112 5401 3527 113 BUF_X16
* cell instance $15127 m0 *1 136.23,120.4
X$15127 8331 8442 8332 112 113 8159 MUX2_X1
* cell instance $15130 m0 *1 141.36,120.4
X$15130 8339 112 113 6153 CLKBUF_X2
* cell instance $15131 m0 *1 142.12,120.4
X$15131 5979 8538 113 112 8333 AND2_X1
* cell instance $15134 r0 *1 133.95,120.4
X$15134 8441 8434 8330 112 113 8532 NAND3_X1
* cell instance $15135 r0 *1 134.71,120.4
X$15135 8532 8441 8533 113 112 7822 OAI21_X2
* cell instance $15139 r0 *1 137.37,120.4
X$15139 8578 194 8534 112 113 8579 MUX2_X1
* cell instance $15142 r0 *1 140.41,120.4
X$15142 7534 6920 6922 113 112 6924 OAI21_X4
* cell instance $15143 r0 *1 142.88,120.4
X$15143 7996 6920 6922 113 112 7824 OAI21_X4
* cell instance $15144 m0 *1 143.45,120.4
X$15144 7919 7534 7528 7416 112 113 8210 OR4_X1
* cell instance $15146 m0 *1 144.59,120.4
X$15146 8580 113 6920 112 BUF_X4
* cell instance $15147 m0 *1 145.92,120.4
X$15147 6148 8280 8540 112 113 6921 MUX2_X1
* cell instance $15148 m0 *1 147.25,120.4
X$15148 6934 8214 6658 6895 113 112 8538 OAI22_X1
* cell instance $15149 m0 *1 148.2,120.4
X$15149 8298 112 113 17167 INV_X2
* cell instance $15150 m0 *1 148.77,120.4
X$15150 8046 8400 6156 6353 6688 113 112 8336 OAI221_X1
* cell instance $15151 m0 *1 149.91,120.4
X$15151 8280 8540 112 113 8046 NOR2_X1
* cell instance $15155 r0 *1 145.92,120.4
X$15155 112 6640 7030 8443 8338 113 AOI21_X4
* cell instance $15157 r0 *1 148.77,120.4
X$15157 8539 112 113 8298 CLKBUF_X3
* cell instance $15158 r0 *1 149.72,120.4
X$15158 8628 8215 7923 7667 112 113 8543 NAND4_X1
* cell instance $15159 r0 *1 150.67,120.4
X$15159 6640 6691 7922 113 8628 112 OAI21_X1
* cell instance $15160 m0 *1 151.05,120.4
X$15160 7109 6932 112 113 8337 NOR2_X1
* cell instance $15162 m0 *1 151.62,120.4
X$15162 8444 8337 6156 8340 5981 113 112 8401 OAI221_X1
* cell instance $15163 m0 *1 152.76,120.4
X$15163 8443 8338 8339 112 113 7912 NAND3_X1
* cell instance $15164 m0 *1 153.52,120.4
X$15164 8446 7532 8401 113 8335 112 OAI21_X1
* cell instance $15165 m0 *1 154.28,120.4
X$15165 7667 5985 7912 113 8399 112 OAI21_X1
* cell instance $15167 m0 *1 155.23,120.4
X$15167 6407 7533 7662 113 8400 112 OAI21_X1
* cell instance $15168 m0 *1 155.99,120.4
X$15168 8341 7254 113 8447 112 AND2_X4
* cell instance $15169 m0 *1 157.7,120.4
X$15169 8341 7915 112 113 8291 NOR2_X2
* cell instance $15170 m0 *1 158.65,120.4
X$15170 112 7470 8291 8340 6349 8283 113 AOI22_X4
* cell instance $15171 m0 *1 161.88,120.4
X$15171 8541 8449 7923 113 8448 112 OAI21_X1
* cell instance $15172 m0 *1 162.64,120.4
X$15172 7866 7917 8582 113 8733 112 OAI21_X1
* cell instance $15173 m0 *1 163.4,120.4
X$15173 6261 8158 6548 112 113 NOR2_X4
* cell instance $15174 m0 *1 165.11,120.4
X$15174 7596 113 7662 112 BUF_X4
* cell instance $15175 m0 *1 166.44,120.4
X$15175 6267 113 7119 112 BUF_X4
* cell instance $15176 m0 *1 167.77,120.4
X$15176 112 8173 6268 113 BUF_X32
* cell instance $15177 m0 *1 177.08,120.4
X$15177 8219 113 6080 112 BUF_X4
* cell instance $15179 r0 *1 151.43,120.4
X$15179 8543 8336 8050 112 113 8409 NAND3_X1
* cell instance $15180 r0 *1 152.19,120.4
X$15180 7912 5985 112 113 8445 NAND2_X1
* cell instance $15181 r0 *1 152.76,120.4
X$15181 7922 8445 7205 6353 6894 112 113 8446 AOI221_X1
* cell instance $15182 r0 *1 153.9,120.4
X$15182 7121 7919 112 113 8449 NOR2_X1
* cell instance $15183 r0 *1 154.47,120.4
X$15183 8443 6267 8338 112 113 7254 NAND3_X2
* cell instance $15184 r0 *1 155.8,120.4
X$15184 7824 8447 8581 6407 7534 8545 113 112 AOI221_X2
* cell instance $15185 r0 *1 157.89,120.4
X$15185 6261 8158 112 113 8053 NAND2_X1
* cell instance $15186 r0 *1 158.46,120.4
X$15186 112 7996 113 7775 BUF_X8
* cell instance $15187 r0 *1 160.93,120.4
X$15187 7910 7996 7872 112 6642 113 NAND3_X4
* cell instance $15188 r0 *1 163.4,120.4
X$15188 8544 7987 8173 6255 7778 8170 113 112 AOI221_X2
* cell instance $15189 r0 *1 165.49,120.4
X$15189 7470 5985 6541 112 8541 113 AOI21_X1
* cell instance $15190 r0 *1 166.25,120.4
X$15190 6924 8537 7778 8665 7667 8618 112 113 OAI221_X2
* cell instance $15191 r0 *1 168.34,120.4
X$15191 8283 8161 112 113 6697 NOR2_X2
* cell instance $15193 r0 *1 169.48,120.4
X$15193 112 8536 113 7777 BUF_X8
* cell instance $15194 r0 *1 171.95,120.4
X$15194 7827 7030 8537 112 113 NOR2_X4
* cell instance $15195 r0 *1 173.66,120.4
X$15195 8280 113 7604 112 BUF_X4
* cell instance $15196 r0 *1 174.99,120.4
X$15196 8616 3932 113 8450 112 XOR2_X2
* cell instance $15197 r0 *1 176.7,120.4
X$15197 7467 7980 8453 112 113 8584 MUX2_X1
* cell instance $15198 r0 *1 178.03,120.4
X$15198 6470 8536 8280 112 8218 113 AOI21_X2
* cell instance $15199 m0 *1 179.55,120.4
X$15199 8451 8343 8452 113 8389 112 OAI21_X1
* cell instance $15200 m0 *1 178.79,120.4
X$15200 8451 5177 8535 112 113 8452 NAND3_X1
* cell instance $15204 r0 *1 179.55,120.4
X$15204 5213 6625 113 8473 112 XOR2_X2
* cell instance $15210 m0 *1 182.4,120.4
X$15210 5637 8454 112 113 8345 NOR2_X1
* cell instance $15212 m0 *1 182.97,120.4
X$15212 8345 8344 112 113 8525 NAND2_X1
* cell instance $15213 m0 *1 183.54,120.4
X$15213 8345 8346 112 113 8530 NAND2_X1
* cell instance $15215 m0 *1 184.3,120.4
X$15215 8346 6773 8454 112 113 8455 NAND3_X1
* cell instance $15216 m0 *1 185.06,120.4
X$15216 7856 112 113 8385 BUF_X1
* cell instance $15217 m0 *1 185.63,120.4
X$15217 6164 7854 113 112 8524 XNOR2_X1
* cell instance $15219 m0 *1 186.96,120.4
X$15219 112 8522 8347 8382 6705 113 DFF_X1
* cell instance $15220 m0 *1 190.19,120.4
X$15220 8347 5995 8366 112 113 8382 MUX2_X1
* cell instance $15223 m0 *1 194.75,120.4
X$15223 112 16896 8456 8514 8221 113 DFF_X1
* cell instance $15225 m0 *1 198.17,120.4
X$15225 4841 112 113 8221 CLKBUF_X3
* cell instance $15226 m0 *1 199.12,120.4
X$15226 8513 113 6164 112 BUF_X4
* cell instance $15227 m0 *1 200.45,120.4
X$15227 7748 3952 113 112 8060 XNOR2_X1
* cell instance $15228 m0 *1 201.59,120.4
X$15228 8221 112 113 16471 CLKBUF_X1
* cell instance $15230 m0 *1 202.35,120.4
X$15230 8348 6708 113 7748 112 XOR2_X2
* cell instance $15232 m0 *1 204.25,120.4
X$15232 8363 8295 8610 112 113 8510 MUX2_X1
* cell instance $15236 r0 *1 182.21,120.4
X$15236 8344 7362 8454 112 113 8531 NAND3_X1
* cell instance $15237 r0 *1 182.97,120.4
X$15237 8524 8530 8531 112 8586 113 AOI21_X2
* cell instance $15240 r0 *1 184.87,120.4
X$15240 8264 8455 8525 112 8614 113 AOI21_X2
* cell instance $15243 r0 *1 186.77,120.4
X$15243 112 7362 113 6138 BUF_X8
* cell instance $15247 r0 *1 191.71,120.4
X$15247 8456 5322 3438 113 112 8516 MUX2_X2
* cell instance $15250 r0 *1 195.13,120.4
X$15250 8456 5995 8364 112 113 8514 MUX2_X1
* cell instance $15253 r0 *1 197.6,120.4
X$15253 112 16952 8513 8457 8221 113 DFF_X1
* cell instance $15255 r0 *1 201.21,120.4
X$15255 8365 7930 112 113 8611 NAND2_X1
* cell instance $15258 r0 *1 203.49,120.4
X$15258 8348 3952 113 112 8610 XNOR2_X1
* cell instance $15259 r0 *1 204.63,120.4
X$15259 112 17073 8511 8510 7043 113 DFF_X1
* cell instance $15260 r0 *1 207.86,120.4
X$15260 8511 112 113 8348 CLKBUF_X3
* cell instance $15262 m0 *1 211.09,120.4
X$15262 8352 6721 8381 112 8507 113 AOI21_X1
* cell instance $15263 m0 *1 209.76,120.4
X$15263 6852 5446 5427 112 113 8381 MUX2_X1
* cell instance $15264 m0 *1 211.85,120.4
X$15264 8507 7431 112 113 8380 NOR2_X1
* cell instance $15268 r0 *1 210.9,120.4
X$15268 8606 8380 8349 112 113 8508 OR3_X1
* cell instance $15270 r0 *1 212.04,120.4
X$15270 8508 8609 8504 8375 113 112 8457 AND4_X2
* cell instance $15271 m0 *1 214.13,120.4
X$15271 5658 6003 6429 112 8503 113 AOI21_X1
* cell instance $15272 m0 *1 212.8,120.4
X$15272 8350 6028 8503 112 113 8506 MUX2_X1
* cell instance $15274 r0 *1 213.37,120.4
X$15274 8506 7431 8223 113 8501 112 OAI21_X1
* cell instance $15275 r0 *1 214.13,120.4
X$15275 8486 8501 8500 113 8504 112 OAI21_X1
* cell instance $15276 r0 *1 214.89,120.4
X$15276 8351 7448 6460 112 113 8500 NOR3_X1
* cell instance $15277 m0 *1 215.46,120.4
X$15277 5658 6453 6171 112 113 8352 NOR3_X1
* cell instance $15279 m0 *1 216.22,120.4
X$15279 6283 8497 8355 112 8225 113 AOI21_X1
* cell instance $15280 m0 *1 216.98,120.4
X$15280 8354 6562 112 113 8497 NAND2_X1
* cell instance $15282 m0 *1 217.74,120.4
X$15282 7325 8496 8355 113 7937 112 OAI21_X1
* cell instance $15283 m0 *1 218.5,120.4
X$15283 6026 5564 6436 112 8496 113 AOI21_X1
* cell instance $15286 r0 *1 215.65,120.4
X$15286 8061 8588 6721 112 113 8498 NOR3_X1
* cell instance $15288 r0 *1 216.6,120.4
X$15288 8498 8494 7448 112 113 8353 NOR3_X1
* cell instance $15290 r0 *1 218.88,120.4
X$15290 7942 8701 6835 112 113 8606 NOR3_X1
* cell instance $15292 r0 *1 219.83,120.4
X$15292 5769 7048 7051 113 8698 112 OAI21_X1
* cell instance $15293 r0 *1 220.59,120.4
X$15293 8458 112 113 8494 INV_X1
* cell instance $15295 m0 *1 222.49,120.4
X$15295 8356 8357 8459 6425 8358 113 112 8375 OAI221_X1
* cell instance $15296 m0 *1 221.16,120.4
X$15296 6287 5877 6453 113 112 8458 OAI21_X2
* cell instance $15297 m0 *1 223.63,120.4
X$15297 7448 6331 112 113 8459 NOR2_X1
* cell instance $15299 m0 *1 224.39,120.4
X$15299 6026 6313 7051 112 113 8487 NOR3_X1
* cell instance $15300 m0 *1 225.15,120.4
X$15300 7838 8372 8487 6835 8369 8368 112 113 8486 OAI33_X1
* cell instance $15301 m0 *1 226.48,120.4
X$15301 7574 7325 112 113 8369 NOR2_X1
* cell instance $15302 m0 *1 227.05,120.4
X$15302 6026 5877 7051 113 8461 112 OAI21_X1
* cell instance $15304 m0 *1 228,120.4
X$15304 7280 6714 7325 112 8482 113 AOI21_X1
* cell instance $15306 r0 *1 221.35,120.4
X$15306 6283 112 113 7448 CLKBUF_X3
* cell instance $15309 r0 *1 223.25,120.4
X$15309 6721 5895 6591 112 8590 113 AOI21_X1
* cell instance $15311 r0 *1 224.2,120.4
X$15311 6453 6313 6287 112 113 8460 NOR3_X1
* cell instance $15313 r0 *1 225.15,120.4
X$15313 6432 6835 6460 112 113 8694 NAND3_X1
* cell instance $15314 r0 *1 225.91,120.4
X$15314 6723 6311 6432 113 8605 112 OAI21_X1
* cell instance $15316 r0 *1 227.05,120.4
X$15316 6283 8461 8593 112 8462 113 AOI21_X1
* cell instance $15317 r0 *1 227.81,120.4
X$15317 8605 8462 8481 6432 113 112 6972 OAI22_X2
* cell instance $15318 m0 *1 229.52,120.4
X$15318 7298 113 6831 112 BUF_X4
* cell instance $15319 m0 *1 229.14,120.4
X$15319 8091 112 113 6019 INV_X1
* cell instance $15320 m0 *1 230.85,120.4
X$15320 6283 8480 8464 112 8481 113 AOI21_X1
* cell instance $15321 m0 *1 231.61,120.4
X$15321 8367 6562 112 113 8464 NAND2_X1
* cell instance $15322 m0 *1 232.18,120.4
X$15322 8465 6733 8228 112 7297 113 AOI21_X1
* cell instance $15323 m0 *1 232.94,120.4
X$15323 7298 6003 112 113 8475 NAND2_X1
* cell instance $15326 r0 *1 229.52,120.4
X$15326 6292 8483 6723 6733 8482 113 112 8602 OAI221_X1
* cell instance $15327 r0 *1 230.66,120.4
X$15327 8463 6313 112 113 8594 NOR2_X1
* cell instance $15328 r0 *1 231.23,120.4
X$15328 8594 8475 6283 7689 8474 113 112 8465 OAI221_X1
* cell instance $15330 r0 *1 232.56,120.4
X$15330 5446 112 113 7689 CLKBUF_X3
* cell instance $15334 m0 *1 63.65,72.8
X$15334 112 16893 4082 3567 4423 113 DFF_X1
* cell instance $15339 r0 *1 63.84,72.8
X$15339 4193 112 113 5954 CLKBUF_X3
* cell instance $15350 r0 *1 70.3,72.8
X$15350 112 4085 3983 113 BUF_X16
* cell instance $15351 m0 *1 72.77,72.8
X$15351 4083 3983 16496 113 112 4194 HA_X1
* cell instance $15353 m0 *1 74.67,72.8
X$15353 4306 3985 4147 112 113 4149 MUX2_X1
* cell instance $15354 m0 *1 76,72.8
X$15354 112 4252 4083 113 BUF_X16
* cell instance $15355 m0 *1 80.75,72.8
X$15355 4085 112 113 4088 CLKBUF_X3
* cell instance $15356 m0 *1 81.7,72.8
X$15356 3984 113 3870 112 BUF_X4
* cell instance $15357 m0 *1 83.03,72.8
X$15357 3871 4088 112 113 4087 NOR2_X2
* cell instance $15358 m0 *1 83.98,72.8
X$15358 3922 4089 112 113 4153 NAND2_X1
* cell instance $15359 m0 *1 84.55,72.8
X$15359 3985 3984 112 113 4086 NOR2_X1
* cell instance $15363 r0 *1 76,72.8
X$15363 4305 4085 4366 112 113 4256 MUX2_X1
* cell instance $15364 r0 *1 77.33,72.8
X$15364 3982 4633 4194 112 113 4198 MUX2_X1
* cell instance $15365 r0 *1 78.66,72.8
X$15365 4028 4196 4149 112 113 4255 MUX2_X1
* cell instance $15367 r0 *1 80.75,72.8
X$15367 112 4199 4256 4311 4086 4197 4087 4151 113 AOI222_X2
* cell instance $15369 r0 *1 83.6,72.8
X$15369 4198 3988 113 4258 112 AND2_X4
* cell instance $15370 r0 *1 85.31,72.8
X$15370 112 4259 4258 4091 4090 113 AOI21_X4
* cell instance $15371 m0 *1 86.83,72.8
X$15371 3871 112 113 4491 CLKBUF_X3
* cell instance $15372 m0 *1 85.5,72.8
X$15372 4026 3985 4029 112 113 4090 MUX2_X1
* cell instance $15373 m0 *1 87.78,72.8
X$15373 4095 3983 16555 113 112 4154 HA_X1
* cell instance $15374 m0 *1 89.68,72.8
X$15374 3987 112 113 4091 CLKBUF_X3
* cell instance $15375 m0 *1 90.63,72.8
X$15375 4154 3988 4156 113 4092 112 OAI21_X1
* cell instance $15376 m0 *1 91.39,72.8
X$15376 3988 4088 112 113 4155 NOR2_X1
* cell instance $15377 m0 *1 91.96,72.8
X$15377 4093 3988 113 112 4264 AND2_X1
* cell instance $15379 m0 *1 92.91,72.8
X$15379 4093 3987 112 113 4094 OR2_X1
* cell instance $15380 m0 *1 93.67,72.8
X$15380 4157 3983 16514 113 112 4093 HA_X1
* cell instance $15381 m0 *1 95.57,72.8
X$15381 3986 113 4095 112 BUF_X4
* cell instance $15384 r0 *1 87.78,72.8
X$15384 3982 3871 4088 112 113 4201 MUX2_X1
* cell instance $15386 r0 *1 89.49,72.8
X$15386 4260 4201 4153 4155 4196 4202 112 113 OAI221_X2
* cell instance $15387 r0 *1 91.58,72.8
X$15387 4153 4317 3870 112 113 4262 NOR3_X1
* cell instance $15388 r0 *1 92.34,72.8
X$15388 4262 4264 4380 112 113 4261 NOR3_X1
* cell instance $15390 r0 *1 93.48,72.8
X$15390 4388 4094 4380 112 113 4602 NAND3_X1
* cell instance $15392 r0 *1 97.28,72.8
X$15392 112 4265 4204 4032 4203 113 DFF_X1
* cell instance $15394 m0 *1 98.8,72.8
X$15394 4054 113 3465 112 BUF_X4
* cell instance $15395 m0 *1 100.7,72.8
X$15395 3831 4204 113 112 4037 XNOR2_X1
* cell instance $15397 m0 *1 101.84,72.8
X$15397 3831 4205 113 112 4158 XNOR2_X1
* cell instance $15398 m0 *1 102.98,72.8
X$15398 121 4389 4158 112 113 4159 MUX2_X1
* cell instance $15399 m0 *1 104.31,72.8
X$15399 112 16891 4160 4159 4203 113 DFF_X1
* cell instance $15400 m0 *1 107.54,72.8
X$15400 4160 113 3831 112 BUF_X4
* cell instance $15403 r0 *1 101.27,72.8
X$15403 4036 4265 113 4205 112 XOR2_X2
* cell instance $15405 r0 *1 103.74,72.8
X$15405 4542 3775 4205 112 4096 113 AOI21_X1
* cell instance $15409 r0 *1 106.59,72.8
X$15409 112 17134 4207 2306 4097 113 DFF_X1
* cell instance $15410 m0 *1 109.44,72.8
X$15410 3578 4161 254 112 113 3933 OR3_X1
* cell instance $15414 m0 *1 112.67,72.8
X$15414 112 16921 4274 4041 4097 113 DFF_X1
* cell instance $15416 m0 *1 116.09,72.8
X$15416 4098 4043 113 112 3633 XNOR2_X1
* cell instance $15417 m0 *1 117.23,72.8
X$15417 3879 4163 3578 112 113 4046 NAND3_X2
* cell instance $15418 m0 *1 118.56,72.8
X$15418 4099 3880 112 113 4045 NAND2_X1
* cell instance $15419 m0 *1 119.13,72.8
X$15419 4099 3993 3879 112 113 4047 NAND3_X1
* cell instance $15420 m0 *1 119.89,72.8
X$15420 3993 3880 4163 3578 112 113 3991 NAND4_X1
* cell instance $15426 r0 *1 112.67,72.8
X$15426 4273 4208 113 3287 112 XOR2_X2
* cell instance $15429 r0 *1 115.33,72.8
X$15429 4274 112 113 4395 CLKBUF_X3
* cell instance $15430 r0 *1 116.28,72.8
X$15430 4167 4319 112 113 4275 XOR2_X1
* cell instance $15431 r0 *1 117.42,72.8
X$15431 301 4209 4275 112 113 4396 MUX2_X1
* cell instance $15435 r0 *1 121.22,72.8
X$15435 2764 4172 112 113 3880 XNOR2_X2
* cell instance $15436 m0 *1 122.93,72.8
X$15436 4098 4101 113 112 4050 XNOR2_X1
* cell instance $15437 m0 *1 121.22,72.8
X$15437 4172 2764 113 3879 112 XOR2_X2
* cell instance $15438 m0 *1 124.07,72.8
X$15438 4100 4051 113 112 4043 XNOR2_X1
* cell instance $15439 m0 *1 125.21,72.8
X$15439 4098 4101 112 113 3992 XOR2_X1
* cell instance $15441 r0 *1 123.12,72.8
X$15441 3880 4100 113 112 4277 XNOR2_X1
* cell instance $15449 r0 *1 125.02,72.8
X$15449 3531 4277 113 112 4401 XNOR2_X1
* cell instance $15451 m0 *1 127.87,72.8
X$15451 3747 4167 113 218 112 XOR2_X2
* cell instance $15452 m0 *1 126.73,72.8
X$15452 2764 3782 113 112 4051 XNOR2_X1
* cell instance $15454 m0 *1 130.34,72.8
X$15454 419 3784 4321 112 113 4168 MUX2_X1
* cell instance $15459 r0 *1 128.25,72.8
X$15459 133 3530 112 113 4210 NOR2_X1
* cell instance $15465 r0 *1 132.05,72.8
X$15465 4167 4168 112 113 4048 XNOR2_X2
* cell instance $15466 m0 *1 133,72.8
X$15466 4059 113 4545 112 BUF_X4
* cell instance $15468 m0 *1 134.33,72.8
X$15468 165 3783 112 113 4280 NOR2_X1
* cell instance $15472 m0 *1 137.37,72.8
X$15472 112 16782 4170 3950 4057 113 DFF_X1
* cell instance $15473 m0 *1 140.6,72.8
X$15473 4170 112 113 3196 CLKBUF_X3
* cell instance $15474 m0 *1 141.55,72.8
X$15474 3289 3196 113 4171 112 XOR2_X2
* cell instance $15476 m0 *1 143.45,72.8
X$15476 737 4172 113 112 3885 XNOR2_X1
* cell instance $15477 m0 *1 144.59,72.8
X$15477 3882 3886 112 113 3884 NAND2_X1
* cell instance $15478 m0 *1 145.16,72.8
X$15478 3995 4173 3996 112 113 3997 MUX2_X1
* cell instance $15481 r0 *1 134.33,72.8
X$15481 4279 112 113 4057 CLKBUF_X3
* cell instance $15482 r0 *1 135.28,72.8
X$15482 4057 112 113 17204 INV_X1
* cell instance $15485 r0 *1 139.46,72.8
X$15485 3376 737 113 112 4406 XNOR2_X1
* cell instance $15488 r0 *1 141.55,72.8
X$15488 3736 3109 112 113 4101 XNOR2_X2
* cell instance $15490 r0 *1 143.64,72.8
X$15490 737 4172 112 113 4212 XOR2_X1
* cell instance $15491 r0 *1 144.78,72.8
X$15491 3579 112 113 3886 INV_X1
* cell instance $15492 r0 *1 145.16,72.8
X$15492 4212 3780 3886 112 113 4281 NOR3_X1
* cell instance $15493 r0 *1 145.92,72.8
X$15493 4212 3780 3579 112 113 4213 NOR3_X1
* cell instance $15494 r0 *1 146.68,72.8
X$15494 4213 4173 4281 112 113 3998 MUX2_X1
* cell instance $15495 m0 *1 149.53,72.8
X$15495 3584 2763 4106 112 4282 113 AOI21_X2
* cell instance $15496 m0 *1 146.87,72.8
X$15496 112 3997 3998 3888 4102 113 NOR3_X4
* cell instance $15497 m0 *1 150.86,72.8
X$15497 4102 4214 112 113 4061 NOR2_X2
* cell instance $15498 m0 *1 151.81,72.8
X$15498 3890 112 113 2913 CLKBUF_X3
* cell instance $15499 m0 *1 152.76,72.8
X$15499 3199 4103 2464 3590 4174 113 112 AOI211_X2
* cell instance $15500 m0 *1 154.47,72.8
X$15500 112 3963 4103 2909 4042 113 AOI21_X4
* cell instance $15501 m0 *1 156.94,72.8
X$15501 4102 2568 112 113 3588 NAND2_X2
* cell instance $15503 r0 *1 148.01,72.8
X$15503 4323 113 3785 112 BUF_X4
* cell instance $15504 r0 *1 149.34,72.8
X$15504 3584 4214 2763 113 4284 112 OAI21_X1
* cell instance $15506 r0 *1 150.29,72.8
X$15506 4061 3591 4282 4284 3585 4216 113 112 AOI221_X2
* cell instance $15508 r0 *1 152.57,72.8
X$15508 4398 113 4215 112 BUF_X4
* cell instance $15509 r0 *1 153.9,72.8
X$15509 4102 113 3291 112 BUF_X4
* cell instance $15510 r0 *1 155.23,72.8
X$15510 3291 2463 2913 112 113 4285 NOR3_X1
* cell instance $15512 r0 *1 156.37,72.8
X$15512 4104 3007 3999 2354 4287 4165 112 113 OAI221_X2
* cell instance $15513 m0 *1 158.46,72.8
X$15513 3689 4176 4060 3887 4177 113 112 4056 OAI221_X1
* cell instance $15516 r0 *1 158.46,72.8
X$15516 4325 112 113 3847 BUF_X2
* cell instance $15518 r0 *1 159.41,72.8
X$15518 3594 113 2465 112 BUF_X4
* cell instance $15519 m0 *1 160.17,72.8
X$15519 3088 3590 2643 112 113 4177 MUX2_X1
* cell instance $15521 m0 *1 161.5,72.8
X$15521 3689 4004 112 113 3448 OR2_X2
* cell instance $15522 m0 *1 162.45,72.8
X$15522 4061 3200 3085 112 4104 113 AOI21_X1
* cell instance $15523 m0 *1 163.21,72.8
X$15523 2914 2404 2757 112 113 4060 NAND3_X1
* cell instance $15524 m0 *1 163.97,72.8
X$15524 2357 2634 2914 113 4288 112 OAI21_X1
* cell instance $15525 m0 *1 164.73,72.8
X$15525 2683 4174 112 113 4105 OR2_X1
* cell instance $15526 m0 *1 165.49,72.8
X$15526 2689 3594 4106 113 4055 112 OAI21_X1
* cell instance $15528 m0 *1 166.44,72.8
X$15528 2472 3276 4002 2885 4003 113 112 4000 OAI221_X1
* cell instance $15529 m0 *1 167.58,72.8
X$15529 112 2908 3276 3340 2689 2360 3587 4038 113 OAI222_X2
* cell instance $15530 m0 *1 170.24,72.8
X$15530 3296 4004 2360 2681 112 113 4005 AOI22_X1
* cell instance $15531 m0 *1 171.19,72.8
X$15531 2974 4005 4105 4164 113 112 4107 OAI22_X1
* cell instance $15532 m0 *1 172.14,72.8
X$15532 4166 4165 3893 4107 112 113 4006 AOI22_X1
* cell instance $15534 m0 *1 173.28,72.8
X$15534 3083 3698 4042 112 113 4109 MUX2_X1
* cell instance $15535 m0 *1 174.61,72.8
X$15535 2467 4109 3479 113 4164 112 OAI21_X1
* cell instance $15537 r0 *1 160.74,72.8
X$15537 4217 4048 112 113 2756 NAND2_X1
* cell instance $15538 r0 *1 161.31,72.8
X$15538 2685 4288 113 112 4326 XNOR2_X1
* cell instance $15539 r0 *1 162.45,72.8
X$15539 2913 4169 112 113 4176 OR2_X1
* cell instance $15540 r0 *1 163.21,72.8
X$15540 3112 4218 3450 112 113 4175 NOR3_X1
* cell instance $15541 r0 *1 163.97,72.8
X$15541 112 3561 113 4215 BUF_X8
* cell instance $15542 r0 *1 166.44,72.8
X$15542 3561 3340 3276 3687 4002 4286 112 113 OAI221_X2
* cell instance $15543 r0 *1 168.53,72.8
X$15543 3201 3113 2689 112 113 4329 NAND3_X1
* cell instance $15545 r0 *1 169.48,72.8
X$15545 4169 2913 3892 2642 3561 4283 113 112 AOI221_X2
* cell instance $15547 r0 *1 171.95,72.8
X$15547 4001 4048 112 113 3485 NAND2_X1
* cell instance $15549 r0 *1 174.04,72.8
X$15549 3697 2471 2467 112 4108 113 AOI21_X1
* cell instance $15550 r0 *1 174.8,72.8
X$15550 2354 4108 2916 2360 3587 113 112 4110 OAI221_X1
* cell instance $15551 m0 *1 177.08,72.8
X$15551 4110 3087 112 113 4111 NOR2_X1
* cell instance $15552 m0 *1 175.75,72.8
X$15552 4162 3012 4004 112 113 4040 MUX2_X1
* cell instance $15554 m0 *1 177.84,72.8
X$15554 3487 2755 2685 112 4276 113 AOI21_X1
* cell instance $15555 m0 *1 178.6,72.8
X$15555 2404 2355 112 113 4112 NAND2_X1
* cell instance $15556 m0 *1 179.17,72.8
X$15556 3698 4039 4106 112 3835 113 AOI21_X1
* cell instance $15557 m0 *1 179.93,72.8
X$15557 2403 2471 112 113 4039 NAND2_X1
* cell instance $15559 m0 *1 183.54,72.8
X$15559 112 16919 4367 3958 4554 113 DFF_X1
* cell instance $15564 r0 *1 175.94,72.8
X$15564 3005 3170 4330 112 4219 113 AOI21_X1
* cell instance $15565 r0 *1 176.7,72.8
X$15565 3077 3291 112 113 4278 NAND2_X1
* cell instance $15566 r0 *1 177.27,72.8
X$15566 3297 4112 2640 3296 4276 112 113 4381 AOI221_X1
* cell instance $15568 r0 *1 178.79,72.8
X$15568 3294 3451 2403 112 4220 113 AOI21_X2
* cell instance $15575 r0 *1 180.12,72.8
X$15575 3487 3267 112 113 4374 NOR2_X1
* cell instance $15577 r0 *1 181.07,72.8
X$15577 3299 4106 4220 112 4114 113 AOI21_X1
* cell instance $15578 r0 *1 181.83,72.8
X$15578 4114 4272 3341 4038 112 113 3600 AOI22_X1
* cell instance $15579 r0 *1 182.78,72.8
X$15579 3271 4373 3698 112 113 4271 NOR3_X1
* cell instance $15580 r0 *1 183.54,72.8
X$15580 4271 4175 3341 113 4270 112 OAI21_X1
* cell instance $15585 r0 *1 190,72.8
X$15585 4269 4221 113 112 4268 XNOR2_X1
* cell instance $15586 r0 *1 191.14,72.8
X$15586 4222 4268 4161 113 112 2849 MUX2_X2
* cell instance $15588 m0 *1 192.47,72.8
X$15588 112 3527 3780 113 BUF_X16
* cell instance $15590 r0 *1 193.04,72.8
X$15590 112 17064 4222 4267 3264 113 DFF_X1
* cell instance $15591 r0 *1 196.27,72.8
X$15591 4222 3947 4266 112 113 4267 MUX2_X1
* cell instance $15593 m0 *1 197.79,72.8
X$15593 2479 2921 2481 112 2945 113 NAND3_X4
* cell instance $15598 r0 *1 200.83,72.8
X$15598 2945 4223 112 113 3061 NOR2_X2
* cell instance $15599 m0 *1 202.35,72.8
X$15599 2396 2731 112 113 4117 NOR2_X1
* cell instance $15600 m0 *1 201.4,72.8
X$15600 3901 4115 113 112 3601 AND2_X2
* cell instance $15602 r0 *1 201.78,72.8
X$15602 4223 2036 1856 113 112 2396 OAI21_X4
* cell instance $15603 m0 *1 203.49,72.8
X$15603 3071 3705 3704 112 3494 113 AOI21_X2
* cell instance $15605 m0 *1 204.82,72.8
X$15605 2481 113 3705 112 BUF_X4
* cell instance $15606 m0 *1 206.15,72.8
X$15606 2621 1856 2036 113 112 4115 OAI21_X2
* cell instance $15607 m0 *1 207.48,72.8
X$15607 3705 3704 2141 112 113 3042 NAND3_X2
* cell instance $15608 m0 *1 208.81,72.8
X$15608 2146 2503 112 113 4263 OR2_X1
* cell instance $15611 r0 *1 204.25,72.8
X$15611 112 3543 1858 2481 2479 113 AOI21_X4
* cell instance $15612 r0 *1 206.72,72.8
X$15612 2846 113 3065 112 BUF_X4
* cell instance $15615 r0 *1 208.62,72.8
X$15615 1943 3705 3704 112 3899 113 AOI21_X1
* cell instance $15616 r0 *1 209.38,72.8
X$15616 4263 3540 3234 2596 4152 113 112 4224 OAI221_X1
* cell instance $15618 r0 *1 210.71,72.8
X$15618 2047 3899 112 113 4152 OR2_X2
* cell instance $15619 m0 *1 212.8,72.8
X$15619 2372 4150 2815 2846 4007 112 113 OAI211_X2
* cell instance $15620 m0 *1 210.71,72.8
X$15620 2155 2396 2621 2382 2493 4027 112 113 OAI221_X2
* cell instance $15621 m0 *1 214.51,72.8
X$15621 3901 2157 2589 112 113 4008 NAND3_X1
* cell instance $15623 m0 *1 216.03,72.8
X$15623 4117 4009 2846 2596 4020 113 112 4251 OAI221_X1
* cell instance $15624 m0 *1 217.17,72.8
X$15624 1943 2382 2705 113 4009 112 OAI21_X1
* cell instance $15625 m0 *1 217.93,72.8
X$15625 3494 2047 112 113 4021 OR2_X1
* cell instance $15626 m0 *1 218.69,72.8
X$15626 4009 3540 2930 2596 4021 113 112 3497 OAI221_X1
* cell instance $15628 m0 *1 220.59,72.8
X$15628 2725 4140 2589 112 113 4138 NOR3_X1
* cell instance $15631 m0 *1 223.06,72.8
X$15631 4011 4138 3034 113 4133 112 OAI21_X1
* cell instance $15635 r0 *1 212.8,72.8
X$15635 4007 3798 4225 4333 112 113 4257 NAND4_X1
* cell instance $15637 r0 *1 213.94,72.8
X$15637 4008 4027 2930 112 113 4254 NAND3_X1
* cell instance $15638 r0 *1 214.7,72.8
X$15638 4251 4254 3129 3500 112 113 4226 NAND4_X1
* cell instance $15640 r0 *1 216.41,72.8
X$15640 4117 3532 2589 112 113 4227 NOR3_X1
* cell instance $15642 r0 *1 217.93,72.8
X$15642 4118 4227 3500 2262 4247 113 112 4010 OAI221_X1
* cell instance $15643 r0 *1 219.07,72.8
X$15643 1870 3222 2614 113 4247 112 OAI21_X1
* cell instance $15644 r0 *1 219.83,72.8
X$15644 4139 2262 112 113 4118 NAND2_X1
* cell instance $15645 r0 *1 220.4,72.8
X$15645 2044 3543 2950 113 4228 112 OAI21_X1
* cell instance $15646 r0 *1 221.16,72.8
X$15646 3252 4228 4243 112 4336 113 AOI21_X1
* cell instance $15647 r0 *1 221.92,72.8
X$15647 4139 3317 3045 113 112 4243 AND3_X1
* cell instance $15649 r0 *1 223.25,72.8
X$15649 3400 2157 3222 112 4229 113 AOI21_X1
* cell instance $15652 m0 *1 224.2,72.8
X$15652 112 3820 3139 4132 4134 4120 4121 4017 113 AOI222_X2
* cell instance $15654 r0 *1 224.96,72.8
X$15654 4350 4133 2926 112 113 4120 NAND3_X1
* cell instance $15656 r0 *1 227.24,72.8
X$15656 2930 4239 3540 112 4235 113 AOI21_X1
* cell instance $15657 m0 *1 228.38,72.8
X$15657 2950 3042 2157 112 4122 113 AOI21_X1
* cell instance $15658 m0 *1 227.24,72.8
X$15658 1943 2945 2930 2396 2607 113 112 4012 OAI221_X1
* cell instance $15659 m0 *1 229.14,72.8
X$15659 3071 2251 1943 112 113 4124 MUX2_X1
* cell instance $15660 m0 *1 230.47,72.8
X$15660 2396 3130 3222 112 113 3905 MUX2_X1
* cell instance $15661 m0 *1 231.8,72.8
X$15661 2705 1943 112 113 4123 NAND2_X1
* cell instance $15663 r0 *1 228,72.8
X$15663 4238 2930 3129 4012 4122 113 112 4240 OAI221_X1
* cell instance $15666 r0 *1 229.71,72.8
X$15666 2950 4234 4452 113 4342 112 OAI21_X1
* cell instance $15668 r0 *1 230.85,72.8
X$15668 3602 3543 4338 2381 112 113 3131 AOI22_X1
* cell instance $15669 r0 *1 231.8,72.8
X$15669 2720 4124 3711 113 4234 112 OAI21_X1
* cell instance $15671 m0 *1 232.94,72.8
X$15671 2588 113 2828 112 BUF_X4
* cell instance $15673 m0 *1 234.27,72.8
X$15673 4230 112 113 3642 CLKBUF_X2
* cell instance $15678 r0 *1 232.94,72.8
X$15678 3906 2828 4123 112 113 4691 MUX2_X1
* cell instance $15687 r0 *1 236.17,72.8
X$15687 112 17097 4690 4171 4454 113 DFF_X1
* cell instance $15692 m0 *1 13.3,154
X$15692 11088 112 113 10614 BUF_X1
* cell instance $15708 m0 *1 34.96,154
X$15708 10967 10104 112 113 10971 NOR2_X1
* cell instance $15710 m0 *1 35.53,154
X$15710 11178 10976 112 113 11324 NOR2_X1
* cell instance $15711 m0 *1 36.1,154
X$15711 10104 10453 10451 112 11170 113 AOI21_X1
* cell instance $15712 m0 *1 36.86,154
X$15712 10968 113 10873 112 BUF_X4
* cell instance $15714 m0 *1 38.38,154
X$15714 10967 9867 10026 113 112 11251 OAI21_X4
* cell instance $15715 m0 *1 40.85,154
X$15715 10970 10892 10800 112 113 11089 NOR3_X1
* cell instance $15716 m0 *1 41.61,154
X$15716 11328 10968 10640 113 11178 112 OAI21_X1
* cell instance $15717 m0 *1 42.37,154
X$15717 10622 10549 10875 112 113 10878 NAND3_X1
* cell instance $15719 m0 *1 43.32,154
X$15719 10548 10972 112 113 10976 NOR2_X2
* cell instance $15720 m0 *1 44.27,154
X$15720 10390 10645 10640 112 113 11090 NOR3_X1
* cell instance $15721 m0 *1 45.03,154
X$15721 10224 10406 113 112 11181 AND2_X1
* cell instance $15722 m0 *1 45.79,154
X$15722 10967 11036 11037 112 11329 113 AOI21_X1
* cell instance $15723 m0 *1 46.55,154
X$15723 11181 11329 11392 10798 112 113 11094 NOR4_X1
* cell instance $15725 r0 *1 34.96,154
X$15725 10794 112 113 11718 INV_X1
* cell instance $15726 r0 *1 35.34,154
X$15726 10794 9867 10026 113 112 11476 OAI21_X4
* cell instance $15728 r0 *1 38,154
X$15728 9867 10026 10891 113 11481 112 OAI21_X1
* cell instance $15729 r0 *1 38.76,154
X$15729 10797 11249 11482 113 11642 112 OAI21_X1
* cell instance $15731 r0 *1 39.9,154
X$15731 11480 11391 10798 113 11482 112 OAI21_X1
* cell instance $15732 r0 *1 40.66,154
X$15732 10225 11250 11476 112 11391 113 AOI21_X1
* cell instance $15734 r0 *1 41.61,154
X$15734 10108 10742 10640 112 113 11480 NOR3_X1
* cell instance $15735 r0 *1 42.37,154
X$15735 11252 11324 112 113 11644 OR2_X1
* cell instance $15737 r0 *1 43.32,154
X$15737 10803 11250 11487 112 11252 113 AOI21_X2
* cell instance $15738 r0 *1 44.65,154
X$15738 11258 10968 10972 112 113 11648 MUX2_X1
* cell instance $15740 r0 *1 46.36,154
X$15740 11058 10972 112 113 11332 NOR2_X2
* cell instance $15741 r0 *1 47.31,154
X$15741 10679 10798 11490 112 11333 113 AOI21_X2
* cell instance $15743 m0 *1 47.88,154
X$15743 10629 10979 10981 113 11186 112 OAI21_X1
* cell instance $15744 m0 *1 48.83,154
X$15744 11332 11095 10396 10108 10797 11184 112 113 OAI221_X2
* cell instance $15745 m0 *1 50.92,154
X$15745 11334 10969 10983 113 11095 112 OAI21_X1
* cell instance $15746 m0 *1 51.68,154
X$15746 11096 11186 113 112 11190 AND2_X1
* cell instance $15747 m0 *1 52.44,154
X$15747 11188 11252 11254 112 113 11341 NOR3_X1
* cell instance $15748 m0 *1 53.2,154
X$15748 10557 10739 112 113 11096 NOR2_X2
* cell instance $15749 m0 *1 54.15,154
X$15749 11097 11341 10985 113 11340 112 NOR3_X2
* cell instance $15750 m0 *1 55.48,154
X$15750 11399 10685 112 113 11343 NOR2_X1
* cell instance $15752 m0 *1 56.24,154
X$15752 11344 11098 11340 10806 113 11257 112 NOR4_X2
* cell instance $15753 m0 *1 57.95,154
X$15753 11258 112 113 11092 INV_X1
* cell instance $15754 m0 *1 58.33,154
X$15754 112 11345 10026 9867 11255 113 NOR3_X4
* cell instance $15755 m0 *1 60.99,154
X$15755 10553 113 11192 112 BUF_X4
* cell instance $15757 m0 *1 62.51,154
X$15757 10463 113 11254 112 BUF_X4
* cell instance $15758 m0 *1 63.84,154
X$15758 11348 10106 11254 113 11200 112 OAI21_X1
* cell instance $15761 m0 *1 66.31,154
X$15761 112 16932 11351 11256 10234 113 DFF_X1
* cell instance $15762 m0 *1 69.54,154
X$15762 11351 112 113 8855 CLKBUF_X3
* cell instance $15764 r0 *1 48.64,154
X$15764 11333 11343 10739 11184 11189 11494 113 112 AOI221_X2
* cell instance $15766 r0 *1 51.11,154
X$15766 11651 10322 10458 112 11336 113 AOI21_X1
* cell instance $15767 r0 *1 51.87,154
X$15767 11497 11336 11500 11254 10895 11339 113 112 AOI221_X2
* cell instance $15768 r0 *1 53.96,154
X$15768 11255 113 10984 112 BUF_X4
* cell instance $15769 r0 *1 55.29,154
X$15769 11396 11190 11339 11257 11397 11256 113 112 AOI221_X2
* cell instance $15770 r0 *1 57.38,154
X$15770 10640 11328 112 113 11400 NOR2_X1
* cell instance $15771 r0 *1 57.95,154
X$15771 11400 10969 11399 113 11506 112 OAI21_X1
* cell instance $15772 r0 *1 58.71,154
X$15772 11258 113 11345 112 BUF_X4
* cell instance $15774 r0 *1 60.23,154
X$15774 10742 11393 11399 112 11402 113 AOI21_X1
* cell instance $15776 r0 *1 61.18,154
X$15776 10902 10906 10873 11479 11092 113 112 11348 OAI221_X1
* cell instance $15777 r0 *1 62.32,154
X$15777 112 10228 10902 10906 11569 113 NOR3_X4
* cell instance $15782 m0 *1 74.1,154
X$15782 112 16927 10809 11259 11099 113 DFF_X1
* cell instance $15783 m0 *1 70.87,154
X$15783 112 16928 10992 11973 11099 113 DFF_X1
* cell instance $15784 m0 *1 77.33,154
X$15784 11100 112 113 11260 INV_X2
* cell instance $15786 m0 *1 78.66,154
X$15786 10658 11259 11510 113 112 11355 HA_X1
* cell instance $15787 m0 *1 80.56,154
X$15787 11355 112 113 11360 BUF_X2
* cell instance $15790 m0 *1 83.6,154
X$15790 112 10994 8040 10772 10566 11406 113 NOR4_X4
* cell instance $15791 m0 *1 87.02,154
X$15791 11067 113 11513 112 BUF_X4
* cell instance $15792 m0 *1 88.35,154
X$15792 8133 112 113 17266 CLKBUF_X3
* cell instance $15794 m0 *1 89.49,154
X$15794 112 10993 10811 10813 11101 11515 113 NAND4_X4
* cell instance $15797 m0 *1 93.86,154
X$15797 112 16751 11215 11520 11099 113 DFF_X1
* cell instance $15806 r0 *1 73.91,154
X$15806 11259 10658 16667 113 112 11100 HA_X1
* cell instance $15807 r0 *1 75.81,154
X$15807 11100 113 11407 112 BUF_X4
* cell instance $15809 r0 *1 77.52,154
X$15809 11510 113 11404 112 BUF_X4
* cell instance $15810 r0 *1 78.85,154
X$15810 112 11359 113 11404 BUF_X8
* cell instance $15811 r0 *1 81.32,154
X$15811 10993 11359 10811 112 11405 113 NAND3_X4
* cell instance $15814 r0 *1 84.36,154
X$15814 10566 10812 11403 112 113 NOR2_X4
* cell instance $15816 r0 *1 86.26,154
X$15816 1747 112 113 8133 CLKBUF_X3
* cell instance $15817 r0 *1 87.21,154
X$15817 11067 113 11514 112 BUF_X4
* cell instance $15818 r0 *1 88.54,154
X$15818 11407 11408 11261 112 11517 113 AOI21_X2
* cell instance $15819 r0 *1 89.87,154
X$15819 10692 113 11410 112 BUF_X4
* cell instance $15821 r0 *1 92.72,154
X$15821 11408 11261 11407 112 113 11413 NAND3_X1
* cell instance $15822 r0 *1 93.48,154
X$15822 10993 113 11261 112 BUF_X4
* cell instance $15824 r0 *1 95.19,154
X$15824 10811 113 11408 112 BUF_X4
* cell instance $15827 r0 *1 98.42,154
X$15827 112 17012 11264 11263 10465 113 DFF_X1
* cell instance $15830 m0 *1 102.79,154
X$15830 10465 112 113 17154 INV_X2
* cell instance $15833 m0 *1 105.45,154
X$15833 11366 9701 112 113 11224 NAND2_X1
* cell instance $15836 m0 *1 106.21,154
X$15836 10574 11368 11103 113 11265 112 OAI21_X1
* cell instance $15838 m0 *1 107.73,154
X$15838 11243 10661 10814 112 113 11366 NAND3_X1
* cell instance $15839 m0 *1 108.49,154
X$15839 10998 11267 113 112 11368 AND2_X1
* cell instance $15840 m0 *1 109.25,154
X$15840 11104 11532 10200 9966 112 113 11229 NAND4_X1
* cell instance $15841 m0 *1 110.2,154
X$15841 11370 11105 11371 9980 112 113 11104 NAND4_X1
* cell instance $15842 m0 *1 111.15,154
X$15842 9939 9969 10788 113 11102 112 OAI21_X1
* cell instance $15843 m0 *1 111.91,154
X$15843 10077 10814 112 113 11371 NAND2_X1
* cell instance $15845 m0 *1 112.67,154
X$15845 10441 11374 10788 10536 9935 113 112 11237 OAI221_X1
* cell instance $15847 m0 *1 114,154
X$15847 9632 9971 112 113 11273 NAND2_X2
* cell instance $15850 r0 *1 106.97,154
X$15850 10343 10466 10468 113 11528 112 OAI21_X1
* cell instance $15852 r0 *1 108.11,154
X$15852 11266 10305 11267 113 10782 112 OAI21_X1
* cell instance $15855 r0 *1 110.01,154
X$15855 10068 10057 10663 112 11533 113 AOI21_X1
* cell instance $15856 r0 *1 110.77,154
X$15856 10065 10247 112 113 11689 NAND2_X1
* cell instance $15857 r0 *1 111.34,154
X$15857 9973 9936 112 113 11417 NOR2_X1
* cell instance $15858 r0 *1 111.91,154
X$15858 10343 10466 11371 11268 10441 113 112 11535 OAI221_X1
* cell instance $15861 r0 *1 114.76,154
X$15861 9632 9936 112 113 11418 NAND2_X1
* cell instance $15864 m0 *1 115.33,154
X$15864 10068 11106 10472 10466 113 112 11269 OAI22_X1
* cell instance $15865 m0 *1 116.47,154
X$15865 10068 10662 11270 112 11239 113 AOI21_X1
* cell instance $15866 m0 *1 117.23,154
X$15866 11237 11107 11376 112 113 11272 NAND3_X1
* cell instance $15868 m0 *1 118.18,154
X$15868 112 11242 11109 11272 11245 11221 113 AND4_X4
* cell instance $15869 m0 *1 120.65,154
X$15869 10960 9966 112 113 11108 NAND2_X1
* cell instance $15870 m0 *1 121.22,154
X$15870 11273 112 113 11244 INV_X1
* cell instance $15872 r0 *1 115.71,154
X$15872 11270 11269 10305 11271 112 113 11421 AOI22_X1
* cell instance $15873 r0 *1 116.66,154
X$15873 11421 11542 112 113 11084 NAND2_X1
* cell instance $15874 r0 *1 117.23,154
X$15874 11422 9969 10240 112 11376 113 AOI21_X1
* cell instance $15875 r0 *1 117.99,154
X$15875 9943 10121 112 113 11422 NAND2_X1
* cell instance $15878 r0 *1 120.46,154
X$15878 11270 10820 112 113 11423 NOR2_X1
* cell instance $15882 m0 *1 121.98,154
X$15882 112 10823 10672 11245 12011 11380 113 AOI22_X4
* cell instance $15883 m0 *1 125.4,154
X$15883 11386 11111 10474 112 113 11113 NOR3_X1
* cell instance $15884 m0 *1 126.16,154
X$15884 10445 10256 11114 11110 11248 11247 112 113 OAI221_X2
* cell instance $15885 m0 *1 128.25,154
X$15885 10243 9936 112 113 11248 NOR2_X1
* cell instance $15887 m0 *1 129.01,154
X$15887 11115 11116 112 113 11712 NAND2_X1
* cell instance $15888 m0 *1 129.58,154
X$15888 10998 10194 10702 112 113 11116 NAND3_X1
* cell instance $15890 r0 *1 121.98,154
X$15890 11544 11548 10072 112 113 11380 AND3_X4
* cell instance $15894 r0 *1 124.07,154
X$15894 9941 112 113 11270 CLKBUF_X3
* cell instance $15895 r0 *1 125.02,154
X$15895 11384 11111 9973 112 113 10954 NOR3_X1
* cell instance $15896 r0 *1 125.78,154
X$15896 11270 10248 11552 113 112 11752 AND3_X1
* cell instance $15897 r0 *1 126.73,154
X$15897 10440 11551 10216 112 11386 113 AOI21_X1
* cell instance $15900 r0 *1 128.06,154
X$15900 9876 10252 112 113 11425 NAND2_X2
* cell instance $15901 r0 *1 129.01,154
X$15901 9876 10252 112 113 10821 NOR2_X2
* cell instance $15904 m0 *1 130.91,154
X$15904 11389 10446 11001 113 10666 112 OAI21_X1
* cell instance $15906 m0 *1 131.67,154
X$15906 9827 10781 10194 112 11428 113 AOI21_X1
* cell instance $15909 r0 *1 132.43,154
X$15909 10355 10254 11266 112 113 10663 NAND3_X2
* cell instance $15910 m0 *1 135.28,154
X$15910 10096 10136 10937 113 11389 112 NOR3_X2
* cell instance $15911 m0 *1 132.81,154
X$15911 10254 10247 10355 112 11243 113 NAND3_X4
* cell instance $15912 m0 *1 136.61,154
X$15912 10096 10136 112 113 11390 NOR2_X2
* cell instance $15914 r0 *1 133.76,154
X$15914 11117 10661 11110 112 113 11552 NAND3_X1
* cell instance $15916 r0 *1 134.9,154
X$15916 10254 10098 10355 112 10571 113 NAND3_X4
* cell instance $15917 r0 *1 137.37,154
X$15917 10573 11117 10661 112 11274 113 AOI21_X1
* cell instance $15918 m0 *1 138.13,154
X$15918 10355 10254 10125 112 113 11117 NAND3_X1
* cell instance $15921 m0 *1 139.08,154
X$15921 11240 112 113 10937 INV_X2
* cell instance $15923 m0 *1 140.41,154
X$15923 11240 10829 11000 113 112 10057 OAI21_X4
* cell instance $15928 r0 *1 139.08,154
X$15928 9982 11555 16639 113 112 11240 HA_X1
* cell instance $15929 r0 *1 140.98,154
X$15929 11240 113 10125 112 BUF_X4
* cell instance $15930 r0 *1 142.31,154
X$15930 11554 9097 112 113 11275 XNOR2_X2
* cell instance $15931 m0 *1 144.21,154
X$15931 9999 6498 112 113 9097 XNOR2_X2
* cell instance $15935 m0 *1 148.39,154
X$15935 11118 112 113 11387 INV_X1
* cell instance $15936 m0 *1 148.77,154
X$15936 112 11387 11235 8388 11236 11073 113 OAI211_X4
* cell instance $15939 m0 *1 153.71,154
X$15939 112 11382 11119 11385 11863 10535 113 NAND4_X4
* cell instance $15940 m0 *1 157.13,154
X$15940 11122 11121 11120 11434 112 113 11385 AOI22_X2
* cell instance $15942 m0 *1 159.03,154
X$15942 11383 11129 11123 11379 11381 112 113 11378 AOI221_X1
* cell instance $15943 m0 *1 160.17,154
X$15943 11125 11007 112 113 11124 NAND2_X2
* cell instance $15944 m0 *1 161.12,154
X$15944 11126 112 113 11129 CLKBUF_X3
* cell instance $15950 r0 *1 147.06,154
X$15950 11599 7107 11275 112 11388 113 AOI21_X1
* cell instance $15951 r0 *1 147.82,154
X$15951 112 17019 11553 11388 9211 113 DFF_X1
* cell instance $15953 r0 *1 151.43,154
X$15953 11553 113 9999 112 BUF_X4
* cell instance $15955 r0 *1 155.8,154
X$15955 11123 113 11277 112 BUF_X4
* cell instance $15956 r0 *1 157.13,154
X$15956 11540 11549 11435 11072 11547 11434 112 113 OAI221_X2
* cell instance $15957 r0 *1 159.22,154
X$15957 11277 11005 11436 112 113 11382 OR3_X1
* cell instance $15959 r0 *1 160.93,154
X$15959 11234 11126 11766 112 113 11438 MUX2_X1
* cell instance $15961 m0 *1 162.64,154
X$15961 11124 11700 11439 11378 113 112 11127 OAI22_X1
* cell instance $15963 m0 *1 163.59,154
X$15963 11125 11007 112 113 11128 NOR2_X1
* cell instance $15964 m0 *1 164.16,154
X$15964 11128 11129 112 113 11279 NAND2_X1
* cell instance $15966 r0 *1 163.78,154
X$15966 11138 11440 11433 112 11278 113 AOI21_X1
* cell instance $15968 r0 *1 164.73,154
X$15968 11126 113 11283 112 BUF_X4
* cell instance $15970 m0 *1 165.11,154
X$15970 11132 11279 11772 11375 113 112 11233 OAI22_X1
* cell instance $15971 r0 *1 166.06,154
X$15971 11541 11008 112 113 11006 NAND2_X1
* cell instance $15972 m0 *1 167.01,154
X$15972 11280 11122 11277 112 113 11225 NAND3_X1
* cell instance $15973 m0 *1 166.44,154
X$15973 11377 11129 112 113 11280 NAND2_X1
* cell instance $15975 m0 *1 167.96,154
X$15975 11282 11234 11004 112 113 11227 NAND3_X1
* cell instance $15977 r0 *1 166.63,154
X$15977 11440 11130 11433 113 11282 112 OAI21_X1
* cell instance $15978 r0 *1 167.39,154
X$15978 11445 11281 11130 112 11540 113 AOI21_X1
* cell instance $15979 r0 *1 168.15,154
X$15979 11283 11284 10951 113 112 11538 AND3_X1
* cell instance $15980 m0 *1 169.29,154
X$15980 11289 10957 10836 112 11373 113 AOI21_X1
* cell instance $15983 m0 *1 170.24,154
X$15983 11287 11373 11288 11222 113 112 11286 OAI22_X1
* cell instance $15984 m0 *1 171.19,154
X$15984 11446 10836 10957 112 11222 113 AOI21_X1
* cell instance $15985 m0 *1 171.95,154
X$15985 11367 112 113 11287 CLKBUF_X3
* cell instance $15988 r0 *1 169.29,154
X$15988 11534 11285 11443 11537 11538 11286 112 113 11131 OAI33_X1
* cell instance $15990 r0 *1 170.81,154
X$15990 112 11450 11447 11531 11536 113 NOR3_X4
* cell instance $15991 m0 *1 173.85,154
X$15991 11372 11281 11365 112 11132 113 AOI21_X1
* cell instance $15992 m0 *1 173.28,154
X$15992 11530 11283 112 113 11217 NAND2_X1
* cell instance $15995 r0 *1 173.66,154
X$15995 11776 11529 11283 112 11133 113 AOI21_X2
* cell instance $15996 m0 *1 175.56,154
X$15996 11290 10836 11369 112 113 11135 MUX2_X1
* cell instance $15997 m0 *1 174.99,154
X$15997 11010 10834 112 113 11134 NAND2_X1
* cell instance $15998 m0 *1 176.89,154
X$15998 10951 10836 11136 112 11214 113 AOI21_X1
* cell instance $16000 m0 *1 177.84,154
X$16000 11211 11010 10713 112 113 11213 NAND3_X1
* cell instance $16001 m0 *1 178.6,154
X$16001 11292 11367 11291 112 113 11211 NAND3_X1
* cell instance $16002 m0 *1 179.36,154
X$16002 10713 11289 11293 112 113 11137 NOR3_X1
* cell instance $16003 m0 *1 180.12,154
X$16003 11292 11138 11137 11364 11288 11365 113 112 AOI221_X2
* cell instance $16005 r0 *1 174.99,154
X$16005 11293 11011 11287 11138 11524 112 113 11372 AOI221_X1
* cell instance $16007 r0 *1 176.51,154
X$16007 11294 113 11447 112 BUF_X4
* cell instance $16008 r0 *1 177.84,154
X$16008 11453 113 11531 112 BUF_X4
* cell instance $16009 r0 *1 179.17,154
X$16009 11448 11012 11449 113 11524 112 OAI21_X1
* cell instance $16014 r0 *1 180.31,154
X$16014 11453 11294 11452 11013 11284 113 112 AOI211_X2
* cell instance $16015 r0 *1 182.02,154
X$16015 8670 112 113 11523 INV_X4
* cell instance $16017 m0 *1 182.59,154
X$16017 8670 8268 11292 112 113 NOR2_X4
* cell instance $16018 m0 *1 184.49,154
X$16018 11295 112 113 11207 BUF_X1
* cell instance $16019 m0 *1 185.06,154
X$16019 8522 2861 10484 112 113 11296 NAND3_X2
* cell instance $16020 m0 *1 186.39,154
X$16020 112 8268 11450 113 BUF_X16
* cell instance $16021 m0 *1 191.14,154
X$16021 112 11297 11363 2861 11204 10845 113 OAI211_X4
* cell instance $16022 m0 *1 194.37,154
X$16022 5231 10367 112 113 11459 NOR2_X2
* cell instance $16024 r0 *1 182.97,154
X$16024 11523 8268 11130 112 113 NOR2_X4
* cell instance $16025 r0 *1 184.68,154
X$16025 112 11519 113 8670 BUF_X8
* cell instance $16026 r0 *1 187.15,154
X$16026 11519 11012 112 11449 113 NAND2_X4
* cell instance $16027 r0 *1 188.86,154
X$16027 11141 11296 112 11923 113 NAND2_X4
* cell instance $16028 r0 *1 190.57,154
X$16028 11141 11296 113 112 11452 AND2_X1
* cell instance $16029 r0 *1 191.33,154
X$16029 11456 112 113 11140 BUF_X1
* cell instance $16030 r0 *1 191.9,154
X$16030 10757 2861 112 113 11363 NAND2_X1
* cell instance $16031 r0 *1 192.47,154
X$16031 10844 112 113 11297 INV_X1
* cell instance $16032 r0 *1 192.85,154
X$16032 11516 11458 11457 113 112 11518 OAI21_X2
* cell instance $16033 r0 *1 194.18,154
X$16033 10299 112 113 10847 CLKBUF_X3
* cell instance $16034 r0 *1 195.13,154
X$16034 11458 5995 11169 112 113 11662 MUX2_X1
* cell instance $16035 m0 *1 195.89,154
X$16035 9918 113 11347 112 BUF_X4
* cell instance $16039 r0 *1 196.84,154
X$16039 112 11151 11299 11361 11298 113 AOI21_X4
* cell instance $16040 m0 *1 199.31,154
X$16040 11353 11358 11357 113 112 10884 OAI21_X4
* cell instance $16041 m0 *1 197.6,154
X$16041 10044 10852 11300 112 113 NOR2_X4
* cell instance $16042 m0 *1 201.78,154
X$16042 11356 11302 10006 11143 11354 11342 113 112 AOI221_X2
* cell instance $16043 m0 *1 203.87,154
X$16043 11144 11302 112 113 11143 NOR2_X1
* cell instance $16044 m0 *1 204.44,154
X$16044 10637 11352 112 113 11187 NOR2_X2
* cell instance $16045 m0 *1 205.39,154
X$16045 11145 11144 11147 11172 112 113 11146 AOI22_X1
* cell instance $16046 m0 *1 206.34,154
X$16046 11147 112 113 11350 CLKBUF_X3
* cell instance $16048 m0 *1 208.05,154
X$16048 11303 112 113 11021 CLKBUF_X3
* cell instance $16049 m0 *1 209,154
X$16049 11349 11350 112 113 11148 NOR2_X1
* cell instance $16050 m0 *1 209.57,154
X$16050 11301 11347 112 113 11149 NOR2_X1
* cell instance $16052 m0 *1 210.9,154
X$16052 11346 11305 11021 113 11193 112 OAI21_X1
* cell instance $16054 m0 *1 211.85,154
X$16054 11193 11024 10373 11038 11191 113 112 11195 OAI221_X1
* cell instance $16055 m0 *1 212.99,154
X$16055 11022 11335 10910 113 11191 112 OAI21_X1
* cell instance $16057 m0 *1 213.94,154
X$16057 11152 11467 10722 112 113 11025 NAND3_X2
* cell instance $16058 m0 *1 215.27,154
X$16058 11027 11029 112 113 11152 NAND2_X2
* cell instance $16062 r0 *1 200.26,154
X$16062 11299 11016 10756 113 112 11301 OAI21_X2
* cell instance $16063 r0 *1 201.59,154
X$16063 10044 112 113 11358 BUF_X1
* cell instance $16064 r0 *1 202.16,154
X$16064 10852 112 113 11357 BUF_X1
* cell instance $16066 r0 *1 203.11,154
X$16066 10638 11353 11147 113 11354 112 OAI21_X1
* cell instance $16067 r0 *1 203.87,154
X$16067 11151 11511 10755 11509 11303 11352 113 112 AOI221_X2
* cell instance $16068 r0 *1 205.96,154
X$16068 11053 11346 11460 113 112 11509 OAI21_X4
* cell instance $16069 r0 *1 208.43,154
X$16069 11308 10399 11461 112 113 11349 MUX2_X1
* cell instance $16070 r0 *1 209.76,154
X$16070 11304 10737 11507 112 113 11056 MUX2_X1
* cell instance $16071 r0 *1 211.09,154
X$16071 11150 11308 11504 113 11507 112 OAI21_X1
* cell instance $16072 r0 *1 211.85,154
X$16072 11303 10592 11461 112 113 11465 MUX2_X1
* cell instance $16073 r0 *1 213.18,154
X$16073 11306 11026 10853 112 113 11504 NAND3_X1
* cell instance $16074 r0 *1 213.94,154
X$16074 11502 11466 11495 11342 113 10724 112 NOR4_X2
* cell instance $16076 r0 *1 216.03,154
X$16076 11461 10910 113 112 11501 AND2_X1
* cell instance $16077 m0 *1 217.36,154
X$16077 10726 10491 11468 113 112 11173 OAI21_X2
* cell instance $16078 m0 *1 216.6,154
X$16078 11305 11338 11157 112 11052 113 AOI21_X1
* cell instance $16081 r0 *1 217.17,154
X$16081 11498 11307 10599 113 10602 112 OAI21_X1
* cell instance $16083 r0 *1 218.69,154
X$16083 11499 11496 112 11491 113 OR2_X4
* cell instance $16084 m0 *1 221.16,154
X$16084 11346 11335 10858 113 11179 112 OAI21_X1
* cell instance $16085 m0 *1 219.07,154
X$16085 10491 11337 11153 112 113 11496 AND3_X4
* cell instance $16087 m0 *1 222.11,154
X$16087 11310 11155 11150 11017 112 113 10609 AOI22_X1
* cell instance $16089 m0 *1 223.25,154
X$16089 11154 11033 11158 11042 113 112 10730 OAI22_X1
* cell instance $16090 m0 *1 224.2,154
X$16090 10905 11157 11331 112 10743 113 AOI21_X1
* cell instance $16091 m0 *1 224.96,154
X$16091 11145 11330 112 113 10863 NOR2_X1
* cell instance $16093 r0 *1 220.4,154
X$16093 10625 11493 11492 11315 11491 10270 112 113 OAI221_X2
* cell instance $16094 r0 *1 222.49,154
X$16094 11469 10729 10489 113 11492 112 OAI21_X1
* cell instance $16096 r0 *1 223.63,154
X$16096 11309 11350 112 113 11331 NAND2_X1
* cell instance $16098 r0 *1 224.58,154
X$16098 11145 11147 112 113 11317 NAND2_X1
* cell instance $16100 r0 *1 225.53,154
X$16100 11026 10595 112 113 11159 NAND2_X1
* cell instance $16101 m0 *1 226.67,154
X$16101 11160 11157 11161 112 113 11162 NOR3_X1
* cell instance $16102 m0 *1 225.91,154
X$16102 11017 10593 11310 112 11160 113 AOI21_X1
* cell instance $16103 m0 *1 227.43,154
X$16103 11311 11162 11325 113 11171 112 OAI21_X1
* cell instance $16104 m0 *1 228.19,154
X$16104 11312 11173 11163 11164 11171 11315 112 113 OAI221_X2
* cell instance $16105 m0 *1 230.28,154
X$16105 11165 11326 11327 112 113 11318 NOR3_X1
* cell instance $16106 m0 *1 231.04,154
X$16106 10727 10608 112 113 11325 NOR2_X1
* cell instance $16109 m0 *1 233.89,154
X$16109 112 16845 11320 10911 10501 113 DFF_X1
* cell instance $16110 m0 *1 237.12,154
X$16110 10869 112 113 11169 BUF_X1
* cell instance $16113 r0 *1 226.1,154
X$16113 11308 11313 112 113 11040 NOR2_X1
* cell instance $16115 r0 *1 226.86,154
X$16115 11175 112 113 11156 BUF_X1
* cell instance $16117 r0 *1 227.81,154
X$16117 11313 11314 10720 113 11470 112 OAI21_X1
* cell instance $16119 r0 *1 228.76,154
X$16119 11470 10610 112 113 11471 NAND2_X1
* cell instance $16120 r0 *1 229.33,154
X$16120 10860 11306 113 112 11316 AND2_X1
* cell instance $16122 r0 *1 230.28,154
X$16122 11478 11317 11316 112 11327 113 AOI21_X1
* cell instance $16124 r0 *1 231.23,154
X$16124 11318 10604 11472 11474 112 113 11473 OR4_X1
* cell instance $16125 r0 *1 232.37,154
X$16125 4841 112 113 10501 CLKBUF_X3
* cell instance $16126 r0 *1 233.32,154
X$16126 10501 112 113 17180 INV_X2
* cell instance $16131 r0 *1 236.93,154
X$16131 11321 112 113 10760 BUF_X1
* cell instance $16133 r0 *1 237.88,154
X$16133 11168 112 113 11322 BUF_X1
* cell instance $16137 m0 *1 187.53,140
X$16137 9999 112 113 10051 INV_X1
* cell instance $16140 m0 *1 193.23,140
X$16140 9326 9240 113 112 9762 XNOR2_X1
* cell instance $16141 m0 *1 194.37,140
X$16141 9763 9913 9673 113 112 10002 MUX2_X2
* cell instance $16142 m0 *1 196.08,140
X$16142 9895 9764 10002 112 113 10368 OR3_X4
* cell instance $16145 m0 *1 199.88,140
X$16145 9324 9110 113 10038 112 XOR2_X2
* cell instance $16146 m0 *1 201.59,140
X$16146 9804 3882 8672 112 113 10037 NOR3_X1
* cell instance $16147 m0 *1 202.35,140
X$16147 10043 9673 10037 112 113 10004 MUX2_X1
* cell instance $16149 m0 *1 203.87,140
X$16149 10038 4678 8672 112 113 10003 NOR3_X1
* cell instance $16150 m0 *1 204.63,140
X$16150 10003 9673 9896 112 113 10005 MUX2_X1
* cell instance $16153 m0 *1 209.19,140
X$16153 112 9899 10024 17233 9739 113 DFF_X2
* cell instance $16158 m0 *1 186.58,140
X$16158 5399 9999 112 113 10054 NAND2_X1
* cell instance $16162 r0 *1 186.58,140
X$16162 9998 10054 10149 113 10178 112 OAI21_X1
* cell instance $16163 r0 *1 187.34,140
X$16163 9998 7516 10051 112 113 10149 NAND3_X1
* cell instance $16166 r0 *1 188.67,140
X$16166 9647 9431 113 112 10150 XNOR2_X1
* cell instance $16168 r0 *1 190.57,140
X$16168 10000 9110 113 112 10176 XNOR2_X1
* cell instance $16169 r0 *1 191.71,140
X$16169 9110 9326 112 113 10174 XOR2_X1
* cell instance $16170 r0 *1 192.85,140
X$16170 9761 10174 113 112 10151 XNOR2_X1
* cell instance $16171 r0 *1 193.99,140
X$16171 10001 10151 113 112 10168 XNOR2_X1
* cell instance $16174 r0 *1 195.7,140
X$16174 112 10002 9764 9895 10046 113 NOR3_X4
* cell instance $16175 r0 *1 198.36,140
X$16175 10173 10172 9911 113 112 10044 MUX2_X2
* cell instance $16178 r0 *1 202.35,140
X$16178 4678 9108 112 113 10153 NOR2_X1
* cell instance $16181 r0 *1 204.82,140
X$16181 112 10004 10005 9897 10006 113 NOR3_X4
* cell instance $16182 r0 *1 207.48,140
X$16182 10004 10005 9897 112 113 10155 OR3_X2
* cell instance $16183 r0 *1 208.62,140
X$16183 9996 112 113 9898 BUF_X1
* cell instance $16186 r0 *1 210.14,140
X$16186 10007 112 113 9240 CLKBUF_X3
* cell instance $16189 r0 *1 212.99,140
X$16189 9110 3733 113 10023 112 XOR2_X2
* cell instance $16193 r0 *1 216.79,140
X$16193 9108 9647 112 113 10010 XOR2_X1
* cell instance $16194 r0 *1 217.93,140
X$16194 10027 112 113 9647 BUF_X2
* cell instance $16196 m0 *1 218.5,140
X$16196 112 16908 9907 10028 10024 113 DFF_X1
* cell instance $16198 m0 *1 222.3,140
X$16198 5025 9750 112 113 10025 XOR2_X1
* cell instance $16200 m0 *1 223.44,140
X$16200 112 9759 10008 10022 9656 113 DFF_X1
* cell instance $16201 m0 *1 226.67,140
X$16201 10008 9209 9903 112 113 10022 MUX2_X1
* cell instance $16202 m0 *1 228,140
X$16202 112 16924 8081 10157 9656 113 DFF_X1
* cell instance $16203 m0 *1 231.23,140
X$16203 112 16850 9904 10009 10158 113 DFF_X1
* cell instance $16206 m0 *1 235.41,140
X$16206 9900 112 113 10021 BUF_X2
* cell instance $16207 m0 *1 236.17,140
X$16207 9901 112 113 9905 BUF_X1
* cell instance $16214 r0 *1 232.18,140
X$16214 10013 112 113 9653 BUF_X1
* cell instance $16217 r0 *1 233.32,140
X$16217 112 16972 10011 9769 10158 113 DFF_X1
* cell instance $16221 r0 *1 236.55,140
X$16221 112 16971 10012 10010 10158 113 DFF_X1
* cell instance $16225 m0 *1 13.3,95.2
X$16225 6504 112 113 5942 BUF_X1
* cell instance $16228 m0 *1 16.15,95.2
X$16228 112 16750 5775 6014 5133 113 DFF_X1
* cell instance $16229 m0 *1 19.38,95.2
X$16229 112 5137 113 5943 BUF_X8
* cell instance $16239 r0 *1 22.8,95.2
X$16239 6299 113 6030 112 BUF_X4
* cell instance $16241 m0 *1 23.75,95.2
X$16241 5943 112 113 5886 INV_X2
* cell instance $16244 m0 *1 25.65,95.2
X$16244 5886 113 4062 112 BUF_X4
* cell instance $16247 m0 *1 27.17,95.2
X$16247 5513 5256 5943 112 5214 113 AOI21_X2
* cell instance $16248 m0 *1 28.5,95.2
X$16248 112 3764 113 5605 BUF_X8
* cell instance $16253 r0 *1 29.26,95.2
X$16253 5454 113 5606 112 BUF_X4
* cell instance $16254 r0 *1 30.59,95.2
X$16254 3972 5454 4840 112 113 6305 NOR3_X1
* cell instance $16256 m0 *1 31.35,95.2
X$16256 4185 6021 5262 6022 6181 4969 113 112 AOI221_X2
* cell instance $16257 r0 *1 31.35,95.2
X$16257 6115 5820 4185 4892 6305 6181 113 112 AOI221_X2
* cell instance $16258 r0 *1 33.44,95.2
X$16258 6377 4301 6116 112 113 6310 MUX2_X1
* cell instance $16260 m0 *1 33.82,95.2
X$16260 4475 6025 5944 113 6116 112 OAI21_X1
* cell instance $16262 m0 *1 36.29,95.2
X$16262 4848 112 113 4185 INV_X4
* cell instance $16265 r0 *1 34.77,95.2
X$16265 4998 4301 6306 112 113 5946 MUX2_X1
* cell instance $16268 r0 *1 38,95.2
X$16268 5606 3851 112 113 5733 NAND2_X1
* cell instance $16269 m0 *1 38.57,95.2
X$16269 4412 5008 5945 112 6029 113 AOI21_X1
* cell instance $16272 r0 *1 38.57,95.2
X$16272 5948 5606 5526 112 113 6118 MUX2_X1
* cell instance $16273 m0 *1 39.9,95.2
X$16273 6118 4065 6031 112 113 5949 MUX2_X1
* cell instance $16275 m0 *1 41.23,95.2
X$16275 6033 4067 5949 112 6308 113 AOI21_X1
* cell instance $16277 m0 *1 42.18,95.2
X$16277 4185 113 4025 112 BUF_X4
* cell instance $16280 r0 *1 40.09,95.2
X$16280 5368 4137 4856 4610 5214 112 113 6033 AOI221_X1
* cell instance $16282 r0 *1 41.42,95.2
X$16282 6308 3854 6310 112 113 6190 MUX2_X1
* cell instance $16284 r0 *1 42.94,95.2
X$16284 4462 5733 5825 4520 5948 113 112 6445 OAI221_X1
* cell instance $16285 m0 *1 46.36,95.2
X$16285 5951 4620 4475 112 113 6184 NOR3_X1
* cell instance $16286 m0 *1 43.89,95.2
X$16286 3976 4241 5951 113 112 5825 OAI21_X4
* cell instance $16288 r0 *1 44.08,95.2
X$16288 4015 112 113 5948 INV_X1
* cell instance $16289 r0 *1 44.46,95.2
X$16289 5826 5953 5948 112 113 6034 NOR3_X1
* cell instance $16291 r0 *1 45.6,95.2
X$16291 4614 5454 5952 113 6225 112 OAI21_X1
* cell instance $16294 r0 *1 46.93,95.2
X$16294 4856 4071 3764 4062 6039 6320 113 112 AOI221_X2
* cell instance $16296 m0 *1 47.5,95.2
X$16296 5260 5734 3764 112 113 6119 NAND3_X1
* cell instance $16297 m0 *1 48.83,95.2
X$16297 4412 5260 4463 112 6316 113 AOI21_X1
* cell instance $16300 m0 *1 49.78,95.2
X$16300 3765 5945 5952 112 6189 113 AOI21_X1
* cell instance $16302 m0 *1 50.73,95.2
X$16302 6038 4301 6189 112 113 6041 MUX2_X1
* cell instance $16304 m0 *1 52.25,95.2
X$16304 4702 4856 4241 112 6318 113 AOI21_X1
* cell instance $16306 r0 *1 49.02,95.2
X$16306 6184 6316 3810 112 113 6226 NOR3_X1
* cell instance $16308 r0 *1 50.16,95.2
X$16308 4856 112 113 4301 CLKBUF_X3
* cell instance $16310 r0 *1 51.49,95.2
X$16310 3854 112 113 5226 CLKBUF_X3
* cell instance $16311 r0 *1 52.44,95.2
X$16311 3765 6318 113 112 6321 AND2_X1
* cell instance $16312 r0 *1 53.2,95.2
X$16312 6321 6320 3854 112 113 6322 NOR3_X1
* cell instance $16314 m0 *1 53.39,95.2
X$16314 4244 5226 6041 113 112 6045 OAI21_X2
* cell instance $16316 r0 *1 54.15,95.2
X$16316 6322 5226 5946 112 6227 113 AOI21_X1
* cell instance $16318 m0 *1 56.05,95.2
X$16318 6323 5370 6192 112 113 6048 MUX2_X1
* cell instance $16319 m0 *1 55.1,95.2
X$16319 6045 6046 4244 6190 113 112 6192 OAI22_X1
* cell instance $16325 r0 *1 58.9,95.2
X$16325 112 17110 6228 4025 4795 113 DFF_X1
* cell instance $16326 m0 *1 60.23,95.2
X$16326 6050 112 113 4795 CLKBUF_X3
* cell instance $16333 r0 *1 64.41,95.2
X$16333 4432 4541 16703 113 112 5914 HA_X1
* cell instance $16334 m0 *1 65.55,95.2
X$16334 4432 3983 16511 113 112 5959 HA_X1
* cell instance $16336 m0 *1 67.45,95.2
X$16336 5956 113 4366 112 BUF_X4
* cell instance $16338 m0 *1 68.97,95.2
X$16338 5957 4305 112 113 6120 NOR2_X1
* cell instance $16339 m0 *1 69.54,95.2
X$16339 6054 6197 6056 3871 6057 5958 113 112 AOI221_X2
* cell instance $16340 m0 *1 71.63,95.2
X$16340 4738 4637 4980 113 5373 112 OAI21_X1
* cell instance $16341 m0 *1 72.39,95.2
X$16341 6122 4633 4151 113 6197 112 OAI21_X1
* cell instance $16342 m0 *1 73.15,95.2
X$16342 4606 5090 5961 112 5960 113 AOI21_X1
* cell instance $16343 m0 *1 73.91,95.2
X$16343 5829 112 113 3988 CLKBUF_X3
* cell instance $16344 m0 *1 74.86,95.2
X$16344 5150 4307 5829 113 6123 112 OAI21_X1
* cell instance $16345 m0 *1 75.62,95.2
X$16345 5830 5829 112 113 5962 NOR2_X1
* cell instance $16346 m0 *1 76.19,95.2
X$16346 4305 4981 4880 4366 112 113 6203 AOI22_X1
* cell instance $16347 m0 *1 77.14,95.2
X$16347 5923 5270 5269 112 4387 113 AOI21_X2
* cell instance $16348 m0 *1 78.47,95.2
X$16348 6072 5706 113 6131 112 AND2_X4
* cell instance $16349 m0 *1 80.18,95.2
X$16349 5706 5923 4488 113 112 5626 OAI21_X4
* cell instance $16351 m0 *1 82.84,95.2
X$16351 5962 4387 4156 112 113 6337 NOR3_X1
* cell instance $16352 m0 *1 83.6,95.2
X$16352 5935 3987 6210 112 6068 113 AOI21_X1
* cell instance $16353 m0 *1 84.36,95.2
X$16353 6075 112 113 5016 INV_X4
* cell instance $16355 m0 *1 85.5,95.2
X$16355 4480 6125 112 113 5964 NAND2_X1
* cell instance $16359 r0 *1 66.88,95.2
X$16359 5828 113 4480 112 BUF_X4
* cell instance $16363 r0 *1 68.21,95.2
X$16363 5956 113 3871 112 BUF_X4
* cell instance $16365 r0 *1 69.92,95.2
X$16365 112 4026 113 6121 BUF_X8
* cell instance $16366 r0 *1 72.39,95.2
X$16366 5914 113 4425 112 BUF_X4
* cell instance $16368 r0 *1 74.1,95.2
X$16368 5959 3988 6123 113 6229 112 OAI21_X1
* cell instance $16369 r0 *1 74.86,95.2
X$16369 4981 6120 4631 4425 4640 6332 113 112 AOI221_X2
* cell instance $16371 r0 *1 77.14,95.2
X$16371 4195 6125 6385 3922 4987 6461 112 113 OAI221_X2
* cell instance $16372 r0 *1 79.23,95.2
X$16372 4629 113 4380 112 BUF_X4
* cell instance $16373 r0 *1 80.56,95.2
X$16373 4636 3984 112 113 4987 NAND2_X2
* cell instance $16374 r0 *1 81.51,95.2
X$16374 4156 6203 5743 6338 6337 5930 113 112 AOI221_X2
* cell instance $16376 r0 *1 83.79,95.2
X$16376 5832 4482 4480 112 6124 113 AOI21_X2
* cell instance $16377 r0 *1 85.12,95.2
X$16377 6124 6126 4631 3988 6128 4607 113 112 AOI221_X2
* cell instance $16379 m0 *1 86.45,95.2
X$16379 6126 6056 5964 112 113 6214 MUX2_X1
* cell instance $16380 m0 *1 87.97,95.2
X$16380 4433 5964 5965 112 6127 113 AOI21_X1
* cell instance $16381 m0 *1 88.73,95.2
X$16381 5388 6127 112 113 5379 OR2_X1
* cell instance $16383 m0 *1 89.68,95.2
X$16383 5598 112 113 6219 BUF_X1
* cell instance $16384 m0 *1 90.25,95.2
X$16384 6091 6129 5388 112 113 5966 NAND3_X1
* cell instance $16385 m0 *1 91.01,95.2
X$16385 4157 6131 5968 3983 4734 6129 112 113 OAI221_X2
* cell instance $16387 r0 *1 87.21,95.2
X$16387 5830 6126 4491 112 113 6088 NAND3_X1
* cell instance $16388 r0 *1 87.97,95.2
X$16388 3984 5965 4307 4797 113 112 6128 OAI22_X2
* cell instance $16389 r0 *1 89.68,95.2
X$16389 4728 3988 4745 112 6346 113 AOI21_X1
* cell instance $16391 r0 *1 90.82,95.2
X$16391 6130 4809 5966 4904 112 5963 113 NAND4_X2
* cell instance $16392 r0 *1 92.53,95.2
X$16392 6233 5540 3986 113 6234 112 OAI21_X1
* cell instance $16393 r0 *1 93.29,95.2
X$16393 4156 4317 112 113 6233 NOR2_X1
* cell instance $16394 m0 *1 94.05,95.2
X$16394 5388 6220 5626 112 5541 113 AOI21_X1
* cell instance $16395 m0 *1 93.48,95.2
X$16395 6214 4538 112 113 6098 NAND2_X1
* cell instance $16396 m0 *1 94.81,95.2
X$16396 5815 6098 4380 4803 6132 5939 113 112 AOI221_X2
* cell instance $16398 r0 *1 93.86,95.2
X$16398 4643 4904 112 113 5282 NAND2_X1
* cell instance $16400 r0 *1 94.62,95.2
X$16400 4433 4606 6128 113 112 6218 AND3_X1
* cell instance $16402 r0 *1 96.33,95.2
X$16402 5926 4026 4433 112 6217 113 AOI21_X1
* cell instance $16405 m0 *1 97.28,95.2
X$16405 6218 5969 4497 113 5970 112 OAI21_X1
* cell instance $16407 m0 *1 104.88,95.2
X$16407 6106 5120 112 113 6134 NOR2_X1
* cell instance $16410 r0 *1 97.66,95.2
X$16410 6217 6236 4643 4871 6133 113 112 5632 OAI221_X1
* cell instance $16415 r0 *1 103.93,95.2
X$16415 3068 6106 113 112 6356 AND2_X1
* cell instance $16416 r0 *1 104.69,95.2
X$16416 6356 6134 6237 113 112 312 MUX2_X2
* cell instance $16417 m0 *1 106.02,95.2
X$16417 5955 5972 113 112 6110 XNOR2_X1
* cell instance $16419 m0 *1 107.16,95.2
X$16419 2919 6110 113 112 6609 XNOR2_X1
* cell instance $16424 r0 *1 108.3,95.2
X$16424 112 17056 6362 6216 5751 113 DFF_X1
* cell instance $16425 m0 *1 109.63,95.2
X$16425 4279 112 113 5751 CLKBUF_X3
* cell instance $16427 m0 *1 110.58,95.2
X$16427 6361 3776 5752 112 6216 113 AOI21_X1
* cell instance $16429 m0 *1 112.86,95.2
X$16429 112 6213 5973 6048 5288 113 DFF_X1
* cell instance $16430 m0 *1 116.09,95.2
X$16430 4031 5973 113 112 6135 XNOR2_X1
* cell instance $16433 r0 *1 111.72,95.2
X$16433 6362 112 113 6215 CLKBUF_X3
* cell instance $16435 r0 *1 113.43,95.2
X$16435 1747 112 113 4279 CLKBUF_X3
* cell instance $16436 r0 *1 114.38,95.2
X$16436 6240 6238 113 112 6136 XNOR2_X1
* cell instance $16437 r0 *1 115.52,95.2
X$16437 4279 112 113 17171 INV_X2
* cell instance $16439 r0 *1 116.28,95.2
X$16439 4817 6135 113 112 6242 XNOR2_X1
* cell instance $16441 m0 *1 118.75,95.2
X$16441 257 6211 6212 112 113 6114 MUX2_X1
* cell instance $16442 m0 *1 117.61,95.2
X$16442 2919 6136 113 112 6212 XNOR2_X1
* cell instance $16446 r0 *1 119.13,95.2
X$16446 6243 3776 6136 112 6489 113 AOI21_X1
* cell instance $16447 r0 *1 119.89,95.2
X$16447 221 6244 112 113 6243 NOR2_X1
* cell instance $16449 m0 *1 123.31,95.2
X$16449 142 6211 6137 112 113 6113 MUX2_X1
* cell instance $16450 m0 *1 121.98,95.2
X$16450 5974 113 2919 112 BUF_X4
* cell instance $16451 m0 *1 124.64,95.2
X$16451 5976 6138 5634 112 113 5975 NAND3_X1
* cell instance $16452 m0 *1 125.4,95.2
X$16452 112 16768 6108 6113 4918 113 DFF_X1
* cell instance $16453 m0 *1 128.63,95.2
X$16453 6108 113 5993 112 BUF_X4
* cell instance $16457 m0 *1 132.43,95.2
X$16457 6398 5977 113 112 5546 XNOR2_X1
* cell instance $16462 r0 *1 123.31,95.2
X$16462 5993 6370 113 112 6137 XNOR2_X1
* cell instance $16471 r0 *1 130.15,95.2
X$16471 6375 6374 112 113 5971 XNOR2_X2
* cell instance $16472 r0 *1 132.05,95.2
X$16472 5977 6373 112 113 6375 XNOR2_X2
* cell instance $16473 r0 *1 133.95,95.2
X$16473 112 1013 4918 17256 6245 113 DFF_X2
* cell instance $16474 m0 *1 134.14,95.2
X$16474 6104 6107 113 5547 112 XOR2_X2
* cell instance $16476 m0 *1 135.85,95.2
X$16476 5978 6105 112 113 6209 XNOR2_X2
* cell instance $16477 m0 *1 137.75,95.2
X$16477 3470 112 113 6104 BUF_X2
* cell instance $16480 r0 *1 137.56,95.2
X$16480 5547 112 113 6372 BUF_X1
* cell instance $16481 r0 *1 138.13,95.2
X$16481 6246 5922 112 113 6247 NAND2_X1
* cell instance $16482 r0 *1 138.7,95.2
X$16482 6246 5801 112 113 6500 NAND2_X1
* cell instance $16484 r0 *1 139.46,95.2
X$16484 5922 6138 6498 112 113 6369 NAND3_X1
* cell instance $16486 m0 *1 143.64,95.2
X$16486 6254 113 5982 112 BUF_X4
* cell instance $16487 m0 *1 140.41,95.2
X$16487 112 16756 6103 6102 5919 113 DFF_X1
* cell instance $16489 m0 *1 145.73,95.2
X$16489 6141 6142 112 113 6100 NOR2_X1
* cell instance $16490 m0 *1 146.3,95.2
X$16490 6207 6101 5979 6208 112 113 6096 AOI22_X1
* cell instance $16491 m0 *1 147.25,95.2
X$16491 6143 6100 5980 112 6207 113 AOI21_X1
* cell instance $16492 m0 *1 148.01,95.2
X$16492 6081 6144 112 113 6143 NAND2_X1
* cell instance $16497 r0 *1 143.07,95.2
X$16497 6196 6139 112 113 6368 NOR2_X1
* cell instance $16499 r0 *1 143.83,95.2
X$16499 6366 6248 6358 112 113 5296 NAND3_X1
* cell instance $16501 r0 *1 144.97,95.2
X$16501 6364 6140 112 113 6249 NOR2_X1
* cell instance $16502 r0 *1 145.54,95.2
X$16502 6249 6492 6206 6363 112 113 6366 AOI22_X1
* cell instance $16506 r0 *1 148.58,95.2
X$16506 6252 6198 6364 6257 112 113 6206 NOR4_X1
* cell instance $16507 m0 *1 150.1,95.2
X$16507 5988 5984 5845 112 6089 113 AOI21_X1
* cell instance $16508 m0 *1 148.96,95.2
X$16508 6205 5981 113 112 5983 XNOR2_X1
* cell instance $16511 m0 *1 153.14,95.2
X$16511 6142 5985 6097 112 6086 113 AOI21_X1
* cell instance $16512 m0 *1 153.9,95.2
X$16512 6144 5982 112 113 6147 NOR2_X1
* cell instance $16513 m0 *1 154.47,95.2
X$16513 6201 6150 5989 113 6087 112 OAI21_X1
* cell instance $16514 m0 *1 155.23,95.2
X$16514 5987 6148 5991 112 5986 113 AOI21_X1
* cell instance $16518 r0 *1 150.67,95.2
X$16518 6359 6352 6256 113 6363 112 OAI21_X1
* cell instance $16521 r0 *1 153.14,95.2
X$16521 6144 6152 112 113 6258 NOR2_X1
* cell instance $16522 r0 *1 153.71,95.2
X$16522 6146 6258 6202 6147 112 113 6259 AOI22_X1
* cell instance $16523 r0 *1 154.66,95.2
X$16523 6354 6259 6357 112 6479 113 AOI21_X1
* cell instance $16526 r0 *1 155.99,95.2
X$16526 6355 6150 6195 6260 6200 113 112 6151 OAI221_X1
* cell instance $16527 m0 *1 157.13,95.2
X$16527 5987 6199 112 113 6200 NOR2_X1
* cell instance $16528 m0 *1 156.37,95.2
X$16528 6087 6151 5848 112 113 6090 NAND3_X1
* cell instance $16531 m0 *1 158.27,95.2
X$16531 6081 6254 112 113 5989 NOR2_X1
* cell instance $16533 m0 *1 158.84,95.2
X$16533 6199 6154 6152 112 113 6082 NOR3_X1
* cell instance $16534 m0 *1 159.6,95.2
X$16534 5979 6196 6155 112 113 5850 NAND3_X1
* cell instance $16535 m0 *1 160.36,95.2
X$16535 6144 5985 5989 5991 6153 113 112 6079 OAI221_X1
* cell instance $16536 m0 *1 161.5,95.2
X$16536 6080 112 113 6144 CLKBUF_X3
* cell instance $16537 m0 *1 162.45,95.2
X$16537 6081 113 6195 112 BUF_X4
* cell instance $16539 m0 *1 163.97,95.2
X$16539 5981 6080 112 113 6157 NAND2_X1
* cell instance $16540 m0 *1 164.54,95.2
X$16540 6079 6158 6094 112 113 6076 NAND3_X1
* cell instance $16543 r0 *1 158.84,95.2
X$16543 6353 6260 6157 6159 6144 6154 112 113 6198 OAI33_X1
* cell instance $16544 r0 *1 160.17,95.2
X$16544 6352 6262 112 113 6155 NAND2_X1
* cell instance $16546 r0 *1 160.93,95.2
X$16546 6347 6094 112 113 6350 NAND2_X1
* cell instance $16547 r0 *1 161.5,95.2
X$16547 6260 6349 112 113 6264 NOR2_X1
* cell instance $16548 r0 *1 162.07,95.2
X$16548 6264 5991 5846 6153 6266 113 112 6348 OAI221_X1
* cell instance $16550 r0 *1 163.4,95.2
X$16550 6139 6345 6156 6256 6266 113 112 6347 OAI221_X1
* cell instance $16552 r0 *1 164.73,95.2
X$16552 6144 6345 6344 6159 6157 113 112 6158 OAI221_X1
* cell instance $16553 m0 *1 165.87,95.2
X$16553 5846 112 113 6257 CLKBUF_X3
* cell instance $16555 m0 *1 166.82,95.2
X$16555 5992 113 6148 112 BUF_X4
* cell instance $16558 m0 *1 169.1,95.2
X$16558 5853 112 113 5994 BUF_X1
* cell instance $16561 r0 *1 166.63,95.2
X$16561 6267 5992 112 113 6265 NOR2_X2
* cell instance $16562 r0 *1 167.58,95.2
X$16562 6268 6255 16660 113 112 5992 HA_X1
* cell instance $16565 r0 *1 170.05,95.2
X$16565 6142 113 6139 112 BUF_X4
* cell instance $16567 m0 *1 170.05,95.2
X$16567 112 16909 6193 5101 5758 113 DFF_X1
* cell instance $16569 m0 *1 173.85,95.2
X$16569 401 112 113 5758 CLKBUF_X3
* cell instance $16571 m0 *1 174.8,95.2
X$16571 5758 112 113 16469 CLKBUF_X1
* cell instance $16574 m0 *1 178.98,95.2
X$16574 5993 112 113 6070 INV_X1
* cell instance $16575 m0 *1 176.51,95.2
X$16575 112 6163 113 6193 BUF_X8
* cell instance $16576 m0 *1 179.36,95.2
X$16576 6160 6161 6191 112 113 2742 OR3_X2
* cell instance $16579 m0 *1 183.73,95.2
X$16579 6069 6188 112 113 6067 XNOR2_X2
* cell instance $16581 m0 *1 185.82,95.2
X$16581 5857 6067 112 113 6185 XNOR2_X2
* cell instance $16583 m0 *1 187.91,95.2
X$16583 5997 6066 112 113 5857 XNOR2_X2
* cell instance $16587 r0 *1 178.6,95.2
X$16587 6271 5928 5993 112 113 6342 NAND3_X1
* cell instance $16588 r0 *1 179.36,95.2
X$16588 6339 6342 6341 112 6161 113 AOI21_X1
* cell instance $16593 r0 *1 180.31,95.2
X$16593 3442 6163 113 6162 112 XOR2_X2
* cell instance $16596 r0 *1 183.73,95.2
X$16596 6186 6187 113 112 6188 XNOR2_X1
* cell instance $16598 r0 *1 187.91,95.2
X$16598 6163 113 6165 112 BUF_X4
* cell instance $16599 r0 *1 189.24,95.2
X$16599 6165 112 113 6063 BUF_X1
* cell instance $16600 r0 *1 189.81,95.2
X$16600 6187 4817 113 6275 112 XOR2_X2
* cell instance $16601 m0 *1 191.9,95.2
X$16601 6063 4659 113 6176 112 XOR2_X2
* cell instance $16602 m0 *1 190.19,95.2
X$16602 6187 6165 113 5457 112 XOR2_X2
* cell instance $16605 m0 *1 194.56,95.2
X$16605 5997 6061 112 113 6183 XNOR2_X2
* cell instance $16608 m0 *1 203.3,95.2
X$16608 5449 5998 112 113 6001 XNOR2_X2
* cell instance $16609 m0 *1 205.2,95.2
X$16609 5865 113 6167 112 BUF_X4
* cell instance $16613 r0 *1 191.9,95.2
X$16613 3442 6336 113 112 6335 XNOR2_X1
* cell instance $16616 r0 *1 193.61,95.2
X$16616 4674 5763 113 112 6334 XNOR2_X1
* cell instance $16620 r0 *1 203.11,95.2
X$16620 5997 6333 113 5444 112 XOR2_X2
* cell instance $16623 r0 *1 205.39,95.2
X$16623 6333 5572 112 113 6331 XNOR2_X2
* cell instance $16625 r0 *1 207.48,95.2
X$16625 6166 113 6170 112 BUF_X4
* cell instance $16626 m0 *1 210.14,95.2
X$16626 5421 113 6175 112 BUF_X4
* cell instance $16627 m0 *1 207.67,95.2
X$16627 112 6053 5421 5861 5862 113 AOI21_X4
* cell instance $16631 r0 *1 209,95.2
X$16631 5861 5862 5421 112 113 6277 NAND3_X2
* cell instance $16632 r0 *1 210.33,95.2
X$16632 5875 5656 5999 112 6002 113 NAND3_X4
* cell instance $16634 m0 *1 212.61,95.2
X$16634 6166 5420 5868 6167 6279 113 112 AOI211_X2
* cell instance $16635 m0 *1 214.51,95.2
X$16635 6167 112 113 6005 CLKBUF_X3
* cell instance $16638 r0 *1 212.8,95.2
X$16638 6002 5420 6280 113 6281 112 OAI21_X1
* cell instance $16640 r0 *1 213.75,95.2
X$16640 5569 5870 6328 5446 113 112 6327 OAI22_X1
* cell instance $16643 r0 *1 215.27,95.2
X$16643 6171 6327 6170 113 6282 112 OAI21_X1
* cell instance $16644 r0 *1 216.03,95.2
X$16644 6001 112 113 6173 CLKBUF_X3
* cell instance $16646 m0 *1 216.6,95.2
X$16646 6000 6043 6173 113 6047 112 OAI21_X1
* cell instance $16647 m0 *1 218.12,95.2
X$16647 6002 5662 112 113 6043 NOR2_X1
* cell instance $16648 m0 *1 218.69,95.2
X$16648 5866 6004 6001 5424 5864 6182 113 112 AOI221_X2
* cell instance $16650 r0 *1 216.98,95.2
X$16650 6043 5427 6277 112 6325 113 AOI21_X1
* cell instance $16652 r0 *1 217.93,95.2
X$16652 6005 6311 5781 113 6285 112 OAI21_X1
* cell instance $16654 r0 *1 219.07,95.2
X$16654 6182 6037 6283 6288 6168 6286 113 112 AOI221_X2
* cell instance $16655 m0 *1 222.49,95.2
X$16655 6006 5446 5874 113 6035 112 OAI21_X1
* cell instance $16656 m0 *1 221.16,95.2
X$16656 5562 5660 5659 113 112 6169 OAI21_X2
* cell instance $16659 r0 *1 221.16,95.2
X$16659 6170 5198 6053 112 6288 113 AOI21_X1
* cell instance $16660 r0 *1 221.92,95.2
X$16660 5782 6028 6169 112 6172 113 AOI21_X1
* cell instance $16661 r0 *1 222.68,95.2
X$16661 6172 6173 6174 113 6435 112 OAI21_X1
* cell instance $16662 r0 *1 223.44,95.2
X$16662 6287 5874 6291 113 112 6315 AND3_X1
* cell instance $16663 r0 *1 224.39,95.2
X$16663 6171 5874 6052 112 6180 113 AOI21_X1
* cell instance $16665 m0 *1 224.39,95.2
X$16665 6007 5198 112 113 6008 NOR2_X1
* cell instance $16666 m0 *1 225.15,95.2
X$16666 5780 112 113 6174 CLKBUF_X3
* cell instance $16668 m0 *1 226.29,95.2
X$16668 6311 6005 5780 113 6314 112 OAI21_X1
* cell instance $16670 m0 *1 227.24,95.2
X$16670 6028 6179 6027 113 6309 112 OAI21_X1
* cell instance $16672 r0 *1 225.15,95.2
X$16672 6280 112 113 6287 CLKBUF_X3
* cell instance $16674 r0 *1 226.48,95.2
X$16674 6314 6008 6289 6174 6309 113 112 6290 OAI221_X1
* cell instance $16676 r0 *1 228,95.2
X$16676 6292 6291 6174 6028 6009 113 112 6307 OAI221_X1
* cell instance $16677 m0 *1 229.14,95.2
X$16677 6024 6010 6019 113 6178 112 OAI21_X1
* cell instance $16678 m0 *1 228.38,95.2
X$16678 5873 5446 6009 113 6179 112 OAI21_X1
* cell instance $16679 m0 *1 229.9,95.2
X$16679 6175 113 6171 112 BUF_X4
* cell instance $16680 m0 *1 231.23,95.2
X$16680 6006 113 6003 112 BUF_X4
* cell instance $16682 m0 *1 234.08,95.2
X$16682 6005 5662 112 113 6301 NAND2_X1
* cell instance $16686 r0 *1 229.14,95.2
X$16686 5427 5871 112 113 6292 XNOR2_X2
* cell instance $16687 r0 *1 231.04,95.2
X$16687 6175 6006 5446 112 113 6303 MUX2_X1
* cell instance $16688 r0 *1 232.37,95.2
X$16688 5870 6171 6003 112 113 6302 NAND3_X1
* cell instance $16689 r0 *1 233.13,95.2
X$16689 6303 5771 6301 5783 6302 6300 112 113 OAI221_X2
* cell instance $16690 r0 *1 235.22,95.2
X$16690 112 16943 6729 6176 5429 113 DFF_X1
* cell instance $16694 r0 *1 238.45,95.2
X$16694 6013 112 113 6298 BUF_X1
* cell instance $16696 r0 *1 239.21,95.2
X$16696 6294 112 113 6295 BUF_X1
* cell instance $16772 r0 *1 57,33.6
X$16772 1113 1112 1114 113 112 1073 HA_X1
* cell instance $16773 m0 *1 58.71,33.6
X$16773 1073 112 113 1349 CLKBUF_X3
* cell instance $16776 m0 *1 59.85,33.6
X$16776 1266 1030 112 113 1474 NOR2_X1
* cell instance $16779 r0 *1 58.9,33.6
X$16779 1114 112 113 1144 BUF_X2
* cell instance $16780 r0 *1 59.66,33.6
X$16780 1114 113 1311 112 BUF_X4
* cell instance $16781 r0 *1 60.99,33.6
X$16781 1115 1146 16678 113 112 1030 HA_X1
* cell instance $16783 m0 *1 62.32,33.6
X$16783 1075 1031 112 113 1074 NOR2_X1
* cell instance $16787 r0 *1 62.89,33.6
X$16787 1115 1146 16720 113 112 1312 HA_X1
* cell instance $16788 r0 *1 64.79,33.6
X$16788 937 112 113 1031 INV_X2
* cell instance $16789 r0 *1 65.36,33.6
X$16789 112 1116 113 1145 BUF_X8
* cell instance $16790 r0 *1 67.83,33.6
X$16790 1113 1146 16653 113 112 1353 HA_X1
* cell instance $16795 m0 *1 68.78,33.6
X$16795 112 1116 938 113 INV_X16
* cell instance $16798 r0 *1 69.73,33.6
X$16798 1115 1112 16690 113 112 1117 HA_X1
* cell instance $16799 r0 *1 71.63,33.6
X$16799 1115 1112 16661 113 112 1147 HA_X1
* cell instance $16803 r0 *1 76,33.6
X$16803 112 938 1149 113 BUF_X32
* cell instance $16804 m0 *1 80.94,33.6
X$16804 687 867 834 112 113 941 MUX2_X1
* cell instance $16805 m0 *1 78.47,33.6
X$16805 112 997 113 470 BUF_X8
* cell instance $16806 m0 *1 82.27,33.6
X$16806 1033 942 1076 995 113 112 1150 OAI22_X1
* cell instance $16807 m0 *1 83.22,33.6
X$16807 1079 1033 1032 1078 1034 113 112 AOI211_X2
* cell instance $16809 r0 *1 85.31,33.6
X$16809 1035 451 1195 112 113 1118 MUX2_X1
* cell instance $16810 m0 *1 85.5,33.6
X$16810 687 268 576 112 113 1078 MUX2_X1
* cell instance $16812 m0 *1 86.83,33.6
X$16812 691 867 1154 112 1079 113 AOI21_X1
* cell instance $16814 m0 *1 88.35,33.6
X$16814 366 691 524 112 113 1036 MUX2_X1
* cell instance $16815 m0 *1 89.68,33.6
X$16815 867 366 112 113 1037 NAND2_X1
* cell instance $16816 m0 *1 90.25,33.6
X$16816 1038 1037 1042 112 1076 113 AOI21_X1
* cell instance $16817 m0 *1 91.01,33.6
X$16817 997 833 112 113 1039 NAND2_X1
* cell instance $16819 m0 *1 91.77,33.6
X$16819 1040 794 870 112 1119 113 AOI21_X1
* cell instance $16820 m0 *1 92.53,33.6
X$16820 1040 715 112 113 999 NOR2_X1
* cell instance $16822 m0 *1 93.29,33.6
X$16822 551 945 1001 113 1041 112 OAI21_X1
* cell instance $16823 m0 *1 94.05,33.6
X$16823 944 833 112 113 1001 NAND2_X1
* cell instance $16825 m0 *1 94.81,33.6
X$16825 997 413 112 113 1042 NAND2_X1
* cell instance $16826 m0 *1 95.38,33.6
X$16826 1042 1003 113 112 1083 AND2_X1
* cell instance $16827 m0 *1 96.14,33.6
X$16827 1043 1084 1083 1085 1044 646 112 113 1086 OAI33_X1
* cell instance $16829 m0 *1 97.66,33.6
X$16829 470 617 112 113 1005 NAND2_X1
* cell instance $16831 m0 *1 98.42,33.6
X$16831 1086 1045 947 112 113 1243 MUX2_X1
* cell instance $16833 m0 *1 99.94,33.6
X$16833 112 867 113 364 BUF_X8
* cell instance $16837 r0 *1 87.59,33.6
X$16837 1157 999 1156 113 1237 112 OAI21_X1
* cell instance $16839 r0 *1 88.73,33.6
X$16839 1160 1157 840 1158 1036 113 112 1319 OAI221_X1
* cell instance $16840 r0 *1 89.87,33.6
X$16840 264 525 112 113 1158 NAND2_X1
* cell instance $16842 r0 *1 90.82,33.6
X$16842 714 1039 945 112 1160 113 AOI21_X1
* cell instance $16845 r0 *1 92.15,33.6
X$16845 867 523 519 112 113 1120 NAND3_X1
* cell instance $16847 r0 *1 93.1,33.6
X$16847 1041 520 1197 997 1162 1161 113 112 AOI221_X2
* cell instance $16848 r0 *1 95.19,33.6
X$16848 872 943 112 113 1162 NAND2_X1
* cell instance $16849 r0 *1 95.76,33.6
X$16849 1042 1166 872 112 113 1165 NAND3_X1
* cell instance $16850 r0 *1 96.52,33.6
X$16850 1165 1043 112 113 1044 NAND2_X1
* cell instance $16854 r0 *1 101.84,33.6
X$16854 263 264 16659 113 112 1122 HA_X1
* cell instance $16856 m0 *1 102.79,33.6
X$16856 1122 309 1090 112 113 948 MUX2_X1
* cell instance $16857 m0 *1 104.31,33.6
X$16857 579 112 113 1038 CLKBUF_X3
* cell instance $16858 m0 *1 105.26,33.6
X$16858 719 263 364 113 112 1090 OAI21_X2
* cell instance $16863 r0 *1 105.64,33.6
X$16863 1122 505 112 113 1203 OR2_X1
* cell instance $16865 m0 *1 107.92,33.6
X$16865 718 798 416 112 113 1173 MUX2_X1
* cell instance $16873 m0 *1 116.66,33.6
X$16873 955 952 1047 953 954 113 112 1094 OAI221_X1
* cell instance $16876 m0 *1 117.99,33.6
X$16876 1094 583 1175 112 1095 113 AOI21_X1
* cell instance $16878 m0 *1 118.94,33.6
X$16878 583 635 1046 113 956 112 OAI21_X1
* cell instance $16879 m0 *1 119.7,33.6
X$16879 112 956 532 1179 635 957 723 1048 113 AOI222_X2
* cell instance $16881 m0 *1 122.55,33.6
X$16881 1100 1015 635 1027 1101 1016 113 112 AOI221_X2
* cell instance $16883 m0 *1 124.83,33.6
X$16883 958 707 952 731 1023 964 113 112 AOI221_X2
* cell instance $16888 r0 *1 116.85,33.6
X$16888 805 854 1012 582 1048 1123 112 113 1175 OAI33_X1
* cell instance $16889 r0 *1 118.18,33.6
X$16889 952 1023 112 113 1123 NOR2_X1
* cell instance $16890 r0 *1 118.75,33.6
X$16890 112 1124 113 922 BUF_X8
* cell instance $16895 r0 *1 124.26,33.6
X$16895 585 727 1125 113 958 112 OAI21_X1
* cell instance $16896 r0 *1 125.02,33.6
X$16896 725 724 721 112 113 1125 NAND3_X1
* cell instance $16900 r0 *1 127.11,33.6
X$16900 1126 530 112 113 814 NAND2_X2
* cell instance $16901 r0 *1 128.06,33.6
X$16901 814 1049 1127 113 112 1183 AND3_X1
* cell instance $16903 m0 *1 129.58,33.6
X$16903 529 922 112 113 1049 NOR2_X1
* cell instance $16904 m0 *1 130.15,33.6
X$16904 960 1103 1265 1099 113 112 1106 OAI22_X2
* cell instance $16905 m0 *1 131.86,33.6
X$16905 722 1050 792 583 1051 1103 112 113 OAI221_X2
* cell instance $16907 m0 *1 134.71,33.6
X$16907 733 961 1108 113 1110 112 OAI21_X1
* cell instance $16908 m0 *1 135.47,33.6
X$16908 1109 1052 588 112 113 1108 OR3_X1
* cell instance $16909 m0 *1 136.42,33.6
X$16909 855 1110 1053 963 113 112 1111 OAI22_X1
* cell instance $16911 m0 *1 138.13,33.6
X$16911 1111 1026 1020 1055 1016 1022 112 113 1054 OAI33_X1
* cell instance $16912 m0 *1 139.46,33.6
X$16912 964 1056 1047 112 113 1107 NOR3_X1
* cell instance $16918 r0 *1 131.86,33.6
X$16918 112 1186 1263 1184 1185 1127 1106 1029 113 AOI222_X2
* cell instance $16921 r0 *1 135.09,33.6
X$16921 1126 1128 112 113 1052 NOR2_X1
* cell instance $16923 r0 *1 137.18,33.6
X$16923 1258 1052 810 112 113 1260 NOR3_X1
* cell instance $16925 r0 *1 138.7,33.6
X$16925 1027 1017 965 112 113 1257 NOR3_X1
* cell instance $16926 r0 *1 139.46,33.6
X$16926 928 1055 1179 112 113 1256 OR3_X1
* cell instance $16928 m0 *1 141.36,33.6
X$16928 1209 528 1182 583 588 113 112 1105 OAI221_X1
* cell instance $16929 m0 *1 140.6,33.6
X$16929 808 1107 1057 113 1181 112 OAI21_X1
* cell instance $16930 m0 *1 142.5,33.6
X$16930 1020 112 113 1057 INV_X1
* cell instance $16932 r0 *1 140.6,33.6
X$16932 1017 532 814 112 1129 113 AOI21_X1
* cell instance $16935 r0 *1 143.07,33.6
X$16935 721 112 113 1128 INV_X1
* cell instance $16936 m0 *1 143.45,33.6
X$16936 1049 528 583 112 113 1102 NOR3_X1
* cell instance $16939 m0 *1 144.4,33.6
X$16939 1102 734 112 113 966 NOR2_X1
* cell instance $16943 r0 *1 143.83,33.6
X$16943 966 656 1055 1018 1131 1180 113 112 AOI221_X2
* cell instance $16945 r0 *1 146.11,33.6
X$16945 591 662 112 113 1177 NAND2_X1
* cell instance $16946 m0 *1 146.87,33.6
X$16946 731 659 1025 113 1178 112 OAI21_X1
* cell instance $16947 m0 *1 146.11,33.6
X$16947 967 886 1058 112 113 1206 NOR3_X1
* cell instance $16948 m0 *1 147.63,33.6
X$16948 659 660 112 113 1059 NOR2_X1
* cell instance $16951 r0 *1 146.87,33.6
X$16951 591 1178 1177 1059 113 112 1132 OAI22_X1
* cell instance $16952 r0 *1 147.82,33.6
X$16952 1051 965 112 113 1176 NAND2_X1
* cell instance $16953 r0 *1 148.39,33.6
X$16953 658 1885 1017 969 704 1252 113 112 AOI221_X2
* cell instance $16954 m0 *1 148.77,33.6
X$16954 1051 113 1099 112 BUF_X4
* cell instance $16959 m0 *1 162.45,33.6
X$16959 240 478 976 112 1097 113 AOI21_X1
* cell instance $16960 m0 *1 163.21,33.6
X$16960 887 478 373 112 1096 113 AOI21_X1
* cell instance $16966 r0 *1 161.5,33.6
X$16966 1060 113 441 112 BUF_X4
* cell instance $16968 r0 *1 163.02,33.6
X$16968 295 1167 894 113 112 1213 OAI21_X2
* cell instance $16969 r0 *1 164.35,33.6
X$16969 1133 1134 547 681 480 816 113 112 AOI221_X2
* cell instance $16971 m0 *1 164.54,33.6
X$16971 327 972 1093 112 113 970 OR3_X2
* cell instance $16972 m0 *1 165.68,33.6
X$16972 971 1133 535 112 918 113 AOI21_X1
* cell instance $16973 m0 *1 166.44,33.6
X$16973 518 971 1089 1062 1061 1174 112 113 1093 OAI33_X1
* cell instance $16974 m0 *1 167.77,33.6
X$16974 1060 380 112 113 1061 NAND2_X1
* cell instance $16976 m0 *1 168.53,33.6
X$16976 1061 403 907 112 1092 113 AOI21_X1
* cell instance $16979 m0 *1 171,33.6
X$16979 506 1091 534 112 1062 113 AOI21_X1
* cell instance $16980 m0 *1 171.76,33.6
X$16980 973 566 112 113 534 NAND2_X2
* cell instance $16983 m0 *1 173.66,33.6
X$16983 847 1082 441 319 1063 972 113 112 AOI221_X2
* cell instance $16985 r0 *1 166.44,33.6
X$16985 279 534 998 112 1135 113 AOI21_X1
* cell instance $16989 r0 *1 169.67,33.6
X$16989 851 973 112 113 1136 NAND2_X1
* cell instance $16991 r0 *1 170.43,33.6
X$16991 373 668 1171 113 1172 112 OAI21_X1
* cell instance $16992 r0 *1 171.19,33.6
X$16992 851 1070 112 113 1170 NOR2_X1
* cell instance $16993 r0 *1 171.76,33.6
X$16993 450 1170 494 113 1171 112 OAI21_X1
* cell instance $16994 r0 *1 172.52,33.6
X$16994 974 322 1066 480 112 113 1169 AOI22_X1
* cell instance $16996 r0 *1 173.66,33.6
X$16996 400 1163 670 112 113 NOR2_X4
* cell instance $16998 r0 *1 175.75,33.6
X$16998 1167 280 1091 112 1067 113 AOI21_X1
* cell instance $17000 m0 *1 176.13,33.6
X$17000 681 1064 895 112 1089 113 AOI21_X1
* cell instance $17002 r0 *1 176.89,33.6
X$17002 319 1138 1137 112 113 1065 OR3_X1
* cell instance $17004 m0 *1 177.27,33.6
X$17004 1088 1065 327 112 113 512 NAND3_X1
* cell instance $17006 r0 *1 178.03,33.6
X$17006 1164 279 112 113 1138 NOR2_X1
* cell instance $17007 m0 *1 178.6,33.6
X$17007 1087 977 319 112 113 1088 NAND3_X1
* cell instance $17010 m0 *1 179.55,33.6
X$17010 1066 1068 234 113 1087 112 OAI21_X1
* cell instance $17014 r0 *1 179.17,33.6
X$17014 610 387 112 113 1066 NOR2_X1
* cell instance $17015 r0 *1 179.74,33.6
X$17015 1163 373 681 113 1239 112 OAI21_X1
* cell instance $17021 m0 *1 180.69,33.6
X$17021 506 818 112 113 1068 NOR2_X1
* cell instance $17022 r0 *1 180.88,33.6
X$17022 826 1140 343 1139 542 1063 113 112 AOI221_X2
* cell instance $17024 m0 *1 181.83,33.6
X$17024 1069 494 112 977 113 OR2_X4
* cell instance $17025 m0 *1 183.54,33.6
X$17025 1068 1081 234 113 979 112 OAI21_X1
* cell instance $17026 m0 *1 184.3,33.6
X$17026 677 984 112 113 980 NOR2_X1
* cell instance $17027 m0 *1 184.87,33.6
X$17027 980 1070 894 112 113 678 OR3_X4
* cell instance $17028 m0 *1 186.96,33.6
X$17028 609 1071 1080 990 234 917 113 112 AOI221_X2
* cell instance $17029 m0 *1 189.05,33.6
X$17029 280 320 112 113 994 NOR2_X1
* cell instance $17031 m0 *1 191.14,33.6
X$17031 990 400 1072 112 113 985 MUX2_X1
* cell instance $17032 m0 *1 192.47,33.6
X$17032 673 280 322 113 1072 112 OAI21_X1
* cell instance $17033 m0 *1 193.23,33.6
X$17033 973 112 113 862 CLKBUF_X3
* cell instance $17035 r0 *1 182.97,33.6
X$17035 235 1140 1139 112 113 1152 NAND3_X1
* cell instance $17037 r0 *1 184.11,33.6
X$17037 279 1155 235 113 896 112 OAI21_X1
* cell instance $17039 r0 *1 185.25,33.6
X$17039 994 1060 1151 1153 543 981 113 112 AOI221_X2
* cell instance $17040 r0 *1 187.34,33.6
X$17040 1152 862 112 113 1151 NAND2_X1
* cell instance $17041 r0 *1 187.91,33.6
X$17041 1232 494 112 113 1071 NOR2_X1
* cell instance $17042 r0 *1 188.48,33.6
X$17042 973 1140 112 113 761 NAND2_X1
* cell instance $17045 r0 *1 190.19,33.6
X$17045 761 1070 112 113 1142 NAND2_X1
* cell instance $17046 r0 *1 190.76,33.6
X$17046 668 423 380 112 113 1143 NOR3_X1
* cell instance $17049 r0 *1 192.09,33.6
X$17049 893 1214 280 113 112 668 MUX2_X2
* cell instance $17051 m0 *1 194.75,33.6
X$17051 973 113 494 112 BUF_X4
* cell instance $17063 r0 *1 195.51,33.6
X$17063 983 113 497 112 BUF_X4
* cell instance $17090 m0 *1 87.02,16.8
X$17090 261 186 125 112 113 244 MUX2_X1
* cell instance $17111 r0 *1 84.36,16.8
X$17111 112 244 243 17251 261 113 DFF_X2
* cell instance $17112 r0 *1 87.97,16.8
X$17112 263 264 16625 113 112 245 HA_X1
* cell instance $17113 r0 *1 89.87,16.8
X$17113 245 112 113 291 INV_X1
* cell instance $17116 r0 *1 91.96,16.8
X$17116 264 394 16697 113 112 293 HA_X1
* cell instance $17117 r0 *1 93.86,16.8
X$17117 304 112 113 336 INV_X2
* cell instance $17120 r0 *1 95.38,16.8
X$17120 247 266 223 112 113 267 MUX2_X1
* cell instance $17124 r0 *1 100.32,16.8
X$17124 225 113 268 112 BUF_X4
* cell instance $17125 r0 *1 103.36,16.8
X$17125 225 112 113 266 INV_X8
* cell instance $17150 r0 *1 29.83,173.6
X$17150 112 13067 10314 113 BUF_X32
* cell instance $17151 m0 *1 33.63,173.6
X$17151 11398 10314 13196 113 112 13061 HA_X1
* cell instance $17154 m0 *1 36.1,173.6
X$17154 11395 113 12583 112 BUF_X4
* cell instance $17156 m0 *1 37.43,173.6
X$17156 10741 13243 12948 113 13112 112 OAI21_X1
* cell instance $17157 m0 *1 38.19,173.6
X$17157 12181 13196 112 113 13203 NOR2_X1
* cell instance $17158 m0 *1 38.76,173.6
X$17158 12181 11882 10314 113 13118 112 OAI21_X1
* cell instance $17160 m0 *1 39.71,173.6
X$17160 11394 112 113 11880 CLKBUF_X3
* cell instance $17162 m0 *1 40.85,173.6
X$17162 12793 11880 112 113 13151 NAND2_X1
* cell instance $17163 m0 *1 41.42,173.6
X$17163 13151 11717 11486 12583 13114 113 112 13152 OAI221_X1
* cell instance $17164 m0 *1 42.56,173.6
X$17164 13200 13152 10795 112 113 13201 NAND3_X1
* cell instance $17166 m0 *1 43.51,173.6
X$17166 10554 13118 13202 12460 12950 113 112 13117 OAI221_X1
* cell instance $17168 r0 *1 39.14,173.6
X$17168 12583 10314 16647 113 112 11174 HA_X1
* cell instance $17170 r0 *1 41.23,173.6
X$17170 10797 112 113 10404 CLKBUF_X3
* cell instance $17171 r0 *1 42.18,173.6
X$17171 13278 10512 12575 112 113 13244 MUX2_X1
* cell instance $17173 r0 *1 43.89,173.6
X$17173 10739 13201 13375 113 112 13250 OAI21_X2
* cell instance $17175 m0 *1 45.03,173.6
X$17175 11254 11334 10409 112 13153 113 AOI21_X1
* cell instance $17176 m0 *1 45.98,173.6
X$17176 13203 12022 13063 112 13062 113 AOI21_X1
* cell instance $17179 m0 *1 47.69,173.6
X$17179 11093 10404 112 113 13154 NAND2_X1
* cell instance $17180 m0 *1 48.26,173.6
X$17180 13204 13155 13154 12256 12460 13206 113 112 AOI221_X2
* cell instance $17182 m0 *1 50.54,173.6
X$17182 13206 13003 112 113 12739 NOR2_X1
* cell instance $17183 m0 *1 51.11,173.6
X$17183 13064 11880 13248 112 13120 113 AOI21_X1
* cell instance $17184 m0 *1 51.87,173.6
X$17184 11395 11036 11037 112 13064 113 AOI21_X1
* cell instance $17185 m0 *1 52.63,173.6
X$17185 12186 12583 13156 113 13063 112 OAI21_X1
* cell instance $17186 m0 *1 53.39,173.6
X$17186 13208 12735 13250 13209 13066 13128 112 113 OAI221_X2
* cell instance $17187 m0 *1 55.48,173.6
X$17187 13067 10988 12303 9952 11395 13282 112 113 OAI221_X2
* cell instance $17189 m0 *1 57.76,173.6
X$17189 12019 12956 13246 13124 112 113 13065 AOI22_X1
* cell instance $17190 m0 *1 58.71,173.6
X$17190 12581 10684 12649 112 113 13157 NAND3_X1
* cell instance $17194 r0 *1 45.79,173.6
X$17194 13067 10548 10873 10452 12649 13155 112 113 OAI221_X2
* cell instance $17195 r0 *1 47.88,173.6
X$17195 10409 9952 112 113 13245 NAND2_X1
* cell instance $17196 r0 *1 48.45,173.6
X$17196 10452 12303 12649 13067 10988 113 112 13279 OAI221_X1
* cell instance $17197 r0 *1 49.59,173.6
X$17197 13246 13155 12524 11060 112 113 13247 NAND4_X1
* cell instance $17199 r0 *1 50.73,173.6
X$17199 11944 10512 113 112 13249 AND2_X1
* cell instance $17201 r0 *1 51.68,173.6
X$17201 13249 10106 12181 113 13000 112 OAI21_X1
* cell instance $17202 r0 *1 52.44,173.6
X$17202 11716 10983 13156 113 12954 112 OAI21_X1
* cell instance $17203 r0 *1 53.2,173.6
X$17203 112 12106 12372 113 BUF_X16
* cell instance $17205 r0 *1 58.14,173.6
X$17205 10983 113 11395 112 BUF_X4
* cell instance $17206 r0 *1 59.47,173.6
X$17206 11716 10983 13068 113 13522 112 OAI21_X1
* cell instance $17207 m0 *1 60.04,173.6
X$17207 11487 11569 13157 13211 12022 113 112 12309 OAI221_X1
* cell instance $17209 m0 *1 61.18,173.6
X$17209 11569 12372 112 113 13211 NAND2_X1
* cell instance $17210 m0 *1 61.75,173.6
X$17210 13157 13212 12186 13127 112 113 12955 AOI22_X1
* cell instance $17212 m0 *1 62.89,173.6
X$17212 12186 12022 11882 112 13212 113 AOI21_X1
* cell instance $17217 r0 *1 60.8,173.6
X$17217 10873 113 12022 112 BUF_X4
* cell instance $17220 r0 *1 63.84,173.6
X$17220 112 12186 113 13067 BUF_X8
* cell instance $17222 m0 *1 64.79,173.6
X$17222 112 16916 10329 13128 10234 113 DFF_X1
* cell instance $17225 m0 *1 70.49,173.6
X$17225 12857 13018 16535 113 112 13216 HA_X1
* cell instance $17234 r0 *1 69.92,173.6
X$17234 13018 10658 16637 113 112 13287 HA_X1
* cell instance $17235 r0 *1 71.82,173.6
X$17235 12588 113 13158 112 BUF_X4
* cell instance $17236 r0 *1 73.15,173.6
X$17236 13213 12929 11259 113 13253 112 OAI21_X1
* cell instance $17237 m0 *1 74.1,173.6
X$17237 11576 12588 12311 112 113 13218 MUX2_X1
* cell instance $17238 m0 *1 73.53,173.6
X$17238 12588 12592 112 113 13159 NAND2_X1
* cell instance $17240 r0 *1 73.91,173.6
X$17240 13158 12398 11583 112 113 13213 NOR3_X1
* cell instance $17241 r0 *1 74.67,173.6
X$17241 11572 13288 12588 112 13215 113 AOI21_X1
* cell instance $17278 r0 *1 79.04,25.2
X$17278 112 711 393 113 BUF_X16
* cell instance $17279 m0 *1 82.27,25.2
X$17279 263 361 16521 113 112 575 HA_X1
* cell instance $17285 r0 *1 84.36,25.2
X$17285 575 112 113 617 CLKBUF_X3
* cell instance $17287 r0 *1 85.69,25.2
X$17287 247 112 113 576 INV_X4
* cell instance $17288 m0 *1 86.64,25.2
X$17288 391 112 113 687 BUF_X2
* cell instance $17289 m0 *1 86.07,25.2
X$17289 469 112 113 608 INV_X2
* cell instance $17290 m0 *1 87.4,25.2
X$17290 413 470 519 112 113 548 MUX2_X1
* cell instance $17292 m0 *1 88.92,25.2
X$17292 391 112 113 265 BUF_X2
* cell instance $17294 r0 *1 86.64,25.2
X$17294 304 112 113 577 BUF_X2
* cell instance $17295 r0 *1 87.4,25.2
X$17295 577 113 641 112 BUF_X4
* cell instance $17296 r0 *1 88.73,25.2
X$17296 611 393 16715 113 112 578 HA_X1
* cell instance $17298 m0 *1 90.06,25.2
X$17298 499 579 548 112 113 612 MUX2_X1
* cell instance $17299 m0 *1 91.58,25.2
X$17299 500 551 550 112 113 614 MUX2_X1
* cell instance $17300 m0 *1 92.91,25.2
X$17300 304 268 454 112 113 613 MUX2_X1
* cell instance $17301 m0 *1 94.24,25.2
X$17301 551 113 451 112 BUF_X4
* cell instance $17302 m0 *1 95.57,25.2
X$17302 293 470 519 112 521 113 AOI21_X2
* cell instance $17303 m0 *1 96.9,25.2
X$17303 397 520 521 112 113 558 MUX2_X1
* cell instance $17305 m0 *1 98.42,25.2
X$17305 578 522 113 112 471 AND2_X1
* cell instance $17306 m0 *1 99.18,25.2
X$17306 556 525 558 112 716 113 AOI21_X1
* cell instance $17307 m0 *1 99.94,25.2
X$17307 508 523 309 112 113 621 NOR3_X1
* cell instance $17310 m0 *1 102.41,25.2
X$17310 305 364 524 112 113 560 MUX2_X1
* cell instance $17313 m0 *1 104.69,25.2
X$17313 367 113 520 112 BUF_X4
* cell instance $17314 m0 *1 106.02,25.2
X$17314 562 474 626 112 113 526 MUX2_X1
* cell instance $17316 m0 *1 107.54,25.2
X$17316 475 525 526 112 113 720 MUX2_X1
* cell instance $17320 m0 *1 114.19,25.2
X$17320 112 568 582 113 BUF_X32
* cell instance $17321 m0 *1 123.5,25.2
X$17321 112 16899 527 513 152 113 DFF_X1
* cell instance $17323 m0 *1 128.25,25.2
X$17323 112 583 113 530 BUF_X8
* cell instance $17326 m0 *1 133,25.2
X$17326 371 112 113 17159 INV_X2
* cell instance $17329 m0 *1 134.52,25.2
X$17329 528 529 530 571 112 113 531 NAND4_X1
* cell instance $17332 r0 *1 90.63,25.2
X$17332 468 112 113 524 INV_X2
* cell instance $17334 r0 *1 91.58,25.2
X$17334 362 333 112 113 642 NAND2_X2
* cell instance $17335 r0 *1 92.53,25.2
X$17335 333 112 113 694 BUF_X1
* cell instance $17337 r0 *1 93.29,25.2
X$17337 579 613 617 643 113 112 626 OAI22_X1
* cell instance $17338 r0 *1 94.24,25.2
X$17338 368 451 619 112 113 645 MUX2_X1
* cell instance $17339 r0 *1 95.57,25.2
X$17339 306 362 581 112 113 696 MUX2_X1
* cell instance $17340 r0 *1 96.9,25.2
X$17340 612 525 112 113 646 NOR2_X1
* cell instance $17341 r0 *1 97.47,25.2
X$17341 522 113 337 112 BUF_X4
* cell instance $17344 r0 *1 99.75,25.2
X$17344 522 112 113 647 INV_X1
* cell instance $17345 r0 *1 100.13,25.2
X$17345 647 113 309 112 BUF_X4
* cell instance $17346 r0 *1 101.46,25.2
X$17346 225 581 715 112 113 NOR2_X4
* cell instance $17347 r0 *1 103.17,25.2
X$17347 472 112 113 519 CLKBUF_X3
* cell instance $17348 r0 *1 104.12,25.2
X$17348 472 112 113 581 BUF_X1
* cell instance $17352 r0 *1 117.23,25.2
X$17352 583 582 16632 113 112 650 HA_X1
* cell instance $17353 r0 *1 119.13,25.2
X$17353 583 582 16630 113 112 652 HA_X1
* cell instance $17354 r0 *1 121.03,25.2
X$17354 112 585 113 652 BUF_X8
* cell instance $17355 r0 *1 123.5,25.2
X$17355 583 532 16648 113 112 726 HA_X1
* cell instance $17359 r0 *1 125.4,25.2
X$17359 632 582 16644 113 112 653 HA_X1
* cell instance $17364 r0 *1 130.15,25.2
X$17364 708 530 112 113 634 NAND2_X1
* cell instance $17366 r0 *1 131.1,25.2
X$17366 584 112 113 574 CLKBUF_X3
* cell instance $17368 r0 *1 132.43,25.2
X$17368 707 112 113 591 CLKBUF_X3
* cell instance $17369 r0 *1 133.38,25.2
X$17369 635 585 705 112 586 113 AOI21_X1
* cell instance $17370 r0 *1 134.14,25.2
X$17370 586 112 113 655 INV_X1
* cell instance $17371 r0 *1 134.52,25.2
X$17371 593 634 531 583 588 113 112 592 OAI221_X1
* cell instance $17372 r0 *1 135.66,25.2
X$17372 530 589 574 587 588 113 112 590 OAI221_X1
* cell instance $17374 m0 *1 136.61,25.2
X$17374 529 113 593 112 BUF_X4
* cell instance $17380 r0 *1 136.8,25.2
X$17380 591 592 590 113 656 112 OAI21_X1
* cell instance $17382 r0 *1 138.32,25.2
X$17382 574 585 112 113 594 NAND2_X1
* cell instance $17383 r0 *1 138.89,25.2
X$17383 594 658 589 112 113 703 NAND3_X1
* cell instance $17384 r0 *1 139.65,25.2
X$17384 663 582 640 113 112 573 HA_X1
* cell instance $17385 r0 *1 141.55,25.2
X$17385 635 640 659 112 595 113 AOI21_X1
* cell instance $17388 r0 *1 143.26,25.2
X$17388 639 112 113 791 INV_X4
* cell instance $17391 r0 *1 144.78,25.2
X$17391 639 113 587 112 BUF_X4
* cell instance $17392 r0 *1 146.11,25.2
X$17392 593 113 659 112 BUF_X4
* cell instance $17394 r0 *1 148.2,25.2
X$17394 112 571 532 113 BUF_X32
* cell instance $17396 m0 *1 159.03,25.2
X$17396 112 16877 569 294 360 113 DFF_X1
* cell instance $17400 m0 *1 163.21,25.2
X$17400 543 240 553 112 113 533 OR3_X1
* cell instance $17402 m0 *1 164.35,25.2
X$17402 295 534 326 565 497 597 112 113 OAI221_X2
* cell instance $17404 m0 *1 166.63,25.2
X$17404 318 479 112 113 535 NAND2_X1
* cell instance $17406 m0 *1 167.39,25.2
X$17406 479 318 279 113 536 112 OAI21_X1
* cell instance $17407 m0 *1 168.15,25.2
X$17407 497 113 324 112 BUF_X4
* cell instance $17408 m0 *1 169.48,25.2
X$17408 425 506 112 113 567 NAND2_X1
* cell instance $17413 r0 *1 160.36,25.2
X$17413 637 517 738 441 636 638 113 112 AOI221_X2
* cell instance $17414 r0 *1 162.45,25.2
X$17414 597 664 112 113 637 OR2_X1
* cell instance $17416 r0 *1 163.59,25.2
X$17416 701 533 596 112 113 636 NAND3_X1
* cell instance $17417 r0 *1 164.35,25.2
X$17417 324 598 597 633 441 784 112 113 OAI221_X2
* cell instance $17418 r0 *1 166.44,25.2
X$17418 506 667 463 112 633 113 AOI21_X1
* cell instance $17419 r0 *1 167.2,25.2
X$17419 600 329 744 743 599 699 112 113 OAI221_X2
* cell instance $17421 r0 *1 169.48,25.2
X$17421 373 279 478 112 113 599 NAND3_X1
* cell instance $17423 m0 *1 171.19,25.2
X$17423 543 566 112 113 481 NOR2_X1
* cell instance $17424 m0 *1 170.43,25.2
X$17424 567 463 631 112 537 113 AOI21_X1
* cell instance $17426 m0 *1 171.95,25.2
X$17426 232 112 113 479 INV_X2
* cell instance $17427 m0 *1 172.52,25.2
X$17427 199 112 113 17155 INV_X2
* cell instance $17429 m0 *1 173.28,25.2
X$17429 424 320 494 112 539 113 AOI21_X2
* cell instance $17431 r0 *1 170.43,25.2
X$17431 542 669 599 325 600 113 112 538 OAI221_X1
* cell instance $17432 r0 *1 171.57,25.2
X$17432 610 389 630 112 629 113 AOI21_X2
* cell instance $17435 r0 *1 173.85,25.2
X$17435 601 539 113 112 624 AND2_X1
* cell instance $17437 m0 *1 177.08,25.2
X$17437 484 542 237 112 113 625 NOR3_X1
* cell instance $17438 m0 *1 174.99,25.2
X$17438 323 540 628 563 564 602 112 113 OAI221_X2
* cell instance $17439 m0 *1 177.84,25.2
X$17439 557 325 112 113 511 NOR2_X1
* cell instance $17440 m0 *1 178.41,25.2
X$17440 623 561 559 453 112 555 113 NAND4_X2
* cell instance $17441 m0 *1 180.12,25.2
X$17441 557 478 552 237 541 554 112 113 OAI221_X2
* cell instance $17442 m0 *1 182.21,25.2
X$17442 488 675 487 554 112 620 113 NAND4_X2
* cell instance $17443 m0 *1 183.92,25.2
X$17443 542 325 318 112 552 113 AOI21_X1
* cell instance $17445 m0 *1 184.87,25.2
X$17445 440 441 112 113 604 NOR2_X1
* cell instance $17446 m0 *1 185.44,25.2
X$17446 610 282 112 113 492 NOR2_X1
* cell instance $17447 m0 *1 186.01,25.2
X$17447 280 113 543 112 BUF_X4
* cell instance $17449 r0 *1 176.13,25.2
X$17449 436 690 112 113 628 OR2_X1
* cell instance $17451 r0 *1 177.27,25.2
X$17451 670 484 237 112 113 627 NOR3_X1
* cell instance $17452 r0 *1 178.03,25.2
X$17452 627 624 622 113 623 112 OAI21_X1
* cell instance $17453 r0 *1 178.79,25.2
X$17453 671 625 622 113 615 112 OAI21_X1
* cell instance $17455 r0 *1 179.74,25.2
X$17455 112 620 555 602 616 692 113 NAND4_X4
* cell instance $17460 r0 *1 183.92,25.2
X$17460 689 488 688 604 982 618 113 112 AOI221_X2
* cell instance $17462 r0 *1 186.39,25.2
X$17462 752 615 604 112 113 616 NAND3_X2
* cell instance $17463 r0 *1 187.72,25.2
X$17463 497 283 112 113 541 NOR2_X2
* cell instance $17464 m0 *1 188.48,25.2
X$17464 544 283 112 113 439 NAND2_X2
* cell instance $17465 m0 *1 187.72,25.2
X$17465 546 549 436 112 113 489 NOR3_X1
* cell instance $17466 m0 *1 189.43,25.2
X$17466 330 113 437 112 BUF_X4
* cell instance $17467 m0 *1 190.76,25.2
X$17467 544 113 380 112 BUF_X4
* cell instance $17470 r0 *1 189.05,25.2
X$17470 450 606 112 113 686 NOR2_X1
* cell instance $17472 r0 *1 189.81,25.2
X$17472 609 686 439 605 494 760 113 112 AOI221_X2
* cell instance $17474 r0 *1 192.28,25.2
X$17474 606 112 113 373 CLKBUF_X3
* cell instance $17476 m0 *1 192.47,25.2
X$17476 237 238 16575 113 112 545 HA_X1
* cell instance $17478 r0 *1 193.61,25.2
X$17478 683 607 283 112 113 682 NAND3_X1
* cell instance $17517 m0 *1 82.08,22.4
X$17517 363 112 113 263 INV_X4
* cell instance $17518 m0 *1 83.79,22.4
X$17518 410 112 113 413 BUF_X2
* cell instance $17521 r0 *1 82.65,22.4
X$17521 393 361 16714 113 112 247 HA_X1
* cell instance $17524 m0 *1 84.93,22.4
X$17524 393 361 391 113 112 445 HA_X1
* cell instance $17525 r0 *1 85.31,22.4
X$17525 445 112 113 468 BUF_X1
* cell instance $17526 r0 *1 85.88,22.4
X$17526 391 112 113 469 BUF_X1
* cell instance $17527 r0 *1 86.45,22.4
X$17527 391 112 113 411 BUF_X2
* cell instance $17528 r0 *1 87.21,22.4
X$17528 112 266 470 113 BUF_X16
* cell instance $17529 m0 *1 87.21,22.4
X$17529 391 266 363 112 113 397 MUX2_X1
* cell instance $17530 m0 *1 88.54,22.4
X$17530 415 364 112 113 499 XNOR2_X2
* cell instance $17531 m0 *1 90.44,22.4
X$17531 578 268 333 112 449 113 AOI21_X1
* cell instance $17532 m0 *1 91.2,22.4
X$17532 291 337 365 112 113 550 MUX2_X1
* cell instance $17533 m0 *1 92.53,22.4
X$17533 334 367 395 112 113 412 MUX2_X1
* cell instance $17534 m0 *1 93.86,22.4
X$17534 454 112 113 363 BUF_X1
* cell instance $17537 m0 *1 96.71,22.4
X$17537 452 451 369 112 113 414 MUX2_X1
* cell instance $17539 m0 *1 98.8,22.4
X$17539 411 362 336 112 113 507 MUX2_X1
* cell instance $17542 r0 *1 91.96,22.4
X$17542 499 337 449 112 113 500 MUX2_X1
* cell instance $17543 r0 *1 93.29,22.4
X$17543 412 451 501 112 113 502 MUX2_X1
* cell instance $17545 r0 *1 94.81,22.4
X$17545 312 272 112 113 333 NOR2_X2
* cell instance $17547 r0 *1 96.52,22.4
X$17547 413 112 113 306 INV_X2
* cell instance $17548 r0 *1 97.09,22.4
X$17548 414 505 502 112 113 580 MUX2_X1
* cell instance $17550 r0 *1 98.8,22.4
X$17550 471 523 335 507 556 113 112 AOI211_X2
* cell instance $17551 r0 *1 100.51,22.4
X$17551 247 225 413 112 113 508 MUX2_X1
* cell instance $17552 r0 *1 101.84,22.4
X$17552 413 364 416 112 113 473 MUX2_X1
* cell instance $17553 m0 *1 103.36,22.4
X$17553 399 112 113 416 INV_X4
* cell instance $17554 m0 *1 102.03,22.4
X$17554 415 266 416 112 113 417 MUX2_X1
* cell instance $17555 m0 *1 104.31,22.4
X$17555 341 112 113 271 BUF_X1
* cell instance $17557 m0 *1 105.07,22.4
X$17557 336 364 416 112 113 418 MUX2_X1
* cell instance $17558 m0 *1 106.4,22.4
X$17558 418 337 417 112 113 510 MUX2_X1
* cell instance $17559 m0 *1 107.73,22.4
X$17559 112 416 262 113 BUF_X16
* cell instance $17563 m0 *1 114.95,22.4
X$17563 112 16742 314 461 227 113 DFF_X1
* cell instance $17564 m0 *1 118.18,22.4
X$17564 112 408 227 17234 347 113 DFF_X2
* cell instance $17568 r0 *1 103.17,22.4
X$17568 508 367 560 112 113 509 MUX2_X1
* cell instance $17569 r0 *1 104.5,22.4
X$17569 399 112 113 472 BUF_X1
* cell instance $17570 r0 *1 105.07,22.4
X$17570 473 337 417 112 113 562 MUX2_X1
* cell instance $17572 r0 *1 106.78,22.4
X$17572 509 474 510 112 113 475 MUX2_X1
* cell instance $17576 r0 *1 118.75,22.4
X$17576 189 112 113 227 CLKBUF_X3
* cell instance $17577 r0 *1 119.7,22.4
X$17577 227 112 113 17205 INV_X1
* cell instance $17582 r0 *1 126.16,22.4
X$17582 527 186 476 112 113 513 MUX2_X1
* cell instance $17586 m0 *1 129.77,22.4
X$17586 419 194 252 112 113 514 MUX2_X1
* cell instance $17590 r0 *1 130.15,22.4
X$17590 112 17055 419 514 371 113 DFF_X1
* cell instance $17591 m0 *1 133.95,22.4
X$17591 420 316 276 112 113 466 MUX2_X1
* cell instance $17592 m0 *1 133,22.4
X$17592 189 112 113 371 CLKBUF_X3
* cell instance $17596 r0 *1 133.38,22.4
X$17596 112 17059 420 466 371 113 DFF_X1
* cell instance $17598 r0 *1 139.65,22.4
X$17598 112 467 231 17261 421 113 DFF_X2
* cell instance $17599 m0 *1 140.41,22.4
X$17599 421 316 156 112 113 467 MUX2_X1
* cell instance $17603 m0 *1 143.45,22.4
X$17603 465 316 135 112 113 422 MUX2_X1
* cell instance $17608 r0 *1 143.26,22.4
X$17608 112 17103 465 422 360 113 DFF_X1
* cell instance $17611 r0 *1 152.76,22.4
X$17611 401 112 113 360 CLKBUF_X3
* cell instance $17612 r0 *1 153.71,22.4
X$17612 360 112 113 17210 INV_X1
* cell instance $17617 r0 *1 162.26,22.4
X$17617 441 380 477 112 517 113 AOI21_X1
* cell instance $17628 m0 *1 51.3,39.2
X$17628 1189 112 113 1417 CLKBUF_X3
* cell instance $17629 m0 *1 52.25,39.2
X$17629 1418 113 1419 112 BUF_X4
* cell instance $17630 m0 *1 53.58,39.2
X$17630 1385 1419 1470 112 1473 113 AOI21_X1
* cell instance $17631 m0 *1 54.34,39.2
X$17631 1418 112 113 1188 CLKBUF_X3
* cell instance $17632 m0 *1 55.29,39.2
X$17632 112 1571 1522 1383 1472 113 AOI21_X4
* cell instance $17633 m0 *1 57.76,39.2
X$17633 1349 1189 1187 112 113 1470 MUX2_X1
* cell instance $17634 m0 *1 59.09,39.2
X$17634 1268 1313 1314 113 1385 112 NOR3_X2
* cell instance $17635 m0 *1 60.42,39.2
X$17635 1350 1228 1149 1266 1578 112 113 OAI211_X2
* cell instance $17647 r0 *1 46.74,39.2
X$17647 1113 1112 16672 113 112 1425 HA_X1
* cell instance $17651 r0 *1 52.25,39.2
X$17651 1418 113 1268 112 BUF_X4
* cell instance $17653 r0 *1 53.96,39.2
X$17653 1420 1387 112 113 1515 NAND2_X1
* cell instance $17654 r0 *1 54.53,39.2
X$17654 1310 1383 1417 112 113 1513 NAND3_X1
* cell instance $17656 r0 *1 55.67,39.2
X$17656 1419 1420 987 1266 1516 112 113 OAI211_X2
* cell instance $17657 r0 *1 57.38,39.2
X$17657 1422 1423 1144 113 1512 112 OAI21_X1
* cell instance $17659 r0 *1 58.52,39.2
X$17659 1421 1422 1423 113 112 1510 OAI21_X4
* cell instance $17661 r0 *1 61.37,39.2
X$17661 1267 1188 1480 112 113 1582 NOR3_X1
* cell instance $17663 r0 *1 62.32,39.2
X$17663 1582 1474 1584 113 1520 112 OAI21_X1
* cell instance $17664 m0 *1 63.08,39.2
X$17664 112 1476 1031 1272 1390 113 AOI21_X4
* cell instance $17665 m0 *1 62.51,39.2
X$17665 1477 1387 112 113 1478 NOR2_X1
* cell instance $17667 m0 *1 65.74,39.2
X$17667 1425 112 113 1481 BUF_X2
* cell instance $17668 m0 *1 66.5,39.2
X$17668 1522 1352 1351 113 112 1426 OAI21_X2
* cell instance $17669 m0 *1 67.83,39.2
X$17669 1314 1075 1483 1427 1352 113 112 AOI211_X2
* cell instance $17670 m0 *1 69.54,39.2
X$17670 112 1421 113 1353 BUF_X8
* cell instance $17671 m0 *1 72.01,39.2
X$17671 1191 1117 1271 112 1420 113 NAND3_X4
* cell instance $17676 r0 *1 63.08,39.2
X$17676 1425 1390 1272 112 113 1511 NAND3_X2
* cell instance $17677 r0 *1 64.41,39.2
X$17677 1351 1584 1478 112 113 1586 OR3_X2
* cell instance $17678 r0 *1 65.55,39.2
X$17678 1479 113 1418 112 BUF_X4
* cell instance $17679 r0 *1 66.88,39.2
X$17679 1421 1075 938 112 113 1523 MUX2_X1
* cell instance $17683 r0 *1 68.21,39.2
X$17683 1524 1526 112 113 1525 NAND2_X1
* cell instance $17684 r0 *1 68.78,39.2
X$17684 1075 113 1588 112 BUF_X4
* cell instance $17686 r0 *1 70.49,39.2
X$17686 1427 113 1524 112 BUF_X4
* cell instance $17687 r0 *1 71.82,39.2
X$17687 1425 112 113 1480 INV_X2
* cell instance $17688 r0 *1 72.39,39.2
X$17688 1117 113 1589 112 BUF_X4
* cell instance $17690 r0 *1 74.1,39.2
X$17690 1147 112 113 1187 CLKBUF_X3
* cell instance $17691 r0 *1 75.05,39.2
X$17691 1528 113 1267 112 BUF_X4
* cell instance $17695 m0 *1 80.37,39.2
X$17695 1238 1392 112 113 1590 NAND2_X1
* cell instance $17697 m0 *1 80.94,39.2
X$17697 940 1032 1391 112 113 1488 MUX2_X1
* cell instance $17698 m0 *1 82.27,39.2
X$17698 1193 335 1485 1428 1354 1394 113 112 AOI221_X2
* cell instance $17700 m0 *1 84.55,39.2
X$17700 1034 1487 1355 112 113 1194 NOR3_X1
* cell instance $17701 m0 *1 85.31,39.2
X$17701 335 1429 794 112 1356 113 AOI21_X1
* cell instance $17702 m0 *1 86.07,39.2
X$17702 468 112 113 1429 CLKBUF_X3
* cell instance $17703 m0 *1 87.02,39.2
X$17703 468 867 262 112 113 1430 MUX2_X1
* cell instance $17706 r0 *1 80.75,39.2
X$17706 1590 1193 1192 1392 1591 113 112 1593 OAI221_X1
* cell instance $17708 r0 *1 82.08,39.2
X$17708 1032 1428 264 113 1591 112 OAI21_X1
* cell instance $17710 r0 *1 83.03,39.2
X$17710 1615 1491 1593 113 1597 112 OAI21_X1
* cell instance $17712 r0 *1 85.31,39.2
X$17712 798 113 1530 112 BUF_X4
* cell instance $17713 r0 *1 86.64,39.2
X$17713 1595 1157 1242 1355 1488 113 112 1598 OAI221_X1
* cell instance $17715 r0 *1 88.16,39.2
X$17715 451 868 1430 113 112 1157 OAI21_X2
* cell instance $17716 m0 *1 91.39,39.2
X$17716 691 112 113 1196 CLKBUF_X3
* cell instance $17717 m0 *1 88.73,39.2
X$17717 112 411 579 713 1431 113 NOR3_X4
* cell instance $17718 m0 *1 92.34,39.2
X$17718 868 394 867 113 1492 112 OAI21_X1
* cell instance $17719 m0 *1 93.1,39.2
X$17719 867 361 112 113 1360 NAND2_X2
* cell instance $17721 r0 *1 89.49,39.2
X$17721 832 617 1431 943 765 1491 113 112 AOI221_X2
* cell instance $17723 r0 *1 91.96,39.2
X$17723 715 335 112 113 1532 NOR2_X1
* cell instance $17726 r0 *1 93.1,39.2
X$17726 1196 1432 112 113 1534 NOR2_X1
* cell instance $17727 r0 *1 93.67,39.2
X$17727 1492 1534 1361 648 264 113 112 1603 OAI221_X1
* cell instance $17728 m0 *1 95.57,39.2
X$17728 641 872 1392 579 112 113 1358 AOI22_X1
* cell instance $17729 m0 *1 94.43,39.2
X$17729 613 451 1038 1432 1357 113 112 1650 OAI221_X1
* cell instance $17734 r0 *1 95.76,39.2
X$17734 520 696 1429 832 112 113 1605 AOI22_X1
* cell instance $17737 m0 *1 98.23,39.2
X$17737 1359 1497 451 113 1495 112 OAI21_X1
* cell instance $17738 m0 *1 97.66,39.2
X$17738 698 868 112 113 1359 NOR2_X1
* cell instance $17739 m0 *1 98.99,39.2
X$17739 1498 1497 474 112 113 1487 NOR3_X1
* cell instance $17742 r0 *1 98.04,39.2
X$17742 1542 1433 1192 113 1535 112 OAI21_X1
* cell instance $17743 r0 *1 98.8,39.2
X$17743 505 1536 621 112 113 1537 OR3_X1
* cell instance $17793 r0 *1 109.82,14
X$17793 189 112 113 184 CLKBUF_X3
* cell instance $17797 m0 *1 113.43,14
X$17797 112 16767 217 177 150 113 DFF_X1
* cell instance $17801 r0 *1 115.14,14
X$17801 112 17032 183 215 150 113 DFF_X1
* cell instance $17802 m0 *1 118.37,14
X$17802 189 112 113 150 CLKBUF_X3
* cell instance $17803 m0 *1 119.32,14
X$17803 150 112 113 16473 CLKBUF_X1
* cell instance $17805 m0 *1 124.07,14
X$17805 112 16892 171 172 152 113 DFF_X1
* cell instance $17808 r0 *1 118.37,14
X$17808 112 17027 151 220 150 113 DFF_X1
* cell instance $17809 r0 *1 121.6,14
X$17809 112 17130 174 191 150 113 DFF_X1
* cell instance $17813 r0 *1 124.83,14
X$17813 112 17084 154 192 152 113 DFF_X1
* cell instance $17826 r0 *1 138.7,14
X$17826 198 194 164 112 113 197 MUX2_X1
* cell instance $17838 m0 *1 174.04,14
X$17838 112 16755 119 160 199 113 DFF_X1
* cell instance $17856 r0 *1 146.11,14
X$17856 112 17053 158 206 231 113 DFF_X1
* cell instance $17861 r0 *1 167.77,14
X$17861 112 16975 162 202 199 113 DFF_X1
* cell instance $17897 m0 *1 81.13,30.8
X$17897 112 264 113 867 BUF_X8
* cell instance $17898 m0 *1 83.6,30.8
X$17898 454 113 992 112 BUF_X4
* cell instance $17916 r0 *1 64.03,30.8
X$17916 936 113 987 112 BUF_X4
* cell instance $17917 r0 *1 65.36,30.8
X$17917 937 113 988 112 BUF_X4
* cell instance $17923 r0 *1 68.59,30.8
X$17923 938 113 939 112 BUF_X4
* cell instance $17928 r0 *1 79.61,30.8
X$17928 834 470 711 112 113 940 MUX2_X1
* cell instance $17929 r0 *1 80.94,30.8
X$17929 991 868 941 112 113 942 MUX2_X1
* cell instance $17930 r0 *1 82.27,30.8
X$17930 940 868 831 112 113 1077 MUX2_X1
* cell instance $17931 r0 *1 83.6,30.8
X$17931 362 711 112 113 1193 NOR2_X1
* cell instance $17932 r0 *1 84.17,30.8
X$17932 1078 335 901 112 113 1035 MUX2_X1
* cell instance $17933 m0 *1 85.5,30.8
X$17933 415 798 617 112 113 901 MUX2_X1
* cell instance $17935 m0 *1 86.83,30.8
X$17935 112 394 113 711 BUF_X8
* cell instance $17936 m0 *1 89.3,30.8
X$17936 577 112 113 834 INV_X1
* cell instance $17937 m0 *1 89.68,30.8
X$17937 468 798 577 112 113 904 MUX2_X1
* cell instance $17938 m0 *1 91.01,30.8
X$17938 869 795 454 112 113 870 MUX2_X1
* cell instance $17939 m0 *1 92.34,30.8
X$17939 223 470 337 113 1040 112 OAI21_X1
* cell instance $17940 m0 *1 93.1,30.8
X$17940 268 795 871 112 113 NOR2_X4
* cell instance $17941 m0 *1 94.81,30.8
X$17941 871 908 796 833 867 1084 113 112 AOI221_X2
* cell instance $17942 m0 *1 96.9,30.8
X$17942 223 112 113 911 INV_X1
* cell instance $17944 r0 *1 85.5,30.8
X$17944 943 523 711 112 113 993 MUX2_X1
* cell instance $17946 r0 *1 87.02,30.8
X$17946 713 335 943 112 113 830 NOR3_X1
* cell instance $17947 r0 *1 87.78,30.8
X$17947 474 830 112 113 995 OR2_X1
* cell instance $17950 r0 *1 90.44,30.8
X$17950 577 112 113 869 BUF_X1
* cell instance $17951 r0 *1 91.01,30.8
X$17951 337 112 113 868 CLKBUF_X3
* cell instance $17953 r0 *1 92.15,30.8
X$17953 363 112 113 307 INV_X2
* cell instance $17954 r0 *1 92.72,30.8
X$17954 944 113 551 112 BUF_X4
* cell instance $17956 r0 *1 94.24,30.8
X$17956 944 337 872 112 113 NOR2_X4
* cell instance $17958 r0 *1 96.14,30.8
X$17958 946 247 867 112 1003 113 AOI21_X1
* cell instance $17960 r0 *1 97.09,30.8
X$17960 944 112 113 795 INV_X2
* cell instance $17962 m0 *1 97.85,30.8
X$17962 795 113 523 112 BUF_X4
* cell instance $17964 m0 *1 99.18,30.8
X$17964 798 415 112 113 945 NAND2_X2
* cell instance $17965 m0 *1 100.13,30.8
X$17965 911 268 307 112 113 877 MUX2_X1
* cell instance $17968 m0 *1 102.41,30.8
X$17968 362 307 112 113 874 NAND2_X2
* cell instance $17969 m0 *1 103.36,30.8
X$17969 718 113 943 112 BUF_X4
* cell instance $17970 m0 *1 104.69,30.8
X$17970 841 520 904 112 113 914 MUX2_X1
* cell instance $17972 m0 *1 106.21,30.8
X$17972 798 718 112 113 875 NAND2_X1
* cell instance $17973 m0 *1 106.78,30.8
X$17973 877 579 842 112 113 878 MUX2_X1
* cell instance $17975 m0 *1 108.87,30.8
X$17975 112 798 113 364 BUF_X8
* cell instance $17980 r0 *1 97.85,30.8
X$17980 795 522 112 113 946 NAND2_X2
* cell instance $17982 r0 *1 98.99,30.8
X$17982 1004 505 716 112 113 947 MUX2_X1
* cell instance $17985 r0 *1 100.89,30.8
X$17985 945 1005 112 113 873 NAND2_X1
* cell instance $17986 r0 *1 101.46,30.8
X$17986 551 948 876 873 872 112 113 1004 AOI221_X1
* cell instance $17987 r0 *1 102.6,30.8
X$17987 1005 875 949 112 113 1006 NAND3_X1
* cell instance $17988 r0 *1 103.36,30.8
X$17988 946 875 874 112 876 113 AOI21_X1
* cell instance $17990 r0 *1 104.5,30.8
X$17990 523 337 949 112 113 NOR2_X4
* cell instance $17991 r0 *1 106.21,30.8
X$17991 877 112 113 1007 BUF_X2
* cell instance $17992 r0 *1 106.97,30.8
X$17992 914 950 878 112 113 951 MUX2_X1
* cell instance $17998 r0 *1 117.23,30.8
X$17998 952 582 112 113 954 NAND2_X1
* cell instance $18001 r0 *1 118.37,30.8
X$18001 662 572 721 705 112 113 955 AOI22_X1
* cell instance $18003 r0 *1 119.7,30.8
X$18003 880 922 112 113 1012 NAND2_X1
* cell instance $18004 m0 *1 120.84,30.8
X$18004 651 112 113 800 BUF_X1
* cell instance $18005 m0 *1 120.08,30.8
X$18005 801 922 570 112 879 113 AOI21_X1
* cell instance $18007 r0 *1 120.27,30.8
X$18007 800 879 1014 113 957 112 OAI21_X1
* cell instance $18009 r0 *1 121.41,30.8
X$18009 787 922 1098 112 1014 113 AOI21_X1
* cell instance $18011 m0 *1 121.98,30.8
X$18011 802 854 805 113 112 792 OAI21_X4
* cell instance $18016 r0 *1 123.5,30.8
X$18016 708 707 958 112 1015 113 AOI21_X1
* cell instance $18021 r0 *1 124.64,30.8
X$18021 880 708 112 959 113 NAND2_X4
* cell instance $18023 m0 *1 124.83,30.8
X$18023 568 113 731 112 BUF_X4
* cell instance $18024 m0 *1 126.35,30.8
X$18024 112 814 588 881 528 582 778 849 113 OAI222_X2
* cell instance $18026 m0 *1 129.2,30.8
X$18026 776 854 805 584 112 113 850 NOR4_X1
* cell instance $18028 m0 *1 130.34,30.8
X$18028 883 801 584 113 857 112 OAI21_X1
* cell instance $18030 r0 *1 126.35,30.8
X$18030 806 953 1023 721 112 113 881 AOI22_X2
* cell instance $18033 r0 *1 128.63,30.8
X$18033 953 583 1023 112 882 113 AOI21_X1
* cell instance $18034 r0 *1 129.39,30.8
X$18034 882 582 112 113 960 NOR2_X1
* cell instance $18037 r0 *1 130.53,30.8
X$18037 651 854 805 113 112 1025 OAI21_X2
* cell instance $18038 m0 *1 132.24,30.8
X$18038 929 810 885 112 930 113 AOI21_X1
* cell instance $18039 m0 *1 131.48,30.8
X$18039 805 854 932 113 884 112 OAI21_X1
* cell instance $18043 r0 *1 132.43,30.8
X$18043 722 112 113 1024 INV_X1
* cell instance $18045 r0 *1 133,30.8
X$18045 880 1024 730 113 112 855 OAI21_X2
* cell instance $18046 m0 *1 134.14,30.8
X$18046 884 736 112 113 856 NOR2_X1
* cell instance $18047 m0 *1 133.38,30.8
X$18047 854 805 1024 113 933 112 OAI21_X1
* cell instance $18049 r0 *1 134.33,30.8
X$18049 850 593 962 112 961 113 AOI21_X1
* cell instance $18050 m0 *1 135.28,30.8
X$18050 734 935 856 112 113 859 OR3_X1
* cell instance $18053 r0 *1 135.09,30.8
X$18053 1027 657 112 113 962 NOR2_X1
* cell instance $18055 r0 *1 136.42,30.8
X$18055 857 1029 112 113 963 NAND2_X1
* cell instance $18056 m0 *1 136.8,30.8
X$18056 591 934 112 113 885 NAND2_X1
* cell instance $18060 m0 *1 139.08,30.8
X$18060 735 800 112 113 931 NAND2_X1
* cell instance $18062 m0 *1 140.41,30.8
X$18062 572 705 112 113 807 NOR2_X1
* cell instance $18063 m0 *1 140.98,30.8
X$18063 928 809 859 112 861 113 AOI21_X1
* cell instance $18065 m0 *1 141.93,30.8
X$18065 661 806 926 658 813 811 112 113 OAI221_X2
* cell instance $18066 m0 *1 144.02,30.8
X$18066 814 810 582 112 113 813 NAND3_X1
* cell instance $18068 r0 *1 136.99,30.8
X$18068 635 1027 112 113 1029 NOR2_X2
* cell instance $18070 r0 *1 138.13,30.8
X$18070 1017 931 885 112 1028 113 AOI21_X1
* cell instance $18071 r0 *1 138.89,30.8
X$18071 736 933 731 659 1021 112 113 OAI211_X2
* cell instance $18073 r0 *1 140.79,30.8
X$18073 927 528 591 800 810 113 112 1019 OAI221_X1
* cell instance $18074 r0 *1 141.93,30.8
X$18074 1018 1105 1019 113 112 1022 AND3_X1
* cell instance $18076 r0 *1 143.07,30.8
X$18076 632 582 16701 113 112 965 HA_X1
* cell instance $18079 m0 *1 145.16,30.8
X$18079 815 863 959 112 113 886 NOR3_X1
* cell instance $18082 r0 *1 146.11,30.8
X$18082 959 1017 968 112 113 967 NOR3_X1
* cell instance $18084 r0 *1 147.63,30.8
X$18084 663 532 16695 113 112 968 HA_X1
* cell instance $18086 m0 *1 147.82,30.8
X$18086 924 810 704 113 925 112 OAI21_X1
* cell instance $18088 m0 *1 148.96,30.8
X$18088 593 112 113 810 CLKBUF_X3
* cell instance $18090 m0 *1 159.03,30.8
X$18090 112 16862 923 618 360 113 DFF_X1
* cell instance $18091 m0 *1 162.26,30.8
X$18091 866 742 112 113 921 NOR2_X1
* cell instance $18092 m0 *1 162.83,30.8
X$18092 240 295 112 113 887 NAND2_X1
* cell instance $18094 m0 *1 163.59,30.8
X$18094 296 853 921 888 112 113 920 OR4_X1
* cell instance $18095 m0 *1 164.73,30.8
X$18095 887 670 819 112 113 888 NOR3_X1
* cell instance $18097 m0 *1 165.68,30.8
X$18097 438 1010 860 112 889 113 AOI21_X2
* cell instance $18098 m0 *1 167.01,30.8
X$18098 917 919 918 112 860 113 AOI21_X1
* cell instance $18099 m0 *1 167.77,30.8
X$18099 741 542 284 113 919 112 OAI21_X1
* cell instance $18102 r0 *1 149.72,30.8
X$18102 968 112 113 969 INV_X1
* cell instance $18109 r0 *1 162.07,30.8
X$18109 424 916 998 112 664 113 AOI21_X1
* cell instance $18111 r0 *1 163.21,30.8
X$18111 112 865 739 1013 889 970 113 AOI22_X4
* cell instance $18112 r0 *1 166.44,30.8
X$18112 441 324 112 113 971 NAND2_X1
* cell instance $18113 r0 *1 167.01,30.8
X$18113 977 1011 425 1092 1009 1010 113 112 AOI221_X2
* cell instance $18114 m0 *1 169.1,30.8
X$18114 915 916 544 667 890 112 113 853 AOI221_X1
* cell instance $18116 m0 *1 170.24,30.8
X$18116 741 358 112 113 915 NOR2_X1
* cell instance $18118 m0 *1 171,30.8
X$18118 606 320 112 113 819 NOR2_X1
* cell instance $18119 m0 *1 171.57,30.8
X$18119 851 426 112 113 820 NOR2_X1
* cell instance $18120 m0 *1 172.14,30.8
X$18120 820 819 279 112 113 892 NOR3_X1
* cell instance $18122 m0 *1 173.09,30.8
X$18122 753 893 677 112 890 113 AOI21_X1
* cell instance $18123 m0 *1 173.85,30.8
X$18123 819 821 237 112 113 891 NOR3_X1
* cell instance $18124 m0 *1 174.61,30.8
X$18124 891 913 324 112 113 540 NOR3_X1
* cell instance $18125 m0 *1 175.37,30.8
X$18125 426 893 112 113 821 NOR2_X1
* cell instance $18126 m0 *1 175.94,30.8
X$18126 234 282 112 113 912 NAND2_X1
* cell instance $18130 r0 *1 169.67,30.8
X$18130 973 818 112 113 667 NAND2_X1
* cell instance $18133 r0 *1 171.38,30.8
X$18133 1008 289 851 112 113 NOR2_X4
* cell instance $18134 r0 *1 173.09,30.8
X$18134 430 112 113 1008 BUF_X2
* cell instance $18136 r0 *1 174.23,30.8
X$18136 542 974 284 112 113 913 NOR3_X1
* cell instance $18177 r0 *1 81.51,19.6
X$18177 263 361 16622 113 112 410 HA_X1
* cell instance $18181 r0 *1 85.5,19.6
X$18181 112 362 113 266 BUF_X8
* cell instance $18182 m0 *1 87.78,19.6
X$18182 263 262 16523 113 112 305 HA_X1
* cell instance $18183 m0 *1 85.88,19.6
X$18183 393 262 16519 113 112 304 HA_X1
* cell instance $18184 m0 *1 89.68,19.6
X$18184 265 364 307 112 113 334 MUX2_X1
* cell instance $18185 m0 *1 91.01,19.6
X$18185 393 262 16524 113 112 223 HA_X1
* cell instance $18187 r0 *1 87.97,19.6
X$18187 391 112 113 415 INV_X2
* cell instance $18188 r0 *1 88.54,19.6
X$18188 305 266 333 112 113 395 MUX2_X1
* cell instance $18189 r0 *1 89.87,19.6
X$18189 265 266 306 112 113 365 MUX2_X1
* cell instance $18190 r0 *1 91.2,19.6
X$18190 305 112 113 366 BUF_X1
* cell instance $18193 r0 *1 92.34,19.6
X$18193 112 361 113 311 BUF_X8
* cell instance $18195 m0 *1 93.29,19.6
X$18195 309 112 113 335 CLKBUF_X3
* cell instance $18196 m0 *1 94.43,19.6
X$18196 336 266 307 112 113 308 MUX2_X1
* cell instance $18197 m0 *1 95.76,19.6
X$18197 308 337 267 112 113 452 MUX2_X1
* cell instance $18198 m0 *1 97.09,19.6
X$18198 223 266 336 112 113 339 MUX2_X1
* cell instance $18200 r0 *1 94.81,19.6
X$18200 293 367 308 112 113 368 MUX2_X1
* cell instance $18202 r0 *1 96.52,19.6
X$18202 397 367 339 112 113 369 MUX2_X1
* cell instance $18204 m0 *1 100.13,19.6
X$18204 267 335 340 112 113 269 MUX2_X1
* cell instance $18205 m0 *1 98.8,19.6
X$18205 336 268 310 112 113 340 MUX2_X1
* cell instance $18211 r0 *1 99.94,19.6
X$18211 309 113 367 112 BUF_X4
* cell instance $18212 r0 *1 101.27,19.6
X$18212 270 341 454 112 113 NOR2_X4
* cell instance $18215 r0 *1 103.55,19.6
X$18215 112 271 270 312 719 272 113 OAI22_X4
* cell instance $18216 m0 *1 104.69,19.6
X$18216 272 312 311 112 113 NOR2_X4
* cell instance $18217 m0 *1 104.12,19.6
X$18217 270 271 112 113 310 NOR2_X1
* cell instance $18219 m0 *1 107.16,19.6
X$18219 112 342 184 17240 254 113 DFF_X2
* cell instance $18221 m0 *1 111.53,19.6
X$18221 112 273 184 345 344 113 DFF_X2
* cell instance $18224 m0 *1 117.42,19.6
X$18224 112 16730 190 406 227 113 DFF_X1
* cell instance $18228 m0 *1 126.73,19.6
X$18228 349 186 153 112 113 370 MUX2_X1
* cell instance $18230 m0 *1 128.82,19.6
X$18230 112 16783 275 313 152 113 DFF_X1
* cell instance $18235 m0 *1 137.56,19.6
X$18235 277 316 195 112 113 298 MUX2_X1
* cell instance $18238 m0 *1 141.93,19.6
X$18238 189 112 113 231 CLKBUF_X3
* cell instance $18239 m0 *1 142.88,19.6
X$18239 231 112 113 16465 CLKBUF_X1
* cell instance $18241 r0 *1 106.78,19.6
X$18241 311 113 399 112 BUF_X4
* cell instance $18244 r0 *1 109.25,19.6
X$18244 112 225 364 113 BUF_X16
* cell instance $18247 r0 *1 117.23,19.6
X$18247 314 186 136 112 113 461 MUX2_X1
* cell instance $18250 r0 *1 121.79,19.6
X$18250 112 17123 348 315 227 113 DFF_X1
* cell instance $18256 r0 *1 125.97,19.6
X$18256 112 370 152 409 349 113 DFF_X2
* cell instance $18261 r0 *1 130.72,19.6
X$18261 112 17060 354 353 371 113 DFF_X1
* cell instance $18264 r0 *1 135.09,19.6
X$18264 112 298 231 407 277 113 DFF_X2
* cell instance $18267 r0 *1 139.84,19.6
X$18267 112 17092 355 356 231 113 DFF_X1
* cell instance $18269 m0 *1 144.02,19.6
X$18269 278 316 138 112 113 317 MUX2_X1
* cell instance $18278 m0 *1 169.1,19.6
X$18278 279 113 237 112 BUF_X4
* cell instance $18280 r0 *1 143.83,19.6
X$18280 112 317 360 17254 278 113 DFF_X2
* cell instance $18282 r0 *1 148.96,19.6
X$18282 112 16940 159 359 360 113 DFF_X1
* cell instance $18288 r0 *1 165.87,19.6
X$18288 295 113 279 112 BUF_X4
* cell instance $18289 r0 *1 167.2,19.6
X$18289 426 113 318 112 BUF_X4
* cell instance $18290 r0 *1 168.53,19.6
X$18290 284 403 16654 113 112 236 HA_X1
* cell instance $18291 r0 *1 170.43,19.6
X$18291 236 318 319 113 402 112 OAI21_X1
* cell instance $18292 m0 *1 171,19.6
X$18292 232 113 325 112 BUF_X4
* cell instance $18297 r0 *1 171.76,19.6
X$18297 358 357 112 113 374 NAND2_X1
* cell instance $18298 r0 *1 172.33,19.6
X$18298 320 280 374 113 375 112 OAI21_X1
* cell instance $18299 m0 *1 172.9,19.6
X$18299 280 113 295 112 BUF_X4
* cell instance $18302 m0 *1 174.42,19.6
X$18302 352 233 279 112 113 351 NOR3_X1
* cell instance $18304 m0 *1 175.37,19.6
X$18304 322 281 112 113 350 NAND2_X1
* cell instance $18307 r0 *1 173.47,19.6
X$18307 281 321 351 350 319 398 112 113 OAI221_X2
* cell instance $18309 r0 *1 175.75,19.6
X$18309 289 373 325 112 113 378 MUX2_X1
* cell instance $18310 m0 *1 176.51,19.6
X$18310 346 281 112 113 323 NAND2_X1
* cell instance $18314 m0 *1 178.79,19.6
X$18314 238 329 322 113 396 112 OAI21_X1
* cell instance $18315 m0 *1 179.55,19.6
X$18315 240 113 319 112 BUF_X4
* cell instance $18317 r0 *1 177.08,19.6
X$18317 284 378 324 282 326 113 112 346 OAI221_X1
* cell instance $18319 r0 *1 178.6,19.6
X$18319 318 396 113 112 382 XNOR2_X1
* cell instance $18325 m0 *1 181.45,19.6
X$18325 325 326 281 284 338 113 112 290 OAI221_X1
* cell instance $18326 m0 *1 182.59,19.6
X$18326 292 234 319 113 286 112 OAI21_X1
* cell instance $18327 m0 *1 183.35,19.6
X$18327 282 318 279 319 112 113 328 AOI22_X1
* cell instance $18329 m0 *1 185.06,19.6
X$18329 281 385 284 332 287 112 113 OAI211_X2
* cell instance $18331 m0 *1 186.96,19.6
X$18331 318 288 325 388 112 113 332 AOI22_X1
* cell instance $18334 r0 *1 181.64,19.6
X$18334 343 285 327 113 384 112 OAI21_X1
* cell instance $18335 r0 *1 182.4,19.6
X$18335 384 290 324 112 113 487 NAND3_X1
* cell instance $18338 r0 *1 183.73,19.6
X$18338 390 328 327 329 112 113 448 NAND4_X1
* cell instance $18341 r0 *1 185.63,19.6
X$18341 331 112 113 389 INV_X2
* cell instance $18344 r0 *1 187.34,19.6
X$18344 284 387 16684 113 112 386 HA_X1
* cell instance $18345 m0 *1 188.48,19.6
X$18345 329 238 16534 113 112 330 HA_X1
* cell instance $18357 r0 *1 189.24,19.6
X$18357 241 387 16623 113 112 331 HA_X1
* cell instance $18358 r0 *1 191.14,19.6
X$18358 331 113 289 112 BUF_X4
* cell instance $18359 r0 *1 192.47,19.6
X$18359 358 113 280 112 BUF_X4
* cell instance $18409 r0 *1 80.75,28
X$18409 112 711 113 454 BUF_X8
* cell instance $18410 m0 *1 82.08,28
X$18410 394 611 16522 113 112 712 HA_X1
* cell instance $18411 m0 *1 83.98,28
X$18411 413 711 362 113 112 698 MUX2_X2
* cell instance $18412 m0 *1 85.69,28
X$18412 335 112 113 714 CLKBUF_X3
* cell instance $18415 r0 *1 83.6,28
X$18415 712 112 113 991 INV_X1
* cell instance $18417 r0 *1 84.17,28
X$18417 362 113 794 112 BUF_X4
* cell instance $18419 r0 *1 85.69,28
X$18419 830 793 112 113 758 NOR2_X1
* cell instance $18420 r0 *1 86.26,28
X$18420 268 113 713 112 BUF_X4
* cell instance $18421 m0 *1 88.35,28
X$18421 641 832 712 691 112 113 619 AOI22_X1
* cell instance $18422 m0 *1 87.02,28
X$18422 576 268 468 112 113 644 MUX2_X1
* cell instance $18423 m0 *1 89.3,28
X$18423 362 309 617 112 113 693 NOR3_X1
* cell instance $18425 r0 *1 87.59,28
X$18425 415 713 366 112 113 831 MUX2_X1
* cell instance $18426 r0 *1 88.92,28
X$18426 411 713 833 112 113 835 MUX2_X1
* cell instance $18429 m0 *1 90.44,28
X$18429 758 763 525 766 112 113 695 AOI22_X1
* cell instance $18430 m0 *1 91.58,28
X$18430 715 367 693 765 524 766 113 112 AOI221_X2
* cell instance $18432 m0 *1 93.86,28
X$18432 520 644 641 832 112 113 501 AOI22_X1
* cell instance $18434 r0 *1 90.44,28
X$18434 835 714 112 113 763 NAND2_X1
* cell instance $18435 r0 *1 91.01,28
X$18435 713 337 112 113 643 NAND2_X1
* cell instance $18437 r0 *1 91.77,28
X$18437 362 309 832 112 113 NOR2_X4
* cell instance $18441 r0 *1 94.81,28
X$18441 551 367 642 112 796 113 AOI21_X1
* cell instance $18443 m0 *1 95.19,28
X$18443 645 505 695 112 113 697 MUX2_X1
* cell instance $18445 r0 *1 95.57,28
X$18445 413 309 310 112 113 908 MUX2_X1
* cell instance $18446 r0 *1 96.9,28
X$18446 223 112 113 833 CLKBUF_X3
* cell instance $18448 m0 *1 97.66,28
X$18448 522 113 579 112 BUF_X4
* cell instance $18449 r0 *1 97.85,28
X$18449 697 840 580 112 113 797 MUX2_X1
* cell instance $18451 m0 *1 101.27,28
X$18451 367 113 691 112 BUF_X4
* cell instance $18452 m0 *1 99.37,28
X$18452 647 364 112 113 765 XNOR2_X2
* cell instance $18454 m0 *1 102.79,28
X$18454 523 112 113 717 CLKBUF_X3
* cell instance $18456 r0 *1 99.37,28
X$18456 717 112 113 793 CLKBUF_X3
* cell instance $18458 r0 *1 100.51,28
X$18458 794 367 112 113 1279 NAND2_X2
* cell instance $18460 r0 *1 101.65,28
X$18460 339 717 698 112 113 799 MUX2_X1
* cell instance $18461 r0 *1 102.98,28
X$18461 718 362 416 112 113 841 MUX2_X1
* cell instance $18463 m0 *1 104.12,28
X$18463 648 364 310 112 113 771 MUX2_X1
* cell instance $18464 r0 *1 104.31,28
X$18464 718 112 113 648 INV_X1
* cell instance $18465 r0 *1 104.69,28
X$18465 519 798 310 112 113 842 MUX2_X1
* cell instance $18466 m0 *1 107.16,28
X$18466 649 717 269 112 113 702 MUX2_X1
* cell instance $18467 m0 *1 105.83,28
X$18467 339 367 771 112 113 649 MUX2_X1
* cell instance $18472 r0 *1 106.4,28
X$18472 717 112 113 525 CLKBUF_X3
* cell instance $18474 r0 *1 107.73,28
X$18474 263 262 16627 113 112 718 HA_X1
* cell instance $18476 m0 *1 111.34,28
X$18476 112 225 113 3104 BUF_X8
* cell instance $18481 m0 *1 117.8,28
X$18481 650 112 113 721 CLKBUF_X3
* cell instance $18482 m0 *1 118.75,28
X$18482 532 583 16516 113 112 651 HA_X1
* cell instance $18483 m0 *1 120.65,28
X$18483 723 568 662 112 710 113 AOI21_X1
* cell instance $18484 m0 *1 121.41,28
X$18484 725 113 728 112 BUF_X4
* cell instance $18488 r0 *1 116.66,28
X$18488 662 582 16628 113 112 722 HA_X1
* cell instance $18489 r0 *1 118.56,28
X$18489 725 724 722 112 113 732 NAND3_X2
* cell instance $18490 r0 *1 119.89,28
X$18490 584 113 736 112 BUF_X4
* cell instance $18491 r0 *1 121.22,28
X$18491 802 112 113 707 CLKBUF_X3
* cell instance $18494 r0 *1 122.74,28
X$18494 724 530 725 112 845 113 NAND3_X4
* cell instance $18495 m0 *1 125.59,28
X$18495 724 113 848 112 BUF_X4
* cell instance $18496 m0 *1 123.12,28
X$18496 725 724 776 112 588 113 NAND3_X4
* cell instance $18497 m0 *1 126.92,28
X$18497 653 573 112 113 709 NOR2_X1
* cell instance $18498 m0 *1 127.49,28
X$18498 727 113 589 112 BUF_X4
* cell instance $18499 m0 *1 128.82,28
X$18499 589 710 113 112 781 XNOR2_X1
* cell instance $18500 m0 *1 129.96,28
X$18500 780 704 781 112 113 1185 MUX2_X1
* cell instance $18505 r0 *1 125.21,28
X$18505 726 727 803 113 846 112 OAI21_X1
* cell instance $18506 r0 *1 125.97,28
X$18506 728 848 802 722 112 113 803 NAND4_X1
* cell instance $18508 r0 *1 127.11,28
X$18508 530 588 792 112 729 113 AOI21_X1
* cell instance $18509 r0 *1 127.87,28
X$18509 729 589 723 112 778 113 AOI21_X1
* cell instance $18510 r0 *1 128.63,28
X$18510 722 112 113 804 BUF_X1
* cell instance $18513 r0 *1 130.15,28
X$18513 883 731 589 112 783 113 AOI21_X2
* cell instance $18514 r0 *1 131.48,28
X$18514 806 730 845 735 783 113 112 780 OAI221_X1
* cell instance $18515 m0 *1 131.86,28
X$18515 731 583 659 113 654 112 OAI21_X1
* cell instance $18517 m0 *1 132.62,28
X$18517 591 654 732 112 788 113 AOI21_X1
* cell instance $18518 m0 *1 133.38,28
X$18518 789 855 788 655 704 706 112 113 OAI221_X2
* cell instance $18519 m0 *1 135.47,28
X$18519 570 571 593 721 574 789 113 112 AOI221_X2
* cell instance $18521 m0 *1 137.75,28
X$18521 657 112 113 735 CLKBUF_X3
* cell instance $18522 m0 *1 138.7,28
X$18522 657 660 112 113 658 NAND2_X2
* cell instance $18523 m0 *1 139.65,28
X$18523 734 790 528 703 595 808 113 112 AOI221_X2
* cell instance $18525 r0 *1 132.62,28
X$18525 659 726 112 113 929 NOR2_X1
* cell instance $18526 r0 *1 133.19,28
X$18526 587 722 112 113 932 NOR2_X1
* cell instance $18529 r0 *1 134.71,28
X$18529 787 570 593 731 112 113 935 NOR4_X1
* cell instance $18532 r0 *1 136.61,28
X$18532 733 730 857 113 790 112 OAI21_X1
* cell instance $18535 r0 *1 139.08,28
X$18535 723 589 858 585 807 1026 113 112 AOI221_X2
* cell instance $18537 r0 *1 141.93,28
X$18537 800 792 734 810 812 113 112 809 OAI221_X1
* cell instance $18538 m0 *1 142.31,28
X$18538 735 660 659 112 113 661 MUX2_X1
* cell instance $18540 m0 *1 143.64,28
X$18540 662 532 16583 113 112 639 HA_X1
* cell instance $18542 r0 *1 143.07,28
X$18542 735 791 112 113 812 NOR2_X1
* cell instance $18544 r0 *1 143.83,28
X$18544 735 583 731 112 113 863 NOR3_X1
* cell instance $18545 r0 *1 144.59,28
X$18545 733 736 589 113 815 112 OAI21_X1
* cell instance $18548 r0 *1 145.92,28
X$18548 736 113 632 112 BUF_X4
* cell instance $18549 m0 *1 146.11,28
X$18549 735 113 663 112 BUF_X4
* cell instance $18554 m0 *1 152.76,28
X$18554 569 112 113 737 CLKBUF_X3
* cell instance $18557 m0 *1 161.31,28
X$18557 440 327 112 113 738 NAND2_X1
* cell instance $18560 r0 *1 148.01,28
X$18560 632 864 16708 113 112 924 HA_X1
* cell instance $18565 r0 *1 161.31,28
X$18565 665 240 424 112 113 866 NAND3_X1
* cell instance $18568 m0 *1 162.26,28
X$18568 665 786 547 543 112 113 701 NAND4_X1
* cell instance $18570 r0 *1 162.64,28
X$18570 440 779 666 112 865 113 AOI21_X2
* cell instance $18571 m0 *1 163.78,28
X$18571 630 785 112 113 786 NAND2_X1
* cell instance $18573 m0 *1 164.35,28
X$18573 700 784 281 112 113 739 NAND3_X2
* cell instance $18575 m0 *1 165.87,28
X$18575 816 775 296 113 700 112 OAI21_X1
* cell instance $18578 r0 *1 164.16,28
X$18578 681 782 786 112 563 113 AOI21_X2
* cell instance $18579 r0 *1 165.49,28
X$18579 862 289 112 113 782 NAND2_X1
* cell instance $18582 r0 *1 166.63,28
X$18582 281 740 817 112 779 113 AOI21_X1
* cell instance $18584 m0 *1 167.01,28
X$18584 352 744 741 536 113 112 598 OAI22_X1
* cell instance $18585 r0 *1 167.39,28
X$18585 237 553 741 536 113 112 740 OAI22_X1
* cell instance $18587 m0 *1 168.34,28
X$18587 319 699 668 486 460 666 112 113 OAI221_X2
* cell instance $18588 m0 *1 170.62,28
X$18588 426 777 112 113 743 NOR2_X2
* cell instance $18589 m0 *1 171.57,28
X$18589 631 629 380 539 745 775 113 112 AOI221_X2
* cell instance $18590 m0 *1 173.66,28
X$18590 629 482 112 113 674 NAND2_X1
* cell instance $18591 m0 *1 174.23,28
X$18591 400 565 112 113 601 NAND2_X1
* cell instance $18592 m0 *1 174.8,28
X$18592 601 774 436 543 534 767 113 112 AOI221_X2
* cell instance $18593 m0 *1 176.89,28
X$18593 234 673 112 113 484 NOR2_X1
* cell instance $18595 r0 *1 168.34,28
X$18595 742 743 506 113 1009 112 OAI21_X1
* cell instance $18596 r0 *1 169.1,28
X$18596 818 373 681 113 744 112 OAI21_X1
* cell instance $18599 r0 *1 170.43,28
X$18599 852 743 112 113 844 NOR2_X1
* cell instance $18600 r0 *1 171,28
X$18600 851 494 543 113 852 112 OAI21_X1
* cell instance $18604 r0 *1 173.09,28
X$18604 606 325 112 113 665 NAND2_X1
* cell instance $18605 r0 *1 173.66,28
X$18605 665 601 424 112 113 847 NAND3_X1
* cell instance $18607 r0 *1 175.18,28
X$18607 669 241 234 112 773 113 AOI21_X1
* cell instance $18609 r0 *1 176.13,28
X$18609 844 773 822 113 746 112 OAI21_X1
* cell instance $18610 r0 *1 176.89,28
X$18610 324 425 112 113 822 NOR2_X2
* cell instance $18611 m0 *1 178.98,28
X$18611 673 557 381 279 772 113 112 770 OAI221_X1
* cell instance $18612 m0 *1 177.84,28
X$18612 241 295 622 600 437 113 112 672 OAI221_X1
* cell instance $18614 m0 *1 180.88,28
X$18614 544 283 112 113 622 NOR2_X2
* cell instance $18617 r0 *1 178.03,28
X$18617 742 670 284 112 113 671 NOR3_X1
* cell instance $18619 r0 *1 179.55,28
X$18619 606 387 112 113 742 NOR2_X2
* cell instance $18623 r0 *1 180.5,28
X$18623 892 747 622 113 843 112 OAI21_X1
* cell instance $18625 r0 *1 181.45,28
X$18625 770 839 746 843 112 113 689 NAND4_X1
* cell instance $18626 m0 *1 182.21,28
X$18626 431 769 112 113 749 OR2_X1
* cell instance $18627 m0 *1 182.97,28
X$18627 676 748 515 677 493 112 113 769 AOI221_X1
* cell instance $18630 r0 *1 182.59,28
X$18630 748 622 112 113 750 NAND2_X1
* cell instance $18631 r0 *1 183.16,28
X$18631 823 751 824 112 113 603 NOR3_X1
* cell instance $18632 r0 *1 183.92,28
X$18632 403 826 541 113 823 112 OAI21_X1
* cell instance $18634 m0 *1 184.49,28
X$18634 440 235 112 113 679 NOR2_X1
* cell instance $18636 m0 *1 186.77,28
X$18636 759 749 768 767 760 680 112 113 688 OAI33_X1
* cell instance $18637 m0 *1 185.44,28
X$18637 439 678 674 112 768 113 AOI21_X2
* cell instance $18639 m0 *1 188.29,28
X$18639 672 751 679 762 764 113 112 680 OAI221_X1
* cell instance $18640 m0 *1 189.43,28
X$18640 403 761 681 112 762 113 AOI21_X1
* cell instance $18642 m0 *1 190.38,28
X$18642 761 238 112 113 751 NOR2_X1
* cell instance $18646 r0 *1 186.01,28
X$18646 838 320 690 282 826 905 113 112 AOI221_X2
* cell instance $18648 r0 *1 188.48,28
X$18648 426 322 541 785 326 113 112 764 OAI221_X1
* cell instance $18649 r0 *1 189.62,28
X$18649 681 113 284 112 BUF_X4
* cell instance $18661 m0 *1 46.17,61.6
X$18661 1781 1807 2098 3093 2317 113 112 3134 OAI221_X1
* cell instance $18662 m0 *1 47.31,61.6
X$18662 1781 2317 3093 1807 113 112 3225 OAI22_X1
* cell instance $18663 m0 *1 48.26,61.6
X$18663 3225 3135 3136 113 2989 112 OAI21_X1
* cell instance $18665 m0 *1 49.21,61.6
X$18665 2439 3093 2095 1115 2886 3137 112 113 OAI221_X2
* cell instance $18666 m0 *1 51.3,61.6
X$18666 3093 1898 2095 2776 3136 3039 112 113 OAI221_X2
* cell instance $18667 m0 *1 53.39,61.6
X$18667 2093 1638 112 113 3136 NOR2_X2
* cell instance $18682 r0 *1 45.41,61.6
X$18682 3181 1952 112 113 3224 NOR2_X1
* cell instance $18683 r0 *1 45.98,61.6
X$18683 1113 1782 1812 1417 112 113 3181 AOI22_X1
* cell instance $18685 r0 *1 47.12,61.6
X$18685 3134 3224 2774 2092 2060 113 112 3277 OAI221_X1
* cell instance $18688 r0 *1 49.4,61.6
X$18688 1420 1638 112 113 3278 NAND2_X1
* cell instance $18689 r0 *1 49.97,61.6
X$18689 2658 2094 112 113 3182 NAND2_X1
* cell instance $18691 r0 *1 50.73,61.6
X$18691 1113 3182 2166 112 3407 113 AOI21_X1
* cell instance $18694 r0 *1 52.44,61.6
X$18694 1313 1113 2658 112 3227 113 AOI21_X1
* cell instance $18695 r0 *1 53.2,61.6
X$18695 1584 3227 1952 3279 113 112 3185 OAI22_X1
* cell instance $18696 r0 *1 54.15,61.6
X$18696 1782 1812 1417 112 3279 113 AOI21_X1
* cell instance $18698 r0 *1 55.29,61.6
X$18698 3280 2050 3141 2387 113 112 3321 OAI22_X1
* cell instance $18699 m0 *1 55.67,61.6
X$18699 1960 1589 2834 1266 1812 3183 113 112 AOI221_X2
* cell instance $18702 m0 *1 57.95,61.6
X$18702 2734 1476 1899 112 113 3232 NOR3_X1
* cell instance $18704 m0 *1 58.9,61.6
X$18704 1813 1510 2992 113 112 3230 AND3_X1
* cell instance $18706 m0 *1 60.04,61.6
X$18706 2834 2312 112 113 2167 NOR2_X1
* cell instance $18707 m0 *1 60.61,61.6
X$18707 1901 2536 2992 112 3186 113 AOI21_X1
* cell instance $18708 m0 *1 61.37,61.6
X$18708 112 1781 1960 2317 988 1115 1807 3097 113 OAI222_X2
* cell instance $18709 m0 *1 64.03,61.6
X$18709 2995 1639 2657 1481 1782 3099 113 112 AOI221_X2
* cell instance $18711 m0 *1 66.31,61.6
X$18711 3148 3239 2994 113 3155 112 OAI21_X1
* cell instance $18712 m0 *1 67.07,61.6
X$18712 3189 3058 1522 1901 2717 112 113 3239 AOI221_X1
* cell instance $18713 m0 *1 68.21,61.6
X$18713 3185 2894 2774 113 3154 112 OAI21_X1
* cell instance $18714 m0 *1 68.97,61.6
X$18714 2997 3154 2288 3101 3155 3240 113 112 AOI221_X2
* cell instance $18716 r0 *1 56.24,61.6
X$18716 3183 1871 112 113 3281 NOR2_X1
* cell instance $18717 r0 *1 56.81,61.6
X$18717 3281 3231 3233 3352 112 113 3411 AOI22_X1
* cell instance $18719 r0 *1 58.14,61.6
X$18719 3232 3230 2891 113 3231 112 OAI21_X1
* cell instance $18722 r0 *1 59.85,61.6
X$18722 3235 2891 112 113 3233 NAND2_X1
* cell instance $18724 r0 *1 60.8,61.6
X$18724 3184 987 2724 2658 1781 3235 113 112 AOI221_X2
* cell instance $18725 r0 *1 62.89,61.6
X$18725 1877 1871 3186 112 3282 113 AOI21_X1
* cell instance $18726 r0 *1 63.65,61.6
X$18726 2102 1812 112 113 3184 NOR2_X1
* cell instance $18727 r0 *1 64.22,61.6
X$18727 3236 3001 3186 112 113 3187 NOR3_X1
* cell instance $18729 r0 *1 65.17,61.6
X$18729 3098 3188 2167 113 3283 112 OAI21_X1
* cell instance $18731 r0 *1 66.12,61.6
X$18731 1813 2663 988 1807 113 112 3188 OAI22_X1
* cell instance $18732 r0 *1 67.07,61.6
X$18732 1228 1901 112 113 3420 NAND2_X1
* cell instance $18739 r0 *1 68.97,61.6
X$18739 1905 1953 112 113 3098 NAND2_X1
* cell instance $18741 r0 *1 69.73,61.6
X$18741 2940 1517 1387 112 113 3284 NOR3_X1
* cell instance $18743 r0 *1 70.68,61.6
X$18743 2173 113 1905 112 BUF_X4
* cell instance $18744 m0 *1 71.63,61.6
X$18744 2177 3100 112 113 3141 NOR2_X1
* cell instance $18746 m0 *1 72.2,61.6
X$18746 3100 1639 3054 112 113 3055 MUX2_X1
* cell instance $18749 r0 *1 72.2,61.6
X$18749 1961 112 113 3285 INV_X1
* cell instance $18751 r0 *1 72.96,61.6
X$18751 1648 1420 113 112 3189 AND2_X1
* cell instance $18753 m0 *1 74.67,61.6
X$18753 3159 3190 2657 3059 3241 112 113 3158 AOI221_X1
* cell instance $18754 m0 *1 73.91,61.6
X$18754 3100 2177 112 113 3190 OR2_X1
* cell instance $18755 m0 *1 75.81,61.6
X$18755 112 1144 2324 2231 2734 113 NOR3_X4
* cell instance $18756 m0 *1 78.47,61.6
X$18756 112 1646 2324 2231 2663 113 NOR3_X4
* cell instance $18760 r0 *1 74.1,61.6
X$18760 1528 2776 112 113 3100 NAND2_X1
* cell instance $18761 r0 *1 74.67,61.6
X$18761 1479 1228 113 112 3191 AND2_X1
* cell instance $18763 r0 *1 75.81,61.6
X$18763 3191 3058 112 113 3241 NAND2_X1
* cell instance $18764 r0 *1 76.38,61.6
X$18764 112 2658 1648 1271 1191 113 AOI21_X4
* cell instance $18767 r0 *1 80.75,61.6
X$18767 3244 113 1271 112 BUF_X4
* cell instance $18768 r0 *1 82.08,61.6
X$18768 3246 3325 113 112 3244 AND2_X1
* cell instance $18770 m0 *1 83.98,61.6
X$18770 112 16811 3192 1615 3063 113 DFF_X1
* cell instance $18775 m0 *1 92.53,61.6
X$18775 3249 3162 114 113 112 950 OAI21_X4
* cell instance $18776 m0 *1 95,61.6
X$18776 3102 3162 117 113 112 2969 OAI21_X2
* cell instance $18782 r0 *1 85.5,61.6
X$18782 3248 3327 261 112 113 3246 OR3_X2
* cell instance $18784 r0 *1 86.83,61.6
X$18784 3192 112 113 3572 CLKBUF_X3
* cell instance $18788 r0 *1 90.44,61.6
X$18788 161 112 113 3329 CLKBUF_X1
* cell instance $18789 r0 *1 91.01,61.6
X$18789 3002 112 113 3363 CLKBUF_X3
* cell instance $18791 r0 *1 92.72,61.6
X$18791 3328 3162 112 113 3249 NAND2_X1
* cell instance $18794 r0 *1 94.43,61.6
X$18794 3623 3162 112 113 3102 NAND2_X1
* cell instance $18796 r0 *1 95.38,61.6
X$18796 189 112 113 3164 CLKBUF_X3
* cell instance $18799 r0 *1 96.9,61.6
X$18799 112 17082 3330 3067 3164 113 DFF_X1
* cell instance $18800 r0 *1 100.13,61.6
X$18800 112 2666 3164 17247 3365 113 DFF_X2
* cell instance $18801 m0 *1 101.46,61.6
X$18801 112 16867 3431 1984 3164 113 DFF_X1
* cell instance $18806 m0 *1 107.16,61.6
X$18806 3070 112 113 16461 CLKBUF_X1
* cell instance $18808 m0 *1 108.49,61.6
X$18808 112 16726 3193 3103 3070 113 DFF_X1
* cell instance $18812 r0 *1 104.5,61.6
X$18812 112 1244 3070 17250 3334 113 DFF_X2
* cell instance $18813 r0 *1 108.11,61.6
X$18813 189 112 113 3070 CLKBUF_X3
* cell instance $18816 r0 *1 111.34,61.6
X$18816 3193 113 3368 112 BUF_X4
* cell instance $18819 m0 *1 112.86,61.6
X$18819 134 3105 3172 112 113 3167 MUX2_X1
* cell instance $18820 r0 *1 113.05,61.6
X$18820 3196 1281 112 113 3337 XNOR2_X2
* cell instance $18822 m0 *1 114.57,61.6
X$18822 2859 3287 113 112 3172 XNOR2_X1
* cell instance $18825 m0 *1 117.8,61.6
X$18825 2671 113 1748 112 BUF_X4
* cell instance $18827 m0 *1 119.13,61.6
X$18827 2762 2670 2457 112 113 NOR2_X4
* cell instance $18830 m0 *1 121.79,61.6
X$18830 2021 113 1284 112 BUF_X4
* cell instance $18831 m0 *1 123.12,61.6
X$18831 1922 113 802 112 BUF_X4
* cell instance $18833 m0 *1 124.64,61.6
X$18833 3175 3194 113 2456 112 XOR2_X2
* cell instance $18834 m0 *1 126.35,61.6
X$18834 112 1455 1543 3078 3079 113 AOI21_X4
* cell instance $18836 m0 *1 130.34,61.6
X$18836 3176 1560 3107 112 113 3195 MUX2_X1
* cell instance $18843 r0 *1 118.94,61.6
X$18843 1748 113 1126 112 BUF_X4
* cell instance $18846 r0 *1 120.84,61.6
X$18846 3258 112 113 3259 BUF_X1
* cell instance $18847 r0 *1 121.41,61.6
X$18847 3258 3468 2309 112 113 NOR2_X4
* cell instance $18848 r0 *1 123.12,61.6
X$18848 530 3106 3371 113 112 1259 OAI21_X4
* cell instance $18852 r0 *1 125.59,61.6
X$18852 3260 112 113 530 INV_X8
* cell instance $18854 r0 *1 127.49,61.6
X$18854 3194 3175 112 113 1919 XNOR2_X2
* cell instance $18859 r0 *1 130.53,61.6
X$18859 112 17035 3372 3195 3288 113 DFF_X1
* cell instance $18860 r0 *1 133.76,61.6
X$18860 3196 3344 112 113 1752 XNOR2_X2
* cell instance $18861 r0 *1 135.66,61.6
X$18861 3344 3196 113 2121 112 XOR2_X2
* cell instance $18864 r0 *1 138.51,61.6
X$18864 112 17145 3439 1794 3288 113 DFF_X1
* cell instance $18865 m0 *1 143.64,61.6
X$18865 3109 3194 113 297 112 XOR2_X2
* cell instance $18866 m0 *1 140.41,61.6
X$18866 112 16800 3197 1502 3288 113 DFF_X1
* cell instance $18867 m0 *1 145.35,61.6
X$18867 2986 113 3375 112 BUF_X4
* cell instance $18868 m0 *1 146.68,61.6
X$18868 3111 3110 113 112 3179 AND2_X1
* cell instance $18873 r0 *1 143.07,61.6
X$18873 3197 112 113 3289 BUF_X2
* cell instance $18875 r0 *1 144.21,61.6
X$18875 112 17026 3290 1337 2133 113 DFF_X1
* cell instance $18877 m0 *1 148.01,61.6
X$18877 3179 113 2568 112 BUF_X4
* cell instance $18882 m0 *1 151.81,61.6
X$18882 3201 3113 3110 3111 112 113 2795 AOI22_X2
* cell instance $18883 m0 *1 153.52,61.6
X$18883 112 2681 2763 3201 3113 113 AOI21_X4
* cell instance $18884 m0 *1 155.99,61.6
X$18884 3111 3110 2405 113 112 2911 AND3_X1
* cell instance $18886 m0 *1 157.13,61.6
X$18886 2405 2568 112 113 2974 NAND2_X2
* cell instance $18887 m0 *1 158.08,61.6
X$18887 3178 2974 2980 113 3378 112 NOR3_X2
* cell instance $18888 m0 *1 159.41,61.6
X$18888 112 2357 2408 113 BUF_X16
* cell instance $18889 m0 *1 164.16,61.6
X$18889 2680 3275 2469 3177 3202 3295 113 112 AOI221_X2
* cell instance $18890 m0 *1 166.25,61.6
X$18890 3009 3088 2977 112 3275 113 AOI21_X1
* cell instance $18892 m0 *1 167.2,61.6
X$18892 3113 2872 3201 112 3209 113 NAND3_X4
* cell instance $18893 m0 *1 169.67,61.6
X$18893 2471 3085 3200 2410 2685 112 113 3204 AOI221_X1
* cell instance $18894 m0 *1 170.81,61.6
X$18894 2405 2566 112 113 3116 NAND2_X2
* cell instance $18895 m0 *1 171.76,61.6
X$18895 3204 3173 3087 112 113 3300 NOR3_X1
* cell instance $18896 m0 *1 172.52,61.6
X$18896 2800 3174 112 113 3081 NAND2_X1
* cell instance $18897 m0 *1 173.09,61.6
X$18897 112 3268 2915 3273 3206 3342 113 OR4_X4
* cell instance $18898 m0 *1 175.56,61.6
X$18898 3171 3083 2681 112 3207 113 AOI21_X1
* cell instance $18902 r0 *1 150.1,61.6
X$18902 3198 2355 16650 113 112 3004 HA_X1
* cell instance $18904 r0 *1 152.38,61.6
X$18904 3291 113 3200 112 BUF_X4
* cell instance $18905 r0 *1 153.71,61.6
X$18905 2463 2566 112 113 3445 NAND2_X1
* cell instance $18906 r0 *1 154.28,61.6
X$18906 112 2909 3270 3292 3085 113 NOR3_X4
* cell instance $18907 r0 *1 156.94,61.6
X$18907 2909 3180 112 113 3199 NOR2_X2
* cell instance $18908 r0 *1 157.89,61.6
X$18908 2464 113 3294 112 BUF_X4
* cell instance $18910 r0 *1 159.41,61.6
X$18910 3092 3448 3200 2683 3349 3084 113 112 AOI221_X2
* cell instance $18912 r0 *1 161.69,61.6
X$18912 3201 3113 3199 3294 2471 3205 113 112 AOI221_X2
* cell instance $18913 r0 *1 163.78,61.6
X$18913 3267 2917 113 112 3274 AND2_X1
* cell instance $18914 r0 *1 164.54,61.6
X$18914 3276 3478 112 113 3202 NAND2_X1
* cell instance $18915 r0 *1 165.11,61.6
X$18915 3085 2681 112 113 3276 NOR2_X2
* cell instance $18916 r0 *1 166.06,61.6
X$18916 2872 3292 3270 113 112 3203 OAI21_X2
* cell instance $18917 r0 *1 167.39,61.6
X$18917 3384 3088 112 113 3297 NOR2_X2
* cell instance $18919 r0 *1 168.72,61.6
X$18919 2685 3272 2885 112 3171 113 AOI21_X1
* cell instance $18921 r0 *1 169.86,61.6
X$18921 3348 2403 3203 113 3298 112 OAI21_X1
* cell instance $18922 r0 *1 170.62,61.6
X$18922 2639 3347 3299 3180 2681 112 113 3273 AOI221_X1
* cell instance $18923 r0 *1 171.76,61.6
X$18923 112 3116 3345 3205 3342 3208 113 OAI22_X4
* cell instance $18924 r0 *1 174.99,61.6
X$18924 3271 2757 2685 112 3301 113 AOI21_X1
* cell instance $18925 r0 *1 175.75,61.6
X$18925 3208 2576 3269 112 3302 113 AOI21_X2
* cell instance $18926 m0 *1 180.12,61.6
X$18926 3209 2962 3116 3211 3117 3265 113 112 AOI221_X2
* cell instance $18927 m0 *1 176.7,61.6
X$18927 112 3168 3166 3169 3268 3165 113 NAND4_X4
* cell instance $18928 m0 *1 182.21,61.6
X$18928 2963 3006 112 113 3117 NOR2_X1
* cell instance $18931 r0 *1 177.08,61.6
X$18931 2757 3296 2914 113 3269 112 OAI21_X1
* cell instance $18933 r0 *1 178.03,61.6
X$18933 2358 3013 3341 2755 3340 113 112 3115 OAI221_X1
* cell instance $18934 r0 *1 179.17,61.6
X$18934 3209 2639 112 113 3266 NAND2_X1
* cell instance $18936 r0 *1 179.93,61.6
X$18936 3339 3267 3266 2806 2911 3444 112 113 OAI221_X2
* cell instance $18940 r0 *1 182.02,61.6
X$18940 3265 2960 3443 3206 113 3212 112 NOR4_X2
* cell instance $18942 m0 *1 184.87,61.6
X$18942 2691 2690 3874 113 112 3075 MUX2_X2
* cell instance $18944 m0 *1 186.58,61.6
X$18944 3303 2848 113 242 112 XOR2_X2
* cell instance $18947 r0 *1 186.77,61.6
X$18947 112 17009 3213 3165 3264 113 DFF_X1
* cell instance $18948 m0 *1 189.62,61.6
X$18948 3118 3163 112 113 1933 XNOR2_X2
* cell instance $18955 r0 *1 190.19,61.6
X$18955 3213 112 113 3303 BUF_X2
* cell instance $18958 r0 *1 192.09,61.6
X$18958 112 17007 3263 3254 3264 113 DFF_X1
* cell instance $18959 r0 *1 195.32,61.6
X$18959 3263 112 113 3304 CLKBUF_X3
* cell instance $18962 r0 *1 197.22,61.6
X$18962 3261 3119 2379 3016 3214 3262 113 112 AOI221_X2
* cell instance $18963 m0 *1 197.98,61.6
X$18963 3120 3262 3147 3017 3216 3215 113 112 AOI221_X2
* cell instance $18964 m0 *1 197.22,61.6
X$18964 3214 3119 2846 113 3120 112 OAI21_X1
* cell instance $18965 m0 *1 200.07,61.6
X$18965 3121 3161 2377 3257 3160 3216 113 112 AOI221_X2
* cell instance $18967 m0 *1 202.92,61.6
X$18967 3255 2147 112 113 3160 NOR2_X1
* cell instance $18971 r0 *1 203.87,61.6
X$18971 2480 2138 112 113 3126 NOR2_X2
* cell instance $18972 m0 *1 204.06,61.6
X$18972 3126 3217 112 113 3257 NOR2_X1
* cell instance $18974 m0 *1 204.63,61.6
X$18974 2814 2248 112 113 3217 NAND2_X1
* cell instance $18976 r0 *1 204.82,61.6
X$18976 3217 3336 3309 112 3331 113 AOI21_X1
* cell instance $18977 m0 *1 206.72,61.6
X$18977 2810 1864 112 113 3255 NOR2_X2
* cell instance $18978 m0 *1 205.58,61.6
X$18978 2614 2045 3121 3122 113 112 3333 AND4_X1
* cell instance $18980 m0 *1 207.86,61.6
X$18980 3252 3019 3123 112 3253 113 AOI21_X1
* cell instance $18982 r0 *1 205.58,61.6
X$18982 3331 3306 2623 3333 113 3256 112 NOR4_X2
* cell instance $18984 r0 *1 207.48,61.6
X$18984 3256 3253 3245 3251 113 3254 112 OR4_X2
* cell instance $18985 r0 *1 208.81,61.6
X$18985 2482 2374 112 113 3045 NOR2_X2
* cell instance $18986 m0 *1 209.19,61.6
X$18986 2374 2138 112 113 3124 NAND2_X1
* cell instance $18988 m0 *1 209.76,61.6
X$18988 3150 2695 112 113 3156 OR2_X1
* cell instance $18989 m0 *1 210.52,61.6
X$18989 2399 2715 112 113 3152 NOR2_X1
* cell instance $18992 r0 *1 210.14,61.6
X$18992 3125 3637 3250 3247 112 113 3251 NOR4_X1
* cell instance $19022 r0 *1 62.7,184.8
X$19022 112 6509 113 224 BUF_X8
* cell instance $19030 m0 *1 70.87,184.8
X$19030 13158 113 13492 112 BUF_X4
* cell instance $19033 m0 *1 72.39,184.8
X$19033 12591 112 113 12959 CLKBUF_X3
* cell instance $19035 r0 *1 70.87,184.8
X$19035 11884 11259 13680 113 112 13816 HA_X1
* cell instance $19038 m0 *1 74.29,184.8
X$19038 13492 12865 11259 112 113 13747 NAND3_X1
* cell instance $19039 m0 *1 73.72,184.8
X$19039 11669 11260 112 113 13711 NOR2_X1
* cell instance $19040 m0 *1 75.05,184.8
X$19040 13681 13747 13009 112 113 13643 NAND3_X1
* cell instance $19041 m0 *1 75.81,184.8
X$19041 13288 13009 13682 112 113 13846 MUX2_X1
* cell instance $19042 m0 *1 77.14,184.8
X$19042 12865 13018 112 113 13620 NAND2_X1
* cell instance $19043 m0 *1 77.71,184.8
X$19043 13816 13009 13292 112 113 13784 MUX2_X1
* cell instance $19045 m0 *1 79.23,184.8
X$19045 13552 11581 13783 112 113 13782 MUX2_X1
* cell instance $19046 m0 *1 80.56,184.8
X$19046 12959 13717 13920 113 13750 112 OAI21_X1
* cell instance $19048 m0 *1 81.51,184.8
X$19048 12469 112 113 11839 CLKBUF_X3
* cell instance $19049 m0 *1 82.46,184.8
X$19049 11988 13784 13817 11744 13683 113 112 13818 OAI221_X1
* cell instance $19051 m0 *1 83.79,184.8
X$19051 13492 12263 13431 13684 113 112 13799 AND4_X1
* cell instance $19052 m0 *1 84.93,184.8
X$19052 12398 11678 11844 112 113 13684 NAND3_X1
* cell instance $19053 m0 *1 85.69,184.8
X$19053 13685 13791 13621 112 13792 113 AOI21_X1
* cell instance $19054 m0 *1 86.45,184.8
X$19054 13597 13792 13720 10658 13805 113 112 AOI211_X2
* cell instance $19055 m0 *1 88.16,184.8
X$19055 11678 12315 112 113 13686 NOR2_X1
* cell instance $19057 r0 *1 73.91,184.8
X$19057 12857 11259 16617 113 112 13288 HA_X1
* cell instance $19059 r0 *1 76.19,184.8
X$19059 12667 12313 11973 13816 112 113 13989 AOI22_X2
* cell instance $19061 r0 *1 78.09,184.8
X$19061 12857 11259 16689 113 112 13850 HA_X1
* cell instance $19062 r0 *1 79.99,184.8
X$19062 12685 12667 112 113 13885 NOR2_X1
* cell instance $19063 r0 *1 80.56,184.8
X$19063 13850 12959 13854 112 113 13783 MUX2_X1
* cell instance $19065 r0 *1 82.27,184.8
X$19065 13780 11520 13818 112 113 13787 MUX2_X1
* cell instance $19066 r0 *1 83.6,184.8
X$19066 11259 12685 13492 113 13856 112 OAI21_X1
* cell instance $19067 r0 *1 84.36,184.8
X$19067 13554 13856 13857 113 112 13848 OAI21_X2
* cell instance $19068 r0 *1 85.69,184.8
X$19068 112 12594 12550 13298 13857 113 NOR3_X4
* cell instance $19069 r0 *1 88.35,184.8
X$19069 13846 10928 11263 13819 13657 113 112 13820 OAI221_X1
* cell instance $19070 m0 *1 89.87,184.8
X$19070 13686 13721 11888 112 13748 113 AOI21_X1
* cell instance $19071 m0 *1 89.11,184.8
X$19071 13535 13686 13685 113 13725 112 OAI21_X1
* cell instance $19072 m0 *1 90.63,184.8
X$19072 12967 112 113 13721 INV_X1
* cell instance $19074 m0 *1 91.2,184.8
X$19074 13688 13749 13722 13799 112 113 13751 OR4_X1
* cell instance $19078 m0 *1 94.81,184.8
X$19078 12929 11574 12263 12273 13559 13821 113 112 AOI221_X2
* cell instance $19080 m0 *1 97.09,184.8
X$19080 11744 13800 13690 113 112 13804 AND3_X1
* cell instance $19081 m0 *1 98.04,184.8
X$19081 12413 12693 13805 13732 113 112 13806 OAI22_X1
* cell instance $19082 m0 *1 98.99,184.8
X$19082 11839 112 113 10928 CLKBUF_X3
* cell instance $19086 r0 *1 89.49,184.8
X$19086 13791 10928 112 113 13819 NAND2_X1
* cell instance $19088 r0 *1 90.25,184.8
X$19088 13750 11973 13748 112 13749 113 AOI21_X1
* cell instance $19090 r0 *1 91.2,184.8
X$19090 13687 13750 12413 113 13864 112 OAI21_X1
* cell instance $19092 r0 *1 92.15,184.8
X$19092 12413 13751 13930 113 13867 112 OAI21_X1
* cell instance $19094 r0 *1 93.1,184.8
X$19094 12402 13725 13888 113 13866 112 OAI21_X1
* cell instance $19096 r0 *1 94.24,184.8
X$19096 11744 112 113 11263 CLKBUF_X3
* cell instance $19098 r0 *1 95.57,184.8
X$19098 12477 11743 13627 113 112 13865 AND3_X1
* cell instance $19100 r0 *1 96.71,184.8
X$19100 13865 13864 13804 12413 13933 13866 112 113 13868 OAI33_X1
* cell instance $19102 r0 *1 98.23,184.8
X$19102 11839 112 113 11743 CLKBUF_X3
* cell instance $19103 r0 *1 99.18,184.8
X$19103 12320 112 113 12477 CLKBUF_X3
* cell instance $19106 r0 *1 102.41,184.8
X$19106 13787 9307 13867 112 113 13879 MUX2_X1
* cell instance $19107 m0 *1 102.79,184.8
X$19107 13806 9307 13693 112 113 13735 MUX2_X1
* cell instance $19111 m0 *1 110.96,184.8
X$19111 13752 112 113 9960 CLKBUF_X3
* cell instance $19115 m0 *1 114.38,184.8
X$19115 13753 112 113 9956 BUF_X2
* cell instance $19120 m0 *1 120.65,184.8
X$19120 112 13812 13754 13353 13673 113 DFF_X1
* cell instance $19121 m0 *1 123.88,184.8
X$19121 13753 13754 113 112 13811 XNOR2_X1
* cell instance $19124 m0 *1 125.97,184.8
X$19124 13811 10484 113 112 13827 XNOR2_X1
* cell instance $19125 m0 *1 127.11,184.8
X$19125 13757 7408 112 113 13755 NOR2_X1
* cell instance $19126 m0 *1 127.68,184.8
X$19126 13756 113 6107 112 BUF_X4
* cell instance $19127 m0 *1 129.01,184.8
X$19127 13812 13757 112 113 13809 XNOR2_X2
* cell instance $19128 m0 *1 130.91,184.8
X$19128 11597 13763 112 113 13757 XNOR2_X2
* cell instance $19130 m0 *1 134.33,184.8
X$19130 8539 112 113 13633 CLKBUF_X3
* cell instance $19131 m0 *1 135.28,184.8
X$19131 6107 11597 113 13815 112 XOR2_X2
* cell instance $19132 m0 *1 136.99,184.8
X$19132 13814 13881 113 13758 112 XOR2_X2
* cell instance $19134 m0 *1 139.46,184.8
X$19134 112 13813 13759 13735 13635 113 DFF_X1
* cell instance $19135 m0 *1 142.69,184.8
X$19135 9960 13759 113 112 13697 XNOR2_X1
* cell instance $19136 m0 *1 143.83,184.8
X$19136 11015 13697 113 112 13760 XNOR2_X1
* cell instance $19137 m0 *1 144.97,184.8
X$19137 13813 13614 113 112 13761 XNOR2_X1
* cell instance $19143 r0 *1 106.59,184.8
X$19143 13694 112 113 17192 INV_X2
* cell instance $19144 r0 *1 107.16,184.8
X$19144 8133 112 113 13694 CLKBUF_X3
* cell instance $19145 r0 *1 108.11,184.8
X$19145 112 17001 13752 13823 13694 113 DFF_X1
* cell instance $19147 r0 *1 114.38,184.8
X$19147 13891 113 13753 112 BUF_X4
* cell instance $19151 r0 *1 118.37,184.8
X$19151 13673 112 113 16485 CLKBUF_X1
* cell instance $19152 r0 *1 118.94,184.8
X$19152 13871 3928 112 113 13872 NOR2_X1
* cell instance $19153 r0 *1 119.51,184.8
X$19153 8539 112 113 13673 CLKBUF_X3
* cell instance $19155 r0 *1 120.84,184.8
X$19155 112 13824 13872 3928 13873 113 AOI21_X4
* cell instance $19156 r0 *1 123.31,184.8
X$19156 13825 13874 112 113 13873 XNOR2_X2
* cell instance $19161 r0 *1 125.97,184.8
X$19161 13830 7408 112 113 13826 NOR2_X1
* cell instance $19162 r0 *1 126.54,184.8
X$19162 13826 13755 13827 113 112 14018 MUX2_X2
* cell instance $19163 r0 *1 128.25,184.8
X$19163 13757 6509 112 113 13828 NAND2_X1
* cell instance $19164 r0 *1 128.82,184.8
X$19164 13830 6509 112 113 13829 NAND2_X1
* cell instance $19169 r0 *1 130.91,184.8
X$19169 13763 11597 113 13830 112 XOR2_X2
* cell instance $19172 r0 *1 133.57,184.8
X$19172 112 13881 13884 13879 13633 113 DFF_X1
* cell instance $19175 r0 *1 137.37,184.8
X$19175 13814 13882 112 113 13874 XNOR2_X2
* cell instance $19176 r0 *1 139.27,184.8
X$19176 9765 13884 113 112 13882 XNOR2_X1
* cell instance $19177 r0 *1 140.41,184.8
X$19177 9765 13758 113 112 14003 XNOR2_X1
* cell instance $19180 r0 *1 142.5,184.8
X$19180 13892 113 9765 112 BUF_X4
* cell instance $19181 r0 *1 143.83,184.8
X$19181 13614 13760 112 113 13883 XNOR2_X2
* cell instance $19182 r0 *1 145.73,184.8
X$19182 11597 8577 13946 112 113 14008 OR3_X2
* cell instance $19184 m0 *1 146.49,184.8
X$19184 13878 7107 13761 112 13634 113 AOI21_X1
* cell instance $19186 m0 *1 148.2,184.8
X$19186 112 16904 13808 13762 13635 113 DFF_X1
* cell instance $19187 m0 *1 151.43,184.8
X$19187 13808 112 113 11015 CLKBUF_X3
* cell instance $19189 r0 *1 146.87,184.8
X$19189 13880 5708 112 113 13878 NOR2_X1
* cell instance $19190 r0 *1 147.44,184.8
X$19190 11597 13754 112 113 13877 XOR2_X1
* cell instance $19193 r0 *1 152,184.8
X$19193 10484 13809 113 112 13942 XNOR2_X1
* cell instance $19195 m0 *1 152.76,184.8
X$19195 13961 7107 13809 112 13876 113 AOI21_X1
* cell instance $19199 r0 *1 153.14,184.8
X$19199 112 17038 13875 13876 13894 113 DFF_X1
* cell instance $19200 r0 *1 156.37,184.8
X$19200 13875 113 13763 112 BUF_X4
* cell instance $19201 r0 *1 157.7,184.8
X$19201 13831 113 10484 112 BUF_X4
* cell instance $19204 m0 *1 159.22,184.8
X$19204 12619 13699 16504 113 112 13698 HA_X1
* cell instance $19205 m0 *1 161.31,184.8
X$19205 12619 13699 16561 113 112 12295 HA_X1
* cell instance $19207 m0 *1 164.73,184.8
X$19207 12619 11861 16540 113 112 13807 HA_X1
* cell instance $19208 m0 *1 166.63,184.8
X$19208 12447 11861 16554 113 112 13700 HA_X1
* cell instance $19209 m0 *1 168.53,184.8
X$19209 12447 11861 16557 113 112 13321 HA_X1
* cell instance $19213 r0 *1 160.36,184.8
X$19213 112 11549 113 11915 BUF_X8
* cell instance $19217 r0 *1 167.58,184.8
X$19217 112 11693 113 11977 BUF_X8
* cell instance $19219 r0 *1 170.24,184.8
X$19219 13398 113 11684 112 BUF_X4
* cell instance $19221 m0 *1 170.81,184.8
X$19221 13807 112 113 13731 INV_X1
* cell instance $19223 m0 *1 172.14,184.8
X$19223 11537 13699 16565 113 112 13637 HA_X1
* cell instance $19227 m0 *1 176.51,184.8
X$19227 11537 13699 13870 113 112 13232 HA_X1
* cell instance $19234 r0 *1 176.7,184.8
X$19234 13870 113 11977 112 BUF_X4
* cell instance $19240 r0 *1 181.83,184.8
X$19240 5395 13719 112 113 13869 NOR2_X1
* cell instance $19241 m0 *1 182.02,184.8
X$19241 13763 112 113 13719 INV_X1
* cell instance $19243 m0 *1 182.4,184.8
X$19243 10188 112 113 13801 BUF_X1
* cell instance $19244 m0 *1 182.97,184.8
X$19244 4508 13763 112 113 13802 NAND2_X1
* cell instance $19245 m0 *1 183.54,184.8
X$19245 4508 13719 112 113 13803 NAND2_X1
* cell instance $19246 m0 *1 184.11,184.8
X$19246 13802 13803 13801 113 112 13965 MUX2_X2
* cell instance $19248 m0 *1 186.58,184.8
X$19248 112 13764 13765 13766 13903 113 NOR3_X4
* cell instance $19250 m0 *1 189.43,184.8
X$19250 13764 11204 11362 112 13798 113 AOI21_X2
* cell instance $19252 m0 *1 190.95,184.8
X$19252 11362 10516 11204 112 13770 113 NAND3_X4
* cell instance $19253 m0 *1 193.42,184.8
X$19253 13798 13797 112 113 13835 NOR2_X2
* cell instance $19255 r0 *1 182.4,184.8
X$19255 5395 13763 112 113 13832 NOR2_X1
* cell instance $19256 r0 *1 182.97,184.8
X$19256 13869 13832 10188 113 112 14081 MUX2_X2
* cell instance $19258 r0 *1 185.06,184.8
X$19258 10840 113 13833 112 BUF_X4
* cell instance $19260 r0 *1 186.77,184.8
X$19260 11204 113 13966 112 BUF_X4
* cell instance $19261 r0 *1 188.1,184.8
X$19261 11205 113 13765 112 BUF_X4
* cell instance $19262 r0 *1 189.43,184.8
X$19262 11362 113 13898 112 BUF_X4
* cell instance $19263 r0 *1 190.76,184.8
X$19263 112 13834 10516 11204 11362 113 AOI21_X4
* cell instance $19264 r0 *1 193.23,184.8
X$19264 13798 113 13836 112 BUF_X4
* cell instance $19265 r0 *1 194.56,184.8
X$19265 13836 13797 13833 113 13934 112 OAI21_X1
* cell instance $19266 m0 *1 196.84,184.8
X$19266 13795 13716 13793 13768 112 113 13652 AOI22_X1
* cell instance $19267 m0 *1 194.75,184.8
X$19267 13796 13704 13767 13705 13794 13795 113 112 AOI221_X2
* cell instance $19268 m0 *1 197.79,184.8
X$19268 13769 13770 13790 113 13863 112 OAI21_X1
* cell instance $19269 m0 *1 198.55,184.8
X$19269 13704 13640 112 113 13789 NAND2_X1
* cell instance $19270 m0 *1 199.12,184.8
X$19270 13640 13705 112 113 13788 NAND2_X1
* cell instance $19271 m0 *1 199.69,184.8
X$19271 13702 13640 112 113 13786 NAND2_X1
* cell instance $19272 m0 *1 200.26,184.8
X$19272 13716 13580 112 113 13785 NAND2_X2
* cell instance $19273 m0 *1 201.21,184.8
X$19273 13580 113 13776 112 BUF_X4
* cell instance $19276 r0 *1 196.08,184.8
X$19276 10299 112 113 13638 CLKBUF_X3
* cell instance $19277 r0 *1 197.03,184.8
X$19277 13716 13862 13863 112 13768 113 AOI21_X1
* cell instance $19279 r0 *1 198.17,184.8
X$19279 13904 13834 13786 13903 13837 112 113 13861 AOI221_X1
* cell instance $19283 r0 *1 200.64,184.8
X$19283 13769 13835 13861 113 13860 112 OAI21_X1
* cell instance $19284 r0 *1 201.4,184.8
X$19284 13905 13931 13852 13860 112 113 13859 NAND4_X1
* cell instance $19286 r0 *1 202.73,184.8
X$19286 13907 13858 13859 13849 112 113 13220 NAND4_X1
* cell instance $19287 m0 *1 203.11,184.8
X$19287 13771 13706 112 113 13708 NOR2_X1
* cell instance $19307 m0 *1 38.19,179.2
X$19307 13510 112 113 13333 INV_X1
* cell instance $19309 m0 *1 38.57,179.2
X$19309 11720 13485 10873 112 13510 113 AOI21_X1
* cell instance $19310 m0 *1 39.33,179.2
X$19310 10969 112 113 12181 CLKBUF_X3
* cell instance $19311 m0 *1 40.28,179.2
X$19311 11398 10030 16576 113 112 13485 HA_X1
* cell instance $19313 m0 *1 42.37,179.2
X$19313 11487 10549 12649 112 113 13511 NAND3_X1
* cell instance $19314 m0 *1 43.13,179.2
X$19314 13511 13512 10404 112 113 13515 NAND3_X1
* cell instance $19319 r0 *1 41.04,179.2
X$19319 12458 13423 13150 113 13516 112 OAI21_X1
* cell instance $19323 m0 *1 46.74,179.2
X$19323 13425 10981 12458 112 113 13582 NAND3_X1
* cell instance $19325 m0 *1 47.5,179.2
X$19325 10404 13458 13515 113 13486 112 OAI21_X1
* cell instance $19327 m0 *1 49.02,179.2
X$19327 13516 13487 13519 113 13550 112 OAI21_X1
* cell instance $19328 m0 *1 49.78,179.2
X$19328 11876 12019 112 113 13487 NAND2_X1
* cell instance $19331 m0 *1 52.06,179.2
X$19331 11720 112 113 10981 CLKBUF_X3
* cell instance $19334 r0 *1 46.93,179.2
X$19334 13456 13582 13486 12458 13583 112 113 OAI211_X2
* cell instance $19336 r0 *1 48.83,179.2
X$19336 13583 11494 13550 11093 13332 13584 113 112 AOI221_X2
* cell instance $19338 m0 *1 53.58,179.2
X$19338 10404 112 113 12019 CLKBUF_X3
* cell instance $19343 r0 *1 54.53,179.2
X$19343 112 17008 13586 13584 13585 113 DFF_X1
* cell instance $19344 m0 *1 55.48,179.2
X$19344 11878 10684 12372 112 113 13518 NAND3_X1
* cell instance $19345 m0 *1 54.91,179.2
X$19345 13517 10404 112 113 13427 NAND2_X1
* cell instance $19346 m0 *1 56.24,179.2
X$19346 13428 13520 11876 10981 112 113 13519 NAND4_X1
* cell instance $19347 m0 *1 57.19,179.2
X$19347 13518 13521 12581 112 113 13520 NAND3_X1
* cell instance $19349 r0 *1 57.76,179.2
X$19349 11398 10030 16640 113 112 13488 HA_X1
* cell instance $19350 m0 *1 58.52,179.2
X$19350 11192 13488 112 113 13521 NAND2_X1
* cell instance $19352 m0 *1 59.09,179.2
X$19352 13488 10969 13522 112 113 13517 MUX2_X1
* cell instance $19354 m0 *1 61.18,179.2
X$19354 10684 112 113 12458 CLKBUF_X3
* cell instance $19355 m0 *1 62.13,179.2
X$19355 11192 113 11882 112 BUF_X4
* cell instance $19363 r0 *1 63.84,179.2
X$19363 13586 113 8626 112 BUF_X4
* cell instance $19369 m0 *1 69.35,179.2
X$19369 13158 12959 112 113 13524 NAND2_X1
* cell instance $19371 m0 *1 69.92,179.2
X$19371 112 13523 10658 13524 12958 11259 13252 13489 113 OAI222_X2
* cell instance $19373 m0 *1 72.77,179.2
X$19373 12313 12311 13340 112 13523 113 AOI21_X1
* cell instance $19374 m0 *1 73.53,179.2
X$19374 13588 13643 13526 112 13464 113 AOI21_X1
* cell instance $19375 m0 *1 74.29,179.2
X$19375 13462 13490 13159 11973 112 113 13526 NAND4_X1
* cell instance $19377 m0 *1 75.43,179.2
X$19377 12313 12673 12592 112 13589 113 AOI21_X1
* cell instance $19378 m0 *1 76.19,179.2
X$19378 13009 12590 112 113 13491 NAND2_X1
* cell instance $19379 m0 *1 76.76,179.2
X$19379 13009 13429 13491 113 13528 112 OAI21_X1
* cell instance $19380 m0 *1 77.52,179.2
X$19380 13492 12273 11359 113 13490 112 OAI21_X1
* cell instance $19381 m0 *1 78.28,179.2
X$19381 12133 11574 112 113 13254 NAND2_X1
* cell instance $19385 r0 *1 70.3,179.2
X$19385 112 12311 11259 113 BUF_X16
* cell instance $19387 r0 *1 75.43,179.2
X$19387 13018 13589 13461 13591 13340 13551 112 113 OAI221_X2
* cell instance $19388 r0 *1 77.52,179.2
X$19388 12594 11734 112 113 13591 NOR2_X1
* cell instance $19389 r0 *1 78.09,179.2
X$19389 13493 13009 13010 112 13592 113 AOI21_X1
* cell instance $19390 r0 *1 78.85,179.2
X$19390 11260 11513 13009 13254 112 113 13594 AOI22_X1
* cell instance $19392 m0 *1 79.23,179.2
X$19392 13340 11665 13530 113 112 13493 OAI21_X2
* cell instance $19393 m0 *1 80.75,179.2
X$19393 11206 11407 112 113 13494 NOR2_X1
* cell instance $19394 m0 *1 81.32,179.2
X$19394 12857 13345 13461 112 13432 113 AOI21_X1
* cell instance $19395 m0 *1 82.08,179.2
X$19395 11206 113 12685 112 BUF_X4
* cell instance $19396 m0 *1 83.41,179.2
X$19396 13493 13595 11743 11574 12313 13496 113 112 AOI221_X2
* cell instance $19398 r0 *1 79.8,179.2
X$19398 12398 11844 11577 112 13553 113 AOI21_X1
* cell instance $19399 r0 *1 80.56,179.2
X$19399 13553 13344 13492 113 13595 112 OAI21_X1
* cell instance $19400 r0 *1 81.32,179.2
X$19400 112 12663 12397 113 BUF_X16
* cell instance $19401 m0 *1 87.21,179.2
X$19401 13535 11359 11262 112 13598 113 AOI21_X1
* cell instance $19402 m0 *1 85.88,179.2
X$19402 12549 13494 13160 10928 13554 13598 112 113 13534 OAI33_X1
* cell instance $19403 m0 *1 87.97,179.2
X$19403 13018 12270 11665 113 13535 112 OAI21_X1
* cell instance $19405 m0 *1 88.92,179.2
X$19405 11572 12594 112 113 13495 NAND2_X1
* cell instance $19408 r0 *1 86.26,179.2
X$19408 12315 12591 10926 113 13654 112 OAI21_X1
* cell instance $19409 r0 *1 87.02,179.2
X$19409 13621 12961 11663 113 13597 112 OAI21_X1
* cell instance $19411 r0 *1 88.54,179.2
X$19411 11407 13495 12397 11884 113 112 13657 OAI22_X1
* cell instance $19412 r0 *1 89.49,179.2
X$19412 11572 11734 112 113 13558 NOR2_X2
* cell instance $19414 m0 *1 89.87,179.2
X$19414 12592 12673 112 113 13555 NAND2_X1
* cell instance $19448 r0 *1 68.97,182
X$19448 13018 10658 16601 113 112 13616 HA_X1
* cell instance $19449 m0 *1 70.11,182
X$19449 13616 112 113 12034 INV_X4
* cell instance $19451 m0 *1 71.06,182
X$19451 13617 11669 12127 112 113 13646 MUX2_X1
* cell instance $19452 m0 *1 72.39,182
X$19452 12591 12663 112 113 13618 NOR2_X1
* cell instance $19453 m0 *1 72.96,182
X$19453 12397 13252 13159 112 13588 113 AOI21_X1
* cell instance $19454 m0 *1 73.72,182
X$19454 13489 11259 13645 112 13644 113 AOI21_X1
* cell instance $19455 m0 *1 74.48,182
X$19455 12959 13492 13618 112 113 13645 MUX2_X1
* cell instance $19456 m0 *1 75.81,182
X$19456 12591 12663 112 113 13461 NAND2_X1
* cell instance $19457 m0 *1 76.38,182
X$19457 13551 13343 13620 13618 112 113 13619 AOI22_X2
* cell instance $19458 m0 *1 78.09,182
X$19458 13344 13340 112 113 13714 NOR2_X1
* cell instance $19459 m0 *1 78.66,182
X$19459 11260 12133 12034 112 113 13717 MUX2_X1
* cell instance $19461 r0 *1 70.87,182
X$19461 13680 112 113 13617 INV_X1
* cell instance $19462 r0 *1 71.25,182
X$19462 13616 113 11844 112 BUF_X4
* cell instance $19463 r0 *1 72.58,182
X$19463 13340 113 12320 112 BUF_X4
* cell instance $19464 r0 *1 73.91,182
X$19464 12320 13018 12397 112 113 13681 NAND3_X1
* cell instance $19466 r0 *1 74.86,182
X$19466 13711 13618 12865 113 13713 112 OAI21_X1
* cell instance $19467 r0 *1 75.62,182
X$19467 12667 12592 13161 112 113 13682 MUX2_X1
* cell instance $19468 r0 *1 76.95,182
X$19468 13713 13714 12320 13646 112 113 13715 AOI22_X1
* cell instance $19469 r0 *1 77.9,182
X$19469 13715 11581 13848 112 113 13780 MUX2_X1
* cell instance $19471 r0 *1 79.61,182
X$19471 12592 113 12273 112 BUF_X4
* cell instance $19472 m0 *1 81.13,182
X$19472 13340 112 113 12135 CLKBUF_X3
* cell instance $19473 m0 *1 80.37,182
X$19473 13650 11744 13594 112 13649 113 AOI21_X1
* cell instance $19474 m0 *1 82.08,182
X$19474 12667 12313 13158 11577 13654 112 113 13650 AOI221_X1
* cell instance $19475 m0 *1 83.22,182
X$19475 112 12663 13161 113 BUF_X16
* cell instance $19476 m0 *1 87.97,182
X$19476 11572 12034 12032 112 13656 113 AOI21_X1
* cell instance $19480 r0 *1 81.13,182
X$19480 12469 13158 112 113 11988 NAND2_X2
* cell instance $19481 r0 *1 82.08,182
X$19481 13431 11839 13020 112 113 13683 MUX2_X1
* cell instance $19482 r0 *1 83.41,182
X$19482 12032 13256 112 113 13718 NAND2_X1
* cell instance $19483 r0 *1 83.98,182
X$19483 13158 13718 13622 112 13621 113 AOI21_X2
* cell instance $19485 r0 *1 85.5,182
X$19485 13345 13621 12685 11744 113 112 13720 OAI22_X2
* cell instance $19487 r0 *1 87.59,182
X$19487 13340 13656 13555 112 13685 113 AOI21_X1
* cell instance $19489 r0 *1 88.54,182
X$19489 12591 13721 12592 112 13622 113 AOI21_X2
* cell instance $19490 r0 *1 89.87,182
X$19490 13622 13726 112 113 13623 NAND2_X1
* cell instance $19491 m0 *1 91.01,182
X$19491 12865 11259 112 113 13726 NAND2_X1
* cell instance $19492 m0 *1 89.87,182
X$19492 11664 12593 12549 10658 13558 112 113 13722 AOI221_X1
* cell instance $19494 r0 *1 90.44,182
X$19494 13623 12402 112 113 13557 NAND2_X1
* cell instance $19495 r0 *1 91.01,182
X$19495 13009 13555 13726 112 13687 113 AOI21_X1
* cell instance $19496 r0 *1 91.77,182
X$19496 11678 13624 11988 12967 12929 112 113 13688 AOI221_X1
* cell instance $19498 m0 *1 91.96,182
X$19498 12035 12746 112 113 13624 NAND2_X1
* cell instance $19500 m0 *1 94.81,182
X$19500 13558 13164 12273 112 113 13625 NOR3_X1
* cell instance $19501 m0 *1 95.57,182
X$19501 11262 11893 11844 12593 113 112 13627 OAI22_X1
* cell instance $19502 m0 *1 96.52,182
X$19502 11262 13164 12035 113 13662 112 OAI21_X1
* cell instance $19503 m0 *1 97.28,182
X$19503 13661 13492 13229 112 113 13665 MUX2_X1
* cell instance $19504 m0 *1 98.61,182
X$19504 12135 13662 13600 113 13730 112 OAI21_X1
* cell instance $19506 m0 *1 99.56,182
X$19506 13619 10120 13665 112 113 13666 MUX2_X1
* cell instance $19507 m0 *1 100.89,182
X$19507 13644 10120 13649 112 113 12603 MUX2_X1
* cell instance $19513 r0 *1 93.86,182
X$19513 13387 11581 112 113 13800 NAND2_X1
* cell instance $19514 r0 *1 94.43,182
X$19514 12477 13528 13728 13626 112 113 13689 AOI22_X1
* cell instance $19515 r0 *1 95.38,182
X$19515 12135 11844 12929 112 13626 113 AOI21_X1
* cell instance $19516 r0 *1 96.14,182
X$19516 13074 13492 12857 112 113 13733 NAND3_X1
* cell instance $19518 r0 *1 97.09,182
X$19518 11663 12825 112 113 13690 OR2_X1
* cell instance $19519 r0 *1 97.85,182
X$19519 12402 13689 12413 113 13732 112 OAI21_X1
* cell instance $19520 r0 *1 98.61,182
X$19520 11663 112 113 12402 CLKBUF_X3
* cell instance $19522 r0 *1 99.94,182
X$19522 13733 10120 112 113 13629 NAND2_X1
* cell instance $19524 r0 *1 100.7,182
X$19524 13629 13592 10120 13730 113 112 13734 OAI22_X1
* cell instance $19526 r0 *1 101.84,182
X$19526 13734 12402 13666 112 113 13693 MUX2_X1
* cell instance $19528 m0 *1 105.07,182
X$19528 9300 9960 113 13630 112 XOR2_X2
* cell instance $19531 m0 *1 107.54,182
X$19531 112 16863 13668 13822 13694 113 DFF_X1
* cell instance $19536 r0 *1 107.35,182
X$19536 112 16999 13669 13692 13694 113 DFF_X1
* cell instance $19538 m0 *1 112.1,182
X$19538 13669 113 4172 112 BUF_X4
* cell instance $19541 m0 *1 119.51,182
X$19541 13671 4209 13564 112 113 13565 MUX2_X1
* cell instance $19545 m0 *1 123.31,182
X$19545 112 16898 13674 13631 13673 113 DFF_X1
* cell instance $19546 m0 *1 126.54,182
X$19546 112 7658 113 13674 BUF_X8
* cell instance $19549 m0 *1 130.72,182
X$19549 8454 9473 113 112 13743 XNOR2_X1
* cell instance $19551 m0 *1 132.05,182
X$19551 112 16936 13568 13675 13633 113 DFF_X1
* cell instance $19554 r0 *1 112.1,182
X$19554 112 17042 13737 13695 13673 113 DFF_X1
* cell instance $19559 r0 *1 120.84,182
X$19559 112 13810 13673 8868 13741 113 DFF_X2
* cell instance $19563 r0 *1 124.45,182
X$19563 7658 13741 112 113 13742 XOR2_X1
* cell instance $19564 r0 *1 125.59,182
X$19564 13740 4209 13742 112 113 13631 MUX2_X1
* cell instance $19569 r0 *1 130.72,182
X$19569 13744 6211 13743 112 113 13608 MUX2_X1
* cell instance $19571 r0 *1 132.43,182
X$19571 13632 7107 9473 112 13675 113 AOI21_X1
* cell instance $19572 r0 *1 133.19,182
X$19572 13746 5708 112 113 13632 NOR2_X1
* cell instance $19575 r0 *1 135.66,182
X$19575 13633 112 113 17193 INV_X2
* cell instance $19577 m0 *1 139.65,182
X$19577 13677 112 113 13579 CLKBUF_X3
* cell instance $19578 m0 *1 136.42,182
X$19578 112 16853 13677 13676 13633 113 DFF_X1
* cell instance $19580 m0 *1 140.79,182
X$19580 112 16926 13679 13569 13635 113 DFF_X1
* cell instance $19582 m0 *1 144.21,182
X$19582 13679 113 10709 112 BUF_X4
* cell instance $19584 m0 *1 145.73,182
X$19584 112 16883 13678 13634 13635 113 DFF_X1
* cell instance $19587 r0 *1 137.18,182
X$19587 13696 7107 13758 112 13676 113 AOI21_X1
* cell instance $19588 r0 *1 137.94,182
X$19588 13745 6244 112 113 13696 NOR2_X1
* cell instance $19592 r0 *1 146.3,182
X$19592 11015 13761 113 112 13739 XNOR2_X1
* cell instance $19593 r0 *1 147.44,182
X$19593 13738 6211 13739 112 113 13762 MUX2_X1
* cell instance $19596 m0 *1 149.34,182
X$19596 13678 112 113 13362 CLKBUF_X3
* cell instance $19599 m0 *1 154.28,182
X$19599 12335 113 12619 112 BUF_X4
* cell instance $19600 m0 *1 155.61,182
X$19600 11442 112 113 12337 CLKBUF_X3
* cell instance $19603 m0 *1 158.84,182
X$19603 13574 11549 11914 112 13636 113 AOI21_X2
* cell instance $19604 m0 *1 156.94,182
X$19604 11437 11861 16502 113 112 13573 HA_X1
* cell instance $19606 m0 *1 160.36,182
X$19606 11915 11537 11446 113 13574 112 OAI21_X1
* cell instance $19608 m0 *1 161.31,182
X$19608 13672 13636 11770 112 113 13576 NOR3_X1
* cell instance $19612 r0 *1 158.65,182
X$19612 11433 113 11281 112 BUF_X4
* cell instance $19613 r0 *1 159.98,182
X$19613 11433 13698 112 113 13265 NOR2_X1
* cell instance $19615 r0 *1 160.74,182
X$19615 11442 13698 13736 112 113 13672 NOR3_X1
* cell instance $19617 r0 *1 162.26,182
X$19617 12447 13699 13670 113 112 13736 HA_X1
* cell instance $19618 m0 *1 163.4,182
X$19618 11921 112 113 11433 CLKBUF_X3
* cell instance $19620 m0 *1 164.35,182
X$19620 10835 13670 12337 112 12876 113 AOI21_X1
* cell instance $19622 m0 *1 165.87,182
X$19622 12215 11138 112 113 11770 NAND2_X2
* cell instance $19627 r0 *1 165.11,182
X$19627 11437 13699 16655 113 112 12218 HA_X1
* cell instance $19630 r0 *1 167.58,182
X$19630 13700 11433 13667 13729 11138 12877 112 113 OAI221_X2
* cell instance $19632 m0 *1 168.72,182
X$19632 11693 11289 11921 113 13729 112 OAI21_X1
* cell instance $19634 r0 *1 169.67,182
X$19634 13700 10836 113 112 13723 AND2_X1
* cell instance $19636 r0 *1 170.62,182
X$19636 13699 11437 16604 113 112 12339 HA_X1
* cell instance $19637 m0 *1 170.81,182
X$19637 13731 12349 11446 112 113 13664 MUX2_X1
* cell instance $19640 m0 *1 173.09,182
X$19640 12344 112 113 11446 CLKBUF_X3
* cell instance $19641 m0 *1 172.52,182
X$19641 12344 12342 112 113 13577 NOR2_X1
* cell instance $19644 r0 *1 173.28,182
X$19644 13663 11838 13664 11281 13724 13723 112 113 13727 OAI33_X1
* cell instance $19645 m0 *1 176.13,182
X$19645 13637 113 13508 112 BUF_X4
* cell instance $19646 m0 *1 174.42,182
X$19646 13637 13471 11919 112 113 NOR2_X4
* cell instance $19649 r0 *1 174.8,182
X$19649 11292 12215 13699 112 113 13724 NOR3_X1
* cell instance $19652 r0 *1 177.46,182
X$19652 112 12933 113 11977 BUF_X8
* cell instance $19653 m0 *1 179.74,182
X$19653 11860 12880 112 113 13660 NOR2_X1
* cell instance $19654 m0 *1 177.84,182
X$19654 11537 11861 16533 113 112 13471 HA_X1
* cell instance $19655 m0 *1 180.31,182
X$19655 13660 12068 13659 112 113 13578 MUX2_X1
* cell instance $19656 m0 *1 181.64,182
X$19656 11977 12344 11919 112 113 13659 MUX2_X1
* cell instance $19657 m0 *1 182.97,182
X$19657 13658 10949 112 113 13599 NAND2_X1
* cell instance $19663 r0 *1 180.31,182
X$19663 6186 8454 113 13701 112 XOR2_X2
* cell instance $19666 m0 *1 183.92,182
X$19666 12349 113 12215 112 BUF_X4
* cell instance $19668 m0 *1 186.96,182
X$19668 13655 113 6186 112 BUF_X4
* cell instance $19669 m0 *1 188.29,182
X$19669 112 16734 13655 13647 13638 113 DFF_X1
* cell instance $19672 r0 *1 188.29,182
X$19672 10936 113 13766 112 BUF_X4
* cell instance $19674 r0 *1 190,182
X$19674 112 10516 11205 10936 13797 113 NOR3_X4
* cell instance $19675 m0 *1 192.09,182
X$19675 13362 12507 112 113 13703 XNOR2_X2
* cell instance $19677 m0 *1 193.99,182
X$19677 12507 13362 113 13639 112 XOR2_X2
* cell instance $19680 m0 *1 197.41,182
X$19680 13579 9356 112 113 13640 XNOR2_X2
* cell instance $19681 m0 *1 199.31,182
X$19681 10267 9807 112 113 13712 XNOR2_X2
* cell instance $19686 r0 *1 192.85,182
X$19686 13703 113 13702 112 BUF_X4
* cell instance $19689 r0 *1 194.75,182
X$19689 13703 10046 112 113 13709 NAND2_X2
* cell instance $19692 r0 *1 196.65,182
X$19692 10368 13712 112 113 13704 NOR2_X1
* cell instance $19693 r0 *1 197.22,182
X$19693 13640 113 13716 112 BUF_X4
* cell instance $19696 r0 *1 199.69,182
X$19696 13651 113 13706 112 BUF_X4
* cell instance $19697 r0 *1 201.02,182
X$19697 13706 13580 112 113 13772 NAND2_X2
* cell instance $19699 r0 *1 202.73,182
X$19699 10046 113 13707 112 BUF_X4
* cell instance $19702 m0 *1 208.43,182
X$19702 11157 12103 16532 113 112 13295 HA_X1
* cell instance $19704 m0 *1 212.04,182
X$19704 11790 13448 112 113 13648 NAND2_X1
* cell instance $19708 m0 *1 214.7,182
X$19708 12086 13448 16564 113 112 13365 HA_X1
* cell instance $19710 m0 *1 216.6,182
X$19710 11964 113 13368 112 BUF_X4
* cell instance $19711 m0 *1 217.93,182
X$19711 12266 11799 11937 112 13581 113 AOI21_X1
* cell instance $19715 m0 *1 221.16,182
X$19715 112 11161 113 12985 BUF_X8
* cell instance $19716 m0 *1 223.63,182
X$19716 10737 13641 112 113 13454 NOR2_X1
* cell instance $19719 r0 *1 216.41,182
X$19719 112 11964 13448 113 BUF_X16
* cell instance $19721 m0 *1 224.77,182
X$19721 11157 13448 16488 113 112 13642 HA_X1
* cell instance $19723 m0 *1 226.67,182
X$19723 12086 12985 16527 113 112 12637 HA_X1
* cell instance $19762 m0 *1 60.8,187.6
X$19762 112 3162 113 6509 BUF_X8
* cell instance $19766 m0 *1 71.82,187.6
X$19766 12398 113 11973 112 BUF_X4
* cell instance $19768 m0 *1 74.67,187.6
X$19768 112 11734 13018 113 BUF_X16
* cell instance $19776 r0 *1 72.2,187.6
X$19776 112 12663 12026 113 BUF_X32
* cell instance $19777 m0 *1 80.37,187.6
X$19777 13018 12026 16574 113 112 13256 HA_X1
* cell instance $19778 m0 *1 79.8,187.6
X$19778 12469 13158 112 113 13920 NOR2_X1
* cell instance $19779 m0 *1 82.27,187.6
X$19779 12195 12594 11734 112 113 13854 MUX2_X1
* cell instance $19782 r0 *1 81.89,187.6
X$19782 14044 13885 11581 113 13817 112 OAI21_X1
* cell instance $19783 r0 *1 82.65,187.6
X$19783 112 11664 12471 13131 12663 14010 12685 13981 113 OAI222_X2
* cell instance $19784 m0 *1 84.17,187.6
X$19784 12550 13018 12959 112 13982 113 AOI21_X1
* cell instance $19786 m0 *1 84.93,187.6
X$19786 13981 12263 13886 112 113 13539 MUX2_X1
* cell instance $19787 m0 *1 86.26,187.6
X$19787 12959 13018 13161 112 113 13791 NAND3_X1
* cell instance $19788 m0 *1 87.02,187.6
X$19788 13982 12320 11888 112 113 14044 NOR3_X1
* cell instance $19793 r0 *1 85.88,187.6
X$19793 13256 112 113 14010 BUF_X2
* cell instance $19794 r0 *1 86.64,187.6
X$19794 112 11678 113 12594 BUF_X8
* cell instance $19796 m0 *1 88.92,187.6
X$19796 11678 13161 12398 112 13983 113 AOI21_X1
* cell instance $19797 r0 *1 89.11,187.6
X$19797 112 13983 13018 12685 12397 12195 12471 13985 113 OAI222_X2
* cell instance $19798 m0 *1 90.25,187.6
X$19798 11743 13983 112 113 13929 OR2_X1
* cell instance $19800 m0 *1 91.01,187.6
X$19800 13985 12402 12477 13987 13929 113 112 13887 OAI221_X1
* cell instance $19801 m0 *1 92.15,187.6
X$19801 13887 13820 12413 112 113 13930 NAND3_X1
* cell instance $19802 m0 *1 92.91,187.6
X$19802 13989 10928 112 113 13949 NOR2_X1
* cell instance $19803 m0 *1 93.48,187.6
X$19803 13947 12402 11744 112 113 13888 NAND3_X1
* cell instance $19805 m0 *1 94.43,187.6
X$19805 13932 12477 13782 113 112 13691 OAI21_X2
* cell instance $19807 m0 *1 95.95,187.6
X$19807 11743 14011 13625 112 113 13950 OR3_X1
* cell instance $19811 r0 *1 92.34,187.6
X$19811 11262 11259 112 113 14046 NOR2_X1
* cell instance $19812 r0 *1 92.91,187.6
X$19812 14045 14046 11574 11973 113 112 13947 OAI22_X1
* cell instance $19814 r0 *1 94.05,187.6
X$19814 12600 12857 112 113 13987 NOR2_X1
* cell instance $19815 r0 *1 94.62,187.6
X$19815 11262 13948 112 113 14011 NOR2_X1
* cell instance $19816 r0 *1 95.19,187.6
X$19816 13949 13821 12477 113 13932 112 OAI21_X1
* cell instance $19818 r0 *1 96.33,187.6
X$19818 13492 113 11744 112 BUF_X4
* cell instance $19819 m0 *1 97.47,187.6
X$19819 11263 13628 13950 112 13933 113 AOI21_X1
* cell instance $19823 r0 *1 97.85,187.6
X$19823 11678 113 11888 112 BUF_X4
* cell instance $19824 m0 *1 98.8,187.6
X$19824 112 11884 113 11678 BUF_X8
* cell instance $19833 r0 *1 102.03,187.6
X$19833 112 14015 13694 17252 10300 113 DFF_X2
* cell instance $19834 m0 *1 104.12,187.6
X$19834 112 16933 13935 13889 13694 113 DFF_X1
* cell instance $19836 m0 *1 107.35,187.6
X$19836 13935 112 113 13825 BUF_X2
* cell instance $19839 m0 *1 109.06,187.6
X$19839 9299 13825 113 14050 112 XOR2_X2
* cell instance $19841 m0 *1 111.53,187.6
X$19841 112 16885 13891 13890 13673 113 DFF_X1
* cell instance $19843 m0 *1 115.52,187.6
X$19843 13951 13822 13998 112 113 13563 MUX2_X1
* cell instance $19848 r0 *1 107.92,187.6
X$19848 14049 14012 13889 113 112 6109 MUX2_X2
* cell instance $19851 r0 *1 110.77,187.6
X$19851 14052 13999 13889 113 112 6487 MUX2_X2
* cell instance $19854 r0 *1 114.76,187.6
X$19854 14135 13889 14054 112 113 13951 MUX2_X1
* cell instance $19856 r0 *1 116.28,187.6
X$19856 13953 13952 14055 112 113 14054 MUX2_X1
* cell instance $19858 r0 *1 118.37,187.6
X$19858 13952 112 113 14013 INV_X2
* cell instance $19859 m0 *1 121.98,187.6
X$19859 13824 113 13889 112 BUF_X4
* cell instance $19860 m0 *1 118.75,187.6
X$19860 112 16880 13756 13936 13673 113 DFF_X1
* cell instance $19863 m0 *1 126.54,187.6
X$19863 13827 112 113 13937 BUF_X1
* cell instance $19864 m0 *1 127.11,187.6
X$19864 13566 112 113 13952 CLKBUF_X3
* cell instance $19865 m0 *1 128.06,187.6
X$19865 13828 13937 13829 112 113 13955 MUX2_X1
* cell instance $19869 r0 *1 119.51,187.6
X$19869 13954 13889 14059 112 113 13810 MUX2_X1
* cell instance $19872 r0 *1 121.41,187.6
X$19872 14013 13889 112 113 14014 NOR2_X1
* cell instance $19874 r0 *1 122.17,187.6
X$19874 14001 14015 14058 112 113 14059 MUX2_X1
* cell instance $19880 r0 *1 125.4,187.6
X$19880 14061 14013 14064 112 113 13999 MUX2_X1
* cell instance $19881 r0 *1 126.73,187.6
X$19881 112 14000 14019 14100 13955 14066 113 AOI22_X4
* cell instance $19882 m0 *1 129.96,187.6
X$19882 13940 6509 13567 112 113 13941 MUX2_X1
* cell instance $19884 m0 *1 131.29,187.6
X$19884 13941 113 13956 112 BUF_X4
* cell instance $19886 m0 *1 135.66,187.6
X$19886 13263 113 14000 112 BUF_X4
* cell instance $19891 r0 *1 130.34,187.6
X$19891 14020 8862 112 113 14066 NAND2_X1
* cell instance $19894 r0 *1 131.86,187.6
X$19894 14067 112 113 14020 INV_X1
* cell instance $19896 r0 *1 132.43,187.6
X$19896 9469 113 14176 112 BUF_X4
* cell instance $19899 r0 *1 134.9,187.6
X$19899 3068 14021 112 113 14022 OR2_X1
* cell instance $19903 r0 *1 137.75,187.6
X$19903 13570 13884 112 113 13957 XOR2_X1
* cell instance $19904 m0 *1 138.32,187.6
X$19904 14004 6211 14003 112 113 13945 MUX2_X1
* cell instance $19906 m0 *1 139.65,187.6
X$19906 112 16907 13892 13945 13635 113 DFF_X1
* cell instance $19909 m0 *1 143.83,187.6
X$19909 11118 13759 112 113 13958 XOR2_X1
* cell instance $19910 m0 *1 144.97,187.6
X$19910 8539 112 113 13635 CLKBUF_X3
* cell instance $19912 m0 *1 146.11,187.6
X$19912 13946 3780 11597 112 113 13893 NAND3_X2
* cell instance $19916 r0 *1 143.45,187.6
X$19916 14074 8295 13958 112 113 14009 MUX2_X1
* cell instance $19917 r0 *1 144.78,187.6
X$19917 13959 112 113 11118 CLKBUF_X3
* cell instance $19919 r0 *1 145.92,187.6
X$19919 14147 113 14075 112 BUF_X4
* cell instance $19920 r0 *1 147.25,187.6
X$19920 14008 13893 113 112 14024 AND2_X2
* cell instance $19921 m0 *1 148.01,187.6
X$19921 13944 8295 13877 112 113 13960 MUX2_X1
* cell instance $19924 m0 *1 150.1,187.6
X$19924 13943 113 11597 112 BUF_X4
* cell instance $19928 r0 *1 148.96,187.6
X$19928 112 17148 13943 13960 13894 113 DFF_X1
* cell instance $19930 m0 *1 152.76,187.6
X$19930 14007 3783 13942 112 113 14006 MUX2_X1
* cell instance $19933 r0 *1 152.95,187.6
X$19933 14077 5708 112 113 13961 NOR2_X1
* cell instance $19936 m0 *1 154.47,187.6
X$19936 112 16935 13831 14006 13894 113 DFF_X1
* cell instance $19941 r0 *1 157.7,187.6
X$19941 13894 112 113 16481 CLKBUF_X1
* cell instance $19942 r0 *1 158.27,187.6
X$19942 8539 112 113 13894 CLKBUF_X3
* cell instance $19943 r0 *1 159.22,187.6
X$19943 14080 13763 113 14079 112 XOR2_X2
* cell instance $19946 m0 *1 162.64,187.6
X$19946 9988 9217 113 14005 112 XOR2_X2
* cell instance $19951 r0 *1 166.06,187.6
X$19951 112 17139 13962 14189 13894 113 DFF_X1
* cell instance $19953 m0 *1 166.25,187.6
X$19953 13895 113 9988 112 BUF_X4
* cell instance $19955 m0 *1 168.91,187.6
X$19955 13962 112 113 10000 CLKBUF_X3
* cell instance $19959 m0 *1 176.13,187.6
X$19959 14002 4939 13939 112 113 13938 MUX2_X1
* cell instance $19960 m0 *1 177.46,187.6
X$19960 112 13963 14002 13938 14106 113 DFF_X1
* cell instance $19961 m0 *1 180.69,187.6
X$19961 13963 5395 13763 112 113 13964 NAND3_X2
* cell instance $19962 m0 *1 182.02,187.6
X$19962 13763 5240 13963 112 113 13896 OR3_X2
* cell instance $19968 r0 *1 172.14,187.6
X$19968 112 11915 13699 113 BUF_X16
* cell instance $19976 r0 *1 182.59,187.6
X$19976 13964 13896 112 14082 113 NAND2_X4
* cell instance $19977 m0 *1 183.73,187.6
X$19977 13896 13964 113 112 13897 AND2_X2
* cell instance $19979 m0 *1 184.68,187.6
X$19979 112 13901 10840 13965 13897 113 AOI21_X4
* cell instance $19980 m0 *1 187.15,187.6
X$19980 112 13898 13966 13965 13897 13910 113 NAND4_X4
* cell instance $19985 r0 *1 186.77,187.6
X$19985 10840 112 113 13967 INV_X4
* cell instance $19986 r0 *1 187.72,187.6
X$19986 112 14025 113 13765 BUF_X8
* cell instance $19987 r0 *1 190.19,187.6
X$19987 112 14053 13833 11204 11362 113 AOI21_X4
* cell instance $19989 m0 *1 190.95,187.6
X$19989 13797 10046 13798 112 113 13899 MUX2_X1
* cell instance $19991 m0 *1 192.66,187.6
X$19991 13702 113 13900 112 BUF_X4
* cell instance $19992 r0 *1 192.66,187.6
X$19992 13898 13967 13966 112 14043 113 NAND3_X4
* cell instance $19993 m0 *1 194.56,187.6
X$19993 14078 13934 13900 112 113 13902 NAND3_X1
* cell instance $19996 m0 *1 195.51,187.6
X$19996 13934 13994 13639 10046 13997 112 113 13996 AOI221_X1
* cell instance $19997 m0 *1 196.65,187.6
X$19997 13915 13968 13709 13916 13834 112 113 13790 AOI221_X1
* cell instance $19998 m0 *1 197.79,187.6
X$19998 13903 13901 10046 13990 13834 112 113 13994 AOI221_X1
* cell instance $19999 m0 *1 198.93,187.6
X$19999 13651 13712 112 113 13995 NAND2_X2
* cell instance $20000 m0 *1 199.88,187.6
X$20000 13702 13651 112 113 13969 NAND2_X1
* cell instance $20001 m0 *1 200.45,187.6
X$20001 13993 13969 112 113 13905 OR2_X1
* cell instance $20002 m0 *1 201.21,187.6
X$20002 13906 13992 13972 113 13931 112 OAI21_X1
* cell instance $20003 m0 *1 201.97,187.6
X$20003 13716 13712 112 113 14032 NAND2_X1
* cell instance $20004 m0 *1 202.54,187.6
X$20004 13716 13991 13908 112 13992 113 AOI21_X1
* cell instance $20005 m0 *1 203.3,187.6
X$20005 13970 13910 13716 13990 13903 13928 113 112 AOI221_X2
* cell instance $20006 m0 *1 205.39,187.6
X$20006 13911 13927 13902 112 13838 113 AOI21_X1
* cell instance $20010 m0 *1 208.62,187.6
X$20010 13926 13969 112 113 13851 NOR2_X1
* cell instance $20011 m0 *1 209.19,187.6
X$20011 13913 13986 13924 13839 112 113 13841 NOR4_X1
* cell instance $20012 m0 *1 210.14,187.6
X$20012 13925 13706 112 113 13710 NAND2_X1
* cell instance $20014 m0 *1 210.9,187.6
X$20014 14039 13770 13972 13915 13979 113 112 13921 OAI221_X1
* cell instance $20016 r0 *1 195.13,187.6
X$20016 13833 13836 14076 13922 113 112 13997 OAI22_X1
* cell instance $20017 r0 *1 196.08,187.6
X$20017 13638 112 113 17174 INV_X2
* cell instance $20019 r0 *1 197.03,187.6
X$20019 10368 113 14038 112 BUF_X4
* cell instance $20021 r0 *1 198.55,187.6
X$20021 13904 13966 13898 112 14030 113 AOI21_X1
* cell instance $20022 r0 *1 199.31,187.6
X$20022 13996 13995 112 113 14031 NOR2_X1
* cell instance $20024 r0 *1 200.07,187.6
X$20024 112 13797 13984 13993 13916 14072 14071 13836 113 AOI222_X2
* cell instance $20026 r0 *1 202.92,187.6
X$20026 13916 13918 13970 113 13991 112 OAI21_X1
* cell instance $20029 r0 *1 205.39,187.6
X$20029 14069 14065 14036 113 14062 112 OAI21_X1
* cell instance $20031 r0 *1 206.34,187.6
X$20031 14035 14036 13925 112 113 13927 NAND3_X1
* cell instance $20033 r0 *1 207.48,187.6
X$20033 14060 13839 14062 112 13926 113 AOI21_X1
* cell instance $20035 r0 *1 209,187.6
X$20035 13915 13979 13971 113 13912 112 OAI21_X1
* cell instance $20037 r0 *1 209.95,187.6
X$20037 14053 13984 13903 112 13980 113 AOI21_X1
* cell instance $20039 r0 *1 211.09,187.6
X$20039 14048 13706 14125 112 113 13914 NOR3_X1
* cell instance $20041 r0 *1 212.23,187.6
X$20041 13900 13980 13977 14047 13978 113 112 14048 OAI221_X1
* cell instance $20043 m0 *1 212.42,187.6
X$20043 13797 13915 13836 112 14047 113 AOI21_X1
* cell instance $20045 m0 *1 214.89,187.6
X$20045 13705 13706 13917 113 112 13974 AND3_X1
* cell instance $20047 r0 *1 213.37,187.6
X$20047 13922 13973 112 113 14040 NOR2_X1
* cell instance $20048 r0 *1 213.94,187.6
X$20048 13976 14040 13900 113 13977 112 OAI21_X1
* cell instance $20049 r0 *1 214.7,187.6
X$20049 13916 13979 14043 112 13976 113 AOI21_X1
* cell instance $20051 r0 *1 216.22,187.6
X$20051 13919 13975 14038 112 113 14124 NAND3_X1
* cell instance $20052 m0 *1 216.41,187.6
X$20052 13911 112 113 13839 CLKBUF_X3
* cell instance $20063 r0 *1 219.07,187.6
X$20063 112 17106 13101 14437 13638 113 DFF_X1
* cell instance $20090 m0 *1 35.53,176.4
X$20090 13112 10797 11810 112 113 13370 MUX2_X1
* cell instance $20091 m0 *1 34.2,176.4
X$20091 10741 113 11398 112 BUF_X4
* cell instance $20092 m0 *1 36.86,176.4
X$20092 11476 10630 10457 113 112 13243 OAI21_X2
* cell instance $20093 m0 *1 38.19,176.4
X$20093 13370 11882 13372 112 113 13332 MUX2_X1
* cell instance $20094 m0 *1 39.52,176.4
X$20094 13371 12573 12250 13333 113 112 13372 OAI22_X1
* cell instance $20095 m0 *1 40.47,176.4
X$20095 12649 13243 11944 10409 112 113 13423 AOI22_X1
* cell instance $20099 m0 *1 42.56,176.4
X$20099 11174 12581 11254 113 13371 112 OAI21_X1
* cell instance $20100 m0 *1 41.8,176.4
X$20100 10548 10167 113 112 13278 AND2_X1
* cell instance $20101 m0 *1 43.32,176.4
X$20101 13244 11254 11192 13153 13374 13375 113 112 AOI221_X2
* cell instance $20102 m0 *1 45.41,176.4
X$20102 10630 12303 10167 113 13334 112 OAI21_X1
* cell instance $20103 m0 *1 46.17,176.4
X$20103 10457 112 113 12581 CLKBUF_X3
* cell instance $20106 r0 *1 43.89,176.4
X$20106 12581 10684 13485 112 113 13455 NAND3_X1
* cell instance $20107 r0 *1 44.65,176.4
X$20107 10677 12793 11394 112 113 13512 NAND3_X1
* cell instance $20108 r0 *1 45.41,176.4
X$20108 13334 11398 112 113 13374 NAND2_X1
* cell instance $20110 r0 *1 46.17,176.4
X$20110 11488 13424 112 113 13425 NAND2_X1
* cell instance $20111 r0 *1 46.74,176.4
X$20111 12793 11037 12649 112 113 13424 NAND3_X1
* cell instance $20113 m0 *1 48.26,176.4
X$20113 13245 13279 11817 11060 112 113 13336 NAND4_X1
* cell instance $20114 m0 *1 47.5,176.4
X$20114 11394 10167 10549 112 13377 113 AOI21_X1
* cell instance $20115 m0 *1 49.21,176.4
X$20115 10739 13336 13247 113 112 12953 AND3_X1
* cell instance $20117 m0 *1 50.35,176.4
X$20117 11393 10969 12793 113 13248 112 OAI21_X1
* cell instance $20119 m0 *1 51.3,176.4
X$20119 11393 10106 10457 113 13337 112 OAI21_X1
* cell instance $20121 r0 *1 47.69,176.4
X$20121 12303 12106 112 113 13426 NAND2_X1
* cell instance $20122 r0 *1 48.26,176.4
X$20122 13377 13426 12182 112 13335 113 AOI21_X1
* cell instance $20124 r0 *1 49.21,176.4
X$20124 11060 13335 13246 112 13456 113 AOI21_X1
* cell instance $20125 r0 *1 49.97,176.4
X$20125 13455 10981 11060 112 113 12378 NAND3_X1
* cell instance $20126 r0 *1 50.73,176.4
X$20126 13249 12649 13248 112 13458 113 AOI21_X1
* cell instance $20127 r0 *1 51.49,176.4
X$20127 12524 13337 113 112 13457 AND2_X1
* cell instance $20128 r0 *1 52.25,176.4
X$20128 11192 13457 10981 112 13378 113 AOI21_X1
* cell instance $20129 m0 *1 52.63,176.4
X$20129 10512 9952 112 113 13156 NAND2_X1
* cell instance $20131 m0 *1 53.2,176.4
X$20131 12581 13249 10556 12904 113 112 13283 OAI22_X2
* cell instance $20133 r0 *1 53.01,176.4
X$20133 11882 11959 10795 13427 13378 13209 113 112 AOI221_X2
* cell instance $20136 m0 *1 55.29,176.4
X$20136 11254 11192 112 113 13246 NOR2_X1
* cell instance $20137 m0 *1 56.05,176.4
X$20137 13282 13338 11882 11060 13283 12854 113 112 AOI221_X2
* cell instance $20139 m0 *1 58.33,176.4
X$20139 11944 11394 12106 112 113 13382 MUX2_X1
* cell instance $20140 m0 *1 59.66,176.4
X$20140 12583 12372 16530 113 112 13380 HA_X1
* cell instance $20141 m0 *1 61.56,176.4
X$20141 12181 12372 112 113 13381 NAND2_X1
* cell instance $20144 r0 *1 56.24,176.4
X$20144 11393 12303 11487 113 13459 112 OAI21_X1
* cell instance $20145 r0 *1 57,176.4
X$20145 11060 12649 13459 112 13338 113 AOI21_X1
* cell instance $20148 r0 *1 58.33,176.4
X$20148 13460 12181 112 113 13428 NAND2_X1
* cell instance $20151 r0 *1 59.47,176.4
X$20151 13380 10682 13068 112 113 13460 MUX2_X1
* cell instance $20153 m0 *1 62.7,176.4
X$20153 13381 10106 12458 12022 13382 113 112 12662 OAI221_X1
* cell instance $20162 m0 *1 69.35,176.4
X$20162 13251 13339 10658 113 13284 112 OAI21_X1
* cell instance $20163 m0 *1 68.78,176.4
X$20163 13340 12398 112 113 13251 NOR2_X1
* cell instance $20164 m0 *1 70.11,176.4
X$20164 13158 11669 12311 112 113 13339 NOR3_X1
* cell instance $20165 m0 *1 70.87,176.4
X$20165 13284 13253 13383 13285 112 113 13386 NAND4_X1
* cell instance $20166 m0 *1 71.82,176.4
X$20166 12590 13252 112 113 13285 OR2_X1
* cell instance $20168 m0 *1 72.77,176.4
X$20168 11995 11669 12032 112 113 13252 NAND3_X1
* cell instance $20169 m0 *1 73.53,176.4
X$20169 13287 112 113 13342 BUF_X1
* cell instance $20170 m0 *1 74.1,176.4
X$20170 13287 113 12312 112 BUF_X4
* cell instance $20171 m0 *1 75.43,176.4
X$20171 11995 113 13340 112 BUF_X4
* cell instance $20172 m0 *1 76.76,176.4
X$20172 11661 11359 112 113 13429 NAND2_X1
* cell instance $20173 m0 *1 77.33,176.4
X$20173 12743 11743 13386 112 113 13294 MUX2_X1
* cell instance $20175 m0 *1 78.85,176.4
X$20175 12590 11661 12663 112 113 13530 MUX2_X1
* cell instance $20179 r0 *1 73.91,176.4
X$20179 13461 13159 112 113 13383 OR2_X1
* cell instance $20180 r0 *1 74.67,176.4
X$20180 13340 12865 11259 112 113 13462 NAND3_X1
* cell instance $20181 r0 *1 75.43,176.4
X$20181 12594 11407 112 113 13341 NAND2_X1
* cell instance $20182 r0 *1 76,176.4
X$20182 13341 13429 11995 112 113 13385 NAND3_X1
* cell instance $20184 r0 *1 76.95,176.4
X$20184 12685 12543 112 113 13430 NOR2_X1
* cell instance $20185 r0 *1 77.52,176.4
X$20185 12313 13342 13430 12470 12590 13552 113 112 AOI221_X2
* cell instance $20186 r0 *1 79.61,176.4
X$20186 11406 12543 13494 12470 11735 13387 113 112 AOI221_X2
* cell instance $20188 m0 *1 80.56,176.4
X$20188 11206 11359 112 113 13344 NOR2_X2
* cell instance $20190 m0 *1 83.98,176.4
X$20190 11212 112 113 13345 INV_X1
* cell instance $20191 m0 *1 81.89,176.4
X$20191 12470 13389 13344 13342 11406 13296 113 112 AOI221_X2
* cell instance $20193 r0 *1 82.08,176.4
X$20193 12663 12470 11735 12313 112 113 13431 AOI22_X1
* cell instance $20194 r0 *1 83.03,176.4
X$20194 12959 11359 112 113 13465 NOR2_X1
* cell instance $20195 r0 *1 83.6,176.4
X$20195 13465 11981 11884 112 113 13466 NOR3_X1
* cell instance $20196 r0 *1 84.36,176.4
X$20196 13466 13432 12477 113 13469 112 OAI21_X1
* cell instance $20197 m0 *1 85.31,176.4
X$20197 12270 12311 12593 12747 13158 13343 112 113 OAI221_X2
* cell instance $20198 m0 *1 84.74,176.4
X$20198 13256 112 113 13389 BUF_X1
* cell instance $20199 m0 *1 87.4,176.4
X$20199 12963 11520 13391 112 13393 113 AOI21_X1
* cell instance $20201 m0 *1 88.92,176.4
X$20201 11514 112 113 12929 BUF_X2
* cell instance $20204 m0 *1 90.63,176.4
X$20204 12692 11070 12857 113 13346 112 OAI21_X1
* cell instance $20206 r0 *1 85.12,176.4
X$20206 13340 11665 11668 113 112 13554 OAI21_X4
* cell instance $20207 r0 *1 87.59,176.4
X$20207 13464 10928 13135 112 113 13391 MUX2_X1
* cell instance $20209 r0 *1 89.3,176.4
X$20209 11574 12685 112 113 13468 OR2_X1
* cell instance $20210 r0 *1 90.06,176.4
X$20210 12549 13468 13346 112 13347 113 AOI21_X1
* cell instance $20212 r0 *1 91.2,176.4
X$20212 12402 13469 13470 112 13433 113 AOI21_X1
* cell instance $20213 m0 *1 91.96,176.4
X$20213 12747 12471 12143 113 13348 112 OAI21_X1
* cell instance $20216 m0 *1 93.48,176.4
X$20216 13164 13226 11577 113 12143 112 OAI21_X1
* cell instance $20217 m0 *1 94.24,176.4
X$20217 13226 11070 112 113 13399 OR2_X1
* cell instance $20218 m0 *1 95,176.4
X$20218 12263 12600 13392 113 13302 112 OAI21_X1
* cell instance $20219 m0 *1 95.76,176.4
X$20219 12857 13302 13129 113 13303 112 OAI21_X1
* cell instance $20220 m0 *1 96.52,176.4
X$20220 13077 11839 13225 112 113 13304 MUX2_X1
* cell instance $20222 m0 *1 98.04,176.4
X$20222 13294 11520 13299 112 113 13404 MUX2_X1
* cell instance $20225 m0 *1 100.32,176.4
X$20225 13352 12135 12675 112 113 13401 MUX2_X1
* cell instance $20228 m0 *1 102.6,176.4
X$20228 13401 12413 13308 112 113 13403 MUX2_X1
* cell instance $20230 m0 *1 104.69,176.4
X$20230 13233 9307 13403 112 113 13353 MUX2_X1
* cell instance $20234 m0 *1 111.34,176.4
X$20234 10814 12762 16548 113 112 13165 HA_X1
* cell instance $20238 r0 *1 91.96,176.4
X$20238 13348 11263 112 113 13470 NAND2_X1
* cell instance $20239 r0 *1 92.53,176.4
X$20239 12319 12817 113 112 13434 AND2_X1
* cell instance $20240 r0 *1 93.29,176.4
X$20240 12142 12311 12591 112 13349 113 AOI21_X1
* cell instance $20241 r0 *1 94.05,176.4
X$20241 12032 13349 11260 12593 113 112 13472 OAI22_X1
* cell instance $20242 r0 *1 95,176.4
X$20242 12142 11981 12857 113 13350 112 OAI21_X1
* cell instance $20243 r0 *1 95.76,176.4
X$20243 13257 11411 12865 112 113 13435 NAND3_X1
* cell instance $20244 r0 *1 96.52,176.4
X$20244 13257 12319 12592 112 113 13351 NAND3_X1
* cell instance $20245 r0 *1 97.28,176.4
X$20245 13350 13351 10928 112 113 13628 NAND3_X1
* cell instance $20246 r0 *1 98.04,176.4
X$20246 11577 13399 13351 113 13474 112 OAI21_X1
* cell instance $20247 r0 *1 98.8,176.4
X$20247 12692 12602 112 113 13436 OR2_X1
* cell instance $20249 r0 *1 99.75,176.4
X$20249 13472 12263 13474 112 113 13352 MUX2_X1
* cell instance $20251 r0 *1 101.46,176.4
X$20251 13437 11520 12476 112 113 13477 MUX2_X1
* cell instance $20252 r0 *1 102.79,176.4
X$20252 13601 9307 12151 112 113 13407 MUX2_X1
* cell instance $20254 r0 *1 104.5,176.4
X$20254 13404 9307 13868 112 113 13438 MUX2_X1
* cell instance $20256 r0 *1 106.02,176.4
X$20256 13393 9307 13477 112 113 13480 MUX2_X1
* cell instance $20259 m0 *1 116.09,176.4
X$20259 10068 12572 16551 113 112 11702 HA_X1
* cell instance $20262 m0 *1 118.56,176.4
X$20262 10814 12572 16547 113 112 13259 HA_X1
* cell instance $20264 m0 *1 120.46,176.4
X$20264 112 12762 113 9826 BUF_X8
* cell instance $20265 m0 *1 122.93,176.4
X$20265 10696 10250 13408 112 113 11384 NOR3_X1
* cell instance $20266 m0 *1 123.69,176.4
X$20266 10814 12762 16501 113 112 13408 HA_X1
* cell instance $20267 m0 *1 125.59,176.4
X$20267 112 13411 13083 17227 5639 113 DFF_X2
* cell instance $20269 m0 *1 130.72,176.4
X$20269 5639 112 113 13414 BUF_X1
* cell instance $20272 m0 *1 133,176.4
X$20272 13412 13312 13261 113 112 14102 MUX2_X2
* cell instance $20273 m0 *1 134.71,176.4
X$20273 13313 13261 13262 112 113 13263 MUX2_X1
* cell instance $20274 m0 *1 136.04,176.4
X$20274 8539 112 113 13083 CLKBUF_X3
* cell instance $20275 m0 *1 136.99,176.4
X$20275 13414 6498 113 13354 112 XOR2_X2
* cell instance $20276 m0 *1 138.7,176.4
X$20276 10367 13416 113 112 13261 XNOR2_X1
* cell instance $20280 m0 *1 145.16,176.4
X$20280 13355 7107 13413 112 13169 113 AOI21_X1
* cell instance $20283 m0 *1 146.87,176.4
X$20283 10415 13417 112 113 13483 XOR2_X1
* cell instance $20288 m0 *1 153.52,176.4
X$20288 12551 11913 11442 112 13440 113 AOI21_X1
* cell instance $20289 m0 *1 154.28,176.4
X$20289 11600 112 113 12492 CLKBUF_X3
* cell instance $20292 r0 *1 122.55,176.4
X$20292 10474 13408 112 113 13406 NOR2_X1
* cell instance $20293 r0 *1 123.12,176.4
X$20293 112 9599 13479 13407 13562 113 DFF_X1
* cell instance $20297 r0 *1 126.35,176.4
X$20297 10300 13478 113 112 13498 XNOR2_X1
* cell instance $20305 r0 *1 131.48,176.4
X$20305 8008 13479 112 113 13546 XOR2_X1
* cell instance $20308 r0 *1 133.57,176.4
X$20308 112 13315 13481 13480 13083 113 DFF_X1
* cell instance $20309 r0 *1 136.8,176.4
X$20309 13083 112 113 16483 CLKBUF_X1
* cell instance $20310 r0 *1 137.37,176.4
X$20310 10562 13481 113 112 13416 XNOR2_X1
* cell instance $20315 r0 *1 141.36,176.4
X$20315 112 13419 13417 13438 13083 113 DFF_X1
* cell instance $20318 r0 *1 145.73,176.4
X$20318 13482 5708 112 113 13355 NOR2_X1
* cell instance $20320 r0 *1 147.06,176.4
X$20320 13439 13483 113 112 13478 XNOR2_X1
* cell instance $20322 r0 *1 148.39,176.4
X$20322 13439 13419 113 10585 112 XOR2_X2
* cell instance $20326 r0 *1 152.76,176.4
X$20326 112 12447 113 12625 BUF_X8
* cell instance $20327 r0 *1 155.23,176.4
X$20327 10949 12715 12831 112 13441 113 AOI21_X2
* cell instance $20328 m0 *1 155.8,176.4
X$20328 13356 12056 13421 13357 13331 11121 112 113 OAI221_X2
* cell instance $20330 m0 *1 157.89,176.4
X$20330 112 13171 13442 13331 13241 13415 113 AOI22_X4
* cell instance $20332 r0 *1 156.56,176.4
X$20332 13441 12447 13484 112 13356 113 AOI21_X1
* cell instance $20333 r0 *1 157.32,176.4
X$20333 11549 12337 12624 113 13484 112 OAI21_X1
* cell instance $20335 r0 *1 158.27,176.4
X$20335 13545 13418 11003 113 12971 112 OAI21_X1
* cell instance $20338 r0 *1 160.74,176.4
X$20338 11288 12930 11913 11432 113 112 13420 OAI22_X1
* cell instance $20339 m0 *1 161.69,176.4
X$20339 13357 13420 13327 12056 13329 12975 112 113 13418 OAI33_X1
* cell instance $20341 m0 *1 163.02,176.4
X$20341 12492 12930 11526 112 13329 113 AOI21_X1
* cell instance $20342 m0 *1 163.78,176.4
X$20342 112 12070 13358 13415 11449 11284 113 AOI22_X4
* cell instance $20343 m0 *1 167.01,176.4
X$20343 12335 11527 13359 112 13327 113 AOI21_X1
* cell instance $20344 m0 *1 167.77,176.4
X$20344 13359 11527 113 112 13409 AND2_X1
* cell instance $20345 m0 *1 168.53,176.4
X$20345 11914 13409 13182 113 13325 112 OAI21_X1
* cell instance $20346 m0 *1 169.29,176.4
X$20346 13319 13325 12427 13361 13322 11232 113 112 AOI221_X2
* cell instance $20347 m0 *1 171.38,176.4
X$20347 13475 11123 112 113 13319 NOR2_X1
* cell instance $20349 m0 *1 172.14,176.4
X$20349 12342 13314 112 113 12498 NAND2_X1
* cell instance $20350 m0 *1 172.71,176.4
X$20350 13311 112 113 12816 INV_X2
* cell instance $20352 r0 *1 161.69,176.4
X$20352 11602 12771 11684 11601 112 113 13443 AOI22_X1
* cell instance $20353 r0 *1 162.64,176.4
X$20353 11004 10834 112 113 13357 NAND2_X1
* cell instance $20356 r0 *1 163.78,176.4
X$20356 112 13183 13099 13358 11762 11855 113 AOI22_X4
* cell instance $20357 r0 *1 167.01,176.4
X$20357 11855 12930 11442 11449 113 112 13446 OAI22_X1
* cell instance $20358 r0 *1 167.96,176.4
X$20358 13360 11288 13446 112 13410 113 AOI21_X1
* cell instance $20359 r0 *1 168.72,176.4
X$20359 11693 11432 11690 11525 113 112 13360 OAI22_X1
* cell instance $20360 r0 *1 169.67,176.4
X$20360 11287 12816 112 113 13445 NOR2_X1
* cell instance $20362 r0 *1 170.43,176.4
X$20362 10835 13536 13476 112 13361 113 AOI21_X1
* cell instance $20363 r0 *1 171.19,176.4
X$20363 11693 12070 11526 112 13405 113 AOI21_X1
* cell instance $20364 r0 *1 171.95,176.4
X$20364 13473 13402 13405 12222 113 13266 112 NOR4_X2
* cell instance $20365 m0 *1 174.42,176.4
X$20365 12539 113 13398 112 BUF_X4
* cell instance $20366 m0 *1 173.66,176.4
X$20366 12342 12715 13359 112 13039 113 AOI21_X1
* cell instance $20367 m0 *1 175.75,176.4
X$20367 12933 11453 11294 113 112 12715 OAI21_X4
* cell instance $20368 m0 *1 178.22,176.4
X$20368 12930 13398 112 113 12927 NOR2_X1
* cell instance $20369 m0 *1 178.79,176.4
X$20369 12879 12880 112 113 12343 NOR2_X1
* cell instance $20371 r0 *1 173.66,176.4
X$20371 11842 11287 13398 112 113 13402 NOR3_X1
* cell instance $20372 r0 *1 174.42,176.4
X$20372 12627 11289 11448 112 113 13473 NOR3_X1
* cell instance $20373 r0 *1 175.18,176.4
X$20373 12339 112 113 11690 INV_X1
* cell instance $20374 r0 *1 175.56,176.4
X$20374 13099 11012 13183 112 12831 113 NAND3_X4
* cell instance $20376 r0 *1 178.22,176.4
X$20376 13232 112 113 11913 CLKBUF_X3
* cell instance $20378 r0 *1 179.36,176.4
X$20378 12624 12831 11289 112 113 13396 NAND3_X1
* cell instance $20379 m0 *1 179.93,176.4
X$20379 11913 11921 13267 113 13397 112 OAI21_X1
* cell instance $20381 m0 *1 180.69,176.4
X$20381 11600 13397 13396 113 13395 112 OAI21_X1
* cell instance $20382 m0 *1 181.45,176.4
X$20382 13267 12068 112 113 13307 NAND2_X1
* cell instance $20383 m0 *1 182.02,176.4
X$20383 13471 11367 11526 113 13394 112 OAI21_X1
* cell instance $20384 m0 *1 182.78,176.4
X$20384 12414 11367 12503 113 13300 112 OAI21_X1
* cell instance $20385 m0 *1 183.54,176.4
X$20385 13300 12068 13394 112 113 13467 MUX2_X1
* cell instance $20387 m0 *1 185.06,176.4
X$20387 11437 11861 16538 113 112 13270 HA_X1
* cell instance $20388 m0 *1 186.96,176.4
X$20388 13270 112 113 12414 BUF_X2
* cell instance $20395 r0 *1 180.12,176.4
X$20395 112 11431 113 13471 BUF_X8
* cell instance $20396 r0 *1 182.59,176.4
X$20396 13395 12215 13467 112 113 12423 MUX2_X1
* cell instance $20397 r0 *1 183.92,176.4
X$20397 12711 113 11448 112 BUF_X4
* cell instance $20398 r0 *1 185.25,176.4
X$20398 12414 112 113 13533 BUF_X2
* cell instance $20400 r0 *1 186.2,176.4
X$20400 112 12627 11012 11780 11784 113 AOI21_X4
* cell instance $20401 r0 *1 188.67,176.4
X$20401 112 12711 11861 113 BUF_X32
* cell instance $20402 m0 *1 194.37,176.4
X$20402 112 16833 13102 13653 13184 113 DFF_X1
* cell instance $20403 m0 *1 192.66,176.4
X$20403 9326 13362 113 13276 112 XOR2_X2
* cell instance $20405 m0 *1 198.36,176.4
X$20405 112 16838 13271 13390 13184 113 DFF_X1
* cell instance $20406 m0 *1 201.59,176.4
X$20406 112 11790 113 11460 BUF_X8
* cell instance $20407 m0 *1 204.06,176.4
X$20407 112 11338 113 12350 BUF_X8
* cell instance $20408 m0 *1 206.53,176.4
X$20408 112 11313 113 11353 BUF_X8
* cell instance $20409 m0 *1 209,176.4
X$20409 13363 113 12683 112 BUF_X4
* cell instance $20410 m0 *1 210.33,176.4
X$20410 11966 113 11022 112 BUF_X4
* cell instance $20411 m0 *1 211.66,176.4
X$20411 13295 113 13125 112 BUF_X4
* cell instance $20412 m0 *1 212.99,176.4
X$20412 10853 12683 112 113 13364 NOR2_X1
* cell instance $20413 m0 *1 213.56,176.4
X$20413 13365 12366 13364 13366 10492 11337 112 113 OAI221_X2
* cell instance $20415 r0 *1 197.98,176.4
X$20415 13184 112 113 17170 INV_X2
* cell instance $20417 r0 *1 198.93,176.4
X$20417 9323 13579 113 13388 112 XOR2_X2
* cell instance $20420 r0 *1 204.06,176.4
X$20420 12350 113 11147 112 BUF_X4
* cell instance $20422 r0 *1 205.77,176.4
X$20422 10853 113 11649 112 BUF_X4
* cell instance $20423 r0 *1 207.1,176.4
X$20423 11313 13448 16608 113 112 11966 HA_X1
* cell instance $20424 r0 *1 209,176.4
X$20424 11346 112 113 11484 INV_X2
* cell instance $20425 r0 *1 209.57,176.4
X$20425 11157 13448 13103 113 112 13449 HA_X1
* cell instance $20426 r0 *1 211.47,176.4
X$20426 10853 113 10864 112 BUF_X4
* cell instance $20427 r0 *1 212.8,176.4
X$20427 12266 113 11038 112 BUF_X4
* cell instance $20428 r0 *1 214.13,176.4
X$20428 13016 112 113 11624 INV_X4
* cell instance $20429 r0 *1 215.08,176.4
X$20429 11624 11038 11309 113 13366 112 OAI21_X1
* cell instance $20431 m0 *1 217.36,176.4
X$20431 12984 10864 11960 113 12982 112 OAI21_X1
* cell instance $20432 m0 *1 216.03,176.4
X$20432 13289 11303 13384 112 113 13367 MUX2_X1
* cell instance $20433 m0 *1 218.12,176.4
X$20433 13368 12508 10594 113 12776 112 OAI21_X1
* cell instance $20435 m0 *1 219.07,176.4
X$20435 12229 11330 112 11628 113 NAND2_X4
* cell instance $20436 m0 *1 220.78,176.4
X$20436 12266 11628 13379 112 113 NOR2_X4
* cell instance $20437 m0 *1 222.49,176.4
X$20437 11305 13379 13272 112 113 NOR2_X4
* cell instance $20438 m0 *1 224.2,176.4
X$20438 11330 11960 13368 112 113 13373 MUX2_X1
* cell instance $20439 m0 *1 225.53,176.4
X$20439 11960 113 11309 112 BUF_X4
* cell instance $20440 m0 *1 226.86,176.4
X$20440 11638 13369 12088 12253 11314 113 112 13376 OAI221_X1
* cell instance $20441 m0 *1 228,176.4
X$20441 12089 12508 112 113 13369 NOR2_X1
* cell instance $20443 r0 *1 216.22,176.4
X$20443 13450 11622 12237 13367 10737 13186 113 112 AOI221_X2
* cell instance $20444 r0 *1 218.31,176.4
X$20444 13286 13451 10626 113 13187 112 OAI21_X1
* cell instance $20446 r0 *1 219.45,176.4
X$20446 13463 13272 113 13008 112 AND2_X4
* cell instance $20447 r0 *1 221.16,176.4
X$20447 11029 11624 112 113 13463 NAND2_X1
* cell instance $20448 r0 *1 221.73,176.4
X$20448 13452 113 12985 112 BUF_X4
* cell instance $20449 r0 *1 223.06,176.4
X$20449 11638 13453 12102 11314 113 112 13274 OAI22_X1
* cell instance $20450 r0 *1 224.01,176.4
X$20450 13281 13376 10489 112 113 12986 NAND3_X1
* cell instance $20452 r0 *1 224.96,176.4
X$20452 10864 113 11638 112 BUF_X4
* cell instance $20453 r0 *1 226.29,176.4
X$20453 12237 10737 112 113 12088 NOR2_X2
* cell instance $20454 r0 *1 227.24,176.4
X$20454 12253 11038 11309 113 13514 112 OAI21_X1
* cell instance $20455 r0 *1 228,176.4
X$20455 13016 112 113 11175 BUF_X1
* cell instance $20457 m0 *1 229.71,176.4
X$20457 13275 11030 13373 112 113 13192 MUX2_X1
* cell instance $20458 m0 *1 228.95,176.4
X$20458 12245 11309 10910 113 13275 112 OAI21_X1
* cell instance $20464 r0 *1 230.28,176.4
X$20464 112 12102 113 12510 BUF_X8
* cell instance $20466 r0 *1 234.27,176.4
X$20466 112 17129 10866 13388 12247 113 DFF_X1
* cell instance $20482 m0 *1 34.01,170.8
X$20482 10401 10450 16562 113 112 11258 HA_X1
* cell instance $20491 r0 *1 13.87,170.8
X$20491 12248 112 113 13060 BUF_X1
* cell instance $20499 r0 *1 35.53,170.8
X$20499 12583 10314 16669 113 112 12643 HA_X1
* cell instance $20500 m0 *1 36.48,170.8
X$20500 11479 10802 11393 10457 12948 112 113 OAI211_X2
* cell instance $20502 m0 *1 38.19,170.8
X$20502 11944 10452 112 113 12848 NOR2_X1
* cell instance $20503 m0 *1 38.76,170.8
X$20503 12848 12303 112 113 12731 NAND2_X1
* cell instance $20505 m0 *1 39.52,170.8
X$20505 12848 10969 11479 113 12849 112 OAI21_X1
* cell instance $20507 r0 *1 37.43,170.8
X$20507 11258 112 113 11328 CLKBUF_X2
* cell instance $20508 r0 *1 38.19,170.8
X$20508 12303 12643 13061 112 113 12995 NOR3_X1
* cell instance $20510 r0 *1 39.33,170.8
X$20510 11334 112 113 12992 INV_X1
* cell instance $20511 r0 *1 39.71,170.8
X$20511 12992 12181 11036 113 13114 112 OAI21_X1
* cell instance $20513 m0 *1 40.85,170.8
X$20513 12732 12649 12896 112 12949 113 AOI21_X2
* cell instance $20515 m0 *1 42.18,170.8
X$20515 10891 12303 11394 113 12850 112 OAI21_X1
* cell instance $20518 m0 *1 43.89,170.8
X$20518 10315 10406 10891 10409 112 113 12950 AOI22_X1
* cell instance $20519 m0 *1 44.84,170.8
X$20519 12899 11724 112 113 12578 NOR2_X1
* cell instance $20520 m0 *1 45.41,170.8
X$20520 12851 12951 12849 112 12899 113 AOI21_X1
* cell instance $20521 m0 *1 46.17,170.8
X$20521 12791 12460 112 113 12660 NAND2_X1
* cell instance $20523 m0 *1 46.93,170.8
X$20523 12581 12372 112 113 12851 NOR2_X1
* cell instance $20524 m0 *1 47.5,170.8
X$20524 12184 12851 11724 12583 12852 113 112 12580 OAI221_X1
* cell instance $20527 m0 *1 49.59,170.8
X$20527 11880 12793 11476 112 12952 113 AOI21_X1
* cell instance $20528 m0 *1 50.35,170.8
X$20528 12952 12460 112 113 12738 NOR2_X1
* cell instance $20530 m0 *1 51.11,170.8
X$20530 12949 10800 12999 13000 10635 12802 113 112 AOI221_X2
* cell instance $20532 r0 *1 40.66,170.8
X$20532 12849 12896 10800 11717 12850 113 112 13150 OAI221_X1
* cell instance $20533 r0 *1 41.8,170.8
X$20533 12107 12576 12995 112 113 13200 OR3_X1
* cell instance $20534 r0 *1 42.75,170.8
X$20534 10797 10684 112 113 11486 NOR2_X2
* cell instance $20535 r0 *1 43.7,170.8
X$20535 10981 10795 10806 112 113 13202 NOR3_X1
* cell instance $20537 r0 *1 44.65,170.8
X$20537 10167 10548 11880 112 113 12951 NAND3_X1
* cell instance $20539 r0 *1 45.6,170.8
X$20539 12180 12577 12460 13062 112 113 13002 AOI22_X1
* cell instance $20542 r0 *1 47.69,170.8
X$20542 10457 11944 10682 9952 10554 13204 113 112 AOI221_X2
* cell instance $20543 r0 *1 49.78,170.8
X$20543 11192 112 113 12460 CLKBUF_X3
* cell instance $20546 r0 *1 51.3,170.8
X$20546 11096 10981 112 113 12999 NAND2_X1
* cell instance $20547 r0 *1 51.87,170.8
X$20547 11060 10806 112 113 12735 NAND2_X1
* cell instance $20548 r0 *1 52.44,170.8
X$20548 13120 12019 10739 113 12382 112 NOR3_X2
* cell instance $20550 m0 *1 53.58,170.8
X$20550 10457 10682 112 113 12853 NOR2_X1
* cell instance $20551 m0 *1 54.34,170.8
X$20551 12853 10639 10404 12581 12856 112 113 13001 AOI221_X1
* cell instance $20555 r0 *1 53.96,170.8
X$20555 10797 12954 12853 112 11826 113 AOI21_X1
* cell instance $20556 r0 *1 54.72,170.8
X$20556 13001 12019 13002 112 13208 113 AOI21_X1
* cell instance $20557 r0 *1 55.48,170.8
X$20557 12372 10988 11878 12904 12258 113 112 13124 OAI221_X1
* cell instance $20558 m0 *1 56.81,170.8
X$20558 12581 11192 112 113 13004 NAND2_X1
* cell instance $20560 m0 *1 57.38,170.8
X$20560 12186 12909 12855 13004 12016 113 112 12956 OAI221_X1
* cell instance $20562 r0 *1 56.62,170.8
X$20562 13117 10450 12955 112 13003 113 AOI21_X1
* cell instance $20565 r0 *1 57.95,170.8
X$20565 13065 13006 11096 112 113 13066 NAND3_X1
* cell instance $20567 m0 *1 59.85,170.8
X$20567 10800 13067 112 113 12914 NAND2_X1
* cell instance $20568 m0 *1 58.9,170.8
X$20568 12855 12912 11880 12586 112 113 12856 AOI22_X1
* cell instance $20569 m0 *1 60.42,170.8
X$20569 12583 12259 12914 113 112 13005 AND3_X1
* cell instance $20572 m0 *1 62.32,170.8
X$20572 11254 112 113 11724 CLKBUF_X3
* cell instance $20575 m0 *1 70.11,170.8
X$20575 12857 13018 16560 113 112 12916 HA_X1
* cell instance $20576 m0 *1 72.01,170.8
X$20576 12263 11973 112 113 12957 NAND2_X1
* cell instance $20581 r0 *1 62.32,170.8
X$20581 12741 13005 11724 10315 13127 113 112 13006 OAI221_X1
* cell instance $20582 r0 *1 63.46,170.8
X$20582 12022 12458 112 113 13127 NAND2_X1
* cell instance $20590 r0 *1 71.44,170.8
X$20590 12916 12957 12958 11973 113 112 12937 OAI22_X2
* cell instance $20591 r0 *1 73.15,170.8
X$20591 12590 12133 12312 112 113 12958 MUX2_X1
* cell instance $20593 m0 *1 73.72,170.8
X$20593 12032 112 113 12865 CLKBUF_X3
* cell instance $20595 m0 *1 75.24,170.8
X$20595 11573 113 12594 112 BUF_X4
* cell instance $20597 m0 *1 76.57,170.8
X$20597 12469 12398 112 113 12858 NAND2_X1
* cell instance $20598 m0 *1 77.14,170.8
X$20598 11665 112 113 13009 CLKBUF_X3
* cell instance $20599 m0 *1 78.09,170.8
X$20599 12860 12673 11732 11844 12861 12813 113 112 AOI221_X2
* cell instance $20601 m0 *1 80.37,170.8
X$20601 11888 13012 11735 12859 113 112 12862 OAI22_X1
* cell instance $20602 m0 *1 81.32,170.8
X$20602 11212 11732 11512 112 13012 113 AOI21_X1
* cell instance $20604 r0 *1 75.24,170.8
X$20604 11735 12594 11844 112 113 13130 MUX2_X1
* cell instance $20605 r0 *1 76.57,170.8
X$20605 12397 12858 12959 11407 12865 13129 112 113 OAI221_X2
* cell instance $20606 r0 *1 78.66,170.8
X$20606 12129 112 113 12543 INV_X8
* cell instance $20607 r0 *1 80.37,170.8
X$20607 12861 12026 13070 112 113 13013 MUX2_X1
* cell instance $20608 r0 *1 81.7,170.8
X$20608 12862 11743 13013 112 12960 113 AOI21_X1
* cell instance $20609 m0 *1 83.79,170.8
X$20609 10334 10655 112 113 12673 OR2_X2
* cell instance $20610 m0 *1 82.46,170.8
X$20610 11885 113 11664 112 BUF_X4
* cell instance $20612 r0 *1 82.46,170.8
X$20612 11573 11515 113 112 13131 AND2_X1
* cell instance $20613 r0 *1 83.22,170.8
X$20613 13132 11263 12960 112 12938 113 AOI21_X1
* cell instance $20614 r0 *1 83.98,170.8
X$20614 11573 11070 11512 112 113 13071 NOR3_X1
* cell instance $20615 r0 *1 84.74,170.8
X$20615 11839 12924 12961 112 12863 113 AOI21_X1
* cell instance $20616 m0 *1 85.88,170.8
X$20616 11209 13018 112 113 12961 NAND2_X1
* cell instance $20617 m0 *1 85.12,170.8
X$20617 12550 11512 12270 113 12924 112 OAI21_X1
* cell instance $20618 m0 *1 86.45,170.8
X$20618 11520 12864 12926 112 12963 113 AOI21_X1
* cell instance $20619 m0 *1 87.21,170.8
X$20619 12550 12597 12865 112 113 12965 NOR3_X1
* cell instance $20620 m0 *1 87.97,170.8
X$20620 12314 12865 12866 112 13020 113 AOI21_X2
* cell instance $20621 m0 *1 89.3,170.8
X$20621 112 12597 13073 10811 10993 113 AOI21_X4
* cell instance $20622 m0 *1 91.77,170.8
X$20622 12395 11408 11261 112 12966 113 AOI21_X1
* cell instance $20624 m0 *1 92.72,170.8
X$20624 10811 10993 12967 112 113 12817 NAND3_X2
* cell instance $20626 r0 *1 85.5,170.8
X$20626 12477 12962 12925 113 13135 112 OAI21_X1
* cell instance $20627 r0 *1 86.26,170.8
X$20627 12965 12857 12964 112 12962 113 AOI21_X1
* cell instance $20628 r0 *1 87.02,170.8
X$20628 11583 11739 12472 112 13072 113 AOI21_X2
* cell instance $20630 r0 *1 88.54,170.8
X$20630 11512 10658 13009 112 12964 113 AOI21_X1
* cell instance $20632 r0 *1 89.49,170.8
X$20632 11212 12195 12959 112 13023 113 AOI21_X1
* cell instance $20634 r0 *1 90.63,170.8
X$20634 12026 11515 12320 11888 13023 113 112 13138 OAI221_X1
* cell instance $20635 r0 *1 91.77,170.8
X$20635 11410 11578 12967 113 12596 112 OAI21_X1
* cell instance $20636 r0 *1 92.53,170.8
X$20636 11410 11578 11360 113 13163 112 OAI21_X1
* cell instance $20647 m0 *1 45.22,56
X$20647 1881 1113 1952 113 2708 112 OAI21_X1
* cell instance $20649 m0 *1 46.17,56
X$20649 2709 2499 2655 2534 113 112 2821 OAI22_X2
* cell instance $20650 m0 *1 47.88,56
X$20650 2657 2718 1639 112 2598 113 AOI21_X2
* cell instance $20651 m0 *1 49.21,56
X$20651 2711 2535 2442 112 113 2656 NOR3_X1
* cell instance $20652 m0 *1 49.97,56
X$20652 1872 2658 2657 1722 2536 112 113 2711 AOI221_X1
* cell instance $20653 m0 *1 51.11,56
X$20653 2713 2660 1871 113 2659 112 OAI21_X1
* cell instance $20656 m0 *1 52.82,56
X$20656 1872 2095 2717 1268 2536 2602 112 113 OAI221_X2
* cell instance $20657 m0 *1 54.91,56
X$20657 112 2718 1572 987 1524 113 AOI21_X4
* cell instance $20658 m0 *1 57.38,56
X$20658 1883 112 113 2162 BUF_X1
* cell instance $20659 m0 *1 57.95,56
X$20659 2539 2154 2774 2222 112 113 2942 AOI22_X1
* cell instance $20660 m0 *1 58.9,56
X$20660 2723 2321 2992 2722 2092 2824 112 113 OAI221_X2
* cell instance $20661 m0 *1 60.99,56
X$20661 1812 2657 1722 112 2722 113 AOI21_X1
* cell instance $20662 m0 *1 61.75,56
X$20662 2537 2538 1519 112 113 2661 NOR3_X1
* cell instance $20663 m0 *1 62.51,56
X$20663 1883 1419 112 113 2723 NAND2_X1
* cell instance $20664 m0 *1 63.08,56
X$20664 1901 1228 2000 112 2538 113 AOI21_X1
* cell instance $20665 m0 *1 63.84,56
X$20665 2663 1268 1521 112 113 2724 NOR3_X1
* cell instance $20666 m0 *1 64.6,56
X$20666 2663 1767 112 113 2445 NAND2_X1
* cell instance $20667 m0 *1 65.17,56
X$20667 1524 1521 112 113 2166 NAND2_X2
* cell instance $20668 m0 *1 66.12,56
X$20668 987 2000 1387 112 2726 113 AOI21_X1
* cell instance $20682 r0 *1 44.27,56
X$20682 2096 2817 113 112 2935 XNOR2_X1
* cell instance $20683 r0 *1 45.41,56
X$20683 1812 936 1113 112 2817 113 AOI21_X1
* cell instance $20684 r0 *1 46.17,56
X$20684 1865 2708 2000 112 2820 113 AOI21_X1
* cell instance $20685 r0 *1 46.93,56
X$20685 2824 2820 2220 113 2655 112 OAI21_X1
* cell instance $20687 r0 *1 47.88,56
X$20687 2442 2716 113 112 2938 AND2_X1
* cell instance $20688 r0 *1 48.64,56
X$20688 2889 1587 2826 2390 112 113 2825 NAND4_X1
* cell instance $20690 r0 *1 49.78,56
X$20690 2658 1781 112 113 2826 NAND2_X1
* cell instance $20691 r0 *1 50.35,56
X$20691 1951 2773 2891 113 2830 112 OAI21_X1
* cell instance $20692 r0 *1 51.11,56
X$20692 2659 2441 2821 1871 113 112 2831 OAI22_X2
* cell instance $20693 r0 *1 52.82,56
X$20693 1387 2775 2776 1881 112 113 2440 AOI22_X1
* cell instance $20695 r0 *1 53.96,56
X$20695 1187 1524 1228 113 2775 112 OAI21_X1
* cell instance $20696 r0 *1 54.72,56
X$20696 1572 1645 1899 112 113 2777 NOR3_X1
* cell instance $20698 r0 *1 55.86,56
X$20698 112 1149 2094 113 BUF_X16
* cell instance $20700 r0 *1 60.99,56
X$20700 2661 2778 2615 112 2779 113 AOI21_X1
* cell instance $20702 r0 *1 61.94,56
X$20702 2780 1386 2662 113 2836 112 OAI21_X1
* cell instance $20703 r0 *1 62.7,56
X$20703 2834 2506 112 113 2662 NOR2_X1
* cell instance $20704 r0 *1 63.27,56
X$20704 1519 1767 2658 112 2781 113 AOI21_X1
* cell instance $20705 r0 *1 64.03,56
X$20705 1813 1721 2663 2094 112 113 2952 AOI22_X2
* cell instance $20707 r0 *1 66.5,56
X$20707 1677 1807 112 113 2782 NAND2_X1
* cell instance $20708 r0 *1 67.07,56
X$20708 1677 1228 113 2717 112 AND2_X4
* cell instance $20710 m0 *1 67.26,56
X$20710 2316 2726 2657 113 2541 112 OAI21_X1
* cell instance $20711 m0 *1 68.21,56
X$20711 2539 2619 2541 1727 1959 2728 113 112 AOI221_X2
* cell instance $20712 m0 *1 70.3,56
X$20712 2663 1483 112 113 2542 NAND2_X1
* cell instance $20713 m0 *1 70.87,56
X$20713 2228 2542 1642 1588 2320 112 113 2620 AOI221_X1
* cell instance $20718 r0 *1 68.78,56
X$20718 2782 1767 112 113 2839 NAND2_X1
* cell instance $20720 r0 *1 69.54,56
X$20720 2173 1517 112 113 2780 NAND2_X1
* cell instance $20721 r0 *1 70.11,56
X$20721 2412 1642 112 113 2940 NAND2_X2
* cell instance $20723 r0 *1 71.44,56
X$20723 1419 2729 2166 2317 1883 113 112 2783 OAI221_X1
* cell instance $20724 m0 *1 72.58,56
X$20724 2073 1268 2729 112 2730 113 AOI21_X2
* cell instance $20726 m0 *1 73.91,56
X$20726 1905 1953 112 113 2539 NOR2_X2
* cell instance $20727 m0 *1 74.86,56
X$20727 1812 2321 2735 2732 112 113 2733 OR4_X1
* cell instance $20728 m0 *1 76,56
X$20728 1483 2173 1646 112 2735 113 AOI21_X1
* cell instance $20731 r0 *1 72.77,56
X$20731 1349 2658 1729 2784 112 113 2840 AOI22_X1
* cell instance $20733 r0 *1 73.91,56
X$20733 2840 2841 2539 2221 112 113 3056 NAND4_X1
* cell instance $20734 r0 *1 74.86,56
X$20734 2834 2417 2733 113 112 2897 AND3_X2
* cell instance $20736 r0 *1 76.19,56
X$20736 2737 1647 112 113 2732 NOR2_X1
* cell instance $20738 m0 *1 77.71,56
X$20738 1648 1729 112 113 2737 NAND2_X1
* cell instance $20739 m0 *1 77.14,56
X$20739 2734 1909 112 113 2448 NOR2_X1
* cell instance $20742 m0 *1 85.12,56
X$20742 793 112 113 1192 CLKBUF_X3
* cell instance $20745 r0 *1 77.52,56
X$20745 112 1648 2324 2231 1881 113 NOR3_X4
* cell instance $20748 m0 *1 87.97,56
X$20748 2544 2545 2546 2743 113 112 2547 OAI22_X1
* cell instance $20749 m0 *1 87.21,56
X$20749 1032 1166 2548 112 1595 113 AOI21_X1
* cell instance $20750 m0 *1 88.92,56
X$20750 2547 1043 1320 112 113 2550 MUX2_X1
* cell instance $20753 r0 *1 89.68,56
X$20753 1693 1615 112 113 2851 NOR2_X1
* cell instance $20755 m0 *1 91.39,56
X$20755 1536 1154 871 112 2549 113 AOI21_X1
* cell instance $20756 m0 *1 90.63,56
X$20756 1200 2633 2549 113 2743 112 OAI21_X1
* cell instance $20758 r0 *1 91.77,56
X$20758 611 576 112 113 2845 NAND2_X1
* cell instance $20760 m0 *1 93.1,56
X$20760 871 793 1007 112 2633 113 AOI21_X1
* cell instance $20761 m0 *1 92.53,56
X$20761 611 2425 112 113 2548 NAND2_X1
* cell instance $20763 m0 *1 95.38,56
X$20763 1192 1166 2548 112 2665 113 AOI21_X1
* cell instance $20764 m0 *1 96.14,56
X$20764 2548 949 112 113 2748 NOR2_X1
* cell instance $20766 r0 *1 92.72,56
X$20766 2425 112 113 2850 BUF_X1
* cell instance $20767 r0 *1 93.29,56
X$20767 1242 1404 112 113 2785 OR2_X1
* cell instance $20769 r0 *1 94.43,56
X$20769 1200 2233 2664 113 2786 112 OAI21_X1
* cell instance $20770 r0 *1 95.19,56
X$20770 2667 2665 1200 113 2664 112 OAI21_X1
* cell instance $20773 m0 *1 97.09,56
X$20773 641 611 617 112 113 2668 MUX2_X1
* cell instance $20776 r0 *1 98.04,56
X$20776 2668 1741 112 113 2853 NAND2_X1
* cell instance $20777 r0 *1 98.61,56
X$20777 1192 2852 2552 113 112 2787 AND3_X1
* cell instance $20778 m0 *1 99.75,56
X$20778 2113 2553 946 2748 112 113 2750 AOI22_X1
* cell instance $20779 m0 *1 98.8,56
X$20779 1192 2553 2747 113 112 2667 AND3_X1
* cell instance $20781 r0 *1 99.56,56
X$20781 2853 2854 1355 112 113 2333 NAND3_X1
* cell instance $20782 r0 *1 100.32,56
X$20782 2900 2788 1501 264 1429 113 112 2854 OAI221_X1
* cell instance $20783 m0 *1 101.27,56
X$20783 2747 2553 949 112 113 2669 NAND3_X1
* cell instance $20785 m0 *1 102.03,56
X$20785 2750 2669 1541 112 113 2751 NAND3_X1
* cell instance $20787 m0 *1 102.98,56
X$20787 611 1200 833 112 113 2856 NAND3_X1
* cell instance $20790 r0 *1 102.22,56
X$20790 2857 2552 2856 112 2753 113 AOI21_X1
* cell instance $20791 r0 *1 102.98,56
X$20791 2454 1355 112 113 2857 NAND2_X1
* cell instance $20794 m0 *1 104.12,56
X$20794 2751 2454 112 113 2115 NAND2_X1
* cell instance $20796 m0 *1 105.64,56
X$20796 2116 1242 2550 112 113 2754 MUX2_X1
* cell instance $20800 m0 *1 114,56
X$20800 1440 2670 2671 530 2089 113 112 AOI211_X2
* cell instance $20803 r0 *1 104.5,56
X$20803 950 112 113 505 INV_X4
* cell instance $20804 r0 *1 105.45,56
X$20804 2555 2556 2753 1541 112 113 2789 NOR4_X1
* cell instance $20808 r0 *1 107.73,56
X$20808 505 113 1043 112 BUF_X4
* cell instance $20810 r0 *1 109.44,56
X$20810 112 17142 3435 2754 3070 113 DFF_X1
* cell instance $20813 r0 *1 113.24,56
X$20813 112 1439 113 2670 BUF_X8
* cell instance $20856 r0 *1 43.89,50.4
X$20856 2217 1112 2265 113 112 2266 HA_X1
* cell instance $20857 m0 *1 46.55,50.4
X$20857 1419 113 2217 112 BUF_X4
* cell instance $20858 m0 *1 45.6,50.4
X$20858 2266 1998 1723 112 113 2216 OR3_X1
* cell instance $20859 m0 *1 47.88,50.4
X$20859 1584 112 113 2092 CLKBUF_X3
* cell instance $20860 m0 *1 48.83,50.4
X$20860 2093 2151 2152 112 2535 113 AOI21_X1
* cell instance $20863 r0 *1 45.79,50.4
X$20863 2216 2093 2092 112 113 2387 NAND3_X1
* cell instance $20865 r0 *1 46.74,50.4
X$20865 1510 2268 2312 2390 1900 2499 113 112 AOI221_X2
* cell instance $20868 r0 *1 49.4,50.4
X$20868 2217 1672 2095 2094 2312 2392 112 113 OAI221_X2
* cell instance $20869 m0 *1 50.92,50.4
X$20869 1476 1146 1417 112 2271 113 AOI21_X1
* cell instance $20874 r0 *1 51.68,50.4
X$20874 1722 2166 2217 2271 112 113 2311 AOI22_X1
* cell instance $20877 m0 *1 52.82,50.4
X$20877 1189 1418 112 113 2095 NAND2_X2
* cell instance $20878 m0 *1 53.96,50.4
X$20878 1954 2097 2159 112 2268 113 AOI21_X1
* cell instance $20880 m0 *1 54.91,50.4
X$20880 2006 1513 2221 113 2160 112 OAI21_X1
* cell instance $20881 m0 *1 55.67,50.4
X$20881 1954 2219 2160 2220 1777 2092 112 113 2161 OAI33_X1
* cell instance $20882 m0 *1 57,50.4
X$20882 2176 112 113 2159 INV_X1
* cell instance $20884 m0 *1 57.57,50.4
X$20884 2096 2098 112 113 2165 NAND2_X1
* cell instance $20885 m0 *1 58.14,50.4
X$20885 1952 2046 2167 2165 1526 113 112 2222 OAI221_X1
* cell instance $20887 m0 *1 59.47,50.4
X$20887 1267 939 112 113 2223 NOR2_X2
* cell instance $20888 m0 *1 60.42,50.4
X$20888 1588 1721 1585 112 2537 113 AOI21_X2
* cell instance $20889 m0 *1 61.75,50.4
X$20889 112 1767 113 936 BUF_X8
* cell instance $20891 r0 *1 52.82,50.4
X$20891 1638 2272 2312 112 2218 113 AOI21_X1
* cell instance $20892 r0 *1 53.58,50.4
X$20892 2273 2092 112 113 2393 NOR2_X1
* cell instance $20894 r0 *1 54.53,50.4
X$20894 1267 112 113 2096 CLKBUF_X3
* cell instance $20895 r0 *1 55.48,50.4
X$20895 2395 1387 2275 112 2272 113 AOI21_X1
* cell instance $20897 r0 *1 56.62,50.4
X$20897 1349 1524 1228 113 2275 112 OAI21_X1
* cell instance $20899 r0 *1 57.57,50.4
X$20899 1902 1144 112 113 2395 NOR2_X1
* cell instance $20902 r0 *1 58.71,50.4
X$20902 1813 2223 1476 113 112 2390 OAI21_X2
* cell instance $20905 r0 *1 60.61,50.4
X$20905 2223 1725 1585 1424 2312 2402 112 113 OAI221_X2
* cell instance $20907 r0 *1 63.46,50.4
X$20907 1585 1721 113 112 2225 AND2_X1
* cell instance $20910 m0 *1 64.6,50.4
X$20910 2172 2064 1584 1901 2225 113 112 2224 OAI221_X1
* cell instance $20911 m0 *1 65.93,50.4
X$20911 2099 1387 112 113 2174 NOR2_X1
* cell instance $20912 m0 *1 66.5,50.4
X$20912 1909 1483 112 113 2226 NAND2_X1
* cell instance $20913 m0 *1 67.07,50.4
X$20913 988 2102 939 112 113 2227 MUX2_X1
* cell instance $20914 m0 *1 68.4,50.4
X$20914 112 1787 2220 2069 2093 2288 113 NOR4_X4
* cell instance $20915 m0 *1 71.82,50.4
X$20915 1589 2102 2173 1268 2009 112 113 2289 AOI221_X1
* cell instance $20916 m0 *1 72.96,50.4
X$20916 1418 1589 112 113 2176 NOR2_X2
* cell instance $20917 m0 *1 73.91,50.4
X$20917 2221 1642 112 113 2291 NOR2_X1
* cell instance $20918 m0 *1 74.48,50.4
X$20918 1075 1483 112 113 2177 NOR2_X2
* cell instance $20919 m0 *1 75.43,50.4
X$20919 1811 1427 2296 112 113 2103 NOR3_X1
* cell instance $20920 m0 *1 76.19,50.4
X$20920 1907 2173 2000 112 113 2178 MUX2_X1
* cell instance $20921 m0 *1 77.52,50.4
X$20921 2178 2104 112 113 2062 NOR2_X1
* cell instance $20926 m0 *1 83.6,50.4
X$20926 2105 474 112 113 2181 NAND2_X1
* cell instance $20927 m0 *1 84.17,50.4
X$20927 992 1154 112 113 2014 NOR2_X1
* cell instance $20928 m0 *1 84.74,50.4
X$20928 2105 2014 112 113 2189 NOR2_X1
* cell instance $20929 m0 *1 85.31,50.4
X$20929 1432 794 1428 112 113 2298 MUX2_X1
* cell instance $20930 m0 *1 86.64,50.4
X$20930 112 1428 113 711 BUF_X8
* cell instance $20931 m0 *1 89.11,50.4
X$20931 1649 868 2106 112 113 2112 MUX2_X1
* cell instance $20932 m0 *1 90.44,50.4
X$20932 366 112 113 1432 INV_X1
* cell instance $20933 m0 *1 90.82,50.4
X$20933 714 112 113 1732 CLKBUF_X3
* cell instance $20936 m0 *1 92.72,50.4
X$20936 2108 262 949 112 2428 113 AOI21_X1
* cell instance $20937 m0 *1 93.48,50.4
X$20937 2108 262 2186 1688 247 2233 113 112 AOI221_X2
* cell instance $20938 m0 *1 95.57,50.4
X$20938 505 868 608 112 113 2234 NAND3_X1
* cell instance $20940 r0 *1 64.98,50.4
X$20940 2098 2285 2224 113 2315 112 OAI21_X1
* cell instance $20941 r0 *1 65.74,50.4
X$20941 1639 2225 113 112 2283 AND2_X1
* cell instance $20942 r0 *1 66.5,50.4
X$20942 2283 2319 2093 113 2281 112 OAI21_X1
* cell instance $20943 r0 *1 67.26,50.4
X$20943 1901 2409 1818 113 2285 112 OAI21_X1
* cell instance $20947 r0 *1 68.02,50.4
X$20947 1813 2227 2226 2174 112 113 2318 AOI22_X1
* cell instance $20948 r0 *1 68.97,50.4
X$20948 1075 1349 1528 112 2228 113 AOI21_X1
* cell instance $20949 r0 *1 69.73,50.4
X$20949 1353 113 1643 112 BUF_X4
* cell instance $20951 r0 *1 71.25,50.4
X$20951 2289 2101 1727 112 113 2413 NOR3_X1
* cell instance $20952 r0 *1 72.01,50.4
X$20952 2099 1145 2102 112 2320 113 AOI21_X1
* cell instance $20953 r0 *1 72.77,50.4
X$20953 2229 2290 1419 112 113 2322 NOR3_X1
* cell instance $20954 r0 *1 73.53,50.4
X$20954 1953 1726 2291 113 2415 112 OAI21_X1
* cell instance $20956 r0 *1 74.48,50.4
X$20956 1188 1791 2323 1642 2295 113 112 2417 OAI221_X1
* cell instance $20957 r0 *1 75.62,50.4
X$20957 1907 1883 112 113 2295 OR2_X1
* cell instance $20960 r0 *1 76.95,50.4
X$20960 2231 2324 1353 113 2099 112 NOR3_X2
* cell instance $20962 r0 *1 78.47,50.4
X$20962 2231 113 1422 112 BUF_X4
* cell instance $20966 r0 *1 83.79,50.4
X$20966 1485 112 113 474 CLKBUF_X3
* cell instance $20969 r0 *1 85.31,50.4
X$20969 576 794 1429 112 113 2420 MUX2_X1
* cell instance $20970 r0 *1 86.64,50.4
X$20970 608 2114 474 1196 2298 113 112 2326 OAI221_X1
* cell instance $20971 r0 *1 87.78,50.4
X$20971 2015 1242 2300 112 2424 113 AOI21_X1
* cell instance $20973 r0 *1 88.92,50.4
X$20973 1649 1200 112 113 2327 NAND2_X1
* cell instance $20975 r0 *1 89.68,50.4
X$20975 366 112 113 2425 BUF_X1
* cell instance $20976 r0 *1 90.25,50.4
X$20976 642 1275 1741 112 113 2328 NAND3_X1
* cell instance $20977 r0 *1 91.01,50.4
X$20977 1741 1398 874 112 2329 113 AOI21_X1
* cell instance $20979 r0 *1 91.96,50.4
X$20979 2108 2301 1536 2107 2232 2330 113 112 AOI221_X2
* cell instance $20981 r0 *1 94.43,50.4
X$20981 1432 1038 2234 113 2301 112 OAI21_X1
* cell instance $20983 r0 *1 95.95,50.4
X$20983 1392 2114 2235 113 2332 112 OAI21_X1
* cell instance $20985 m0 *1 96.71,50.4
X$20985 521 1238 112 113 2235 NAND2_X1
* cell instance $20986 m0 *1 98.04,50.4
X$20986 2189 872 1825 1913 2113 112 113 2236 AOI221_X1
* cell instance $20988 m0 *1 99.37,50.4
X$20988 2110 1199 113 112 2113 AND2_X1
* cell instance $20991 m0 *1 101.08,50.4
X$20991 997 943 112 113 2303 NAND2_X1
* cell instance $20993 m0 *1 101.84,50.4
X$20993 1392 1530 911 112 113 2194 MUX2_X1
* cell instance $20995 m0 *1 103.36,50.4
X$20995 872 2194 2110 1173 112 113 2433 AOI22_X1
* cell instance $20998 r0 *1 98.23,50.4
X$20998 1238 473 1392 1278 113 112 2300 OAI22_X1
* cell instance $20999 r0 *1 99.18,50.4
X$20999 2236 2333 2334 2111 112 113 2429 AOI22_X1
* cell instance $21000 r0 *1 100.13,50.4
X$21000 874 872 1275 112 113 2334 NAND3_X1
* cell instance $21002 r0 *1 101.27,50.4
X$21002 2303 2018 112 113 2527 NAND2_X1
* cell instance $21004 r0 *1 102.03,50.4
X$21004 2303 945 1732 112 113 2435 NAND3_X1
* cell instance $21006 r0 *1 103.17,50.4
X$21006 1196 1275 874 113 112 2335 AND3_X1
* cell instance $21008 r0 *1 104.5,50.4
X$21008 473 1038 112 113 2305 NOR2_X1
* cell instance $21010 m0 *1 104.69,50.4
X$21010 714 1275 1915 112 2237 113 AOI21_X1
* cell instance $21012 r0 *1 105.26,50.4
X$21012 2237 2305 112 113 2432 NOR2_X1
* cell instance $21013 r0 *1 105.83,50.4
X$21013 2198 525 2432 112 113 2338 MUX2_X1
* cell instance $21014 m0 *1 106.02,50.4
X$21014 714 1090 1361 641 2114 113 112 2199 OAI221_X1
* cell instance $21017 m0 *1 107.35,50.4
X$21017 1361 2112 2199 113 2200 112 OAI21_X1
* cell instance $21020 m0 *1 108.68,50.4
X$21020 2200 1830 1887 112 113 2238 MUX2_X1
* cell instance $21025 m0 *1 114.76,50.4
X$21025 112 1996 113 2019 BUF_X8
* cell instance $21029 r0 *1 109.25,50.4
X$21029 1438 1045 2238 112 113 2862 MUX2_X1
* cell instance $21032 r0 *1 114.38,50.4
X$21032 2309 927 652 2239 113 112 2430 OAI22_X1
* cell instance $21033 r0 *1 115.33,50.4
X$21033 572 2019 1919 2239 2117 2339 113 112 AOI221_X2
* cell instance $21034 r0 *1 117.42,50.4
X$21034 2240 722 2239 112 2340 113 AOI21_X1
* cell instance $21035 m0 *1 117.8,50.4
X$21035 112 1749 2019 1896 1831 113 AOI21_X4
* cell instance $21037 m0 *1 120.27,50.4
X$21037 722 112 113 2118 BUF_X1
* cell instance $21039 r0 *1 118.18,50.4
X$21039 1896 1831 112 113 2239 NAND2_X2
* cell instance $21041 r0 *1 119.51,50.4
X$21041 880 113 635 112 BUF_X4
* cell instance $21042 r0 *1 120.84,50.4
X$21042 2342 635 1415 112 2341 113 AOI21_X1
* cell instance $21043 m0 *1 121.41,50.4
X$21043 657 2205 2118 705 112 113 2241 AOI22_X1
* cell instance $21046 m0 *1 123.12,50.4
X$21046 1364 529 1449 113 2205 112 OAI21_X1
* cell instance $21048 m0 *1 124.07,50.4
X$21048 1627 1027 112 113 2242 NOR2_X1
* cell instance $21049 m0 *1 124.64,50.4
X$21049 657 1282 845 112 2243 113 AOI21_X1
* cell instance $21050 m0 *1 125.4,50.4
X$21050 585 1440 805 113 112 1449 OAI21_X4
* cell instance $21053 r0 *1 121.79,50.4
X$21053 952 2241 112 113 2343 OR2_X1
* cell instance $21054 r0 *1 122.55,50.4
X$21054 1749 1922 2021 1653 2308 113 112 AOI211_X2
* cell instance $21058 r0 *1 124.26,50.4
X$21058 1748 1504 112 113 2344 NAND2_X1
* cell instance $21060 r0 *1 125.21,50.4
X$21060 2243 2308 1290 112 113 2307 NOR3_X1
* cell instance $21061 r0 *1 125.97,50.4
X$21061 2304 1183 2307 2119 113 2421 112 OR4_X2
* cell instance $21063 r0 *1 127.68,50.4
X$21063 1983 2346 959 589 112 113 2304 NOR4_X1
* cell instance $21064 m0 *1 129.01,50.4
X$21064 1844 2211 2121 1443 2213 112 113 2120 AOI221_X1
* cell instance $21065 m0 *1 128.25,50.4
X$21065 530 584 2210 113 2213 112 OAI21_X1
* cell instance $21066 m0 *1 130.15,50.4
X$21066 2120 1835 1409 112 113 2122 NOR3_X1
* cell instance $21068 m0 *1 131.67,50.4
X$21068 1660 2127 2121 1749 2302 113 112 2080 OAI221_X1
* cell instance $21069 m0 *1 132.81,50.4
X$21069 112 848 728 1126 2347 1996 113 OAI211_X4
* cell instance $21070 m0 *1 136.04,50.4
X$21070 2122 2124 1292 1560 112 113 2209 NOR4_X1
* cell instance $21073 r0 *1 129.01,50.4
X$21073 585 529 1922 113 2423 112 OAI21_X1
* cell instance $21077 r0 *1 130.53,50.4
X$21077 1922 1210 112 113 2302 OR2_X1
* cell instance $21079 r0 *1 132.05,50.4
X$21079 854 805 2118 112 113 2247 NOR3_X1
* cell instance $21080 r0 *1 132.81,50.4
X$21080 1996 854 805 113 112 2208 OAI21_X2
* cell instance $21083 r0 *1 136.04,50.4
X$21083 587 635 572 113 2348 112 OAI21_X1
* cell instance $21084 r0 *1 136.8,50.4
X$21084 1994 1627 2245 2459 2126 1346 112 113 2246 OAI33_X1
* cell instance $21086 m0 *1 137.37,50.4
X$21086 1713 2208 112 113 2212 NAND2_X1
* cell instance $21088 r0 *1 138.13,50.4
X$21088 2209 2246 2299 112 113 2350 OR3_X2
* cell instance $21089 r0 *1 139.27,50.4
X$21089 1788 2076 113 112 2351 AND2_X1
* cell instance $21091 m0 *1 139.84,50.4
X$21091 728 848 587 112 113 1713 NAND3_X1
* cell instance $21093 m0 *1 141.55,50.4
X$21093 1259 1443 112 113 2127 NOR2_X1
* cell instance $21096 m0 *1 143.83,50.4
X$21096 2127 2297 736 112 113 2203 NOR3_X1
* cell instance $21097 m0 *1 144.59,50.4
X$21097 1290 2128 2129 1975 2203 858 112 113 2130 OAI33_X1
* cell instance $21098 m0 *1 145.92,50.4
X$21098 587 728 848 112 1839 113 AOI21_X2
* cell instance $21099 m0 *1 147.25,50.4
X$21099 734 112 113 1018 CLKBUF_X3
* cell instance $21104 m0 *1 161.31,50.4
X$21104 2360 2355 16531 113 112 2293 HA_X1
* cell instance $21106 m0 *1 166.25,50.4
X$21106 1460 112 113 2191 INV_X1
* cell instance $21110 r0 *1 140.22,50.4
X$21110 1560 2121 112 113 1627 NAND2_X2
* cell instance $21111 r0 *1 141.17,50.4
X$21111 1449 845 663 112 113 2526 NAND3_X1
* cell instance $21113 r0 *1 142.31,50.4
X$21113 2127 2247 112 113 2414 NOR2_X1
* cell instance $21114 r0 *1 142.88,50.4
X$21114 528 112 113 1409 CLKBUF_X3
* cell instance $21115 r0 *1 143.83,50.4
X$21115 593 587 112 113 2297 NOR2_X1
* cell instance $21116 r0 *1 144.4,50.4
X$21116 2247 1839 1445 113 1788 112 OAI21_X1
* cell instance $21118 r0 *1 145.54,50.4
X$21118 2414 959 663 112 113 2131 NOR3_X1
* cell instance $21121 r0 *1 146.87,50.4
X$21121 1210 1839 632 113 2353 112 OAI21_X1
* cell instance $21123 r0 *1 153.71,50.4
X$21123 2354 2408 16633 113 112 2356 HA_X1
* cell instance $21127 r0 *1 160.55,50.4
X$21127 2357 2360 16704 113 112 2468 HA_X1
* cell instance $21131 r0 *1 163.78,50.4
X$21131 2293 113 2410 112 BUF_X4
* cell instance $21134 m0 *1 170.05,50.4
X$21134 565 113 329 112 BUF_X4
* cell instance $21136 m0 *1 173.09,50.4
X$21136 1669 566 1936 112 2029 113 AOI21_X2
* cell instance $21137 m0 *1 174.42,50.4
X$21137 2029 2134 1376 774 2292 2183 113 112 AOI221_X2
* cell instance $21138 m0 *1 176.51,50.4
X$21138 565 1064 2179 358 2135 2184 112 113 OAI221_X2
* cell instance $21139 m0 *1 178.6,50.4
X$21139 893 1667 1140 112 113 2179 MUX2_X1
* cell instance $21141 m0 *1 180.12,50.4
X$21141 1140 112 113 565 INV_X4
* cell instance $21142 m0 *1 181.07,50.4
X$21142 1936 984 565 112 676 113 AOI21_X2
* cell instance $21143 m0 *1 182.4,50.4
X$21143 2510 112 113 984 INV_X8
* cell instance $21144 m0 *1 184.11,50.4
X$21144 2175 113 1462 112 BUF_X4
* cell instance $21145 m0 *1 185.44,50.4
X$21145 1669 2136 112 113 2031 NAND2_X2
* cell instance $21146 m0 *1 186.39,50.4
X$21146 1462 1936 112 113 826 XNOR2_X2
* cell instance $21147 m0 *1 188.29,50.4
X$21147 1462 113 358 112 BUF_X4
* cell instance $21148 m0 *1 189.62,50.4
X$21148 1140 113 241 112 BUF_X4
* cell instance $21155 r0 *1 175.56,50.4
X$21155 1674 357 1936 112 2292 113 AOI21_X1
* cell instance $21157 r0 *1 177.08,50.4
X$21157 1669 1759 112 113 2361 NOR2_X1
* cell instance $21158 r0 *1 177.65,50.4
X$21158 1933 1303 2361 112 2135 113 AOI21_X1
* cell instance $21160 r0 *1 179.93,50.4
X$21160 2175 112 113 1935 BUF_X1
* cell instance $21164 r0 *1 180.5,50.4
X$21164 329 387 16676 113 112 2362 HA_X1
* cell instance $21167 r0 *1 183.35,50.4
X$21167 241 387 2364 113 112 2286 HA_X1
* cell instance $21168 r0 *1 185.25,50.4
X$21168 2286 112 113 818 CLKBUF_X3
* cell instance $21170 r0 *1 186.39,50.4
X$21170 112 1854 1855 2368 2509 1302 113 NAND4_X4
* cell instance $21171 r0 *1 189.81,50.4
X$21171 1936 113 1303 112 BUF_X4
* cell instance $21173 r0 *1 191.9,50.4
X$21173 329 387 16692 113 112 2284 HA_X1
* cell instance $21174 m0 *1 193.04,50.4
X$21174 2284 112 113 893 CLKBUF_X3
* cell instance $21176 m0 *1 193.99,50.4
X$21176 112 984 238 113 BUF_X32
* cell instance $21179 m0 *1 204.25,50.4
X$21179 112 2282 113 1945 BUF_X8
* cell instance $21180 m0 *1 206.72,50.4
X$21180 112 2037 1939 2039 2153 113 NOR3_X4
* cell instance $21181 m0 *1 209.38,50.4
X$21181 2037 2280 2164 112 113 NOR2_X4
* cell instance $21182 m0 *1 211.09,50.4
X$21182 1945 1948 112 113 2279 NOR2_X1
* cell instance $21184 m0 *1 211.85,50.4
X$21184 112 2138 1939 2039 2398 113 NOR3_X4
* cell instance $21185 m0 *1 214.51,50.4
X$21185 1766 113 2276 112 BUF_X4
* cell instance $21186 m0 *1 215.84,50.4
X$21186 2262 2142 2139 2254 1940 113 112 2140 OAI221_X1
* cell instance $21187 m0 *1 216.98,50.4
X$21187 112 1939 2143 2039 2274 113 NOR3_X4
* cell instance $21189 m0 *1 221.16,50.4
X$21189 2156 112 113 2146 CLKBUF_X3
* cell instance $21190 m0 *1 222.11,50.4
X$21190 112 2492 113 2038 BUF_X8
* cell instance $21191 m0 *1 224.58,50.4
X$21191 1860 2264 113 112 2144 XNOR2_X1
* cell instance $21192 m0 *1 225.72,50.4
X$21192 2141 2145 2045 113 2149 112 OAI21_X1
* cell instance $21193 m0 *1 226.48,50.4
X$21193 2144 2146 2149 112 113 2263 MUX2_X1
* cell instance $21194 m0 *1 227.81,50.4
X$21194 2147 113 2145 112 BUF_X4
* cell instance $21195 m0 *1 229.14,50.4
X$21195 1937 2040 112 113 2261 NAND2_X1
* cell instance $21202 r0 *1 199.88,50.4
X$21202 112 2147 113 2252 BUF_X8
* cell instance $21205 r0 *1 203.49,50.4
X$21205 1938 113 2369 112 BUF_X4
* cell instance $21206 r0 *1 204.82,50.4
X$21206 2248 113 2255 112 BUF_X4
* cell instance $21207 r0 *1 206.15,50.4
X$21207 2147 2248 2249 112 113 2277 MUX2_X1
* cell instance $21209 r0 *1 207.67,50.4
X$21209 1948 2250 112 2621 113 OR2_X4
* cell instance $21210 r0 *1 209.38,50.4
X$21210 2250 112 113 2280 BUF_X2
* cell instance $21211 r0 *1 210.14,50.4
X$21211 2252 2279 2480 1766 2398 2399 113 112 AOI221_X2
* cell instance $21213 r0 *1 212.99,50.4
X$21213 1857 112 113 2163 BUF_X2
* cell instance $21214 r0 *1 213.75,50.4
X$21214 2157 1864 2252 113 112 2487 OAI21_X2
* cell instance $21215 r0 *1 215.08,50.4
X$21215 2376 2040 2277 112 113 2254 MUX2_X1
* cell instance $21216 r0 *1 216.41,50.4
X$21216 2381 2255 112 113 2372 NOR2_X2
* cell instance $21217 r0 *1 217.36,50.4
X$21217 2255 113 2251 112 BUF_X4
* cell instance $21218 r0 *1 218.69,50.4
X$21218 2040 2145 2256 113 2373 112 OAI21_X1
* cell instance $21219 r0 *1 219.45,50.4
X$21219 2374 2377 2257 1863 2375 113 112 AOI211_X2
* cell instance $21220 r0 *1 221.16,50.4
X$21220 1863 2377 2257 112 113 2378 NAND3_X1
* cell instance $21221 r0 *1 221.92,50.4
X$21221 2141 112 113 2258 INV_X2
* cell instance $21222 r0 *1 222.49,50.4
X$21222 2260 2379 112 113 2391 NAND2_X1
* cell instance $21224 r0 *1 223.25,50.4
X$21224 2153 1937 2260 112 2269 113 AOI21_X1
* cell instance $21225 r0 *1 224.01,50.4
X$21225 2269 1861 112 113 2389 NOR2_X1
* cell instance $21227 r0 *1 225.34,50.4
X$21227 2260 2251 1940 2259 112 113 2267 NAND4_X1
* cell instance $21228 r0 *1 226.29,50.4
X$21228 2261 2496 2267 113 2388 112 OAI21_X1
* cell instance $21229 r0 *1 227.05,50.4
X$21229 2261 2145 112 113 2380 NOR2_X1
* cell instance $21231 r0 *1 227.81,50.4
X$21231 2263 2262 2383 112 113 2385 MUX2_X1
* cell instance $21233 r0 *1 229.9,50.4
X$21233 2264 113 2381 112 BUF_X4
* cell instance $21263 r0 *1 44.27,53.2
X$21263 2265 1898 2437 112 113 2599 MUX2_X1
* cell instance $21264 m0 *1 45.03,53.2
X$21264 1521 2000 1723 1589 1387 2386 112 113 OAI221_X2
* cell instance $21267 m0 *1 47.31,53.2
X$21267 2310 1639 1767 112 113 2437 MUX2_X1
* cell instance $21270 m0 *1 49.59,53.2
X$21270 1188 1872 112 113 2500 NOR2_X1
* cell instance $21272 r0 *1 45.6,53.2
X$21272 2386 2598 2098 2312 2600 2534 113 112 AOI221_X2
* cell instance $21273 r0 *1 47.69,53.2
X$21273 2096 2500 2439 988 113 112 2600 OAI22_X2
* cell instance $21274 r0 *1 49.4,53.2
X$21274 1812 2500 1417 113 2438 112 OAI21_X1
* cell instance $21276 r0 *1 50.35,53.2
X$21276 1808 2438 2312 1638 2440 112 113 2713 AOI221_X1
* cell instance $21277 m0 *1 50.73,53.2
X$21277 1589 112 113 2310 INV_X1
* cell instance $21279 m0 *1 51.11,53.2
X$21279 2281 2218 2220 2392 2393 2441 113 112 AOI221_X2
* cell instance $21280 m0 *1 53.2,53.2
X$21280 2290 1588 112 113 2501 NOR2_X1
* cell instance $21281 m0 *1 53.77,53.2
X$21281 1524 1517 112 113 2313 NOR2_X1
* cell instance $21282 m0 *1 54.34,53.2
X$21282 1417 2501 1387 2313 112 113 2314 AOI22_X1
* cell instance $21284 m0 *1 55.48,53.2
X$21284 2314 1781 112 113 2219 NOR2_X1
* cell instance $21285 m0 *1 56.05,53.2
X$21285 2400 2006 112 113 2502 NOR2_X1
* cell instance $21286 m0 *1 56.62,53.2
X$21286 1875 1417 112 113 2400 NOR2_X1
* cell instance $21289 r0 *1 51.87,53.2
X$21289 1865 2311 2402 113 2716 112 OAI21_X1
* cell instance $21290 r0 *1 52.63,53.2
X$21290 2418 1953 2602 112 113 2604 MUX2_X1
* cell instance $21291 r0 *1 53.96,53.2
X$21291 2442 2604 2605 2502 1571 2606 113 112 AOI221_X2
* cell instance $21293 r0 *1 56.43,53.2
X$21293 2442 2599 2443 113 2608 112 OAI21_X1
* cell instance $21294 r0 *1 57.19,53.2
X$21294 2944 2395 2442 113 2443 112 OAI21_X1
* cell instance $21295 m0 *1 58.52,53.2
X$21295 1907 1422 1423 113 112 2439 OAI21_X4
* cell instance $21296 m0 *1 57.57,53.2
X$21296 1902 112 113 2317 CLKBUF_X3
* cell instance $21297 m0 *1 60.99,53.2
X$21297 2223 1899 1115 113 2615 112 OAI21_X1
* cell instance $21299 r0 *1 57.95,53.2
X$21299 2609 2221 112 113 2605 NAND2_X1
* cell instance $21302 r0 *1 59.09,53.2
X$21302 1422 1423 988 113 2892 112 OAI21_X1
* cell instance $21303 r0 *1 59.85,53.2
X$21303 1115 2439 2506 113 2612 112 OAI21_X1
* cell instance $21304 r0 *1 60.61,53.2
X$21304 2537 2612 1875 2321 1584 2611 112 113 OAI221_X2
* cell instance $21305 m0 *1 63.08,53.2
X$21305 112 2446 1907 1587 936 2310 2439 2444 113 OAI222_X2
* cell instance $21306 m0 *1 62.13,53.2
X$21306 1647 2290 112 113 1579 NOR2_X2
* cell instance $21307 m0 *1 65.74,53.2
X$21307 2444 1905 2100 112 113 2406 MUX2_X1
* cell instance $21308 m0 *1 67.07,53.2
X$21308 2445 1579 2317 112 113 2316 NAND3_X1
* cell instance $21309 m0 *1 67.83,53.2
X$21309 1314 2099 112 113 2409 OR2_X1
* cell instance $21310 m0 *1 68.59,53.2
X$21310 1677 1188 112 113 2319 NOR2_X1
* cell instance $21311 m0 *1 69.16,53.2
X$21311 1909 2296 1427 112 2446 113 AOI21_X1
* cell instance $21312 m0 *1 69.92,53.2
X$21312 2226 1907 2412 1643 1524 2273 113 112 AOI221_X2
* cell instance $21313 m0 *1 72.01,53.2
X$21313 1589 1189 1587 113 2729 112 OAI21_X1
* cell instance $21314 m0 *1 72.77,53.2
X$21314 2230 2322 2415 112 113 2447 OR3_X1
* cell instance $21315 m0 *1 73.72,53.2
X$21315 2506 1267 112 113 2323 NOR2_X1
* cell instance $21316 m0 *1 74.29,53.2
X$21316 938 1313 1187 2102 112 113 2229 AOI22_X1
* cell instance $21318 r0 *1 62.7,53.2
X$21318 112 1572 1311 1271 1191 113 AOI21_X4
* cell instance $21319 r0 *1 65.17,53.2
X$21319 1767 2540 1579 2317 988 113 112 2609 OAI221_X1
* cell instance $21321 r0 *1 66.69,53.2
X$21321 1587 2000 1588 112 113 2540 NAND3_X1
* cell instance $21322 r0 *1 67.45,53.2
X$21322 1813 2409 2540 113 2619 112 OAI21_X1
* cell instance $21327 r0 *1 68.59,53.2
X$21327 2620 2442 2318 112 2504 113 AOI21_X1
* cell instance $21329 r0 *1 69.54,53.2
X$21329 112 938 2104 113 BUF_X16
* cell instance $21330 r0 *1 74.29,53.2
X$21330 2412 1528 112 113 2321 NAND2_X2
* cell instance $21341 m0 *1 53.58,36.4
X$21341 1350 1187 112 113 1310 NAND2_X1
* cell instance $21343 m0 *1 54.34,36.4
X$21343 1188 1149 112 113 1383 NAND2_X1
* cell instance $21344 m0 *1 54.91,36.4
X$21344 1226 1267 112 113 1472 NOR2_X2
* cell instance $21345 m0 *1 55.86,36.4
X$21345 112 1149 1146 113 BUF_X32
* cell instance $21346 m0 *1 65.17,36.4
X$21346 1189 1226 1074 112 113 1190 OR3_X2
* cell instance $21347 m0 *1 66.31,36.4
X$21347 112 1145 936 113 BUF_X16
* cell instance $21348 m0 *1 71.06,36.4
X$21348 1427 113 1189 112 BUF_X4
* cell instance $21349 m0 *1 72.39,36.4
X$21349 1191 937 1271 112 1228 113 NAND3_X4
* cell instance $21353 m0 *1 79.61,36.4
X$21353 112 611 113 997 BUF_X8
* cell instance $21354 m0 *1 82.08,36.4
X$21354 1394 474 1077 112 1231 113 AOI21_X1
* cell instance $21355 m0 *1 82.84,36.4
X$21355 1231 1192 1150 112 113 1233 MUX2_X1
* cell instance $21356 m0 *1 84.17,36.4
X$21356 840 1233 1235 1194 113 112 1234 OAI22_X2
* cell instance $21357 m0 *1 85.88,36.4
X$21357 1316 840 112 113 1235 NAND2_X1
* cell instance $21359 m0 *1 87.21,36.4
X$21359 1118 1033 1237 112 113 1236 MUX2_X1
* cell instance $21362 m0 *1 89.49,36.4
X$21362 943 643 642 291 1238 113 112 1159 OAI221_X1
* cell instance $21363 m0 *1 90.63,36.4
X$21363 268 576 112 113 1275 NAND2_X2
* cell instance $21365 m0 *1 92.34,36.4
X$21365 944 992 112 113 1276 NAND2_X1
* cell instance $21381 r0 *1 49.59,36.4
X$21381 112 936 1112 113 BUF_X32
* cell instance $21382 r0 *1 58.9,36.4
X$21382 1189 113 1266 112 BUF_X4
* cell instance $21384 r0 *1 60.61,36.4
X$21384 1030 1267 1226 112 113 1386 MUX2_X1
* cell instance $21385 r0 *1 61.94,36.4
X$21385 1268 939 112 113 1424 NOR2_X1
* cell instance $21386 r0 *1 62.51,36.4
X$21386 1312 113 937 112 BUF_X4
* cell instance $21387 r0 *1 63.84,36.4
X$21387 1479 1269 1226 112 113 NOR2_X4
* cell instance $21388 r0 *1 65.55,36.4
X$21388 1313 1270 1268 113 1351 112 NOR3_X2
* cell instance $21390 r0 *1 67.07,36.4
X$21390 112 1270 1269 1272 1390 113 AOI21_X4
* cell instance $21396 r0 *1 70.11,36.4
X$21396 1311 112 113 1269 INV_X8
* cell instance $21397 r0 *1 71.82,36.4
X$21397 112 1314 1311 1271 1191 113 AOI21_X4
* cell instance $21398 r0 *1 74.29,36.4
X$21398 1191 113 1390 112 BUF_X4
* cell instance $21399 r0 *1 75.62,36.4
X$21399 1271 113 1272 112 BUF_X4
* cell instance $21403 r0 *1 81.13,36.4
X$21403 1315 867 361 112 113 1391 MUX2_X1
* cell instance $21406 r0 *1 83.03,36.4
X$21406 361 335 112 113 1354 NAND2_X1
* cell instance $21409 r0 *1 85.31,36.4
X$21409 1356 1273 714 112 1195 113 AOI21_X1
* cell instance $21410 r0 *1 86.07,36.4
X$21410 617 112 113 1273 INV_X1
* cell instance $21412 r0 *1 86.64,36.4
X$21412 867 1273 112 113 1398 NAND2_X1
* cell instance $21414 r0 *1 87.59,36.4
X$21414 713 307 112 113 1166 NAND2_X2
* cell instance $21415 r0 *1 88.54,36.4
X$21415 840 1274 1319 113 1320 112 OAI21_X1
* cell instance $21416 r0 *1 89.3,36.4
X$21416 1192 1159 1321 113 1274 112 OAI21_X1
* cell instance $21417 r0 *1 90.06,36.4
X$21417 1432 264 793 1038 1322 113 112 1321 OAI221_X1
* cell instance $21419 r0 *1 91.58,36.4
X$21419 997 413 112 113 1322 NOR2_X1
* cell instance $21422 r0 *1 92.72,36.4
X$21422 1154 1276 643 112 1404 113 AOI21_X1
* cell instance $21424 m0 *1 93.29,36.4
X$21424 335 1120 1276 112 1197 113 AOI21_X1
* cell instance $21425 m0 *1 94.81,36.4
X$21425 832 949 112 113 1198 NOR2_X1
* cell instance $21430 r0 *1 93.67,36.4
X$21430 1361 1121 1276 113 1405 112 OAI21_X1
* cell instance $21433 r0 *1 95,36.4
X$21433 524 1198 1357 867 1358 113 112 1406 OAI221_X1
* cell instance $21434 r0 *1 96.14,36.4
X$21434 614 840 1406 112 113 1407 MUX2_X1
* cell instance $21436 r0 *1 97.66,36.4
X$21436 470 262 112 113 1277 NAND2_X1
* cell instance $21437 m0 *1 98.23,36.4
X$21437 268 617 112 113 1199 NAND2_X1
* cell instance $21439 m0 *1 98.8,36.4
X$21439 797 1242 1243 112 113 1244 MUX2_X1
* cell instance $21441 m0 *1 100.89,36.4
X$21441 524 867 1199 113 1121 112 OAI21_X1
* cell instance $21443 m0 *1 101.84,36.4
X$21443 1199 946 474 1200 799 113 112 1201 OAI221_X1
* cell instance $21445 m0 *1 103.17,36.4
X$21445 1196 473 113 112 1202 AND2_X1
* cell instance $21446 m0 *1 103.93,36.4
X$21446 578 1038 474 113 1168 112 OAI21_X1
* cell instance $21447 m0 *1 104.69,36.4
X$21447 1121 1196 1203 112 113 1246 MUX2_X1
* cell instance $21449 r0 *1 98.23,36.4
X$21449 946 1277 1275 112 1085 113 AOI21_X1
* cell instance $21450 r0 *1 98.99,36.4
X$21450 1278 247 112 113 1497 NOR2_X1
* cell instance $21453 r0 *1 101.46,36.4
X$21453 608 1278 1361 113 1325 112 OAI21_X1
* cell instance $21455 r0 *1 102.41,36.4
X$21455 1323 1326 1201 113 1280 112 OAI21_X1
* cell instance $21456 r0 *1 103.17,36.4
X$21456 1325 1202 1033 113 1326 112 OAI21_X1
* cell instance $21459 r0 *1 104.88,36.4
X$21459 1275 1277 112 113 1327 NAND2_X1
* cell instance $21460 r0 *1 105.45,36.4
X$21460 1121 523 1327 112 113 1328 MUX2_X1
* cell instance $21461 m0 *1 106.59,36.4
X$21461 1038 112 113 1200 CLKBUF_X3
* cell instance $21464 r0 *1 106.78,36.4
X$21464 949 696 505 1038 1328 1329 113 112 AOI221_X2
* cell instance $21465 m0 *1 108.11,36.4
X$21465 1280 1045 720 112 113 1248 MUX2_X1
* cell instance $21468 r0 *1 108.87,36.4
X$21468 416 263 798 112 113 1362 MUX2_X1
* cell instance $21470 m0 *1 109.82,36.4
X$21470 1248 1043 1234 112 113 1249 MUX2_X1
* cell instance $21473 m0 *1 116.47,36.4
X$21473 572 1124 1204 736 1255 1253 113 112 AOI221_X2
* cell instance $21475 m0 *1 118.75,36.4
X$21475 1283 1253 1047 112 113 1104 NOR3_X1
* cell instance $21476 m0 *1 119.51,36.4
X$21476 1210 1204 657 113 1046 112 OAI21_X1
* cell instance $21477 m0 *1 120.27,36.4
X$21477 112 922 113 1334 BUF_X8
* cell instance $21478 m0 *1 122.74,36.4
X$21478 112 1338 662 1205 1124 1261 730 1101 113 OAI222_X2
* cell instance $21482 r0 *1 110.77,36.4
X$21482 112 17115 1281 1249 227 113 DFF_X1
* cell instance $21485 r0 *1 115.9,36.4
X$21485 662 582 1506 113 112 1261 HA_X1
* cell instance $21487 r0 *1 118.56,36.4
X$21487 707 1332 635 806 1023 112 113 1283 AOI221_X1
* cell instance $21488 r0 *1 119.7,36.4
X$21488 1364 727 1416 113 1332 112 OAI21_X1
* cell instance $21489 r0 *1 120.46,36.4
X$21489 1282 732 112 113 1255 NAND2_X1
* cell instance $21492 r0 *1 121.6,36.4
X$21492 707 1336 1335 113 1415 112 OAI21_X1
* cell instance $21494 r0 *1 122.55,36.4
X$21494 584 1284 727 112 1338 113 AOI21_X1
* cell instance $21497 r0 *1 123.88,36.4
X$21497 1284 529 1282 113 1339 112 OAI21_X1
* cell instance $21501 r0 *1 124.64,36.4
X$21501 1285 1550 776 657 1339 1254 113 112 AOI221_X2
* cell instance $21503 m0 *1 125.78,36.4
X$21503 728 848 802 112 113 1205 NAND3_X2
* cell instance $21504 m0 *1 127.3,36.4
X$21504 728 848 1126 112 113 1050 NAND3_X2
* cell instance $21505 m0 *1 128.63,36.4
X$21505 1261 112 113 1286 INV_X2
* cell instance $21507 m0 *1 129.39,36.4
X$21507 721 1205 806 730 113 112 1264 OAI22_X1
* cell instance $21511 r0 *1 127.87,36.4
X$21511 1050 804 1340 582 1414 1413 112 113 OAI221_X2
* cell instance $21515 m0 *1 130.72,36.4
X$21515 1264 1286 1341 112 1265 113 AOI21_X1
* cell instance $21517 r0 *1 131.1,36.4
X$21517 1050 792 112 113 1341 NAND2_X2
* cell instance $21518 m0 *1 132.05,36.4
X$21518 1262 1051 1132 112 1263 113 AOI21_X1
* cell instance $21520 m0 *1 132.81,36.4
X$21520 1126 927 732 112 1287 113 AOI21_X1
* cell instance $21523 m0 *1 135.28,36.4
X$21523 926 1128 727 112 1342 113 AOI21_X1
* cell instance $21526 m0 *1 136.99,36.4
X$21526 1259 736 112 113 1258 NOR2_X1
* cell instance $21527 m0 *1 137.56,36.4
X$21527 1257 1260 1051 112 113 1346 NOR3_X1
* cell instance $21531 r0 *1 132.24,36.4
X$21531 657 1342 1285 1050 733 113 112 1636 OAI221_X1
* cell instance $21535 r0 *1 134.71,36.4
X$21535 1204 1027 112 113 1186 NOR2_X2
* cell instance $21536 r0 *1 135.66,36.4
X$21536 792 1286 1289 864 1186 1288 112 113 OAI221_X2
* cell instance $21537 r0 *1 137.75,36.4
X$21537 1341 582 112 113 1411 NOR2_X1
* cell instance $21538 r0 *1 138.32,36.4
X$21538 1340 864 814 659 1029 1366 112 113 OAI221_X2
* cell instance $21540 m0 *1 139.46,36.4
X$21540 1348 1018 112 113 1056 NOR2_X1
* cell instance $21543 m0 *1 140.41,36.4
X$21543 1129 1128 953 112 1345 113 AOI21_X1
* cell instance $21544 m0 *1 141.36,36.4
X$21544 1020 861 1208 1058 1104 1095 112 113 1207 OAI33_X1
* cell instance $21545 m0 *1 142.69,36.4
X$21545 591 1128 112 113 1344 NAND2_X1
* cell instance $21547 r0 *1 140.6,36.4
X$21547 1290 1345 1206 1347 1018 113 112 1410 OAI221_X1
* cell instance $21548 r0 *1 141.74,36.4
X$21548 1017 1344 814 112 1343 113 AOI21_X1
* cell instance $21549 r0 *1 142.5,36.4
X$21549 1210 574 112 113 1454 NOR2_X1
* cell instance $21550 r0 *1 143.07,36.4
X$21550 574 112 113 1289 CLKBUF_X3
* cell instance $21551 m0 *1 143.83,36.4
X$21551 1209 632 112 113 1130 NOR2_X1
* cell instance $21554 r0 *1 144.02,36.4
X$21554 1180 1408 1207 112 113 1337 NOR3_X1
* cell instance $21556 m0 *1 144.78,36.4
X$21556 1128 728 848 112 1211 113 AOI21_X2
* cell instance $21557 m0 *1 146.87,36.4
X$21557 1210 1211 112 113 1293 NOR2_X1
* cell instance $21559 m0 *1 148.2,36.4
X$21559 1059 1098 112 113 1251 NOR2_X1
* cell instance $21562 r0 *1 144.97,36.4
X$21562 1254 1409 1291 112 1131 113 AOI21_X1
* cell instance $21564 r0 *1 145.92,36.4
X$21564 736 1293 1259 572 112 113 1291 AOI22_X1
* cell instance $21565 r0 *1 146.87,36.4
X$21565 1369 1289 1293 112 1294 113 AOI21_X1
* cell instance $21567 r0 *1 147.82,36.4
X$21567 1295 1018 1294 112 1208 113 AOI21_X1
* cell instance $21569 r0 *1 148.96,36.4
X$21569 1211 582 1017 112 1297 113 AOI21_X1
* cell instance $21570 m0 *1 149.91,36.4
X$21570 704 1289 662 864 112 113 1212 NAND4_X1
* cell instance $21571 m0 *1 149.15,36.4
X$21571 1250 1252 1292 113 1296 112 OAI21_X1
* cell instance $21572 m0 *1 150.86,36.4
X$21572 810 1212 1176 112 1250 113 AOI21_X1
* cell instance $21577 m0 *1 160.17,36.4
X$21577 1213 1097 441 1298 1096 1371 113 112 AOI221_X2
* cell instance $21578 m0 *1 162.26,36.4
X$21578 1148 1247 441 1241 1403 113 112 AOI211_X2
* cell instance $21579 m0 *1 163.97,36.4
X$21579 440 425 112 113 1247 NAND2_X1
* cell instance $21586 r0 *1 160.93,36.4
X$21586 1333 240 1240 112 113 1401 MUX2_X1
* cell instance $21589 r0 *1 163.21,36.4
X$21589 1372 1298 1133 112 1333 113 AOI21_X1
* cell instance $21590 r0 *1 163.97,36.4
X$21590 785 326 380 681 1299 113 112 1400 OAI221_X1
* cell instance $21591 m0 *1 165.68,36.4
X$21591 677 1214 112 113 1134 NAND2_X1
* cell instance $21592 m0 *1 164.92,36.4
X$21592 1134 1136 113 112 1299 AND2_X1
* cell instance $21593 m0 *1 166.25,36.4
X$21593 677 320 112 113 1298 NAND2_X1
* cell instance $21595 r0 *1 165.11,36.4
X$21595 423 289 112 113 1399 NAND2_X1
* cell instance $21596 r0 *1 165.68,36.4
X$21596 357 862 238 112 113 1331 MUX2_X1
* cell instance $21598 m0 *1 167.77,36.4
X$21598 907 670 506 113 1245 112 OAI21_X1
* cell instance $21599 m0 *1 167.2,36.4
X$21599 1215 478 112 113 1174 NOR2_X1
* cell instance $21602 r0 *1 168.15,36.4
X$21602 506 1331 1397 113 1330 112 OAI21_X1
* cell instance $21603 m0 *1 169.1,36.4
X$21603 1060 544 112 113 817 NOR2_X2
* cell instance $21606 m0 *1 170.81,36.4
X$21606 1217 458 324 113 1216 112 OAI21_X1
* cell instance $21609 r0 *1 169.67,36.4
X$21609 1232 547 112 113 1397 NOR2_X1
* cell instance $21610 r0 *1 170.24,36.4
X$21610 1330 1216 296 281 112 113 1300 NAND4_X1
* cell instance $21612 r0 *1 171.57,36.4
X$21612 1307 566 1218 112 1133 113 AOI21_X2
* cell instance $21613 m0 *1 172.14,36.4
X$21613 1218 777 112 113 482 NAND2_X1
* cell instance $21615 m0 *1 172.71,36.4
X$21615 482 745 113 112 1301 AND2_X1
* cell instance $21617 r0 *1 172.9,36.4
X$21617 1301 506 1302 112 113 321 MUX2_X1
* cell instance $21618 m0 *1 174.42,36.4
X$21618 563 1304 1219 113 1241 112 OAI21_X1
* cell instance $21619 m0 *1 173.85,36.4
X$21619 1303 1163 112 113 745 NAND2_X1
* cell instance $21620 m0 *1 175.18,36.4
X$21620 1222 1066 380 423 1324 113 112 1219 OAI221_X1
* cell instance $21621 m0 *1 176.32,36.4
X$21621 1303 325 112 113 1091 NAND2_X1
* cell instance $21623 m0 *1 177.08,36.4
X$21623 975 600 1220 400 113 112 1240 OAI22_X1
* cell instance $21625 r0 *1 174.23,36.4
X$21625 423 1395 322 112 1217 113 AOI21_X1
* cell instance $21627 r0 *1 175.75,36.4
X$21627 1393 325 295 112 1324 113 AOI21_X1
* cell instance $21629 r0 *1 176.7,36.4
X$21629 1373 1167 681 112 113 1137 NOR3_X1
* cell instance $21631 r0 *1 177.65,36.4
X$21631 112 826 566 1375 1163 838 241 976 113 AOI222_X2
* cell instance $21633 m0 *1 178.41,36.4
X$21633 893 112 113 1220 INV_X1
* cell instance $21634 m0 *1 178.98,36.4
X$21634 980 1220 423 112 772 113 AOI21_X1
* cell instance $21636 m0 *1 179.93,36.4
X$21636 980 1239 907 978 113 112 1221 OAI22_X1
* cell instance $21641 r0 *1 180.31,36.4
X$21641 1317 113 425 112 BUF_X4
* cell instance $21643 m0 *1 181.26,36.4
X$21643 606 1140 112 113 907 NOR2_X2
* cell instance $21644 m0 *1 182.4,36.4
X$21644 1223 1303 112 113 553 XNOR2_X2
* cell instance $21646 r0 *1 181.64,36.4
X$21646 479 426 547 1305 326 113 112 1304 OAI221_X1
* cell instance $21647 r0 *1 182.78,36.4
X$21647 753 478 112 113 1318 NOR2_X1
* cell instance $21648 r0 *1 183.35,36.4
X$21648 479 389 112 113 1389 NAND2_X1
* cell instance $21652 m0 *1 184.68,36.4
X$21652 1229 1464 112 113 982 OR2_X1
* cell instance $21653 r0 *1 185.06,36.4
X$21653 1318 1081 862 113 1306 112 OAI21_X1
* cell instance $21654 r0 *1 185.82,36.4
X$21654 1317 1306 113 112 897 AND2_X1
* cell instance $21656 m0 *1 185.82,36.4
X$21656 973 498 112 113 1222 OR2_X1
* cell instance $21658 m0 *1 187.15,36.4
X$21658 1307 289 112 113 498 NOR2_X2
* cell instance $21660 m0 *1 188.1,36.4
X$21660 1081 973 112 113 1230 NAND2_X1
* cell instance $21661 m0 *1 188.67,36.4
X$21661 1227 1230 1060 497 1067 1148 113 112 AOI221_X2
* cell instance $21662 m0 *1 190.76,36.4
X$21662 1142 1227 283 547 985 112 113 1229 AOI221_X1
* cell instance $21663 m0 *1 191.9,36.4
X$21663 753 1223 112 113 549 NAND2_X2
* cell instance $21665 m0 *1 193.04,36.4
X$21665 1070 630 984 240 112 113 1224 AOI22_X1
* cell instance $21667 m0 *1 194.18,36.4
X$21667 329 1224 549 486 1060 1225 112 113 OAI221_X2
* cell instance $21668 m0 *1 196.27,36.4
X$21668 606 544 112 113 1378 NAND2_X1
* cell instance $21678 r0 *1 187.53,36.4
X$21678 1302 1307 1308 112 113 NOR2_X4
* cell instance $21680 r0 *1 189.43,36.4
X$21680 450 443 358 112 1141 113 AOI21_X2
* cell instance $21681 r0 *1 190.76,36.4
X$21681 1307 984 112 113 903 NAND2_X1
* cell instance $21682 r0 *1 191.33,36.4
X$21682 681 486 1215 113 1382 112 OAI21_X1
* cell instance $21683 r0 *1 192.09,36.4
X$21683 1309 983 112 113 1384 NOR2_X1
* cell instance $21685 r0 *1 193.42,36.4
X$21685 426 497 329 112 113 1380 NAND3_X1
* cell instance $21686 r0 *1 194.18,36.4
X$21686 1225 1143 1381 113 989 112 NOR3_X2
* cell instance $21687 r0 *1 195.51,36.4
X$21687 1309 113 973 112 BUF_X4
* cell instance $21721 r0 *1 45.98,42
X$21721 1425 1387 1767 112 113 1768 MUX2_X1
* cell instance $21722 m0 *1 46.55,42
X$21722 1350 1510 1511 112 1670 113 AOI21_X1
* cell instance $21724 m0 *1 47.31,42
X$21724 1510 1511 1419 112 113 1770 AND3_X4
* cell instance $21727 r0 *1 47.69,42
X$21727 1638 1770 1671 113 112 1869 OAI21_X2
* cell instance $21728 r0 *1 49.02,42
X$21728 1670 1638 112 113 1900 NOR2_X1
* cell instance $21730 m0 *1 49.97,42
X$21730 1512 1511 113 112 1672 AND2_X1
* cell instance $21732 m0 *1 50.73,42
X$21732 1588 1512 1420 112 1673 113 AOI21_X1
* cell instance $21735 r0 *1 50.16,42
X$21735 1673 1584 112 113 1771 NOR2_X1
* cell instance $21737 m0 *1 52.06,42
X$21737 1588 113 1387 112 BUF_X4
* cell instance $21739 m0 *1 53.39,42
X$21739 1268 113 1639 112 BUF_X4
* cell instance $21740 m0 *1 54.72,42
X$21740 1587 1512 1639 112 113 1514 NAND3_X1
* cell instance $21741 m0 *1 55.48,42
X$21741 1572 1515 1514 113 1577 112 OAI21_X1
* cell instance $21742 m0 *1 56.24,42
X$21742 1517 1640 1516 112 1573 113 AOI21_X1
* cell instance $21743 m0 *1 57,42
X$21743 1228 1510 1588 112 113 1576 NAND3_X1
* cell instance $21745 r0 *1 52.25,42
X$21745 1188 1187 112 113 1719 NOR2_X1
* cell instance $21749 r0 *1 54.91,42
X$21749 1418 1421 112 113 1720 NOR2_X2
* cell instance $21750 r0 *1 55.86,42
X$21750 112 1875 1720 939 1811 113 AOI21_X4
* cell instance $21752 m0 *1 58.14,42
X$21752 1573 1641 1575 1577 1579 1676 113 112 AOI221_X2
* cell instance $21753 m0 *1 60.42,42
X$21753 1721 1587 1419 112 113 1518 NAND3_X1
* cell instance $21754 m0 *1 61.18,42
X$21754 1519 1578 1518 112 1575 113 AOI21_X1
* cell instance $21756 m0 *1 62.13,42
X$21756 1642 1517 112 113 1519 NAND2_X1
* cell instance $21757 m0 *1 62.7,42
X$21757 1272 1390 1311 112 113 1585 NAND3_X2
* cell instance $21759 m0 *1 64.22,42
X$21759 1349 1524 1511 113 1477 112 OAI21_X1
* cell instance $21760 m0 *1 64.98,42
X$21760 112 1269 1423 1422 1645 113 NOR3_X4
* cell instance $21761 m0 *1 67.64,42
X$21761 1523 1266 1522 1521 1525 113 112 1680 OAI221_X1
* cell instance $21763 r0 *1 58.33,42
X$21763 1576 1644 1522 112 113 1641 NAND3_X1
* cell instance $21764 r0 *1 59.09,42
X$21764 1589 1422 1423 113 112 1721 OAI21_X4
* cell instance $21765 r0 *1 61.56,42
X$21765 1311 112 113 1781 CLKBUF_X3
* cell instance $21766 r0 *1 62.51,42
X$21766 1188 1643 112 113 1783 NAND2_X1
* cell instance $21767 r0 *1 63.08,42
X$21767 1677 1420 1419 112 113 1644 NAND3_X1
* cell instance $21768 r0 *1 63.84,42
X$21768 112 1782 1479 1272 1390 113 AOI21_X4
* cell instance $21769 r0 *1 66.31,42
X$21769 1075 1269 112 113 1725 NAND2_X2
* cell instance $21770 r0 *1 67.26,42
X$21770 1642 112 113 1638 CLKBUF_X3
* cell instance $21774 r0 *1 68.21,42
X$21774 1268 1646 112 113 1526 NAND2_X1
* cell instance $21775 r0 *1 68.78,42
X$21775 1647 112 113 1522 CLKBUF_X3
* cell instance $21777 m0 *1 69.16,42
X$21777 1390 1646 1272 112 1587 113 NAND3_X4
* cell instance $21778 r0 *1 69.73,42
X$21778 1727 1680 1520 112 1787 113 AOI21_X1
* cell instance $21779 r0 *1 70.49,42
X$21779 1479 1646 1722 112 113 NOR2_X4
* cell instance $21781 m0 *1 72.01,42
X$21781 1646 113 1115 112 BUF_X4
* cell instance $21782 m0 *1 73.53,42
X$21782 1648 113 1075 112 BUF_X4
* cell instance $21783 m0 *1 74.86,42
X$21783 1882 1075 112 113 1527 NAND2_X2
* cell instance $21785 m0 *1 76,42
X$21785 1271 1191 112 1528 113 NAND2_X4
* cell instance $21790 r0 *1 72.96,42
X$21790 1311 1647 1147 112 113 1791 MUX2_X1
* cell instance $21791 r0 *1 74.29,42
X$21791 1647 113 1642 112 BUF_X4
* cell instance $21794 r0 *1 76.19,42
X$21794 1648 1646 1811 112 113 NOR2_X4
* cell instance $21795 r0 *1 77.9,42
X$21795 243 112 113 16725 INV_X4
* cell instance $21798 m0 *1 80.37,42
X$21798 687 113 1392 112 BUF_X4
* cell instance $21800 r0 *1 81.13,42
X$21800 1685 1238 698 112 1687 113 AOI21_X1
* cell instance $21801 r0 *1 81.89,42
X$21801 698 1032 941 112 113 1796 MUX2_X1
* cell instance $21802 m0 *1 82.65,42
X$21802 394 264 1592 113 112 1531 HA_X1
* cell instance $21803 m0 *1 82.08,42
X$21803 868 1592 112 113 1685 NOR2_X1
* cell instance $21805 m0 *1 85.31,42
X$21805 997 993 1429 1688 112 113 1529 AOI22_X1
* cell instance $21806 m0 *1 86.26,42
X$21806 1529 1196 112 113 1594 NOR2_X1
* cell instance $21807 m0 *1 86.83,42
X$21807 1242 1597 1598 113 1690 112 OAI21_X1
* cell instance $21808 m0 *1 87.59,42
X$21808 687 867 519 112 113 1649 MUX2_X1
* cell instance $21809 m0 *1 88.92,42
X$21809 1431 1200 1430 112 1693 113 AOI21_X1
* cell instance $21810 m0 *1 89.68,42
X$21810 1530 687 112 113 1501 NAND2_X2
* cell instance $21812 m0 *1 90.82,42
X$21812 1531 112 113 1601 INV_X1
* cell instance $21813 m0 *1 91.2,42
X$21813 1533 1532 451 1601 714 1323 113 112 AOI221_X2
* cell instance $21816 r0 *1 83.98,42
X$21816 1032 1533 1033 264 307 113 112 1730 OAI221_X1
* cell instance $21817 r0 *1 85.12,42
X$21817 1687 1242 1355 1730 1689 113 112 1316 OAI221_X1
* cell instance $21818 r0 *1 86.26,42
X$21818 1732 1731 113 112 1689 AND2_X1
* cell instance $21820 r0 *1 87.21,42
X$21820 992 519 794 112 113 1731 MUX2_X1
* cell instance $21821 r0 *1 88.54,42
X$21821 608 867 648 112 113 1800 MUX2_X1
* cell instance $21822 r0 *1 89.87,42
X$21822 397 1732 112 113 1734 NOR2_X1
* cell instance $21823 r0 *1 90.44,42
X$21823 309 833 867 112 1735 113 AOI21_X1
* cell instance $21825 r0 *1 91.58,42
X$21825 551 1531 112 113 1737 NOR2_X1
* cell instance $21827 r0 *1 92.53,42
X$21827 1355 1532 1533 112 1710 113 AOI21_X1
* cell instance $21829 r0 *1 93.48,42
X$21829 411 470 247 112 113 1738 MUX2_X1
* cell instance $21830 m0 *1 93.86,42
X$21830 1530 551 112 113 1357 NAND2_X1
* cell instance $21835 r0 *1 95,42
X$21835 519 309 715 112 113 1739 MUX2_X1
* cell instance $21838 m0 *1 96.33,42
X$21838 1605 451 112 113 1702 NOR2_X1
* cell instance $21839 m0 *1 97.66,42
X$21839 451 691 112 113 1704 NAND2_X1
* cell instance $21840 m0 *1 98.23,42
X$21840 1708 1535 1603 112 1707 113 AOI21_X1
* cell instance $21841 m0 *1 98.99,42
X$21841 949 521 1537 1608 793 112 113 1705 AOI221_X1
* cell instance $21842 m0 *1 100.13,42
X$21842 112 411 1538 1279 247 691 1539 1608 113 OAI222_X2
* cell instance $21844 r0 *1 96.52,42
X$21844 1702 1701 1594 1825 112 113 1706 NOR4_X1
* cell instance $21845 r0 *1 97.47,42
X$21845 1704 1913 1199 112 1701 113 AOI21_X1
* cell instance $21847 r0 *1 98.42,42
X$21847 1536 950 112 113 1708 NAND2_X1
* cell instance $21849 r0 *1 99.18,42
X$21849 1707 1705 1803 1706 112 113 1740 OR4_X1
* cell instance $21850 r0 *1 100.32,42
X$21850 307 519 112 113 1805 NAND2_X1
* cell instance $21852 r0 *1 101.27,42
X$21852 867 262 112 113 1539 NAND2_X2
* cell instance $21853 r0 *1 102.22,42
X$21853 305 867 648 112 113 1742 MUX2_X1
* cell instance $21855 m0 *1 103.17,42
X$21855 1612 1732 112 113 1613 NOR2_X1
* cell instance $21856 r0 *1 103.55,42
X$21856 520 719 262 1530 1745 112 113 OAI211_X2
* cell instance $21858 m0 *1 104.31,42
X$21858 1613 1540 1541 1431 113 1712 112 NOR4_X2
* cell instance $21860 m0 *1 106.21,42
X$21860 1712 1617 840 1436 113 1651 112 NOR4_X2
* cell instance $21861 m0 *1 107.92,42
X$21861 641 798 519 112 113 1619 MUX2_X1
* cell instance $21863 m0 *1 115.33,42
X$21863 112 1543 1439 1440 801 113 NOR3_X4
* cell instance $21864 m0 *1 117.99,42
X$21864 801 662 1023 112 1545 113 AOI21_X1
* cell instance $21865 m0 *1 118.75,42
X$21865 1124 1507 1204 1545 113 112 1544 OAI22_X1
* cell instance $21868 r0 *1 106.02,42
X$21868 1501 1277 1200 112 113 1802 NAND3_X1
* cell instance $21871 r0 *1 107.73,42
X$21871 1437 1361 1801 112 113 1746 MUX2_X1
* cell instance $21875 r0 *1 113.81,42
X$21875 112 934 113 1363 BUF_X8
* cell instance $21876 r0 *1 116.28,42
X$21876 112 705 1748 725 724 113 AOI21_X4
* cell instance $21877 r0 *1 118.75,42
X$21877 112 926 1543 1896 1831 113 AOI21_X4
* cell instance $21878 m0 *1 120.27,42
X$21878 725 724 652 112 113 1552 NAND3_X2
* cell instance $21881 m0 *1 121.79,42
X$21881 1544 1546 1027 113 1547 112 OAI21_X1
* cell instance $21883 m0 *1 122.74,42
X$21883 926 953 1284 113 1628 112 OAI21_X1
* cell instance $21884 m0 *1 123.5,42
X$21884 725 724 1543 112 113 1549 NAND3_X2
* cell instance $21886 m0 *1 125.02,42
X$21886 858 1655 1631 959 1442 1658 112 113 1656 OAI33_X1
* cell instance $21887 m0 *1 126.35,42
X$21887 657 1549 1282 112 1658 113 AOI21_X1
* cell instance $21890 r0 *1 121.22,42
X$21890 529 721 1126 1652 801 1797 113 112 AOI221_X2
* cell instance $21891 r0 *1 123.31,42
X$21891 1654 1748 1652 1653 1655 113 112 AOI211_X2
* cell instance $21896 r0 *1 125.21,42
X$21896 1656 1657 1560 113 1798 112 OAI21_X1
* cell instance $21897 r0 *1 125.97,42
X$21897 1748 1716 1653 112 1550 113 AOI21_X1
* cell instance $21900 r0 *1 127.87,42
X$21900 1210 1284 529 112 1753 113 AOI21_X1
* cell instance $21902 m0 *1 129.2,42
X$21902 1632 1548 1551 1127 112 113 1553 NAND4_X1
* cell instance $21904 m0 *1 130.15,42
X$21904 574 1554 1365 112 1717 113 AOI21_X1
* cell instance $21909 r0 *1 130.15,42
X$21909 570 571 529 1716 707 1715 113 112 AOI221_X2
* cell instance $21910 m0 *1 131.48,42
X$21910 1554 707 112 113 1660 NAND2_X1
* cell instance $21912 m0 *1 132.05,42
X$21912 1551 1554 112 113 1629 NAND2_X1
* cell instance $21913 m0 *1 132.62,42
X$21913 959 1636 1290 1556 113 112 1659 OAI22_X1
* cell instance $21918 r0 *1 132.62,42
X$21918 1051 1659 1798 1754 849 112 113 1714 AOI221_X1
* cell instance $21922 r0 *1 135.09,42
X$21922 1715 1654 855 928 112 113 1792 NOR4_X1
* cell instance $21924 m0 *1 136.42,42
X$21924 1259 529 112 113 1505 NOR2_X2
* cell instance $21930 r0 *1 137.94,42
X$21930 1459 1505 1182 113 1755 112 OAI21_X1
* cell instance $21931 r0 *1 138.7,42
X$21931 1714 1054 112 113 1794 OR2_X1
* cell instance $21933 m0 *1 140.22,42
X$21933 928 1634 1633 113 1347 112 OAI21_X1
* cell instance $21945 m0 *1 45.22,44.8
X$21945 1865 1898 1768 112 1868 113 AOI21_X1
* cell instance $21957 m0 *1 46.55,44.8
X$21957 1807 1728 112 113 1671 NOR2_X1
* cell instance $21959 m0 *1 47.12,44.8
X$21959 1869 1810 1865 1871 1718 1769 113 112 AOI221_X2
* cell instance $21960 m0 *1 49.21,44.8
X$21960 1807 1872 1771 1808 1772 1718 112 113 OAI221_X2
* cell instance $21962 m0 *1 51.49,44.8
X$21962 1522 1809 1782 113 1772 112 OAI21_X1
* cell instance $21963 m0 *1 52.25,44.8
X$21963 1812 1719 1723 113 1773 112 OAI21_X1
* cell instance $21965 m0 *1 53.2,44.8
X$21965 1809 1642 112 113 1808 NOR2_X2
* cell instance $21967 m0 *1 54.34,44.8
X$21967 1645 1588 987 1723 2051 113 112 AOI211_X2
* cell instance $21968 m0 *1 56.05,44.8
X$21968 1720 1642 112 113 1640 NOR2_X1
* cell instance $21972 r0 *1 47.31,44.8
X$21972 1417 112 113 1898 CLKBUF_X3
* cell instance $21973 r0 *1 48.26,44.8
X$21973 1868 1808 112 113 1946 NAND2_X1
* cell instance $21974 r0 *1 48.83,44.8
X$21974 1350 988 112 113 2043 NOR2_X1
* cell instance $21976 r0 *1 49.59,44.8
X$21976 1350 113 1899 112 BUF_X4
* cell instance $21978 r0 *1 51.11,44.8
X$21978 1188 112 113 1901 CLKBUF_X3
* cell instance $21980 r0 *1 52.82,44.8
X$21980 1313 1952 1811 112 1950 113 AOI21_X1
* cell instance $21981 r0 *1 53.58,44.8
X$21981 1727 1571 1773 112 1810 113 AOI21_X2
* cell instance $21982 r0 *1 54.91,44.8
X$21982 939 1811 1267 1187 1350 112 113 1873 AOI221_X1
* cell instance $21983 r0 *1 56.05,44.8
X$21983 1421 112 113 1872 INV_X2
* cell instance $21985 m0 *1 57.19,44.8
X$21985 1473 1953 1814 112 113 1777 MUX2_X1
* cell instance $21988 r0 *1 57.38,44.8
X$21988 1782 1421 1642 1639 1780 3816 113 112 AOI221_X2
* cell instance $21990 m0 *1 58.9,44.8
X$21990 1588 113 1813 112 BUF_X4
* cell instance $21991 r0 *1 59.47,44.8
X$21991 1780 1813 112 113 2052 NAND2_X1
* cell instance $21994 r0 *1 60.61,44.8
X$21994 1418 1728 112 113 1815 NOR2_X1
* cell instance $21995 m0 *1 61.18,44.8
X$21995 1422 1423 1728 112 113 1816 NOR3_X1
* cell instance $21996 m0 *1 60.61,44.8
X$21996 1816 1314 112 113 1780 NOR2_X1
* cell instance $21997 m0 *1 61.94,44.8
X$21997 1422 1423 1146 1812 1722 113 112 1817 OAI221_X1
* cell instance $21998 m0 *1 63.08,44.8
X$21998 1190 1723 1875 113 112 1724 OAI21_X2
* cell instance $21999 m0 *1 64.41,44.8
X$21999 1723 1783 1725 112 1878 113 AOI21_X1
* cell instance $22000 m0 *1 65.17,44.8
X$22000 1878 1809 1638 112 113 1879 NOR3_X1
* cell instance $22001 m0 *1 65.93,44.8
X$22001 1816 1270 1268 113 1726 112 OAI21_X1
* cell instance $22002 m0 *1 66.69,44.8
X$22002 1270 939 1189 112 1880 113 AOI21_X2
* cell instance $22003 m0 *1 68.02,44.8
X$22003 1588 1880 1881 1729 112 113 1814 AOI22_X2
* cell instance $22004 m0 *1 69.73,44.8
X$22004 1819 113 1807 112 BUF_X4
* cell instance $22005 m0 *1 71.06,44.8
X$22005 1272 1390 1722 1820 938 1809 113 112 AOI221_X2
* cell instance $22006 m0 *1 73.15,44.8
X$22006 1349 112 113 1728 INV_X2
* cell instance $22008 m0 *1 73.91,44.8
X$22008 1882 113 1883 112 BUF_X4
* cell instance $22009 m0 *1 75.24,44.8
X$22009 1272 1390 1648 112 113 1819 NAND3_X2
* cell instance $22011 r0 *1 61.18,44.8
X$22011 1815 1642 112 113 1903 NAND2_X1
* cell instance $22012 r0 *1 61.75,44.8
X$22012 1815 1811 1898 113 1955 112 OAI21_X1
* cell instance $22014 r0 *1 62.7,44.8
X$22014 1871 1817 1955 112 1877 113 AOI21_X1
* cell instance $22015 r0 *1 63.46,44.8
X$22015 1272 1390 1728 112 113 1906 NAND3_X1
* cell instance $22017 r0 *1 64.6,44.8
X$22017 1187 1723 1677 113 2063 112 OAI21_X1
* cell instance $22018 r0 *1 65.36,44.8
X$22018 1907 113 1350 112 BUF_X4
* cell instance $22020 r0 *1 67.07,44.8
X$22020 1189 1725 1818 113 112 1958 AND3_X1
* cell instance $22025 r0 *1 68.21,44.8
X$22025 1957 1638 1724 113 112 1959 OAI21_X2
* cell instance $22026 r0 *1 69.54,44.8
X$22026 1643 1819 1522 1767 1960 113 112 1957 OAI221_X1
* cell instance $22027 r0 *1 70.68,44.8
X$22027 1272 1390 1349 112 113 1966 NAND3_X1
* cell instance $22029 r0 *1 71.82,44.8
X$22029 1820 938 1528 1907 1147 1961 113 112 AOI221_X2
* cell instance $22030 r0 *1 73.91,44.8
X$22030 1966 1677 112 113 1965 NAND2_X1
* cell instance $22032 r0 *1 74.67,44.8
X$22032 1967 1353 1882 112 113 NOR2_X4
* cell instance $22034 r0 *1 76.57,44.8
X$22034 1425 113 1967 112 BUF_X4
* cell instance $22035 m0 *1 79.61,44.8
X$22035 1648 1729 112 113 1820 NOR2_X2
* cell instance $22036 m0 *1 76.95,44.8
X$22036 112 1729 1423 1422 1313 113 NOR3_X4
* cell instance $22039 r0 *1 77.9,44.8
X$22039 1820 113 1812 112 BUF_X4
* cell instance $22040 r0 *1 79.23,44.8
X$22040 189 112 113 243 CLKBUF_X3
* cell instance $22044 r0 *1 82.84,44.8
X$22044 1969 1242 1796 112 113 2013 MUX2_X1
* cell instance $22045 m0 *1 84.93,44.8
X$22045 470 523 1688 112 113 NOR2_X4
* cell instance $22046 m0 *1 83.98,44.8
X$22046 691 112 113 1032 CLKBUF_X3
* cell instance $22048 m0 *1 87.4,44.8
X$22048 832 1315 1821 691 1800 2015 113 112 AOI221_X2
* cell instance $22049 m0 *1 89.49,44.8
X$22049 1238 1398 642 112 1733 113 AOI21_X1
* cell instance $22050 m0 *1 90.25,44.8
X$22050 1733 1734 1615 112 113 1744 NOR3_X1
* cell instance $22051 m0 *1 91.01,44.8
X$22051 1735 874 112 113 1736 NAND2_X1
* cell instance $22052 m0 *1 91.58,44.8
X$22052 1737 1736 1119 1738 949 1887 113 112 AOI221_X2
* cell instance $22053 m0 *1 93.67,44.8
X$22053 470 944 112 113 1823 NOR2_X1
* cell instance $22056 m0 *1 95.95,44.8
X$22056 717 1739 1888 691 1824 112 113 1890 AOI221_X1
* cell instance $22060 r0 *1 84.93,44.8
X$22060 1485 112 113 1821 INV_X1
* cell instance $22064 r0 *1 87.78,44.8
X$22064 1821 112 113 1033 CLKBUF_X3
* cell instance $22065 r0 *1 88.73,44.8
X$22065 713 641 112 113 1533 NAND2_X2
* cell instance $22066 r0 *1 89.68,44.8
X$22066 1731 868 112 113 2081 NAND2_X1
* cell instance $22067 r0 *1 90.25,44.8
X$22067 1735 576 1912 112 1969 113 AOI21_X1
* cell instance $22068 r0 *1 91.01,44.8
X$22068 794 579 112 113 1912 NOR2_X1
* cell instance $22071 r0 *1 92.72,44.8
X$22071 713 992 112 113 1822 NAND2_X1
* cell instance $22072 r0 *1 93.29,44.8
X$22072 247 112 113 1315 BUF_X1
* cell instance $22073 r0 *1 93.86,44.8
X$22073 1433 1823 1827 1738 112 113 2082 AOI22_X1
* cell instance $22075 r0 *1 95,44.8
X$22075 1166 717 112 113 2085 NAND2_X1
* cell instance $22076 r0 *1 95.57,44.8
X$22076 1825 1977 1650 112 1889 113 AOI21_X1
* cell instance $22077 r0 *1 96.33,44.8
X$22077 523 1805 1822 113 1824 112 OAI21_X1
* cell instance $22078 r0 *1 97.09,44.8
X$22078 1979 1890 1889 1830 1407 1982 113 112 AOI221_X2
* cell instance $22079 m0 *1 99.56,44.8
X$22079 523 520 112 113 1827 NOR2_X1
* cell instance $22080 m0 *1 98.99,44.8
X$22080 1536 950 112 113 1826 NOR2_X1
* cell instance $22081 m0 *1 100.13,44.8
X$22081 1429 793 1806 113 1804 112 OAI21_X1
* cell instance $22082 m0 *1 100.89,44.8
X$22082 997 717 834 112 113 1806 NAND3_X1
* cell instance $22085 m0 *1 103.36,44.8
X$22085 833 1279 1741 1742 113 112 1743 OAI22_X1
* cell instance $22086 m0 *1 104.31,44.8
X$22086 1744 1615 1743 112 1892 113 AOI21_X1
* cell instance $22087 m0 *1 105.07,44.8
X$22087 1501 717 698 112 113 1894 MUX2_X1
* cell instance $22089 r0 *1 99.18,44.8
X$22089 717 641 1912 112 1891 113 AOI21_X1
* cell instance $22091 r0 *1 100.13,44.8
X$22091 1740 1541 1982 112 113 1984 MUX2_X1
* cell instance $22093 r0 *1 101.84,44.8
X$22093 1006 1916 1541 112 113 1990 NAND3_X1
* cell instance $22095 r0 *1 102.98,44.8
X$22095 1830 1238 1804 112 1828 113 AOI21_X1
* cell instance $22097 r0 *1 104.12,44.8
X$22097 1918 1710 1355 1987 112 113 1988 AOI22_X1
* cell instance $22099 r0 *1 105.45,44.8
X$22099 1541 1988 1990 1991 1826 1993 112 113 OAI221_X2
* cell instance $22100 m0 *1 106.97,44.8
X$22100 714 1742 1745 113 1801 112 OAI21_X1
* cell instance $22106 r0 *1 107.54,44.8
X$22106 1894 1732 112 113 1829 NAND2_X1
* cell instance $22108 r0 *1 108.3,44.8
X$22108 1828 1829 1830 1746 112 113 2201 AOI22_X1
* cell instance $22120 m0 *1 45.22,47.6
X$22120 1899 1112 16493 113 112 1998 HA_X1
* cell instance $22121 m0 *1 47.12,47.6
X$22121 1881 1782 1960 112 113 NOR2_X4
* cell instance $22122 m0 *1 48.83,47.6
X$22122 1417 2043 1584 1999 112 113 2046 AOI22_X1
* cell instance $22137 r0 *1 46.17,47.6
X$22137 1905 113 1584 112 BUF_X4
* cell instance $22139 r0 *1 47.88,47.6
X$22139 1728 1417 1899 1112 1587 113 112 2151 OAI221_X1
* cell instance $22141 r0 *1 49.78,47.6
X$22141 988 1950 2000 2094 1999 2154 112 113 OAI221_X2
* cell instance $22142 m0 *1 50.35,47.6
X$22142 1350 1115 112 113 1999 NAND2_X1
* cell instance $22145 m0 *1 51.11,47.6
X$22145 1898 1999 1949 112 2001 113 AOI21_X1
* cell instance $22146 m0 *1 51.87,47.6
X$22146 1901 1728 112 113 1949 NAND2_X1
* cell instance $22147 m0 *1 52.44,47.6
X$22147 2049 2003 1865 113 1951 112 OAI21_X1
* cell instance $22148 m0 *1 53.2,47.6
X$22148 1589 1782 1522 1901 2004 112 113 2003 AOI221_X1
* cell instance $22149 m0 *1 54.34,47.6
X$22149 1873 1954 2006 113 2049 112 OAI21_X1
* cell instance $22150 m0 *1 55.1,47.6
X$22150 2051 1899 2004 112 2050 113 AOI21_X1
* cell instance $22154 r0 *1 51.87,47.6
X$22154 2001 2002 2092 113 2270 112 OAI21_X1
* cell instance $22155 r0 *1 52.63,47.6
X$22155 1781 2096 2005 113 2152 112 OAI21_X1
* cell instance $22157 r0 *1 53.58,47.6
X$22157 1267 939 1811 112 2097 113 AOI21_X1
* cell instance $22158 r0 *1 54.34,47.6
X$22158 1811 939 1267 1350 2162 2002 113 112 AOI221_X2
* cell instance $22160 r0 *1 56.81,47.6
X$22160 1524 1998 112 113 2066 NOR2_X1
* cell instance $22161 r0 *1 57.38,47.6
X$22161 1907 1187 1267 112 2005 113 AOI21_X1
* cell instance $22162 r0 *1 58.14,47.6
X$22162 1517 2005 2166 112 2053 113 AOI21_X1
* cell instance $22164 m0 *1 58.52,47.6
X$22164 1422 1423 1418 113 1902 112 OAI21_X1
* cell instance $22165 m0 *1 60.04,47.6
X$22165 1647 1480 1902 113 112 1954 OAI21_X2
* cell instance $22166 m0 *1 61.37,47.6
X$22166 1905 1188 939 112 113 1904 NAND3_X1
* cell instance $22168 r0 *1 58.9,47.6
X$22168 2052 2053 2098 2006 2169 2168 113 112 AOI221_X2
* cell instance $22169 r0 *1 60.99,47.6
X$22169 1266 1903 1904 112 2056 113 AOI21_X1
* cell instance $22170 r0 *1 61.75,47.6
X$22170 2057 2056 2062 2006 112 113 2170 NOR4_X1
* cell instance $22172 m0 *1 62.51,47.6
X$22172 2007 1424 1723 112 113 2057 NOR3_X1
* cell instance $22173 m0 *1 63.46,47.6
X$22173 1881 1269 2064 1813 2063 2060 113 112 AOI221_X2
* cell instance $22175 r0 *1 62.7,47.6
X$22175 112 1521 113 2171 BUF_X8
* cell instance $22176 r0 *1 65.17,47.6
X$22176 1145 112 113 2171 BUF_X1
* cell instance $22177 r0 *1 65.74,47.6
X$22177 2000 1145 112 113 2064 NOR2_X2
* cell instance $22179 m0 *1 65.93,47.6
X$22179 1480 1881 2064 1075 1965 112 113 2100 AOI221_X1
* cell instance $22180 r0 *1 66.69,47.6
X$22180 988 1723 1419 113 2172 112 OAI21_X1
* cell instance $22182 m0 *1 68.21,47.6
X$22182 1908 1426 1953 112 113 2069 AND3_X4
* cell instance $22183 m0 *1 67.45,47.6
X$22183 1958 2066 1905 113 1908 112 OAI21_X1
* cell instance $22184 m0 *1 70.3,47.6
X$22184 939 1909 1524 1480 112 113 2004 AOI22_X2
* cell instance $22185 m0 *1 72.01,47.6
X$22185 1427 1480 112 113 2009 NAND2_X1
* cell instance $22186 m0 *1 72.58,47.6
X$22186 1269 1819 1527 1427 1647 2073 112 113 OAI221_X2
* cell instance $22187 m0 *1 74.67,47.6
X$22187 1075 1145 1427 112 113 2010 MUX2_X1
* cell instance $22189 r0 *1 67.64,47.6
X$22189 1418 1589 112 113 1818 NAND2_X1
* cell instance $22194 r0 *1 68.4,47.6
X$22194 1646 2173 1907 112 2007 113 AOI21_X1
* cell instance $22195 r0 *1 69.16,47.6
X$22195 1116 112 113 1483 INV_X4
* cell instance $22196 r0 *1 70.11,47.6
X$22196 1966 2008 1647 1115 1188 2101 113 112 AOI221_X2
* cell instance $22197 r0 *1 72.2,47.6
X$22197 2008 2009 1517 1728 1418 112 113 2230 AOI221_X1
* cell instance $22198 r0 *1 73.34,47.6
X$22198 1479 938 1528 112 2008 113 AOI21_X2
* cell instance $22199 r0 *1 74.67,47.6
X$22199 2177 2000 2103 2010 1269 2169 113 112 AOI221_X2
* cell instance $22200 m0 *1 77.71,47.6
X$22200 1479 112 113 1648 INV_X4
* cell instance $22201 m0 *1 76.38,47.6
X$22201 1648 113 1907 112 BUF_X4
* cell instance $22203 m0 *1 81.7,47.6
X$22203 1033 112 113 1242 CLKBUF_X3
* cell instance $22204 m0 *1 82.65,47.6
X$22204 1533 1033 1238 264 1970 113 112 2011 OAI221_X1
* cell instance $22206 m0 *1 83.98,47.6
X$22206 1429 1821 1910 113 1970 112 OAI21_X1
* cell instance $22210 r0 *1 77.33,47.6
X$22210 112 1909 1646 1271 1191 113 AOI21_X4
* cell instance $22213 r0 *1 80.94,47.6
X$22213 868 112 113 1238 CLKBUF_X3
* cell instance $22215 r0 *1 82.27,47.6
X$22215 2014 1033 1192 2180 2011 112 113 2012 AOI221_X1
* cell instance $22217 r0 *1 83.6,47.6
X$22217 2012 1615 2013 112 2077 113 AOI21_X1
* cell instance $22218 r0 *1 84.36,47.6
X$22218 2181 1910 1032 112 113 2180 NAND3_X1
* cell instance $22219 m0 *1 85.31,47.6
X$22219 1821 262 112 113 1910 NAND2_X1
* cell instance $22223 m0 *1 88.16,47.6
X$22223 1530 833 112 113 1911 NOR2_X1
* cell instance $22224 m0 *1 88.73,47.6
X$22224 694 113 1154 112 BUF_X4
* cell instance $22226 m0 *1 90.25,47.6
X$22226 992 871 579 943 1823 2185 113 112 AOI221_X2
* cell instance $22228 m0 *1 92.53,47.6
X$22228 1392 1823 834 871 112 113 1974 AOI22_X1
* cell instance $22231 r0 *1 85.5,47.6
X$22231 1530 262 112 113 2105 NOR2_X1
* cell instance $22232 r0 *1 86.07,47.6
X$22232 2105 2014 1200 113 2091 112 OAI21_X1
* cell instance $22234 r0 *1 87.02,47.6
X$22234 714 1911 1033 641 611 113 112 2325 OAI221_X1
* cell instance $22236 r0 *1 88.35,47.6
X$22236 833 713 262 112 113 2106 MUX2_X1
* cell instance $22238 r0 *1 89.87,47.6
X$22238 306 765 642 1032 113 112 2107 OAI22_X2
* cell instance $22241 r0 *1 92.15,47.6
X$22241 713 551 112 113 2108 NOR2_X2
* cell instance $22244 r0 *1 93.67,47.6
X$22244 2108 714 1688 112 2016 113 AOI21_X1
* cell instance $22246 m0 *1 93.86,47.6
X$22246 1038 1974 2082 2016 306 113 112 2086 OAI221_X1
* cell instance $22247 m0 *1 95.19,47.6
X$22247 2085 1911 1196 1429 793 113 112 1977 OAI221_X1
* cell instance $22250 r0 *1 94.62,47.6
X$22250 1688 2108 911 112 113 2186 NOR3_X1
* cell instance $22253 r0 *1 95.95,47.6
X$22253 525 1914 2081 112 2109 113 AOI21_X1
* cell instance $22254 m0 *1 96.9,47.6
X$22254 1822 1913 1196 112 113 1914 NAND3_X1
* cell instance $22256 m0 *1 97.66,47.6
X$22256 874 1827 2018 112 113 1979 NAND3_X1
* cell instance $22258 m0 *1 98.61,47.6
X$22258 1826 2088 1495 113 112 1803 AND3_X1
* cell instance $22260 m0 *1 99.75,47.6
X$22260 306 611 1915 113 2017 112 OAI21_X1
* cell instance $22261 m0 *1 100.51,47.6
X$22261 1827 2018 1915 112 113 1916 NAND3_X1
* cell instance $22263 m0 *1 101.46,47.6
X$22263 611 834 112 113 1917 NOR2_X1
* cell instance $22265 m0 *1 102.22,47.6
X$22265 1911 1917 1741 113 1985 112 OAI21_X1
* cell instance $22267 m0 *1 103.17,47.6
X$22267 1741 1539 1985 113 1987 112 OAI21_X1
* cell instance $22269 m0 *1 104.12,47.6
X$22269 1275 1915 1741 112 113 1918 NAND3_X1
* cell instance $22270 m0 *1 104.88,47.6
X$22270 1892 1541 112 113 2090 NOR2_X1
* cell instance $22272 m0 *1 105.64,47.6
X$22272 1690 1045 1830 113 1989 112 OAI21_X1
* cell instance $22273 m0 *1 106.4,47.6
X$22273 1615 1745 2091 113 112 1991 AND3_X1
* cell instance $22276 m0 *1 108.3,47.6
X$22276 2086 1830 702 112 113 2202 MUX2_X1
* cell instance $22279 m0 *1 113.43,47.6
X$22279 1922 112 113 584 CLKBUF_X3
* cell instance $22280 m0 *1 114.38,47.6
X$22280 1363 112 113 2019 INV_X8
* cell instance $22284 r0 *1 97.66,47.6
X$22284 1536 505 112 113 1825 NAND2_X1
* cell instance $22285 r0 *1 98.23,47.6
X$22285 2081 1891 1708 2110 2017 2111 113 112 AOI221_X2
* cell instance $22286 r0 *1 100.32,47.6
X$22286 551 520 112 113 2110 NOR2_X1
* cell instance $22288 r0 *1 101.08,47.6
X$22288 997 608 112 113 1915 NAND2_X1
* cell instance $22292 r0 *1 102.98,47.6
X$22292 1196 1090 1360 943 1279 113 112 2198 OAI221_X1
* cell instance $22295 r0 *1 104.69,47.6
X$22295 1530 520 112 113 2114 NAND2_X2
* cell instance $22296 r0 *1 105.64,47.6
X$22296 1989 1651 2115 2090 1993 2306 112 113 OAI221_X2
* cell instance $22299 r0 *1 108.68,47.6
X$22299 2201 1045 2202 112 113 2116 MUX2_X1
* cell instance $22303 r0 *1 115.33,47.6
X$22303 2019 113 806 112 BUF_X4
* cell instance $22304 m0 *1 116.66,47.6
X$22304 1921 1922 1919 2020 1920 1997 113 112 AOI221_X2
* cell instance $22306 m0 *1 118.75,47.6
X$22306 1920 113 1023 112 BUF_X4
* cell instance $22307 m0 *1 120.08,47.6
X$22307 1748 1543 787 112 113 NOR2_X4
* cell instance $22308 m0 *1 121.79,47.6
X$22308 2021 112 113 1652 INV_X2
* cell instance $22309 m0 *1 122.36,47.6
X$22309 1921 1652 112 113 1548 NAND2_X1
* cell instance $22310 m0 *1 122.93,47.6
X$22310 112 2021 2089 1832 1983 1549 934 1023 113 AOI222_X2
* cell instance $22312 m0 *1 126.35,47.6
X$22312 1919 776 112 113 1508 NAND2_X2
* cell instance $22313 m0 *1 127.3,47.6
X$22313 2087 1923 113 112 2244 AND2_X1
* cell instance $22316 r0 *1 116.85,47.6
X$22316 2671 1363 112 113 2117 NOR2_X2
* cell instance $22317 r0 *1 117.8,47.6
X$22317 2240 1896 1831 112 1920 113 AOI21_X2
* cell instance $22318 r0 *1 119.13,47.6
X$22318 1364 112 113 2020 BUF_X1
* cell instance $22321 r0 *1 120.27,47.6
X$22321 1748 113 657 112 BUF_X4
* cell instance $22323 r0 *1 121.98,47.6
X$22323 1996 1748 652 112 113 2206 MUX2_X1
* cell instance $22324 r0 *1 123.31,47.6
X$22324 653 1653 2206 112 113 2207 MUX2_X1
* cell instance $22328 r0 *1 124.64,47.6
X$22328 1508 2207 846 858 113 112 2119 OAI22_X2
* cell instance $22329 r0 *1 126.35,47.6
X$22329 571 1653 112 113 2026 XNOR2_X2
* cell instance $22330 r0 *1 128.25,47.6
X$22330 802 1364 112 113 2210 NAND2_X1
* cell instance $22331 m0 *1 128.63,47.6
X$22331 1919 776 112 113 1127 NOR2_X2
* cell instance $22334 r0 *1 128.82,47.6
X$22334 787 570 112 113 2211 NOR2_X1
* cell instance $22335 r0 *1 129.39,47.6
X$22335 802 568 112 113 2083 NAND2_X1
* cell instance $22337 m0 *1 130.91,47.6
X$22337 2084 662 1341 112 1995 113 AOI21_X1
* cell instance $22338 m0 *1 129.96,47.6
X$22338 571 927 1996 1205 113 112 2084 OAI22_X1
* cell instance $22340 m0 *1 132.43,47.6
X$22340 1182 1549 1441 953 112 113 2023 AOI22_X1
* cell instance $22342 m0 *1 134.14,47.6
X$22342 657 1441 112 113 2079 NOR2_X2
* cell instance $22344 r0 *1 130.15,47.6
X$22344 727 568 112 113 2022 NAND2_X1
* cell instance $22345 r0 *1 130.72,47.6
X$22345 1558 2083 2121 2022 2117 1262 113 112 AOI221_X2
* cell instance $22347 r0 *1 133,47.6
X$22347 2023 1508 112 113 2072 NOR2_X1
* cell instance $22348 r0 *1 133.57,47.6
X$22348 1992 2025 2022 1047 112 113 2215 NAND4_X1
* cell instance $22349 r0 *1 134.52,47.6
X$22349 1047 2080 2125 112 2124 113 AOI21_X1
* cell instance $22351 m0 *1 136.23,47.6
X$22351 953 662 112 113 2025 NAND2_X1
* cell instance $22352 m0 *1 135.47,47.6
X$22352 1654 1921 735 113 2024 112 OAI21_X1
* cell instance $22354 m0 *1 136.99,47.6
X$22354 1924 952 112 113 1981 NAND2_X1
* cell instance $22355 m0 *1 137.56,47.6
X$22355 1409 952 1924 1925 113 112 1980 AND4_X1
* cell instance $22356 m0 *1 138.7,47.6
X$22356 864 1341 791 953 112 113 1927 AOI22_X1
* cell instance $22357 m0 *1 139.65,47.6
X$22357 1927 1292 928 1981 1028 113 112 2075 OAI221_X1
* cell instance $22359 m0 *1 142.31,47.6
X$22359 1980 1453 112 113 2074 NOR2_X1
* cell instance $22361 r0 *1 135.66,47.6
X$22361 704 2024 1182 2026 2125 112 113 OAI211_X2
* cell instance $22362 r0 *1 137.37,47.6
X$22362 2078 2025 1755 112 2126 113 AOI21_X1
* cell instance $22364 r0 *1 138.32,47.6
X$22364 953 1364 112 113 2076 NAND2_X1
* cell instance $22367 r0 *1 139.46,47.6
X$22367 2071 2121 112 113 1055 NAND2_X2
* cell instance $22369 r0 *1 141.17,47.6
X$22369 1058 2075 2204 112 2299 113 AOI21_X1
* cell instance $22372 r0 *1 142.5,47.6
X$22372 1127 1929 2027 2028 112 113 2204 AOI22_X1
* cell instance $22373 m0 *1 143.45,47.6
X$22373 1099 2074 1978 112 2070 113 AOI21_X1
* cell instance $22376 m0 *1 144.4,47.6
X$22376 1509 1839 736 112 113 2129 NOR3_X1
* cell instance $22377 m0 *1 145.16,47.6
X$22377 1098 1558 735 113 1975 112 NOR3_X2
* cell instance $22378 m0 *1 146.49,47.6
X$22378 1560 704 112 113 1058 NAND2_X1
* cell instance $22380 m0 *1 147.25,47.6
X$22380 1020 1841 2197 1846 2070 113 112 2132 OAI221_X1
* cell instance $22383 r0 *1 143.64,47.6
X$22383 1098 663 864 113 2027 112 OAI21_X1
* cell instance $22385 r0 *1 144.78,47.6
X$22385 2026 1445 112 113 2128 NOR2_X1
* cell instance $22386 r0 *1 145.35,47.6
X$22386 2130 2072 2131 1055 113 2197 112 OR4_X2
* cell instance $22388 r0 *1 146.87,47.6
X$22388 2071 704 112 113 1020 NAND2_X2
* cell instance $22389 r0 *1 147.82,47.6
X$22389 1921 1124 858 593 1445 2028 113 112 AOI221_X2
* cell instance $22390 m0 *1 148.96,47.6
X$22390 1752 113 704 112 BUF_X4
* cell instance $22398 r0 *1 153.14,47.6
X$22398 112 17146 2294 2196 2133 113 DFF_X1
* cell instance $22401 m0 *1 163.78,47.6
X$22401 1460 2067 2068 112 2195 113 AOI21_X1
* cell instance $22405 m0 *1 165.49,47.6
X$22405 1756 1848 1245 2065 112 113 2068 AOI22_X1
* cell instance $22407 m0 *1 166.63,47.6
X$22407 320 1971 2187 113 2067 112 OAI21_X1
* cell instance $22408 m0 *1 167.39,47.6
X$22408 1757 1136 2029 112 2065 113 AOI21_X1
* cell instance $22409 m0 *1 168.15,47.6
X$22409 630 2061 2031 112 1972 113 AOI21_X1
* cell instance $22412 r0 *1 164.16,47.6
X$22412 920 1930 2195 281 2193 2196 113 112 AOI221_X2
* cell instance $22413 r0 *1 166.25,47.6
X$22413 438 283 112 113 1460 NAND2_X1
* cell instance $22414 r0 *1 166.82,47.6
X$22414 2054 438 2192 112 113 2193 MUX2_X1
* cell instance $22416 r0 *1 168.91,47.6
X$22416 2058 2188 2059 2190 2191 1563 112 113 OAI221_X2
* cell instance $22417 m0 *1 169.48,47.6
X$22417 610 1666 112 113 2061 NAND2_X1
* cell instance $22419 m0 *1 170.05,47.6
X$22419 1666 557 1756 113 2190 112 OAI21_X1
* cell instance $22420 m0 *1 170.81,47.6
X$22420 677 673 112 113 2030 NAND2_X1
* cell instance $22422 m0 *1 171.57,47.6
X$22422 1218 1214 112 113 631 NAND2_X2
* cell instance $22423 m0 *1 172.52,47.6
X$22423 1484 235 112 113 2058 NAND2_X1
* cell instance $22424 m0 *1 173.09,47.6
X$22424 2032 2055 240 289 838 2187 113 112 AOI221_X2
* cell instance $22426 m0 *1 175.37,47.6
X$22426 1462 1666 1667 112 774 113 AOI21_X2
* cell instance $22428 m0 *1 176.89,47.6
X$22428 1218 984 112 113 1064 NAND2_X1
* cell instance $22430 r0 *1 171,47.6
X$22430 610 631 2030 112 2059 113 AOI21_X1
* cell instance $22431 r0 *1 171.76,47.6
X$22431 2031 2032 113 112 2188 AND2_X1
* cell instance $22432 r0 *1 172.52,47.6
X$22432 838 320 112 113 1962 NAND2_X1
* cell instance $22434 r0 *1 173.28,47.6
X$22434 1218 984 358 112 2032 113 AOI21_X1
* cell instance $22435 r0 *1 174.04,47.6
X$22435 1674 893 753 112 2055 113 AOI21_X1
* cell instance $22436 r0 *1 174.8,47.6
X$22436 2183 2184 2182 1756 1932 2054 113 112 AOI221_X2
* cell instance $22437 r0 *1 176.89,47.6
X$22437 2033 1936 1757 673 485 2182 113 112 AOI221_X2
* cell instance $22438 m0 *1 179.55,47.6
X$22438 1933 1376 112 1757 113 NAND2_X4
* cell instance $22439 m0 *1 177.84,47.6
X$22439 1933 1376 1682 112 113 NOR2_X4
* cell instance $22441 m0 *1 181.45,47.6
X$22441 1669 1852 112 113 1851 NOR2_X1
* cell instance $22442 m0 *1 182.02,47.6
X$22442 2034 565 112 322 113 NAND2_X4
* cell instance $22443 m0 *1 183.73,47.6
X$22443 2031 1218 112 113 343 NOR2_X2
* cell instance $22444 m0 *1 184.68,47.6
X$22444 1934 1081 1467 113 1853 112 OAI21_X1
* cell instance $22445 m0 *1 185.44,47.6
X$22445 777 1933 984 112 113 1153 MUX2_X1
* cell instance $22446 m0 *1 186.77,47.6
X$22446 1933 112 113 235 CLKBUF_X3
* cell instance $22448 r0 *1 178.98,47.6
X$22448 1139 565 322 113 2033 112 OAI21_X1
* cell instance $22449 r0 *1 179.74,47.6
X$22449 1667 1462 112 113 557 NAND2_X2
* cell instance $22453 r0 *1 180.69,47.6
X$22453 1674 984 1667 112 2134 113 AOI21_X1
* cell instance $22456 r0 *1 183.16,47.6
X$22456 1762 112 113 2034 BUF_X2
* cell instance $22459 r0 *1 185.82,47.6
X$22459 2136 113 320 112 BUF_X4
* cell instance $22460 r0 *1 187.15,47.6
X$22460 1935 112 113 1669 INV_X4
* cell instance $22462 m0 *1 189.81,47.6
X$22462 1933 983 112 113 1080 NAND2_X1
* cell instance $22463 m0 *1 188.1,47.6
X$22463 1936 1669 838 112 113 NOR2_X4
* cell instance $22464 m0 *1 190.38,47.6
X$22464 1936 113 1467 112 BUF_X4
* cell instance $22465 m0 *1 191.71,47.6
X$22465 1669 113 753 112 BUF_X4
* cell instance $22467 m0 *1 193.23,47.6
X$22467 1574 113 777 112 BUF_X4
* cell instance $22469 m0 *1 195.32,47.6
X$22469 2035 112 113 1214 CLKBUF_X3
* cell instance $22472 r0 *1 188.29,47.6
X$22472 1936 1462 485 112 113 NOR2_X4
* cell instance $22473 r0 *1 190,47.6
X$22473 1933 983 1756 112 113 NOR2_X4
* cell instance $22474 r0 *1 191.71,47.6
X$22474 1669 1574 112 113 1934 NOR2_X1
* cell instance $22476 r0 *1 192.66,47.6
X$22476 358 113 610 112 BUF_X4
* cell instance $22477 r0 *1 193.99,47.6
X$22477 329 238 16699 113 112 2035 HA_X1
* cell instance $22481 m0 *1 199.88,47.6
X$22481 1867 113 2264 112 BUF_X4
* cell instance $22483 m0 *1 201.21,47.6
X$22483 2036 1856 1867 112 113 NOR2_X4
* cell instance $22484 m0 *1 202.92,47.6
X$22484 1858 113 1937 112 BUF_X4
* cell instance $22485 m0 *1 204.25,47.6
X$22485 1947 2036 1856 113 112 2045 OAI21_X4
* cell instance $22486 m0 *1 206.72,47.6
X$22486 112 2039 113 2036 BUF_X8
* cell instance $22487 m0 *1 209.19,47.6
X$22487 1940 1941 16597 113 112 1945 HA_X1
* cell instance $22488 m0 *1 211.09,47.6
X$22488 1937 1941 16581 113 112 1857 HA_X1
* cell instance $22490 r0 *1 199.88,47.6
X$22490 112 2038 1856 2036 2048 113 NOR3_X4
* cell instance $22491 r0 *1 202.54,47.6
X$22491 2037 113 2156 112 BUF_X4
* cell instance $22494 r0 *1 204.44,47.6
X$22494 112 1856 2163 2036 2047 113 NOR3_X4
* cell instance $22496 r0 *1 207.29,47.6
X$22496 2037 2039 1939 113 112 2249 OAI21_X2
* cell instance $22497 r0 *1 208.62,47.6
X$22497 1945 113 2250 112 BUF_X4
* cell instance $22498 r0 *1 209.95,47.6
X$22498 2252 1766 2044 112 113 NOR2_X4
* cell instance $22499 r0 *1 211.66,47.6
X$22499 2138 113 1940 112 BUF_X4
* cell instance $22502 m0 *1 10.64,162.4
X$22502 12097 112 113 12175 BUF_X1
* cell instance $22514 m0 *1 18.43,162.4
X$22514 112 16808 12248 11974 11557 113 DFF_X1
* cell instance $22522 r0 *1 32.49,162.4
X$22522 10798 11479 11716 112 113 12300 NOR3_X1
* cell instance $22523 m0 *1 32.87,162.4
X$22523 10315 10401 16525 113 112 10224 HA_X1
* cell instance $22525 m0 *1 34.77,162.4
X$22525 10453 10451 11868 12101 11479 12250 113 112 AOI221_X2
* cell instance $22526 m0 *1 36.86,162.4
X$22526 12016 10457 11393 112 113 11948 NAND3_X1
* cell instance $22527 m0 *1 37.62,162.4
X$22527 112 11725 10875 12176 10798 10971 12106 12105 113 AOI222_X2
* cell instance $22528 m0 *1 40.28,162.4
X$22528 10390 10640 10975 11058 12251 113 112 AOI211_X2
* cell instance $22530 r0 *1 33.25,162.4
X$22530 12015 10106 10797 113 12368 112 OAI21_X1
* cell instance $22534 r0 *1 38.95,162.4
X$22534 10280 11394 112 113 12456 NOR2_X1
* cell instance $22535 r0 *1 39.52,162.4
X$22535 12107 12302 12301 112 12371 113 AOI21_X1
* cell instance $22537 r0 *1 40.47,162.4
X$22537 11869 11394 11717 112 12017 113 AOI21_X1
* cell instance $22540 r0 *1 42.18,162.4
X$22540 10409 10450 112 113 11871 NAND2_X1
* cell instance $22541 m0 *1 43.13,162.4
X$22541 12251 12018 10404 112 113 12177 NOR3_X1
* cell instance $22542 m0 *1 42.37,162.4
X$22542 10684 12372 10971 112 12178 113 AOI21_X1
* cell instance $22544 m0 *1 44.08,162.4
X$22544 10741 11250 12179 10108 112 113 12118 AOI22_X1
* cell instance $22545 m0 *1 45.03,162.4
X$22545 11489 10742 11880 113 12180 112 OAI21_X1
* cell instance $22546 m0 *1 45.79,162.4
X$22546 112 11641 113 10401 BUF_X8
* cell instance $22547 m0 *1 48.26,162.4
X$22547 11650 11880 11648 112 12256 113 AOI21_X2
* cell instance $22549 m0 *1 49.78,162.4
X$22549 12182 11875 12111 10458 10547 12183 113 112 AOI221_X2
* cell instance $22550 m0 *1 51.87,162.4
X$22550 10988 10230 112 113 11565 NOR2_X1
* cell instance $22552 m0 *1 52.63,162.4
X$22552 12114 11877 11060 10684 12118 12020 113 112 AOI221_X2
* cell instance $22553 m0 *1 54.72,162.4
X$22553 11724 10739 112 113 12117 NAND2_X1
* cell instance $22555 m0 *1 56.05,162.4
X$22555 10742 12186 10796 112 12258 113 AOI21_X1
* cell instance $22556 m0 *1 56.81,162.4
X$22556 11875 11398 112 113 11962 NAND2_X1
* cell instance $22558 r0 *1 42.75,162.4
X$22558 10106 10030 10554 112 12252 113 AOI21_X1
* cell instance $22559 r0 *1 43.51,162.4
X$22559 10393 112 113 11334 BUF_X2
* cell instance $22560 r0 *1 44.27,162.4
X$22560 10800 12252 12374 12178 112 113 12262 AOI22_X1
* cell instance $22562 r0 *1 45.6,162.4
X$22562 12016 12181 10322 112 113 12374 NAND3_X1
* cell instance $22563 r0 *1 46.36,162.4
X$22563 11096 112 113 12304 INV_X1
* cell instance $22564 r0 *1 46.74,162.4
X$22564 11648 11395 10742 11725 10458 12375 113 112 AOI221_X2
* cell instance $22565 r0 *1 48.83,162.4
X$22565 10326 10319 112 113 11955 NAND2_X1
* cell instance $22566 r0 *1 49.4,162.4
X$22566 12305 11882 12378 12306 12022 12377 113 112 AOI221_X2
* cell instance $22567 r0 *1 51.49,162.4
X$22567 112 10460 10030 113 INV_X16
* cell instance $22568 r0 *1 54.72,162.4
X$22568 12382 12383 12386 113 12384 112 NOR3_X2
* cell instance $22569 r0 *1 56.05,162.4
X$22569 11880 10804 10897 9952 10556 113 112 12389 OAI221_X1
* cell instance $22570 r0 *1 57.19,162.4
X$22570 11965 112 113 12306 INV_X1
* cell instance $22571 r0 *1 57.57,162.4
X$22571 10685 12184 12016 113 12390 112 OAI21_X1
* cell instance $22573 m0 *1 57.76,162.4
X$22573 10108 10553 112 113 12259 NAND2_X1
* cell instance $22574 m0 *1 59.85,162.4
X$22574 12122 10685 112 113 12023 NOR2_X1
* cell instance $22575 m0 *1 60.42,162.4
X$22575 10685 10806 112 113 11876 NOR2_X2
* cell instance $22576 m0 *1 61.37,162.4
X$22576 10108 10406 10030 112 113 12024 NOR3_X1
* cell instance $22578 m0 *1 62.32,162.4
X$22578 11883 12188 12123 113 12187 112 OAI21_X1
* cell instance $22583 r0 *1 58.33,162.4
X$22583 11197 10630 112 113 12308 NAND2_X1
* cell instance $22585 r0 *1 59.09,162.4
X$22585 12390 11332 10800 10458 12023 112 113 12185 AOI221_X1
* cell instance $22587 r0 *1 60.42,162.4
X$22587 10315 10406 10795 12186 10108 113 112 12534 OAI221_X1
* cell instance $22589 r0 *1 61.75,162.4
X$22589 10409 12022 10106 112 12261 113 AOI21_X1
* cell instance $22590 r0 *1 62.51,162.4
X$22590 11876 112 113 11731 INV_X1
* cell instance $22591 r0 *1 62.89,162.4
X$22591 12261 12186 112 113 12188 NOR2_X1
* cell instance $22592 r0 *1 63.46,162.4
X$22592 12019 12309 12262 112 113 12189 OR3_X1
* cell instance $22599 m0 *1 71.82,162.4
X$22599 11259 12026 16556 113 112 12028 HA_X1
* cell instance $22600 m0 *1 73.91,162.4
X$22600 12028 113 11576 112 BUF_X4
* cell instance $22601 m0 *1 75.24,162.4
X$22601 11259 12026 16558 113 112 12027 HA_X1
* cell instance $22602 m0 *1 77.14,162.4
X$22602 11661 112 113 12032 CLKBUF_X3
* cell instance $22603 m0 *1 78.09,162.4
X$22603 12027 113 11574 112 BUF_X4
* cell instance $22606 r0 *1 73.72,162.4
X$22606 12028 112 113 12665 BUF_X1
* cell instance $22607 r0 *1 74.29,162.4
X$22607 11884 11259 16668 113 112 12029 HA_X1
* cell instance $22611 r0 *1 77.52,162.4
X$22611 112 12311 113 11068 BUF_X8
* cell instance $22612 m0 *1 80.37,162.4
X$22612 12028 112 113 12195 INV_X4
* cell instance $22613 m0 *1 79.8,162.4
X$22613 11736 11735 112 113 12190 NAND2_X1
* cell instance $22614 m0 *1 81.32,162.4
X$22614 10811 10993 12027 112 113 11892 NAND3_X2
* cell instance $22615 m0 *1 82.65,162.4
X$22615 12032 11212 11981 112 113 12191 OR3_X1
* cell instance $22616 m0 *1 83.6,162.4
X$22616 12191 12192 12263 112 113 12030 NAND3_X1
* cell instance $22618 m0 *1 85.12,162.4
X$22618 11839 12397 112 113 12267 NAND2_X1
* cell instance $22620 r0 *1 79.99,162.4
X$22620 10810 113 12263 112 BUF_X4
* cell instance $22623 r0 *1 82.27,162.4
X$22623 112 11981 12312 10811 10993 113 AOI21_X4
* cell instance $22624 r0 *1 84.74,162.4
X$22624 11406 113 12313 112 BUF_X4
* cell instance $22625 r0 *1 86.07,162.4
X$22625 11408 11261 11735 112 113 12193 NAND3_X1
* cell instance $22627 m0 *1 86.07,162.4
X$22627 12267 12193 10926 112 113 12136 NAND3_X1
* cell instance $22628 m0 *1 87.02,162.4
X$22628 12032 11411 12193 112 12314 113 AOI21_X2
* cell instance $22629 m0 *1 88.35,162.4
X$22629 11884 12138 12033 113 12140 112 OAI21_X1
* cell instance $22630 m0 *1 89.11,162.4
X$22630 12398 12195 112 113 11671 NOR2_X1
* cell instance $22633 m0 *1 90.63,162.4
X$22633 11839 12314 11742 112 113 12196 OR3_X1
* cell instance $22634 m0 *1 91.58,162.4
X$22634 12195 10692 10812 113 112 12036 OAI21_X4
* cell instance $22635 m0 *1 94.05,162.4
X$22635 11844 11410 11578 113 112 12035 OAI21_X2
* cell instance $22636 m0 *1 95.38,162.4
X$22636 12032 11405 12036 113 112 12406 AND3_X1
* cell instance $22638 m0 *1 96.52,162.4
X$22638 12273 10926 12148 113 12147 112 OAI21_X1
* cell instance $22639 m0 *1 97.28,162.4
X$22639 12035 11405 11678 112 113 12148 NAND3_X1
* cell instance $22640 m0 *1 98.04,162.4
X$22640 11845 11520 12134 112 113 12151 MUX2_X1
* cell instance $22644 r0 *1 87.78,162.4
X$22644 11209 12315 112 113 12197 NAND2_X1
* cell instance $22645 r0 *1 88.35,162.4
X$22645 11664 11982 12316 12313 12194 112 113 12269 AOI221_X1
* cell instance $22647 r0 *1 91.01,162.4
X$22647 12402 12269 12196 113 12399 112 OAI21_X1
* cell instance $22649 r0 *1 92.15,162.4
X$22649 12402 12140 12401 113 12318 112 OAI21_X1
* cell instance $22650 r0 *1 92.91,162.4
X$22650 12317 12197 11581 112 113 12401 NAND3_X1
* cell instance $22651 r0 *1 93.67,162.4
X$22651 11744 12144 12271 112 113 12555 NOR3_X1
* cell instance $22652 r0 *1 94.43,162.4
X$22652 12198 12406 11663 112 113 12271 NOR3_X1
* cell instance $22653 r0 *1 95.19,162.4
X$22653 12142 11981 12270 112 113 12198 NOR3_X1
* cell instance $22655 r0 *1 96.33,162.4
X$22655 12199 11263 12318 112 113 12412 MUX2_X1
* cell instance $22657 r0 *1 97.85,162.4
X$22657 11886 11405 12273 112 113 12411 NAND3_X1
* cell instance $22659 r0 *1 99.37,162.4
X$22659 12040 12413 12412 112 12274 113 AOI21_X1
* cell instance $22661 m0 *1 99.75,162.4
X$22661 12038 12320 112 113 12039 NOR2_X1
* cell instance $22662 m0 *1 106.4,162.4
X$22662 11265 10121 12276 112 113 12419 MUX2_X1
* cell instance $22663 m0 *1 107.73,162.4
X$22663 12042 12322 12277 112 113 9499 AND3_X4
* cell instance $22664 m0 *1 109.82,162.4
X$22664 9966 9980 12156 112 113 12277 NAND3_X1
* cell instance $22670 r0 *1 102.98,162.4
X$22670 12696 9307 12274 112 113 12168 MUX2_X1
* cell instance $22675 r0 *1 107.16,162.4
X$22675 10240 12419 12420 113 12421 112 OAI21_X1
* cell instance $22676 r0 *1 107.92,162.4
X$22676 12278 12478 12421 11273 12753 10118 112 113 OAI221_X2
* cell instance $22678 r0 *1 110.2,162.4
X$22678 10200 10243 12425 113 112 12324 OAI21_X2
* cell instance $22679 m0 *1 112.1,162.4
X$22679 11417 112 113 12201 INV_X1
* cell instance $22680 m0 *1 110.96,162.4
X$22680 12200 12324 11247 12480 12201 113 112 12156 OAI221_X1
* cell instance $22681 m0 *1 112.48,162.4
X$22681 12043 12157 9980 112 113 12202 NAND3_X1
* cell instance $22685 r0 *1 112.1,162.4
X$22685 10127 12426 12327 12202 12322 112 113 OAI211_X2
* cell instance $22687 m0 *1 113.62,162.4
X$22687 12203 11897 10787 12281 112 113 12426 AOI22_X2
* cell instance $22688 m0 *1 116.09,162.4
X$22688 9934 12045 112 113 12044 NOR2_X1
* cell instance $22692 r0 *1 114.19,162.4
X$22692 12044 12429 11110 113 12203 112 OAI21_X1
* cell instance $22693 r0 *1 114.95,162.4
X$22693 10245 10213 112 113 12429 NOR2_X1
* cell instance $22694 r0 *1 115.52,162.4
X$22694 9962 12430 12282 10200 112 113 12281 AOI22_X2
* cell instance $22695 r0 *1 117.23,162.4
X$22695 10245 12482 10243 113 12282 112 OAI21_X1
* cell instance $22696 r0 *1 117.99,162.4
X$22696 10446 10472 10440 112 12483 113 AOI21_X2
* cell instance $22697 m0 *1 118.75,162.4
X$22697 10440 112 113 10245 CLKBUF_X3
* cell instance $22699 m0 *1 119.7,162.4
X$22699 11270 10200 112 113 12435 NAND2_X1
* cell instance $22702 r0 *1 119.7,162.4
X$22702 12435 12434 12439 12436 113 112 12327 OAI22_X2
* cell instance $22704 m0 *1 120.65,162.4
X$22704 9962 9971 112 113 12436 NAND2_X1
* cell instance $22705 r0 *1 121.41,162.4
X$22705 12332 10068 12204 112 12434 113 AOI21_X1
* cell instance $22707 m0 *1 121.6,162.4
X$22707 11426 10245 11427 112 12204 113 AOI21_X1
* cell instance $22709 r0 *1 122.17,162.4
X$22709 11426 10817 10440 112 12290 113 AOI21_X2
* cell instance $22710 r0 *1 123.5,162.4
X$22710 12437 10240 112 113 11082 NOR2_X1
* cell instance $22714 r0 *1 124.07,162.4
X$22714 11757 10445 10814 12290 113 112 12437 OAI22_X1
* cell instance $22716 m0 *1 124.26,162.4
X$22716 9941 11713 112 113 12170 NOR2_X1
* cell instance $22720 r0 *1 125.21,162.4
X$22720 10349 10701 10130 112 12013 113 AOI21_X2
* cell instance $22722 r0 *1 126.73,162.4
X$22722 12442 10814 12205 112 12439 113 AOI21_X1
* cell instance $22723 r0 *1 127.49,162.4
X$22723 112 11590 113 12052 BUF_X8
* cell instance $22724 m0 *1 127.68,162.4
X$22724 9974 10822 112 113 12048 NOR2_X1
* cell instance $22726 m0 *1 128.25,162.4
X$22726 11900 11713 11427 112 12205 113 AOI21_X1
* cell instance $22727 m0 *1 129.01,162.4
X$22727 10125 11713 12049 113 12206 112 OAI21_X1
* cell instance $22731 r0 *1 130.15,162.4
X$22731 10342 10571 12049 113 112 12442 AND3_X1
* cell instance $22733 m0 *1 130.91,162.4
X$22733 12049 9967 113 10960 112 AND2_X4
* cell instance $22735 r0 *1 131.48,162.4
X$22735 10121 12207 11110 12451 12172 113 112 AOI211_X2
* cell instance $22736 m0 *1 133.19,162.4
X$22736 10829 11000 12050 113 12049 112 OAI21_X1
* cell instance $22738 m0 *1 133.95,162.4
X$22738 10130 9974 113 112 12209 XNOR2_X1
* cell instance $22739 m0 *1 135.09,162.4
X$22739 12050 112 113 11757 INV_X1
* cell instance $22741 m0 *1 136.23,162.4
X$22741 112 11426 12051 10210 10135 113 AOI21_X4
* cell instance $22742 m0 *1 138.7,162.4
X$22742 112 10446 12210 10210 10135 113 AOI21_X4
* cell instance $22744 m0 *1 141.36,162.4
X$22744 12053 112 113 12052 INV_X8
* cell instance $22748 r0 *1 133.57,162.4
X$22748 9876 10130 10340 112 113 12208 NOR3_X1
* cell instance $22749 r0 *1 134.33,162.4
X$22749 12209 11590 12208 12048 11757 12451 113 112 AOI221_X2
* cell instance $22750 r0 *1 136.42,162.4
X$22750 10210 10135 12050 112 113 11267 NAND3_X2
* cell instance $22752 r0 *1 137.94,162.4
X$22752 10135 12210 10210 112 9967 113 NAND3_X4
* cell instance $22755 r0 *1 143.64,162.4
X$22755 12454 8295 12299 112 113 12453 MUX2_X1
* cell instance $22757 r0 *1 145.16,162.4
X$22757 112 17023 12452 12453 11904 113 DFF_X1
* cell instance $22758 m0 *1 146.68,162.4
X$22758 9509 12054 112 113 12299 XOR2_X1
* cell instance $22761 m0 *1 148.39,162.4
X$22761 10357 12167 112 113 12844 XNOR2_X2
* cell instance $22764 m0 *1 151.05,162.4
X$22764 11004 12213 12297 113 112 12298 AND3_X2
* cell instance $22765 m0 *1 152.19,162.4
X$22765 11277 12298 12055 113 112 11905 OAI21_X2
* cell instance $22766 m0 *1 153.52,162.4
X$22766 12212 12213 113 112 11761 AND2_X1
* cell instance $22769 m0 *1 155.99,162.4
X$22769 11287 12295 112 113 12163 NOR2_X1
* cell instance $22771 m0 *1 156.75,162.4
X$22771 11008 11913 11601 112 12296 113 AOI21_X1
* cell instance $22772 m0 *1 157.51,162.4
X$22772 12057 12214 10833 112 113 11119 NAND3_X1
* cell instance $22773 m0 *1 158.27,162.4
X$22773 11907 12294 11908 12444 112 113 12057 AOI22_X1
* cell instance $22775 m0 *1 159.98,162.4
X$22775 12060 12070 112 113 11379 NAND2_X1
* cell instance $22776 m0 *1 160.55,162.4
X$22776 12061 11287 12215 112 113 11703 NOR3_X1
* cell instance $22780 r0 *1 148.58,162.4
X$22780 12452 112 113 9509 CLKBUF_X3
* cell instance $22782 r0 *1 152.57,162.4
X$22782 12447 11913 112 113 12211 NAND2_X1
* cell instance $22783 r0 *1 153.14,162.4
X$22783 12337 12211 12212 11778 11525 113 112 12333 OAI221_X1
* cell instance $22784 r0 *1 154.28,162.4
X$22784 12449 12335 112 113 12297 NAND2_X1
* cell instance $22786 r0 *1 155.04,162.4
X$22786 11448 11287 12450 113 12449 112 OAI21_X1
* cell instance $22787 r0 *1 155.8,162.4
X$22787 11549 12445 12296 11432 11437 113 112 12446 OAI221_X1
* cell instance $22790 r0 *1 157.51,162.4
X$22790 12724 12446 11277 112 113 12214 NAND3_X1
* cell instance $22794 r0 *1 159.6,162.4
X$22794 11855 12334 11536 113 112 12213 OAI21_X2
* cell instance $22795 r0 *1 160.93,162.4
X$22795 11072 12441 12337 112 12294 113 AOI21_X1
* cell instance $22796 r0 *1 161.69,162.4
X$22796 12334 112 113 12561 BUF_X1
* cell instance $22798 r0 *1 163.02,162.4
X$22798 11912 11284 12335 113 12212 112 OAI21_X1
* cell instance $22799 r0 *1 163.78,162.4
X$22799 11523 12063 112 113 12062 NOR2_X2
* cell instance $22800 r0 *1 164.73,162.4
X$22800 12215 12336 12216 113 112 11697 AND3_X1
* cell instance $22801 m0 *1 165.68,162.4
X$22801 11277 12217 12292 113 11772 112 OAI21_X1
* cell instance $22802 m0 *1 164.73,162.4
X$22802 12063 11909 12337 11449 113 112 12064 OAI22_X1
* cell instance $22803 m0 *1 166.44,162.4
X$22803 12067 11909 12066 11693 11601 112 113 12217 AOI221_X1
* cell instance $22804 m0 *1 167.58,162.4
X$22804 12068 12339 112 113 11688 NAND2_X1
* cell instance $22805 m0 *1 168.15,162.4
X$22805 11768 12285 12069 112 11698 113 AOI21_X2
* cell instance $22807 r0 *1 165.68,162.4
X$22807 12291 11130 11446 113 12216 112 OAI21_X1
* cell instance $22808 r0 *1 166.44,162.4
X$22808 12342 12338 112 113 12291 NOR2_X1
* cell instance $22809 r0 *1 167.01,162.4
X$22809 11432 12338 112 113 12066 NOR2_X1
* cell instance $22811 r0 *1 169.1,162.4
X$22811 11442 11130 12289 112 113 12553 OR3_X1
* cell instance $22812 m0 *1 170.05,162.4
X$22812 12072 11455 11537 112 12289 113 AOI21_X1
* cell instance $22814 m0 *1 170.81,162.4
X$22814 12061 12072 112 113 12286 NOR2_X2
* cell instance $22816 m0 *1 171.95,162.4
X$22816 12283 12071 11003 12215 12287 11220 113 112 AOI221_X2
* cell instance $22817 m0 *1 174.04,162.4
X$22817 12218 112 113 12063 INV_X4
* cell instance $22821 r0 *1 171.19,162.4
X$22821 11525 11693 112 113 12431 NOR2_X1
* cell instance $22822 r0 *1 171.76,162.4
X$22822 11603 11526 12068 112 113 12288 NAND3_X1
* cell instance $22823 r0 *1 172.52,162.4
X$22823 12288 12285 113 12287 112 AND2_X4
* cell instance $22824 r0 *1 174.23,162.4
X$22824 11674 12422 112 113 11917 NOR2_X1
* cell instance $22825 r0 *1 174.8,162.4
X$22825 12407 12427 11277 12423 12284 113 112 AOI211_X2
* cell instance $22827 m0 *1 175.37,162.4
X$22827 12424 12284 11983 12280 113 10589 112 OR4_X2
* cell instance $22828 r0 *1 176.51,162.4
X$22828 12344 11523 112 113 11607 NOR2_X2
* cell instance $22830 m0 *1 177.08,162.4
X$22830 12279 12139 12222 12074 12280 113 112 AOI211_X2
* cell instance $22831 m0 *1 178.98,162.4
X$22831 10834 12221 12275 112 12279 113 AOI21_X1
* cell instance $22832 m0 *1 179.74,162.4
X$22832 11837 113 12222 112 BUF_X4
* cell instance $22834 m0 *1 181.26,162.4
X$22834 11837 113 10834 112 BUF_X4
* cell instance $22835 m0 *1 182.59,162.4
X$22835 11291 12137 12076 12075 112 113 12275 OR4_X1
* cell instance $22836 m0 *1 183.73,162.4
X$22836 10949 11208 112 113 12077 NOR2_X1
* cell instance $22839 r0 *1 177.84,162.4
X$22839 12342 12343 11012 11445 112 113 11136 AOI22_X1
* cell instance $22840 r0 *1 178.79,162.4
X$22840 11130 12345 12344 12339 11523 11906 113 112 AOI221_X2
* cell instance $22844 r0 *1 180.88,162.4
X$22844 12132 113 12219 112 BUF_X4
* cell instance $22845 r0 *1 182.21,162.4
X$22845 12416 12812 112 113 12705 NOR2_X1
* cell instance $22846 r0 *1 182.78,162.4
X$22846 12223 112 113 12073 BUF_X1
* cell instance $22847 r0 *1 183.35,162.4
X$22847 12414 112 113 11208 INV_X1
* cell instance $22848 r0 *1 183.73,162.4
X$22848 11288 12404 12079 112 12220 113 AOI21_X1
* cell instance $22849 r0 *1 184.49,162.4
X$22849 11014 112 113 11916 BUF_X1
* cell instance $22850 m0 *1 185.63,162.4
X$22850 11922 112 113 11534 BUF_X1
* cell instance $22851 m0 *1 184.68,162.4
X$22851 11670 11130 12076 112 113 12272 OR3_X1
* cell instance $22852 m0 *1 186.2,162.4
X$22852 11291 12219 112 113 12079 NAND2_X1
* cell instance $22854 m0 *1 186.96,162.4
X$22854 12225 11455 11991 112 113 12131 MUX2_X1
* cell instance $22855 m0 *1 188.29,162.4
X$22855 12225 112 113 12345 INV_X8
* cell instance $22856 m0 *1 190,162.4
X$22856 12080 113 12072 112 BUF_X4
* cell instance $22857 m0 *1 191.33,162.4
X$22857 112 11915 113 12080 BUF_X8
* cell instance $22861 m0 *1 196.27,162.4
X$22861 112 11347 11353 113 INV_X16
* cell instance $22862 m0 *1 199.5,162.4
X$22862 10515 11353 112 113 11043 NAND2_X2
* cell instance $22863 m0 *1 200.45,162.4
X$22863 112 12226 11299 12126 12228 11924 12229 11463 113 AOI222_X2
* cell instance $22865 m0 *1 203.3,162.4
X$22865 12081 11346 112 113 12268 NAND2_X1
* cell instance $22867 m0 *1 204.06,162.4
X$22867 11614 11158 12266 12351 113 112 12125 OAI22_X1
* cell instance $22869 r0 *1 185.06,162.4
X$22869 12072 11208 112 113 12408 NAND2_X1
* cell instance $22871 r0 *1 185.82,162.4
X$22871 11765 12078 10713 12272 12405 12407 113 112 AOI221_X2
* cell instance $22872 r0 *1 187.91,162.4
X$22872 12348 12400 12349 113 12405 112 OAI21_X1
* cell instance $22873 r0 *1 188.67,162.4
X$22873 11295 112 113 12223 BUF_X1
* cell instance $22874 r0 *1 189.24,162.4
X$22874 11456 11295 112 113 12403 OR2_X1
* cell instance $22875 r0 *1 190,162.4
X$22875 12080 113 12225 112 BUF_X4
* cell instance $22876 r0 *1 191.33,162.4
X$22876 11923 112 113 11922 BUF_X1
* cell instance $22877 r0 *1 191.9,162.4
X$22877 11292 12072 112 113 12400 NOR2_X1
* cell instance $22880 r0 *1 196.27,162.4
X$22880 11299 11353 12357 112 113 NOR2_X4
* cell instance $22881 r0 *1 197.98,162.4
X$22881 112 11353 10756 11016 11172 113 NOR3_X4
* cell instance $22883 r0 *1 200.83,162.4
X$22883 12357 12228 12227 11299 11330 12230 113 112 AOI221_X2
* cell instance $22884 r0 *1 202.92,162.4
X$22884 12227 12229 11656 12350 11172 12232 113 112 AOI221_X2
* cell instance $22885 r0 *1 205.01,162.4
X$22885 12532 12230 10856 12234 113 12231 112 NOR4_X2
* cell instance $22886 m0 *1 205.58,162.4
X$22886 12265 12231 12264 113 11019 112 OAI21_X1
* cell instance $22888 m0 *1 206.34,162.4
X$22888 11790 12229 11303 11147 12226 12396 113 112 AOI221_X2
* cell instance $22889 m0 *1 208.43,162.4
X$22889 11624 11301 10593 113 12082 112 OAI21_X1
* cell instance $22890 m0 *1 209.19,162.4
X$22890 12230 10594 112 113 11928 NOR2_X1
* cell instance $22891 m0 *1 209.76,162.4
X$22891 11799 10858 10492 11638 112 113 12233 NAND4_X1
* cell instance $22892 m0 *1 210.71,162.4
X$22892 12121 12237 112 113 12083 NAND2_X1
* cell instance $22893 m0 *1 211.28,162.4
X$22893 10864 11631 10858 112 12234 113 AOI21_X1
* cell instance $22895 m0 *1 212.23,162.4
X$22895 11059 12238 11790 112 113 12121 NAND3_X1
* cell instance $22896 m0 *1 212.99,162.4
X$22896 12085 12260 12083 113 112 10919 OAI21_X2
* cell instance $22897 m0 *1 214.32,162.4
X$22897 12226 12239 112 113 12084 NAND2_X1
* cell instance $22898 m0 *1 214.89,162.4
X$22898 11958 112 113 12116 BUF_X1
* cell instance $22899 m0 *1 215.46,162.4
X$22899 11932 12084 12237 12266 11933 12119 113 112 AOI221_X2
* cell instance $22900 m0 *1 217.55,162.4
X$22900 10885 11791 11150 11308 113 112 12240 OAI22_X1
* cell instance $22901 m0 *1 218.5,162.4
X$22901 11313 11301 11030 10856 113 112 12241 OAI22_X1
* cell instance $22902 m0 *1 219.45,162.4
X$22902 11022 11929 11930 112 12257 113 AOI21_X2
* cell instance $22903 m0 *1 220.78,162.4
X$22903 11024 12257 12086 113 12112 112 OAI21_X1
* cell instance $22907 r0 *1 207.1,162.4
X$22907 12082 12396 10606 12352 12232 113 112 12264 OAI221_X1
* cell instance $22908 r0 *1 208.24,162.4
X$22908 10593 12232 12353 112 113 12235 OR3_X2
* cell instance $22910 r0 *1 209.57,162.4
X$22910 12233 12235 12236 112 113 11619 AND3_X4
* cell instance $22911 r0 *1 211.66,162.4
X$22911 11624 11308 11799 113 12353 112 OAI21_X1
* cell instance $22912 r0 *1 212.42,162.4
X$22912 10373 12393 10638 112 12236 113 AOI21_X1
* cell instance $22913 r0 *1 213.18,162.4
X$22913 12092 11960 12103 112 113 12393 MUX2_X1
* cell instance $22914 r0 *1 214.51,162.4
X$22914 11017 10595 11151 112 12671 113 AOI21_X1
* cell instance $22915 r0 *1 215.27,162.4
X$22915 12092 11303 12238 113 12388 112 OAI21_X1
* cell instance $22917 r0 *1 216.22,162.4
X$22917 12242 11928 10595 10722 12240 12381 113 112 AOI221_X2
* cell instance $22918 r0 *1 218.31,162.4
X$22918 12244 12239 112 113 11623 NAND2_X1
* cell instance $22920 r0 *1 219.07,162.4
X$22920 10491 12355 12387 113 11952 112 OAI21_X1
* cell instance $22921 r0 *1 219.83,162.4
X$22921 12388 11145 112 113 12242 NAND2_X1
* cell instance $22922 r0 *1 220.4,162.4
X$22922 11029 12092 112 113 11155 NAND2_X1
* cell instance $22924 r0 *1 221.16,162.4
X$22924 12381 12380 12255 112 10886 113 AOI21_X2
* cell instance $22925 r0 *1 222.49,162.4
X$22925 12102 12241 11157 12379 112 113 12380 AOI22_X1
* cell instance $22926 m0 *1 222.87,162.4
X$22926 11145 12237 112 113 12243 NOR2_X1
* cell instance $22929 r0 *1 223.44,162.4
X$22929 11643 12243 10737 10860 12087 12255 113 112 AOI221_X2
* cell instance $22931 m0 *1 223.82,162.4
X$22931 11150 11618 12254 113 12087 112 OAI21_X1
* cell instance $22932 m0 *1 224.77,162.4
X$22932 12245 11314 10859 12253 11791 113 112 11798 OAI221_X1
* cell instance $22933 m0 *1 225.91,162.4
X$22933 12253 11017 11161 12244 112 113 12091 AOI22_X1
* cell instance $22934 m0 *1 226.86,162.4
X$22934 11313 11791 12091 113 10880 112 OAI21_X1
* cell instance $22935 m0 *1 227.62,162.4
X$22935 11960 12092 112 113 12089 NOR2_X1
* cell instance $22937 m0 *1 228.38,162.4
X$22937 12245 112 113 12092 INV_X2
* cell instance $22938 m0 *1 228.95,162.4
X$22938 11350 11309 10859 11330 11926 113 112 12100 OAI221_X1
* cell instance $22939 m0 *1 230.09,162.4
X$22939 10626 10737 12092 11151 12246 113 112 AOI211_X2
* cell instance $22941 m0 *1 231.99,162.4
X$22941 12100 12094 11794 113 12095 112 OAI21_X1
* cell instance $22946 r0 *1 225.53,162.4
X$22946 11145 12358 12237 113 112 12254 OAI21_X2
* cell instance $22947 r0 *1 226.86,162.4
X$22947 11638 10856 12373 11926 12358 113 112 11311 OAI221_X1
* cell instance $22948 r0 *1 228,162.4
X$22948 12357 11032 10722 11350 112 113 12373 NAND4_X1
* cell instance $22950 r0 *1 229.14,162.4
X$22950 12257 11350 11309 112 12370 113 AOI21_X1
* cell instance $22951 r0 *1 229.9,162.4
X$22951 11350 12357 11330 12086 112 113 12369 AOI22_X1
* cell instance $22952 r0 *1 230.85,162.4
X$22952 12369 12366 10491 113 12249 112 OAI21_X1
* cell instance $22954 r0 *1 231.8,162.4
X$22954 10607 12246 12093 112 12359 113 AOI21_X1
* cell instance $22955 r0 *1 232.56,162.4
X$22955 12360 12095 12359 12249 12083 113 112 12365 OAI221_X1
* cell instance $22961 r0 *1 235.98,162.4
X$22961 112 17143 12361 9844 12247 113 DFF_X1
* cell instance $22962 m0 *1 238.64,162.4
X$22962 12362 112 113 12096 BUF_X1
* cell instance $22971 m0 *1 18.81,151.2
X$22971 10792 8585 11167 112 113 10870 MUX2_X1
* cell instance $22972 m0 *1 20.14,151.2
X$22972 112 16789 10792 10870 10313 113 DFF_X1
* cell instance $22976 m0 *1 28.12,151.2
X$22976 11035 8585 12364 112 113 10871 MUX2_X1
* cell instance $22977 m0 *1 29.45,151.2
X$22977 112 10871 11557 10759 11035 113 DFF_X2
* cell instance $22989 m0 *1 34.01,151.2
X$22989 10793 10796 10873 113 11039 112 OAI21_X1
* cell instance $22990 m0 *1 33.44,151.2
X$22990 10803 10105 112 113 10793 NOR2_X1
* cell instance $22991 m0 *1 34.77,151.2
X$22991 10454 9867 10026 113 112 11037 OAI21_X4
* cell instance $22992 m0 *1 37.24,151.2
X$22992 11036 10677 112 113 10973 NAND2_X1
* cell instance $22993 m0 *1 37.81,151.2
X$22993 10107 112 113 10968 CLKBUF_X3
* cell instance $22994 m0 *1 38.76,151.2
X$22994 10972 10968 10971 10796 112 113 11176 OR4_X1
* cell instance $22995 m0 *1 39.9,151.2
X$22995 11089 10795 112 113 10678 NOR2_X1
* cell instance $22996 m0 *1 40.47,151.2
X$22996 10741 10798 10552 112 113 10974 OR3_X1
* cell instance $22997 m0 *1 41.42,151.2
X$22997 10799 10974 10878 10800 112 113 10740 NAND4_X1
* cell instance $22998 m0 *1 42.37,151.2
X$22998 10400 112 113 10972 BUF_X2
* cell instance $22999 m0 *1 43.13,151.2
X$22999 10742 10975 112 113 10681 NAND2_X2
* cell instance $23000 m0 *1 44.08,151.2
X$23000 10800 10801 10879 112 113 11048 OR3_X2
* cell instance $23001 m0 *1 45.22,151.2
X$23001 10977 11048 10795 112 113 11046 NAND3_X2
* cell instance $23004 r0 *1 34.01,151.2
X$23004 10967 113 10803 112 BUF_X4
* cell instance $23005 r0 *1 35.34,151.2
X$23005 10794 112 113 10547 INV_X8
* cell instance $23007 r0 *1 37.24,151.2
X$23007 10969 10798 11174 112 113 10970 NOR3_X1
* cell instance $23008 r0 *1 38,151.2
X$23008 11039 11176 10797 112 113 10799 NAND3_X1
* cell instance $23009 r0 *1 38.76,151.2
X$23009 10107 112 113 10969 CLKBUF_X3
* cell instance $23011 r0 *1 40.09,151.2
X$23011 11170 10972 10968 112 10978 113 AOI21_X1
* cell instance $23012 r0 *1 40.85,151.2
X$23012 10981 11177 11045 113 10977 112 OAI21_X1
* cell instance $23013 r0 *1 41.61,151.2
X$23013 10875 10973 10682 11090 11091 11045 113 112 AOI221_X2
* cell instance $23014 r0 *1 43.7,151.2
X$23014 11046 10877 11253 11180 11093 10029 113 112 AOI221_X2
* cell instance $23015 r0 *1 45.79,151.2
X$23015 10224 112 113 10509 BUF_X2
* cell instance $23017 r0 *1 46.74,151.2
X$23017 11092 10554 10320 10803 10548 112 113 10979 AOI221_X1
* cell instance $23019 m0 *1 46.93,151.2
X$23019 10802 10748 10320 10803 10978 10980 113 112 AOI221_X2
* cell instance $23021 r0 *1 48.26,151.2
X$23021 10980 10680 11060 10981 113 11183 112 OR4_X2
* cell instance $23022 m0 *1 50.16,151.2
X$23022 10106 10401 10226 10891 10225 10892 113 112 AOI221_X2
* cell instance $23023 m0 *1 49.4,151.2
X$23023 10512 11054 10746 113 10555 112 OAI21_X1
* cell instance $23024 m0 *1 52.25,151.2
X$23024 10228 10982 112 113 10639 NOR2_X2
* cell instance $23025 m0 *1 53.2,151.2
X$23025 10984 10230 10226 112 10804 113 AOI21_X2
* cell instance $23026 m0 *1 54.53,151.2
X$23026 10226 113 11058 112 BUF_X4
* cell instance $23027 m0 *1 55.86,151.2
X$23027 10326 10454 112 113 10796 NOR2_X2
* cell instance $23028 m0 *1 56.81,151.2
X$23028 10890 10805 10987 10897 113 112 10899 AND4_X1
* cell instance $23029 m0 *1 57.95,151.2
X$23029 10326 112 113 10983 CLKBUF_X3
* cell instance $23031 m0 *1 59.09,151.2
X$23031 10410 11401 10899 10806 10901 10989 113 112 AOI221_X2
* cell instance $23034 r0 *1 49.59,151.2
X$23034 10557 10806 112 113 11093 NOR2_X2
* cell instance $23035 r0 *1 50.54,151.2
X$23035 11037 10317 113 112 11054 AND2_X1
* cell instance $23037 r0 *1 51.49,151.2
X$23037 10982 9867 10026 113 112 10802 OAI21_X2
* cell instance $23038 r0 *1 52.82,151.2
X$23038 11097 11094 112 113 11189 NOR2_X1
* cell instance $23039 r0 *1 53.39,151.2
X$23039 10983 10231 112 113 11188 NOR2_X1
* cell instance $23041 r0 *1 54.15,151.2
X$23041 10390 10983 10167 112 10986 113 AOI21_X1
* cell instance $23042 r0 *1 54.91,151.2
X$23042 10986 11192 112 113 11194 NOR2_X1
* cell instance $23043 r0 *1 55.48,151.2
X$23043 10887 10981 11194 11060 113 11098 112 NOR4_X2
* cell instance $23044 r0 *1 57.19,151.2
X$23044 11197 11036 10988 112 113 10987 NAND3_X1
* cell instance $23046 r0 *1 58.33,151.2
X$23046 10104 9867 10026 113 112 10988 OAI21_X4
* cell instance $23048 r0 *1 61.56,151.2
X$23048 10795 11199 11200 113 112 10901 OAI21_X2
* cell instance $23050 m0 *1 62.32,151.2
X$23050 10906 10902 10553 112 113 NOR2_X4
* cell instance $23052 r0 *1 63.08,151.2
X$23052 10228 113 10967 112 BUF_X4
* cell instance $23053 m0 *1 64.6,151.2
X$23053 10904 10990 112 10320 113 NAND2_X4
* cell instance $23055 m0 *1 66.31,151.2
X$23055 10906 112 113 10904 INV_X2
* cell instance $23056 m0 *1 66.88,151.2
X$23056 8734 10808 112 113 10806 XNOR2_X2
* cell instance $23057 m0 *1 68.78,151.2
X$23057 4163 10686 112 113 10991 NAND2_X1
* cell instance $23058 m0 *1 69.35,151.2
X$23058 10991 10908 10237 113 112 10990 MUX2_X2
* cell instance $23059 m0 *1 71.06,151.2
X$23059 4163 8994 112 113 10908 NAND2_X1
* cell instance $23061 m0 *1 71.82,151.2
X$23061 10907 10909 10237 113 112 10902 MUX2_X2
* cell instance $23064 r0 *1 64.41,151.2
X$23064 112 11197 10967 10904 10990 113 AOI21_X4
* cell instance $23066 r0 *1 67.07,151.2
X$23066 10808 8734 113 10739 112 XOR2_X2
* cell instance $23072 r0 *1 69.92,151.2
X$23072 8855 8994 113 11202 112 XOR2_X2
* cell instance $23076 r0 *1 73.72,151.2
X$23076 10992 112 113 8036 CLKBUF_X3
* cell instance $23078 m0 *1 78.28,151.2
X$23078 112 10562 10915 3672 10914 10687 113 OAI211_X4
* cell instance $23079 m0 *1 76.95,151.2
X$23079 10809 113 9419 112 BUF_X4
* cell instance $23082 m0 *1 82.08,151.2
X$23082 10687 10075 10917 10562 112 113 11064 AOI211_X4
* cell instance $23084 m0 *1 84.17,151.2
X$23084 10811 10993 8040 3989 9114 11067 113 112 AOI221_X2
* cell instance $23085 m0 *1 86.26,151.2
X$23085 6239 9114 113 112 10994 AND2_X2
* cell instance $23088 r0 *1 84.55,151.2
X$23088 112 10566 10772 8040 11206 10994 113 OAI22_X4
* cell instance $23090 m0 *1 87.59,151.2
X$23090 112 10812 113 10772 BUF_X8
* cell instance $23091 r0 *1 87.78,151.2
X$23091 8864 10922 10566 10691 3989 11209 113 112 AOI221_X2
* cell instance $23093 r0 *1 90.25,151.2
X$23093 11101 10813 10692 10691 8862 11212 113 112 AOI221_X2
* cell instance $23094 m0 *1 92.15,151.2
X$23094 10325 3989 112 113 10813 NAND2_X2
* cell instance $23095 m0 *1 90.44,151.2
X$23095 10813 9630 112 11068 113 NAND2_X4
* cell instance $23096 m0 *1 93.1,151.2
X$23096 8862 10325 113 112 10927 AND2_X1
* cell instance $23097 m0 *1 93.86,151.2
X$23097 112 16752 10567 10928 9870 113 DFF_X1
* cell instance $23099 m0 *1 103.17,151.2
X$23099 10929 112 113 8819 CLKBUF_X3
* cell instance $23102 r0 *1 92.34,151.2
X$23102 9630 112 113 11101 BUF_X1
* cell instance $23105 r0 *1 95.19,151.2
X$23105 10691 5120 112 10993 113 NAND2_X4
* cell instance $23106 r0 *1 96.9,151.2
X$23106 11215 112 113 8734 CLKBUF_X3
* cell instance $23108 r0 *1 98.61,151.2
X$23108 11226 112 113 7645 BUF_X2
* cell instance $23111 r0 *1 101.08,151.2
X$23111 11264 112 113 8994 CLKBUF_X3
* cell instance $23112 r0 *1 102.03,151.2
X$23112 8133 112 113 10465 CLKBUF_X3
* cell instance $23113 r0 *1 102.98,151.2
X$23113 112 17013 11226 11221 10465 113 DFF_X1
* cell instance $23114 m0 *1 106.21,151.2
X$23114 10930 11103 10956 112 113 10568 NAND3_X1
* cell instance $23116 m0 *1 106.97,151.2
X$23116 11224 10933 10821 9701 10694 113 112 10931 OAI221_X1
* cell instance $23117 m0 *1 108.11,151.2
X$23117 10814 10934 10816 112 10933 113 AOI21_X1
* cell instance $23118 m0 *1 108.87,151.2
X$23118 10305 9971 10937 112 113 10934 NAND3_X1
* cell instance $23120 m0 *1 109.82,151.2
X$23120 9935 10536 112 113 10995 NOR2_X1
* cell instance $23123 m0 *1 112.67,151.2
X$23123 10257 10470 9593 9873 10943 10815 113 112 AOI221_X2
* cell instance $23124 m0 *1 114.76,151.2
X$23124 10441 10822 10817 112 113 10943 MUX2_X1
* cell instance $23126 m0 *1 116.28,151.2
X$23126 10942 10819 11084 10335 113 112 9285 AND4_X2
* cell instance $23128 m0 *1 119.13,151.2
X$23128 10250 10348 10476 10247 10696 11086 113 112 AOI221_X2
* cell instance $23129 m0 *1 121.22,151.2
X$23129 10820 10127 112 113 10823 NOR2_X1
* cell instance $23130 m0 *1 121.79,151.2
X$23130 10817 112 113 10256 INV_X2
* cell instance $23131 m0 *1 122.36,151.2
X$23131 10789 11082 10823 113 10819 112 OAI21_X1
* cell instance $23135 r0 *1 107.35,151.2
X$23135 10998 10571 10702 112 113 11103 NAND3_X1
* cell instance $23138 r0 *1 109.06,151.2
X$23138 10998 9967 10200 112 113 10816 NAND3_X1
* cell instance $23139 r0 *1 109.82,151.2
X$23139 11081 10995 10305 113 11370 112 OAI21_X1
* cell instance $23140 r0 *1 110.58,151.2
X$23140 9941 10662 9734 112 113 11081 NOR3_X1
* cell instance $23142 r0 *1 112.1,151.2
X$23142 10574 9973 113 112 11374 XNOR2_X1
* cell instance $23144 r0 *1 114,151.2
X$23144 10201 11085 112 113 11105 NOR2_X1
* cell instance $23147 r0 *1 115.52,151.2
X$23147 10348 10817 10245 112 11106 113 AOI21_X1
* cell instance $23149 r0 *1 117.04,151.2
X$23149 9734 11239 11083 113 11107 112 OAI21_X1
* cell instance $23150 r0 *1 117.8,151.2
X$23150 11112 10243 10245 112 113 11085 NOR3_X1
* cell instance $23151 r0 *1 118.56,151.2
X$23151 11086 11108 11241 112 11087 113 AOI21_X1
* cell instance $23152 r0 *1 119.32,151.2
X$23152 11110 10077 10121 112 11241 113 AOI21_X1
* cell instance $23153 r0 *1 120.08,151.2
X$23153 11270 11087 11246 10699 11244 11242 112 113 OAI221_X2
* cell instance $23154 r0 *1 122.17,151.2
X$23154 9964 10470 9934 10702 9982 11083 113 112 AOI221_X2
* cell instance $23155 m0 *1 123.69,151.2
X$23155 10670 10474 10824 112 113 10996 MUX2_X1
* cell instance $23158 m0 *1 126.54,151.2
X$23158 10065 10821 10578 113 112 10955 AND3_X1
* cell instance $23159 m0 *1 127.49,151.2
X$23159 10955 10954 10953 112 113 10251 NOR3_X1
* cell instance $23160 m0 *1 128.25,151.2
X$23160 10956 10997 10825 113 112 10953 AND3_X1
* cell instance $23162 m0 *1 130.72,151.2
X$23162 9939 10352 10574 112 10999 113 AOI21_X1
* cell instance $23165 m0 *1 132.43,151.2
X$23165 10960 10476 112 113 11078 NAND2_X1
* cell instance $23166 m0 *1 133,151.2
X$23166 11080 11079 10704 112 113 10932 OR3_X2
* cell instance $23167 m0 *1 134.14,151.2
X$23167 10827 11078 9632 9936 10963 112 113 11079 AOI221_X1
* cell instance $23172 r0 *1 124.26,151.2
X$23172 9962 11113 112 113 11246 OR2_X2
* cell instance $23173 r0 *1 125.21,151.2
X$23173 9979 11112 112 113 11111 NOR2_X2
* cell instance $23177 r0 *1 127.49,151.2
X$23177 10580 10213 10439 112 11114 113 AOI21_X1
* cell instance $23179 r0 *1 128.44,151.2
X$23179 10580 11426 10198 113 10997 112 OAI21_X1
* cell instance $23180 r0 *1 129.2,151.2
X$23180 10077 10348 10065 113 11115 112 OAI21_X1
* cell instance $23184 r0 *1 130.72,151.2
X$23184 10243 10121 112 113 11080 NAND2_X2
* cell instance $23185 r0 *1 131.67,151.2
X$23185 10776 10829 11000 113 112 10998 OAI21_X4
* cell instance $23186 r0 *1 134.14,151.2
X$23186 112 11000 10247 10829 10703 113 NOR3_X4
* cell instance $23187 m0 *1 135.85,151.2
X$23187 10708 112 113 10466 CLKBUF_X3
* cell instance $23190 r0 *1 136.8,151.2
X$23190 10777 11001 11240 112 113 11112 MUX2_X1
* cell instance $23191 m0 *1 137.37,151.2
X$23191 11001 10829 11000 113 112 10708 OAI21_X2
* cell instance $23193 m0 *1 138.7,151.2
X$23193 10340 10473 10937 10708 113 112 10828 OAI22_X1
* cell instance $23197 r0 *1 138.7,151.2
X$23197 10777 10829 11000 113 112 10661 OAI21_X4
* cell instance $23199 m0 *1 140.03,151.2
X$23199 10096 113 10829 112 BUF_X4
* cell instance $23202 m0 *1 143.83,151.2
X$23202 10830 3672 112 113 11076 NAND2_X1
* cell instance $23205 r0 *1 141.17,151.2
X$23205 10136 113 11000 112 BUF_X4
* cell instance $23208 r0 *1 144.78,151.2
X$23208 112 10709 11076 8388 11238 10711 113 OAI211_X4
* cell instance $23209 m0 *1 145.73,151.2
X$23209 10774 10709 10831 112 11077 113 AOI21_X2
* cell instance $23211 m0 *1 147.06,151.2
X$23211 10711 4161 10831 10709 112 113 11075 AOI211_X4
* cell instance $23212 m0 *1 149.15,151.2
X$23212 10583 7930 10964 112 113 10832 MUX2_X1
* cell instance $23213 m0 *1 150.48,151.2
X$23213 3678 10851 112 113 11074 OR2_X1
* cell instance $23217 m0 *1 158.27,151.2
X$23217 112 16780 10929 11069 10586 113 DFF_X1
* cell instance $23220 r0 *1 148.01,151.2
X$23220 112 11118 11074 8388 11276 11002 113 OAI211_X4
* cell instance $23221 r0 *1 151.24,151.2
X$23221 10851 8388 112 113 11235 NAND2_X1
* cell instance $23225 r0 *1 156.75,151.2
X$23225 11005 10835 112 113 11120 NOR2_X1
* cell instance $23228 r0 *1 157.89,151.2
X$23228 11125 11003 112 113 11122 NOR2_X1
* cell instance $23229 r0 *1 158.46,151.2
X$23229 11004 112 113 11072 CLKBUF_X3
* cell instance $23230 r0 *1 159.41,151.2
X$23230 11004 11234 113 112 11381 AND2_X1
* cell instance $23235 r0 *1 163.02,151.2
X$23235 11233 11232 11127 113 9740 112 NOR3_X2
* cell instance $23236 r0 *1 164.35,151.2
X$23236 11138 113 11123 112 BUF_X4
* cell instance $23238 m0 *1 164.92,151.2
X$23238 10834 113 10835 112 BUF_X4
* cell instance $23240 m0 *1 169.48,151.2
X$23240 10833 10835 112 113 11009 NAND2_X1
* cell instance $23241 m0 *1 170.05,151.2
X$23241 10836 112 113 11004 CLKBUF_X3
* cell instance $23243 m0 *1 171.19,151.2
X$23243 10957 113 10951 112 BUF_X4
* cell instance $23244 m0 *1 172.52,151.2
X$23244 10951 11010 112 113 10833 NOR2_X2
* cell instance $23245 m0 *1 173.47,151.2
X$23245 10834 11218 113 112 11219 AND2_X1
* cell instance $23246 m0 *1 174.23,151.2
X$23246 10951 10952 112 113 11005 NAND2_X2
* cell instance $23247 m0 *1 175.18,151.2
X$23247 10952 113 11003 112 BUF_X4
* cell instance $23249 r0 *1 165.68,151.2
X$23249 11128 11072 112 113 11375 NAND2_X1
* cell instance $23251 r0 *1 166.44,151.2
X$23251 11007 11006 11231 112 11066 113 AOI21_X1
* cell instance $23255 r0 *1 168.53,151.2
X$23255 11230 11008 11227 113 11228 112 OAI21_X1
* cell instance $23257 r0 *1 169.48,151.2
X$23257 11009 11228 11225 11131 113 112 11223 OAI22_X1
* cell instance $23258 r0 *1 170.43,151.2
X$23258 11065 11216 11223 11071 113 11069 112 OR4_X2
* cell instance $23259 r0 *1 171.76,151.2
X$23259 11066 10951 11220 10835 113 11071 112 NOR4_X2
* cell instance $23260 r0 *1 173.47,151.2
X$23260 11063 11219 11005 11133 11123 11065 113 112 AOI221_X2
* cell instance $23261 r0 *1 175.56,151.2
X$23261 11217 11214 11134 10951 11135 11216 113 112 AOI221_X2
* cell instance $23262 m0 *1 178.6,151.2
X$23262 11010 113 11007 112 BUF_X4
* cell instance $23263 m0 *1 176.89,151.2
X$23263 8939 10415 113 11010 112 XOR2_X2
* cell instance $23265 m0 *1 180.69,151.2
X$23265 10950 10837 7924 113 112 11013 MUX2_X2
* cell instance $23267 m0 *1 182.59,151.2
X$23267 10839 6185 10761 112 113 10941 MUX2_X1
* cell instance $23268 m0 *1 183.92,151.2
X$23268 10944 10939 6185 113 112 11139 MUX2_X2
* cell instance $23269 m0 *1 185.63,151.2
X$23269 112 11294 113 10941 BUF_X8
* cell instance $23270 m0 *1 188.1,151.2
X$23270 10841 10844 10075 10842 10936 113 112 AOI211_X2
* cell instance $23271 m0 *1 189.81,151.2
X$23271 112 10844 10843 4676 11362 10842 113 OAI211_X4
* cell instance $23273 r0 *1 177.65,151.2
X$23273 11291 113 11126 112 BUF_X4
* cell instance $23274 r0 *1 178.98,151.2
X$23274 11210 10836 112 113 11063 OR2_X2
* cell instance $23279 r0 *1 180.31,151.2
X$23279 10713 113 11138 112 BUF_X4
* cell instance $23280 r0 *1 181.64,151.2
X$23280 11012 10834 10949 113 11364 112 OAI21_X1
* cell instance $23282 r0 *1 182.78,151.2
X$23282 11207 11140 11291 112 113 NOR2_X4
* cell instance $23284 r0 *1 184.68,151.2
X$23284 112 8268 11012 113 INV_X16
* cell instance $23286 r0 *1 188.1,151.2
X$23286 8522 8577 10484 112 113 11141 OR3_X4
* cell instance $23287 r0 *1 190.19,151.2
X$23287 11203 11297 5231 10845 11205 113 112 AOI211_X2
* cell instance $23288 r0 *1 191.9,151.2
X$23288 10846 11015 11062 4950 11295 113 112 AOI211_X2
* cell instance $23289 m0 *1 193.61,151.2
X$23289 5648 11015 113 10850 112 XOR2_X2
* cell instance $23291 m0 *1 195.32,151.2
X$23291 6183 5573 112 113 11062 XOR2_X1
* cell instance $23293 m0 *1 196.65,151.2
X$23293 112 16914 10851 11061 10847 113 DFF_X1
* cell instance $23294 m0 *1 199.88,151.2
X$23294 10851 7930 10872 112 113 11061 MUX2_X1
* cell instance $23295 m0 *1 201.21,151.2
X$23295 10515 10044 10852 113 112 11059 OAI21_X2
* cell instance $23298 r0 *1 193.61,151.2
X$23298 10757 7362 112 113 11203 NOR2_X1
* cell instance $23300 r0 *1 194.37,151.2
X$23300 10848 11201 10849 4950 11456 113 112 AOI211_X2
* cell instance $23301 r0 *1 196.08,151.2
X$23301 11015 112 113 11201 INV_X1
* cell instance $23304 r0 *1 198.74,151.2
X$23304 112 10515 10756 11016 11017 113 NOR3_X4
* cell instance $23305 r0 *1 201.4,151.2
X$23305 11059 10755 11142 112 113 11356 MUX2_X1
* cell instance $23307 r0 *1 203.49,151.2
X$23307 11142 11143 113 112 10747 AND2_X1
* cell instance $23309 m0 *1 204.63,151.2
X$23309 112 10285 10925 10916 11018 10924 113 OR4_X4
* cell instance $23311 m0 *1 207.1,151.2
X$23311 10603 11019 113 112 10925 AND2_X2
* cell instance $23313 m0 *1 208.24,151.2
X$23313 10921 10492 11057 11148 113 10718 112 NOR4_X2
* cell instance $23315 m0 *1 210.14,151.2
X$23315 10905 10719 112 113 11462 NOR2_X1
* cell instance $23316 m0 *1 210.71,151.2
X$23316 10918 11021 112 113 10912 NOR2_X1
* cell instance $23317 m0 *1 211.28,151.2
X$23317 10855 10862 10919 10856 11056 10916 113 112 AOI221_X2
* cell instance $23320 r0 *1 205.96,151.2
X$23320 10637 11146 11198 113 11057 112 OAI21_X1
* cell instance $23322 r0 *1 207.1,151.2
X$23322 10492 11508 11195 113 112 10854 AND3_X1
* cell instance $23323 r0 *1 208.05,151.2
X$23323 11145 11020 10637 112 113 11198 NAND3_X1
* cell instance $23326 r0 *1 209.38,151.2
X$23326 10884 11151 11149 11017 11150 10855 113 112 AOI221_X2
* cell instance $23330 r0 *1 212.8,151.2
X$23330 11022 11309 11023 113 11055 112 OAI21_X1
* cell instance $23331 r0 *1 213.56,151.2
X$23331 11025 11187 9768 10608 11185 10633 113 112 AOI221_X2
* cell instance $23333 m0 *1 213.75,151.2
X$23333 10593 10860 11024 112 10857 113 AOI21_X1
* cell instance $23334 m0 *1 214.7,151.2
X$23334 11026 10858 112 113 11027 NAND2_X2
* cell instance $23335 m0 *1 215.65,151.2
X$23335 11055 11030 112 113 10596 NAND2_X1
* cell instance $23336 m0 *1 216.22,151.2
X$23336 11053 10864 112 113 11028 NAND2_X1
* cell instance $23337 m0 *1 216.79,151.2
X$23337 11028 11052 10593 10860 11049 113 112 10861 OAI221_X1
* cell instance $23338 m0 *1 217.93,151.2
X$23338 10727 11044 10603 10861 112 10627 113 NAND4_X2
* cell instance $23340 m0 *1 219.83,151.2
X$23340 11029 10720 11026 112 113 11047 NAND3_X2
* cell instance $23341 m0 *1 221.16,151.2
X$23341 10626 10488 112 113 10862 NOR2_X1
* cell instance $23343 m0 *1 221.92,151.2
X$23343 11156 11030 11031 10863 10856 11044 112 113 OAI221_X2
* cell instance $23344 m0 *1 224.01,151.2
X$23344 11042 10863 10606 10860 11041 113 112 10881 OAI221_X1
* cell instance $23346 r0 *1 215.65,151.2
X$23346 11151 11154 11051 11050 11149 10856 112 113 11185 OAI33_X1
* cell instance $23347 r0 *1 216.98,151.2
X$23347 11150 11021 10626 113 11051 112 OAI21_X1
* cell instance $23348 r0 *1 217.74,151.2
X$23348 11049 11029 112 113 11050 NOR2_X1
* cell instance $23350 r0 *1 218.5,151.2
X$23350 11030 11179 11047 113 10605 112 OAI21_X1
* cell instance $23351 r0 *1 219.26,151.2
X$23351 11047 11182 10610 112 113 11153 NAND3_X2
* cell instance $23352 r0 *1 220.59,151.2
X$23352 112 10883 10860 11161 11182 11032 113 OAI211_X4
* cell instance $23353 r0 *1 223.82,151.2
X$23353 11021 11026 112 113 11031 NAND2_X2
* cell instance $23355 r0 *1 224.96,151.2
X$23355 10864 10883 112 11042 113 NAND2_X4
* cell instance $23356 m0 *1 226.29,151.2
X$23356 10864 113 10860 112 BUF_X4
* cell instance $23357 m0 *1 225.53,151.2
X$23357 11032 10884 113 112 11041 AND2_X1
* cell instance $23359 m0 *1 227.81,151.2
X$23359 11021 112 113 11030 CLKBUF_X3
* cell instance $23361 m0 *1 228.95,151.2
X$23361 10727 10373 112 113 11163 NAND2_X1
* cell instance $23364 m0 *1 230.47,151.2
X$23364 10859 112 113 10491 CLKBUF_X3
* cell instance $23366 r0 *1 226.67,151.2
X$23366 11175 11032 11038 113 11033 112 OAI21_X1
* cell instance $23367 r0 *1 227.43,151.2
X$23367 11159 11033 10492 113 11165 112 OAI21_X1
* cell instance $23368 r0 *1 228.19,151.2
X$23368 10859 11172 11042 113 11326 112 NOR3_X2
* cell instance $23370 r0 *1 229.9,151.2
X$23370 10626 113 10856 112 BUF_X4
* cell instance $23371 r0 *1 231.23,151.2
X$23371 112 16978 10874 11319 10376 113 DFF_X1
* cell instance $23372 m0 *1 231.99,151.2
X$23372 10874 113 9887 112 BUF_X4
* cell instance $23375 m0 *1 234.08,151.2
X$23375 10733 112 113 9663 BUF_X1
* cell instance $23385 r0 *1 236.93,151.2
X$23385 10495 112 113 11034 BUF_X1
* cell instance $23386 m0 *1 237.5,151.2
X$23386 10867 112 113 10872 BUF_X1
* cell instance $23389 m0 *1 238.26,151.2
X$23389 10734 112 113 9903 BUF_X1
* cell instance $23395 r0 *1 238.07,151.2
X$23395 11166 112 113 9665 BUF_X1
* cell instance $23398 r0 *1 239.21,151.2
X$23398 10868 112 113 10281 BUF_X1
* cell instance $23401 m0 *1 15.2,168
X$23401 12730 112 113 11323 BUF_X1
* cell instance $23405 m0 *1 34.2,168
X$23405 10450 10314 16563 113 112 12790 HA_X1
* cell instance $23406 m0 *1 36.1,168
X$23406 12099 12181 12574 113 12791 112 OAI21_X1
* cell instance $23407 m0 *1 36.86,168
X$23407 10453 10451 11395 10452 112 113 12574 NAND4_X1
* cell instance $23408 m0 *1 37.81,168
X$23408 10451 11258 10453 112 11036 113 NAND3_X4
* cell instance $23410 m0 *1 40.47,168
X$23410 10453 10451 9952 112 113 12793 NAND3_X2
* cell instance $23412 m0 *1 41.99,168
X$23412 10453 10451 10807 10803 11393 12576 113 112 AOI221_X2
* cell instance $23413 m0 *1 44.08,168
X$23413 10406 10409 11719 112 113 NOR2_X4
* cell instance $23427 r0 *1 31.54,168
X$23427 112 10230 13067 113 BUF_X16
* cell instance $23429 r0 *1 36.48,168
X$23429 12790 112 113 10891 CLKBUF_X3
* cell instance $23431 r0 *1 37.62,168
X$23431 11398 10618 10677 113 112 12796 AND3_X1
* cell instance $23433 r0 *1 38.76,168
X$23433 12795 12731 12456 112 12794 113 AOI21_X1
* cell instance $23435 r0 *1 39.71,168
X$23435 11720 10682 112 113 12795 NAND2_X1
* cell instance $23437 r0 *1 40.47,168
X$23437 10807 10457 112 113 12896 NOR2_X1
* cell instance $23438 r0 *1 41.04,168
X$23438 12796 12732 12458 113 12734 112 OAI21_X1
* cell instance $23439 r0 *1 41.8,168
X$23439 11479 11036 10802 112 12732 113 AOI21_X1
* cell instance $23441 r0 *1 42.75,168
X$23441 10873 10106 11719 9952 112 113 12798 AOI22_X2
* cell instance $23442 r0 *1 44.46,168
X$23442 11817 12798 10739 12794 12180 12900 113 112 AOI221_X2
* cell instance $23443 m0 *1 46.93,168
X$23443 10797 10280 11334 12581 112 113 12656 AOI22_X1
* cell instance $23444 m0 *1 46.17,168
X$23444 11724 12375 12580 113 12646 112 OAI21_X1
* cell instance $23446 r0 *1 46.55,168
X$23446 11093 12458 112 113 12579 NAND2_X1
* cell instance $23447 r0 *1 47.12,168
X$23447 11258 10873 10030 112 113 12852 MUX2_X1
* cell instance $23448 m0 *1 49.02,168
X$23448 10460 112 113 12106 INV_X8
* cell instance $23449 m0 *1 48.26,168
X$23449 12581 12733 10635 113 12648 112 OAI21_X1
* cell instance $23450 m0 *1 50.73,168
X$23450 12953 12655 11183 112 113 12528 NAND3_X2
* cell instance $23453 r0 *1 48.64,168
X$23453 11334 12583 11955 113 12733 112 OAI21_X1
* cell instance $23454 r0 *1 49.4,168
X$23454 11328 112 113 12904 BUF_X1
* cell instance $23456 r0 *1 50.16,168
X$23456 10794 9867 10026 113 112 11487 OAI21_X4
* cell instance $23457 m0 *1 52.63,168
X$23457 10982 12022 12460 12583 10681 113 112 12736 OAI221_X1
* cell instance $23459 m0 *1 53.77,168
X$23459 10635 12738 12654 113 12655 112 OAI21_X1
* cell instance $23460 m0 *1 54.53,168
X$23460 11720 10739 112 113 10897 NOR2_X1
* cell instance $23462 r0 *1 52.63,168
X$23462 10554 10982 112 113 12524 NAND2_X1
* cell instance $23463 r0 *1 53.2,168
X$23463 11881 12736 12734 112 12737 113 AOI21_X1
* cell instance $23464 r0 *1 53.96,168
X$23464 12115 12802 12737 112 113 12908 NOR3_X1
* cell instance $23465 r0 *1 54.72,168
X$23465 10512 10315 112 113 12184 NAND2_X1
* cell instance $23467 m0 *1 56.24,168
X$23467 12463 12584 12259 112 12654 113 AOI21_X1
* cell instance $23468 m0 *1 55.48,168
X$23468 12583 12656 112 113 12661 OR2_X1
* cell instance $23469 m0 *1 57,168
X$23469 11254 10795 112 113 12463 NAND2_X1
* cell instance $23471 m0 *1 58.33,168
X$23471 11944 10320 9952 112 113 12586 MUX2_X1
* cell instance $23472 m0 *1 59.66,168
X$23472 12585 11487 11724 12583 112 113 12659 NAND4_X1
* cell instance $23474 m0 *1 60.8,168
X$23474 12181 10231 11192 112 12740 113 AOI21_X1
* cell instance $23475 m0 *1 61.56,168
X$23475 12587 12659 12661 12458 112 113 12742 NAND4_X1
* cell instance $23476 m0 *1 62.51,168
X$23476 12660 12662 12019 112 113 12537 NAND3_X1
* cell instance $23479 m0 *1 65.55,168
X$23479 112 16911 10235 12806 10234 113 DFF_X1
* cell instance $23482 r0 *1 55.48,168
X$23482 12739 12803 12908 112 113 12806 NAND3_X1
* cell instance $23484 r0 *1 56.43,168
X$23484 11255 11192 11398 113 12909 112 OAI21_X1
* cell instance $23485 r0 *1 57.19,168
X$23485 12466 12854 10897 113 12803 112 OAI21_X1
* cell instance $23487 r0 *1 58.14,168
X$23487 10682 10315 12179 112 113 12855 NAND3_X1
* cell instance $23488 r0 *1 58.9,168
X$23488 10983 11393 11399 112 12912 113 AOI21_X1
* cell instance $23489 r0 *1 59.66,168
X$23489 10618 10800 112 113 12913 NOR2_X1
* cell instance $23491 r0 *1 60.61,168
X$23491 12913 12740 12583 112 113 12741 NOR3_X1
* cell instance $23493 r0 *1 61.56,168
X$23493 10406 11724 12186 112 113 12587 NAND3_X1
* cell instance $23494 r0 *1 62.32,168
X$23494 10795 12900 12742 112 11830 113 AOI21_X1
* cell instance $23501 m0 *1 70.87,168
X$23501 112 10531 12663 113 INV_X16
* cell instance $23503 m0 *1 74.1,168
X$23503 11995 112 113 12588 INV_X2
* cell instance $23504 m0 *1 74.67,168
X$23504 11572 12588 12471 113 12589 112 OAI21_X1
* cell instance $23505 m0 *1 75.43,168
X$23505 12591 11664 10658 10810 113 12809 112 NOR4_X2
* cell instance $23506 m0 *1 77.14,168
X$23506 12672 11732 12809 10658 12744 12199 113 112 AOI221_X2
* cell instance $23508 m0 *1 79.42,168
X$23508 12590 12685 12395 12471 113 112 12672 OAI22_X1
* cell instance $23510 m0 *1 80.56,168
X$23510 11070 12673 12592 112 12745 113 AOI21_X1
* cell instance $23511 m0 *1 81.32,168
X$23511 11583 12546 12590 12593 113 112 12674 OAI22_X1
* cell instance $23512 m0 *1 82.27,168
X$23512 11360 112 113 12590 CLKBUF_X3
* cell instance $23513 m0 *1 83.22,168
X$23513 12677 11406 10810 12594 12815 112 113 12595 AOI221_X1
* cell instance $23514 m0 *1 84.36,168
X$23514 12680 12678 11732 112 113 13133 NOR3_X1
* cell instance $23515 m0 *1 85.12,168
X$23515 11576 11521 12596 113 12815 112 OAI21_X1
* cell instance $23516 m0 *1 85.88,168
X$23516 11262 12681 12596 112 12818 113 AOI21_X1
* cell instance $23520 r0 *1 71.82,168
X$23520 11521 113 12591 112 BUF_X4
* cell instance $23521 r0 *1 73.15,168
X$23521 11573 113 12592 112 BUF_X4
* cell instance $23522 r0 *1 74.48,168
X$23522 12032 11995 12807 12589 12590 112 113 12743 AOI221_X1
* cell instance $23523 r0 *1 75.62,168
X$23523 12469 12591 12032 113 12920 112 OAI21_X1
* cell instance $23526 r0 *1 77.52,168
X$23526 12920 12858 12859 112 113 12744 NAND3_X1
* cell instance $23527 r0 *1 78.28,168
X$23527 10810 11669 12592 112 113 12859 NAND3_X1
* cell instance $23528 r0 *1 79.04,168
X$23528 11209 11513 112 113 12861 NOR2_X1
* cell instance $23530 r0 *1 79.99,168
X$23530 12395 12857 12190 113 13010 112 OAI21_X1
* cell instance $23531 r0 *1 80.75,168
X$23531 11209 112 113 12468 BUF_X1
* cell instance $23533 r0 *1 81.51,168
X$23533 12313 10658 12469 11407 12745 12814 113 112 AOI221_X2
* cell instance $23535 r0 *1 83.79,168
X$23535 12813 12814 12477 12857 12136 113 112 12926 OAI221_X1
* cell instance $23537 r0 *1 85.31,168
X$23537 12135 12863 12818 112 113 12864 OR3_X1
* cell instance $23540 r0 *1 87.4,168
X$23540 12817 12036 112 113 12866 NAND2_X2
* cell instance $23541 r0 *1 88.35,168
X$23541 12929 11844 10810 12594 12866 12748 113 112 AOI221_X2
* cell instance $23542 m0 *1 88.73,168
X$23542 12142 12597 12594 112 113 12680 NOR3_X1
* cell instance $23544 m0 *1 89.49,168
X$23544 12822 12316 11732 113 12820 112 NOR3_X2
* cell instance $23545 m0 *1 90.82,168
X$23545 12592 12596 11515 112 12822 113 AOI21_X1
* cell instance $23547 m0 *1 91.77,168
X$23547 11359 12685 12320 11888 12689 113 112 12686 OAI221_X1
* cell instance $23549 m0 *1 93.1,168
X$23549 12474 12597 112 113 12689 NOR2_X1
* cell instance $23550 m0 *1 93.67,168
X$23550 11661 12598 12597 112 113 12599 OR3_X4
* cell instance $23554 r0 *1 90.63,168
X$23554 12746 12319 12270 112 113 12192 NAND3_X1
* cell instance $23555 r0 *1 91.39,168
X$23555 10811 10993 12747 112 113 12746 NAND3_X2
* cell instance $23557 r0 *1 93.1,168
X$23557 12474 11512 12133 112 113 12749 NOR3_X1
* cell instance $23558 r0 *1 93.86,168
X$23558 11070 11360 11521 112 12934 113 AOI21_X1
* cell instance $23559 r0 *1 94.62,168
X$23559 11678 12934 12599 113 12825 112 OAI21_X1
* cell instance $23560 r0 *1 95.38,168
X$23560 12746 12036 112 113 12936 NAND2_X2
* cell instance $23562 r0 *1 96.71,168
X$23562 12748 11663 12750 112 12826 113 AOI21_X1
* cell instance $23563 r0 *1 97.47,168
X$23563 12599 12273 12751 113 112 12750 OAI21_X2
* cell instance $23564 m0 *1 97.85,168
X$23564 11884 12600 12601 113 12690 112 OAI21_X1
* cell instance $23566 m0 *1 98.61,168
X$23566 12602 12692 11884 113 12601 112 OAI21_X1
* cell instance $23569 m0 *1 106.97,168
X$23569 10340 11753 11243 113 12604 112 OAI21_X1
* cell instance $23570 m0 *1 107.73,168
X$23570 12604 10702 12698 112 113 12562 MUX2_X1
* cell instance $23571 m0 *1 109.06,168
X$23571 10213 9934 9965 113 12698 112 OAI21_X1
* cell instance $23574 r0 *1 99.18,168
X$23574 12548 12135 12826 112 113 12867 MUX2_X1
* cell instance $23577 r0 *1 106.78,168
X$23577 10213 11753 10571 113 12752 112 OAI21_X1
* cell instance $23579 r0 *1 107.92,168
X$23579 12752 9873 12829 112 113 12827 MUX2_X1
* cell instance $23581 r0 *1 109.63,168
X$23581 10470 11753 11243 113 12829 112 OAI21_X1
* cell instance $23582 m0 *1 110.39,168
X$23582 9873 10781 11243 113 112 12754 AND3_X1
* cell instance $23586 r0 *1 110.39,168
X$23586 12754 10068 12940 112 12833 113 AOI21_X1
* cell instance $23587 r0 *1 111.15,168
X$23587 12755 10536 11713 112 12940 113 AOI21_X1
* cell instance $23589 r0 *1 112.1,168
X$23589 12755 10788 12868 112 12325 113 AOI21_X1
* cell instance $23590 m0 *1 112.67,168
X$23590 10074 12833 12701 113 12152 112 OAI21_X1
* cell instance $23592 m0 *1 113.43,168
X$23592 10346 10347 10340 112 113 12755 NOR3_X1
* cell instance $23593 m0 *1 114.19,168
X$23593 10098 10346 10347 113 112 9965 OAI21_X4
* cell instance $23594 m0 *1 116.66,168
X$23594 12005 12702 12606 10305 12482 113 112 12701 OAI221_X1
* cell instance $23595 m0 *1 117.8,168
X$23595 9934 9830 112 113 12702 OR2_X1
* cell instance $23597 m0 *1 118.75,168
X$23597 10476 12608 10346 10347 12758 12703 112 113 OAI221_X2
* cell instance $23599 m0 *1 121.03,168
X$23599 9964 10250 112 113 12606 NOR2_X1
* cell instance $23602 r0 *1 113.62,168
X$23602 9873 10213 112 113 12869 NOR2_X1
* cell instance $23603 r0 *1 114.19,168
X$23603 12869 12005 10788 112 113 12756 NOR3_X1
* cell instance $23604 r0 *1 114.95,168
X$23604 9733 10098 9969 112 113 NOR2_X4
* cell instance $23605 r0 *1 116.66,168
X$23605 10777 112 113 12045 INV_X1
* cell instance $23606 r0 *1 117.04,168
X$23606 12045 10822 12607 112 113 12941 MUX2_X1
* cell instance $23607 r0 *1 118.37,168
X$23607 12836 12758 12757 11713 112 113 12330 AOI22_X1
* cell instance $23608 r0 *1 119.32,168
X$23608 9940 12607 112 113 12758 NAND2_X1
* cell instance $23609 r0 *1 119.89,168
X$23609 10065 9967 12448 112 12871 113 AOI21_X1
* cell instance $23610 r0 *1 120.65,168
X$23610 9969 10822 12607 112 113 12759 NOR3_X1
* cell instance $23612 r0 *1 121.6,168
X$23612 10473 10474 10777 112 113 13035 NOR3_X1
* cell instance $23614 m0 *1 121.98,168
X$23614 10696 10216 113 112 12836 AND2_X1
* cell instance $23615 m0 *1 123.5,168
X$23615 9876 12485 9830 112 113 12710 OR3_X1
* cell instance $23617 m0 *1 124.64,168
X$23617 9979 12710 12328 112 12843 113 AOI21_X1
* cell instance $23620 r0 *1 122.74,168
X$23620 12760 112 113 12607 INV_X4
* cell instance $23621 r0 *1 123.69,168
X$23621 10440 112 113 11753 CLKBUF_X3
* cell instance $23627 r0 *1 125.21,168
X$23627 9979 112 113 10439 CLKBUF_X3
* cell instance $23628 m0 *1 127.11,168
X$23628 12005 10447 112 113 12761 NOR2_X2
* cell instance $23629 m0 *1 125.78,168
X$23629 10701 9979 9982 112 113 12713 MUX2_X1
* cell instance $23630 m0 *1 128.06,168
X$23630 12762 11899 12713 10065 10821 12714 112 113 OAI221_X2
* cell instance $23632 r0 *1 126.16,168
X$23632 12846 12843 10474 112 113 11711 OR3_X2
* cell instance $23633 r0 *1 127.3,168
X$23633 10349 113 9827 112 BUF_X4
* cell instance $23634 r0 *1 128.63,168
X$23634 10447 113 9974 112 BUF_X4
* cell instance $23638 m0 *1 12.16,156.8
X$23638 11633 112 113 11556 BUF_X1
* cell instance $23641 m0 *1 19.76,156.8
X$23641 112 16870 11633 11564 11557 113 DFF_X1
* cell instance $23657 r0 *1 23.56,156.8
X$23657 6050 112 113 11557 CLKBUF_X3
* cell instance $23658 r0 *1 24.51,156.8
X$23658 11557 112 113 17177 INV_X2
* cell instance $23661 m0 *1 33.44,156.8
X$23661 112 11716 113 10794 BUF_X8
* cell instance $23663 m0 *1 35.91,156.8
X$23663 10968 10225 112 113 11559 NAND2_X1
* cell instance $23664 m0 *1 36.48,156.8
X$23664 10453 10451 10224 112 113 11250 NAND3_X2
* cell instance $23665 m0 *1 37.81,156.8
X$23665 10640 113 11479 112 BUF_X4
* cell instance $23667 m0 *1 39.33,156.8
X$23667 10225 112 113 11394 CLKBUF_X3
* cell instance $23668 m0 *1 40.28,156.8
X$23668 10630 11058 10677 113 11561 112 OAI21_X1
* cell instance $23672 r0 *1 37.81,156.8
X$23672 10807 10968 112 113 11717 NOR2_X1
* cell instance $23673 r0 *1 38.38,156.8
X$23673 10550 10512 112 113 11558 NAND2_X1
* cell instance $23674 r0 *1 38.95,156.8
X$23674 112 11037 11641 11719 10450 11718 11559 11813 113 OAI222_X2
* cell instance $23675 m0 *1 43.51,156.8
X$23675 10105 11251 10404 10450 11559 113 112 11562 OAI221_X1
* cell instance $23676 m0 *1 41.42,156.8
X$23676 11642 10684 11645 11486 11644 11253 113 112 AOI221_X2
* cell instance $23678 m0 *1 44.84,156.8
X$23678 11036 10550 11395 112 113 11488 NAND3_X1
* cell instance $23679 m0 *1 45.6,156.8
X$23679 10968 11092 112 113 11489 NOR2_X2
* cell instance $23681 r0 *1 41.61,156.8
X$23681 10681 11560 11720 10741 11561 11870 113 112 AOI221_X2
* cell instance $23682 r0 *1 43.7,156.8
X$23682 11558 10742 11720 11394 11561 113 112 11815 OAI221_X1
* cell instance $23683 r0 *1 44.84,156.8
X$23683 10618 11037 112 113 11647 NAND2_X1
* cell instance $23684 r0 *1 45.41,156.8
X$23684 11332 11558 11489 10396 113 112 11819 OAI22_X2
* cell instance $23686 m0 *1 46.93,156.8
X$23686 11395 10550 10317 112 11650 113 AOI21_X1
* cell instance $23687 r0 *1 47.12,156.8
X$23687 10460 112 113 10975 INV_X8
* cell instance $23689 m0 *1 48.07,156.8
X$23689 10108 11955 10742 11328 10225 10968 112 113 11490 OAI33_X1
* cell instance $23690 r0 *1 48.83,156.8
X$23690 11393 10988 10983 112 11956 113 AOI21_X1
* cell instance $23691 r0 *1 49.59,156.8
X$23691 10618 10975 10968 113 112 11722 OAI21_X2
* cell instance $23692 m0 *1 50.35,156.8
X$23692 11652 11394 11097 10322 10406 11563 113 112 AOI221_X2
* cell instance $23693 m0 *1 49.78,156.8
X$23693 10891 112 113 10982 INV_X2
* cell instance $23695 r0 *1 50.92,156.8
X$23695 10107 10319 112 113 11392 NOR2_X1
* cell instance $23696 r0 *1 51.49,156.8
X$23696 10798 11399 112 113 11651 NAND2_X1
* cell instance $23697 r0 *1 52.06,156.8
X$23697 10640 11058 10624 113 112 11820 OAI21_X4
* cell instance $23698 m0 *1 53.39,156.8
X$23698 10976 11394 10167 112 11497 113 AOI21_X1
* cell instance $23699 m0 *1 52.82,156.8
X$23699 11399 10557 112 113 11097 NAND2_X1
* cell instance $23700 m0 *1 54.15,156.8
X$23700 11395 11255 112 113 11655 OR2_X1
* cell instance $23702 m0 *1 55.1,156.8
X$23702 11655 11565 10404 11398 10683 113 112 11503 OAI221_X1
* cell instance $23704 m0 *1 56.43,156.8
X$23704 11503 11566 11343 112 113 11397 NAND3_X1
* cell instance $23706 r0 *1 54.53,156.8
X$23706 11479 11647 11820 11565 11720 11821 112 113 OAI221_X2
* cell instance $23707 r0 *1 56.62,156.8
X$23707 11196 113 11823 112 BUF_X4
* cell instance $23708 m0 *1 58.52,156.8
X$23708 10806 11826 11505 112 11401 113 AOI21_X1
* cell instance $23709 m0 *1 57.57,156.8
X$23709 11399 112 113 10800 CLKBUF_X3
* cell instance $23711 m0 *1 59.47,156.8
X$23711 11727 11567 11506 11402 11395 113 112 11505 OAI221_X1
* cell instance $23713 r0 *1 57.95,156.8
X$23713 11392 11196 112 113 11825 OR2_X1
* cell instance $23715 r0 *1 58.9,156.8
X$23715 11568 11091 10618 113 112 11728 AND3_X1
* cell instance $23716 r0 *1 59.85,156.8
X$23716 11569 10969 112 113 11567 NOR2_X1
* cell instance $23717 r0 *1 60.42,156.8
X$23717 10969 11725 112 113 11570 NOR2_X1
* cell instance $23719 m0 *1 61.94,156.8
X$23719 10906 10902 11398 11570 11332 113 112 11571 OAI221_X1
* cell instance $23720 m0 *1 60.99,156.8
X$23720 10320 112 113 11399 CLKBUF_X3
* cell instance $23723 r0 *1 61.37,156.8
X$23723 11570 10742 112 113 11729 NOR2_X1
* cell instance $23724 r0 *1 61.94,156.8
X$23724 11197 11568 10807 113 11828 112 OAI21_X1
* cell instance $23725 r0 *1 62.7,156.8
X$23725 11569 10315 112 113 11730 NAND2_X1
* cell instance $23728 r0 *1 63.84,156.8
X$23728 10989 11830 11731 11832 113 112 11658 OAI22_X1
* cell instance $23729 m0 *1 64.41,156.8
X$23729 8626 8199 113 11564 112 XOR2_X2
* cell instance $23737 r0 *1 66.88,156.8
X$23737 112 17058 11833 11658 11099 113 DFF_X1
* cell instance $23743 m0 *1 70.3,156.8
X$23743 11834 112 113 8199 CLKBUF_X3
* cell instance $23745 r0 *1 70.49,156.8
X$23745 11833 112 113 8622 BUF_X2
* cell instance $23747 m0 *1 72.58,156.8
X$23747 112 10658 113 10531 BUF_X8
* cell instance $23751 r0 *1 75.05,156.8
X$23751 11572 113 11669 112 BUF_X4
* cell instance $23752 m0 *1 75.62,156.8
X$23752 11099 112 113 17157 INV_X2
* cell instance $23754 m0 *1 76.19,156.8
X$23754 8133 112 113 11099 CLKBUF_X3
* cell instance $23756 m0 *1 77.33,156.8
X$23756 11403 113 11572 112 BUF_X4
* cell instance $23757 m0 *1 78.66,156.8
X$23757 11404 112 113 11735 INV_X8
* cell instance $23758 m0 *1 80.37,156.8
X$23758 112 11512 11404 10811 10993 113 AOI21_X4
* cell instance $23760 r0 *1 76.38,156.8
X$23760 11661 112 113 11583 CLKBUF_X3
* cell instance $23761 r0 *1 77.33,156.8
X$23761 11572 113 11665 112 BUF_X4
* cell instance $23762 r0 *1 78.66,156.8
X$23762 11404 11406 113 112 11733 AND2_X1
* cell instance $23763 r0 *1 79.42,156.8
X$23763 11736 113 11661 112 BUF_X4
* cell instance $23764 r0 *1 80.75,156.8
X$23764 11573 112 113 11577 CLKBUF_X3
* cell instance $23765 r0 *1 81.7,156.8
X$23765 11663 11978 12030 113 11836 112 OAI21_X1
* cell instance $23766 r0 *1 82.46,156.8
X$23766 11664 11573 11515 113 11980 112 OAI21_X1
* cell instance $23768 m0 *1 83.79,156.8
X$23768 10994 8040 11405 11665 11407 113 112 11738 OAI221_X1
* cell instance $23769 m0 *1 83.22,156.8
X$23769 8864 10922 112 113 11666 NAND2_X1
* cell instance $23770 m0 *1 84.93,156.8
X$23770 8040 10994 11574 113 11575 112 NOR3_X2
* cell instance $23771 m0 *1 86.26,156.8
X$23771 112 11668 11575 11577 11576 113 AOI21_X4
* cell instance $23772 m0 *1 88.73,156.8
X$23772 10812 113 11578 112 BUF_X4
* cell instance $23773 m0 *1 90.06,156.8
X$23773 11671 11517 11262 113 11579 112 OAI21_X1
* cell instance $23774 m0 *1 90.82,156.8
X$23774 11512 11070 11577 113 11580 112 OAI21_X1
* cell instance $23775 m0 *1 91.58,156.8
X$23775 11577 11673 11409 112 11742 113 AOI21_X1
* cell instance $23777 m0 *1 92.53,156.8
X$23777 11410 11578 11407 113 11673 112 OAI21_X1
* cell instance $23778 m0 *1 93.29,156.8
X$23778 11575 11411 11412 112 11582 113 AOI21_X1
* cell instance $23779 m0 *1 94.05,156.8
X$23779 11412 10926 112 113 11675 NAND2_X1
* cell instance $23780 m0 *1 94.62,156.8
X$23780 11678 11409 113 112 11412 AND2_X1
* cell instance $23782 m0 *1 95.57,156.8
X$23782 11521 11574 112 113 11414 NAND2_X1
* cell instance $23783 m0 *1 96.14,156.8
X$23783 11413 11411 112 113 11893 NAND2_X1
* cell instance $23784 m0 *1 96.71,156.8
X$23784 11413 11414 11262 112 113 11677 NAND3_X1
* cell instance $23785 m0 *1 97.47,156.8
X$23785 11583 11414 11409 113 112 11680 AND3_X1
* cell instance $23789 m0 *1 106.21,156.8
X$23789 9701 9971 10127 112 113 11415 NAND3_X1
* cell instance $23790 m0 *1 106.97,156.8
X$23790 11535 11415 10240 113 11416 112 OAI21_X1
* cell instance $23793 r0 *1 84.17,156.8
X$23793 11666 113 11573 112 BUF_X4
* cell instance $23794 r0 *1 85.5,156.8
X$23794 11666 112 113 11736 INV_X2
* cell instance $23797 r0 *1 87.02,156.8
X$23797 11261 11576 11408 112 11739 113 NAND3_X4
* cell instance $23798 r0 *1 89.49,156.8
X$23798 10922 8864 11517 11669 11734 112 113 11740 AOI221_X1
* cell instance $23800 r0 *1 91.01,156.8
X$23800 11839 11580 11841 113 112 11843 AND3_X1
* cell instance $23802 r0 *1 92.34,156.8
X$23802 11409 11886 12270 112 113 11841 NAND3_X1
* cell instance $23804 r0 *1 93.29,156.8
X$23804 11843 11581 11582 112 11676 113 AOI21_X1
* cell instance $23806 r0 *1 94.43,156.8
X$23806 11675 11677 11581 11744 112 113 11745 NAND4_X1
* cell instance $23808 r0 *1 95.57,156.8
X$23808 11408 11261 11844 112 113 11409 NAND3_X1
* cell instance $23811 r0 *1 96.9,156.8
X$23811 11583 11739 10926 112 11679 113 AOI21_X1
* cell instance $23812 r0 *1 97.66,156.8
X$23812 11583 112 113 11262 CLKBUF_X3
* cell instance $23813 r0 *1 98.61,156.8
X$23813 11679 11680 11839 113 11895 112 OAI21_X1
* cell instance $23817 r0 *1 106.02,156.8
X$23817 11415 11102 11850 112 11584 113 AOI21_X1
* cell instance $23818 r0 *1 106.78,156.8
X$23818 11424 12418 11585 112 113 11848 NAND3_X1
* cell instance $23820 r0 *1 107.73,156.8
X$23820 11584 11587 11416 113 11585 112 OAI21_X1
* cell instance $23821 m0 *1 109.25,156.8
X$23821 11588 11687 9701 113 11532 112 OAI21_X1
* cell instance $23822 m0 *1 108.11,156.8
X$23822 11586 10253 9701 11528 11533 113 112 11685 OAI221_X1
* cell instance $23823 m0 *1 110.01,156.8
X$23823 10340 11543 9941 10439 11689 112 113 11687 AOI221_X1
* cell instance $23824 m0 *1 111.15,156.8
X$23824 11543 10439 9941 112 11589 113 AOI21_X1
* cell instance $23825 m0 *1 111.91,156.8
X$23825 10937 11589 9935 10814 11692 113 112 11694 OAI221_X1
* cell instance $23826 m0 *1 113.05,156.8
X$23826 11418 10127 11694 112 11545 113 AOI21_X1
* cell instance $23829 r0 *1 108.49,156.8
X$23829 11543 11266 112 113 11851 NAND2_X1
* cell instance $23830 r0 *1 109.06,156.8
X$23830 9962 11686 11851 112 11588 113 AOI21_X1
* cell instance $23831 r0 *1 109.82,156.8
X$23831 9969 10788 112 113 12001 NAND2_X1
* cell instance $23834 r0 *1 112.1,156.8
X$23834 11701 10127 11853 112 11587 113 AOI21_X1
* cell instance $23835 r0 *1 112.86,156.8
X$23835 10342 11590 112 113 11695 NAND2_X1
* cell instance $23837 r0 *1 113.62,156.8
X$23837 10439 11695 11747 112 11696 113 AOI21_X1
* cell instance $23840 m0 *1 115.52,156.8
X$23840 10125 10305 9966 10256 10473 113 112 11420 OAI221_X1
* cell instance $23841 m0 *1 114.95,156.8
X$23841 11418 11419 112 113 10945 NOR2_X1
* cell instance $23842 m0 *1 116.66,156.8
X$23842 11420 9943 112 113 11701 NAND2_X1
* cell instance $23844 r0 *1 114.95,156.8
X$23844 11696 11591 11425 112 113 11419 NOR3_X1
* cell instance $23845 r0 *1 115.71,156.8
X$23845 10245 11699 10067 112 11591 113 AOI21_X1
* cell instance $23846 r0 *1 116.47,156.8
X$23846 10342 10777 112 113 11699 NAND2_X1
* cell instance $23849 m0 *1 117.61,156.8
X$23849 11422 11702 10442 112 11542 113 AOI21_X1
* cell instance $23851 m0 *1 119.32,156.8
X$23851 11273 10127 112 113 11705 NOR2_X1
* cell instance $23852 m0 *1 119.89,156.8
X$23852 112 11423 10996 11424 11705 11706 11750 11545 113 AOI222_X2
* cell instance $23853 m0 *1 122.55,156.8
X$23853 11592 11389 10068 113 11686 112 OAI21_X1
* cell instance $23854 m0 *1 123.31,156.8
X$23854 9974 10125 112 113 11550 NOR2_X1
* cell instance $23855 m0 *1 123.88,156.8
X$23855 9827 9982 112 113 11593 NOR2_X1
* cell instance $23858 r0 *1 118.94,156.8
X$23858 112 10536 113 10701 BUF_X8
* cell instance $23859 r0 *1 121.41,156.8
X$23859 9940 11592 10777 11543 112 113 11858 AOI22_X1
* cell instance $23861 r0 *1 122.55,156.8
X$23861 11543 11550 9942 10442 11593 11751 113 112 AOI221_X2
* cell instance $23866 m0 *1 125.02,156.8
X$23866 11427 9940 112 113 11551 NAND2_X1
* cell instance $23870 m0 *1 129.58,156.8
X$23870 10476 112 113 10574 CLKBUF_X3
* cell instance $23871 m0 *1 127.49,156.8
X$23871 11425 11864 11712 10253 11711 10080 112 113 OAI221_X2
* cell instance $23872 m0 *1 130.53,156.8
X$23872 11865 10826 112 113 11706 OR2_X1
* cell instance $23873 m0 *1 131.29,156.8
X$23873 10304 10256 112 113 11427 NAND2_X2
* cell instance $23880 r0 *1 130.72,156.8
X$23880 11755 11713 10999 112 11594 113 AOI21_X1
* cell instance $23881 r0 *1 131.48,156.8
X$23881 11080 11594 10074 11715 9980 12174 112 113 OAI221_X2
* cell instance $23882 m0 *1 133.38,156.8
X$23882 11714 11425 11274 112 113 11544 OR3_X2
* cell instance $23883 m0 *1 132.62,156.8
X$23883 11429 11266 10442 112 11692 113 AOI21_X1
* cell instance $23884 m0 *1 134.52,156.8
X$23884 9940 11426 11429 113 11714 112 NOR3_X2
* cell instance $23887 m0 *1 136.8,156.8
X$23887 112 10776 10347 10346 11429 113 NOR3_X4
* cell instance $23888 m0 *1 139.46,156.8
X$23888 112 11001 11000 10829 11543 113 NOR3_X4
* cell instance $23891 r0 *1 133.57,156.8
X$23891 11428 11110 11756 112 11715 113 AOI21_X1
* cell instance $23894 r0 *1 135.47,156.8
X$23894 112 11592 11427 10254 10355 113 AOI21_X4
* cell instance $23899 m0 *1 143.45,156.8
X$23899 5250 11597 112 113 11595 NOR2_X1
* cell instance $23901 m0 *1 144.02,156.8
X$23901 8434 11598 112 113 11710 NOR2_X1
* cell instance $23903 m0 *1 144.78,156.8
X$23903 11597 112 113 11598 INV_X1
* cell instance $23907 m0 *1 155.8,156.8
X$23907 11707 11430 11072 113 11547 112 OAI21_X1
* cell instance $23908 m0 *1 156.56,156.8
X$23908 11431 112 113 11708 BUF_X1
* cell instance $23910 m0 *1 157.32,156.8
X$23910 11288 11527 11432 112 11707 113 AOI21_X1
* cell instance $23911 m0 *1 158.08,156.8
X$23911 11283 11433 11432 113 11546 112 OAI21_X1
* cell instance $23912 m0 *1 158.84,156.8
X$23912 11703 11437 11546 112 11704 113 AOI21_X1
* cell instance $23913 m0 *1 159.6,156.8
X$23913 11549 11704 11455 11293 11522 113 112 11436 OAI221_X1
* cell instance $23915 m0 *1 161.5,156.8
X$23915 11438 11278 11698 11697 11123 11700 113 112 AOI221_X2
* cell instance $23916 m0 *1 163.59,156.8
X$23916 11691 11523 113 112 11440 AND2_X2
* cell instance $23917 m0 *1 164.54,156.8
X$23917 11442 11449 11437 11284 113 112 11541 OAI22_X1
* cell instance $23919 r0 *1 143.64,156.8
X$23919 11710 11595 6209 113 112 11596 MUX2_X2
* cell instance $23920 r0 *1 145.35,156.8
X$23920 4163 11597 112 113 11758 NAND2_X1
* cell instance $23921 r0 *1 145.92,156.8
X$23921 4163 11598 112 113 11759 NAND2_X1
* cell instance $23923 r0 *1 147.25,156.8
X$23923 11866 5708 112 113 11599 NOR2_X1
* cell instance $23926 r0 *1 148.77,156.8
X$23926 10357 11760 113 9462 112 XOR2_X2
* cell instance $23930 r0 *1 153.14,156.8
X$23930 11709 11600 113 112 11862 AND2_X2
* cell instance $23933 r0 *1 154.66,156.8
X$23933 11536 11708 11765 112 11709 113 AOI21_X1
* cell instance $23934 r0 *1 155.42,156.8
X$23934 11861 11860 113 112 11430 AND2_X1
* cell instance $23935 r0 *1 156.18,156.8
X$23935 112 11762 113 11431 BUF_X8
* cell instance $23936 r0 *1 158.65,156.8
X$23936 11536 11537 11601 112 11435 113 AOI21_X1
* cell instance $23937 r0 *1 159.41,156.8
X$23937 11602 11763 11764 113 11383 112 OAI21_X1
* cell instance $23938 r0 *1 160.17,156.8
X$23938 11526 11600 11537 112 113 11764 NAND3_X1
* cell instance $23939 r0 *1 160.93,156.8
X$23939 11684 11446 11603 113 11763 112 OAI21_X1
* cell instance $23941 r0 *1 161.88,156.8
X$23941 11603 11526 112 113 11604 NAND2_X1
* cell instance $23942 r0 *1 162.45,156.8
X$23942 11602 11604 11536 11601 11693 112 113 11769 AOI221_X1
* cell instance $23943 r0 *1 163.59,156.8
X$23943 11287 11138 11855 112 113 11606 NAND3_X1
* cell instance $23944 r0 *1 164.35,156.8
X$23944 11693 11606 11771 112 11605 113 AOI21_X1
* cell instance $23945 r0 *1 165.11,156.8
X$23945 11446 10834 11600 112 113 11771 NAND3_X1
* cell instance $23946 m0 *1 166.06,156.8
X$23946 11440 11765 11441 112 113 11529 MUX2_X1
* cell instance $23950 m0 *1 168.34,156.8
X$23950 11688 10951 11126 112 113 11539 NAND3_X1
* cell instance $23951 m0 *1 169.1,156.8
X$23951 11607 11442 11539 112 11443 113 AOI21_X1
* cell instance $23953 r0 *1 165.87,156.8
X$23953 11431 112 113 11691 BUF_X1
* cell instance $23956 r0 *1 168.34,156.8
X$23956 11690 11444 11437 11522 113 112 11377 OAI22_X1
* cell instance $23958 r0 *1 170.05,156.8
X$23958 11762 11432 11126 11684 11608 113 112 11773 OAI221_X1
* cell instance $23960 m0 *1 170.24,156.8
X$23960 11522 11444 113 112 11608 AND2_X1
* cell instance $23961 m0 *1 171.19,156.8
X$23961 11773 11283 11683 113 112 11849 OAI21_X2
* cell instance $23963 m0 *1 172.71,156.8
X$23963 11523 11531 11447 113 112 11444 OAI21_X4
* cell instance $23964 m0 *1 175.18,156.8
X$23964 11012 11444 11289 11291 113 112 11609 OAI22_X1
* cell instance $23965 m0 *1 176.13,156.8
X$23965 11012 11531 11447 113 112 11527 OAI21_X4
* cell instance $23966 m0 *1 178.6,156.8
X$23966 11451 11453 11294 113 112 11525 OAI21_X4
* cell instance $23967 m0 *1 181.07,156.8
X$23967 11451 112 113 11674 BUF_X1
* cell instance $23968 m0 *1 181.64,156.8
X$23968 8670 113 11611 112 BUF_X4
* cell instance $23969 m0 *1 182.97,156.8
X$23969 11670 11293 112 113 11672 NOR2_X1
* cell instance $23970 m0 *1 183.54,156.8
X$23970 11611 112 113 11451 BUF_X1
* cell instance $23971 m0 *1 184.11,156.8
X$23971 11139 11667 11454 112 11522 113 NAND3_X4
* cell instance $23972 m0 *1 186.58,156.8
X$23972 11519 112 113 11667 BUF_X1
* cell instance $23973 m0 *1 187.15,156.8
X$23973 11523 11295 11456 113 112 11455 OAI21_X4
* cell instance $23976 r0 *1 171.38,156.8
X$23976 11774 11681 11125 11847 11849 11682 113 112 AOI221_X2
* cell instance $23978 r0 *1 173.66,156.8
X$23978 11003 11123 112 113 11847 NOR2_X1
* cell instance $23979 r0 *1 174.23,156.8
X$23979 11448 11609 11846 11537 112 113 11681 AOI22_X2
* cell instance $23980 r0 *1 175.94,156.8
X$23980 11367 11777 11526 11126 113 112 11846 OAI22_X2
* cell instance $23981 r0 *1 177.65,156.8
X$23981 11523 11012 112 113 11842 NOR2_X2
* cell instance $23983 r0 *1 178.98,156.8
X$23983 11779 113 11601 112 BUF_X4
* cell instance $23987 r0 *1 180.31,156.8
X$23987 11610 11455 11012 11013 11452 11838 113 112 AOI221_X2
* cell instance $23989 r0 *1 182.59,156.8
X$23989 11291 11523 112 113 11777 NAND2_X2
* cell instance $23990 r0 *1 183.54,156.8
X$23990 11139 11452 11013 11454 112 11782 113 NAND4_X2
* cell instance $23992 r0 *1 185.44,156.8
X$23992 11454 11139 11523 112 113 11783 NAND3_X1
* cell instance $23994 r0 *1 186.39,156.8
X$23994 11139 113 11784 112 BUF_X4
* cell instance $23995 r0 *1 187.72,156.8
X$23995 11454 113 11780 112 BUF_X4
* cell instance $23998 r0 *1 189.62,156.8
X$23998 8516 8933 113 10713 112 XOR2_X2
* cell instance $23999 m0 *1 192.47,156.8
X$23999 10847 112 113 17161 INV_X2
* cell instance $24000 m0 *1 190,156.8
X$24000 112 11453 113 11518 BUF_X8
* cell instance $24001 m0 *1 193.04,156.8
X$24001 8434 10367 112 113 11457 NAND2_X1
* cell instance $24002 m0 *1 193.61,156.8
X$24002 11459 11458 112 113 11516 NAND2_X1
* cell instance $24003 m0 *1 194.18,156.8
X$24003 11457 11458 112 113 11612 NOR2_X1
* cell instance $24006 m0 *1 196.46,156.8
X$24006 112 11786 113 11298 BUF_X8
* cell instance $24008 m0 *1 199.69,156.8
X$24008 112 11299 10756 11016 11463 113 NOR3_X4
* cell instance $24010 m0 *1 202.54,156.8
X$24010 11299 11346 112 113 11142 NAND2_X1
* cell instance $24013 m0 *1 204.06,156.8
X$24013 11299 112 113 11303 CLKBUF_X3
* cell instance $24014 m0 *1 205.01,156.8
X$24014 11460 10755 112 113 11618 NAND2_X2
* cell instance $24017 r0 *1 192.85,156.8
X$24017 112 11454 11612 11458 11459 113 AOI21_X4
* cell instance $24018 r0 *1 195.32,156.8
X$24018 11835 112 113 11458 BUF_X2
* cell instance $24021 r0 *1 197.22,156.8
X$24021 112 11785 113 11361 BUF_X8
* cell instance $24023 r0 *1 200.45,156.8
X$24023 11613 113 11460 112 BUF_X4
* cell instance $24024 r0 *1 201.78,156.8
X$24024 11785 11786 11299 112 113 11616 NAND3_X2
* cell instance $24027 r0 *1 204.06,156.8
X$24027 11656 11347 112 113 11614 NAND2_X1
* cell instance $24028 r0 *1 204.63,156.8
X$24028 11659 11615 10856 11831 11018 113 112 AOI211_X2
* cell instance $24029 m0 *1 207.48,156.8
X$24029 11305 11338 112 113 11660 NOR2_X1
* cell instance $24030 m0 *1 206.34,156.8
X$24030 11614 11660 10608 11150 11314 113 112 11508 OAI221_X1
* cell instance $24032 m0 *1 208.24,156.8
X$24032 11347 113 11157 112 BUF_X4
* cell instance $24033 m0 *1 209.57,156.8
X$24033 11464 10492 112 113 11827 NOR2_X1
* cell instance $24036 r0 *1 206.53,156.8
X$24036 11616 112 113 11308 CLKBUF_X3
* cell instance $24037 r0 *1 207.48,156.8
X$24037 10859 9768 112 113 11659 NAND2_X1
* cell instance $24038 r0 *1 208.05,156.8
X$24038 11151 10594 112 113 11617 NAND2_X1
* cell instance $24039 r0 *1 208.62,156.8
X$24039 11829 11617 11157 10885 11618 112 113 11657 AOI221_X1
* cell instance $24040 r0 *1 209.76,156.8
X$24040 11827 11816 11657 10608 112 113 11824 NOR4_X1
* cell instance $24042 m0 *1 210.52,156.8
X$24042 11157 11463 11022 11629 112 113 11464 AOI22_X1
* cell instance $24043 r0 *1 210.71,156.8
X$24043 112 10489 11619 11824 10634 113 NOR3_X4
* cell instance $24044 m0 *1 213.18,156.8
X$24044 11465 10595 11350 112 113 11502 NOR3_X1
* cell instance $24045 m0 *1 211.85,156.8
X$24045 11330 11656 11788 112 113 11654 MUX2_X1
* cell instance $24046 m0 *1 213.94,156.8
X$24046 10592 10006 112 113 11621 NAND2_X1
* cell instance $24047 m0 *1 214.51,156.8
X$24047 11463 10885 112 113 11467 NAND2_X1
* cell instance $24049 m0 *1 215.27,156.8
X$24049 11654 11335 10595 113 10900 112 OAI21_X1
* cell instance $24050 m0 *1 216.03,156.8
X$24050 11623 11932 10737 11029 11501 11307 113 112 AOI221_X2
* cell instance $24051 m0 *1 218.12,156.8
X$24051 11157 11463 10488 11029 11477 112 113 11498 AOI221_X1
* cell instance $24052 m0 *1 219.26,156.8
X$24052 10860 11623 11625 112 10725 113 AOI21_X1
* cell instance $24053 m0 *1 220.02,156.8
X$24053 11627 11625 11626 112 11495 113 AOI21_X1
* cell instance $24056 m0 *1 222.49,156.8
X$24056 10594 10488 112 113 11627 NAND2_X1
* cell instance $24057 m0 *1 223.06,156.8
X$24057 11314 11628 11331 11646 113 112 10738 OAI22_X1
* cell instance $24058 m0 *1 224.01,156.8
X$24058 10905 11629 112 113 11640 NOR2_X1
* cell instance $24061 m0 *1 225.53,156.8
X$24061 11040 11798 11485 112 11469 113 AOI21_X1
* cell instance $24062 m0 *1 226.29,156.8
X$24062 11484 11314 10606 11161 11483 113 112 11485 OAI221_X1
* cell instance $24064 m0 *1 227.62,156.8
X$24064 11172 11310 11643 112 11483 113 AOI21_X1
* cell instance $24065 m0 *1 228.38,156.8
X$24065 10610 11639 11471 11640 11161 113 112 11164 OAI221_X1
* cell instance $24066 m0 *1 229.52,156.8
X$24066 11637 11350 11172 112 11639 113 AOI21_X1
* cell instance $24067 m0 *1 230.28,156.8
X$24067 11038 11317 11477 113 112 11475 AND3_X1
* cell instance $24069 r0 *1 213.37,156.8
X$24069 11789 11620 11621 11353 11649 11466 113 112 AOI221_X2
* cell instance $24071 r0 *1 215.65,156.8
X$24071 10155 11787 11629 112 11622 113 AOI21_X2
* cell instance $24073 r0 *1 217.17,156.8
X$24073 11653 11621 10603 10900 11818 113 112 11499 OAI221_X1
* cell instance $24074 r0 *1 218.31,156.8
X$24074 10155 11150 11649 113 112 11478 OAI21_X2
* cell instance $24075 r0 *1 219.64,156.8
X$24075 11624 11305 11021 113 11626 112 OAI21_X1
* cell instance $24076 r0 *1 220.4,156.8
X$24076 11029 11346 112 113 11792 NOR2_X1
* cell instance $24077 r0 *1 220.97,156.8
X$24077 10372 11161 112 113 11954 NOR2_X1
* cell instance $24079 r0 *1 221.73,156.8
X$24079 11649 11157 112 113 11643 NOR2_X2
* cell instance $24081 r0 *1 223.06,156.8
X$24081 11017 11022 112 113 11795 NAND2_X1
* cell instance $24082 r0 *1 223.63,156.8
X$24082 11043 11032 112 113 10905 NOR2_X2
* cell instance $24084 r0 *1 226.1,156.8
X$24084 11306 11620 10606 11638 11807 11312 113 112 AOI221_X2
* cell instance $24085 r0 *1 228.19,156.8
X$24085 10722 10859 112 113 11803 NAND2_X1
* cell instance $24086 r0 *1 228.76,156.8
X$24086 11643 11317 11634 11310 113 112 11812 OAI22_X1
* cell instance $24087 r0 *1 229.71,156.8
X$24087 11306 11631 11638 112 113 11802 NAND3_X1
* cell instance $24088 r0 *1 230.47,156.8
X$24088 11812 11803 10603 11630 11808 113 112 11804 OAI221_X1
* cell instance $24090 m0 *1 231.61,156.8
X$24090 11475 11636 11627 112 113 11472 NOR3_X1
* cell instance $24091 m0 *1 232.56,156.8
X$24091 11806 11473 11635 112 11319 113 AOI21_X1
* cell instance $24094 r0 *1 231.61,156.8
X$24094 10599 10491 112 113 11630 NAND2_X1
* cell instance $24095 r0 *1 232.18,156.8
X$24095 11631 11023 113 112 11807 AND2_X1
* cell instance $24098 r0 *1 234.84,156.8
X$24098 11632 112 113 9441 BUF_X1
* cell instance $24104 r0 *1 237.12,156.8
X$24104 11320 112 113 11805 BUF_X1
* cell instance $24122 r0 *1 14.44,148.4
X$24122 10791 112 113 9613 BUF_X1
* cell instance $24128 m0 *1 23.56,148.4
X$24128 10676 8585 10615 112 113 10675 MUX2_X1
* cell instance $24131 r0 *1 23.56,148.4
X$24131 112 10675 10313 17260 10676 113 DFF_X2
* cell instance $24148 m0 *1 68.78,215.6
X$24148 14372 16023 112 113 15637 NOR2_X1
* cell instance $24149 m0 *1 69.35,215.6
X$24149 14708 14492 14543 113 15913 112 OAI21_X1
* cell instance $24150 m0 *1 70.11,215.6
X$24150 14546 15274 14987 112 15947 113 AOI21_X1
* cell instance $24151 m0 *1 70.87,215.6
X$24151 15917 15879 14497 113 15880 112 OAI21_X1
* cell instance $24152 m0 *1 71.63,215.6
X$24152 14936 15879 15398 15913 113 112 15980 OAI22_X1
* cell instance $24153 m0 *1 72.58,215.6
X$24153 14709 15882 14801 112 15714 113 NAND3_X4
* cell instance $24154 m0 *1 75.05,215.6
X$24154 112 15596 15882 14801 14709 113 AOI21_X4
* cell instance $24155 m0 *1 77.52,215.6
X$24155 14887 15826 15055 112 15983 113 AOI21_X1
* cell instance $24156 m0 *1 78.28,215.6
X$24156 15790 15826 112 113 15917 NAND2_X1
* cell instance $24157 m0 *1 78.85,215.6
X$24157 14713 14987 14542 15723 15918 15991 113 112 AOI221_X2
* cell instance $24158 m0 *1 80.94,215.6
X$24158 15988 15064 15883 113 15948 112 OAI21_X1
* cell instance $24175 r0 *1 65.93,215.6
X$24175 14987 15208 16664 113 112 16023 HA_X1
* cell instance $24180 r0 *1 68.02,215.6
X$24180 16023 16055 14712 112 113 NOR2_X4
* cell instance $24181 r0 *1 69.73,215.6
X$24181 15216 15947 15500 15879 15981 16057 112 113 OAI221_X2
* cell instance $24182 r0 *1 71.82,215.6
X$24182 15981 15773 16057 113 16062 112 OAI21_X1
* cell instance $24183 r0 *1 72.58,215.6
X$24183 15282 16058 14267 15980 112 113 16082 AOI22_X1
* cell instance $24184 r0 *1 73.53,215.6
X$24184 14607 15774 16025 112 15987 113 AOI21_X1
* cell instance $24185 r0 *1 74.29,215.6
X$24185 16059 15861 16062 112 113 15855 MUX2_X1
* cell instance $24189 r0 *1 76.95,215.6
X$24189 14656 15096 14717 112 15984 113 AOI21_X1
* cell instance $24190 r0 *1 77.71,215.6
X$24190 15984 15729 16063 112 113 15986 MUX2_X1
* cell instance $24192 r0 *1 79.42,215.6
X$24192 15987 16028 112 113 15719 OR2_X1
* cell instance $24194 r0 *1 80.56,215.6
X$24194 15398 14157 14656 113 112 16029 OAI21_X2
* cell instance $24195 r0 *1 81.89,215.6
X$24195 15717 15948 14560 15885 15990 113 112 15884 OAI221_X1
* cell instance $24196 m0 *1 82.65,215.6
X$24196 15885 15825 14717 15286 113 15949 112 NOR4_X2
* cell instance $24197 m0 *1 82.08,215.6
X$24197 14379 15216 112 113 15885 NAND2_X1
* cell instance $24198 m0 *1 84.36,215.6
X$24198 15991 15440 14807 112 113 15951 NOR3_X1
* cell instance $24201 r0 *1 83.03,215.6
X$24201 14989 15326 15211 113 16064 112 OAI21_X1
* cell instance $24203 r0 *1 83.98,215.6
X$24203 15590 15950 16065 112 16066 113 AOI21_X1
* cell instance $24204 r0 *1 84.74,215.6
X$24204 16027 15950 15183 14856 15399 15992 113 112 AOI221_X2
* cell instance $24206 r0 *1 87.02,215.6
X$24206 15729 15714 15952 112 15954 113 AOI21_X1
* cell instance $24207 m0 *1 87.21,215.6
X$24207 14765 15790 15826 112 15953 113 AOI21_X1
* cell instance $24210 m0 *1 88.73,215.6
X$24210 14990 15888 112 113 15994 NOR2_X1
* cell instance $24211 m0 *1 89.3,215.6
X$24211 15828 15887 15956 15924 15827 15996 113 112 AOI221_X2
* cell instance $24212 m0 *1 91.39,215.6
X$24212 14930 16000 15179 14987 15959 112 113 15960 AOI221_X1
* cell instance $24213 m0 *1 92.53,215.6
X$24213 14664 15293 112 113 15925 NOR2_X1
* cell instance $24214 m0 *1 93.1,215.6
X$24214 14987 14849 15861 15537 15961 113 112 15889 OAI221_X1
* cell instance $24215 m0 *1 94.24,215.6
X$24215 15860 14849 14856 113 15890 112 OAI21_X1
* cell instance $24216 m0 *1 95,215.6
X$24216 15064 15533 112 113 15891 NAND2_X1
* cell instance $24217 m0 *1 95.57,215.6
X$24217 15333 15790 15891 112 16004 113 AOI21_X1
* cell instance $24219 m0 *1 96.52,215.6
X$24219 15405 15891 15714 113 112 15928 AND3_X1
* cell instance $24221 r0 *1 87.78,215.6
X$24221 15994 15953 15717 14607 16165 15954 112 113 15955 OAI33_X1
* cell instance $24222 r0 *1 89.11,215.6
X$24222 14716 15951 15955 112 113 15999 OR3_X1
* cell instance $24223 r0 *1 90.06,215.6
X$24223 15281 14558 112 113 15957 NAND2_X1
* cell instance $24224 r0 *1 90.63,215.6
X$24224 15997 15958 15996 15999 112 113 13936 AOI22_X2
* cell instance $24225 r0 *1 92.34,215.6
X$24225 15992 15960 16002 112 15958 113 AOI21_X1
* cell instance $24226 r0 *1 93.1,215.6
X$24226 15861 14442 15889 113 16002 112 OAI21_X1
* cell instance $24227 r0 *1 93.86,215.6
X$24227 14157 15888 15333 112 113 16070 NOR3_X1
* cell instance $24228 r0 *1 94.62,215.6
X$24228 15596 15647 15961 112 113 NOR2_X4
* cell instance $24229 r0 *1 96.33,215.6
X$24229 14213 14891 112 113 16033 NOR2_X1
* cell instance $24230 r0 *1 96.9,215.6
X$24230 15962 16004 16033 112 113 14945 OR3_X1
* cell instance $24231 m0 *1 99.94,215.6
X$24231 15824 14498 112 113 15407 NOR2_X1
* cell instance $24232 m0 *1 97.85,215.6
X$24232 15861 15986 15928 15890 15407 15930 112 113 OAI221_X2
* cell instance $24237 r0 *1 97.85,215.6
X$24237 14558 14498 112 113 15962 NAND2_X1
* cell instance $24240 r0 *1 106.02,215.6
X$24240 15460 15001 112 113 16074 NAND2_X1
* cell instance $24241 m0 *1 107.35,215.6
X$24241 15893 14176 14132 112 113 15829 MUX2_X1
* cell instance $24242 m0 *1 106.21,215.6
X$24242 15893 15354 15117 14808 14723 113 112 15963 OAI221_X1
* cell instance $24243 m0 *1 108.68,215.6
X$24243 14565 14463 15893 14620 113 112 15964 OAI22_X1
* cell instance $24247 r0 *1 107.16,215.6
X$24247 15460 113 14386 112 BUF_X4
* cell instance $24250 m0 *1 110.2,215.6
X$24250 14723 14385 15117 14897 15894 113 112 16006 OAI221_X1
* cell instance $24252 m0 *1 111.34,215.6
X$24252 14051 14499 15895 113 15935 112 OAI21_X1
* cell instance $24255 m0 *1 116.66,215.6
X$24255 14389 14723 112 113 15831 NAND2_X1
* cell instance $24256 m0 *1 117.23,215.6
X$24256 15652 112 113 14723 CLKBUF_X3
* cell instance $24258 m0 *1 118.37,215.6
X$24258 15117 15896 15945 16039 113 112 15073 OAI22_X1
* cell instance $24261 r0 *1 111.15,215.6
X$24261 14866 16077 16006 113 15545 112 OAI21_X1
* cell instance $24262 r0 *1 111.91,215.6
X$24262 15935 14463 14279 14869 15964 112 113 16035 AOI221_X1
* cell instance $24264 r0 *1 113.24,215.6
X$24264 15080 15348 14512 113 16036 112 OAI21_X1
* cell instance $24266 r0 *1 114.38,215.6
X$24266 14998 112 113 15741 CLKBUF_X2
* cell instance $24268 r0 *1 115.33,215.6
X$24268 14729 15741 112 113 16008 NAND2_X1
* cell instance $24269 r0 *1 115.9,215.6
X$24269 14577 14487 15459 112 113 16079 NAND3_X1
* cell instance $24271 r0 *1 116.85,215.6
X$24271 16008 15831 14620 112 113 16038 NAND3_X1
* cell instance $24275 r0 *1 119.7,215.6
X$24275 15743 15000 14463 14869 15553 16097 113 112 AOI221_X2
* cell instance $24276 m0 *1 121.03,215.6
X$24276 15940 14789 15553 112 15897 113 AOI21_X1
* cell instance $24277 m0 *1 119.7,215.6
X$24277 16080 14386 15897 112 113 15746 MUX2_X1
* cell instance $24278 m0 *1 121.79,215.6
X$24278 15614 15605 14808 112 15966 113 AOI21_X1
* cell instance $24280 m0 *1 122.74,215.6
X$24280 13695 15966 15938 113 16011 112 OAI21_X1
* cell instance $24281 m0 *1 123.5,215.6
X$24281 15965 14866 16011 112 15946 113 AOI21_X1
* cell instance $24282 m0 *1 124.26,215.6
X$24282 16017 14897 112 113 15945 NOR2_X1
* cell instance $24285 m0 *1 126.54,215.6
X$24285 14168 15354 15898 15120 14132 113 112 15941 OAI221_X1
* cell instance $24287 m0 *1 127.87,215.6
X$24287 15204 16018 14789 113 15967 112 OAI21_X1
* cell instance $24289 m0 *1 128.82,215.6
X$24289 16017 14487 15748 112 113 16020 MUX2_X1
* cell instance $24291 r0 *1 121.79,215.6
X$24291 14572 15743 15622 14620 16041 112 113 15965 AOI221_X1
* cell instance $24292 r0 *1 122.93,215.6
X$24292 14574 112 113 14729 CLKBUF_X3
* cell instance $24297 r0 *1 124.64,215.6
X$24297 15008 14574 112 15354 113 NAND2_X4
* cell instance $24299 r0 *1 126.73,215.6
X$24299 14392 16100 14166 16043 15967 15944 113 112 AOI221_X2
* cell instance $24301 r0 *1 129.01,215.6
X$24301 14142 112 113 14683 INV_X4
* cell instance $24303 r0 *1 130.15,215.6
X$24303 14574 113 14690 112 BUF_X4
* cell instance $24304 m0 *1 130.72,215.6
X$24304 14247 15899 15943 15740 15834 15942 112 113 OAI221_X2
* cell instance $24306 m0 *1 132.81,215.6
X$24306 16020 14392 15941 112 113 15238 MUX2_X1
* cell instance $24307 m0 *1 134.14,215.6
X$24307 15899 14176 14247 15834 15939 113 112 AOI211_X2
* cell instance $24309 m0 *1 137.37,215.6
X$24309 16101 15521 15937 113 112 15652 HA_X1
* cell instance $24313 r0 *1 131.48,215.6
X$24313 14463 112 113 14906 CLKBUF_X3
* cell instance $24314 r0 *1 132.43,215.6
X$24314 15348 113 14869 112 BUF_X4
* cell instance $24316 r0 *1 134.14,215.6
X$24316 112 14574 113 14176 BUF_X8
* cell instance $24318 m0 *1 142.88,215.6
X$24318 15900 113 14813 112 BUF_X4
* cell instance $24319 m0 *1 141.93,215.6
X$24319 15900 112 113 15125 INV_X4
* cell instance $24320 m0 *1 144.21,215.6
X$24320 15358 113 14289 112 BUF_X4
* cell instance $24321 m0 *1 145.54,215.6
X$24321 15465 113 14600 112 BUF_X4
* cell instance $24324 m0 *1 147.82,215.6
X$24324 112 15015 7211 14515 14514 113 AOI21_X4
* cell instance $24326 m0 *1 150.48,215.6
X$24326 15358 14403 15013 112 113 NOR2_X4
* cell instance $24327 m0 *1 152.19,215.6
X$24327 16021 15632 15756 112 15971 113 AOI21_X2
* cell instance $24331 r0 *1 143.26,215.6
X$24331 14419 16044 16707 113 112 16046 HA_X1
* cell instance $24332 r0 *1 145.16,215.6
X$24332 15304 14795 15465 15974 14289 16072 113 112 AOI221_X2
* cell instance $24333 r0 *1 147.25,215.6
X$24333 10524 113 15836 112 BUF_X4
* cell instance $24334 r0 *1 148.58,215.6
X$24334 14514 15358 14515 112 14522 113 NAND3_X4
* cell instance $24335 r0 *1 151.05,215.6
X$24335 15358 113 14483 112 BUF_X4
* cell instance $24336 r0 *1 152.38,215.6
X$24336 14735 113 15474 112 BUF_X4
* cell instance $24337 r0 *1 153.71,215.6
X$24337 14515 14514 14288 112 113 16103 NAND3_X1
* cell instance $24338 m0 *1 154.09,215.6
X$24338 15819 15751 14184 112 113 16014 NAND3_X1
* cell instance $24341 r0 *1 154.47,215.6
X$24341 15877 15015 14790 113 16019 112 OAI21_X1
* cell instance $24342 r0 *1 155.23,215.6
X$24342 16016 16019 113 112 16071 AND2_X1
* cell instance $24344 m0 *1 155.23,215.6
X$24344 14702 14813 112 113 15875 NAND2_X1
* cell instance $24345 m0 *1 156.56,215.6
X$24345 15934 15083 14822 112 16012 113 AOI21_X1
* cell instance $24346 m0 *1 157.32,215.6
X$24346 14592 15904 14594 112 15934 113 AOI21_X1
* cell instance $24348 m0 *1 158.27,215.6
X$24348 14184 16012 15931 113 15933 112 OAI21_X1
* cell instance $24349 m0 *1 159.03,215.6
X$24349 15479 15012 15968 14412 15260 113 112 15931 OAI221_X1
* cell instance $24353 r0 *1 156.56,215.6
X$24353 15090 16015 15474 112 113 16016 NAND3_X1
* cell instance $24355 r0 *1 157.7,215.6
X$24355 14188 16013 16014 112 16048 113 AOI21_X1
* cell instance $24357 r0 *1 158.84,215.6
X$24357 16010 15969 14601 113 16013 112 OAI21_X1
* cell instance $24360 r0 *1 160.17,215.6
X$24360 14425 14707 15974 15415 16009 113 112 AOI211_X2
* cell instance $24361 m0 *1 161.88,215.6
X$24361 112 15902 15137 15873 15838 113 NOR3_X4
* cell instance $24362 m0 *1 160.55,215.6
X$24362 15901 16009 15758 113 15665 112 NOR3_X2
* cell instance $24363 m0 *1 164.54,215.6
X$24363 14813 15259 112 113 15970 NOR2_X1
* cell instance $24364 m0 *1 165.11,215.6
X$24364 14813 15835 15836 113 112 15904 OAI21_X2
* cell instance $24366 r0 *1 161.88,215.6
X$24366 16009 112 113 16146 BUF_X2
* cell instance $24369 r0 *1 163.21,215.6
X$24369 16007 15835 15836 113 112 15563 OAI21_X2
* cell instance $24370 r0 *1 164.54,215.6
X$24370 14702 15970 15248 112 15903 113 AOI21_X1
* cell instance $24371 r0 *1 165.3,215.6
X$24371 16050 15140 15260 112 113 15426 NAND3_X1
* cell instance $24372 r0 *1 166.06,215.6
X$24372 15365 15835 15836 112 113 16005 NOR3_X1
* cell instance $24373 m0 *1 167.01,215.6
X$24373 15971 15415 15365 112 15806 113 AOI21_X1
* cell instance $24376 r0 *1 166.82,215.6
X$24376 16005 15971 14592 112 113 16003 NOR3_X1
* cell instance $24378 r0 *1 167.77,215.6
X$24378 15835 15836 14961 112 113 15840 NOR3_X1
* cell instance $24379 m0 *1 172.9,215.6
X$24379 15835 15836 14180 113 15998 112 OAI21_X1
* cell instance $24380 m0 *1 168.15,215.6
X$24380 112 15972 15260 113 BUF_X16
* cell instance $24381 m0 *1 173.66,215.6
X$24381 15366 15972 14293 112 15993 113 AOI21_X1
* cell instance $24382 m0 *1 174.42,215.6
X$24382 15907 14525 15995 112 14686 113 AOI21_X1
* cell instance $24383 m0 *1 175.18,215.6
X$24383 14191 15906 16111 112 15907 113 AOI21_X1
* cell instance $24385 m0 *1 176.13,215.6
X$24385 15975 15993 15023 113 15923 112 OAI21_X1
* cell instance $24386 m0 *1 176.89,215.6
X$24386 15908 14526 15922 112 14952 113 AOI21_X1
* cell instance $24391 m0 *1 189.05,215.6
X$24391 112 13916 113 14204 BUF_X8
* cell instance $24392 m0 *1 191.52,215.6
X$24392 14338 112 113 14353 CLKBUF_X2
* cell instance $24394 m0 *1 193.04,215.6
X$24394 13702 113 14128 112 BUF_X4
* cell instance $24396 r0 *1 168.53,215.6
X$24396 15973 15364 14294 112 15995 113 AOI21_X1
* cell instance $24397 r0 *1 169.29,215.6
X$24397 14266 15973 16003 112 113 16052 NOR3_X1
* cell instance $24398 r0 *1 170.05,215.6
X$24398 15415 14180 112 113 15969 NAND2_X1
* cell instance $24400 r0 *1 171,215.6
X$24400 14421 16001 15969 113 16060 112 OAI21_X1
* cell instance $24401 r0 *1 171.76,215.6
X$24401 14192 14419 112 113 16001 NAND2_X1
* cell instance $24402 r0 *1 172.33,215.6
X$24402 15998 15139 112 113 16054 NOR2_X1
* cell instance $24404 r0 *1 173.28,215.6
X$24404 15259 15998 14790 113 16061 112 OAI21_X1
* cell instance $24406 r0 *1 174.23,215.6
X$24406 16060 15260 16061 15974 15760 15866 113 112 AOI221_X2
* cell instance $24407 r0 *1 176.32,215.6
X$24407 15974 14524 14525 113 15975 112 OAI21_X1
* cell instance $24408 r0 *1 177.08,215.6
X$24408 15474 113 14262 112 BUF_X4
* cell instance $24415 r0 *1 192.09,215.6
X$24415 14338 112 113 15501 BUF_X2
* cell instance $24418 m0 *1 194.75,215.6
X$24418 14528 112 113 14029 CLKBUF_X3
* cell instance $24420 m0 *1 196.27,215.6
X$24420 13639 112 113 14750 CLKBUF_X3
* cell instance $24422 m0 *1 197.22,215.6
X$24422 14314 113 15165 112 BUF_X4
* cell instance $24425 r0 *1 196.46,215.6
X$24425 14309 14651 16631 113 112 15845 HA_X1
* cell instance $24426 r0 *1 198.36,215.6
X$24426 13707 113 13911 112 BUF_X4
* cell instance $24427 m0 *1 199.12,215.6
X$24427 14544 14658 112 113 14667 NAND2_X1
* cell instance $24429 m0 *1 199.69,215.6
X$24429 13916 15909 15989 13984 112 113 15785 AOI22_X2
* cell instance $24430 m0 *1 201.4,215.6
X$24430 14750 14573 14029 112 113 15985 NAND3_X1
* cell instance $24434 r0 *1 200.45,215.6
X$24434 15166 14667 15985 113 15989 112 OAI21_X1
* cell instance $24435 r0 *1 201.21,215.6
X$24435 14069 13916 16698 113 112 15763 HA_X1
* cell instance $24436 r0 *1 203.11,215.6
X$24436 14309 13916 16611 113 112 15283 HA_X1
* cell instance $24437 m0 *1 203.49,215.6
X$24437 13639 14448 112 113 15847 NAND2_X2
* cell instance $24440 m0 *1 204.63,215.6
X$24440 15847 13984 15915 15165 15914 15786 112 113 OAI221_X2
* cell instance $24442 m0 *1 206.91,215.6
X$24442 13702 14204 112 113 15976 NOR2_X1
* cell instance $24444 m0 *1 207.67,215.6
X$24444 15976 14123 14433 113 15914 112 OAI21_X1
* cell instance $24446 m0 *1 208.62,215.6
X$24446 14528 15501 112 113 15982 NAND2_X1
* cell instance $24448 m0 *1 209.38,215.6
X$24448 15910 14544 15766 112 113 15978 MUX2_X1
* cell instance $24450 m0 *1 210.9,215.6
X$24450 14309 14651 16494 113 112 15910 HA_X1
* cell instance $24451 m0 *1 212.8,215.6
X$24451 14069 14651 15681 113 112 15977 HA_X1
* cell instance $24452 m0 *1 214.7,215.6
X$24452 15977 15910 112 113 15911 OR2_X1
* cell instance $24453 m0 *1 215.46,215.6
X$24453 15165 113 14309 112 BUF_X4
* cell instance $24463 r0 *1 205.96,215.6
X$24463 13639 113 15166 112 BUF_X4
* cell instance $24464 r0 *1 207.29,215.6
X$24464 15166 13707 16056 112 15979 113 AOI21_X1
* cell instance $24465 r0 *1 208.05,215.6
X$24465 15848 14448 15982 112 113 16056 MUX2_X1
* cell instance $24466 r0 *1 209.38,215.6
X$24466 13911 15978 15979 113 14207 112 OAI21_X1
* cell instance $24469 r0 *1 210.71,215.6
X$24469 14069 13916 16685 113 112 14551 HA_X1
* cell instance $24508 m0 *1 66.31,207.2
X$24508 15880 15325 112 113 15393 NOR2_X1
* cell instance $24514 r0 *1 67.26,207.2
X$24514 14662 14372 113 112 15531 XNOR2_X1
* cell instance $24519 m0 *1 71.63,207.2
X$24519 15100 14936 15101 113 15391 112 OAI21_X1
* cell instance $24520 m0 *1 71.06,207.2
X$24520 9691 14152 112 113 15210 NOR2_X1
* cell instance $24521 m0 *1 72.39,207.2
X$24521 15497 15496 14655 15436 15393 15392 113 112 AOI221_X2
* cell instance $24522 m0 *1 74.48,207.2
X$24522 14801 14709 15328 112 113 15055 NAND3_X2
* cell instance $24523 m0 *1 75.81,207.2
X$24523 14159 14153 15326 112 113 15687 NOR3_X1
* cell instance $24524 m0 *1 76.57,207.2
X$24524 14979 112 113 15328 BUF_X2
* cell instance $24525 m0 *1 77.33,207.2
X$24525 14800 14933 112 113 15329 NOR2_X2
* cell instance $24527 m0 *1 78.47,207.2
X$24527 14887 14656 14159 113 112 15438 OAI21_X4
* cell instance $24528 m0 *1 80.94,207.2
X$24528 14442 15500 15171 15330 14992 15499 113 112 AOI221_X2
* cell instance $24531 r0 *1 72.96,207.2
X$24531 15327 15063 112 113 15436 NAND2_X1
* cell instance $24532 r0 *1 73.53,207.2
X$24532 15326 113 15537 112 BUF_X4
* cell instance $24533 r0 *1 74.86,207.2
X$24533 14763 14332 112 15437 113 NAND2_X4
* cell instance $24535 r0 *1 76.76,207.2
X$24535 15278 15171 15535 113 15534 112 OAI21_X1
* cell instance $24536 r0 *1 77.52,207.2
X$24536 15328 112 113 15535 INV_X1
* cell instance $24537 r0 *1 77.9,207.2
X$24537 14157 14933 14372 112 15441 113 AOI21_X2
* cell instance $24538 r0 *1 79.23,207.2
X$24538 112 15589 15536 15439 15438 14545 113 NAND4_X4
* cell instance $24540 r0 *1 82.84,207.2
X$24540 8133 112 113 13585 CLKBUF_X3
* cell instance $24541 m0 *1 85.5,207.2
X$24541 15502 14988 112 113 15591 NAND2_X1
* cell instance $24542 m0 *1 83.41,207.2
X$24542 14158 15176 14608 15398 15212 15440 113 112 AOI221_X2
* cell instance $24543 m0 *1 86.07,207.2
X$24543 15171 14497 15539 15442 15332 112 113 15503 AOI221_X1
* cell instance $24545 r0 *1 83.79,207.2
X$24545 15437 15538 14608 15101 15441 15590 113 112 AOI221_X2
* cell instance $24546 r0 *1 85.88,207.2
X$24546 112 15647 113 15331 BUF_X8
* cell instance $24547 m0 *1 88.54,207.2
X$24547 15403 15505 112 113 15401 NOR2_X1
* cell instance $24548 m0 *1 87.59,207.2
X$24548 14608 14127 112 113 15439 NOR2_X2
* cell instance $24549 m0 *1 89.11,207.2
X$24549 15401 15506 15504 15444 14985 14457 113 112 AOI221_X2
* cell instance $24551 m0 *1 91.39,207.2
X$24551 14442 14989 14988 14987 14713 15510 113 112 AOI221_X2
* cell instance $24552 m0 *1 93.48,207.2
X$24552 14664 14608 14271 112 113 15447 NOR3_X1
* cell instance $24553 m0 *1 94.24,207.2
X$24553 15063 15336 15510 113 15406 112 OAI21_X1
* cell instance $24555 m0 *1 95.76,207.2
X$24555 14609 15220 15448 113 112 15339 AND3_X1
* cell instance $24558 r0 *1 88.35,207.2
X$24558 15213 15508 15398 14662 14988 113 112 15442 OAI221_X1
* cell instance $24560 r0 *1 89.68,207.2
X$24560 15443 15541 113 112 15507 AND2_X1
* cell instance $24561 r0 *1 90.44,207.2
X$24561 15058 15541 15592 112 15444 113 AOI21_X2
* cell instance $24562 r0 *1 91.77,207.2
X$24562 15063 15445 15507 14213 14267 113 112 15448 OAI221_X1
* cell instance $24563 r0 *1 92.91,207.2
X$24563 15447 14846 15593 112 15445 113 AOI21_X1
* cell instance $24564 r0 *1 93.67,207.2
X$24564 14379 15508 14849 113 15593 112 OAI21_X1
* cell instance $24565 r0 *1 94.43,207.2
X$24565 14983 14612 14859 15537 15441 113 112 15450 OAI221_X1
* cell instance $24566 r0 *1 95.57,207.2
X$24566 15446 15274 15064 112 15517 113 AOI21_X1
* cell instance $24567 r0 *1 96.33,207.2
X$24567 15437 15449 14988 15333 15517 15065 113 112 AOI221_X2
* cell instance $24568 m0 *1 98.04,207.2
X$24568 15407 15406 15450 113 112 15520 AND3_X1
* cell instance $24570 m0 *1 98.99,207.2
X$24570 14807 14498 112 113 15337 NOR2_X1
* cell instance $24571 m0 *1 99.56,207.2
X$24571 15334 15599 15392 15520 15338 15339 112 113 14893 OAI33_X1
* cell instance $24574 r0 *1 98.42,207.2
X$24574 15213 14717 112 113 15598 NOR2_X1
* cell instance $24578 m0 *1 104.5,207.2
X$24578 13822 13823 112 113 15451 NAND2_X1
* cell instance $24583 r0 *1 104.69,207.2
X$24583 15649 15451 14088 113 15340 112 OAI21_X1
* cell instance $24584 r0 *1 105.45,207.2
X$24584 15650 14088 15602 112 113 14228 MUX2_X1
* cell instance $24585 m0 *1 106.4,207.2
X$24585 15354 15521 112 113 15341 NOR2_X1
* cell instance $24587 m0 *1 106.97,207.2
X$24587 15521 14253 14168 15354 112 113 15343 AOI22_X1
* cell instance $24588 m0 *1 107.92,207.2
X$24588 14563 15343 15523 113 14898 112 OAI21_X1
* cell instance $24589 m0 *1 108.68,207.2
X$24589 13560 14253 15452 113 15344 112 OAI21_X1
* cell instance $24593 r0 *1 108.3,207.2
X$24593 15071 15111 14808 112 15522 113 AOI21_X1
* cell instance $24594 r0 *1 109.06,207.2
X$24594 15605 15120 14384 13695 15522 113 112 15523 OAI221_X1
* cell instance $24595 r0 *1 110.2,207.2
X$24595 15204 15071 14274 112 113 15544 NOR3_X1
* cell instance $24596 m0 *1 111.34,207.2
X$24596 15346 15345 14906 112 113 15453 NAND3_X1
* cell instance $24597 m0 *1 110.58,207.2
X$24597 14722 14500 14897 113 15346 112 OAI21_X1
* cell instance $24599 m0 *1 112.29,207.2
X$24599 14624 15307 13956 14734 15413 15114 113 112 AOI221_X2
* cell instance $24600 m0 *1 114.38,207.2
X$24600 14574 15454 112 113 15413 NAND2_X1
* cell instance $24601 m0 *1 114.95,207.2
X$24601 15001 14873 112 113 15350 NOR2_X1
* cell instance $24602 m0 *1 115.52,207.2
X$24602 15550 14734 113 112 15417 AND2_X1
* cell instance $24604 m0 *1 116.47,207.2
X$24604 14166 15351 15455 15420 13695 113 112 14055 OAI221_X1
* cell instance $24605 m0 *1 117.61,207.2
X$24605 13956 15525 15352 112 15233 113 AOI21_X2
* cell instance $24606 m0 *1 118.94,207.2
X$24606 15091 15551 113 112 15420 AND2_X1
* cell instance $24608 m0 *1 119.89,207.2
X$24608 15310 14384 14897 15526 15607 113 112 AOI211_X2
* cell instance $24612 r0 *1 111.53,207.2
X$24612 13823 15545 15546 113 14136 112 OAI21_X1
* cell instance $24613 r0 *1 112.29,207.2
X$24613 15453 15547 14283 112 113 15546 NAND3_X1
* cell instance $24615 r0 *1 113.43,207.2
X$24615 15454 14385 15117 14274 15549 113 112 15547 OAI221_X1
* cell instance $24616 r0 *1 114.57,207.2
X$24616 14486 15349 14808 112 15549 113 AOI21_X1
* cell instance $24618 r0 *1 116.85,207.2
X$24618 14486 14100 15740 113 14677 112 NOR3_X2
* cell instance $24619 r0 *1 118.18,207.2
X$24619 15459 15460 14730 113 15551 112 OAI21_X1
* cell instance $24620 r0 *1 118.94,207.2
X$24620 15458 13823 15456 112 14234 113 AOI21_X1
* cell instance $24622 r0 *1 120.08,207.2
X$24622 15607 14563 15457 112 15456 113 AOI21_X1
* cell instance $24623 r0 *1 120.84,207.2
X$24623 14508 14568 112 113 15553 OR2_X1
* cell instance $24625 m0 *1 122.17,207.2
X$24625 15459 14730 113 112 15526 XNOR2_X1
* cell instance $24627 m0 *1 123.31,207.2
X$24627 14508 14500 14873 113 15123 112 OAI21_X1
* cell instance $24629 m0 *1 124.83,207.2
X$24629 14722 15353 14789 112 113 15527 NOR3_X1
* cell instance $24631 r0 *1 123.12,207.2
X$24631 15527 14677 14866 113 15554 112 OAI21_X1
* cell instance $24632 r0 *1 123.88,207.2
X$24632 15555 15609 14384 14279 15610 14968 113 112 AOI221_X2
* cell instance $24636 r0 *1 125.97,207.2
X$24636 15611 15612 14386 14384 15461 15458 113 112 AOI221_X2
* cell instance $24637 m0 *1 126.16,207.2
X$24637 14463 15459 14100 112 15612 113 AOI21_X1
* cell instance $24640 m0 *1 127.49,207.2
X$24640 14789 15316 15352 113 15461 112 OAI21_X1
* cell instance $24644 r0 *1 128.06,207.2
X$24644 14253 15614 14690 113 15611 112 OAI21_X1
* cell instance $24646 r0 *1 129.2,207.2
X$24646 15460 15616 113 112 15609 AND2_X1
* cell instance $24648 m0 *1 129.39,207.2
X$24648 15353 15462 112 113 15316 OR2_X1
* cell instance $24649 m0 *1 130.91,207.2
X$24649 14253 14722 14869 112 113 15619 NOR3_X1
* cell instance $24650 m0 *1 131.67,207.2
X$24650 15353 14176 15621 15357 15237 113 112 AOI211_X2
* cell instance $24651 m0 *1 133.38,207.2
X$24651 15463 112 113 15454 INV_X1
* cell instance $24654 r0 *1 130.15,207.2
X$24654 14897 15462 15356 113 15618 112 NOR3_X2
* cell instance $24655 r0 *1 131.48,207.2
X$24655 15619 15618 112 113 15608 NOR2_X1
* cell instance $24656 r0 *1 132.05,207.2
X$24656 15462 14500 14574 113 15616 112 OAI21_X1
* cell instance $24658 r0 *1 133.57,207.2
X$24658 14733 14732 15454 113 15462 112 NOR3_X2
* cell instance $24660 m0 *1 134.14,207.2
X$24660 15521 14168 16520 113 112 14811 HA_X1
* cell instance $24661 m0 *1 136.23,207.2
X$24661 14811 112 113 15232 CLKBUF_X3
* cell instance $24665 r0 *1 134.9,207.2
X$24665 15463 112 113 15005 BUF_X2
* cell instance $24667 r0 *1 135.85,207.2
X$24667 112 14509 14732 14733 14508 113 NOR3_X4
* cell instance $24672 r0 *1 143.64,207.2
X$24672 15009 14288 15465 15083 15320 113 112 AOI211_X2
* cell instance $24673 m0 *1 146.49,207.2
X$24673 112 15467 113 14287 BUF_X8
* cell instance $24674 m0 *1 144.4,207.2
X$24674 14739 15083 15358 15359 10773 15240 113 112 AOI221_X2
* cell instance $24677 r0 *1 145.73,207.2
X$24677 15359 10773 15479 112 113 15627 NAND3_X1
* cell instance $24678 r0 *1 146.49,207.2
X$24678 15466 112 113 15365 BUF_X2
* cell instance $24679 r0 *1 147.25,207.2
X$24679 14735 14024 12002 112 113 15530 NAND3_X1
* cell instance $24682 r0 *1 148.58,207.2
X$24682 14600 15083 15530 113 112 15484 AND3_X1
* cell instance $24683 m0 *1 150.1,207.2
X$24683 14181 14707 112 113 15243 NOR2_X1
* cell instance $24684 m0 *1 149.34,207.2
X$24684 15468 14735 15557 112 15360 113 AOI21_X1
* cell instance $24686 m0 *1 150.86,207.2
X$24686 14910 15470 14423 113 15469 112 OAI21_X1
* cell instance $24687 m0 *1 151.62,207.2
X$24687 15304 14182 112 113 15242 NOR2_X1
* cell instance $24688 m0 *1 152.19,207.2
X$24688 15324 15207 14188 14471 15528 15362 113 112 AOI221_X2
* cell instance $24693 r0 *1 150.86,207.2
X$24693 14490 15628 15469 15304 14630 113 112 15363 OAI221_X1
* cell instance $24695 r0 *1 152.38,207.2
X$24695 15558 15529 15361 113 15528 112 OAI21_X1
* cell instance $24697 r0 *1 153.33,207.2
X$24697 14600 14706 112 113 15435 NAND2_X1
* cell instance $24698 r0 *1 153.9,207.2
X$24698 15471 14965 14291 112 113 15529 NOR3_X1
* cell instance $24699 r0 *1 154.66,207.2
X$24699 15013 15471 112 113 15630 OR2_X1
* cell instance $24700 m0 *1 155.61,207.2
X$24700 15433 14525 15363 112 15429 113 AOI21_X1
* cell instance $24701 m0 *1 154.66,207.2
X$24701 15362 14187 112 113 15472 OR2_X2
* cell instance $24702 m0 *1 156.37,207.2
X$24702 15247 15366 14525 113 15432 112 OAI21_X1
* cell instance $24703 m0 *1 157.13,207.2
X$24703 15259 14592 15366 113 15200 112 OAI21_X1
* cell instance $24705 m0 *1 158.08,207.2
X$24705 14739 14820 112 113 15468 NOR2_X2
* cell instance $24706 m0 *1 159.03,207.2
X$24706 15367 15012 112 113 14704 NOR2_X1
* cell instance $24707 m0 *1 159.6,207.2
X$24707 15634 15194 14297 14301 15429 15427 113 112 AOI221_X2
* cell instance $24709 m0 *1 162.45,207.2
X$24709 14884 15668 14694 112 113 15136 NAND3_X1
* cell instance $24711 m0 *1 163.4,207.2
X$24711 15476 15524 15427 15472 15425 14265 112 113 OAI221_X2
* cell instance $24712 m0 *1 165.49,207.2
X$24712 14188 14260 112 113 15368 NOR2_X1
* cell instance $24713 m0 *1 166.06,207.2
X$24713 15368 15370 15371 112 113 15425 NAND3_X1
* cell instance $24715 r0 *1 155.42,207.2
X$24715 14412 15365 15630 14884 113 112 15631 OAI22_X2
* cell instance $24718 r0 *1 157.7,207.2
X$24718 15468 15473 14694 113 15509 112 OAI21_X1
* cell instance $24719 r0 *1 158.46,207.2
X$24719 15074 15304 14791 14884 112 113 15560 AOI22_X1
* cell instance $24723 r0 *1 160.74,207.2
X$24723 14965 15467 112 113 15482 NOR2_X1
* cell instance $24724 r0 *1 161.31,207.2
X$24724 15364 14412 14182 14702 15475 113 112 15428 OAI221_X1
* cell instance $24726 r0 *1 163.21,207.2
X$24726 15477 15561 14184 112 113 15476 NOR3_X1
* cell instance $24730 r0 *1 165.3,207.2
X$24730 14186 15631 14266 15478 15023 15562 112 113 OAI221_X2
* cell instance $24731 m0 *1 167.39,207.2
X$24731 14636 15366 15373 113 15478 112 OAI21_X1
* cell instance $24733 m0 *1 168.15,207.2
X$24733 15304 15366 15260 112 113 15373 NAND3_X1
* cell instance $24734 m0 *1 168.91,207.2
X$24734 14707 14813 112 113 15480 NOR2_X1
* cell instance $24735 m0 *1 169.48,207.2
X$24735 15415 14813 112 113 15483 NOR2_X1
* cell instance $24736 m0 *1 170.05,207.2
X$24736 15483 14694 112 113 15423 NOR2_X1
* cell instance $24737 m0 *1 170.62,207.2
X$24737 15480 112 113 15418 INV_X1
* cell instance $24739 m0 *1 171.76,207.2
X$24739 15474 14425 14820 14822 112 113 15375 AOI22_X1
* cell instance $24740 m0 *1 172.71,207.2
X$24740 15375 14743 112 113 15519 NAND2_X1
* cell instance $24743 r0 *1 167.77,207.2
X$24743 14425 15628 15479 112 113 14359 NOR3_X1
* cell instance $24745 r0 *1 168.91,207.2
X$24745 15481 15480 15137 112 113 15477 NOR3_X1
* cell instance $24746 r0 *1 169.67,207.2
X$24746 15482 15367 15140 112 113 15481 NOR3_X1
* cell instance $24747 r0 *1 170.43,207.2
X$24747 15365 112 113 15255 BUF_X1
* cell instance $24749 r0 *1 171.19,207.2
X$24749 15482 15367 14790 113 15624 112 OAI21_X1
* cell instance $24751 r0 *1 172.14,207.2
X$24751 15367 14191 15479 112 113 15485 NOR3_X1
* cell instance $24753 r0 *1 173.09,207.2
X$24753 15484 15483 112 113 15564 NOR2_X1
* cell instance $24755 m0 *1 173.66,207.2
X$24755 14424 15259 14822 112 15512 113 AOI21_X1
* cell instance $24756 r0 *1 173.66,207.2
X$24756 14471 14191 112 113 15623 NOR2_X1
* cell instance $24757 r0 *1 174.23,207.2
X$24757 15484 15565 112 113 15511 OR2_X1
* cell instance $24759 m0 *1 174.8,207.2
X$24759 15518 15516 15374 112 113 15515 NAND3_X1
* cell instance $24761 m0 *1 176.51,207.2
X$24761 15146 15515 15514 15513 14827 113 112 14828 OAI221_X1
* cell instance $24764 m0 *1 185.25,207.2
X$24764 13833 113 13984 112 BUF_X4
* cell instance $24766 m0 *1 186.77,207.2
X$24766 10516 112 113 13764 INV_X4
* cell instance $24769 m0 *1 188.67,207.2
X$24769 13764 13967 15267 112 113 NOR2_X4
* cell instance $24770 m0 *1 190.38,207.2
X$24770 14338 113 15296 112 BUF_X4
* cell instance $24771 m0 *1 191.71,207.2
X$24771 10516 113 14649 112 BUF_X4
* cell instance $24772 m0 *1 193.04,207.2
X$24772 10516 112 113 14779 CLKBUF_X3
* cell instance $24773 m0 *1 193.99,207.2
X$24773 14573 15268 13922 112 15411 113 AOI21_X1
* cell instance $24774 m0 *1 194.75,207.2
X$24774 13904 15265 15379 14198 113 112 15378 OAI22_X2
* cell instance $24775 m0 *1 196.46,207.2
X$24775 14528 14527 112 113 15487 NAND2_X1
* cell instance $24776 m0 *1 197.03,207.2
X$24776 15148 15494 112 113 15380 NAND2_X1
* cell instance $24781 r0 *1 175.18,207.2
X$24781 15023 14187 112 113 15516 NOR2_X1
* cell instance $24782 r0 *1 175.75,207.2
X$24782 15694 15615 15613 15312 14260 14681 112 113 OAI221_X2
* cell instance $24783 r0 *1 177.84,207.2
X$24783 15509 15512 14297 15027 15511 15613 113 112 AOI221_X2
* cell instance $24791 r0 *1 185.44,207.2
X$24791 13915 14651 16711 113 112 15070 HA_X1
* cell instance $24794 r0 *1 188.29,207.2
X$24794 13898 13833 13966 112 15376 113 NAND3_X4
* cell instance $24795 r0 *1 190.76,207.2
X$24795 15070 112 113 13904 INV_X4
* cell instance $24796 r0 *1 191.71,207.2
X$24796 14649 112 113 14534 CLKBUF_X3
* cell instance $24797 r0 *1 192.66,207.2
X$24797 14649 13967 112 113 15268 NAND2_X2
* cell instance $24799 r0 *1 193.8,207.2
X$24799 10516 13833 112 113 15379 NAND2_X2
* cell instance $24800 r0 *1 194.75,207.2
X$24800 14649 14830 13703 15570 112 113 15568 AOI22_X1
* cell instance $24802 r0 *1 195.89,207.2
X$24802 13797 15404 14128 15266 15606 15486 113 112 AOI221_X2
* cell instance $24803 r0 *1 197.98,207.2
X$24803 14433 13904 112 113 15603 NOR2_X1
* cell instance $24804 r0 *1 198.55,207.2
X$24804 15487 15268 14544 112 113 15572 NAND3_X1
* cell instance $24805 r0 *1 199.31,207.2
X$24805 13707 15572 15166 112 14145 113 AOI21_X2
* cell instance $24807 m0 *1 200.26,207.2
X$24807 15379 14539 112 113 15177 NOR2_X1
* cell instance $24809 m0 *1 201.78,207.2
X$24809 14534 113 14548 112 BUF_X4
* cell instance $24812 m0 *1 204.06,207.2
X$24812 14787 15382 14202 113 15488 112 OAI21_X1
* cell instance $24813 m0 *1 204.82,207.2
X$24813 15501 13966 13898 112 15382 113 AOI21_X1
* cell instance $24815 r0 *1 200.64,207.2
X$24815 14534 14336 112 113 15574 NOR2_X1
* cell instance $24816 r0 *1 201.21,207.2
X$24816 15574 13919 13973 113 15595 112 OAI21_X1
* cell instance $24818 r0 *1 202.16,207.2
X$24818 15489 15595 15594 13972 112 113 15152 AOI22_X2
* cell instance $24819 r0 *1 203.87,207.2
X$24819 14039 13979 15488 113 15594 112 OAI21_X1
* cell instance $24820 r0 *1 204.63,207.2
X$24820 14548 14641 15488 113 15575 112 OAI21_X1
* cell instance $24822 r0 *1 205.58,207.2
X$24822 14534 14039 112 113 15577 NOR2_X1
* cell instance $24823 m0 *1 206.15,207.2
X$24823 112 14780 15267 15385 14528 13990 113 AOI22_X4
* cell instance $24825 m0 *1 209.38,207.2
X$24825 15263 112 113 14115 BUF_X1
* cell instance $24827 m0 *1 211.47,207.2
X$24827 15489 14037 15385 113 112 14925 OAI21_X2
* cell instance $24828 m0 *1 212.8,207.2
X$24828 15385 14037 13911 112 113 15498 NOR3_X1
* cell instance $24829 m0 *1 213.56,207.2
X$24829 15498 15495 14839 113 15052 112 OAI21_X1
* cell instance $24831 m0 *1 214.51,207.2
X$24831 15166 113 13972 112 BUF_X4
* cell instance $24832 m0 *1 215.84,207.2
X$24832 15494 14212 112 113 15045 NOR2_X1
* cell instance $24834 m0 *1 216.6,207.2
X$24834 15387 14037 15493 112 113 14841 MUX2_X1
* cell instance $24835 m0 *1 217.93,207.2
X$24835 14125 15388 14839 113 15037 112 OAI21_X1
* cell instance $24844 r0 *1 206.72,207.2
X$24844 14448 15487 113 112 15384 AND2_X1
* cell instance $24845 r0 *1 207.48,207.2
X$24845 13966 13898 13837 14029 112 113 15587 AOI22_X1
* cell instance $24847 r0 *1 208.81,207.2
X$24847 15166 14195 15587 112 15489 113 AOI21_X2
* cell instance $24850 r0 *1 211.28,207.2
X$24850 13966 13898 14108 14433 112 113 15579 AOI22_X1
* cell instance $24851 r0 *1 212.23,207.2
X$24851 15579 14195 15681 13975 112 113 15492 AOI22_X1
* cell instance $24852 r0 *1 213.18,207.2
X$24852 15492 14125 112 113 15495 NOR2_X1
* cell instance $24853 r0 *1 213.75,207.2
X$24853 15166 15165 15381 112 113 15389 NOR3_X1
* cell instance $24854 r0 *1 214.51,207.2
X$24854 13925 14548 13984 113 15583 112 OAI21_X1
* cell instance $24855 r0 *1 215.27,207.2
X$24855 13919 13916 15583 112 15493 113 AOI21_X1
* cell instance $24857 r0 *1 216.41,207.2
X$24857 14128 112 113 14839 CLKBUF_X3
* cell instance $24881 m0 *1 65.17,218.4
X$24881 16022 112 113 15882 BUF_X2
* cell instance $24882 m0 *1 65.93,218.4
X$24882 16022 112 113 16055 BUF_X2
* cell instance $24883 m0 *1 66.69,218.4
X$24883 14987 14930 16491 113 112 16022 HA_X1
* cell instance $24884 m0 *1 68.59,218.4
X$24884 16022 113 16160 112 BUF_X4
* cell instance $24902 r0 *1 67.45,218.4
X$24902 14127 113 15216 112 BUF_X4
* cell instance $24906 r0 *1 68.78,218.4
X$24906 16023 113 15533 112 BUF_X4
* cell instance $24907 r0 *1 70.11,218.4
X$24907 112 16117 14213 15539 15293 113 AOI21_X4
* cell instance $24908 m0 *1 70.87,218.4
X$24908 14989 16117 14769 113 112 16161 OAI21_X2
* cell instance $24909 m0 *1 70.3,218.4
X$24909 15879 14538 112 113 16058 NOR2_X1
* cell instance $24910 m0 *1 72.2,218.4
X$24910 14127 14538 113 112 16118 XNOR2_X1
* cell instance $24911 m0 *1 73.34,218.4
X$24911 16024 14267 16118 112 16162 113 AOI21_X1
* cell instance $24912 m0 *1 74.1,218.4
X$24912 15721 15216 112 113 16024 NOR2_X1
* cell instance $24914 m0 *1 74.86,218.4
X$24914 15881 14552 14712 112 16081 113 AOI21_X1
* cell instance $24917 r0 *1 72.77,218.4
X$24917 14552 113 16026 112 BUF_X4
* cell instance $24919 r0 *1 74.86,218.4
X$24919 15983 15723 16081 112 16120 113 AOI21_X1
* cell instance $24920 r0 *1 75.62,218.4
X$24920 16120 14856 14807 112 113 16122 NOR3_X1
* cell instance $24921 m0 *1 76.76,218.4
X$24921 15777 16083 16026 113 16027 112 OAI21_X1
* cell instance $24922 m0 *1 76,218.4
X$24922 15881 15282 16026 112 16063 113 AOI21_X1
* cell instance $24926 m0 *1 79.99,218.4
X$24926 14542 14543 112 113 15717 NAND2_X2
* cell instance $24927 m0 *1 80.94,218.4
X$24927 16029 16084 15439 112 113 14853 NAND3_X2
* cell instance $24928 m0 *1 82.27,218.4
X$24928 15925 15983 15717 112 113 16028 NOR3_X1
* cell instance $24929 m0 *1 83.03,218.4
X$24929 16064 15981 112 113 16065 NAND2_X1
* cell instance $24930 m0 *1 83.6,218.4
X$24930 15211 14987 14988 112 16163 113 AOI21_X1
* cell instance $24931 m0 *1 84.36,218.4
X$24931 15722 15881 15723 113 16084 112 OAI21_X1
* cell instance $24932 m0 *1 85.12,218.4
X$24932 16131 15718 16066 112 15504 113 AOI21_X2
* cell instance $24933 m0 *1 86.45,218.4
X$24933 15881 113 16085 112 BUF_X4
* cell instance $24934 m0 *1 87.78,218.4
X$24934 16134 15717 14607 16133 14560 16131 112 113 OAI221_X2
* cell instance $24936 r0 *1 76.38,218.4
X$24936 16122 15861 16181 112 14710 113 AOI21_X2
* cell instance $24937 r0 *1 77.71,218.4
X$24937 15917 15537 112 113 16127 NOR2_X1
* cell instance $24939 r0 *1 78.66,218.4
X$24939 15533 14372 14444 112 113 16125 MUX2_X1
* cell instance $24941 r0 *1 80.37,218.4
X$24941 14983 14769 14379 14765 16125 112 113 16221 AOI221_X1
* cell instance $24942 r0 *1 81.51,218.4
X$24942 14887 14267 112 113 16083 NOR2_X1
* cell instance $24946 r0 *1 83.41,218.4
X$24946 14983 14936 113 112 16164 AND2_X1
* cell instance $24947 r0 *1 84.17,218.4
X$24947 15281 16127 16185 113 112 16129 OAI21_X2
* cell instance $24948 r0 *1 85.5,218.4
X$24948 14157 15398 112 113 16130 NOR2_X1
* cell instance $24949 r0 *1 86.07,218.4
X$24949 16132 15437 16130 112 16133 113 AOI21_X2
* cell instance $24950 r0 *1 87.4,218.4
X$24950 112 16085 15542 15722 16132 113 NOR3_X4
* cell instance $24951 r0 *1 90.06,218.4
X$24951 112 14662 14891 113 BUF_X16
* cell instance $24952 m0 *1 91.01,218.4
X$24952 16135 15326 15961 112 16134 113 AOI21_X2
* cell instance $24953 m0 *1 90.25,218.4
X$24953 15098 15542 113 112 16135 AND2_X1
* cell instance $24956 m0 *1 92.72,218.4
X$24956 14157 14891 15981 112 16137 113 AOI21_X1
* cell instance $24957 m0 *1 93.67,218.4
X$24957 16030 15439 112 113 16138 NAND2_X1
* cell instance $24958 m0 *1 94.24,218.4
X$24958 16129 16031 16138 112 113 16032 NAND3_X1
* cell instance $24959 m0 *1 95,218.4
X$24959 15861 15962 16070 15925 113 16140 112 NOR4_X2
* cell instance $24960 m0 *1 96.71,218.4
X$24960 15537 15437 14717 14943 112 113 16143 AOI22_X2
* cell instance $24961 m0 *1 98.42,218.4
X$24961 16086 16140 16143 14859 113 112 16073 OAI22_X2
* cell instance $24966 r0 *1 95.19,218.4
X$24966 112 14609 16032 15926 16139 16087 16141 14334 113 OAI222_X2
* cell instance $24967 r0 *1 97.85,218.4
X$24967 14718 14498 112 113 16230 NOR2_X1
* cell instance $24968 r0 *1 98.42,218.4
X$24968 16087 16202 16084 112 16086 113 AOI21_X1
* cell instance $24970 r0 *1 99.37,218.4
X$24970 14558 14655 112 113 16087 NAND2_X1
* cell instance $24975 m0 *1 105.07,218.4
X$24975 15830 14729 16074 14723 14386 15354 112 113 16089 OAI33_X1
* cell instance $24977 r0 *1 105.45,218.4
X$24977 14386 14620 112 113 16088 NAND2_X1
* cell instance $24979 r0 *1 106.4,218.4
X$24979 14169 16088 16145 112 16144 113 AOI21_X1
* cell instance $24980 m0 *1 107.54,218.4
X$24980 16144 16089 16147 14906 112 113 15932 NOR4_X1
* cell instance $24981 m0 *1 106.78,218.4
X$24981 16034 14866 15963 113 15604 112 OAI21_X1
* cell instance $24982 m0 *1 108.49,218.4
X$24982 14279 14620 14095 112 113 16148 NAND3_X1
* cell instance $24984 m0 *1 109.44,218.4
X$24984 14620 14095 15830 112 113 15452 NAND3_X1
* cell instance $24987 r0 *1 107.16,218.4
X$24987 14279 14730 14168 112 113 16145 NAND3_X1
* cell instance $24988 r0 *1 107.92,218.4
X$24988 14168 16148 14385 112 16147 113 AOI21_X1
* cell instance $24990 r0 *1 109.44,218.4
X$24990 13561 16193 16090 113 16034 112 OAI21_X1
* cell instance $24993 r0 *1 111.15,218.4
X$24993 16094 16194 15452 113 16150 112 OAI21_X1
* cell instance $24994 m0 *1 112.1,218.4
X$24994 16152 16035 16091 112 113 15870 OR3_X1
* cell instance $24995 m0 *1 111.34,218.4
X$24995 16150 14906 14283 112 113 16091 NOR3_X1
* cell instance $24996 m0 *1 113.05,218.4
X$24996 16092 16036 16078 16151 15605 112 113 16152 AOI221_X1
* cell instance $24998 r0 *1 111.91,218.4
X$24998 14734 14574 112 14385 113 NAND2_X4
* cell instance $25000 r0 *1 114.38,218.4
X$25000 16167 16168 15605 14385 113 112 15736 OAI22_X1
* cell instance $25001 m0 *1 114.76,218.4
X$25001 16079 16093 14463 14279 112 113 16078 NAND4_X1
* cell instance $25004 m0 *1 115.9,218.4
X$25004 15741 15354 16093 15708 14723 113 112 16037 OAI221_X1
* cell instance $25005 m0 *1 117.04,218.4
X$25005 14386 16038 16154 112 14351 113 AOI21_X2
* cell instance $25007 r0 *1 115.33,218.4
X$25007 14734 15740 15080 112 113 16093 NAND3_X1
* cell instance $25008 r0 *1 116.09,218.4
X$25008 15232 112 113 16094 INV_X1
* cell instance $25010 r0 *1 117.23,218.4
X$25010 14389 16094 112 113 15525 NAND2_X1
* cell instance $25011 r0 *1 117.8,218.4
X$25011 16095 14866 16037 112 113 16096 MUX2_X1
* cell instance $25012 m0 *1 119.32,218.4
X$25012 14167 16096 16098 113 14786 112 OAI21_X1
* cell instance $25013 m0 *1 118.75,218.4
X$25013 16040 15117 112 113 16039 NAND2_X1
* cell instance $25014 m0 *1 120.08,218.4
X$25014 15008 14902 15743 112 113 NOR2_X4
* cell instance $25017 r0 *1 119.32,218.4
X$25017 16099 16097 14167 113 16098 112 OAI21_X1
* cell instance $25018 r0 *1 120.08,218.4
X$25018 16157 14166 16169 112 113 14239 MUX2_X1
* cell instance $25019 r0 *1 121.41,218.4
X$25019 14902 15357 112 113 15708 XNOR2_X2
* cell instance $25020 m0 *1 123.5,218.4
X$25020 14866 16042 16040 112 16099 113 AOI21_X1
* cell instance $25021 m0 *1 122.17,218.4
X$25021 14051 14247 15740 112 113 16041 MUX2_X1
* cell instance $25024 r0 *1 123.69,218.4
X$25024 14902 14683 112 113 15300 NAND2_X2
* cell instance $25028 r0 *1 124.64,218.4
X$25028 14176 112 113 14873 CLKBUF_X3
* cell instance $25029 m0 *1 125.4,218.4
X$25029 14873 14512 113 112 16158 AND2_X1
* cell instance $25030 m0 *1 124.64,218.4
X$25030 14485 14729 15318 112 113 16040 NAND3_X1
* cell instance $25031 m0 *1 126.16,218.4
X$25031 14392 14690 14512 112 16076 113 AOI21_X1
* cell instance $25032 m0 *1 126.92,218.4
X$25032 14690 113 14274 112 BUF_X4
* cell instance $25033 m0 *1 128.25,218.4
X$25033 14168 16158 16040 14169 15120 113 112 16075 OAI221_X1
* cell instance $25035 r0 *1 125.59,218.4
X$25035 14734 112 113 14730 CLKBUF_X3
* cell instance $25036 r0 *1 126.54,218.4
X$25036 112 14572 113 15318 BUF_X8
* cell instance $25037 r0 *1 129.01,218.4
X$25037 14392 14095 15614 112 16043 113 AOI21_X1
* cell instance $25039 m0 *1 129.96,218.4
X$25039 14247 113 16159 112 BUF_X4
* cell instance $25041 m0 *1 131.29,218.4
X$25041 14902 113 15348 112 BUF_X4
* cell instance $25043 m0 *1 132.81,218.4
X$25043 15622 112 113 14392 CLKBUF_X3
* cell instance $25044 m0 *1 133.76,218.4
X$25044 16102 113 15318 112 BUF_X4
* cell instance $25045 m0 *1 135.09,218.4
X$25045 14389 113 14095 112 BUF_X4
* cell instance $25048 m0 *1 143.26,218.4
X$25048 14699 112 113 16067 BUF_X1
* cell instance $25049 m0 *1 143.83,218.4
X$25049 112 14425 16045 14515 14514 113 AOI21_X4
* cell instance $25050 m0 *1 146.3,218.4
X$25050 16072 14516 112 113 14601 NOR2_X2
* cell instance $25051 m0 *1 147.25,218.4
X$25051 14735 113 14190 112 BUF_X4
* cell instance $25052 m0 *1 148.58,218.4
X$25052 14514 113 15756 112 BUF_X4
* cell instance $25053 m0 *1 149.91,218.4
X$25053 16046 112 113 15010 INV_X4
* cell instance $25054 m0 *1 150.86,218.4
X$25054 14190 112 113 15479 CLKBUF_X3
* cell instance $25058 r0 *1 130.53,218.4
X$25058 14140 14176 14796 112 113 16189 MUX2_X1
* cell instance $25059 r0 *1 131.86,218.4
X$25059 14169 16101 16675 113 112 16102 HA_X1
* cell instance $25060 r0 *1 133.76,218.4
X$25060 16102 112 113 14796 INV_X2
* cell instance $25061 r0 *1 134.33,218.4
X$25061 15357 113 14734 112 BUF_X4
* cell instance $25065 r0 *1 142.31,218.4
X$25065 14419 16186 16706 113 112 14908 HA_X1
* cell instance $25066 r0 *1 144.21,218.4
X$25066 112 14403 14419 113 BUF_X16
* cell instance $25068 r0 *1 149.15,218.4
X$25068 112 15757 14403 14515 14514 113 AOI21_X4
* cell instance $25069 r0 *1 151.62,218.4
X$25069 16103 16104 112 113 14885 NOR2_X2
* cell instance $25070 m0 *1 153.14,218.4
X$25070 14266 16047 15758 16071 14188 16069 112 113 OAI221_X2
* cell instance $25071 m0 *1 152.19,218.4
X$25071 14483 112 113 14790 CLKBUF_X3
* cell instance $25073 r0 *1 152.57,218.4
X$25073 16103 113 14412 112 BUF_X4
* cell instance $25075 r0 *1 154.09,218.4
X$25075 16104 14735 15010 112 113 16184 MUX2_X1
* cell instance $25077 r0 *1 155.61,218.4
X$25077 15467 16050 14594 113 16105 112 OAI21_X1
* cell instance $25078 m0 *1 157.7,218.4
X$25078 15023 16068 16156 16155 112 113 16107 NOR4_X1
* cell instance $25079 m0 *1 155.61,218.4
X$25079 16105 14190 14266 14791 14520 16156 113 112 AOI221_X2
* cell instance $25080 m0 *1 158.65,218.4
X$25080 15933 16069 14260 113 16049 112 OAI21_X1
* cell instance $25082 m0 *1 159.6,218.4
X$25082 14403 15835 15836 113 112 16050 OAI21_X2
* cell instance $25083 m0 *1 160.93,218.4
X$25083 15835 15836 16067 113 15021 112 NOR3_X2
* cell instance $25084 m0 *1 162.26,218.4
X$25084 16146 112 113 15902 BUF_X2
* cell instance $25085 m0 *1 163.02,218.4
X$25085 15904 16015 14790 112 113 14964 NAND3_X1
* cell instance $25086 m0 *1 163.78,218.4
X$25086 15632 15756 16007 112 113 15668 NAND3_X1
* cell instance $25087 m0 *1 164.54,218.4
X$25087 15474 16050 15668 112 15973 113 AOI21_X1
* cell instance $25088 m0 *1 165.3,218.4
X$25088 16007 112 113 14521 BUF_X2
* cell instance $25089 m0 *1 166.06,218.4
X$25089 15021 16136 15366 112 16174 113 AOI21_X1
* cell instance $25090 m0 *1 166.82,218.4
X$25090 14520 14419 16051 14294 14521 15807 113 112 AOI221_X2
* cell instance $25092 m0 *1 169.1,218.4
X$25092 14260 16109 16052 112 113 16128 NOR3_X1
* cell instance $25094 m0 *1 170.05,218.4
X$25094 14188 16053 16128 112 14362 113 AOI21_X2
* cell instance $25095 m0 *1 171.38,218.4
X$25095 14423 16119 16124 113 16053 112 OAI21_X1
* cell instance $25096 m0 *1 172.14,218.4
X$25096 16054 14490 15089 15259 14294 112 113 16124 AOI221_X1
* cell instance $25099 r0 *1 156.56,218.4
X$25099 14795 15013 14600 15125 14483 112 113 16231 AOI221_X1
* cell instance $25100 r0 *1 157.7,218.4
X$25100 15137 16106 16069 112 16153 113 AOI21_X1
* cell instance $25101 r0 *1 158.46,218.4
X$25101 14260 16107 16048 16149 16153 16049 112 113 14150 OAI33_X1
* cell instance $25102 r0 *1 159.79,218.4
X$25102 16142 15471 15027 113 16172 112 OAI21_X1
* cell instance $25104 r0 *1 160.93,218.4
X$25104 15089 15904 16015 112 16108 113 AOI21_X1
* cell instance $25106 r0 *1 162.07,218.4
X$25106 15632 15756 14403 112 113 14962 NAND3_X2
* cell instance $25107 r0 *1 163.4,218.4
X$25107 14598 14522 16050 112 16142 113 AOI21_X1
* cell instance $25110 r0 *1 165.11,218.4
X$25110 16007 112 113 16136 BUF_X1
* cell instance $25114 r0 *1 167.01,218.4
X$25114 16104 14522 14408 112 16051 113 AOI21_X1
* cell instance $25117 r0 *1 168.91,218.4
X$25117 14421 14516 14598 113 16121 112 OAI21_X1
* cell instance $25118 r0 *1 169.67,218.4
X$25118 14598 14409 14419 113 16116 112 OAI21_X1
* cell instance $25119 r0 *1 170.43,218.4
X$25119 14423 16110 16126 14471 15419 14878 112 113 OAI221_X2
* cell instance $25120 r0 *1 172.52,218.4
X$25120 14471 14790 112 113 16110 NAND2_X1
* cell instance $25121 r0 *1 173.09,218.4
X$25121 16110 15366 16123 112 113 16119 MUX2_X1
* cell instance $25123 m0 *1 173.66,218.4
X$25123 14192 15479 112 113 16123 NAND2_X1
* cell instance $25125 m0 *1 174.8,218.4
X$25125 14424 112 113 15027 CLKBUF_X3
* cell instance $25128 m0 *1 175.94,218.4
X$25128 14524 15089 14526 112 113 16112 NAND3_X1
* cell instance $25130 m0 *1 177.46,218.4
X$25130 16114 15137 16113 112 113 15513 MUX2_X1
* cell instance $25136 m0 *1 195.7,218.4
X$25136 112 15381 113 14748 BUF_X8
* cell instance $25137 m0 *1 198.17,218.4
X$25137 112 14748 14658 113 BUF_X16
* cell instance $25146 r0 *1 174.99,218.4
X$25146 15974 14822 14791 16177 112 113 16115 AOI22_X1
* cell instance $25148 r0 *1 176.32,218.4
X$25148 16116 16217 16112 15027 16115 113 112 16113 OAI221_X1
* cell instance $25159 r0 *1 211.66,218.4
X$25159 112 14658 14651 113 BUF_X32
* cell instance $25198 r0 *1 66.69,212.8
X$25198 14987 15208 15713 113 112 14989 HA_X1
* cell instance $25199 m0 *1 68.4,212.8
X$25199 15713 113 14152 112 BUF_X4
* cell instance $25200 m0 *1 67.64,212.8
X$25200 15713 112 113 15823 BUF_X2
* cell instance $25205 r0 *1 68.59,212.8
X$25205 14127 14160 112 113 15879 NAND2_X1
* cell instance $25206 r0 *1 69.16,212.8
X$25206 112 15293 113 14152 BUF_X8
* cell instance $25207 m0 *1 70.3,212.8
X$25207 15063 15772 15822 15636 15824 113 112 15773 OAI221_X1
* cell instance $25209 m0 *1 71.44,212.8
X$25209 14152 113 15500 112 BUF_X4
* cell instance $25210 m0 *1 72.77,212.8
X$25210 112 15881 14152 14801 14709 113 AOI21_X4
* cell instance $25211 m0 *1 75.24,212.8
X$25211 15637 14887 112 113 15775 NOR2_X1
* cell instance $25213 r0 *1 71.63,212.8
X$25213 15101 14987 15539 112 15772 113 AOI21_X1
* cell instance $25215 r0 *1 72.58,212.8
X$25215 14978 113 15096 112 BUF_X4
* cell instance $25217 r0 *1 74.1,212.8
X$25217 14801 14709 15823 112 113 15790 NAND3_X2
* cell instance $25218 r0 *1 75.43,212.8
X$25218 14801 14709 14331 112 113 15721 NAND3_X2
* cell instance $25219 m0 *1 77.14,212.8
X$25219 15101 15535 112 113 15777 NOR2_X1
* cell instance $25220 m0 *1 76.19,212.8
X$25220 15101 112 113 15729 CLKBUF_X3
* cell instance $25221 m0 *1 77.71,212.8
X$25221 14763 15171 112 113 15716 NOR2_X1
* cell instance $25222 m0 *1 78.28,212.8
X$25222 15716 15825 14542 15535 14442 112 113 15778 AOI221_X1
* cell instance $25224 m0 *1 79.61,212.8
X$25224 15596 14800 112 113 15538 NOR2_X1
* cell instance $25225 m0 *1 80.18,212.8
X$25225 15642 15824 14716 15778 113 15854 112 NOR4_X2
* cell instance $25226 m0 *1 81.89,212.8
X$25226 15921 15920 15505 15855 15780 13411 112 113 OAI221_X2
* cell instance $25227 m0 *1 83.98,212.8
X$25227 14159 112 113 15502 BUF_X2
* cell instance $25228 m0 *1 84.74,212.8
X$25228 15171 15647 112 113 15720 OR2_X1
* cell instance $25229 m0 *1 85.5,212.8
X$25229 15539 15782 15211 112 15645 113 AOI21_X1
* cell instance $25230 m0 *1 86.26,212.8
X$25230 14547 14708 14492 113 112 15952 OAI21_X2
* cell instance $25231 m0 *1 87.59,212.8
X$25231 15826 15714 113 112 15859 AND2_X1
* cell instance $25232 m0 *1 88.35,212.8
X$25232 15723 15859 15725 113 15724 112 OAI21_X1
* cell instance $25233 m0 *1 89.11,212.8
X$25233 15171 14662 112 113 15726 NAND2_X1
* cell instance $25236 r0 *1 77.14,212.8
X$25236 14271 14708 14492 113 112 15826 OAI21_X2
* cell instance $25237 r0 *1 78.47,212.8
X$25237 14495 14933 112 113 15825 NOR2_X1
* cell instance $25239 r0 *1 79.23,212.8
X$25239 14800 14547 112 113 15641 NAND2_X1
* cell instance $25240 r0 *1 79.8,212.8
X$25240 15100 15641 14936 15823 15101 113 112 15883 OAI221_X1
* cell instance $25241 r0 *1 80.94,212.8
X$25241 14933 15826 15823 14980 113 112 15918 OAI22_X1
* cell instance $25245 r0 *1 84.36,212.8
X$25245 15858 15326 15720 112 113 15646 MUX2_X1
* cell instance $25249 r0 *1 88.16,212.8
X$25249 15888 14331 15064 112 15858 113 AOI21_X1
* cell instance $25250 r0 *1 88.92,212.8
X$25250 15886 15055 112 113 15887 NAND2_X1
* cell instance $25252 r0 *1 89.87,212.8
X$25252 15726 15333 112 113 15886 NAND2_X1
* cell instance $25253 m0 *1 91.39,212.8
X$25253 15726 15721 15326 112 113 15787 NAND3_X1
* cell instance $25254 m0 *1 90.06,212.8
X$25254 15724 14718 15219 112 113 15827 MUX2_X1
* cell instance $25255 m0 *1 92.15,212.8
X$25255 15787 15725 14807 112 113 15335 NAND3_X1
* cell instance $25256 m0 *1 92.91,212.8
X$25256 15060 15790 15542 112 113 15725 NAND3_X1
* cell instance $25257 m0 *1 93.67,212.8
X$25257 15728 15063 14442 112 15828 113 AOI21_X1
* cell instance $25259 m0 *1 94.62,212.8
X$25259 14771 15728 14498 15861 15789 113 112 15862 OAI221_X1
* cell instance $25260 m0 *1 95.76,212.8
X$25260 15729 15892 15066 15730 14612 113 112 15789 OAI221_X1
* cell instance $25261 m0 *1 96.9,212.8
X$25261 14158 15714 15729 112 113 15732 NAND3_X1
* cell instance $25263 m0 *1 97.85,212.8
X$25263 15727 15732 15861 112 113 15731 NAND3_X1
* cell instance $25267 r0 *1 90.44,212.8
X$25267 15183 112 113 15924 INV_X1
* cell instance $25269 r0 *1 91.2,212.8
X$25269 14271 14612 15326 14379 113 112 16000 OAI22_X1
* cell instance $25270 r0 *1 92.15,212.8
X$25270 14989 112 113 15860 INV_X1
* cell instance $25272 r0 *1 93.29,212.8
X$25272 14708 14492 15860 113 15888 112 NOR3_X2
* cell instance $25275 r0 *1 95.19,212.8
X$25275 15854 15862 112 113 15926 OR2_X2
* cell instance $25276 r0 *1 96.14,212.8
X$25276 14160 15730 112 113 15286 NOR2_X2
* cell instance $25277 r0 *1 97.09,212.8
X$25277 15730 14612 14856 113 15927 112 OAI21_X1
* cell instance $25279 r0 *1 98.04,212.8
X$25279 15733 15731 15718 112 113 16031 NAND3_X1
* cell instance $25280 r0 *1 98.8,212.8
X$25280 14943 112 113 15730 INV_X1
* cell instance $25281 r0 *1 99.18,212.8
X$25281 15543 14716 15930 112 113 15921 NAND3_X2
* cell instance $25283 m0 *1 102.98,212.8
X$25283 112 13560 113 15830 BUF_X8
* cell instance $25285 m0 *1 105.45,212.8
X$25285 14723 14501 15300 113 15865 112 OAI21_X1
* cell instance $25286 m0 *1 106.21,212.8
X$25286 15932 14563 15739 112 15650 113 AOI21_X1
* cell instance $25287 m0 *1 106.97,212.8
X$25287 15737 15735 15797 15734 14279 14343 113 112 AOI221_X2
* cell instance $25290 m0 *1 110.77,212.8
X$25290 15799 14015 15870 113 112 14052 OAI21_X2
* cell instance $25291 m0 *1 112.1,212.8
X$25291 15198 112 113 14275 CLKBUF_X3
* cell instance $25296 r0 *1 104.88,212.8
X$25296 15737 14808 15865 112 113 15649 MUX2_X1
* cell instance $25297 r0 *1 106.21,212.8
X$25297 14729 112 113 14897 CLKBUF_X3
* cell instance $25299 r0 *1 107.54,212.8
X$25299 14275 112 113 15893 INV_X1
* cell instance $25300 r0 *1 107.92,212.8
X$25300 14730 15829 14512 13890 113 112 15734 OAI22_X2
* cell instance $25301 r0 *1 109.63,212.8
X$25301 14169 14897 16090 15354 14132 113 112 14777 OAI221_X1
* cell instance $25302 r0 *1 110.77,212.8
X$25302 15229 15000 14808 112 15894 113 AOI21_X1
* cell instance $25304 r0 *1 111.72,212.8
X$25304 15204 15229 14574 113 15895 112 OAI21_X1
* cell instance $25306 r0 *1 112.86,212.8
X$25306 15348 112 113 14501 CLKBUF_X3
* cell instance $25307 m0 *1 114.57,212.8
X$25307 14872 15738 15804 113 15739 112 OAI21_X1
* cell instance $25308 m0 *1 113.43,212.8
X$25308 14140 14485 14729 14572 15735 112 113 15738 AOI221_X1
* cell instance $25309 m0 *1 115.33,212.8
X$25309 15232 15740 15621 112 113 15737 MUX2_X1
* cell instance $25313 r0 *1 114.38,212.8
X$25313 112 15741 15743 14955 14506 14503 15830 14100 113 AOI222_X2
* cell instance $25314 r0 *1 117.04,212.8
X$25314 15460 15936 15831 112 14725 113 AOI21_X2
* cell instance $25315 m0 *1 117.8,212.8
X$25315 14364 14577 112 113 15735 NOR2_X1
* cell instance $25316 m0 *1 117.04,212.8
X$25316 13561 14095 15605 112 113 15742 NAND3_X1
* cell instance $25318 m0 *1 118.56,212.8
X$25318 15745 14563 15744 112 15084 113 AOI21_X1
* cell instance $25319 m0 *1 119.32,212.8
X$25319 14501 15651 15742 15521 14241 113 112 15552 OAI221_X1
* cell instance $25322 r0 *1 118.56,212.8
X$25322 13561 15831 15235 113 15896 112 OAI21_X1
* cell instance $25324 r0 *1 119.51,212.8
X$25324 15008 15080 14487 112 15936 113 AOI21_X1
* cell instance $25326 r0 *1 120.46,212.8
X$25326 15348 14241 15235 113 112 15940 AND3_X1
* cell instance $25327 m0 *1 121.98,212.8
X$25327 14132 15001 14809 113 15747 112 OAI21_X1
* cell instance $25328 m0 *1 120.84,212.8
X$25328 14275 15743 13956 14506 15747 112 113 15745 AOI221_X1
* cell instance $25329 m0 *1 122.74,212.8
X$25329 15355 14906 15814 112 113 15832 MUX2_X1
* cell instance $25332 m0 *1 125.78,212.8
X$25332 14809 15357 14998 113 112 15748 OAI21_X2
* cell instance $25333 m0 *1 127.11,212.8
X$25333 13890 15120 15748 13695 15749 14974 112 113 OAI221_X2
* cell instance $25335 r0 *1 121.41,212.8
X$25335 15122 15235 14501 112 113 15938 NAND3_X1
* cell instance $25336 r0 *1 122.17,212.8
X$25336 14873 113 14789 112 BUF_X4
* cell instance $25337 r0 *1 123.5,212.8
X$25337 15944 14167 15832 112 14139 113 AOI21_X2
* cell instance $25343 r0 *1 125.4,212.8
X$25343 15874 14167 15946 112 14061 113 AOI21_X1
* cell instance $25346 r0 *1 126.73,212.8
X$25346 14100 14487 15459 113 15898 112 OAI21_X1
* cell instance $25348 r0 *1 127.87,212.8
X$25348 14485 13890 112 113 16018 NOR2_X1
* cell instance $25350 r0 *1 128.63,212.8
X$25350 15652 15357 14512 113 16017 112 OAI21_X1
* cell instance $25351 r0 *1 129.39,212.8
X$25351 16076 14579 112 113 15876 NAND2_X1
* cell instance $25352 m0 *1 130.34,212.8
X$25352 14364 112 113 15460 INV_X4
* cell instance $25353 m0 *1 129.58,212.8
X$25353 14401 14100 15740 113 15712 112 OAI21_X1
* cell instance $25354 m0 *1 131.29,212.8
X$25354 15622 14364 112 113 15749 NOR2_X1
* cell instance $25357 r0 *1 130.15,212.8
X$25357 15204 14401 112 113 15943 NOR2_X2
* cell instance $25358 r0 *1 131.1,212.8
X$25358 15357 14142 112 113 15899 NAND2_X1
* cell instance $25360 r0 *1 132.05,212.8
X$25360 15942 15833 15939 14869 15356 15874 113 112 AOI221_X2
* cell instance $25362 m0 *1 132.24,212.8
X$25362 15348 15657 15749 113 15833 112 OAI21_X1
* cell instance $25364 m0 *1 134.33,212.8
X$25364 13956 14364 112 113 15834 NOR2_X2
* cell instance $25369 m0 *1 137.37,212.8
X$25369 15937 113 15626 112 BUF_X4
* cell instance $25373 m0 *1 139.65,212.8
X$25373 15626 113 15878 112 BUF_X4
* cell instance $25374 m0 *1 140.98,212.8
X$25374 14791 16044 16579 113 112 15900 HA_X1
* cell instance $25375 m0 *1 142.88,212.8
X$25375 15358 7211 15304 112 113 NOR2_X4
* cell instance $25376 m0 *1 144.59,212.8
X$25376 7211 113 14791 112 BUF_X4
* cell instance $25378 m0 *1 146.68,212.8
X$25378 112 15011 10524 11075 15018 113 NOR3_X4
* cell instance $25379 m0 *1 149.34,212.8
X$25379 11075 113 15835 112 BUF_X4
* cell instance $25381 m0 *1 151.43,212.8
X$25381 14707 15750 15820 15473 14182 15815 112 113 OAI221_X2
* cell instance $25382 m0 *1 153.52,212.8
X$25382 15820 15757 14407 14262 15750 113 112 15751 OAI221_X1
* cell instance $25385 m0 *1 156.37,212.8
X$25385 15752 15473 15753 113 15754 112 OAI21_X1
* cell instance $25386 m0 *1 157.13,212.8
X$25386 15085 15015 15474 113 15753 112 OAI21_X1
* cell instance $25388 m0 *1 158.08,212.8
X$25388 14264 15663 14186 15754 113 112 16155 OAI22_X1
* cell instance $25393 r0 *1 139.46,212.8
X$25393 112 15878 14140 113 BUF_X16
* cell instance $25395 r0 *1 144.4,212.8
X$25395 15900 15659 112 15466 113 OR2_X4
* cell instance $25396 r0 *1 146.11,212.8
X$25396 11075 10524 15125 113 15877 112 NOR3_X2
* cell instance $25398 r0 *1 148.2,212.8
X$25398 112 7211 15836 15835 15628 113 NOR3_X4
* cell instance $25399 r0 *1 150.86,212.8
X$25399 14735 7211 112 113 15471 NOR2_X1
* cell instance $25400 r0 *1 151.43,212.8
X$25400 112 14813 15836 15835 15085 113 NOR3_X4
* cell instance $25402 r0 *1 154.28,212.8
X$25402 14421 15875 14293 112 15661 113 AOI21_X1
* cell instance $25404 r0 *1 155.23,212.8
X$25404 15366 15875 15010 14822 112 113 15837 AOI22_X1
* cell instance $25405 r0 *1 156.18,212.8
X$25405 15837 14407 14184 113 15929 112 OAI21_X1
* cell instance $25408 r0 *1 159.22,212.8
X$25408 15563 15667 15758 14790 15323 16068 113 112 AOI221_X2
* cell instance $25409 m0 *1 160.36,212.8
X$25409 14707 14820 14965 112 15755 113 AOI21_X1
* cell instance $25411 m0 *1 161.12,212.8
X$25411 15018 14483 112 113 15667 NOR2_X2
* cell instance $25412 m0 *1 162.07,212.8
X$25412 15018 15311 15140 112 113 15873 NOR3_X1
* cell instance $25415 m0 *1 163.78,212.8
X$25415 15815 14516 15839 113 112 14480 OAI21_X2
* cell instance $25416 m0 *1 165.11,212.8
X$25416 14483 15757 14521 14524 113 112 15839 OAI22_X1
* cell instance $25417 m0 *1 166.06,212.8
X$25417 14262 15904 15260 14292 112 113 15809 AOI22_X1
* cell instance $25418 m0 *1 167.01,212.8
X$25418 15758 15809 112 113 15518 OR2_X1
* cell instance $25419 m0 *1 167.77,212.8
X$25419 15840 15757 14592 112 113 15808 NOR3_X1
* cell instance $25421 m0 *1 168.72,212.8
X$25421 15757 14961 15415 112 15805 113 AOI21_X1
* cell instance $25423 r0 *1 161.31,212.8
X$25423 15474 15074 15083 113 112 15901 AND3_X1
* cell instance $25424 r0 *1 162.26,212.8
X$25424 15929 15838 112 113 15813 NOR2_X2
* cell instance $25425 r0 *1 163.21,212.8
X$25425 15311 15628 112 113 15872 NOR2_X1
* cell instance $25426 r0 *1 163.78,212.8
X$25426 15903 14703 14191 14592 15872 15864 113 112 AOI221_X2
* cell instance $25430 r0 *1 167.2,212.8
X$25430 15840 10522 15248 112 15871 113 AOI21_X1
* cell instance $25432 r0 *1 168.15,212.8
X$25432 15628 14520 14526 113 15905 112 OAI21_X1
* cell instance $25434 r0 *1 169.1,212.8
X$25434 15757 14795 112 113 15841 NAND2_X1
* cell instance $25435 r0 *1 169.67,212.8
X$25435 15083 14522 15841 113 15869 112 OAI21_X1
* cell instance $25436 m0 *1 171,212.8
X$25436 14261 14407 15843 15842 112 113 15867 OR4_X1
* cell instance $25437 m0 *1 169.86,212.8
X$25437 15807 15137 14184 14695 15869 113 112 15868 OAI221_X1
* cell instance $25439 r0 *1 170.43,212.8
X$25439 15474 15871 15841 15969 14293 113 112 15908 OAI221_X1
* cell instance $25440 r0 *1 171.57,212.8
X$25440 14191 15905 15841 112 15843 113 AOI21_X1
* cell instance $25442 m0 *1 172.71,212.8
X$25442 15697 15868 15075 15867 112 113 15793 AOI22_X1
* cell instance $25444 m0 *1 173.66,212.8
X$25444 14965 14180 112 113 15760 NOR2_X1
* cell instance $25447 m0 *1 175.18,212.8
X$25447 15795 15866 15516 15027 15761 113 112 15794 OAI221_X1
* cell instance $25450 r0 *1 172.71,212.8
X$25450 15836 15835 14490 15474 14820 113 112 15906 OAI221_X1
* cell instance $25453 r0 *1 174.99,212.8
X$25453 15074 15474 15760 112 113 15922 MUX2_X1
* cell instance $25455 r0 *1 176.51,212.8
X$25455 15923 15864 14407 113 15694 112 OAI21_X1
* cell instance $25457 m0 *1 177.65,212.8
X$25457 15794 15793 15863 113 112 15792 OAI21_X2
* cell instance $25459 m0 *1 178.98,212.8
X$25459 14187 15692 15844 112 15863 113 AOI21_X2
* cell instance $25464 m0 *1 188.86,212.8
X$25464 112 14748 113 14829 BUF_X8
* cell instance $25465 m0 *1 191.33,212.8
X$25465 14076 113 14198 112 BUF_X4
* cell instance $25466 m0 *1 192.66,212.8
X$25466 14528 13967 112 113 15570 NAND2_X1
* cell instance $25467 m0 *1 193.23,212.8
X$25467 14076 14528 112 15265 113 NAND2_X4
* cell instance $25468 m0 *1 194.94,212.8
X$25468 112 14204 113 14780 BUF_X8
* cell instance $25469 m0 *1 197.41,212.8
X$25469 14750 112 113 13925 CLKBUF_X3
* cell instance $25470 m0 *1 198.36,212.8
X$25470 13837 14314 14544 113 15762 112 OAI21_X1
* cell instance $25471 m0 *1 199.12,212.8
X$25471 15762 15674 13707 15763 15266 113 112 15675 OAI221_X1
* cell instance $25472 m0 *1 200.26,212.8
X$25472 14448 112 113 15266 CLKBUF_X3
* cell instance $25480 r0 *1 188.29,212.8
X$25480 13984 14651 16713 113 112 14338 HA_X1
* cell instance $25482 r0 *1 191.71,212.8
X$25482 14076 113 14573 112 BUF_X4
* cell instance $25484 r0 *1 193.42,212.8
X$25484 14528 113 14314 112 BUF_X4
* cell instance $25485 r0 *1 194.75,212.8
X$25485 14780 13967 14195 113 15919 112 OAI21_X1
* cell instance $25487 r0 *1 195.7,212.8
X$25487 14198 113 14539 112 BUF_X4
* cell instance $25488 r0 *1 197.03,212.8
X$25488 15266 13707 15845 112 113 15291 NOR3_X1
* cell instance $25489 r0 *1 197.79,212.8
X$25489 15845 14573 15919 112 113 15150 MUX2_X1
* cell instance $25491 r0 *1 199.31,212.8
X$25491 13915 15265 14433 14750 113 112 15909 OAI22_X1
* cell instance $25492 r0 *1 200.26,212.8
X$25492 15267 15166 14539 14204 112 113 15846 NAND4_X1
* cell instance $25507 m0 *1 67.45,210
X$25507 15635 15101 15531 112 113 15580 MUX2_X1
* cell instance $25509 m0 *1 68.97,210
X$25509 15326 14846 112 113 15636 NAND2_X1
* cell instance $25510 m0 *1 69.54,210
X$25510 14801 14709 15532 112 113 15581 NAND3_X1
* cell instance $25511 m0 *1 70.3,210
X$25511 14160 112 113 15398 CLKBUF_X3
* cell instance $25512 m0 *1 71.25,210
X$25512 14160 113 15326 112 BUF_X4
* cell instance $25513 m0 *1 72.58,210
X$25513 15585 15584 15216 113 15497 112 OAI21_X1
* cell instance $25515 m0 *1 73.53,210
X$25515 15209 113 15100 112 BUF_X4
* cell instance $25516 m0 *1 74.86,210
X$25516 15532 14552 14445 113 15586 112 OAI21_X1
* cell instance $25518 m0 *1 75.81,210
X$25518 14850 15398 15586 112 15688 113 AOI21_X1
* cell instance $25519 m0 *1 76.57,210
X$25519 15533 112 113 15532 INV_X1
* cell instance $25520 m0 *1 76.95,210
X$25520 15636 15536 15534 113 112 15689 AND3_X1
* cell instance $25521 m0 *1 77.9,210
X$25521 14713 14331 112 113 15589 NAND2_X1
* cell instance $25522 m0 *1 78.47,210
X$25522 112 15642 14718 15640 15438 113 AOI21_X4
* cell instance $25544 r0 *1 69.35,210
X$25544 15216 15723 15293 112 113 15822 NAND3_X1
* cell instance $25545 r0 *1 70.11,210
X$25545 15714 14989 14552 113 112 15635 OAI21_X2
* cell instance $25546 r0 *1 71.44,210
X$25546 14492 14708 14977 15398 15274 113 112 15774 OAI221_X1
* cell instance $25548 r0 *1 72.96,210
X$25548 15581 14992 15326 112 113 15640 NAND3_X1
* cell instance $25549 r0 *1 73.72,210
X$25549 15437 15775 14607 15723 14932 15715 113 112 AOI221_X2
* cell instance $25551 r0 *1 76,210
X$25551 14765 15714 14992 112 15776 113 AOI21_X1
* cell instance $25553 r0 *1 76.95,210
X$25553 15687 15776 112 113 15638 OR2_X1
* cell instance $25555 r0 *1 77.9,210
X$25555 14763 14934 112 113 15536 NAND2_X1
* cell instance $25556 r0 *1 78.47,210
X$25556 15718 15499 15690 113 15779 112 OAI21_X1
* cell instance $25557 r0 *1 79.23,210
X$25557 15717 15689 15718 15588 113 112 15639 OAI22_X1
* cell instance $25558 r0 *1 80.18,210
X$25558 15168 15641 14943 14664 113 112 15644 OAI22_X1
* cell instance $25559 r0 *1 81.13,210
X$25559 15643 14859 15779 113 112 15780 OAI21_X2
* cell instance $25560 m0 *1 82.46,210
X$25560 15645 14451 14609 15644 15281 112 113 15643 AOI221_X1
* cell instance $25561 m0 *1 81.32,210
X$25561 15641 14982 15718 15537 15102 113 112 15690 OAI221_X1
* cell instance $25562 m0 *1 83.6,210
X$25562 13585 112 113 16722 INV_X4
* cell instance $25563 m0 *1 84.55,210
X$25563 14552 15532 15542 112 15782 113 AOI21_X1
* cell instance $25564 m0 *1 85.31,210
X$25564 15331 112 113 15446 BUF_X1
* cell instance $25565 m0 *1 85.88,210
X$25565 14609 15503 15639 112 113 15699 NOR3_X1
* cell instance $25566 m0 *1 86.64,210
X$25566 15287 15591 14765 112 113 15332 NAND3_X1
* cell instance $25568 r0 *1 82.46,210
X$25568 15884 14854 15715 15505 15781 15719 112 113 15698 OAI33_X1
* cell instance $25569 r0 *1 83.79,210
X$25569 15638 14607 15646 15717 15784 14766 112 113 OAI221_X2
* cell instance $25572 m0 *1 89.11,210
X$25572 15539 14558 112 113 15541 NOR2_X1
* cell instance $25573 m0 *1 87.78,210
X$25573 15580 14718 15691 112 113 15592 MUX2_X1
* cell instance $25575 m0 *1 90.44,210
X$25575 15542 15533 14552 113 112 14990 OAI21_X2
* cell instance $25578 m0 *1 94.05,210
X$25578 14708 14492 14983 113 15701 112 OAI21_X1
* cell instance $25580 m0 *1 95,210
X$25580 15099 14763 15405 113 15727 112 OAI21_X1
* cell instance $25582 m0 *1 96.52,210
X$25582 15099 15542 112 113 15449 NOR2_X1
* cell instance $25584 m0 *1 97.85,210
X$25584 15405 15596 112 113 15597 OR2_X1
* cell instance $25585 m0 *1 98.61,210
X$25585 15597 15598 15337 14451 15648 113 112 15543 OAI221_X1
* cell instance $25587 m0 *1 105.83,210
X$25587 15604 13823 15601 113 15602 112 OAI21_X1
* cell instance $25590 r0 *1 88.16,210
X$25590 15723 14157 14846 14213 113 112 15691 OAI22_X1
* cell instance $25591 r0 *1 89.11,210
X$25591 15722 15539 15508 112 15540 113 AOI21_X1
* cell instance $25592 r0 *1 89.87,210
X$25592 112 15098 14492 14708 15722 113 NOR3_X4
* cell instance $25595 r0 *1 93.1,210
X$25595 15698 15788 15699 112 113 14226 OR3_X2
* cell instance $25596 r0 *1 94.24,210
X$25596 14655 14558 112 113 15505 OR2_X1
* cell instance $25598 r0 *1 95.38,210
X$25598 15729 15701 15790 112 15703 113 AOI21_X1
* cell instance $25600 r0 *1 96.33,210
X$25600 14497 15730 15729 112 15702 113 AOI21_X1
* cell instance $25601 r0 *1 97.09,210
X$25601 15066 14497 112 113 15728 NAND2_X1
* cell instance $25603 r0 *1 97.85,210
X$25603 15537 15222 15702 113 15733 112 OAI21_X1
* cell instance $25606 r0 *1 99.18,210
X$25606 15703 14859 112 113 15648 NOR2_X1
* cell instance $25611 r0 *1 105.45,210
X$25611 15117 112 113 13822 CLKBUF_X3
* cell instance $25614 r0 *1 106.97,210
X$25614 15796 15300 14463 113 15797 112 OAI21_X1
* cell instance $25615 r0 *1 107.73,210
X$25615 14275 15460 14577 113 15796 112 OAI21_X1
* cell instance $25619 m0 *1 110.01,210
X$25619 15705 15544 14563 112 113 15706 NOR3_X1
* cell instance $25620 r0 *1 110.2,210
X$25620 15708 15605 112 113 15410 NOR2_X1
* cell instance $25621 r0 *1 110.77,210
X$25621 15800 13823 15706 15803 14015 15799 112 113 OAI221_X2
* cell instance $25623 m0 *1 111.15,210
X$25623 15229 14500 13695 112 113 15705 NOR3_X1
* cell instance $25624 m0 *1 112.48,210
X$25624 14279 14869 112 113 14872 NOR2_X1
* cell instance $25626 m0 *1 113.05,210
X$25626 15460 14485 112 113 15548 NOR2_X1
* cell instance $25628 m0 *1 113.81,210
X$25628 15548 14869 15349 112 113 15455 NAND3_X1
* cell instance $25629 m0 *1 114.57,210
X$25629 14500 15349 14734 112 14503 113 AOI21_X2
* cell instance $25631 m0 *1 116.66,210
X$25631 15652 112 113 15349 INV_X1
* cell instance $25635 r0 *1 113.05,210
X$25635 15548 15307 14723 113 15804 112 OAI21_X1
* cell instance $25637 r0 *1 114,210
X$25637 15736 13822 14283 113 15803 112 OAI21_X1
* cell instance $25639 r0 *1 115.14,210
X$25639 15741 15354 15708 14132 15742 14350 112 113 OAI221_X2
* cell instance $25640 r0 *1 117.23,210
X$25640 15743 14140 15460 14485 14723 15309 113 112 AOI221_X2
* cell instance $25641 m0 *1 119.13,210
X$25641 14486 14500 112 113 15651 NOR2_X1
* cell instance $25643 m0 *1 119.7,210
X$25643 15552 14866 15608 112 113 15800 MUX2_X1
* cell instance $25646 r0 *1 119.32,210
X$25646 15709 14563 15746 112 14058 113 AOI21_X1
* cell instance $25647 r0 *1 120.08,210
X$25647 112 15000 113 15812 BUF_X8
* cell instance $25648 r0 *1 122.55,210
X$25648 13560 15708 15653 15354 15605 113 112 15814 OAI221_X1
* cell instance $25649 m0 *1 123.12,210
X$25649 15554 15710 14283 112 113 15601 NAND3_X1
* cell instance $25651 m0 *1 123.88,210
X$25651 15654 15123 15555 14906 112 113 15710 NAND4_X1
* cell instance $25652 m0 *1 124.83,210
X$25652 14730 15348 14509 112 113 15555 NAND3_X1
* cell instance $25653 m0 *1 125.59,210
X$25653 14577 14876 112 113 15654 NAND2_X1
* cell instance $25656 r0 *1 123.69,210
X$25656 15614 15740 112 113 15653 NAND2_X1
* cell instance $25662 r0 *1 124.83,210
X$25662 15653 15654 14279 112 113 15711 NAND3_X1
* cell instance $25665 r0 *1 126.54,210
X$25665 15652 14733 14732 113 112 15122 OAI21_X2
* cell instance $25666 m0 *1 127.49,210
X$25666 14733 14732 15318 113 15614 112 NOR3_X2
* cell instance $25668 m0 *1 128.82,210
X$25668 15556 15235 14873 112 113 15617 NAND3_X1
* cell instance $25670 m0 *1 129.77,210
X$25670 15617 15712 112 113 14972 NAND2_X1
* cell instance $25671 m0 *1 130.34,210
X$25671 14809 15556 15348 112 113 14579 NAND3_X1
* cell instance $25673 m0 *1 131.29,210
X$25673 14876 15460 15356 113 15656 112 OAI21_X1
* cell instance $25675 m0 *1 132.24,210
X$25675 15550 14364 14508 113 15620 112 OAI21_X1
* cell instance $25676 m0 *1 133,210
X$25676 15462 15232 15008 112 15657 113 AOI21_X1
* cell instance $25677 m0 *1 133.76,210
X$25677 13956 112 113 15622 INV_X2
* cell instance $25679 m0 *1 134.52,210
X$25679 15008 15621 112 113 15658 NAND2_X1
* cell instance $25680 m0 *1 135.09,210
X$25680 15658 15622 15124 112 113 15464 MUX2_X1
* cell instance $25682 m0 *1 137.18,210
X$25682 15626 14733 14732 113 112 15556 OAI21_X4
* cell instance $25683 m0 *1 139.65,210
X$25683 15626 112 113 14509 INV_X8
* cell instance $25686 r0 *1 127.87,210
X$25686 15711 15817 14463 14789 15816 15709 113 112 AOI221_X2
* cell instance $25689 r0 *1 130.34,210
X$25689 15655 15712 112 113 15817 NAND2_X1
* cell instance $25691 r0 *1 131.1,210
X$25691 14364 15550 14734 112 15655 113 AOI21_X1
* cell instance $25693 r0 *1 132.24,210
X$25693 15620 15656 112 113 15816 NAND2_X1
* cell instance $25694 r0 *1 132.81,210
X$25694 13956 113 14463 112 BUF_X4
* cell instance $25697 r0 *1 135.09,210
X$25697 112 15626 14732 14733 15229 113 NOR3_X4
* cell instance $25698 r0 *1 137.75,210
X$25698 15556 14809 112 113 15124 NAND2_X2
* cell instance $25701 m0 *1 143.26,210
X$25701 15125 14289 15467 112 113 15629 MUX2_X1
* cell instance $25702 m0 *1 144.78,210
X$25702 112 14517 15659 14515 14514 113 AOI21_X4
* cell instance $25703 m0 *1 147.25,210
X$25703 15632 15756 14024 12002 112 113 15470 AOI22_X2
* cell instance $25706 r0 *1 144.97,210
X$25706 11075 10524 15465 112 113 NOR2_X4
* cell instance $25707 r0 *1 146.68,210
X$25707 15659 15465 112 113 15557 OR2_X1
* cell instance $25710 r0 *1 148.01,210
X$25710 15465 14699 112 113 15473 NOR2_X2
* cell instance $25711 r0 *1 148.96,210
X$25711 14699 112 113 15660 BUF_X1
* cell instance $25713 m0 *1 149.34,210
X$25713 15557 14965 15083 113 112 15323 OAI21_X2
* cell instance $25714 m0 *1 150.86,210
X$25714 15470 14293 14180 14421 15629 15704 113 112 AOI221_X2
* cell instance $25716 m0 *1 153.14,210
X$25716 15630 15435 14301 15026 15707 113 112 15819 OAI221_X1
* cell instance $25720 r0 *1 150.67,210
X$25720 15358 15877 112 113 15820 OR2_X2
* cell instance $25723 r0 *1 152.19,210
X$25723 15821 15415 14182 113 15558 112 OAI21_X1
* cell instance $25724 r0 *1 152.95,210
X$25724 14884 14630 113 112 15750 AND2_X1
* cell instance $25725 r0 *1 153.71,210
X$25725 15245 14301 15661 14525 113 15662 112 NOR4_X2
* cell instance $25727 m0 *1 154.66,210
X$25727 15013 15660 15140 112 15707 113 AOI21_X1
* cell instance $25728 m0 *1 156.94,210
X$25728 14517 15660 14421 112 15633 113 AOI21_X1
* cell instance $25729 m0 *1 157.7,210
X$25729 14740 15559 14694 15633 112 113 15663 AOI22_X1
* cell instance $25730 m0 *1 158.65,210
X$25730 14740 14594 112 113 15669 NAND2_X1
* cell instance $25731 m0 *1 159.22,210
X$25731 15560 14186 14187 113 15664 112 OAI21_X1
* cell instance $25732 m0 *1 159.98,210
X$25732 15018 14190 112 113 15559 NOR2_X1
* cell instance $25736 r0 *1 155.8,210
X$25736 15660 112 113 15801 BUF_X1
* cell instance $25737 r0 *1 156.37,210
X$25737 14526 15248 14702 113 15752 112 OAI21_X1
* cell instance $25739 r0 *1 157.51,210
X$25739 14180 14182 112 113 15758 NAND2_X2
* cell instance $25740 r0 *1 158.46,210
X$25740 15662 15664 15665 15818 113 15666 112 NOR4_X2
* cell instance $25741 r0 *1 160.17,210
X$25741 14703 15755 14264 14489 15667 15818 113 112 AOI221_X2
* cell instance $25743 m0 *1 161.69,210
X$25743 15475 15559 14471 14262 15669 15561 113 112 AOI221_X2
* cell instance $25744 r0 *1 162.26,210
X$25744 15667 14884 14192 14790 15669 112 113 15670 AOI221_X1
* cell instance $25745 r0 *1 163.4,210
X$25745 15027 15670 15704 112 113 15692 OR3_X1
* cell instance $25746 m0 *1 164.35,210
X$25746 15632 15756 15259 112 113 15141 NAND3_X2
* cell instance $25750 r0 *1 164.35,210
X$25750 15368 15666 15813 15562 113 112 15514 OAI22_X2
* cell instance $25751 r0 *1 166.06,210
X$25751 14260 15023 15811 112 113 15524 OR3_X1
* cell instance $25752 m0 *1 167.01,210
X$25752 14425 15482 14694 112 113 15810 NOR3_X1
* cell instance $25755 r0 *1 167.01,210
X$25755 14264 15810 15808 15758 15671 15759 112 113 15811 OAI33_X1
* cell instance $25756 m0 *1 168.91,210
X$25756 14965 14961 112 113 15475 NAND2_X1
* cell instance $25757 m0 *1 168.15,210
X$25757 14592 14962 15475 112 15671 113 AOI21_X1
* cell instance $25758 m0 *1 169.48,210
X$25758 14483 15563 14962 112 15700 113 AOI21_X1
* cell instance $25759 m0 *1 170.24,210
X$25759 15563 15141 14424 14694 112 113 15696 NAND4_X1
* cell instance $25761 m0 *1 171.38,210
X$25761 15700 14266 112 113 15625 NOR2_X1
* cell instance $25763 r0 *1 168.34,210
X$25763 14425 15085 15479 112 113 15759 NOR3_X1
* cell instance $25765 r0 *1 169.29,210
X$25765 15805 14790 15806 112 113 15693 MUX2_X1
* cell instance $25766 r0 *1 170.62,210
X$25766 15479 15805 15627 15026 15260 113 112 15802 OAI221_X1
* cell instance $25768 r0 *1 172.14,210
X$25768 15802 14407 15564 112 113 15761 MUX2_X1
* cell instance $25769 m0 *1 174.42,210
X$25769 15696 14188 112 113 15566 NAND2_X1
* cell instance $25770 m0 *1 172.33,210
X$25770 15624 15625 14297 15623 15519 15697 113 112 AOI221_X2
* cell instance $25771 m0 *1 174.99,210
X$25771 15083 15026 112 113 15695 NAND2_X1
* cell instance $25772 m0 *1 175.56,210
X$25772 15485 15695 15566 15693 14184 15615 113 112 AOI221_X2
* cell instance $25776 r0 *1 173.47,210
X$25776 15801 15760 14423 112 113 15798 MUX2_X1
* cell instance $25778 r0 *1 175.56,210
X$25778 15140 15798 15027 113 15795 112 OAI21_X1
* cell instance $25786 r0 *1 186.01,210
X$25786 13967 113 13915 112 BUF_X4
* cell instance $25788 m0 *1 187.15,210
X$25788 13915 13916 16550 113 112 14527 HA_X1
* cell instance $25790 m0 *1 190,210
X$25790 14829 113 14206 112 BUF_X4
* cell instance $25791 m0 *1 191.33,210
X$25791 15070 112 113 14336 BUF_X1
* cell instance $25793 m0 *1 192.66,210
X$25793 14053 14206 15267 112 15672 113 AOI21_X1
* cell instance $25794 m0 *1 193.42,210
X$25794 14527 112 113 15404 CLKBUF_X2
* cell instance $25795 m0 *1 194.18,210
X$25795 15268 15569 13707 14748 15568 113 112 15567 OAI221_X1
* cell instance $25796 m0 *1 195.32,210
X$25796 14245 14314 14108 112 113 15606 MUX2_X1
* cell instance $25797 m0 *1 196.65,210
X$25797 13919 14748 112 113 15571 NOR2_X1
* cell instance $25798 m0 *1 197.22,210
X$25798 15571 15266 14038 14336 13979 113 112 15600 OAI221_X1
* cell instance $25799 m0 *1 198.36,210
X$25799 15603 15674 15569 112 113 15290 NOR3_X1
* cell instance $25800 m0 *1 199.12,210
X$25800 13925 15675 15600 113 112 14918 AND3_X2
* cell instance $25801 m0 *1 200.26,210
X$25801 14316 15569 13979 112 15573 113 AOI21_X1
* cell instance $25803 m0 *1 201.21,210
X$25803 15676 15573 13706 112 113 13924 NOR3_X1
* cell instance $25807 r0 *1 189.62,210
X$25807 14829 112 113 14780 INV_X4
* cell instance $25810 r0 *1 192.47,210
X$25810 15404 15672 15570 15376 14204 113 112 15791 OAI221_X1
* cell instance $25812 r0 *1 193.8,210
X$25812 15567 13925 15791 112 15673 113 AOI21_X2
* cell instance $25813 r0 *1 195.13,210
X$25813 13703 14076 112 113 15569 NAND2_X1
* cell instance $25814 r0 *1 195.7,210
X$25814 14573 113 13973 112 BUF_X4
* cell instance $25817 r0 *1 197.6,210
X$25817 14779 112 113 14311 CLKBUF_X3
* cell instance $25818 r0 *1 198.55,210
X$25818 14448 14779 112 113 15494 NAND2_X1
* cell instance $25819 r0 *1 199.12,210
X$25819 15673 13995 14122 15786 14666 113 112 AOI211_X2
* cell instance $25820 r0 *1 200.83,210
X$25820 14548 13925 15846 15494 14531 113 112 15676 OAI221_X1
* cell instance $25821 r0 *1 201.97,210
X$25821 13922 14779 112 113 15674 NOR2_X1
* cell instance $25822 m0 *1 203.68,210
X$25822 14206 13835 14209 13979 113 112 15677 OAI22_X1
* cell instance $25823 m0 *1 202.35,210
X$25823 14649 113 14202 112 BUF_X4
* cell instance $25824 m0 *1 204.63,210
X$25824 15570 15379 13973 13916 112 113 15576 NAND4_X1
* cell instance $25825 m0 *1 205.58,210
X$25825 15577 15267 15266 113 15578 112 OAI21_X1
* cell instance $25826 m0 *1 206.34,210
X$25826 14038 15578 15576 112 15383 113 AOI21_X1
* cell instance $25827 m0 *1 207.1,210
X$25827 13639 14544 15385 112 14326 113 AOI21_X2
* cell instance $25828 m0 *1 208.43,210
X$25828 14198 15679 15487 112 15680 113 AOI21_X1
* cell instance $25829 m0 *1 209.19,210
X$25829 13919 14573 15680 13797 14209 15491 113 112 AOI221_X2
* cell instance $25835 r0 *1 203.87,210
X$25835 13707 15677 15166 112 15764 113 AOI21_X1
* cell instance $25836 r0 *1 204.63,210
X$25836 14202 113 14069 112 BUF_X4
* cell instance $25837 r0 *1 205.96,210
X$25837 15266 15765 14326 113 15783 112 OAI21_X1
* cell instance $25838 r0 *1 206.72,210
X$25838 15678 15404 14202 112 15765 113 AOI21_X1
* cell instance $25840 r0 *1 207.67,210
X$25840 15376 13639 112 113 14123 NOR2_X2
* cell instance $25842 r0 *1 209,210
X$25842 14779 14245 112 113 15678 NOR2_X2
* cell instance $25843 r0 *1 209.95,210
X$25843 14195 13910 14531 112 113 15767 NAND3_X2
* cell instance $25844 r0 *1 211.28,210
X$25844 15376 14311 15381 112 113 15768 NAND3_X1
* cell instance $25845 r0 *1 212.04,210
X$25845 15379 14539 13916 112 113 15769 NAND3_X1
* cell instance $25846 r0 *1 212.8,210
X$25846 14658 15379 14108 14311 113 112 15682 OAI22_X1
* cell instance $25848 m0 *1 213.18,210
X$25848 15575 14038 15683 112 113 15582 MUX2_X1
* cell instance $25849 m0 *1 214.7,210
X$25849 15684 14839 15582 112 113 14216 MUX2_X1
* cell instance $25850 m0 *1 216.03,210
X$25850 13922 14037 112 113 15047 NOR2_X1
* cell instance $25853 r0 *1 213.94,210
X$25853 14787 15686 14037 15682 112 113 15770 AOI22_X1
* cell instance $25854 r0 *1 214.89,210
X$25854 14122 15770 15685 113 15684 112 OAI21_X1
* cell instance $25855 r0 *1 215.65,210
X$25855 15849 15047 14122 113 15685 112 OAI21_X1
* cell instance $25857 r0 *1 216.6,210
X$25857 15848 13973 15678 112 113 15388 MUX2_X1
* cell instance $25858 m0 *1 217.17,210
X$25858 13915 14651 16570 113 112 14852 HA_X1
* cell instance $25860 m0 *1 219.07,210
X$25860 14852 113 14108 112 BUF_X4
* cell instance $25885 r0 *1 11.59,114.8
X$25885 7876 112 113 8075 BUF_X1
* cell instance $25890 r0 *1 12.92,114.8
X$25890 8010 112 113 6979 CLKBUF_X2
* cell instance $25893 r0 *1 15.39,114.8
X$25893 8011 112 113 6909 BUF_X1
* cell instance $25896 r0 *1 18.24,114.8
X$25896 112 17113 7952 7321 7061 113 DFF_X1
* cell instance $25898 m0 *1 23.56,114.8
X$25898 7632 113 7635 112 BUF_X4
* cell instance $25899 m0 *1 22.8,114.8
X$25899 7568 3834 112 113 6505 OR2_X1
* cell instance $25900 m0 *1 24.89,114.8
X$25900 7633 7632 7488 112 7625 113 NAND3_X4
* cell instance $25901 m0 *1 27.36,114.8
X$25901 7305 7847 7706 113 7955 112 OAI21_X1
* cell instance $25902 m0 *1 28.12,114.8
X$25902 7403 113 7707 112 BUF_X4
* cell instance $25904 m0 *1 29.64,114.8
X$25904 7845 7955 7572 112 113 7958 NAND3_X1
* cell instance $25905 m0 *1 30.4,114.8
X$25905 7956 7445 7126 112 7491 113 AOI21_X1
* cell instance $25906 m0 *1 31.16,114.8
X$25906 7709 7880 7707 112 113 7957 NAND3_X1
* cell instance $25907 m0 *1 31.92,114.8
X$25907 7793 7217 6902 7796 112 113 7845 AOI22_X1
* cell instance $25908 m0 *1 32.87,114.8
X$25908 7633 7632 7216 112 7795 113 NAND3_X4
* cell instance $25909 m0 *1 35.34,114.8
X$25909 7224 7635 7619 112 7796 113 AOI21_X2
* cell instance $25912 r0 *1 23.37,114.8
X$25912 7488 112 113 8236 BUF_X1
* cell instance $25913 r0 *1 23.94,114.8
X$25913 7633 113 7619 112 BUF_X4
* cell instance $25915 r0 *1 25.46,114.8
X$25915 8012 7305 7848 112 113 7877 NOR3_X1
* cell instance $25916 r0 *1 26.22,114.8
X$25916 8083 7877 7970 113 8013 112 OAI21_X1
* cell instance $25917 r0 *1 26.98,114.8
X$25917 7176 7879 7623 112 113 8083 NOR3_X1
* cell instance $25918 r0 *1 27.74,114.8
X$25918 7636 8082 7301 112 7878 113 AOI21_X1
* cell instance $25919 r0 *1 28.5,114.8
X$25919 7878 7954 7703 113 8087 112 OAI21_X1
* cell instance $25920 r0 *1 29.26,114.8
X$25920 7178 7391 7296 113 112 7709 OAI21_X4
* cell instance $25921 r0 *1 31.73,114.8
X$25921 7958 7703 7490 112 8088 113 NAND3_X4
* cell instance $25922 r0 *1 34.2,114.8
X$25922 7065 7632 7633 112 7881 113 AOI21_X2
* cell instance $25924 r0 *1 35.91,114.8
X$25924 7961 7970 7576 112 8017 113 AOI21_X2
* cell instance $25925 m0 *1 37.81,114.8
X$25925 7499 7884 7882 7622 7960 7961 113 112 AOI221_X2
* cell instance $25926 m0 *1 37.05,114.8
X$25926 7402 7880 7847 112 113 7846 NAND3_X1
* cell instance $25928 m0 *1 40.09,114.8
X$25928 7444 7302 7487 112 113 7885 NOR3_X1
* cell instance $25929 m0 *1 40.85,114.8
X$25929 7848 7964 8018 113 7966 112 OAI21_X1
* cell instance $25930 m0 *1 41.61,114.8
X$25930 7632 7633 7065 112 113 6969 NAND3_X2
* cell instance $25931 m0 *1 42.94,114.8
X$25931 7302 6901 7887 112 7964 113 AOI21_X1
* cell instance $25934 r0 *1 37.43,114.8
X$25934 7010 7706 7641 112 7883 113 AOI21_X1
* cell instance $25935 r0 *1 38.19,114.8
X$25935 112 7879 7395 7632 7633 113 AOI21_X4
* cell instance $25936 r0 *1 40.66,114.8
X$25936 6965 112 113 7887 CLKBUF_X3
* cell instance $25937 r0 *1 41.61,114.8
X$25937 7403 7394 112 113 8095 NOR2_X1
* cell instance $25938 r0 *1 42.18,114.8
X$25938 6969 8247 7965 112 113 8018 NAND3_X1
* cell instance $25939 r0 *1 42.94,114.8
X$25939 7069 7394 112 113 7860 NOR2_X1
* cell instance $25940 r0 *1 43.51,114.8
X$25940 8095 7886 7887 113 8097 112 OAI21_X1
* cell instance $25941 m0 *1 44.84,114.8
X$25941 7719 8099 7621 7967 7888 7799 113 112 AOI221_X2
* cell instance $25942 m0 *1 44.08,114.8
X$25942 7503 7634 112 113 7967 OR2_X1
* cell instance $25943 m0 *1 46.93,114.8
X$25943 7619 6967 7635 112 7880 113 NAND3_X4
* cell instance $25945 m0 *1 49.59,114.8
X$25945 7889 7718 7799 112 113 7969 OR3_X4
* cell instance $25948 r0 *1 44.65,114.8
X$25948 8097 7397 113 112 8021 AND2_X2
* cell instance $25950 r0 *1 45.79,114.8
X$25950 7966 8016 7498 112 113 8019 MUX2_X1
* cell instance $25951 r0 *1 47.12,114.8
X$25951 7397 112 113 7888 INV_X1
* cell instance $25954 r0 *1 48.07,114.8
X$25954 8020 7703 112 113 8103 NOR2_X1
* cell instance $25956 r0 *1 48.83,114.8
X$25956 7402 7795 113 8022 112 AND2_X4
* cell instance $25957 r0 *1 50.54,114.8
X$25957 7501 112 113 7703 CLKBUF_X3
* cell instance $25959 r0 *1 51.68,114.8
X$25959 7395 6798 7640 112 113 8104 MUX2_X1
* cell instance $25961 m0 *1 52.06,114.8
X$25961 7798 7970 7852 112 113 7971 MUX2_X1
* cell instance $25964 r0 *1 53.2,114.8
X$25964 7219 6966 7445 7640 8106 113 112 8109 OAI221_X1
* cell instance $25965 r0 *1 54.34,114.8
X$25965 8106 8024 112 113 8023 NOR2_X1
* cell instance $25966 m0 *1 55.29,114.8
X$25966 7588 7891 7582 113 7975 112 OAI21_X1
* cell instance $25967 m0 *1 54.53,114.8
X$25967 6902 7501 7224 112 7891 113 AOI21_X1
* cell instance $25968 m0 *1 56.05,114.8
X$25968 7802 113 7219 112 BUF_X4
* cell instance $25969 m0 *1 57.38,114.8
X$25969 7011 113 6798 112 BUF_X4
* cell instance $25970 m0 *1 58.71,114.8
X$25970 7012 112 113 7507 BUF_X2
* cell instance $25971 m0 *1 59.47,114.8
X$25971 7404 112 113 7859 BUF_X1
* cell instance $25972 m0 *1 60.04,114.8
X$25972 7708 112 113 7405 BUF_X1
* cell instance $25973 m0 *1 60.61,114.8
X$25973 7860 7803 7802 113 7892 112 NOR3_X2
* cell instance $25974 m0 *1 61.94,114.8
X$25974 7803 112 113 7128 CLKBUF_X3
* cell instance $25977 r0 *1 54.91,114.8
X$25977 7128 7802 112 113 7890 NAND2_X1
* cell instance $25978 r0 *1 55.48,114.8
X$25978 7222 7975 8109 113 8107 112 OAI21_X1
* cell instance $25979 r0 *1 56.24,114.8
X$25979 7219 7224 112 113 8106 NAND2_X1
* cell instance $25980 r0 *1 56.81,114.8
X$25980 7621 8110 7851 112 8025 113 AOI21_X1
* cell instance $25982 r0 *1 59.09,114.8
X$25982 7011 7802 112 113 8026 NOR2_X1
* cell instance $25983 r0 *1 59.66,114.8
X$25983 7977 8026 8262 7582 7892 8113 113 112 AOI221_X2
* cell instance $25985 r0 *1 63.27,114.8
X$25985 112 17112 7893 7978 6855 113 DFF_X1
* cell instance $25986 m0 *1 64.22,114.8
X$25986 7893 186 6194 112 113 7978 MUX2_X1
* cell instance $25990 m0 *1 65.93,114.8
X$25990 7893 5393 112 113 7509 NAND2_X1
* cell instance $25999 m0 *1 26.22,98
X$25999 6030 112 113 5439 INV_X8
* cell instance $26000 m0 *1 27.93,98
X$26000 4840 113 4460 112 BUF_X4
* cell instance $26001 m0 *1 29.26,98
X$26001 4460 112 113 4475 CLKBUF_X3
* cell instance $26002 m0 *1 30.21,98
X$26002 5820 113 4462 112 BUF_X4
* cell instance $26003 m0 *1 31.54,98
X$26003 5515 5606 4460 113 6304 112 OAI21_X1
* cell instance $26004 m0 *1 32.3,98
X$26004 112 3861 4988 6306 4462 6304 5526 5145 113 AOI222_X2
* cell instance $26006 m0 *1 35.72,98
X$26006 5950 5256 6222 112 113 5731 MUX2_X1
* cell instance $26007 m0 *1 37.05,98
X$26007 6117 3856 6222 112 6223 113 AOI21_X1
* cell instance $26016 r0 *1 15.58,98
X$26016 6221 112 113 7060 BUF_X1
* cell instance $26019 r0 *1 20.71,98
X$26019 112 5515 4988 113 BUF_X16
* cell instance $26021 r0 *1 25.65,98
X$26021 4411 112 113 4610 CLKBUF_X3
* cell instance $26025 r0 *1 28.69,98
X$26025 112 5515 113 6506 BUF_X8
* cell instance $26026 r0 *1 31.16,98
X$26026 6030 113 4850 112 BUF_X4
* cell instance $26027 r0 *1 32.49,98
X$26027 6506 4891 6442 113 6115 112 OAI21_X1
* cell instance $26028 r0 *1 33.25,98
X$26028 6506 112 113 6376 BUF_X1
* cell instance $26029 r0 *1 33.82,98
X$26029 6506 112 113 6574 INV_X1
* cell instance $26030 r0 *1 34.2,98
X$26030 6574 113 3851 112 BUF_X4
* cell instance $26031 r0 *1 35.53,98
X$26031 5945 6574 4411 113 112 6222 OAI21_X2
* cell instance $26033 m0 *1 38.38,98
X$26033 3861 4844 4856 5606 4992 6224 113 112 AOI221_X2
* cell instance $26035 m0 *1 40.47,98
X$26035 4137 4614 4856 4610 6443 6444 113 112 AOI221_X2
* cell instance $26036 m0 *1 42.56,98
X$26036 6223 4301 6445 112 113 6317 MUX2_X1
* cell instance $26038 m0 *1 44.65,98
X$26038 5948 3861 6378 4460 6225 112 113 6446 AOI221_X1
* cell instance $26040 m0 *1 45.98,98
X$26040 6224 6446 3854 112 113 6447 NOR3_X1
* cell instance $26043 r0 *1 38.57,98
X$26043 5612 5686 6030 112 113 5008 NAND3_X2
* cell instance $26044 r0 *1 39.9,98
X$26044 5262 112 113 3810 CLKBUF_X3
* cell instance $26045 r0 *1 40.85,98
X$26045 4783 5262 4610 4988 112 113 6579 AOI22_X2
* cell instance $26047 r0 *1 42.94,98
X$26047 3767 5330 5073 6507 4015 112 113 6576 AOI221_X1
* cell instance $26049 r0 *1 44.46,98
X$26049 5330 4062 5892 112 113 6578 MUX2_X1
* cell instance $26051 r0 *1 45.98,98
X$26051 6039 4475 4844 112 113 6580 NAND3_X1
* cell instance $26052 r0 *1 46.74,98
X$26052 4856 5454 112 113 6039 NOR2_X2
* cell instance $26053 m0 *1 48.26,98
X$26053 6379 5613 4069 112 113 6448 NOR3_X1
* cell instance $26054 m0 *1 47.12,98
X$26054 3715 4137 6378 4460 5950 112 113 6379 AOI221_X1
* cell instance $26055 m0 *1 49.02,98
X$26055 6448 6447 112 113 6380 OR2_X1
* cell instance $26056 m0 *1 49.78,98
X$26056 6226 6444 3854 113 6319 112 OAI21_X1
* cell instance $26058 m0 *1 50.73,98
X$26058 6378 113 5262 112 BUF_X4
* cell instance $26059 m0 *1 52.06,98
X$26059 5226 6317 6319 113 6449 112 OAI21_X1
* cell instance $26060 m0 *1 52.82,98
X$26060 6378 112 113 4856 INV_X4
* cell instance $26062 m0 *1 53.96,98
X$26062 6449 4244 6227 112 113 6323 MUX2_X1
* cell instance $26063 m0 *1 55.29,98
X$26063 4848 113 4244 112 BUF_X4
* cell instance $26067 r0 *1 47.69,98
X$26067 6119 6583 112 113 6508 NAND2_X1
* cell instance $26069 r0 *1 48.45,98
X$26069 5945 4463 3976 112 113 6583 NAND3_X1
* cell instance $26070 r0 *1 49.21,98
X$26070 5439 5826 5953 113 112 5945 OAI21_X4
* cell instance $26071 r0 *1 51.68,98
X$26071 6584 5805 6509 113 112 6378 MUX2_X2
* cell instance $26073 r0 *1 54.15,98
X$26073 122 224 6511 112 113 NOR2_X4
* cell instance $26074 r0 *1 55.86,98
X$26074 6450 3162 6586 113 112 4848 OAI21_X4
* cell instance $26075 r0 *1 58.33,98
X$26075 6587 113 5826 112 BUF_X4
* cell instance $26076 r0 *1 59.66,98
X$26076 6451 6509 112 113 6450 NAND2_X1
* cell instance $26078 r0 *1 60.61,98
X$26078 3162 122 112 113 6381 OR2_X1
* cell instance $26079 r0 *1 61.37,98
X$26079 112 5612 113 6484 BUF_X8
* cell instance $26080 m0 *1 61.75,98
X$26080 6228 112 113 6382 BUF_X2
* cell instance $26082 m0 *1 62.51,98
X$26082 6382 4597 113 112 6451 XNOR2_X1
* cell instance $26087 r0 *1 64.03,98
X$26087 4083 4541 6588 113 112 6383 HA_X1
* cell instance $26088 r0 *1 65.93,98
X$26088 6384 6383 5832 112 6742 113 AOI21_X1
* cell instance $26089 m0 *1 66.88,98
X$26089 112 5828 5621 5528 4489 113 NOR3_X4
* cell instance $26090 m0 *1 66.31,98
X$26090 6383 112 113 5620 BUF_X1
* cell instance $26092 m0 *1 70.3,98
X$26092 6383 112 113 5376 INV_X2
* cell instance $26093 m0 *1 70.87,98
X$26093 6384 112 113 6459 BUF_X1
* cell instance $26094 m0 *1 71.44,98
X$26094 112 5540 5914 5270 5269 113 AOI21_X4
* cell instance $26096 m0 *1 74.1,98
X$26096 112 5275 4194 5270 5269 113 AOI21_X4
* cell instance $26097 m0 *1 76.57,98
X$26097 4728 4430 112 113 5099 NAND2_X1
* cell instance $26098 m0 *1 77.14,98
X$26098 6461 4424 6229 112 113 6386 MUX2_X1
* cell instance $26100 m0 *1 78.66,98
X$26100 5829 113 4317 112 BUF_X4
* cell instance $26101 m0 *1 79.99,98
X$26101 6752 3983 6230 112 6464 113 AOI21_X1
* cell instance $26102 m0 *1 80.75,98
X$26102 4634 6122 4875 112 5709 113 AOI21_X1
* cell instance $26103 m0 *1 81.51,98
X$26103 4252 5484 5013 113 6230 112 OAI21_X1
* cell instance $26104 m0 *1 82.27,98
X$26104 6231 4425 4899 112 6210 113 AOI21_X1
* cell instance $26105 m0 *1 83.03,98
X$26105 4732 5829 112 113 6351 NAND2_X1
* cell instance $26106 m0 *1 83.6,98
X$26106 4430 4899 4151 113 6469 112 OAI21_X1
* cell instance $26107 m0 *1 84.36,98
X$26107 2959 112 113 6516 BUF_X1
* cell instance $26108 m0 *1 84.93,98
X$26108 4151 6351 112 113 5480 NOR2_X1
* cell instance $26109 m0 *1 85.5,98
X$26109 6125 112 113 5598 BUF_X1
* cell instance $26110 m0 *1 86.07,98
X$26110 6468 3985 112 113 6387 NAND2_X1
* cell instance $26111 m0 *1 86.64,98
X$26111 5741 5535 112 113 6338 NAND2_X1
* cell instance $26113 m0 *1 87.97,98
X$26113 5159 4088 4491 112 6389 113 AOI21_X1
* cell instance $26115 r0 *1 66.69,98
X$26115 5926 5619 5832 112 6454 113 AOI21_X1
* cell instance $26116 r0 *1 67.45,98
X$26116 4083 4541 16682 113 112 6121 HA_X1
* cell instance $26120 r0 *1 69.35,98
X$26120 112 6121 5621 5528 5957 113 NOR3_X4
* cell instance $26121 r0 *1 72.01,98
X$26121 5619 113 4430 112 BUF_X4
* cell instance $26122 r0 *1 73.34,98
X$26122 6121 6514 6747 112 113 6594 NAND3_X2
* cell instance $26123 r0 *1 74.67,98
X$26123 6464 4800 6593 112 6065 113 AOI21_X1
* cell instance $26124 r0 *1 75.43,98
X$26124 6056 113 4631 112 BUF_X4
* cell instance $26126 r0 *1 77.14,98
X$26126 112 6232 5016 4195 4083 4530 4738 6593 113 OAI222_X2
* cell instance $26127 r0 *1 79.8,98
X$26127 4633 113 4307 112 BUF_X4
* cell instance $26129 r0 *1 81.51,98
X$26129 3870 5013 4424 4083 4489 113 112 6515 OAI221_X1
* cell instance $26130 r0 *1 82.65,98
X$26130 6387 4087 4148 6596 6351 113 112 6672 OAI221_X1
* cell instance $26132 r0 *1 84.17,98
X$26132 4489 4640 112 113 6232 NOR2_X2
* cell instance $26133 r0 *1 85.12,98
X$26133 6126 6124 4631 4317 6469 6599 113 112 AOI221_X2
* cell instance $26134 r0 *1 87.21,98
X$26134 6388 4633 4805 112 113 6603 MUX2_X1
* cell instance $26135 r0 *1 88.54,98
X$26135 4430 112 113 6388 INV_X1
* cell instance $26136 r0 *1 88.92,98
X$26136 6390 4432 6600 112 6084 113 AOI21_X1
* cell instance $26138 m0 *1 89.11,98
X$26138 112 4432 5484 6346 3870 4026 5968 6601 113 OAI222_X2
* cell instance $26139 m0 *1 91.96,98
X$26139 4803 6232 4880 4195 113 112 5722 OAI22_X1
* cell instance $26141 m0 *1 93.1,98
X$26141 6234 6235 5282 5014 6386 5810 113 112 AOI221_X2
* cell instance $26143 m0 *1 95.38,98
X$26143 4425 6232 4091 4745 112 113 6133 AOI22_X1
* cell instance $26145 r0 *1 89.68,98
X$26145 5965 5743 4491 112 113 6390 NOR3_X1
* cell instance $26146 r0 *1 90.44,98
X$26146 4734 6601 4202 113 6517 112 OAI21_X1
* cell instance $26147 r0 *1 91.2,98
X$26147 4491 4537 4195 113 6600 112 OAI21_X1
* cell instance $26149 r0 *1 92.15,98
X$26149 5275 5957 4157 113 6519 112 OAI21_X1
* cell instance $26151 r0 *1 93.1,98
X$26151 6474 3870 6676 112 6235 113 AOI21_X1
* cell instance $26152 r0 *1 93.86,98
X$26152 4537 4491 6603 112 5160 113 AOI21_X2
* cell instance $26155 r0 *1 95.76,98
X$26155 5743 3986 112 113 6220 NOR2_X1
* cell instance $26184 r0 *1 65.74,204.4
X$26184 15101 14936 15390 15216 14992 14546 112 113 15325 OAI33_X1
* cell instance $26185 r0 *1 67.07,204.4
X$26185 112 15063 113 15100 BUF_X8
* cell instance $26186 m0 *1 68.21,204.4
X$26186 15096 113 15274 112 BUF_X4
* cell instance $26187 m0 *1 67.64,204.4
X$26187 15208 112 113 15209 BUF_X1
* cell instance $26188 m0 *1 69.54,204.4
X$26188 14267 10764 14943 112 113 15390 MUX2_X1
* cell instance $26189 m0 *1 70.87,204.4
X$26189 112 15208 113 14978 BUF_X8
* cell instance $26190 m0 *1 73.34,204.4
X$26190 14801 14709 15210 14887 15098 15585 113 112 AOI221_X2
* cell instance $26191 m0 *1 75.43,204.4
X$26191 14159 15097 14372 112 14932 113 AOI21_X2
* cell instance $26192 m0 *1 76.76,204.4
X$26192 14160 14271 14270 10563 112 113 15278 NOR4_X1
* cell instance $26193 m0 *1 77.71,204.4
X$26193 15099 14153 14495 112 113 15044 NOR3_X1
* cell instance $26194 m0 *1 78.47,204.4
X$26194 14375 14271 15100 112 113 15394 NOR3_X1
* cell instance $26195 m0 *1 79.23,204.4
X$26195 14496 14157 112 15280 113 OR2_X4
* cell instance $26196 m0 *1 80.94,204.4
X$26196 15100 15172 15281 15282 14664 113 112 15169 OAI221_X1
* cell instance $26198 m0 *1 82.27,204.4
X$26198 14155 14160 112 113 15176 NOR2_X1
* cell instance $26199 m0 *1 82.84,204.4
X$26199 15210 15286 14936 113 15174 112 OAI21_X1
* cell instance $26200 m0 *1 83.6,204.4
X$26200 14451 15174 14984 15212 112 113 15103 AOI22_X2
* cell instance $26201 m0 *1 85.31,204.4
X$26201 14375 14127 112 113 15281 NOR2_X2
* cell instance $26202 m0 *1 86.26,204.4
X$26202 14496 14376 112 113 15213 NAND2_X1
* cell instance $26203 m0 *1 86.83,204.4
X$26203 15213 14980 15101 14608 113 112 15214 OAI22_X1
* cell instance $26209 r0 *1 69.73,204.4
X$26209 14989 15326 15637 15391 15216 15181 112 113 OAI221_X2
* cell instance $26210 r0 *1 71.82,204.4
X$26210 14769 14127 14374 112 113 15327 MUX2_X1
* cell instance $26211 r0 *1 73.15,204.4
X$26211 14268 14662 112 113 15168 NOR2_X1
* cell instance $26212 r0 *1 73.72,204.4
X$26212 14936 14542 112 113 15395 NOR2_X1
* cell instance $26213 r0 *1 74.29,204.4
X$26213 112 15097 14445 14552 15212 15533 113 OAI22_X4
* cell instance $26214 r0 *1 77.52,204.4
X$26214 14153 14765 112 113 15330 NOR2_X1
* cell instance $26215 r0 *1 78.09,204.4
X$26215 15280 15329 15394 15395 14546 15588 113 112 AOI221_X2
* cell instance $26216 r0 *1 80.18,204.4
X$26216 14158 14445 112 113 15396 NAND2_X1
* cell instance $26217 r0 *1 80.75,204.4
X$26217 14374 14943 15168 14800 15396 15284 113 112 AOI221_X2
* cell instance $26219 r0 *1 83.22,204.4
X$26219 14983 14542 14538 113 15287 112 OAI21_X1
* cell instance $26220 r0 *1 83.98,204.4
X$26220 14155 113 15331 112 BUF_X4
* cell instance $26222 r0 *1 85.5,204.4
X$26222 15274 14889 14849 14943 113 112 15399 OAI22_X2
* cell instance $26225 r0 *1 87.78,204.4
X$26225 15183 15274 15214 112 15178 113 AOI21_X1
* cell instance $26226 m0 *1 88.92,204.4
X$26226 15216 14558 112 113 14806 NOR2_X2
* cell instance $26227 m0 *1 88.16,204.4
X$26227 15171 14987 14442 112 15294 113 AOI21_X1
* cell instance $26228 m0 *1 89.87,204.4
X$26228 14662 14445 14267 14849 113 112 15218 OAI22_X1
* cell instance $26229 m0 *1 90.82,204.4
X$26229 15218 14987 14614 112 15219 113 AOI21_X1
* cell instance $26230 m0 *1 91.58,204.4
X$26230 112 14889 15293 14849 14846 14605 14664 15107 113 OAI222_X2
* cell instance $26231 m0 *1 94.24,204.4
X$26231 14718 15294 15063 15105 113 112 15104 OAI22_X1
* cell instance $26233 r0 *1 88.54,204.4
X$26233 14543 14085 112 113 15179 NAND2_X1
* cell instance $26234 r0 *1 89.11,204.4
X$26234 15333 15540 14663 113 15215 112 OAI21_X1
* cell instance $26235 r0 *1 89.87,204.4
X$26235 15215 15063 15217 112 15403 113 AOI21_X1
* cell instance $26236 r0 *1 90.63,204.4
X$26236 15216 14664 14849 113 15217 112 OAI21_X1
* cell instance $26238 r0 *1 91.58,204.4
X$26238 10187 10186 14498 15181 15335 15334 113 112 AOI221_X2
* cell instance $26239 r0 *1 93.67,204.4
X$26239 14608 14983 14538 112 14991 113 AOI21_X1
* cell instance $26240 r0 *1 94.43,204.4
X$26240 14377 14846 14769 112 15336 113 AOI21_X1
* cell instance $26243 m0 *1 95.57,204.4
X$26243 15104 15106 14806 113 15220 112 OAI21_X1
* cell instance $26244 m0 *1 96.52,204.4
X$26244 14158 14445 14765 112 113 15221 NAND3_X1
* cell instance $26246 r0 *1 95.95,204.4
X$26246 15099 15274 14538 112 15222 113 AOI21_X1
* cell instance $26249 r0 *1 97.28,204.4
X$26249 15333 15222 15221 113 15408 112 OAI21_X1
* cell instance $26251 m0 *1 97.66,204.4
X$26251 14990 15108 15405 15186 113 112 15297 OAI22_X1
* cell instance $26252 m0 *1 98.8,204.4
X$26252 15297 14994 15066 113 15067 112 OAI21_X1
* cell instance $26256 m0 *1 104.31,204.4
X$26256 15298 13822 14167 112 113 15224 NOR3_X1
* cell instance $26258 m0 *1 105.26,204.4
X$26258 14896 15109 15300 112 15298 113 AOI21_X1
* cell instance $26261 m0 *1 106.97,204.4
X$26261 15302 13823 112 113 15189 NOR2_X1
* cell instance $26262 m0 *1 107.54,204.4
X$26262 15192 15342 14167 112 113 15110 NOR3_X1
* cell instance $26264 m0 *1 108.49,204.4
X$26264 15303 13822 15112 112 14133 113 AOI21_X1
* cell instance $26265 m0 *1 109.25,204.4
X$26265 15114 14906 15305 112 15113 113 AOI21_X1
* cell instance $26266 m0 *1 110.01,204.4
X$26266 15115 14789 14959 112 15305 113 AOI21_X2
* cell instance $26269 r0 *1 98.8,204.4
X$26269 15107 14718 15408 112 113 15223 MUX2_X1
* cell instance $26270 r0 *1 100.13,204.4
X$26270 15337 15223 113 112 15338 AND2_X1
* cell instance $26275 r0 *1 103.74,204.4
X$26275 14015 15189 15110 15299 15224 15340 112 113 14229 OAI33_X1
* cell instance $26276 r0 *1 105.07,204.4
X$26276 15409 15225 13823 112 113 15299 NOR3_X1
* cell instance $26278 r0 *1 106.59,204.4
X$26278 14866 14867 15341 15410 112 113 15342 NOR4_X1
* cell instance $26280 r0 *1 107.92,204.4
X$26280 15226 14167 15344 112 15112 113 AOI21_X1
* cell instance $26281 r0 *1 108.68,204.4
X$26281 14996 15227 14166 112 113 15226 NOR3_X1
* cell instance $26282 r0 *1 109.44,204.4
X$26282 14563 15228 15345 112 15409 113 AOI21_X1
* cell instance $26283 r0 *1 110.2,204.4
X$26283 14568 15229 14869 113 15345 112 OAI21_X1
* cell instance $26284 r0 *1 110.96,204.4
X$26284 15000 14095 15347 113 15116 112 OAI21_X1
* cell instance $26285 m0 *1 111.91,204.4
X$26285 15080 14577 14899 113 15193 112 OAI21_X1
* cell instance $26287 m0 *1 112.67,204.4
X$26287 14725 15116 15117 14475 15230 15303 113 112 AOI221_X2
* cell instance $26289 m0 *1 114.95,204.4
X$26289 15232 14385 15117 14274 15119 113 112 15231 OAI221_X1
* cell instance $26291 r0 *1 111.72,204.4
X$26291 15001 15080 15348 112 15347 113 AOI21_X1
* cell instance $26292 r0 *1 112.48,204.4
X$26292 15229 14100 14897 112 113 15227 NOR3_X1
* cell instance $26293 r0 *1 113.24,204.4
X$26293 14789 14959 15350 15349 112 113 15230 AOI22_X2
* cell instance $26294 r0 *1 114.95,204.4
X$26294 13822 15306 15231 113 15302 112 OAI21_X1
* cell instance $26295 r0 *1 115.71,204.4
X$26295 15348 15193 15417 15232 15307 112 113 15306 AOI221_X1
* cell instance $26296 m0 *1 116.66,204.4
X$26296 15118 112 113 14895 BUF_X1
* cell instance $26299 r0 *1 116.85,204.4
X$26299 14508 15232 15350 112 15351 113 AOI21_X1
* cell instance $26301 m0 *1 117.61,204.4
X$26301 14383 14683 15001 112 15119 113 AOI21_X1
* cell instance $26302 m0 *1 118.56,204.4
X$26302 14873 15091 14997 112 15310 113 AOI21_X1
* cell instance $26303 m0 *1 119.32,204.4
X$26303 15309 15308 14563 112 113 14352 NOR3_X1
* cell instance $26304 m0 *1 120.08,204.4
X$26304 14140 14577 15122 113 15422 112 OAI21_X1
* cell instance $26305 m0 *1 120.84,204.4
X$26305 15122 14387 14729 112 113 15234 NAND3_X1
* cell instance $26306 m0 *1 121.6,204.4
X$26306 15202 15234 113 112 15002 AND2_X1
* cell instance $26307 m0 *1 122.36,204.4
X$26307 14565 112 113 15314 BUF_X2
* cell instance $26308 m0 *1 123.12,204.4
X$26308 15314 15235 14506 112 113 15202 NAND3_X1
* cell instance $26309 m0 *1 123.88,204.4
X$26309 14502 14399 14999 112 113 15235 NAND3_X2
* cell instance $26310 m0 *1 125.21,204.4
X$26310 14486 15353 14095 113 15205 112 OAI21_X1
* cell instance $26314 r0 *1 118.56,204.4
X$26314 14997 14487 15091 112 15352 113 NAND3_X4
* cell instance $26316 r0 *1 121.41,204.4
X$26316 15348 15422 14169 15307 112 113 14473 AOI22_X1
* cell instance $26317 r0 *1 122.36,204.4
X$26317 15122 15235 14274 112 113 15228 NAND3_X1
* cell instance $26324 r0 *1 124.45,204.4
X$26324 14999 112 113 15424 BUF_X1
* cell instance $26325 r0 *1 125.02,204.4
X$26325 15353 14275 14734 112 15315 113 AOI21_X1
* cell instance $26326 r0 *1 125.78,204.4
X$26326 14873 15315 15424 15354 113 112 14481 OAI22_X1
* cell instance $26328 m0 *1 126.35,204.4
X$26328 14166 15205 14904 112 15308 113 AOI21_X1
* cell instance $26330 m0 *1 128.25,204.4
X$26330 14810 112 113 15118 BUF_X1
* cell instance $26331 m0 *1 127.49,204.4
X$26331 15001 14487 15232 112 113 14904 NAND3_X1
* cell instance $26332 m0 *1 128.82,204.4
X$26332 112 15356 14140 14502 14399 113 AOI21_X4
* cell instance $26334 m0 *1 131.48,204.4
X$26334 112 15353 15318 14000 14019 113 AOI21_X4
* cell instance $26336 r0 *1 127.49,204.4
X$26336 15317 14897 14973 112 15355 113 AOI21_X1
* cell instance $26337 r0 *1 128.25,204.4
X$26337 15318 112 113 15206 BUF_X2
* cell instance $26339 r0 *1 129.2,204.4
X$26339 14486 15356 14690 112 113 15317 NOR3_X1
* cell instance $26343 r0 *1 130.72,204.4
X$26343 14722 15232 14485 112 15236 113 AOI21_X1
* cell instance $26344 r0 *1 131.48,204.4
X$26344 15237 14690 15236 112 15004 113 AOI21_X1
* cell instance $26346 r0 *1 132.62,204.4
X$26346 15238 14475 15430 112 113 14064 MUX2_X1
* cell instance $26348 m0 *1 134.52,204.4
X$26348 14383 14392 14401 112 15319 113 AOI21_X1
* cell instance $26350 m0 *1 135.28,204.4
X$26350 14019 14811 14000 112 14809 113 NAND3_X4
* cell instance $26351 m0 *1 137.75,204.4
X$26351 15239 113 15008 112 BUF_X4
* cell instance $26355 r0 *1 135.66,204.4
X$26355 15319 14095 15464 112 113 15430 MUX2_X1
* cell instance $26356 r0 *1 136.99,204.4
X$26356 14000 14019 112 113 15239 NAND2_X2
* cell instance $26357 r0 *1 137.94,204.4
X$26357 15239 112 113 15357 INV_X4
* cell instance $26361 r0 *1 143.07,204.4
X$26361 8299 112 113 15358 INV_X4
* cell instance $26363 r0 *1 144.21,204.4
X$26363 14739 113 15248 112 BUF_X4
* cell instance $26364 m0 *1 145.73,204.4
X$26364 14516 15240 15320 113 112 15207 OAI21_X2
* cell instance $26366 m0 *1 147.06,204.4
X$26366 8299 14403 112 113 15133 NOR2_X2
* cell instance $26367 m0 *1 148.01,204.4
X$26367 8299 15011 112 113 15241 NOR2_X1
* cell instance $26368 m0 *1 148.58,204.4
X$26368 15203 15241 15248 113 15128 112 OAI21_X1
* cell instance $26369 m0 *1 149.34,204.4
X$26369 15090 14594 14707 112 113 15127 NAND3_X1
* cell instance $26370 m0 *1 150.1,204.4
X$26370 14180 15126 15127 112 15324 113 AOI21_X1
* cell instance $26371 m0 *1 150.86,204.4
X$26371 14289 15125 112 113 15203 NOR2_X1
* cell instance $26372 m0 *1 151.43,204.4
X$26372 15323 15243 14261 15321 15128 112 113 15129 AOI221_X1
* cell instance $26376 r0 *1 146.49,204.4
X$26376 11077 15466 113 15359 112 AND2_X4
* cell instance $26377 r0 *1 148.2,204.4
X$26377 15133 14739 14795 15304 15245 113 112 AOI211_X2
* cell instance $26378 r0 *1 149.91,204.4
X$26378 15360 14516 14371 15242 15434 112 113 15322 AOI221_X1
* cell instance $26380 r0 *1 151.43,204.4
X$26380 15435 15090 14702 112 113 15434 NAND3_X1
* cell instance $26382 r0 *1 152.38,204.4
X$26382 14410 14524 14181 15246 14965 113 112 15361 OAI221_X1
* cell instance $26383 m0 *1 153.71,204.4
X$26383 15241 14739 112 113 15244 NOR2_X1
* cell instance $26384 m0 *1 152.95,204.4
X$26384 15129 15322 15137 113 14823 112 OAI21_X1
* cell instance $26386 m0 *1 154.47,204.4
X$26386 14182 15245 112 113 15134 OR2_X1
* cell instance $26387 m0 *1 155.23,204.4
X$26387 14407 15131 15130 112 15132 113 AOI21_X1
* cell instance $26388 m0 *1 155.99,204.4
X$26388 15248 14483 14410 113 112 15014 OAI21_X2
* cell instance $26389 m0 *1 157.32,204.4
X$26389 15133 14630 15125 14294 112 113 15199 AOI22_X1
* cell instance $26390 m0 *1 158.27,204.4
X$26390 14186 15199 14187 15197 15134 113 112 15135 OAI221_X1
* cell instance $26393 r0 *1 153.71,204.4
X$26393 15245 14182 112 113 15321 NOR2_X1
* cell instance $26395 r0 *1 154.47,204.4
X$26395 15244 14883 14182 14970 14965 112 113 15433 AOI221_X1
* cell instance $26396 r0 *1 155.61,204.4
X$26396 15247 112 113 15246 INV_X1
* cell instance $26397 r0 *1 155.99,204.4
X$26397 15364 14412 15130 15415 14791 113 112 15249 OAI221_X1
* cell instance $26398 r0 *1 157.13,204.4
X$26398 14706 15133 14421 15364 15474 112 113 15431 AOI221_X1
* cell instance $26400 r0 *1 158.65,204.4
X$26400 14600 14820 112 113 15367 NOR2_X2
* cell instance $26401 r0 *1 159.6,204.4
X$26401 15432 15431 14297 113 15250 112 OAI21_X1
* cell instance $26402 m0 *1 160.55,204.4
X$26402 15249 14192 15089 15136 15252 112 113 15251 AOI221_X1
* cell instance $26403 m0 *1 159.79,204.4
X$26403 14192 15133 14489 112 15252 113 AOI21_X1
* cell instance $26404 m0 *1 161.69,204.4
X$26404 14741 113 14881 112 BUF_X4
* cell instance $26405 m0 *1 163.02,204.4
X$26405 15138 15313 15251 15135 113 112 15190 OAI22_X1
* cell instance $26406 m0 *1 163.97,204.4
X$26406 15311 14702 112 113 15020 NOR2_X2
* cell instance $26407 m0 *1 164.92,204.4
X$26407 14262 15141 14489 112 15253 113 AOI21_X1
* cell instance $26408 m0 *1 165.68,204.4
X$26408 15253 14635 14184 113 15254 112 OAI21_X1
* cell instance $26409 m0 *1 166.44,204.4
X$26409 15259 14408 14813 14412 113 112 15191 OAI22_X1
* cell instance $26410 m0 *1 167.39,204.4
X$26410 15191 14699 14520 112 15257 113 AOI21_X1
* cell instance $26412 m0 *1 168.34,204.4
X$26412 15258 14186 14261 15257 14264 113 112 15138 OAI221_X1
* cell instance $26413 m0 *1 169.48,204.4
X$26413 14813 14421 14264 14294 15259 112 113 15421 AOI221_X1
* cell instance $26414 m0 *1 170.62,204.4
X$26414 15139 15014 14525 15140 15141 113 112 15188 OAI221_X1
* cell instance $26415 m0 *1 171.76,204.4
X$26415 14483 14423 112 113 15262 NAND2_X1
* cell instance $26416 m0 *1 172.33,204.4
X$26416 15142 15304 15026 113 15143 112 OAI21_X1
* cell instance $26417 m0 *1 173.09,204.4
X$26417 15143 15144 112 113 15258 NAND2_X1
* cell instance $26418 m0 *1 173.66,204.4
X$26418 14490 15262 15074 112 113 15144 NAND3_X1
* cell instance $26420 r0 *1 160.36,204.4
X$26420 14913 15137 15250 112 15312 113 AOI21_X2
* cell instance $26421 r0 *1 161.69,204.4
X$26421 15428 15134 14192 15423 14414 112 113 15313 AOI221_X1
* cell instance $26425 r0 *1 164.92,204.4
X$26425 15426 14292 15027 14521 14412 113 112 15369 OAI221_X1
* cell instance $26426 r0 *1 166.06,204.4
X$26426 15254 15369 15137 112 113 15371 NAND3_X1
* cell instance $26428 r0 *1 167.2,204.4
X$26428 14790 15255 15372 113 14700 112 OAI21_X1
* cell instance $26429 r0 *1 167.96,204.4
X$26429 15256 15248 112 113 15372 NOR2_X1
* cell instance $26430 r0 *1 168.53,204.4
X$26430 14735 14961 112 113 15256 NOR2_X1
* cell instance $26432 r0 *1 169.29,204.4
X$26432 15014 15256 15421 113 15374 112 OAI21_X1
* cell instance $26435 r0 *1 171.95,204.4
X$26435 14632 15260 112 113 15261 NAND2_X1
* cell instance $26436 r0 *1 172.52,204.4
X$26436 14816 15419 15261 112 15301 113 AOI21_X1
* cell instance $26437 r0 *1 173.28,204.4
X$26437 15074 15418 14883 112 14745 113 AOI21_X2
* cell instance $26439 r0 *1 174.8,204.4
X$26439 14745 15416 15301 113 15370 112 OAI21_X1
* cell instance $26441 m0 *1 174.8,204.4
X$26441 15144 15027 112 113 15416 NAND2_X1
* cell instance $26442 r0 *1 175.56,204.4
X$26442 15414 15415 15262 112 113 14917 MUX2_X1
* cell instance $26444 m0 *1 175.75,204.4
X$26444 15145 15132 112 113 15146 NOR2_X1
* cell instance $26446 m0 *1 176.7,204.4
X$26446 14301 113 15137 112 BUF_X4
* cell instance $26454 m0 *1 183.16,204.4
X$26454 112 15263 14025 14026 14787 113 NOR3_X4
* cell instance $26456 m0 *1 185.82,204.4
X$26456 112 15296 15263 13764 14200 113 NOR3_X4
* cell instance $26457 m0 *1 188.48,204.4
X$26457 14527 14026 14025 113 112 14345 OAI21_X4
* cell instance $26458 m0 *1 190.95,204.4
X$26458 14528 14026 14025 113 112 13979 OAI21_X4
* cell instance $26463 r0 *1 185.82,204.4
X$26463 13984 13916 16679 113 112 15263 HA_X1
* cell instance $26465 r0 *1 187.91,204.4
X$26465 112 14528 113 13764 BUF_X8
* cell instance $26466 r0 *1 190.38,204.4
X$26466 13764 13833 13919 112 113 NOR2_X4
* cell instance $26467 r0 *1 192.09,204.4
X$26467 14204 15265 13702 113 15412 112 OAI21_X1
* cell instance $26469 r0 *1 193.23,204.4
X$26469 15412 15411 15377 13900 15295 15177 112 113 13794 OAI33_X1
* cell instance $26471 m0 *1 193.8,204.4
X$26471 10516 13904 112 113 14429 NOR2_X1
* cell instance $26472 m0 *1 194.56,204.4
X$26472 14429 13703 14198 113 15148 112 OAI21_X1
* cell instance $26474 m0 *1 195.51,204.4
X$26474 14429 13973 112 113 15147 NOR2_X1
* cell instance $26476 r0 *1 194.56,204.4
X$26476 13837 14195 13910 112 15377 113 AOI21_X1
* cell instance $26477 r0 *1 195.32,204.4
X$26477 15378 14750 13789 15381 15380 14246 113 112 AOI221_X2
* cell instance $26478 m0 *1 197.22,204.4
X$26478 14122 15292 15290 15182 112 113 15180 OR4_X1
* cell instance $26479 m0 *1 196.46,204.4
X$26479 15291 15147 15033 112 15154 113 AOI21_X1
* cell instance $26481 m0 *1 198.55,204.4
X$26481 14433 14658 112 113 15034 NAND2_X1
* cell instance $26483 m0 *1 199.31,204.4
X$26483 14643 13911 13900 15150 15167 113 112 AOI211_X2
* cell instance $26485 m0 *1 201.21,204.4
X$26485 15267 14113 15056 112 113 15289 OR3_X1
* cell instance $26487 m0 *1 202.35,204.4
X$26487 15289 15288 13900 112 113 15151 NAND3_X1
* cell instance $26488 m0 *1 203.11,204.4
X$26488 14200 13918 112 113 15288 NAND2_X1
* cell instance $26489 m0 *1 203.68,204.4
X$26489 112 14531 113 14193 BUF_X8
* cell instance $26490 m0 *1 206.15,204.4
X$26490 15383 14125 15173 112 15153 113 AOI21_X1
* cell instance $26492 m0 *1 207.1,204.4
X$26492 14314 13990 14448 112 15158 113 AOI21_X1
* cell instance $26495 m0 *1 208.81,204.4
X$26495 14206 14779 14834 113 15270 112 OAI21_X1
* cell instance $26497 m0 *1 209.76,204.4
X$26497 15160 14027 15376 112 113 15155 NAND3_X1
* cell instance $26499 r0 *1 197.41,204.4
X$26499 15264 15486 14125 13978 13770 113 112 15149 OAI221_X1
* cell instance $26501 r0 *1 198.74,204.4
X$26501 15381 14027 15166 15165 13915 112 113 15264 AOI221_X1
* cell instance $26503 r0 *1 200.26,204.4
X$26503 15263 112 113 13990 INV_X4
* cell instance $26504 r0 *1 201.21,204.4
X$26504 15266 15268 13979 113 14072 112 OAI21_X1
* cell instance $26505 r0 *1 201.97,204.4
X$26505 14125 15151 15402 112 14452 113 AOI21_X1
* cell instance $26507 r0 *1 202.92,204.4
X$26507 15404 15265 13972 13918 15285 113 112 15402 OAI221_X1
* cell instance $26508 r0 *1 204.06,204.4
X$26508 15382 13769 14198 112 15400 113 AOI21_X1
* cell instance $26509 r0 *1 204.82,204.4
X$26509 14069 13990 112 113 15285 NOR2_X1
* cell instance $26510 r0 *1 205.39,204.4
X$26510 15400 14433 112 113 15269 NOR2_X1
* cell instance $26511 r0 *1 205.96,204.4
X$26511 15263 113 14209 112 BUF_X4
* cell instance $26512 r0 *1 207.29,204.4
X$26512 15268 15384 13702 14539 15270 15397 113 112 AOI221_X2
* cell instance $26513 r0 *1 209.38,204.4
X$26513 15397 14835 14125 112 113 15279 OR3_X4
* cell instance $26514 m0 *1 213.37,204.4
X$26514 14658 14544 14345 113 15272 112 OAI21_X1
* cell instance $26515 m0 *1 210.9,204.4
X$26515 15279 15156 15271 112 15157 113 NAND3_X4
* cell instance $26516 m0 *1 214.13,204.4
X$26516 15158 14864 14128 15165 15272 112 113 15275 AOI221_X1
* cell instance $26517 m0 *1 215.27,204.4
X$26517 14851 14536 14309 112 113 15277 NOR3_X1
* cell instance $26518 m0 *1 216.03,204.4
X$26518 15275 14326 15273 112 15159 113 AOI21_X1
* cell instance $26519 m0 *1 216.79,204.4
X$26519 15276 15160 13918 113 15273 112 OAI21_X1
* cell instance $26520 m0 *1 217.55,204.4
X$26520 15046 13972 112 113 15163 NOR2_X1
* cell instance $26521 m0 *1 218.12,204.4
X$26521 14069 13978 112 113 15160 NOR2_X1
* cell instance $26522 m0 *1 218.69,204.4
X$26522 14128 14548 112 113 15161 NOR2_X1
* cell instance $26529 r0 *1 211.47,204.4
X$26529 15266 15381 112 113 14851 NOR2_X1
* cell instance $26530 r0 *1 212.04,204.4
X$26530 15491 14839 14125 15386 15277 113 112 15271 OAI221_X1
* cell instance $26531 r0 *1 213.18,204.4
X$26531 14209 14069 13900 113 15386 112 OAI21_X1
* cell instance $26532 r0 *1 213.94,204.4
X$26532 14309 15272 15265 14108 13900 13842 112 113 OAI221_X2
* cell instance $26533 r0 *1 216.03,204.4
X$26533 14852 112 113 14310 INV_X2
* cell instance $26534 r0 *1 216.6,204.4
X$26534 14309 13769 112 113 15276 NOR2_X1
* cell instance $26535 r0 *1 217.17,204.4
X$26535 15389 13769 15161 112 15387 113 AOI21_X1
* cell instance $26556 r0 *1 11.21,103.6
X$26556 6898 112 113 7059 BUF_X1
* cell instance $26567 r0 *1 19.19,103.6
X$26567 6960 6899 6297 112 113 7001 MUX2_X1
* cell instance $26570 r0 *1 27.36,103.6
X$26570 6961 224 112 113 6900 NOR2_X1
* cell instance $26571 r0 *1 27.93,103.6
X$26571 6900 6905 6506 112 113 NOR2_X4
* cell instance $26573 r0 *1 30.02,103.6
X$26573 7066 113 7065 112 BUF_X4
* cell instance $26574 r0 *1 31.35,103.6
X$26574 6902 6901 16607 113 112 7067 HA_X1
* cell instance $26575 m0 *1 32.87,103.6
X$26575 112 4840 113 6849 BUF_X8
* cell instance $26578 r0 *1 33.25,103.6
X$26578 6962 112 113 7394 INV_X2
* cell instance $26579 r0 *1 33.82,103.6
X$26579 7219 6963 7220 112 7492 113 AOI21_X1
* cell instance $26580 r0 *1 34.58,103.6
X$26580 112 7003 113 7004 BUF_X8
* cell instance $26582 m0 *1 35.72,103.6
X$26582 6796 6901 16571 113 112 6962 HA_X1
* cell instance $26584 m0 *1 38.57,103.6
X$26584 6665 112 113 6849 INV_X4
* cell instance $26585 m0 *1 39.52,103.6
X$26585 5610 5820 5256 112 113 6443 MUX2_X1
* cell instance $26587 m0 *1 41.04,103.6
X$26587 6663 6849 112 113 6507 NOR2_X1
* cell instance $26588 m0 *1 41.61,103.6
X$26588 6665 6663 112 113 5330 XNOR2_X2
* cell instance $26589 m0 *1 43.51,103.6
X$26589 6507 113 3861 112 BUF_X4
* cell instance $26592 r0 *1 37.05,103.6
X$26592 112 6904 113 7005 BUF_X8
* cell instance $26593 r0 *1 39.52,103.6
X$26593 6966 7006 6965 112 113 7071 NAND3_X1
* cell instance $26597 r0 *1 42.75,103.6
X$26597 7007 6967 112 113 7010 NOR2_X2
* cell instance $26599 r0 *1 44.08,103.6
X$26599 112 6910 7009 113 INV_X16
* cell instance $26601 m0 *1 46.74,103.6
X$26601 6665 113 5605 112 BUF_X4
* cell instance $26607 r0 *1 51.3,103.6
X$26607 6969 6968 112 113 7076 NAND2_X1
* cell instance $26608 r0 *1 51.87,103.6
X$26608 6970 112 113 7075 BUF_X1
* cell instance $26609 r0 *1 52.44,103.6
X$26609 6796 7002 16624 113 112 6970 HA_X1
* cell instance $26610 m0 *1 53.58,103.6
X$26610 6797 6509 5953 112 113 NOR2_X4
* cell instance $26611 m0 *1 53.01,103.6
X$26611 6510 112 113 6850 BUF_X1
* cell instance $26614 r0 *1 54.34,103.6
X$26614 6901 6902 16641 113 112 7012 HA_X1
* cell instance $26616 m0 *1 56.62,103.6
X$26616 3068 6797 112 113 6851 OR2_X1
* cell instance $26621 r0 *1 56.81,103.6
X$26621 112 17149 7078 3865 4795 113 DFF_X1
* cell instance $26623 m0 *1 58.52,103.6
X$26623 7404 112 113 7007 INV_X4
* cell instance $26625 m0 *1 60.42,103.6
X$26625 112 16832 6858 4081 6855 113 DFF_X1
* cell instance $26626 m0 *1 63.65,103.6
X$26626 6858 112 113 6860 CLKBUF_X3
* cell instance $26628 r0 *1 60.04,103.6
X$26628 112 6910 6796 113 BUF_X32
* cell instance $26629 m0 *1 69.73,103.6
X$26629 6383 112 113 6125 BUF_X1
* cell instance $26630 m0 *1 64.98,103.6
X$26630 112 5481 4482 113 BUF_X16
* cell instance $26631 m0 *1 70.3,103.6
X$26631 112 5270 113 6747 BUF_X8
* cell instance $26632 m0 *1 72.77,103.6
X$26632 112 4432 113 5714 BUF_X8
* cell instance $26633 m0 *1 75.24,103.6
X$26633 112 4900 113 6749 BUF_X8
* cell instance $26634 m0 *1 77.71,103.6
X$26634 6673 113 4156 112 BUF_X4
* cell instance $26636 m0 *1 79.23,103.6
X$26636 5828 5714 112 113 4875 NOR2_X2
* cell instance $26637 m0 *1 80.18,103.6
X$26637 5270 5269 5828 112 113 6668 NAND3_X1
* cell instance $26638 m0 *1 80.94,103.6
X$26638 5714 5484 5829 4797 113 112 6802 OAI22_X2
* cell instance $26646 r0 *1 69.35,103.6
X$26646 5832 113 5829 112 BUF_X4
* cell instance $26647 r0 *1 70.68,103.6
X$26647 112 5269 113 6514 BUF_X8
* cell instance $26648 r0 *1 73.15,103.6
X$26648 7085 5528 5621 113 112 4197 OAI21_X4
* cell instance $26650 r0 *1 76,103.6
X$26650 112 4639 5828 5270 5269 113 AOI21_X4
* cell instance $26651 r0 *1 78.47,103.6
X$26651 3937 4031 112 113 7014 NOR2_X2
* cell instance $26652 r0 *1 79.42,103.6
X$26652 5828 5096 112 113 7015 NAND2_X1
* cell instance $26653 r0 *1 79.99,103.6
X$26653 5828 6077 4745 112 113 NOR2_X4
* cell instance $26654 r0 *1 81.7,103.6
X$26654 6802 6670 4537 112 113 6911 NOR3_X1
* cell instance $26655 r0 *1 82.46,103.6
X$26655 4482 4728 6912 5829 112 113 7016 AOI22_X1
* cell instance $26656 m0 *1 84.36,103.6
X$26656 6867 5091 4148 113 4495 112 OAI21_X1
* cell instance $26657 m0 *1 83.03,103.6
X$26657 6912 4538 6669 112 113 6867 MUX2_X1
* cell instance $26661 m0 *1 87.59,103.6
X$26661 6672 6674 6803 113 6804 112 OAI21_X1
* cell instance $26663 m0 *1 89.11,103.6
X$26663 5744 4800 112 113 6803 NOR2_X1
* cell instance $26665 r0 *1 83.41,103.6
X$26665 7017 6801 4904 6911 113 112 7089 OAI22_X1
* cell instance $26667 r0 *1 84.74,103.6
X$26667 4745 6122 4089 112 7090 113 AOI21_X1
* cell instance $26668 r0 *1 85.5,103.6
X$26668 4488 7090 113 112 6913 XNOR2_X1
* cell instance $26671 r0 *1 88.54,103.6
X$26671 5744 4424 112 113 5246 NAND2_X1
* cell instance $26673 r0 *1 89.49,103.6
X$26673 4148 112 113 4431 CLKBUF_X3
* cell instance $26674 m0 *1 90.25,103.6
X$26674 3983 4728 5014 113 6805 112 OAI21_X1
* cell instance $26676 m0 *1 91.01,103.6
X$26676 5388 6805 6518 112 6915 113 AOI21_X1
* cell instance $26677 m0 *1 91.77,103.6
X$26677 6976 6806 6915 113 6130 112 OAI21_X1
* cell instance $26680 r0 *1 90.44,103.6
X$26680 5388 5744 6871 7089 113 112 7130 AND4_X1
* cell instance $26681 r0 *1 91.58,103.6
X$26681 4157 3983 16688 113 112 6912 HA_X1
* cell instance $26682 r0 *1 93.48,103.6
X$26682 5090 112 113 5743 CLKBUF_X3
* cell instance $26684 m0 *1 93.67,103.6
X$26684 6872 4734 4639 112 6976 113 AOI21_X1
* cell instance $26686 m0 *1 96.14,103.6
X$26686 4606 112 113 4800 CLKBUF_X3
* cell instance $26687 m0 *1 94.81,103.6
X$26687 5090 113 5014 112 BUF_X4
* cell instance $26691 m0 *1 104.88,103.6
X$26691 5634 7020 112 113 6106 XNOR2_X2
* cell instance $26694 r0 *1 95.19,103.6
X$26694 4606 112 113 5388 CLKBUF_X3
* cell instance $26697 r0 *1 97.09,103.6
X$26697 3428 112 113 7203 CLKBUF_X3
* cell instance $26700 r0 *1 98.99,103.6
X$26700 6909 4209 6877 112 113 7018 MUX2_X1
* cell instance $26703 r0 *1 102.03,103.6
X$26703 6860 6981 113 112 5837 XNOR2_X1
* cell instance $26706 r0 *1 103.74,103.6
X$26706 6979 3530 112 113 6980 NOR2_X1
* cell instance $26707 r0 *1 104.31,103.6
X$26707 6980 3776 6767 112 7098 113 AOI21_X1
* cell instance $26709 m0 *1 108.11,103.6
X$26709 6395 113 3068 112 BUF_X4
* cell instance $26712 m0 *1 110.2,103.6
X$26712 5390 112 113 6916 BUF_X1
* cell instance $26714 m0 *1 112.29,103.6
X$26714 2848 6879 113 112 6807 XNOR2_X1
* cell instance $26717 m0 *1 120.27,103.6
X$26717 6880 7107 6679 112 6982 113 AOI21_X1
* cell instance $26718 m0 *1 121.03,103.6
X$26718 6680 112 113 16460 CLKBUF_X1
* cell instance $26719 m0 *1 121.6,103.6
X$26719 179 6244 112 113 6880 NOR2_X1
* cell instance $26725 r0 *1 110.58,103.6
X$26725 112 7101 7104 6917 6677 3104 113 AND4_X4
* cell instance $26729 r0 *1 117.04,103.6
X$26729 112 16985 7106 6982 6680 113 DFF_X1
* cell instance $26731 r0 *1 120.46,103.6
X$26731 4279 112 113 6680 CLKBUF_X3
* cell instance $26732 r0 *1 121.41,103.6
X$26732 6983 113 3335 112 BUF_X4
* cell instance $26733 r0 *1 122.74,103.6
X$26733 3335 113 7107 112 BUF_X4
* cell instance $26741 r0 *1 124.45,103.6
X$26741 6983 113 3530 112 BUF_X4
* cell instance $26742 m0 *1 125.78,103.6
X$26742 6737 3530 112 113 6624 NOR2_X1
* cell instance $26745 r0 *1 125.78,103.6
X$26745 141 3105 7657 112 113 7108 MUX2_X1
* cell instance $26746 m0 *1 126.92,103.6
X$26746 6881 3530 112 113 5398 NOR2_X1
* cell instance $26749 m0 *1 127.68,103.6
X$26749 409 6775 6986 112 113 6529 NAND3_X1
* cell instance $26750 m0 *1 128.44,103.6
X$26750 5166 112 113 6986 INV_X1
* cell instance $26752 m0 *1 130.34,103.6
X$26752 6532 6918 113 6808 112 XOR2_X2
* cell instance $26753 m0 *1 132.05,103.6
X$26753 5643 7140 113 112 6884 XNOR2_X1
* cell instance $26754 m0 *1 133.19,103.6
X$26754 6808 6773 5166 112 113 6784 NAND3_X1
* cell instance $26755 m0 *1 133.95,103.6
X$26755 6531 6808 112 113 6783 NAND2_X1
* cell instance $26764 r0 *1 130.53,103.6
X$26764 6397 112 113 6918 BUF_X1
* cell instance $26765 r0 *1 131.1,103.6
X$26765 5643 6919 113 112 6683 XNOR2_X1
* cell instance $26766 r0 *1 132.24,103.6
X$26766 112 7338 5919 17245 6397 113 DFF_X2
* cell instance $26767 m0 *1 135.85,103.6
X$26767 6684 6991 6809 112 6992 113 AOI21_X2
* cell instance $26771 m0 *1 143.45,103.6
X$26771 6364 6891 6810 112 7252 113 AOI21_X2
* cell instance $26772 m0 *1 144.78,103.6
X$26772 6811 112 113 6152 CLKBUF_X3
* cell instance $26773 m0 *1 145.73,103.6
X$26773 6257 6995 6690 113 6893 112 OAI21_X1
* cell instance $26774 m0 *1 146.49,103.6
X$26774 6812 6536 6152 112 113 6994 NAND3_X1
* cell instance $26776 r0 *1 135.85,103.6
X$26776 7112 6990 112 113 6988 NAND2_X1
* cell instance $26779 r0 *1 136.99,103.6
X$26779 6990 6064 4407 112 113 6991 NAND3_X1
* cell instance $26784 r0 *1 142.88,103.6
X$26784 112 6148 6922 6920 6201 113 NOR3_X4
* cell instance $26786 r0 *1 145.92,103.6
X$26786 6139 6921 6994 113 6208 112 OAI21_X1
* cell instance $26789 m0 *1 147.63,103.6
X$26789 6812 6811 112 113 6813 NAND2_X1
* cell instance $26791 r0 *1 148.39,103.6
X$26791 6920 6922 7119 113 6996 112 OAI21_X1
* cell instance $26792 m0 *1 148.77,103.6
X$26792 6936 5913 6814 112 6995 113 AOI21_X1
* cell instance $26795 m0 *1 149.72,103.6
X$26795 5913 6896 6895 112 5984 113 AOI21_X1
* cell instance $26796 m0 *1 150.48,103.6
X$26796 6816 6268 6894 112 6896 113 AOI21_X1
* cell instance $26798 r0 *1 149.15,103.6
X$26798 6934 6996 7121 112 6794 113 AOI21_X2
* cell instance $26799 r0 *1 150.48,103.6
X$26799 6894 6352 6268 113 7027 112 OAI21_X1
* cell instance $26802 m0 *1 151.62,103.6
X$26802 7028 6159 6142 112 6538 113 AOI21_X1
* cell instance $26803 m0 *1 153.14,103.6
X$26803 6999 6897 6815 6923 6102 112 113 OAI211_X2
* cell instance $26804 m0 *1 154.85,103.6
X$26804 6890 6925 5851 5848 112 113 6897 NAND4_X1
* cell instance $26805 m0 *1 155.8,103.6
X$26805 6647 6926 6159 6894 112 113 6149 AOI22_X1
* cell instance $26808 m0 *1 157.7,103.6
X$26808 6153 5981 6402 112 113 6928 MUX2_X1
* cell instance $26810 m0 *1 160.55,103.6
X$26810 6930 112 113 6795 INV_X4
* cell instance $26813 m0 *1 162.45,103.6
X$26813 6889 6698 6817 6695 112 113 6890 AOI22_X1
* cell instance $26814 m0 *1 163.4,103.6
X$26814 6816 6781 112 113 6817 NOR2_X1
* cell instance $26815 m0 *1 163.97,103.6
X$26815 5991 6997 113 112 6889 XNOR2_X1
* cell instance $26816 m0 *1 165.11,103.6
X$26816 6818 6698 6888 112 113 6819 NAND3_X1
* cell instance $26817 m0 *1 165.87,103.6
X$26817 6701 113 6816 112 BUF_X4
* cell instance $26820 m0 *1 168.15,103.6
X$26820 6781 112 113 6094 CLKBUF_X3
* cell instance $26824 r0 *1 153.71,103.6
X$26824 6353 6924 6195 113 7123 112 OAI21_X1
* cell instance $26825 r0 *1 154.47,103.6
X$26825 7359 6140 6094 7123 7000 113 112 6925 OAI221_X1
* cell instance $26826 r0 *1 155.61,103.6
X$26826 7205 6927 112 113 7000 NOR2_X1
* cell instance $26828 r0 *1 156.94,103.6
X$26828 6142 6256 112 113 6927 NAND2_X1
* cell instance $26830 r0 *1 157.7,103.6
X$26830 6927 7117 5846 6139 6928 113 112 7120 OAI221_X1
* cell instance $26833 r0 *1 159.79,103.6
X$26833 6930 112 113 6409 BUF_X1
* cell instance $26834 r0 *1 160.36,103.6
X$26834 6929 6653 112 113 6888 NAND2_X1
* cell instance $26835 r0 *1 160.93,103.6
X$26835 6930 6926 6888 7030 6924 113 112 6931 OAI221_X1
* cell instance $26836 r0 *1 162.07,103.6
X$26836 6932 7115 113 112 6998 XNOR2_X1
* cell instance $26837 r0 *1 163.21,103.6
X$26837 6794 6152 6998 112 6933 113 AOI21_X1
* cell instance $26840 r0 *1 164.54,103.6
X$26840 6697 6932 6268 112 6997 113 AOI21_X1
* cell instance $26841 r0 *1 165.3,103.6
X$26841 6934 6148 112 113 7113 NAND2_X1
* cell instance $26844 r0 *1 166.82,103.6
X$26844 6159 6367 16645 113 112 7032 HA_X1
* cell instance $26846 r0 *1 168.91,103.6
X$26846 6935 5981 6811 112 113 6887 NAND3_X1
* cell instance $26847 m0 *1 169.67,103.6
X$26847 6074 6885 6887 112 6936 113 AOI21_X1
* cell instance $26851 r0 *1 170.05,103.6
X$26851 7035 6934 6935 112 6937 113 AOI21_X1
* cell instance $26853 m0 *1 170.81,103.6
X$26853 6251 6937 6885 113 6886 112 OAI21_X1
* cell instance $26856 m0 *1 176.32,103.6
X$26856 6883 5401 6820 112 113 6882 NAND3_X1
* cell instance $26857 m0 *1 177.08,103.6
X$26857 6883 6774 6882 113 6415 112 OAI21_X1
* cell instance $26859 m0 *1 179.36,103.6
X$26859 6939 6940 113 6270 112 XOR2_X2
* cell instance $26861 m0 *1 181.26,103.6
X$26861 6775 6821 112 113 6943 NOR2_X1
* cell instance $26863 r0 *1 170.81,103.6
X$26863 7109 113 6142 112 BUF_X4
* cell instance $26867 r0 *1 174.8,103.6
X$26867 112 6883 6938 6993 5758 113 DFF_X1
* cell instance $26868 r0 *1 178.03,103.6
X$26868 6938 3947 7151 112 113 6993 MUX2_X1
* cell instance $26869 r0 *1 179.36,103.6
X$26869 6940 6939 112 113 6271 XNOR2_X2
* cell instance $26876 r0 *1 181.26,103.6
X$26876 5853 6939 113 6989 112 XOR2_X2
* cell instance $26877 m0 *1 182.4,103.6
X$26877 5794 5853 112 113 6822 XNOR2_X2
* cell instance $26879 m0 *1 184.3,103.6
X$26879 5794 112 113 6944 BUF_X1
* cell instance $26880 m0 *1 184.87,103.6
X$26880 6617 112 113 6770 BUF_X2
* cell instance $26882 r0 *1 182.97,103.6
X$26882 6942 5043 6821 112 113 6941 NAND3_X1
* cell instance $26883 r0 *1 183.73,103.6
X$26883 6943 6987 112 113 7036 NAND2_X1
* cell instance $26884 r0 *1 184.3,103.6
X$26884 6940 7037 112 113 7196 XOR2_X1
* cell instance $26885 r0 *1 185.44,103.6
X$26885 6822 112 113 7037 BUF_X2
* cell instance $26886 m0 *1 187.72,103.6
X$26886 5997 6273 112 113 6942 XNOR2_X2
* cell instance $26887 m0 *1 186.01,103.6
X$26887 5792 5761 113 6553 112 XOR2_X2
* cell instance $26888 m0 *1 189.62,103.6
X$26888 5997 6165 113 6945 112 XOR2_X2
* cell instance $26892 m0 *1 199.69,103.6
X$26892 6985 4948 6298 112 113 6984 MUX2_X1
* cell instance $26894 m0 *1 204.06,103.6
X$26894 6423 6708 113 6823 112 XOR2_X2
* cell instance $26896 r0 *1 186.2,103.6
X$26896 6273 5997 113 6987 112 XOR2_X2
* cell instance $26897 r0 *1 187.91,103.6
X$26897 6942 112 113 6276 BUF_X1
* cell instance $26898 r0 *1 188.48,103.6
X$26898 6939 7037 113 112 7105 XNOR2_X1
* cell instance $26900 r0 *1 190,103.6
X$26900 6704 6554 113 112 7041 XNOR2_X1
* cell instance $26905 r0 *1 196.84,103.6
X$26905 112 7159 6985 6984 5558 113 DFF_X1
* cell instance $26908 r0 *1 200.64,103.6
X$26908 5231 6946 112 113 7349 NOR2_X2
* cell instance $26911 r0 *1 203.49,103.6
X$26911 7097 113 5997 112 BUF_X4
* cell instance $26914 r0 *1 205.77,103.6
X$26914 6823 113 6835 112 BUF_X4
* cell instance $26915 m0 *1 206.34,103.6
X$26915 6166 113 6710 112 BUF_X4
* cell instance $26917 m0 *1 207.67,103.6
X$26917 6823 6460 6878 112 113 NOR2_X4
* cell instance $26918 m0 *1 209.38,103.6
X$26918 6948 6824 6874 6878 6869 5899 113 112 AOI221_X2
* cell instance $26920 r0 *1 207.1,103.6
X$26920 5657 5421 5450 112 113 7094 MUX2_X1
* cell instance $26921 r0 *1 208.43,103.6
X$26921 6952 7047 6331 6949 6559 6948 113 112 AOI221_X2
* cell instance $26922 r0 *1 210.52,103.6
X$26922 6710 5420 112 113 6949 NOR2_X2
* cell instance $26923 r0 *1 211.47,103.6
X$26923 5866 5661 5864 112 113 7088 MUX2_X1
* cell instance $26924 m0 *1 212.04,103.6
X$26924 6873 6825 5780 6875 5898 112 113 6826 AOI221_X1
* cell instance $26926 m0 *1 213.18,103.6
X$26926 6826 6876 6978 112 113 6874 NOR3_X1
* cell instance $26927 m0 *1 213.94,103.6
X$26927 6828 5783 5767 113 6873 112 OAI21_X1
* cell instance $26928 m0 *1 214.7,103.6
X$26928 6278 6827 112 113 6828 NOR2_X1
* cell instance $26929 m0 *1 215.27,103.6
X$26929 6829 6325 6834 113 6978 112 OAI21_X1
* cell instance $26930 m0 *1 216.03,103.6
X$26930 6733 6828 6328 5781 113 112 6977 OAI22_X1
* cell instance $26931 m0 *1 216.98,103.6
X$26931 6831 6723 6977 112 6830 113 AOI21_X1
* cell instance $26932 m0 *1 217.74,103.6
X$26932 6173 6174 112 113 6829 NAND2_X1
* cell instance $26934 m0 *1 219.07,103.6
X$26934 6825 6950 6560 6832 112 113 6868 AOI22_X1
* cell instance $26938 r0 *1 219.07,103.6
X$26938 7084 6286 6834 113 7082 112 OAI21_X1
* cell instance $26939 r0 *1 219.83,103.6
X$26939 112 5771 6007 7077 5424 5864 6426 5866 113 AOI222_X2
* cell instance $26940 m0 *1 221.16,103.6
X$26940 6834 112 113 6833 INV_X1
* cell instance $26941 m0 *1 220.4,103.6
X$26941 6833 6433 6868 112 6951 113 AOI21_X1
* cell instance $26944 m0 *1 224.77,103.6
X$26944 6180 6721 6865 112 6954 113 AOI21_X1
* cell instance $26946 m0 *1 226.29,103.6
X$26946 6170 6835 112 113 6289 NOR2_X2
* cell instance $26947 m0 *1 227.24,103.6
X$26947 6311 6712 6837 6861 5425 113 112 6836 OAI221_X1
* cell instance $26949 r0 *1 222.49,103.6
X$26949 5564 7051 6952 5781 7169 113 112 6866 OAI221_X1
* cell instance $26950 r0 *1 223.63,103.6
X$26950 6436 7095 6949 6007 5425 113 112 6975 OAI221_X1
* cell instance $26951 r0 *1 224.77,103.6
X$26951 6975 7048 5783 112 6953 113 AOI21_X1
* cell instance $26952 r0 *1 225.53,103.6
X$26952 7074 6954 6952 112 6974 113 AOI21_X1
* cell instance $26954 r0 *1 227.05,103.6
X$26954 7052 6974 6971 112 6955 113 AOI21_X1
* cell instance $26955 r0 *1 227.81,103.6
X$26955 6565 6955 7054 6972 5768 113 112 AOI211_X2
* cell instance $26956 m0 *1 229.9,103.6
X$26956 6840 5425 112 113 6973 NOR2_X1
* cell instance $26957 m0 *1 228.76,103.6
X$26957 6561 6717 6173 6838 5869 113 112 6859 OAI221_X1
* cell instance $26958 m0 *1 230.47,103.6
X$26958 6745 5783 5424 6053 112 113 6840 AOI22_X1
* cell instance $26959 m0 *1 231.42,103.6
X$26959 6878 6831 112 113 6841 NAND2_X1
* cell instance $26961 m0 *1 232.75,103.6
X$26961 6852 6712 6956 6838 6847 113 112 6843 OAI221_X1
* cell instance $26962 m0 *1 233.89,103.6
X$26962 5770 6710 6827 112 113 6956 NAND3_X1
* cell instance $26965 r0 *1 229.52,103.6
X$26965 6173 7055 6174 6973 6859 113 112 6971 OAI221_X1
* cell instance $26968 r0 *1 231.8,103.6
X$26968 5878 6852 6170 112 6964 113 AOI21_X1
* cell instance $26969 r0 *1 232.56,103.6
X$26969 6854 6964 6293 7051 6843 7056 113 112 AOI221_X2
* cell instance $26970 r0 *1 234.65,103.6
X$26970 6959 112 113 6737 BUF_X2
* cell instance $26971 r0 *1 235.41,103.6
X$26971 7057 112 113 6570 BUF_X1
* cell instance $26981 m0 *1 236.55,103.6
X$26981 112 5662 113 6564 BUF_X8
* cell instance $26983 r0 *1 236.55,103.6
X$26983 6957 112 113 6881 CLKBUF_X2
* cell instance $26986 r0 *1 237.88,103.6
X$26986 7058 112 113 6569 CLKBUF_X2
* cell instance $26989 r0 *1 239.21,103.6
X$26989 7174 112 113 6958 BUF_X1
* cell instance $27005 r0 *1 22.99,100.8
X$27005 112 5256 113 4840 BUF_X8
* cell instance $27008 r0 *1 26.6,100.8
X$27008 112 4844 113 6030 BUF_X8
* cell instance $27009 m0 *1 28.31,100.8
X$27009 6505 112 113 3972 INV_X2
* cell instance $27010 m0 *1 27.36,100.8
X$27010 6505 112 113 4181 CLKBUF_X3
* cell instance $27014 r0 *1 29.83,100.8
X$27014 6376 112 113 6731 BUF_X1
* cell instance $27015 m0 *1 30.21,100.8
X$27015 5943 6663 6376 112 113 6572 MUX2_X1
* cell instance $27017 m0 *1 31.54,100.8
X$27017 4181 6663 112 113 4891 NAND2_X1
* cell instance $27018 m0 *1 32.11,100.8
X$27018 5454 6506 5943 112 113 6662 NOR3_X1
* cell instance $27019 m0 *1 32.87,100.8
X$27019 5605 6572 6662 4850 5145 112 113 6377 AOI221_X1
* cell instance $27020 m0 *1 34.01,100.8
X$27020 3972 6664 112 113 6442 NAND2_X1
* cell instance $27021 m0 *1 34.58,100.8
X$27021 6663 113 5454 112 BUF_X4
* cell instance $27023 r0 *1 30.4,100.8
X$27023 6376 113 5610 112 BUF_X4
* cell instance $27024 r0 *1 31.73,100.8
X$27024 6731 6663 112 113 5892 XNOR2_X2
* cell instance $27026 r0 *1 34.01,100.8
X$27026 4840 113 3976 112 BUF_X4
* cell instance $27027 r0 *1 35.34,100.8
X$27027 6664 112 113 6663 INV_X4
* cell instance $27030 m0 *1 36.29,100.8
X$27030 6664 113 4411 112 BUF_X4
* cell instance $27031 m0 *1 37.81,100.8
X$27031 6663 6665 112 113 5682 NOR2_X2
* cell instance $27033 r0 *1 37.05,100.8
X$27033 112 6030 6665 6664 5073 113 NOR3_X4
* cell instance $27034 m0 *1 40.85,100.8
X$27034 4411 6665 112 113 5145 NOR2_X2
* cell instance $27035 m0 *1 39.14,100.8
X$27035 5612 5686 112 6664 113 NAND2_X4
* cell instance $27037 m0 *1 41.99,100.8
X$27037 5686 4015 5612 112 4463 113 NAND3_X4
* cell instance $27039 m0 *1 44.65,100.8
X$27039 3856 6579 6580 3810 6578 113 112 6582 OAI221_X1
* cell instance $27042 r0 *1 39.9,100.8
X$27042 6664 6849 4137 112 113 NOR2_X4
* cell instance $27044 r0 *1 41.99,100.8
X$27044 4411 6665 112 4520 113 NAND2_X4
* cell instance $27047 r0 *1 44.27,100.8
X$27047 112 4844 5953 5826 4783 113 NOR3_X4
* cell instance $27049 m0 *1 46.17,100.8
X$27049 3856 113 4526 112 BUF_X4
* cell instance $27052 r0 *1 47.88,100.8
X$27052 6736 4069 6582 112 113 6735 MUX2_X1
* cell instance $27054 m0 *1 47.88,100.8
X$27054 6508 5262 6576 112 113 6736 MUX2_X1
* cell instance $27082 r0 *1 65.74,198.8
X$27082 14800 14712 14977 113 14844 112 OAI21_X1
* cell instance $27083 r0 *1 66.5,198.8
X$27083 112 14846 113 14271 BUF_X8
* cell instance $27084 m0 *1 67.07,198.8
X$27084 14372 113 14552 112 BUF_X4
* cell instance $27086 m0 *1 68.4,198.8
X$27086 14844 14552 112 113 14440 NAND2_X1
* cell instance $27087 m0 *1 68.97,198.8
X$27087 112 14708 14492 14270 14992 14848 113 OAI22_X4
* cell instance $27094 r0 *1 69.54,198.8
X$27094 14800 14708 14492 113 112 14849 OAI21_X4
* cell instance $27096 r0 *1 72.2,198.8
X$27096 14269 113 14800 112 BUF_X4
* cell instance $27097 m0 *1 73.91,198.8
X$27097 14332 14372 14495 113 14756 112 OAI21_X1
* cell instance $27098 m0 *1 72.58,198.8
X$27098 14156 113 14709 112 BUF_X4
* cell instance $27101 r0 *1 73.91,198.8
X$27101 14709 14269 14801 112 14612 113 NAND3_X4
* cell instance $27102 m0 *1 76.38,198.8
X$27102 14603 14543 14542 14711 14759 113 112 AOI211_X2
* cell instance $27103 m0 *1 75.05,198.8
X$27103 9691 14801 14709 112 14757 113 AOI21_X2
* cell instance $27104 m0 *1 78.09,198.8
X$27104 14156 14151 14496 14605 14269 14652 113 112 AOI221_X2
* cell instance $27105 m0 *1 80.18,198.8
X$27105 14758 14654 14759 14609 14657 14803 112 113 14764 OAI33_X1
* cell instance $27107 m0 *1 81.7,198.8
X$27107 14765 14656 14159 113 14762 112 NOR3_X2
* cell instance $27108 m0 *1 83.03,198.8
X$27108 14661 14710 14764 14560 14766 14456 113 112 AOI221_X2
* cell instance $27109 m0 *1 85.12,198.8
X$27109 14273 14332 14768 112 14767 113 AOI21_X1
* cell instance $27110 m0 *1 85.88,198.8
X$27110 14769 14331 14608 14376 14374 14715 113 112 AOI221_X2
* cell instance $27111 m0 *1 87.97,198.8
X$27111 14608 10764 112 14607 113 NAND2_X4
* cell instance $27112 m0 *1 89.68,198.8
X$27112 14449 14268 112 113 14330 NOR2_X2
* cell instance $27113 m0 *1 90.63,198.8
X$27113 14608 113 14718 112 BUF_X4
* cell instance $27114 m0 *1 91.96,198.8
X$27114 14614 14161 14940 14713 14331 14771 113 112 AOI221_X2
* cell instance $27115 m0 *1 94.05,198.8
X$27115 14546 14449 112 113 14772 NOR2_X1
* cell instance $27116 m0 *1 94.62,198.8
X$27116 14939 14664 14859 14992 14772 113 112 14665 OAI221_X1
* cell instance $27117 m0 *1 95.76,198.8
X$27117 14558 112 113 14716 CLKBUF_X3
* cell instance $27118 m0 *1 96.71,198.8
X$27118 14605 14612 14611 113 14613 112 OAI21_X1
* cell instance $27119 m0 *1 97.47,198.8
X$27119 14718 14610 14717 112 14611 113 AOI21_X1
* cell instance $27120 m0 *1 98.23,198.8
X$27120 14655 14613 14665 112 14804 113 AOI21_X1
* cell instance $27121 m0 *1 98.99,198.8
X$27121 14162 112 113 14655 CLKBUF_X3
* cell instance $27125 r0 *1 76.38,198.8
X$27125 14756 14271 14850 14332 14757 14802 113 112 AOI221_X2
* cell instance $27126 r0 *1 78.47,198.8
X$27126 14757 113 14713 112 BUF_X4
* cell instance $27127 r0 *1 79.8,198.8
X$27127 15169 14267 14713 112 14758 113 AOI21_X1
* cell instance $27129 r0 *1 80.75,198.8
X$27129 14607 14802 14853 113 14803 112 OAI21_X1
* cell instance $27132 r0 *1 82.08,198.8
X$27132 14856 14855 14762 14807 113 14854 112 NOR4_X2
* cell instance $27133 r0 *1 83.79,198.8
X$27133 14712 14268 14160 14332 14763 112 113 14855 AOI221_X1
* cell instance $27134 r0 *1 84.93,198.8
X$27134 14716 14655 112 113 14714 NOR2_X1
* cell instance $27135 r0 *1 85.5,198.8
X$27135 112 14376 113 9925 BUF_X8
* cell instance $27136 r0 *1 87.97,198.8
X$27136 112 14547 14987 113 BUF_X32
* cell instance $27137 r0 *1 97.28,198.8
X$27137 14543 113 14807 112 BUF_X4
* cell instance $27139 r0 *1 98.99,198.8
X$27139 14804 14805 14806 113 14863 112 OAI21_X1
* cell instance $27141 r0 *1 100.13,198.8
X$27141 14863 14892 14807 14944 13692 112 113 OAI211_X2
* cell instance $27146 m0 *1 104.12,198.8
X$27146 14475 112 113 13823 CLKBUF_X3
* cell instance $27147 m0 *1 105.26,198.8
X$27147 14623 14723 13561 112 14615 113 AOI21_X1
* cell instance $27148 m0 *1 106.02,198.8
X$27148 14719 13822 14669 112 14775 113 AOI21_X1
* cell instance $27150 m0 *1 106.97,198.8
X$27150 14720 13823 14775 112 14670 113 AOI21_X1
* cell instance $27152 m0 *1 107.92,198.8
X$27152 14867 14617 14563 14283 112 113 14720 NOR4_X1
* cell instance $27154 m0 *1 110.39,198.8
X$27154 14777 14475 14778 112 113 14616 MUX2_X1
* cell instance $27156 m0 *1 111.91,198.8
X$27156 14789 13890 112 113 14567 NOR2_X1
* cell instance $27157 m0 *1 112.48,198.8
X$27157 14501 14724 14692 112 14617 113 AOI21_X1
* cell instance $27158 m0 *1 113.24,198.8
X$27158 14275 14734 14724 113 14576 112 OAI21_X1
* cell instance $27159 m0 *1 114,198.8
X$27159 14618 14725 13952 14576 14872 112 113 14675 AOI221_X1
* cell instance $27160 m0 *1 115.14,198.8
X$27160 14870 14619 14620 113 14618 112 OAI21_X1
* cell instance $27161 m0 *1 115.9,198.8
X$27161 14619 14567 14808 113 14781 112 OAI21_X1
* cell instance $27162 m0 *1 116.66,198.8
X$27162 14785 14725 14475 14782 112 113 13953 AOI22_X1
* cell instance $27163 m0 *1 117.61,198.8
X$27163 14621 14620 112 113 14785 NAND2_X1
* cell instance $27166 r0 *1 104.69,198.8
X$27166 13890 14808 14948 113 14894 112 OAI21_X1
* cell instance $27167 r0 *1 105.45,198.8
X$27167 14383 14895 14501 112 113 14865 NOR3_X1
* cell instance $27168 r0 *1 106.21,198.8
X$27168 14865 14949 14866 112 113 14719 NOR3_X1
* cell instance $27169 r0 *1 106.97,198.8
X$27169 14173 14096 14275 113 14948 112 OAI21_X1
* cell instance $27171 r0 *1 108.11,198.8
X$27171 13823 14898 14954 113 14087 112 OAI21_X1
* cell instance $27173 r0 *1 109.06,198.8
X$27173 13890 14499 14384 113 14956 112 OAI21_X1
* cell instance $27176 r0 *1 111.72,198.8
X$27176 14568 14722 14789 112 113 14721 NOR3_X1
* cell instance $27179 r0 *1 113.05,198.8
X$27179 14502 14399 14723 112 113 14724 NAND3_X1
* cell instance $27180 r0 *1 113.81,198.8
X$27180 14869 14503 14569 113 15076 112 OAI21_X1
* cell instance $27183 r0 *1 116.47,198.8
X$27183 14873 14784 112 113 14870 NOR2_X1
* cell instance $27185 r0 *1 118.56,198.8
X$27185 14088 14781 14900 112 14726 113 AOI21_X1
* cell instance $27186 m0 *1 118.75,198.8
X$27186 14726 14670 14015 14786 112 113 13954 AOI22_X1
* cell instance $27190 m0 *1 120.65,198.8
X$27190 14568 14486 14873 113 14688 112 OAI21_X1
* cell instance $27195 r0 *1 119.89,198.8
X$27195 14731 14274 14809 112 14778 113 AOI21_X1
* cell instance $27196 r0 *1 120.65,198.8
X$27196 14088 13824 112 113 14875 NAND2_X1
* cell instance $27198 m0 *1 123.31,198.8
X$27198 14728 14789 14727 112 14782 113 AOI21_X1
* cell instance $27199 m0 *1 122.55,198.8
X$27199 14692 14512 113 112 14727 AND2_X1
* cell instance $27200 m0 *1 124.07,198.8
X$27200 14696 14100 14729 112 113 14728 NOR3_X1
* cell instance $27201 m0 *1 124.83,198.8
X$27201 14253 14696 14729 113 14698 112 OAI21_X1
* cell instance $27202 m0 *1 125.59,198.8
X$27202 14386 14622 14697 112 14017 113 AOI21_X1
* cell instance $27204 m0 *1 126.54,198.8
X$27204 14693 14731 14389 113 14510 112 OAI21_X1
* cell instance $27205 m0 *1 127.3,198.8
X$27205 14733 113 14173 112 BUF_X4
* cell instance $27207 m0 *1 128.82,198.8
X$27207 112 14624 14732 14733 14693 113 NOR3_X4
* cell instance $27210 r0 *1 122.93,198.8
X$27210 14392 112 113 14866 CLKBUF_X3
* cell instance $27216 r0 *1 125.02,198.8
X$27216 14173 14096 15005 112 113 14696 NOR3_X1
* cell instance $27217 r0 *1 125.78,198.8
X$27217 14876 14730 13952 113 112 14479 AND3_X1
* cell instance $27219 r0 *1 127.11,198.8
X$27219 13952 13824 112 113 14903 NOR2_X1
* cell instance $27220 r0 *1 127.68,198.8
X$27220 14732 113 14096 112 BUF_X4
* cell instance $27224 r0 *1 130.15,198.8
X$27224 14383 14693 14506 112 113 14794 NOR3_X1
* cell instance $27225 r0 *1 130.91,198.8
X$27225 112 14784 14732 14733 14722 113 NOR3_X4
* cell instance $27226 m0 *1 132.05,198.8
X$27226 14623 14508 112 113 14701 NOR2_X1
* cell instance $27229 m0 *1 132.81,198.8
X$27229 112 14796 14254 14102 14810 113 NOR3_X4
* cell instance $27231 r0 *1 133.57,198.8
X$27231 14389 14976 14569 113 14879 112 OAI21_X1
* cell instance $27232 r0 *1 134.33,198.8
X$27232 14879 14392 14880 112 113 14391 MUX2_X1
* cell instance $27233 r0 *1 135.66,198.8
X$27233 112 14623 14811 14000 14019 113 AOI21_X4
* cell instance $27234 m0 *1 136.61,198.8
X$27234 14254 113 14732 112 BUF_X4
* cell instance $27235 m0 *1 135.85,198.8
X$27235 14623 14683 14734 112 14625 113 AOI21_X1
* cell instance $27239 m0 *1 142.69,198.8
X$27239 112 14514 113 11238 BUF_X8
* cell instance $27245 r0 *1 143.26,198.8
X$27245 112 14515 113 10660 BUF_X8
* cell instance $27246 m0 *1 146.11,198.8
X$27246 112 11075 10524 14075 14884 14626 113 OAI22_X4
* cell instance $27247 m0 *1 145.54,198.8
X$27247 14513 112 113 14626 BUF_X1
* cell instance $27248 m0 *1 149.34,198.8
X$27248 14288 14799 14627 113 14910 112 NOR3_X2
* cell instance $27249 m0 *1 150.67,198.8
X$27249 14288 113 14707 112 BUF_X4
* cell instance $27251 m0 *1 152.19,198.8
X$27251 14736 14740 14885 14628 14293 14406 113 112 AOI221_X2
* cell instance $27253 r0 *1 145.73,198.8
X$27253 14288 112 113 14735 CLKBUF_X3
* cell instance $27255 r0 *1 146.87,198.8
X$27255 14179 14404 14288 113 14812 112 NOR3_X2
* cell instance $27257 r0 *1 148.39,198.8
X$27257 14812 113 14822 112 BUF_X4
* cell instance $27258 r0 *1 149.72,198.8
X$27258 14104 14813 14812 112 15126 113 AOI21_X1
* cell instance $27260 r0 *1 150.67,198.8
X$27260 14180 14909 14405 113 112 14816 OAI21_X2
* cell instance $27261 r0 *1 152,198.8
X$27261 14075 112 113 14799 BUF_X1
* cell instance $27262 r0 *1 152.57,198.8
X$27262 14885 14815 14266 14814 113 14877 112 OR4_X2
* cell instance $27263 r0 *1 153.9,198.8
X$27263 14699 14522 14408 112 14814 113 AOI21_X1
* cell instance $27265 m0 *1 154.66,198.8
X$27265 14190 14291 112 113 14736 NOR2_X1
* cell instance $27266 r0 *1 154.66,198.8
X$27266 14524 14817 112 113 14815 NOR2_X1
* cell instance $27267 r0 *1 155.23,198.8
X$27267 14883 14911 14816 14424 14738 112 113 14797 AOI221_X1
* cell instance $27268 m0 *1 155.8,198.8
X$27268 14707 14737 14629 113 14738 112 OAI21_X1
* cell instance $27270 m0 *1 156.56,198.8
X$27270 14411 14739 14735 14290 14740 113 112 14629 OAI221_X1
* cell instance $27272 m0 *1 158.46,198.8
X$27272 14630 14741 113 112 14296 AND2_X1
* cell instance $27274 r0 *1 156.37,198.8
X$27274 14813 14600 14630 113 14737 112 OAI21_X1
* cell instance $27276 r0 *1 157.51,198.8
X$27276 14600 14104 112 113 14912 NAND2_X1
* cell instance $27277 r0 *1 158.08,198.8
X$27277 14967 14705 14301 14882 113 14818 112 NOR4_X2
* cell instance $27278 m0 *1 161.69,198.8
X$27278 14292 14706 112 113 14703 NAND2_X2
* cell instance $27279 m0 *1 159.6,198.8
X$27279 14703 14798 14185 14694 14296 14913 113 112 AOI221_X2
* cell instance $27280 m0 *1 162.64,198.8
X$27280 14797 14742 14519 112 113 14684 OR3_X2
* cell instance $27283 r0 *1 159.98,198.8
X$27283 14104 14735 112 113 14602 NAND2_X1
* cell instance $27284 r0 *1 160.55,198.8
X$27284 14881 14820 14739 113 112 14299 OAI21_X4
* cell instance $27285 r0 *1 163.02,198.8
X$27285 14694 14820 112 113 14819 NAND2_X1
* cell instance $27287 m0 *1 164.35,198.8
X$27287 14791 14489 14707 112 14416 113 AOI21_X1
* cell instance $27289 m0 *1 165.11,198.8
X$27289 14521 14821 14632 14631 14598 113 112 14689 OAI221_X1
* cell instance $27290 m0 *1 166.25,198.8
X$27290 14517 14292 112 113 14793 NOR2_X1
* cell instance $27292 m0 *1 167.01,198.8
X$27292 14631 14795 112 113 14634 NOR2_X1
* cell instance $27294 m0 *1 167.77,198.8
X$27294 14793 14707 14634 14520 14411 14788 113 112 AOI221_X2
* cell instance $27298 r0 *1 167.2,198.8
X$27298 14699 112 113 14411 INV_X2
* cell instance $27301 r0 *1 168.72,198.8
X$27301 14817 112 113 14636 INV_X2
* cell instance $27304 r0 *1 169.86,198.8
X$27304 14878 14877 14187 112 113 14824 NAND3_X1
* cell instance $27306 m0 *1 170.24,198.8
X$27306 14190 112 113 14694 CLKBUF_X3
* cell instance $27308 r0 *1 170.81,198.8
X$27308 14792 14405 112 113 14825 NOR2_X1
* cell instance $27310 m0 *1 171.76,198.8
X$27310 14471 14632 14637 14691 14526 113 112 14792 OAI221_X1
* cell instance $27312 m0 *1 172.9,198.8
X$27312 14790 14791 14192 112 14691 113 AOI21_X1
* cell instance $27313 m0 *1 173.66,198.8
X$27313 14297 14744 14191 14745 14638 112 113 OAI211_X2
* cell instance $27314 m0 *1 175.37,198.8
X$27314 14823 14469 14953 14639 14684 14687 113 112 AOI221_X2
* cell instance $27315 m0 *1 177.46,198.8
X$27315 14827 112 113 14639 INV_X1
* cell instance $27319 m0 *1 187.15,198.8
X$27319 14640 14302 15070 112 113 14679 MUX2_X1
* cell instance $27320 m0 *1 188.48,198.8
X$27320 14353 14194 13922 112 113 14642 MUX2_X1
* cell instance $27321 m0 *1 189.81,198.8
X$27321 14308 14428 14076 112 14746 113 AOI21_X2
* cell instance $27322 m0 *1 191.14,198.8
X$27322 14783 13702 14678 112 113 13796 MUX2_X1
* cell instance $27323 m0 *1 192.47,198.8
X$27323 14028 14780 14194 113 112 14641 OAI21_X2
* cell instance $27324 m0 *1 193.8,198.8
X$27324 14134 14053 14649 112 113 14674 NOR3_X1
* cell instance $27325 m0 *1 194.56,198.8
X$27325 14864 14747 10368 14779 14776 14462 113 112 AOI221_X2
* cell instance $27326 m0 *1 196.65,198.8
X$27326 14204 14573 14534 113 13968 112 OAI21_X1
* cell instance $27327 m0 *1 197.41,198.8
X$27327 14668 13789 14671 112 113 14860 NOR3_X1
* cell instance $27328 m0 *1 198.17,198.8
X$27328 14134 14748 14448 112 14776 113 AOI21_X1
* cell instance $27329 m0 *1 198.93,198.8
X$27329 14774 14761 14749 14666 113 13390 112 NOR4_X2
* cell instance $27332 r0 *1 171.95,198.8
X$27332 14820 14822 14817 14520 112 113 14826 AOI22_X1
* cell instance $27334 r0 *1 173.28,198.8
X$27334 14294 14526 112 113 14743 NAND2_X1
* cell instance $27335 r0 *1 173.85,198.8
X$27335 14826 14743 14191 112 113 14744 NAND3_X1
* cell instance $27338 r0 *1 175.56,198.8
X$27338 14301 14788 14916 113 14874 112 OAI21_X1
* cell instance $27340 r0 *1 176.7,198.8
X$27340 14297 14525 14187 112 113 14951 NAND3_X1
* cell instance $27348 r0 *1 181.83,198.8
X$27348 112 16990 10182 14828 13638 113 DFF_X1
* cell instance $27349 r0 *1 185.06,198.8
X$27349 13833 14081 14082 113 112 13922 OAI21_X4
* cell instance $27351 r0 *1 187.72,198.8
X$27351 14787 14829 14302 112 14680 113 AOI21_X1
* cell instance $27353 r0 *1 188.86,198.8
X$27353 14027 14829 112 113 14111 NOR2_X1
* cell instance $27354 r0 *1 189.43,198.8
X$27354 14676 13716 14871 112 14858 113 AOI21_X1
* cell instance $27355 r0 *1 190.19,198.8
X$27355 14353 14302 13922 112 113 14868 MUX2_X1
* cell instance $27357 r0 *1 191.71,198.8
X$27357 13834 13904 13703 14779 14868 14671 113 112 AOI221_X2
* cell instance $27359 r0 *1 194.18,198.8
X$27359 10516 14310 14302 112 14747 113 AOI21_X2
* cell instance $27360 r0 *1 195.51,198.8
X$27360 14831 14647 14747 112 14760 113 AOI21_X2
* cell instance $27361 r0 *1 196.84,198.8
X$27361 14529 14750 14539 112 113 14941 NOR3_X1
* cell instance $27362 r0 *1 197.6,198.8
X$27362 14302 13922 112 113 14864 OR2_X2
* cell instance $27363 r0 *1 198.55,198.8
X$27363 14642 14033 112 113 14832 NAND2_X1
* cell instance $27364 r0 *1 199.12,198.8
X$27364 13709 14832 14862 112 14861 113 AOI21_X1
* cell instance $27367 r0 *1 200.45,198.8
X$27367 13910 14432 14548 112 113 14862 NAND3_X1
* cell instance $27368 m0 *1 201.21,198.8
X$27368 14032 14773 15052 112 14774 113 AOI21_X1
* cell instance $27370 m0 *1 201.97,198.8
X$27370 14141 14646 112 113 14773 NOR2_X1
* cell instance $27372 m0 *1 202.73,198.8
X$27372 14750 13707 112 113 14645 NAND2_X1
* cell instance $27373 m0 *1 203.3,198.8
X$27373 14645 13776 112 113 14857 NOR2_X1
* cell instance $27374 m0 *1 203.87,198.8
X$27374 14640 112 113 14039 INV_X2
* cell instance $27376 m0 *1 205.2,198.8
X$27376 14645 15269 14434 14070 14770 14648 112 113 14533 OAI33_X1
* cell instance $27378 m0 *1 206.72,198.8
X$27378 14311 14647 14447 112 14770 113 AOI21_X1
* cell instance $27380 m0 *1 207.67,198.8
X$27380 14649 14780 14076 112 14446 113 AOI21_X2
* cell instance $27381 m0 *1 209,198.8
X$27381 14553 14554 14750 14202 14659 14835 113 112 AOI221_X2
* cell instance $27382 m0 *1 211.09,198.8
X$27382 14201 13925 14122 14653 14650 15049 113 112 AOI221_X2
* cell instance $27383 m0 *1 213.18,198.8
X$27383 14553 14752 14548 112 113 14650 NAND3_X1
* cell instance $27387 r0 *1 201.78,198.8
X$27387 14857 14858 14860 15152 14753 13907 113 112 AOI221_X2
* cell instance $27388 r0 *1 203.87,198.8
X$27388 14750 14038 112 113 14070 NAND2_X2
* cell instance $27391 r0 *1 205.96,198.8
X$27391 13709 14837 14937 112 14660 113 AOI21_X1
* cell instance $27392 r0 *1 206.72,198.8
X$27392 14537 14432 112 14833 113 NAND2_X4
* cell instance $27393 r0 *1 208.43,198.8
X$27393 14649 14310 112 113 14834 NAND2_X1
* cell instance $27394 r0 *1 209,198.8
X$27394 14076 14531 112 113 14553 NAND2_X2
* cell instance $27395 r0 *1 209.95,198.8
X$27395 13971 15155 14921 14121 112 113 14836 NAND4_X1
* cell instance $27397 r0 *1 211.09,198.8
X$27397 14544 13769 112 113 14752 NAND2_X1
* cell instance $27398 r0 *1 211.66,198.8
X$27398 13966 13898 14852 112 113 14537 NAND3_X1
* cell instance $27400 r0 *1 212.61,198.8
X$27400 14539 13769 112 113 14838 NOR2_X1
* cell instance $27401 r0 *1 213.18,198.8
X$27401 14838 14851 14033 113 14837 112 OAI21_X1
* cell instance $27402 r0 *1 213.94,198.8
X$27402 14750 14038 112 113 14121 NOR2_X1
* cell instance $27403 m0 *1 215.65,198.8
X$27403 13919 14446 14752 112 14847 113 AOI21_X1
* cell instance $27404 m0 *1 214.32,198.8
X$27404 13772 14751 14535 112 14761 113 AOI21_X2
* cell instance $27405 m0 *1 216.41,198.8
X$27405 13772 14122 112 113 14753 NOR2_X1
* cell instance $27406 m0 *1 216.98,198.8
X$27406 14311 14447 14128 14108 13973 112 113 14755 AOI221_X1
* cell instance $27407 m0 *1 218.12,198.8
X$27407 14316 14539 112 113 14540 NAND2_X1
* cell instance $27408 m0 *1 218.69,198.8
X$27408 14647 14447 112 113 15039 NAND2_X1
* cell instance $27415 r0 *1 214.51,198.8
X$27415 13839 14760 14214 14929 14839 14751 112 113 OAI221_X2
* cell instance $27417 r0 *1 216.98,198.8
X$27417 14548 14752 14043 112 14840 113 AOI21_X1
* cell instance $27419 r0 *1 217.93,198.8
X$27419 14755 14839 14847 112 14842 113 AOI21_X1
* cell instance $27420 r0 *1 218.69,198.8
X$27420 14839 14438 14845 112 14754 113 AOI21_X1
* cell instance $27421 r0 *1 219.45,198.8
X$27421 13974 14841 14753 14842 112 113 14843 AOI22_X1
* cell instance $27444 m0 *1 68.97,196
X$27444 14372 113 14538 112 BUF_X4
* cell instance $27445 m0 *1 70.3,196
X$27445 10764 113 14543 112 BUF_X4
* cell instance $27447 m0 *1 73.15,196
X$27447 11064 10648 112 113 14373 NOR2_X2
* cell instance $27448 m0 *1 74.1,196
X$27448 14373 113 14372 112 BUF_X4
* cell instance $27449 m0 *1 75.43,196
X$27449 10648 113 14492 112 BUF_X4
* cell instance $27450 m0 *1 76.76,196
X$27450 14494 14444 14375 14495 14372 14603 113 112 AOI221_X2
* cell instance $27451 m0 *1 78.85,196
X$27451 14542 113 14497 112 BUF_X4
* cell instance $27452 m0 *1 80.18,196
X$27452 14273 113 14546 112 BUF_X4
* cell instance $27454 m0 *1 81.7,196
X$27454 14156 14271 14151 112 14445 113 NAND3_X4
* cell instance $27455 m0 *1 84.17,196
X$27455 112 14377 14271 14151 14156 113 AOI21_X4
* cell instance $27457 m0 *1 86.83,196
X$27457 112 9925 14547 113 BUF_X16
* cell instance $27458 m0 *1 91.58,196
X$27458 14374 14161 14331 14552 112 113 14455 AOI22_X1
* cell instance $27479 r0 *1 68.97,196
X$27479 11064 113 14708 112 BUF_X4
* cell instance $27480 r0 *1 70.3,196
X$27480 112 9691 10648 11064 14769 113 NOR3_X4
* cell instance $27482 r0 *1 73.34,196
X$27482 14273 14662 14373 14331 14269 14493 113 112 AOI221_X2
* cell instance $27484 r0 *1 75.62,196
X$27484 14154 112 113 14605 BUF_X2
* cell instance $27485 r0 *1 76.38,196
X$27485 14494 14652 14543 14604 14440 14657 113 112 AOI221_X2
* cell instance $27486 r0 *1 78.47,196
X$27486 14493 14375 112 113 14604 NOR2_X1
* cell instance $27487 r0 *1 79.04,196
X$27487 14655 14558 14545 112 113 14654 NAND3_X2
* cell instance $27488 r0 *1 80.37,196
X$27488 112 14547 10648 11064 14656 113 NOR3_X4
* cell instance $27490 r0 *1 83.22,196
X$27490 9691 14271 112 113 14494 NAND2_X2
* cell instance $27492 r0 *1 84.36,196
X$27492 14607 14606 14714 113 14549 112 OAI21_X1
* cell instance $27493 r0 *1 85.12,196
X$27493 14375 14495 14376 113 14768 112 OAI21_X1
* cell instance $27494 r0 *1 85.88,196
X$27494 9925 112 113 14271 INV_X8
* cell instance $27495 r0 *1 87.59,196
X$27495 14549 112 113 14661 INV_X1
* cell instance $27496 r0 *1 87.97,196
X$27496 14496 113 14608 112 BUF_X4
* cell instance $27497 r0 *1 89.3,196
X$27497 14442 14450 14496 14662 14377 14663 113 112 AOI221_X2
* cell instance $27498 r0 *1 91.39,196
X$27498 10186 10187 112 14496 113 NAND2_X4
* cell instance $27500 m0 *1 92.91,196
X$27500 14378 112 113 14664 CLKBUF_X3
* cell instance $27501 r0 *1 93.1,196
X$27501 14375 113 14379 112 BUF_X4
* cell instance $27503 m0 *1 94.24,196
X$27503 14497 14329 14333 14556 14451 14559 113 112 AOI221_X2
* cell instance $27504 m0 *1 96.52,196
X$27504 14557 14498 112 113 14556 NOR2_X1
* cell instance $27508 r0 *1 94.81,196
X$27508 14498 14558 112 113 14609 OR2_X2
* cell instance $27510 r0 *1 96.14,196
X$27510 14538 14610 14494 112 14557 113 AOI21_X1
* cell instance $27512 r0 *1 97.09,196
X$27512 14085 112 113 14558 CLKBUF_X3
* cell instance $27513 r0 *1 98.04,196
X$27513 14213 14612 112 113 14614 NAND2_X1
* cell instance $27515 r0 *1 98.8,196
X$27515 14380 14558 113 112 14560 AND2_X1
* cell instance $27517 m0 *1 98.99,196
X$27517 14380 113 14498 112 BUF_X4
* cell instance $27519 m0 *1 104.88,196
X$27519 14561 14274 14615 112 14461 113 AOI21_X1
* cell instance $27520 m0 *1 105.64,196
X$27520 14381 14383 14274 112 113 14561 NOR3_X1
* cell instance $27522 m0 *1 106.59,196
X$27522 14385 14168 14463 13560 14486 14382 113 112 AOI221_X2
* cell instance $27527 r0 *1 104.31,196
X$27527 14386 113 14475 112 BUF_X4
* cell instance $27529 r0 *1 105.83,196
X$27529 14381 14253 14501 112 113 14564 NOR3_X1
* cell instance $27532 r0 *1 107.16,196
X$27532 14564 13695 14672 112 14669 113 AOI21_X1
* cell instance $27534 r0 *1 108.3,196
X$27534 14512 14565 113 112 14672 AND2_X1
* cell instance $27535 m0 *1 109.25,196
X$27535 14384 112 113 14563 CLKBUF_X3
* cell instance $27537 m0 *1 110.2,196
X$27537 13890 13695 14500 113 14466 112 OAI21_X1
* cell instance $27541 r0 *1 109.63,196
X$27541 14283 14673 14566 113 14089 112 OAI21_X1
* cell instance $27542 r0 *1 110.39,196
X$27542 14501 14383 13560 14499 113 112 14673 OAI22_X1
* cell instance $27543 r0 *1 111.34,196
X$27543 14675 14015 14616 112 14091 113 AOI21_X1
* cell instance $27544 m0 *1 112.1,196
X$27544 14387 14501 112 113 14468 NOR2_X1
* cell instance $27545 m0 *1 111.34,196
X$27545 14468 14567 14475 113 14467 112 OAI21_X1
* cell instance $27546 m0 *1 112.67,196
X$27546 14502 14399 14278 112 113 14387 NAND3_X2
* cell instance $27549 r0 *1 112.1,196
X$27549 14721 14677 14475 113 14566 112 OAI21_X1
* cell instance $27550 r0 *1 112.86,196
X$27550 14278 14502 14399 112 14568 113 AOI21_X2
* cell instance $27553 m0 *1 115.33,196
X$27553 14504 14506 14503 112 14505 113 AOI21_X1
* cell instance $27555 m0 *1 116.09,196
X$27555 14389 14388 14570 112 14504 113 AOI21_X1
* cell instance $27557 m0 *1 117.04,196
X$27557 14505 14384 14571 112 113 14170 MUX2_X1
* cell instance $27560 m0 *1 119.32,196
X$27560 14508 14574 14383 112 113 14575 OR3_X2
* cell instance $27561 m0 *1 120.46,196
X$27561 14506 14576 14575 113 14474 112 OAI21_X1
* cell instance $27563 r0 *1 115.33,196
X$27563 14389 14140 112 113 14619 NOR2_X1
* cell instance $27564 r0 *1 115.9,196
X$27564 14502 14399 14572 112 113 14570 NAND3_X1
* cell instance $27565 r0 *1 116.66,196
X$27565 14275 14574 14683 112 113 14621 MUX2_X1
* cell instance $27568 r0 *1 118.94,196
X$27568 14677 14506 14507 112 14571 113 AOI21_X1
* cell instance $27570 r0 *1 120.46,196
X$27570 14690 14507 14688 113 14281 112 OAI21_X1
* cell instance $27572 m0 *1 121.79,196
X$27572 14474 14392 14393 112 113 14394 MUX2_X1
* cell instance $27576 m0 *1 124.83,196
X$27576 14499 13952 14509 112 113 14395 NOR3_X1
* cell instance $27580 r0 *1 123.31,196
X$27580 14500 14693 112 113 14507 OR2_X1
* cell instance $27585 r0 *1 124.26,196
X$27585 14509 14173 14096 113 112 14565 OAI21_X4
* cell instance $27586 m0 *1 126.16,196
X$27586 14577 14487 14132 112 113 14397 NAND3_X1
* cell instance $27588 m0 *1 126.92,196
X$27588 14510 14397 113 112 14398 AND2_X1
* cell instance $27590 r0 *1 126.73,196
X$27590 14698 14510 14392 112 113 14697 NAND3_X1
* cell instance $27593 m0 *1 129.39,196
X$27593 14508 14500 112 113 14400 OR2_X1
* cell instance $27594 m0 *1 128.06,196
X$27594 14400 14487 15316 112 113 14175 MUX2_X1
* cell instance $27595 m0 *1 130.15,196
X$27595 13956 113 14384 112 BUF_X4
* cell instance $27596 m0 *1 131.48,196
X$27596 14400 14487 14701 112 113 14511 MUX2_X1
* cell instance $27599 r0 *1 128.06,196
X$27599 14000 113 14502 112 BUF_X4
* cell instance $27600 r0 *1 129.39,196
X$27600 14401 14690 112 113 14578 NAND2_X1
* cell instance $27602 r0 *1 130.15,196
X$27602 14578 14579 14384 112 113 14622 NAND3_X1
* cell instance $27603 r0 *1 130.91,196
X$27603 14580 14475 14581 112 113 14001 MUX2_X1
* cell instance $27605 r0 *1 133,196
X$27605 14511 14463 14583 112 113 14580 MUX2_X1
* cell instance $27620 m0 *1 69.73,193.2
X$27620 14152 112 113 14267 INV_X8
* cell instance $27621 m0 *1 71.44,193.2
X$27621 14151 14156 112 113 14268 NAND2_X2
* cell instance $27622 m0 *1 72.39,193.2
X$27622 14269 113 14160 112 BUF_X4
* cell instance $27623 m0 *1 73.72,193.2
X$27623 112 14152 10648 11064 14155 113 NOR3_X4
* cell instance $27650 r0 *1 72.01,193.2
X$27650 9691 113 14495 112 BUF_X4
* cell instance $27652 r0 *1 73.53,193.2
X$27652 112 14374 14269 14151 14156 113 AOI21_X4
* cell instance $27653 r0 *1 76,193.2
X$27653 14375 113 14542 112 BUF_X4
* cell instance $27654 m0 *1 79.23,193.2
X$27654 14154 11064 10648 113 112 14158 OAI21_X4
* cell instance $27655 m0 *1 76.76,193.2
X$27655 112 14157 14154 14151 14156 113 AOI21_X4
* cell instance $27658 m0 *1 83.41,193.2
X$27658 10563 112 113 14324 BUF_X1
* cell instance $27659 m0 *1 83.98,193.2
X$27659 9925 112 113 14083 BUF_X1
* cell instance $27660 m0 *1 84.55,193.2
X$27660 14160 14271 14084 10050 112 113 14325 AOI22_X2
* cell instance $27662 m0 *1 86.45,193.2
X$27662 112 14159 14162 14155 14269 14163 113 NOR4_X4
* cell instance $27663 m0 *1 89.87,193.2
X$27663 14328 14162 14163 14160 14223 14329 113 112 AOI221_X2
* cell instance $27664 m0 *1 91.96,193.2
X$27664 10187 10186 113 112 14453 AND2_X1
* cell instance $27665 m0 *1 92.72,193.2
X$27665 14455 14379 14162 112 113 14333 NOR3_X1
* cell instance $27666 m0 *1 93.48,193.2
X$27666 14273 14332 112 113 14272 NAND2_X1
* cell instance $27670 r0 *1 77.71,193.2
X$27670 112 14269 10648 11064 14442 113 NOR3_X4
* cell instance $27671 r0 *1 80.37,193.2
X$27671 112 14271 10648 11064 14763 113 NOR3_X4
* cell instance $27673 r0 *1 83.22,193.2
X$27673 9925 14324 14270 113 112 14444 OAI21_X4
* cell instance $27675 r0 *1 85.88,193.2
X$27675 10764 14376 112 113 14450 NOR2_X1
* cell instance $27676 r0 *1 86.45,193.2
X$27676 14495 14271 112 113 14449 NOR2_X1
* cell instance $27677 r0 *1 87.02,193.2
X$27677 14269 9925 14273 112 113 NOR2_X4
* cell instance $27679 r0 *1 88.92,193.2
X$27679 112 14451 14375 14330 14272 113 AOI21_X4
* cell instance $27681 r0 *1 91.77,193.2
X$27681 14453 113 14375 112 BUF_X4
* cell instance $27682 r0 *1 93.1,193.2
X$27682 112 16955 14335 14456 14086 113 DFF_X1
* cell instance $27684 m0 *1 95.95,193.2
X$27684 112 16866 14225 14334 14086 113 DFF_X1
* cell instance $27686 r0 *1 96.52,193.2
X$27686 112 16992 14459 14457 14086 113 DFF_X1
* cell instance $27687 m0 *1 99.75,193.2
X$27687 14335 113 5121 112 BUF_X4
* cell instance $27689 m0 *1 101.08,193.2
X$27689 112 16854 14339 14893 14086 113 DFF_X1
* cell instance $27690 m0 *1 104.31,193.2
X$27690 112 5295 113 14339 BUF_X8
* cell instance $27691 m0 *1 106.78,193.2
X$27691 14230 14274 112 113 14165 NOR2_X1
* cell instance $27692 m0 *1 107.35,193.2
X$27692 14169 14341 14343 113 14233 112 OAI21_X1
* cell instance $27693 m0 *1 108.11,193.2
X$27693 14275 14253 13561 14279 112 113 14230 AOI22_X1
* cell instance $27694 m0 *1 109.06,193.2
X$27694 14166 112 113 14167 CLKBUF_X3
* cell instance $27697 m0 *1 110.96,193.2
X$27697 14168 14169 16542 113 112 14278 HA_X1
* cell instance $27698 m0 *1 112.86,193.2
X$27698 14169 13561 113 112 14349 XNOR2_X1
* cell instance $27699 m0 *1 114,193.2
X$27699 13952 14569 13695 14349 14231 112 113 OAI211_X2
* cell instance $27700 m0 *1 115.71,193.2
X$27700 14088 14350 14231 113 14232 112 OAI21_X1
* cell instance $27702 r0 *1 99.75,193.2
X$27702 8133 112 113 14086 CLKBUF_X3
* cell instance $27703 r0 *1 100.7,193.2
X$27703 14086 112 113 17189 INV_X2
* cell instance $27705 r0 *1 102.79,193.2
X$27705 14459 113 4658 112 BUF_X4
* cell instance $27707 r0 *1 105.64,193.2
X$27707 14382 14563 14461 112 14465 113 AOI21_X2
* cell instance $27708 r0 *1 106.97,193.2
X$27708 14165 14253 14164 112 14341 113 AOI21_X1
* cell instance $27709 r0 *1 107.73,193.2
X$27709 14173 14096 14275 112 113 14381 NOR3_X1
* cell instance $27711 r0 *1 108.68,193.2
X$27711 14386 14168 14512 112 14344 113 AOI21_X1
* cell instance $27712 r0 *1 109.44,193.2
X$27712 14168 14385 14344 14499 13560 113 112 14276 OAI221_X1
* cell instance $27713 r0 *1 110.58,193.2
X$27713 14466 14467 14276 112 113 14277 NAND3_X1
* cell instance $27714 r0 *1 111.34,193.2
X$27714 14386 113 14283 112 BUF_X4
* cell instance $27715 r0 *1 112.67,193.2
X$27715 14278 112 113 14132 CLKBUF_X3
* cell instance $27719 r0 *1 116.09,193.2
X$27719 14173 14096 14132 113 14388 112 OAI21_X1
* cell instance $27720 m0 *1 117.04,193.2
X$27720 14351 13952 14283 14170 14092 113 112 AOI211_X2
* cell instance $27724 r0 *1 116.85,193.2
X$27724 14364 113 14279 112 BUF_X4
* cell instance $27725 r0 *1 118.18,193.2
X$27725 14391 14386 14390 112 113 14171 MUX2_X1
* cell instance $27727 m0 *1 120.08,193.2
X$27727 14352 14088 112 113 14235 NOR2_X1
* cell instance $27729 m0 *1 120.65,193.2
X$27729 14088 14167 112 113 14280 NAND2_X1
* cell instance $27730 m0 *1 121.22,193.2
X$27730 14280 14465 14015 14239 113 112 14240 OAI22_X2
* cell instance $27731 m0 *1 122.93,193.2
X$27731 14354 14166 14172 112 113 14238 MUX2_X1
* cell instance $27735 m0 *1 126.73,193.2
X$27735 14396 14283 14174 112 113 14101 MUX2_X1
* cell instance $27737 m0 *1 128.25,193.2
X$27737 14356 13824 14175 112 113 14354 MUX2_X1
* cell instance $27740 r0 *1 121.22,193.2
X$27740 14473 14392 14281 112 113 14282 MUX2_X1
* cell instance $27741 r0 *1 122.55,193.2
X$27741 14282 14475 14394 112 113 14016 MUX2_X1
* cell instance $27742 r0 *1 123.88,193.2
X$27742 14279 113 14166 112 BUF_X4
* cell instance $27749 r0 *1 125.21,193.2
X$27749 14355 14479 14395 14166 112 113 14093 NOR4_X1
* cell instance $27751 r0 *1 126.54,193.2
X$27751 14481 13824 14398 112 113 14174 MUX2_X1
* cell instance $27753 r0 *1 128.63,193.2
X$27753 14019 113 14399 112 BUF_X4
* cell instance $27755 m0 *1 129.96,193.2
X$27755 14485 14252 113 112 14356 XNOR2_X1
* cell instance $27756 m0 *1 131.29,193.2
X$27756 14142 14247 14176 112 113 14252 MUX2_X1
* cell instance $27761 r0 *1 130.72,193.2
X$27761 14176 112 113 14487 CLKBUF_X3
* cell instance $27763 m0 *1 133.19,193.2
X$27763 14284 224 14177 112 113 NOR2_X4
* cell instance $27765 m0 *1 134.9,193.2
X$27765 14177 9386 14000 14021 3162 113 112 14360 OAI221_X1
* cell instance $27769 r0 *1 134.14,193.2
X$27769 14360 112 113 14512 CLKBUF_X3
* cell instance $27770 r0 *1 135.09,193.2
X$27770 112 14177 14285 14254 14102 14401 113 NOR4_X4
* cell instance $27771 m0 *1 136.61,193.2
X$27771 14177 9386 14247 112 113 NOR2_X4
* cell instance $27775 r0 *1 138.7,193.2
X$27775 8862 14491 113 112 14367 AND2_X1
* cell instance $27776 m0 *1 138.89,193.2
X$27776 112 14364 14367 3162 13883 113 AOI21_X4
* cell instance $27779 m0 *1 141.55,193.2
X$27779 4658 11118 113 14286 112 XOR2_X2
* cell instance $27784 r0 *1 142.69,193.2
X$27784 14287 112 113 14290 BUF_X1
* cell instance $27785 r0 *1 143.26,193.2
X$27785 14288 14513 14075 113 112 14490 OAI21_X4
* cell instance $27787 m0 *1 144.4,193.2
X$27787 14147 11596 14287 112 113 NOR2_X4
* cell instance $27788 m0 *1 146.3,193.2
X$27788 112 14404 113 10524 BUF_X8
* cell instance $27791 m0 *1 149.72,193.2
X$27791 112 11276 11236 14179 14405 14404 113 OAI211_X4
* cell instance $27792 m0 *1 152.95,193.2
X$27792 14371 112 113 14187 CLKBUF_X3
* cell instance $27794 r0 *1 145.73,193.2
X$27794 112 14403 10524 11075 14292 113 NOR3_X4
* cell instance $27796 r0 *1 148.77,193.2
X$27796 14288 14403 112 14293 113 NAND2_X4
* cell instance $27798 r0 *1 151.24,193.2
X$27798 14288 14179 14404 113 112 14408 OAI21_X4
* cell instance $27799 r0 *1 153.71,193.2
X$27799 112 14289 14404 14179 14294 113 NOR3_X4
* cell instance $27800 m0 *1 155.61,193.2
X$27800 14290 14181 14292 112 113 14370 MUX2_X1
* cell instance $27801 m0 *1 154.28,193.2
X$27801 14290 113 14291 112 BUF_X4
* cell instance $27803 r0 *1 156.37,193.2
X$27803 14409 14419 14105 14483 14370 14358 113 112 AOI221_X2
* cell instance $27804 m0 *1 158.65,193.2
X$27804 14104 14289 112 113 14295 NAND2_X2
* cell instance $27805 m0 *1 157.32,193.2
X$27805 14105 113 14297 112 BUF_X4
* cell instance $27807 r0 *1 158.46,193.2
X$27807 14294 14410 14293 112 14488 113 AOI21_X1
* cell instance $27809 r0 *1 159.41,193.2
X$27809 14295 14704 14183 14184 14488 113 112 14417 OAI221_X1
* cell instance $27810 m0 *1 160.17,193.2
X$27810 14296 14184 14262 112 113 14183 NAND3_X1
* cell instance $27812 m0 *1 160.93,193.2
X$27812 14185 113 14186 112 BUF_X4
* cell instance $27813 m0 *1 162.26,193.2
X$27813 14182 113 14191 112 BUF_X4
* cell instance $27814 m0 *1 163.59,193.2
X$27814 14368 14365 14260 112 113 14263 NAND3_X1
* cell instance $27815 m0 *1 164.35,193.2
X$27815 14180 14261 112 113 14363 NAND2_X1
* cell instance $27816 m0 *1 164.92,193.2
X$27816 14298 14186 14187 14264 14361 113 112 14418 OAI221_X1
* cell instance $27817 m0 *1 166.06,193.2
X$27817 14362 14263 14188 14420 112 113 14189 AOI22_X1
* cell instance $27820 r0 *1 160.93,193.2
X$27820 14403 14181 14289 112 14369 113 AOI21_X1
* cell instance $27821 r0 *1 161.69,193.2
X$27821 14291 14369 14293 113 14484 112 OAI21_X1
* cell instance $27822 r0 *1 162.45,193.2
X$27822 14292 14181 112 113 14414 NAND2_X1
* cell instance $27823 r0 *1 163.02,193.2
X$27823 14363 14291 14482 112 14366 113 AOI21_X1
* cell instance $27824 r0 *1 163.78,193.2
X$27824 14415 14366 14297 14472 14480 14469 113 112 AOI221_X2
* cell instance $27825 r0 *1 165.87,193.2
X$27825 14418 14599 14417 14363 14477 14420 112 113 OAI221_X2
* cell instance $27826 m0 *1 167.58,193.2
X$27826 14359 14262 14299 112 14361 113 AOI21_X1
* cell instance $27829 m0 *1 169.1,193.2
X$27829 14192 14261 112 113 14472 NOR2_X1
* cell instance $27830 m0 *1 169.67,193.2
X$27830 14261 112 113 14260 CLKBUF_X3
* cell instance $27832 r0 *1 167.96,193.2
X$27832 14523 14407 14476 14187 113 14477 112 OR4_X2
* cell instance $27834 r0 *1 170.05,193.2
X$27834 14180 113 14471 112 BUF_X4
* cell instance $27835 m0 *1 171.76,193.2
X$27835 14191 14299 14357 113 14300 112 OAI21_X1
* cell instance $27836 m0 *1 171,193.2
X$27836 14190 14405 113 112 14357 AND2_X1
* cell instance $27838 m0 *1 173.28,193.2
X$27838 14192 113 14301 112 BUF_X4
* cell instance $27841 m0 *1 175.56,193.2
X$27841 14191 113 14184 112 BUF_X4
* cell instance $27844 m0 *1 186.01,193.2
X$27844 112 14193 14245 113 BUF_X16
* cell instance $27845 m0 *1 190.76,193.2
X$27845 14194 113 14076 112 BUF_X4
* cell instance $27847 r0 *1 171.38,193.2
X$27847 14301 14358 14300 112 14470 113 AOI21_X1
* cell instance $27849 r0 *1 172.52,193.2
X$27849 14471 112 113 14407 CLKBUF_X3
* cell instance $27850 r0 *1 173.47,193.2
X$27850 14297 14180 112 113 14589 NOR2_X1
* cell instance $27860 r0 *1 181.07,193.2
X$27860 14585 112 113 9323 CLKBUF_X3
* cell instance $27863 r0 *1 183.92,193.2
X$27863 112 14193 14025 14026 14205 113 NOR3_X4
* cell instance $27864 r0 *1 186.58,193.2
X$27864 11204 11362 112 14302 113 NAND2_X4
* cell instance $27866 r0 *1 188.48,193.2
X$27866 13766 13765 112 113 14194 NOR2_X2
* cell instance $27868 r0 *1 189.62,193.2
X$27868 112 14308 14193 11204 11362 113 AOI21_X4
* cell instance $27869 r0 *1 192.09,193.2
X$27869 14429 14194 10046 112 113 14107 NOR3_X1
* cell instance $27870 m0 *1 192.66,193.2
X$27870 14303 14302 14353 112 113 14196 MUX2_X1
* cell instance $27872 m0 *1 193.99,193.2
X$27872 13836 14206 13703 14314 14196 14347 113 112 AOI221_X2
* cell instance $27873 m0 *1 196.08,193.2
X$27873 14431 14031 14348 14246 14222 14236 113 112 AOI221_X2
* cell instance $27874 m0 *1 198.17,193.2
X$27874 14347 13788 14464 112 113 14348 NOR3_X1
* cell instance $27875 m0 *1 198.93,193.2
X$27875 14346 14309 14305 112 14342 113 AOI21_X1
* cell instance $27876 m0 *1 199.69,193.2
X$27876 14345 14306 112 113 14305 NAND2_X1
* cell instance $27877 m0 *1 200.26,193.2
X$27877 14073 14199 14128 112 113 14244 NAND3_X1
* cell instance $27879 r0 *1 192.85,193.2
X$27879 112 14303 13837 113 BUF_X16
* cell instance $27880 r0 *1 197.6,193.2
X$27880 11204 11362 13904 112 113 14306 NAND3_X2
* cell instance $27881 r0 *1 198.93,193.2
X$27881 13836 14316 10046 14314 14305 112 113 14307 AOI221_X1
* cell instance $27882 r0 *1 200.07,193.2
X$27882 14307 14462 13925 113 14431 112 OAI21_X1
* cell instance $27883 r0 *1 200.83,193.2
X$27883 14134 14308 14033 112 113 14346 NOR3_X1
* cell instance $27884 m0 *1 203.49,193.2
X$27884 14200 14310 14033 112 14203 113 AOI21_X1
* cell instance $27885 m0 *1 201.4,193.2
X$27885 14216 13772 14337 14032 14236 13653 112 113 OAI221_X2
* cell instance $27886 m0 *1 204.25,193.2
X$27886 14338 112 113 14071 INV_X2
* cell instance $27888 m0 *1 205.01,193.2
X$27888 14204 14053 14336 13973 112 113 14065 AOI22_X1
* cell instance $27889 m0 *1 205.96,193.2
X$27889 14115 14314 14204 112 113 14118 MUX2_X1
* cell instance $27890 m0 *1 207.29,193.2
X$27890 14313 14205 14311 113 14036 112 OAI21_X1
* cell instance $27891 m0 *1 208.05,193.2
X$27891 14071 14198 14043 113 14327 112 OAI21_X1
* cell instance $27894 m0 *1 209.76,193.2
X$27894 14443 14326 13788 14550 13972 14322 113 112 AOI221_X2
* cell instance $27895 m0 *1 211.85,193.2
X$27895 13910 14038 112 113 14323 NAND2_X1
* cell instance $27896 m0 *1 212.42,193.2
X$27896 14322 14208 14218 112 13849 113 AOI21_X1
* cell instance $27897 m0 *1 213.18,193.2
X$27897 13772 14315 13839 112 113 14218 NOR3_X1
* cell instance $27898 m0 *1 213.94,193.2
X$27898 14309 14317 14123 14210 113 112 14208 OAI22_X1
* cell instance $27899 m0 *1 214.89,193.2
X$27899 14209 13918 14309 113 14210 112 OAI21_X1
* cell instance $27901 r0 *1 201.59,193.2
X$27901 14309 14306 14432 112 14340 113 AOI21_X1
* cell instance $27903 r0 *1 202.73,193.2
X$27903 14311 14111 14197 13975 14336 112 113 14312 AOI221_X1
* cell instance $27904 r0 *1 203.87,193.2
X$27904 14312 14458 14452 112 113 14337 NOR3_X1
* cell instance $27905 r0 *1 204.63,193.2
X$27905 14134 14313 14433 113 14454 112 OAI21_X1
* cell instance $27906 r0 *1 205.39,193.2
X$27906 14039 13966 13898 112 14313 113 AOI21_X1
* cell instance $27909 r0 *1 206.72,193.2
X$27909 14447 14446 10046 14039 14202 14060 113 112 AOI221_X2
* cell instance $27911 r0 *1 209.19,193.2
X$27911 14433 14327 13903 14039 112 113 14443 AOI22_X2
* cell instance $27913 r0 *1 211.28,193.2
X$27913 14321 14433 14323 13836 14209 14435 113 112 AOI221_X2
* cell instance $27914 r0 *1 213.37,193.2
X$27914 13972 13918 14316 112 14317 113 AOI21_X1
* cell instance $27915 r0 *1 214.13,193.2
X$27915 14345 14043 112 113 14321 NAND2_X1
* cell instance $27918 r0 *1 215.27,193.2
X$27918 13972 14318 14069 14319 14535 112 113 OAI211_X2
* cell instance $27919 m0 *1 216.22,193.2
X$27919 14122 14215 14212 13918 112 113 14319 AOI22_X1
* cell instance $27921 m0 *1 217.17,193.2
X$27921 13769 13975 14116 113 14320 112 OAI21_X1
* cell instance $27928 r0 *1 217.17,193.2
X$27928 14320 14069 112 113 14438 NAND2_X1
* cell instance $27977 r0 *1 70.49,190.4
X$27977 9691 11064 10648 113 112 14213 OAI21_X4
* cell instance $27980 r0 *1 73.91,190.4
X$27980 9691 112 113 14269 INV_X8
* cell instance $27981 r0 *1 75.62,190.4
X$27981 112 14154 10648 11064 14153 113 NOR3_X4
* cell instance $27982 m0 *1 76.19,190.4
X$27982 10765 113 14127 112 BUF_X4
* cell instance $27985 m0 *1 77.71,190.4
X$27985 112 14159 14267 10913 10914 113 AOI21_X4
* cell instance $27986 m0 *1 80.18,190.4
X$27986 112 14151 113 10913 BUF_X8
* cell instance $27990 r0 *1 80.18,190.4
X$27990 112 14156 113 10914 BUF_X8
* cell instance $27992 m0 *1 83.22,190.4
X$27992 10297 10920 112 14270 113 NAND2_X4
* cell instance $27995 r0 *1 84.17,190.4
X$27995 112 14161 14083 10050 14084 113 AOI21_X4
* cell instance $27996 m0 *1 86.07,190.4
X$27996 10920 10297 113 112 14084 AND2_X1
* cell instance $27997 m0 *1 85.31,190.4
X$27997 13857 11678 13654 112 13886 113 AOI21_X1
* cell instance $27998 m0 *1 86.83,190.4
X$27998 14010 112 113 13948 BUF_X1
* cell instance $28001 m0 *1 88.35,190.4
X$28001 12026 13018 12959 113 14045 112 OAI21_X1
* cell instance $28002 m0 *1 89.11,190.4
X$28002 13018 12026 16498 113 112 14130 HA_X1
* cell instance $28003 m0 *1 91.01,190.4
X$28003 14130 112 113 12967 BUF_X2
* cell instance $28009 r0 *1 88.35,190.4
X$28009 14213 14161 112 113 14328 NOR2_X1
* cell instance $28013 r0 *1 90.25,190.4
X$28013 14331 14268 14158 113 14223 112 OAI21_X1
* cell instance $28015 m0 *1 94.62,190.4
X$28015 9817 10300 113 14085 112 XOR2_X2
* cell instance $28022 r0 *1 98.8,190.4
X$28022 9819 13825 113 14162 112 XOR2_X2
* cell instance $28024 m0 *1 98.99,190.4
X$28024 13825 9819 113 112 14380 XNOR2_X1
* cell instance $28026 m0 *1 101.08,190.4
X$28026 14225 113 5757 112 BUF_X4
* cell instance $28030 m0 *1 107.73,190.4
X$28030 14087 14013 14131 112 113 14049 MUX2_X1
* cell instance $28031 m0 *1 109.06,190.4
X$28031 14063 14013 14133 112 14012 113 AOI21_X1
* cell instance $28035 r0 *1 101.27,190.4
X$28035 112 16995 14227 14226 14086 113 DFF_X1
* cell instance $28036 r0 *1 104.5,190.4
X$28036 14227 113 4655 112 BUF_X4
* cell instance $28038 r0 *1 106.02,190.4
X$28038 14228 14229 13889 113 112 4505 MUX2_X2
* cell instance $28039 r0 *1 107.73,190.4
X$28039 14132 13695 14166 113 14164 112 OAI21_X1
* cell instance $28041 r0 *1 108.68,190.4
X$28041 14088 112 113 14015 CLKBUF_X3
* cell instance $28042 r0 *1 109.63,190.4
X$28042 14089 14088 14277 112 113 14090 MUX2_X1
* cell instance $28043 r0 *1 110.96,190.4
X$28043 14090 13822 14091 112 113 14237 MUX2_X1
* cell instance $28045 m0 *1 110.96,190.4
X$28045 14051 113 13890 112 BUF_X4
* cell instance $28048 m0 *1 114.76,190.4
X$28048 13952 112 113 14088 CLKBUF_X3
* cell instance $28050 m0 *1 116.47,190.4
X$28050 14136 14013 14016 112 113 14056 MUX2_X1
* cell instance $28051 m0 *1 117.8,190.4
X$28051 14137 13889 14056 112 113 7474 MUX2_X1
* cell instance $28053 m0 *1 119.89,190.4
X$28053 14138 13889 14237 112 8147 113 AOI21_X2
* cell instance $28054 m0 *1 121.22,190.4
X$28054 14139 14014 14094 13889 14240 8739 113 112 AOI221_X2
* cell instance $28055 m0 *1 123.31,190.4
X$28055 14097 14098 14051 112 113 NOR2_X4
* cell instance $28056 m0 *1 125.02,190.4
X$28056 14017 14013 14283 14068 14063 113 112 AOI211_X2
* cell instance $28057 m0 *1 126.73,190.4
X$28057 14140 13566 14100 112 113 14099 OR3_X1
* cell instance $28058 m0 *1 127.68,190.4
X$28058 14018 14097 14142 112 113 NOR2_X4
* cell instance $28060 m0 *1 130.91,190.4
X$28060 14000 14019 14018 8862 14020 112 113 14248 AOI221_X1
* cell instance $28062 m0 *1 132.24,190.4
X$28062 14067 224 14097 112 113 NOR2_X4
* cell instance $28064 m0 *1 134.14,190.4
X$28064 14021 3068 14254 112 113 NOR2_X4
* cell instance $28066 m0 *1 136.04,190.4
X$28066 14022 113 14019 112 BUF_X4
* cell instance $28068 m0 *1 137.56,190.4
X$28068 14146 8295 13957 112 113 14103 MUX2_X1
* cell instance $28071 m0 *1 140.6,190.4
X$28071 14023 112 113 13570 CLKBUF_X3
* cell instance $28072 m0 *1 141.55,190.4
X$28072 112 16763 13959 14009 13635 113 DFF_X1
* cell instance $28073 m0 *1 144.78,190.4
X$28073 8299 113 14288 112 BUF_X4
* cell instance $28074 m0 *1 146.11,190.4
X$28074 14008 13893 112 14147 113 NAND2_X4
* cell instance $28077 r0 *1 112.67,190.4
X$28077 14095 113 13695 112 BUF_X4
* cell instance $28080 r0 *1 115.71,190.4
X$28080 14093 14167 14232 112 14135 113 AOI21_X1
* cell instance $28083 r0 *1 117.61,190.4
X$28083 14092 14015 14234 112 14137 113 AOI21_X1
* cell instance $28086 r0 *1 118.94,190.4
X$28086 14171 14088 13824 14235 14233 14138 113 112 AOI221_X2
* cell instance $28089 r0 *1 122.17,190.4
X$28089 14238 14015 14101 112 113 13998 MUX2_X1
* cell instance $28090 r0 *1 123.5,190.4
X$28090 14173 14096 14242 14097 113 112 14241 OAI22_X2
* cell instance $28094 r0 *1 125.21,190.4
X$28094 14098 112 113 14242 BUF_X1
* cell instance $28096 r0 *1 126.16,190.4
X$28096 14095 14099 14243 112 14355 113 AOI21_X1
* cell instance $28097 r0 *1 126.92,190.4
X$28097 14173 14096 14140 14142 13952 113 112 14243 OAI221_X1
* cell instance $28098 r0 *1 128.06,190.4
X$28098 14018 112 113 14098 BUF_X1
* cell instance $28105 r0 *1 130.72,190.4
X$28105 14018 112 113 14250 BUF_X1
* cell instance $28106 r0 *1 131.29,190.4
X$28106 14248 112 113 14253 CLKBUF_X3
* cell instance $28107 r0 *1 132.24,190.4
X$28107 112 14097 14250 14254 14102 14486 113 NOR4_X4
* cell instance $28111 r0 *1 138.32,190.4
X$28111 112 16948 14023 14103 13635 113 DFF_X1
* cell instance $28112 r0 *1 141.55,190.4
X$28112 5121 10709 113 14178 112 XOR2_X2
* cell instance $28114 r0 *1 143.45,190.4
X$28114 5295 13500 113 14259 112 XOR2_X2
* cell instance $28117 r0 *1 145.73,190.4
X$28117 112 14179 113 11075 BUF_X8
* cell instance $28118 r0 *1 148.2,190.4
X$28118 8744 13500 113 14261 112 XOR2_X2
* cell instance $28120 m0 *1 148.2,190.4
X$28120 13500 8744 113 112 14371 XNOR2_X1
* cell instance $28121 m0 *1 149.91,190.4
X$28121 11276 11236 113 112 14148 AND2_X1
* cell instance $28123 m0 *1 150.67,190.4
X$28123 14148 112 113 14104 CLKBUF_X3
* cell instance $28125 m0 *1 153.14,190.4
X$28125 9377 13570 113 14188 112 XOR2_X2
* cell instance $28126 m0 *1 154.85,190.4
X$28126 13570 9377 112 113 14105 XNOR2_X2
* cell instance $28129 m0 *1 158.46,190.4
X$28129 112 14150 13894 17217 9857 113 DFF_X2
* cell instance $28130 m0 *1 162.07,190.4
X$28130 9857 112 113 14080 BUF_X1
* cell instance $28133 r0 *1 150.1,190.4
X$28133 11236 11276 112 14181 113 NAND2_X4
* cell instance $28134 r0 *1 151.81,190.4
X$28134 10584 113 14180 112 BUF_X4
* cell instance $28135 r0 *1 153.14,190.4
X$28135 10584 14181 112 14266 113 NAND2_X4
* cell instance $28139 r0 *1 156.18,190.4
X$28139 14104 113 14182 112 BUF_X4
* cell instance $28142 r0 *1 158.46,190.4
X$28142 10522 14182 112 14264 113 NAND2_X4
* cell instance $28145 r0 *1 162.45,190.4
X$28145 10522 14181 112 113 14185 NAND2_X2
* cell instance $28147 m0 *1 163.02,190.4
X$28147 112 16869 13895 14265 13894 113 DFF_X1
* cell instance $28150 m0 *1 179.93,190.4
X$28150 112 16873 10419 15792 14106 113 DFF_X1
* cell instance $28153 m0 *1 185.44,190.4
X$28153 13967 14026 14025 113 112 14027 OAI21_X4
* cell instance $28155 m0 *1 188.1,190.4
X$28155 112 14026 113 13766 BUF_X8
* cell instance $28157 m0 *1 190.76,190.4
X$28157 14026 14025 13984 112 113 14149 NOR3_X1
* cell instance $28159 m0 *1 191.71,190.4
X$28159 14026 14025 14108 113 13909 112 NOR3_X2
* cell instance $28160 m0 *1 193.04,190.4
X$28160 13837 13834 13978 14149 112 113 14078 AOI22_X1
* cell instance $28164 r0 *1 166.63,190.4
X$28164 10522 112 113 14192 CLKBUF_X3
* cell instance $28169 r0 *1 175.75,190.4
X$28169 112 16960 14258 14687 14106 113 DFF_X1
* cell instance $28170 r0 *1 178.98,190.4
X$28170 14258 112 113 9326 CLKBUF_X3
* cell instance $28175 r0 *1 182.97,190.4
X$28175 14257 112 113 14193 INV_X8
* cell instance $28176 r0 *1 184.68,190.4
X$28176 10516 14081 14082 113 112 14195 OAI21_X4
* cell instance $28177 r0 *1 187.15,190.4
X$28177 112 14257 13765 13766 14134 113 NOR3_X4
* cell instance $28179 r0 *1 190.57,190.4
X$28179 14107 14195 14256 13899 14193 14109 113 112 AOI221_X2
* cell instance $28181 r0 *1 193.42,190.4
X$28181 14027 13651 112 113 14304 NAND2_X1
* cell instance $28194 m0 *1 65.17,201.6
X$28194 112 14886 14662 113 INV_X16
* cell instance $28195 m0 *1 68.4,201.6
X$28195 14846 14930 16495 113 112 14979 HA_X1
* cell instance $28196 m0 *1 70.3,201.6
X$28196 14268 113 14936 112 BUF_X4
* cell instance $28197 m0 *1 71.63,201.6
X$28197 14151 113 14801 112 BUF_X4
* cell instance $28198 m0 *1 72.96,201.6
X$28198 14495 113 14887 112 BUF_X4
* cell instance $28200 m0 *1 74.48,201.6
X$28200 15044 14887 14932 112 14711 113 AOI21_X2
* cell instance $28201 m0 *1 75.81,201.6
X$28201 14151 14156 9691 112 113 14378 NAND3_X2
* cell instance $28202 m0 *1 77.14,201.6
X$28202 14268 112 113 14980 CLKBUF_X3
* cell instance $28203 m0 *1 78.09,201.6
X$28203 14378 14989 112 113 14850 NOR2_X1
* cell instance $28204 m0 *1 78.66,201.6
X$28204 14887 14662 14372 112 14981 113 AOI21_X1
* cell instance $28206 m0 *1 79.61,201.6
X$28206 14886 112 113 14332 INV_X4
* cell instance $28207 m0 *1 80.56,201.6
X$28207 10563 14270 112 113 14933 NOR2_X2
* cell instance $28208 m0 *1 81.51,201.6
X$28208 14375 14800 14933 112 113 14888 NOR3_X1
* cell instance $28209 m0 *1 82.27,201.6
X$28209 15051 14982 14846 113 14938 112 OAI21_X1
* cell instance $28210 m0 *1 83.03,201.6
X$28210 14934 14849 14161 14936 112 113 14935 AOI22_X2
* cell instance $28212 m0 *1 84.93,201.6
X$28212 14983 14889 14717 14546 112 113 14606 AOI22_X1
* cell instance $28214 m0 *1 86.07,201.6
X$28214 14988 14935 14162 14938 14715 14993 113 112 AOI221_X2
* cell instance $28215 m0 *1 88.16,201.6
X$28215 15054 14980 14767 112 113 14986 MUX2_X1
* cell instance $28216 m0 *1 89.49,201.6
X$28216 14939 14378 112 113 14940 NOR2_X1
* cell instance $28217 m0 *1 90.06,201.6
X$28217 14374 14769 112 113 14889 NOR2_X2
* cell instance $28218 m0 *1 91.01,201.6
X$28218 14989 14708 14492 113 112 15060 OAI21_X4
* cell instance $28219 m0 *1 93.48,201.6
X$28219 14712 112 113 14939 INV_X1
* cell instance $28220 m0 *1 93.86,201.6
X$28220 14608 113 14988 112 BUF_X4
* cell instance $28222 m0 *1 95.38,201.6
X$28222 14271 14213 14497 14891 14377 112 113 14942 AOI221_X1
* cell instance $28238 r0 *1 65.36,201.6
X$28238 14800 15098 112 113 14977 NAND2_X1
* cell instance $28239 r0 *1 65.93,201.6
X$28239 15096 112 113 15097 BUF_X1
* cell instance $28240 r0 *1 66.5,201.6
X$28240 10563 112 113 14848 BUF_X1
* cell instance $28241 r0 *1 67.07,201.6
X$28241 14800 112 113 15101 CLKBUF_X3
* cell instance $28245 r0 *1 68.02,201.6
X$28245 14886 113 14934 112 BUF_X4
* cell instance $28246 r0 *1 69.35,201.6
X$28246 10563 14270 14978 112 113 NOR2_X4
* cell instance $28247 r0 *1 71.06,201.6
X$28247 112 14886 113 14978 BUF_X8
* cell instance $28248 r0 *1 73.53,201.6
X$28248 112 15099 15098 14151 14156 113 AOI21_X4
* cell instance $28249 r0 *1 76,201.6
X$28249 14979 113 14154 112 BUF_X4
* cell instance $28251 r0 *1 77.52,201.6
X$28251 112 15171 14547 14151 14156 113 AOI21_X4
* cell instance $28252 r0 *1 79.99,201.6
X$28252 14376 14769 14980 14273 112 113 15172 AOI22_X1
* cell instance $28254 r0 *1 81.32,201.6
X$28254 14664 14934 112 113 15051 NOR2_X1
* cell instance $28256 r0 *1 82.27,201.6
X$28256 14552 14662 112 113 14982 NOR2_X1
* cell instance $28258 r0 *1 83.03,201.6
X$28258 15101 10563 14270 113 112 15211 OAI21_X2
* cell instance $28260 r0 *1 84.74,201.6
X$28260 14888 14989 14984 112 15054 113 AOI21_X1
* cell instance $28261 r0 *1 85.5,201.6
X$28261 14496 14495 112 113 14984 NOR2_X1
* cell instance $28262 r0 *1 86.07,201.6
X$28262 14992 15055 112 113 15102 NAND2_X1
* cell instance $28264 r0 *1 87.4,201.6
X$28264 14273 14981 15060 112 15057 113 AOI21_X1
* cell instance $28265 r0 *1 88.16,201.6
X$28265 14986 15178 14498 14806 15103 14985 113 112 AOI221_X2
* cell instance $28266 r0 *1 90.25,201.6
X$28266 15057 14988 15179 14990 14991 15058 113 112 AOI221_X2
* cell instance $28267 r0 *1 92.34,201.6
X$28267 14127 14085 112 113 15183 NAND2_X2
* cell instance $28268 r0 *1 93.29,201.6
X$28268 14656 14713 15063 113 15185 112 OAI21_X1
* cell instance $28270 r0 *1 94.24,201.6
X$28270 14769 15064 14546 112 15105 113 AOI21_X1
* cell instance $28272 r0 *1 95.38,201.6
X$28272 14856 15185 14890 112 15106 113 AOI21_X1
* cell instance $28274 r0 *1 96.52,201.6
X$28274 14605 14717 14992 113 15186 112 OAI21_X1
* cell instance $28276 m0 *1 96.9,201.6
X$28276 14085 14543 113 112 15066 AND2_X1
* cell instance $28277 m0 *1 97.85,201.6
X$28277 14942 15065 14498 112 113 14805 NOR3_X1
* cell instance $28278 m0 *1 98.61,201.6
X$28278 14160 14943 112 113 14610 NAND2_X1
* cell instance $28279 m0 *1 99.18,201.6
X$28279 14377 14891 112 113 14890 NAND2_X1
* cell instance $28281 r0 *1 97.28,201.6
X$28281 15064 14943 112 113 15108 NOR2_X1
* cell instance $28283 r0 *1 98.04,201.6
X$28283 14993 15187 15067 112 113 14892 OR3_X1
* cell instance $28284 r0 *1 98.99,201.6
X$28284 14859 14655 112 113 14994 NAND2_X1
* cell instance $28287 m0 *1 100.13,201.6
X$28287 14716 14559 14945 14859 16073 14944 112 113 OAI221_X2
* cell instance $28290 m0 *1 104.31,201.6
X$28290 14947 14274 14894 112 15069 113 AOI21_X1
* cell instance $28293 m0 *1 105.26,201.6
X$28293 15069 13822 112 113 15225 NOR2_X1
* cell instance $28294 m0 *1 105.83,201.6
X$28294 14896 14486 14897 112 113 14949 NOR3_X1
* cell instance $28295 m0 *1 106.59,201.6
X$28295 14897 14132 112 113 14947 NOR2_X1
* cell instance $28296 m0 *1 107.16,201.6
X$28296 14173 14096 14132 112 113 15071 NOR3_X1
* cell instance $28300 r0 *1 104.69,201.6
X$28300 14808 13560 13890 112 15109 113 AOI21_X1
* cell instance $28303 r0 *1 106.59,201.6
X$28303 15120 14995 112 113 14867 NOR2_X1
* cell instance $28304 r0 *1 107.16,201.6
X$28304 14995 112 113 15111 BUF_X1
* cell instance $28305 r0 *1 107.73,201.6
X$28305 14623 14895 14501 112 113 14996 NOR3_X1
* cell instance $28307 m0 *1 108.3,201.6
X$28307 14955 14906 14283 14956 14957 113 112 14954 OAI221_X1
* cell instance $28308 m0 *1 109.63,201.6
X$28308 14501 14948 14997 112 14957 113 AOI21_X1
* cell instance $28311 r0 *1 108.49,201.6
X$28311 15073 14475 15113 112 113 14131 MUX2_X1
* cell instance $28312 r0 *1 109.82,201.6
X$28312 14866 15076 113 112 15192 AND2_X2
* cell instance $28313 r0 *1 110.77,201.6
X$28313 14729 14565 14997 112 15115 113 AOI21_X2
* cell instance $28315 m0 *1 114.76,201.6
X$28315 14173 14096 14995 113 14899 112 OAI21_X1
* cell instance $28316 m0 *1 112.29,201.6
X$28316 112 14896 14624 14502 14399 113 AOI21_X4
* cell instance $28317 m0 *1 115.52,201.6
X$28317 14998 14485 14899 113 14959 112 OAI21_X1
* cell instance $28319 m0 *1 117.04,201.6
X$28319 14784 14869 14572 112 113 14901 MUX2_X1
* cell instance $28321 m0 *1 118.56,201.6
X$28321 14963 13561 14901 112 14900 113 AOI21_X1
* cell instance $28323 m0 *1 119.51,201.6
X$28323 14906 14166 112 113 14963 NAND2_X1
* cell instance $28324 m0 *1 120.08,201.6
X$28324 14692 14902 14387 112 14569 113 NAND3_X4
* cell instance $28325 m0 *1 122.55,201.6
X$28325 14167 14875 15084 14900 14905 14968 112 113 14094 OAI33_X1
* cell instance $28326 m0 *1 123.88,201.6
X$28326 13824 15002 15003 113 14172 112 OAI21_X1
* cell instance $28328 m0 *1 124.83,201.6
X$28328 15000 14173 14096 113 112 15091 OAI21_X4
* cell instance $28329 m0 *1 127.3,201.6
X$28329 14810 14731 112 113 14973 OR2_X1
* cell instance $28331 m0 *1 128.25,201.6
X$28331 14971 13824 14972 112 113 14396 MUX2_X1
* cell instance $28332 m0 *1 129.58,201.6
X$28332 14729 14973 14904 113 14971 112 OAI21_X1
* cell instance $28333 m0 *1 130.34,201.6
X$28333 14974 14903 112 113 14905 NAND2_X1
* cell instance $28335 m0 *1 131.1,201.6
X$28335 14623 14169 14730 112 14975 113 AOI21_X1
* cell instance $28337 m0 *1 132.05,201.6
X$28337 14794 14869 14975 112 15006 113 AOI21_X1
* cell instance $28338 m0 *1 132.81,201.6
X$28338 15093 14906 15006 112 14581 113 AOI21_X1
* cell instance $28340 m0 *1 133.76,201.6
X$28340 14486 14624 15008 112 14976 113 AOI21_X1
* cell instance $28342 m0 *1 134.71,201.6
X$28342 14383 14810 112 113 14907 NOR2_X1
* cell instance $28343 m0 *1 135.28,201.6
X$28343 14907 14574 15124 112 113 14880 MUX2_X1
* cell instance $28346 r0 *1 112.48,201.6
X$28346 14399 14140 14502 112 14997 113 NAND3_X4
* cell instance $28347 r0 *1 114.95,201.6
X$28347 14998 113 14999 112 BUF_X4
* cell instance $28348 r0 *1 116.28,201.6
X$28348 14896 15118 14487 112 113 15195 NOR3_X1
* cell instance $28349 r0 *1 117.04,201.6
X$28349 15195 14690 15119 112 15196 113 AOI21_X1
* cell instance $28350 r0 *1 117.8,201.6
X$28350 15233 14384 15196 112 14390 113 AOI21_X1
* cell instance $28351 r0 *1 118.56,201.6
X$28351 15118 15080 14620 112 15121 113 AOI21_X1
* cell instance $28352 r0 *1 119.32,201.6
X$28352 15198 14502 14399 112 14731 113 AOI21_X2
* cell instance $28353 r0 *1 120.65,201.6
X$28353 15000 15120 13824 14095 15121 113 112 15003 OAI221_X1
* cell instance $28354 r0 *1 121.79,201.6
X$28354 14275 15001 14387 113 15201 112 OAI21_X1
* cell instance $28355 r0 *1 122.55,201.6
X$28355 14690 15201 15123 113 14393 112 OAI21_X1
* cell instance $28356 r0 *1 123.31,201.6
X$28356 15005 112 113 14995 BUF_X1
* cell instance $28357 r0 *1 123.88,201.6
X$28357 112 15204 14999 14502 14399 113 AOI21_X4
* cell instance $28362 r0 *1 126.54,201.6
X$28362 15206 14733 14732 113 112 14692 OAI21_X4
* cell instance $28363 r0 *1 129.01,201.6
X$28363 14506 14810 15091 113 15092 112 OAI21_X1
* cell instance $28366 r0 *1 130.15,201.6
X$28366 15004 14384 15092 112 113 14068 MUX2_X1
* cell instance $28367 r0 *1 131.48,201.6
X$28367 112 14383 15005 14000 14019 113 AOI21_X4
* cell instance $28368 r0 *1 133.95,201.6
X$28368 14383 14486 14902 112 113 15007 NOR3_X1
* cell instance $28369 r0 *1 134.71,201.6
X$28369 15007 13956 14389 15094 15093 113 112 AOI211_X2
* cell instance $28370 r0 *1 136.42,201.6
X$28370 14811 15008 14247 112 113 15094 MUX2_X1
* cell instance $28372 m0 *1 143.26,201.6
X$28372 10660 11238 112 14739 113 NAND2_X4
* cell instance $28374 m0 *1 144.97,201.6
X$28374 14908 10660 11238 112 15009 113 AOI21_X2
* cell instance $28375 m0 *1 146.3,201.6
X$28375 14908 113 14817 112 BUF_X4
* cell instance $28376 m0 *1 147.63,201.6
X$28376 14699 14179 14404 113 112 15090 OAI21_X2
* cell instance $28377 m0 *1 148.96,201.6
X$28377 14739 113 14965 112 BUF_X4
* cell instance $28382 r0 *1 145.92,201.6
X$28382 15095 112 113 14795 INV_X8
* cell instance $28383 r0 *1 147.63,201.6
X$28383 14287 113 15095 112 BUF_X4
* cell instance $28384 r0 *1 148.96,201.6
X$28384 15010 8299 15125 112 113 14909 MUX2_X1
* cell instance $28385 r0 *1 150.29,201.6
X$28385 112 14404 15010 14179 15012 113 NOR3_X4
* cell instance $28386 m0 *1 150.86,201.6
X$28386 7211 14179 14404 113 112 14740 OAI21_X2
* cell instance $28389 m0 *1 152.38,201.6
X$28389 15011 14179 14404 113 112 14741 OAI21_X4
* cell instance $28390 m0 *1 154.85,201.6
X$28390 14910 14912 112 113 14911 NOR2_X1
* cell instance $28392 r0 *1 152.95,201.6
X$28392 14483 14628 15012 113 112 15130 OAI21_X2
* cell instance $28393 r0 *1 154.28,201.6
X$28393 15140 15085 14517 112 113 15131 OR3_X1
* cell instance $28394 r0 *1 155.23,201.6
X$28394 15013 14706 112 113 14883 NAND2_X2
* cell instance $28396 m0 *1 155.8,201.6
X$28396 14970 112 113 14969 INV_X1
* cell instance $28398 r0 *1 156.18,201.6
X$28398 15026 15010 112 113 15086 NAND2_X1
* cell instance $28399 r0 *1 156.75,201.6
X$28399 15200 14736 14471 113 15197 112 OAI21_X1
* cell instance $28400 r0 *1 157.51,201.6
X$28400 15014 14516 15125 112 113 14882 NOR3_X1
* cell instance $28401 m0 *1 159.03,201.6
X$28401 14181 112 113 15089 CLKBUF_X3
* cell instance $28402 m0 *1 158.08,201.6
X$28402 14969 14912 14741 14295 113 112 14967 OAI22_X1
* cell instance $28404 r0 *1 158.27,201.6
X$28404 15015 14291 15013 112 14821 113 AOI21_X1
* cell instance $28405 r0 *1 159.03,201.6
X$28405 14295 15090 14594 112 15016 113 AOI21_X1
* cell instance $28406 r0 *1 159.79,201.6
X$28406 15016 15017 14192 112 113 15194 NOR3_X1
* cell instance $28408 m0 *1 160.36,201.6
X$28408 14966 14602 112 113 15017 NOR2_X1
* cell instance $28409 m0 *1 161.12,201.6
X$28409 14817 14965 14884 113 14966 112 OAI21_X1
* cell instance $28412 r0 *1 160.74,201.6
X$28412 14602 15009 15021 15015 14295 15018 112 113 15019 OAI33_X1
* cell instance $28414 m0 *1 162.45,201.6
X$28414 14264 14964 14819 112 14742 113 AOI21_X1
* cell instance $28416 m0 *1 163.21,201.6
X$28416 112 14635 14702 14741 14962 113 AOI21_X4
* cell instance $28417 m0 *1 165.68,201.6
X$28417 14517 14706 14292 112 15081 113 AOI21_X1
* cell instance $28420 m0 *1 167.39,201.6
X$28420 14961 112 113 14960 BUF_X1
* cell instance $28421 m0 *1 167.96,201.6
X$28421 15081 14694 14186 14960 14822 15078 113 112 AOI221_X2
* cell instance $28422 m0 *1 170.05,201.6
X$28422 15079 14186 112 113 14914 NOR2_X1
* cell instance $28423 m0 *1 170.62,201.6
X$28423 14824 14825 14914 15078 15077 14818 112 113 15024 OAI33_X1
* cell instance $28424 m0 *1 171.95,201.6
X$28424 15140 14299 14791 14522 113 112 14915 OAI22_X1
* cell instance $28425 m0 *1 172.9,201.6
X$28425 14190 14817 112 113 15142 NOR2_X1
* cell instance $28426 m0 *1 173.47,201.6
X$28426 14188 14958 14472 112 15075 113 AOI21_X1
* cell instance $28428 r0 *1 162.45,201.6
X$28428 15019 15088 15137 113 14368 112 OAI21_X1
* cell instance $28429 r0 *1 163.21,201.6
X$28429 15087 14489 14191 15020 15086 112 113 15088 AOI221_X1
* cell instance $28430 r0 *1 164.35,201.6
X$28430 15085 14190 112 113 15087 NOR2_X1
* cell instance $28431 r0 *1 164.92,201.6
X$28431 15021 15074 15083 112 15022 113 AOI21_X1
* cell instance $28434 r0 *1 166.25,201.6
X$28434 14592 15022 15020 15082 112 113 15079 AOI22_X2
* cell instance $28436 r0 *1 168.15,201.6
X$28436 14961 112 113 14820 INV_X4
* cell instance $28437 r0 *1 169.1,201.6
X$28437 15026 14636 112 113 15082 NAND2_X1
* cell instance $28439 r0 *1 169.86,201.6
X$28439 15190 15023 15024 112 113 10958 MUX2_X1
* cell instance $28440 r0 *1 171.19,201.6
X$28440 14735 14636 112 113 15139 NOR2_X2
* cell instance $28441 r0 *1 172.14,201.6
X$28441 15188 14407 14260 113 15077 112 OAI21_X1
* cell instance $28442 r0 *1 172.9,201.6
X$28442 14520 15089 15026 112 15025 113 AOI21_X1
* cell instance $28443 r0 *1 173.66,201.6
X$28443 15083 15025 15072 14912 14883 113 112 14958 OAI221_X1
* cell instance $28444 m0 *1 174.8,201.6
X$28444 14965 113 15074 112 BUF_X4
* cell instance $28447 m0 *1 176.32,201.6
X$28447 14917 14301 112 113 14916 NAND2_X1
* cell instance $28449 m0 *1 177.08,201.6
X$28449 14952 14951 14874 14950 113 112 14953 OAI22_X1
* cell instance $28450 m0 *1 178.03,201.6
X$28450 14297 15027 14187 112 113 14950 NAND3_X1
* cell instance $28451 m0 *1 178.79,201.6
X$28451 10299 112 113 14106 CLKBUF_X3
* cell instance $28452 m0 *1 179.74,201.6
X$28452 14106 112 113 17162 INV_X2
* cell instance $28455 m0 *1 187.15,201.6
X$28455 14082 14081 14829 112 113 NOR2_X4
* cell instance $28456 m0 *1 188.86,201.6
X$28456 14082 112 113 15028 BUF_X1
* cell instance $28458 m0 *1 189.62,201.6
X$28458 13919 14748 13833 112 14946 113 AOI21_X1
* cell instance $28459 m0 *1 190.38,201.6
X$28459 14081 112 113 15029 BUF_X1
* cell instance $28460 m0 *1 190.95,201.6
X$28460 14573 14946 113 112 14871 XNOR2_X1
* cell instance $28463 r0 *1 175.18,201.6
X$28463 14915 15137 15027 113 15145 112 OAI21_X1
* cell instance $28464 r0 *1 175.94,201.6
X$28464 14297 112 113 15023 CLKBUF_X3
* cell instance $28465 r0 *1 176.89,201.6
X$28465 15023 14260 112 113 14827 NAND2_X1
* cell instance $28471 r0 *1 185.06,201.6
X$28471 112 14026 14025 15028 14113 15029 113 OAI22_X4
* cell instance $28472 r0 *1 188.29,201.6
X$28472 13967 15029 15028 113 112 14316 OAI21_X2
* cell instance $28474 r0 *1 190,201.6
X$28474 15029 15028 15376 13904 14534 14198 112 113 15068 OAI33_X1
* cell instance $28475 r0 *1 191.33,201.6
X$28475 14026 14025 14338 112 113 15031 NOR3_X1
* cell instance $28477 r0 *1 192.28,201.6
X$28477 15068 15032 14128 112 113 15182 NOR3_X1
* cell instance $28478 m0 *1 192.66,201.6
X$28478 14113 14029 112 113 15030 NAND2_X1
* cell instance $28480 m0 *1 193.23,201.6
X$28480 15030 14205 112 113 15295 NOR2_X1
* cell instance $28482 m0 *1 193.99,201.6
X$28482 14029 14432 14043 112 15032 113 AOI21_X1
* cell instance $28483 m0 *1 194.75,201.6
X$28483 14779 14303 112 113 14529 NOR2_X1
* cell instance $28487 r0 *1 193.23,201.6
X$28487 15030 15031 13911 113 15184 112 OAI21_X1
* cell instance $28489 r0 *1 194.18,201.6
X$28489 15032 15184 112 113 15048 OR2_X1
* cell instance $28491 r0 *1 195.32,201.6
X$28491 14830 15031 15165 112 113 14831 NOR3_X1
* cell instance $28492 r0 *1 196.08,201.6
X$28492 14534 13833 112 113 15056 NOR2_X1
* cell instance $28494 m0 *1 196.46,201.6
X$28494 13901 14311 112 113 15033 NAND2_X1
* cell instance $28496 r0 *1 196.84,201.6
X$28496 15033 14941 113 112 15292 AND2_X1
* cell instance $28497 m0 *1 198.36,201.6
X$28497 14432 14043 14314 112 113 15061 NAND3_X1
* cell instance $28498 m0 *1 197.41,201.6
X$28498 13901 14198 112 113 14647 NAND2_X2
* cell instance $28499 m0 *1 199.12,201.6
X$28499 14861 14918 13785 15059 113 14749 112 NOR4_X2
* cell instance $28500 m0 *1 200.83,201.6
X$28500 14311 14833 14919 14043 112 113 14143 AOI22_X2
* cell instance $28501 m0 *1 202.54,201.6
X$28501 14830 14202 112 113 14919 NOR2_X1
* cell instance $28505 m0 *1 205.58,201.6
X$28505 14029 14053 14787 112 113 14937 OR3_X1
* cell instance $28507 m0 *1 206.72,201.6
X$28507 14573 14204 112 113 14555 NAND2_X1
* cell instance $28508 m0 *1 207.29,201.6
X$28508 14830 14033 112 113 14922 NOR2_X1
* cell instance $28510 m0 *1 208.05,201.6
X$28510 13990 13975 14033 113 14920 112 OAI21_X1
* cell instance $28511 m0 *1 208.81,201.6
X$28511 14205 14920 14834 113 14931 112 OAI21_X1
* cell instance $28512 m0 *1 209.57,201.6
X$28512 13706 13776 112 113 14921 NOR2_X2
* cell instance $28513 m0 *1 210.52,201.6
X$28513 112 14836 15157 15050 14923 13647 113 NAND4_X4
* cell instance $28514 m0 *1 213.94,201.6
X$28514 14839 14435 13839 14925 113 112 14924 OAI22_X2
* cell instance $28515 m0 *1 215.65,201.6
X$28515 14864 14922 14309 14833 112 113 15046 AOI22_X1
* cell instance $28516 m0 *1 216.6,201.6
X$28516 14840 15047 15045 13839 112 113 14926 NOR4_X1
* cell instance $28517 m0 *1 217.55,201.6
X$28517 14926 15037 14921 14839 14126 113 112 14927 OAI221_X1
* cell instance $28518 m0 *1 218.69,201.6
X$28518 14931 14839 13839 113 14928 112 OAI21_X1
* cell instance $28521 r0 *1 197.79,201.6
X$28521 15180 15149 13776 112 113 13793 NAND3_X1
* cell instance $28523 r0 *1 198.74,201.6
X$28523 14864 14779 112 113 15062 NAND2_X1
* cell instance $28524 r0 *1 199.31,201.6
X$28524 15062 15061 14197 15266 14200 15059 113 112 AOI221_X2
* cell instance $28526 r0 *1 201.59,201.6
X$28526 15177 14919 13900 113 15040 112 OAI21_X1
* cell instance $28527 r0 *1 202.35,201.6
X$28527 14197 15035 14070 15175 13716 15170 112 113 OAI221_X2
* cell instance $28528 r0 *1 204.44,201.6
X$28528 14555 15056 15283 13918 113 112 15175 OAI22_X1
* cell instance $28530 r0 *1 205.58,201.6
X$28530 15053 13972 15153 112 13855 113 AOI21_X1
* cell instance $28531 r0 *1 206.34,201.6
X$28531 14937 14845 113 112 15173 AND2_X1
* cell instance $28533 r0 *1 207.29,201.6
X$28533 13972 15154 14921 113 15053 112 OAI21_X1
* cell instance $28535 r0 *1 208.24,201.6
X$28535 13910 14113 15165 112 113 14845 NAND3_X1
* cell instance $28537 r0 *1 209.38,201.6
X$28537 13716 13776 112 113 15156 NOR2_X1
* cell instance $28539 r0 *1 210.14,201.6
X$28539 15170 15049 15490 15167 13776 14923 112 113 OAI221_X2
* cell instance $28541 r0 *1 212.61,201.6
X$28541 14924 15048 14921 112 113 15050 NAND3_X2
* cell instance $28542 r0 *1 213.94,201.6
X$28542 13785 112 113 15164 INV_X1
* cell instance $28543 r0 *1 214.32,201.6
X$28543 14647 15158 15166 15165 15036 15038 113 112 AOI221_X2
* cell instance $28544 r0 *1 216.41,201.6
X$28544 14928 15163 15164 13839 15159 113 112 15043 OAI221_X1
* cell instance $28545 r0 *1 217.55,201.6
X$28545 13837 14539 14043 113 15036 112 OAI21_X1
* cell instance $28546 r0 *1 218.31,201.6
X$28546 15038 15161 15039 112 15162 113 AOI21_X1
* cell instance $28548 r0 *1 219.45,201.6
X$28548 15042 14754 15156 14125 15162 113 112 15041 OAI221_X1
* cell instance $28550 m0 *1 219.83,201.6
X$28550 15043 14927 15041 14843 112 113 14437 NAND4_X1
* cell instance $28555 r0 *1 220.59,201.6
X$28555 15040 14125 112 113 15042 NAND2_X1
* cell instance $28582 m0 *1 107.73,240.8
X$28582 16391 112 113 16390 BUF_X1
* cell instance $28610 r0 *1 37.05,67.2
X$28610 3763 3661 16683 113 112 3712 HA_X1
* cell instance $28612 m0 *1 38.76,67.2
X$28612 3712 112 113 3563 BUF_X2
* cell instance $28615 m0 *1 49.4,67.2
X$28615 2312 112 113 1865 CLKBUF_X3
* cell instance $28616 m0 *1 50.35,67.2
X$28616 2217 1146 16580 113 112 3455 HA_X1
* cell instance $28618 r0 *1 38.95,67.2
X$28618 3563 113 3715 112 BUF_X4
* cell instance $28624 r0 *1 50.73,67.2
X$28624 1899 2094 16606 113 112 3717 HA_X1
* cell instance $28627 m0 *1 52.63,67.2
X$28627 3455 1953 3564 112 113 3716 MUX2_X1
* cell instance $28628 m0 *1 55.48,67.2
X$28628 1953 1807 2776 112 3565 113 AOI21_X1
* cell instance $28630 m0 *1 56.43,67.2
X$28630 3140 2098 2006 113 3663 112 OAI21_X1
* cell instance $28635 r0 *1 54.72,67.2
X$28635 1723 1517 3717 112 113 3662 NOR3_X1
* cell instance $28636 r0 *1 55.48,67.2
X$28636 2098 3565 3662 112 113 3814 OR3_X1
* cell instance $28638 r0 *1 57.19,67.2
X$28638 3716 1898 2092 112 113 3718 NAND3_X1
* cell instance $28640 r0 *1 58.14,67.2
X$28640 3718 3817 2891 112 113 3719 NAND3_X1
* cell instance $28641 r0 *1 58.9,67.2
X$28641 3719 2168 2891 1676 113 112 3664 OAI22_X1
* cell instance $28642 m0 *1 60.04,67.2
X$28642 3321 3615 2891 113 3514 112 OAI21_X1
* cell instance $28643 m0 *1 59.09,67.2
X$28643 3616 3514 3456 2943 113 112 3665 OAI22_X1
* cell instance $28644 m0 *1 60.8,67.2
X$28644 2774 3359 2897 112 3616 113 AOI21_X1
* cell instance $28646 m0 *1 61.75,67.2
X$28646 2834 112 113 2891 CLKBUF_X3
* cell instance $28647 m0 *1 62.7,67.2
X$28647 3099 3566 2092 112 113 3615 NOR3_X1
* cell instance $28649 r0 *1 59.85,67.2
X$28649 1727 113 1871 112 BUF_X4
* cell instance $28651 r0 *1 61.94,67.2
X$28651 1781 1813 3723 112 113 3666 MUX2_X1
* cell instance $28652 r0 *1 63.27,67.2
X$28652 3721 1898 3666 112 3566 113 AOI21_X1
* cell instance $28653 m0 *1 64.03,67.2
X$28653 3354 3517 3516 3143 112 113 3567 NOR4_X1
* cell instance $28655 m0 *1 64.98,67.2
X$28655 1481 2102 2776 112 113 3355 MUX2_X1
* cell instance $28658 r0 *1 64.41,67.2
X$28658 2102 113 1723 112 BUF_X4
* cell instance $28659 r0 *1 65.74,67.2
X$28659 1898 2442 112 113 3770 NOR2_X1
* cell instance $28660 r0 *1 66.31,67.2
X$28660 1727 1725 112 113 3722 OR2_X1
* cell instance $28661 m0 *1 66.88,67.2
X$28661 1871 2093 3518 3358 113 112 3618 AND4_X1
* cell instance $28663 m0 *1 68.02,67.2
X$28663 2442 3522 112 113 3458 OR2_X1
* cell instance $28664 m0 *1 68.78,67.2
X$28664 2728 3051 2220 3617 3360 3618 112 113 3724 OAI33_X1
* cell instance $28665 m0 *1 70.11,67.2
X$28665 3619 3568 112 113 2296 NOR2_X2
* cell instance $28674 r0 *1 71.82,67.2
X$28674 2290 113 1953 112 BUF_X4
* cell instance $28675 m0 *1 72.39,67.2
X$28675 3619 3568 1145 112 113 NOR2_X4
* cell instance $28679 m0 *1 75.81,67.2
X$28679 3526 3771 3568 113 112 2776 OAI21_X4
* cell instance $28682 m0 *1 81.51,67.2
X$28682 3539 3621 113 2834 112 XOR2_X2
* cell instance $28683 m0 *1 83.22,67.2
X$28683 3726 113 1191 112 BUF_X4
* cell instance $28686 m0 *1 85.5,67.2
X$28686 3571 3248 112 113 3569 NOR2_X1
* cell instance $28690 r0 *1 76.38,67.2
X$28690 112 3724 3063 17249 3725 113 DFF_X2
* cell instance $28694 r0 *1 82.46,67.2
X$28694 112 2324 113 3727 BUF_X8
* cell instance $28696 r0 *1 85.69,67.2
X$28696 3569 3668 3570 112 113 3727 MUX2_X1
* cell instance $28697 m0 *1 86.64,67.2
X$28697 3571 3573 112 113 3570 NOR2_X1
* cell instance $28699 m0 *1 87.21,67.2
X$28699 3063 112 113 17153 INV_X2
* cell instance $28700 m0 *1 87.78,67.2
X$28700 3573 112 113 3248 INV_X1
* cell instance $28702 r0 *1 87.02,67.2
X$28702 3728 3668 3823 112 113 3726 MUX2_X1
* cell instance $28703 r0 *1 88.35,67.2
X$28703 189 112 113 3063 CLKBUF_X3
* cell instance $28705 m0 *1 88.54,67.2
X$28705 112 16875 3826 1242 3164 113 DFF_X1
* cell instance $28707 m0 *1 92.72,67.2
X$28707 3574 112 113 3575 CLKBUF_X3
* cell instance $28708 m0 *1 93.67,67.2
X$28708 3575 3626 113 112 3623 XNOR2_X1
* cell instance $28710 m0 *1 95.57,67.2
X$28710 3989 115 113 112 3624 AND2_X1
* cell instance $28712 m0 *1 96.52,67.2
X$28712 112 944 3624 224 3625 113 AOI21_X4
* cell instance $28714 r0 *1 89.3,67.2
X$28714 3873 3573 112 113 3728 NAND2_X1
* cell instance $28717 r0 *1 91.58,67.2
X$28717 112 17045 3827 1741 3164 113 DFF_X1
* cell instance $28721 r0 *1 98.42,67.2
X$28721 3572 3669 113 112 3730 XNOR2_X1
* cell instance $28723 m0 *1 99.37,67.2
X$28723 3628 3731 112 113 3625 XNOR2_X2
* cell instance $28726 r0 *1 99.56,67.2
X$28726 3576 3730 113 112 3731 XNOR2_X1
* cell instance $28729 r0 *1 102.41,67.2
X$28729 3829 3628 112 113 3777 XNOR2_X2
* cell instance $28730 m0 *1 107.16,67.2
X$28730 3461 3629 113 3286 112 XOR2_X2
* cell instance $28731 m0 *1 103.93,67.2
X$28731 112 3629 3463 3667 3070 113 DFF_X1
* cell instance $28735 r0 *1 106.02,67.2
X$28735 3362 3733 112 113 3628 XNOR2_X2
* cell instance $28736 r0 *1 107.92,67.2
X$28736 3670 3775 3286 112 3734 113 AOI21_X1
* cell instance $28737 r0 *1 108.68,67.2
X$28737 209 3530 112 113 3670 NOR2_X1
* cell instance $28739 m0 *1 109.44,67.2
X$28739 112 16770 3631 3630 3464 113 DFF_X1
* cell instance $28741 m0 *1 112.67,67.2
X$28741 3631 112 113 3578 CLKBUF_X3
* cell instance $28742 m0 *1 113.62,67.2
X$28742 187 3633 3465 113 112 3459 MUX2_X2
* cell instance $28744 r0 *1 109.44,67.2
X$28744 112 17144 3671 3734 3464 113 DFF_X1
* cell instance $28745 r0 *1 112.67,67.2
X$28745 189 112 113 3464 CLKBUF_X3
* cell instance $28746 r0 *1 113.62,67.2
X$28746 112 17147 3674 3673 3464 113 DFF_X1
* cell instance $28748 m0 *1 115.71,67.2
X$28748 3576 3777 113 112 3370 XNOR2_X1
* cell instance $28750 r0 *1 116.85,67.2
X$28750 3736 3362 113 406 112 XOR2_X2
* cell instance $28752 m0 *1 117.99,67.2
X$28752 314 3634 3635 113 112 3466 MUX2_X2
* cell instance $28756 r0 *1 119.89,67.2
X$28756 3741 3779 112 2762 113 NAND2_X4
* cell instance $28757 m0 *1 120.27,67.2
X$28757 3739 113 1896 112 BUF_X4
* cell instance $28759 m0 *1 121.6,67.2
X$28759 2764 3579 113 191 112 XOR2_X2
* cell instance $28760 m0 *1 123.31,67.2
X$28760 3258 112 113 3535 BUF_X1
* cell instance $28761 m0 *1 123.88,67.2
X$28761 3639 3742 3675 113 112 3079 OAI21_X4
* cell instance $28762 m0 *1 126.35,67.2
X$28762 112 3676 3580 3641 3288 113 DFF_X1
* cell instance $28763 m0 *1 129.58,67.2
X$28763 3580 316 3642 112 113 3641 MUX2_X1
* cell instance $28764 m0 *1 130.91,67.2
X$28764 3643 3576 113 353 112 XOR2_X2
* cell instance $28766 r0 *1 121.6,67.2
X$28766 3779 3741 113 112 3739 AND2_X1
* cell instance $28769 r0 *1 122.93,67.2
X$28769 3742 3672 112 113 3638 NAND2_X1
* cell instance $28770 r0 *1 123.5,67.2
X$28770 3675 3672 112 113 3537 NAND2_X1
* cell instance $28774 r0 *1 124.07,67.2
X$28774 3676 3646 112 113 3675 NOR2_X2
* cell instance $28775 r0 *1 125.02,67.2
X$28775 3646 3676 113 112 3742 AND2_X1
* cell instance $28778 r0 *1 126.35,67.2
X$28778 3677 113 776 112 BUF_X4
* cell instance $28783 m0 *1 133.19,67.2
X$28783 923 112 113 3782 BUF_X2
* cell instance $28785 m0 *1 133.95,67.2
X$28785 3645 3646 113 405 112 XOR2_X2
* cell instance $28786 m0 *1 135.66,67.2
X$28786 3470 112 113 3645 BUF_X1
* cell instance $28790 m0 *1 136.61,67.2
X$28790 737 3581 113 204 112 XOR2_X2
* cell instance $28794 r0 *1 137.37,67.2
X$28794 112 17020 3840 3837 3288 113 DFF_X1
* cell instance $28795 r0 *1 140.6,67.2
X$28795 3680 3679 113 203 112 XOR2_X2
* cell instance $28796 m0 *1 141.17,67.2
X$28796 112 16764 3471 3582 3288 113 DFF_X1
* cell instance $28800 m0 *1 145.35,67.2
X$28800 3465 3581 112 113 3583 NOR2_X1
* cell instance $28801 m0 *1 145.92,67.2
X$28801 112 16732 3748 1697 2133 113 DFF_X1
* cell instance $28802 m0 *1 149.15,67.2
X$28802 3584 113 2405 112 BUF_X4
* cell instance $28803 m0 *1 150.48,67.2
X$28803 3584 2908 112 113 3472 NOR2_X1
* cell instance $28804 m0 *1 151.05,67.2
X$28804 3472 3585 3584 112 3589 113 AOI21_X2
* cell instance $28806 m0 *1 152.57,67.2
X$28806 2763 112 113 3548 BUF_X1
* cell instance $28807 m0 *1 153.14,67.2
X$28807 2512 2639 2574 112 113 3586 NOR3_X1
* cell instance $28809 m0 *1 154.09,67.2
X$28809 3587 3649 2679 3445 3200 3648 112 113 OAI221_X2
* cell instance $28810 m0 *1 156.18,67.2
X$28810 3473 3590 3588 2746 3687 3475 113 112 AOI221_X2
* cell instance $28812 m0 *1 158.46,67.2
X$28812 3348 2568 3294 112 3654 113 AOI21_X1
* cell instance $28813 m0 *1 159.22,67.2
X$28813 3450 3589 2467 2410 3592 113 112 3552 OAI221_X1
* cell instance $28814 m0 *1 160.36,67.2
X$28814 3291 3590 112 113 3551 NOR2_X1
* cell instance $28816 m0 *1 161.12,67.2
X$28816 3561 3592 2576 2885 3657 113 112 3476 OAI221_X1
* cell instance $28817 m0 *1 162.26,67.2
X$28817 2640 2914 2684 113 3593 112 OAI21_X1
* cell instance $28818 m0 *1 163.02,67.2
X$28818 112 3348 113 3591 BUF_X8
* cell instance $28820 m0 *1 165.68,67.2
X$28820 112 2574 113 2357 BUF_X8
* cell instance $28821 m0 *1 168.15,67.2
X$28821 2577 2914 113 112 3691 AND2_X1
* cell instance $28822 m0 *1 168.91,67.2
X$28822 3008 3594 3209 113 3558 112 OAI21_X1
* cell instance $28823 m0 *1 169.67,67.2
X$28823 2913 3006 2465 113 3595 112 OAI21_X1
* cell instance $28824 m0 *1 170.43,67.2
X$28824 3595 3659 2684 113 3484 112 OAI21_X1
* cell instance $28825 m0 *1 171.19,67.2
X$28825 2918 3660 3481 112 3555 113 AOI21_X1
* cell instance $28827 r0 *1 142.31,67.2
X$28827 126 3783 112 113 3681 NOR2_X1
* cell instance $28830 r0 *1 144.02,67.2
X$28830 3581 112 113 3682 INV_X1
* cell instance $28832 r0 *1 144.59,67.2
X$28832 198 3678 3682 112 113 3746 NOR3_X1
* cell instance $28833 r0 *1 145.35,67.2
X$28833 3746 198 3583 112 3110 113 AOI21_X2
* cell instance $28834 r0 *1 146.68,67.2
X$28834 112 3747 113 3748 BUF_X8
* cell instance $28836 r0 *1 149.53,67.2
X$28836 3960 2647 3683 2643 3684 3685 112 113 OAI221_X2
* cell instance $28837 r0 *1 151.62,67.2
X$28837 3594 2568 3198 2357 112 113 3684 NAND4_X1
* cell instance $28839 r0 *1 152.76,67.2
X$28839 3749 3847 3685 3586 2576 3754 113 112 AOI221_X2
* cell instance $28840 r0 *1 154.85,67.2
X$28840 3890 112 113 3474 BUF_X1
* cell instance $28841 r0 *1 155.42,67.2
X$28841 3686 3587 112 113 3849 NAND2_X1
* cell instance $28842 r0 *1 155.99,67.2
X$28842 2568 2913 112 113 3649 NAND2_X1
* cell instance $28843 r0 *1 156.56,67.2
X$28843 3649 3688 112 113 3749 NAND2_X1
* cell instance $28844 r0 *1 157.13,67.2
X$28844 2568 3590 112 113 3686 NAND2_X1
* cell instance $28845 r0 *1 157.7,67.2
X$28845 2566 2803 112 113 3688 NAND2_X1
* cell instance $28847 r0 *1 158.46,67.2
X$28847 3689 2912 3654 2757 2465 3753 112 113 OAI221_X2
* cell instance $28849 r0 *1 160.74,67.2
X$28849 3698 2577 3112 112 113 3690 MUX2_X1
* cell instance $28851 r0 *1 162.45,67.2
X$28851 3755 3593 3754 3295 3477 2756 112 113 3752 OAI33_X1
* cell instance $28853 r0 *1 163.97,67.2
X$28853 4058 3211 2885 112 113 3658 NAND3_X1
* cell instance $28855 r0 *1 165.11,67.2
X$28855 3658 3691 2684 2683 3758 3759 113 112 AOI221_X2
* cell instance $28859 r0 *1 168.53,67.2
X$28859 3201 3113 3005 112 113 3694 NAND3_X1
* cell instance $28863 r0 *1 170.62,67.2
X$28863 3010 2974 3844 3116 3789 3693 112 113 3692 OAI33_X1
* cell instance $28864 r0 *1 171.95,67.2
X$28864 3694 2574 112 113 3693 NOR2_X1
* cell instance $28865 m0 *1 173.47,67.2
X$28865 3384 112 113 3271 BUF_X2
* cell instance $28866 m0 *1 172.33,67.2
X$28866 2472 3085 3291 3006 3447 112 113 3655 AOI221_X1
* cell instance $28867 m0 *1 174.23,67.2
X$28867 3697 2976 112 113 3562 NOR2_X1
* cell instance $28869 r0 *1 172.52,67.2
X$28869 3588 2354 3760 112 2968 113 AOI21_X1
* cell instance $28870 r0 *1 173.28,67.2
X$28870 3761 3200 112 113 3791 NAND2_X1
* cell instance $28872 r0 *1 174.04,67.2
X$28872 2866 3694 2918 3479 3695 113 112 3696 OAI221_X1
* cell instance $28873 m0 *1 175.37,67.2
X$28873 3594 2913 112 113 3596 NAND2_X1
* cell instance $28876 m0 *1 176.13,67.2
X$28876 3294 3558 2680 3596 3597 112 113 3598 AOI221_X1
* cell instance $28877 m0 *1 177.27,67.2
X$28877 3598 3655 112 113 3656 OR2_X1
* cell instance $28878 m0 *1 178.03,67.2
X$28878 112 3116 3483 3484 3599 3014 113 OAI22_X4
* cell instance $28879 m0 *1 181.26,67.2
X$28879 3485 3387 3600 112 3653 113 AOI21_X2
* cell instance $28881 m0 *1 182.78,67.2
X$28881 3652 2359 3653 3488 113 3651 112 NOR4_X2
* cell instance $28882 m0 *1 184.49,67.2
X$28882 112 16856 3650 3651 3264 113 DFF_X1
* cell instance $28883 m0 *1 187.72,67.2
X$28883 112 3442 113 3650 BUF_X8
* cell instance $28884 m0 *1 190.19,67.2
X$28884 3264 112 113 16470 CLKBUF_X1
* cell instance $28889 r0 *1 175.18,67.2
X$28889 3005 3657 3594 112 3756 113 AOI21_X1
* cell instance $28891 r0 *1 176.32,67.2
X$28891 2639 3657 2404 112 3757 113 AOI21_X1
* cell instance $28892 r0 *1 177.08,67.2
X$28892 3697 3294 112 113 3597 NOR2_X1
* cell instance $28893 r0 *1 177.65,67.2
X$28893 3756 3211 3291 3687 3698 112 113 3699 AOI221_X1
* cell instance $28895 r0 *1 179.17,67.2
X$28895 112 3599 3793 3390 3790 3751 113 OAI22_X4
* cell instance $28899 r0 *1 182.4,67.2
X$28899 3212 3752 3486 3700 113 3701 112 NOR4_X2
* cell instance $28903 r0 *1 189.05,67.2
X$28903 401 112 113 3264 CLKBUF_X3
* cell instance $28904 r0 *1 190,67.2
X$28904 112 16953 3702 3750 3264 113 DFF_X1
* cell instance $28907 m0 *1 196.65,67.2
X$28907 3703 3576 113 2248 112 XOR2_X2
* cell instance $28911 r0 *1 197.22,67.2
X$28911 3576 3703 112 113 2811 XNOR2_X2
* cell instance $28912 m0 *1 198.93,67.2
X$28912 3601 2480 3332 112 113 3261 MUX2_X1
* cell instance $28914 m0 *1 200.26,67.2
X$28914 2264 2248 2810 3602 112 113 3604 NOR4_X1
* cell instance $28915 m0 *1 201.21,67.2
X$28915 2374 2626 112 113 3603 NAND2_X1
* cell instance $28916 m0 *1 201.78,67.2
X$28916 3494 3603 3604 2260 2251 112 113 3647 AOI221_X1
* cell instance $28917 m0 *1 202.92,67.2
X$28917 2814 2811 112 113 3121 NOR2_X2
* cell instance $28918 m0 *1 203.87,67.2
X$28918 2374 2626 2138 112 113 3546 NOR3_X1
* cell instance $28920 r0 *1 199.12,67.2
X$28920 2811 113 2374 112 BUF_X4
* cell instance $28921 r0 *1 200.45,67.2
X$28921 3490 3515 3215 3740 113 3750 112 NOR4_X2
* cell instance $28923 r0 *1 202.35,67.2
X$28923 112 2260 2480 3705 3704 113 AOI21_X4
* cell instance $28924 r0 *1 204.82,67.2
X$28924 1870 3705 3704 112 3022 113 AOI21_X2
* cell instance $28925 m0 *1 206.15,67.2
X$28925 3222 3602 112 113 3492 NOR2_X1
* cell instance $28926 m0 *1 205.01,67.2
X$28926 2480 3542 2814 3336 3493 112 113 3644 AOI221_X1
* cell instance $28927 m0 *1 206.72,67.2
X$28927 3644 2814 2842 112 3640 113 AOI21_X2
* cell instance $28928 m0 *1 208.05,67.2
X$28928 3636 3393 2927 113 3605 112 OAI21_X1
* cell instance $28929 m0 *1 208.81,67.2
X$28929 3632 2842 112 113 3745 NOR2_X1
* cell instance $28930 m0 *1 209.38,67.2
X$28930 3495 3336 3393 2156 3743 3637 113 112 AOI221_X2
* cell instance $28931 m0 *1 211.47,67.2
X$28931 3744 2369 2146 112 3636 113 AOI21_X1
* cell instance $28933 m0 *1 212.42,67.2
X$28933 2695 3150 3045 2596 2370 113 112 3798 OAI221_X1
* cell instance $28934 m0 *1 213.56,67.2
X$28934 2264 3021 112 113 3606 NOR2_X2
* cell instance $28936 r0 *1 206.15,67.2
X$28936 3705 3704 2282 112 113 2704 NAND3_X2
* cell instance $28938 r0 *1 207.67,67.2
X$28938 3640 2262 3605 3745 3234 4116 113 112 AOI221_X2
* cell instance $28939 r0 *1 209.76,67.2
X$28939 2141 3705 3704 112 3324 113 AOI21_X2
* cell instance $28942 r0 *1 211.66,67.2
X$28942 2156 2256 2704 112 3744 113 AOI21_X1
* cell instance $28943 r0 *1 212.42,67.2
X$28943 3027 3332 3121 2253 2492 113 112 4225 OAI221_X1
* cell instance $28945 r0 *1 213.75,67.2
X$28945 3606 2044 112 113 3743 NOR2_X1
* cell instance $28947 r0 *1 214.51,67.2
X$28947 3311 3902 3738 112 3740 113 AOI21_X1
* cell instance $28948 m0 *1 215.46,67.2
X$28948 2720 1870 112 113 3607 NOR2_X1
* cell instance $28949 m0 *1 214.89,67.2
X$28949 2846 3500 112 113 3311 NAND2_X1
* cell instance $28950 m0 *1 216.03,67.2
X$28950 3336 3608 2705 3026 112 113 3632 AOI22_X1
* cell instance $28952 m0 *1 217.17,67.2
X$28952 2274 2626 112 113 3608 NOR2_X1
* cell instance $28954 m0 *1 217.93,67.2
X$28954 2695 1863 2705 112 113 3609 NOR3_X1
* cell instance $28955 m0 *1 218.69,67.2
X$28955 2047 2700 2146 112 113 3627 NOR3_X1
* cell instance $28956 m0 *1 219.45,67.2
X$28956 3422 3425 112 113 3499 NOR2_X1
* cell instance $28957 m0 *1 220.02,67.2
X$28957 112 1861 2607 113 BUF_X16
* cell instance $28958 m0 *1 224.77,67.2
X$28958 3620 3524 2603 112 3622 113 AOI21_X1
* cell instance $28960 r0 *1 215.27,67.2
X$28960 3324 3607 2596 112 113 3737 NOR3_X1
* cell instance $28961 r0 *1 216.03,67.2
X$28961 3735 3737 2926 113 3738 112 OAI21_X1
* cell instance $28962 r0 *1 216.79,67.2
X$28962 3606 2398 3027 112 113 3735 NOR3_X1
* cell instance $28965 r0 *1 218.5,67.2
X$28965 2503 3606 2146 113 3732 112 OAI21_X1
* cell instance $28967 r0 *1 219.45,67.2
X$28967 2257 1863 3606 112 113 3825 NOR3_X1
* cell instance $28968 r0 *1 220.21,67.2
X$28968 3627 3609 3425 112 113 3706 NOR3_X1
* cell instance $28970 r0 *1 221.35,67.2
X$28970 3732 3499 3800 3398 2823 3820 113 112 AOI221_X2
* cell instance $28971 r0 *1 223.44,67.2
X$28971 2282 2253 2370 3805 113 112 3729 OAI22_X1
* cell instance $28972 r0 *1 224.39,67.2
X$28972 3147 3729 3398 112 3707 113 AOI21_X1
* cell instance $28974 m0 *1 226.1,67.2
X$28974 3065 3147 112 113 3519 NAND2_X1
* cell instance $28977 m0 *1 226.86,67.2
X$28977 3610 2928 3500 2262 3504 113 112 3520 OAI221_X1
* cell instance $28978 m0 *1 228,67.2
X$28978 2257 2492 112 113 3709 NAND2_X1
* cell instance $28979 m0 *1 228.57,67.2
X$28979 3611 2595 112 113 3505 NAND2_X1
* cell instance $28981 m0 *1 229.33,67.2
X$28981 3507 3512 3306 113 3515 112 NOR3_X2
* cell instance $28984 r0 *1 226.1,67.2
X$28984 2253 1866 112 113 3819 NOR2_X1
* cell instance $28985 r0 *1 226.67,67.2
X$28985 2498 1866 112 113 3708 NAND2_X1
* cell instance $28986 r0 *1 227.24,67.2
X$28986 2588 3708 3709 112 3610 113 AOI21_X2
* cell instance $28987 r0 *1 228.57,67.2
X$28987 2705 3042 2256 112 3611 113 AOI21_X1
* cell instance $28988 r0 *1 229.33,67.2
X$28988 2704 2256 113 112 3710 AND2_X1
* cell instance $28989 r0 *1 230.09,67.2
X$28989 2251 2498 112 113 3720 NAND2_X1
* cell instance $28990 r0 *1 230.66,67.2
X$28990 3543 2374 112 113 3711 NAND2_X1
* cell instance $28991 m0 *1 231.23,67.2
X$28991 3508 3234 2588 3714 3614 113 112 AOI211_X2
* cell instance $28993 m0 *1 232.94,67.2
X$28993 3510 2846 3506 112 113 3613 NOR3_X1
* cell instance $28996 r0 *1 231.23,67.2
X$28996 2492 2626 3807 112 113 3714 MUX2_X1
* cell instance $28999 r0 *1 233.13,67.2
X$28999 3613 3614 3034 113 3713 112 NOR3_X2
* cell instance $29027 m0 *1 45.79,64.4
X$29027 2506 112 113 2093 CLKBUF_X3
* cell instance $29028 m0 *1 44.84,64.4
X$29028 1905 112 113 2098 CLKBUF_X3
* cell instance $29030 m0 *1 46.93,64.4
X$29030 2092 1113 1952 112 113 3350 NAND3_X1
* cell instance $29034 r0 *1 45.79,64.4
X$29034 1584 1781 112 113 3453 NOR2_X1
* cell instance $29035 r0 *1 46.36,64.4
X$29035 2536 2098 2217 2096 3453 113 112 3454 OAI221_X1
* cell instance $29036 r0 *1 47.5,64.4
X$29036 3509 3350 3454 1871 112 113 3406 NAND4_X1
* cell instance $29037 m0 *1 48.26,64.4
X$29037 3406 3277 2891 112 113 3351 NAND3_X1
* cell instance $29039 m0 *1 49.02,64.4
X$29039 3278 1476 1899 1115 2442 113 112 3509 OAI221_X1
* cell instance $29040 m0 *1 50.16,64.4
X$29040 3407 3137 3280 3409 2891 2709 112 113 OAI221_X2
* cell instance $29042 m0 *1 53.01,64.4
X$29042 1146 2784 2776 2096 113 112 3409 OAI22_X1
* cell instance $29043 m0 *1 53.96,64.4
X$29043 2657 1905 112 113 3280 NAND2_X1
* cell instance $29046 r0 *1 49.97,64.4
X$29046 2657 113 2312 112 BUF_X4
* cell instance $29047 r0 *1 51.3,64.4
X$29047 2098 3511 112 113 2890 OR2_X1
* cell instance $29048 r0 *1 52.06,64.4
X$29048 1781 2784 3455 2096 112 113 3511 AOI22_X1
* cell instance $29050 r0 *1 54.53,64.4
X$29050 1522 112 113 2442 CLKBUF_X3
* cell instance $29051 m0 *1 55.1,64.4
X$29051 3280 3564 2313 112 3410 113 AOI21_X1
* cell instance $29054 r0 *1 55.48,64.4
X$29054 1517 112 113 2006 CLKBUF_X3
* cell instance $29056 m0 *1 56.24,64.4
X$29056 112 1865 2161 3768 3136 3411 3351 3413 113 AOI222_X2
* cell instance $29058 m0 *1 59.85,64.4
X$29058 1865 2779 3412 112 3413 113 AOI21_X1
* cell instance $29060 m0 *1 60.8,64.4
X$29060 3417 3184 2834 3457 3096 112 113 3412 AOI221_X1
* cell instance $29062 m0 *1 62.13,64.4
X$29062 3001 988 1350 112 3417 113 AOI21_X1
* cell instance $29066 r0 *1 57,64.4
X$29066 2006 2991 2220 112 3352 113 AOI21_X1
* cell instance $29067 r0 *1 57.76,64.4
X$29067 2221 113 2220 112 BUF_X4
* cell instance $29068 r0 *1 59.09,64.4
X$29068 3359 2897 2774 2220 3095 3456 113 112 AOI221_X2
* cell instance $29070 r0 *1 61.56,64.4
X$29070 2006 112 113 2774 CLKBUF_X3
* cell instance $29072 r0 *1 62.7,64.4
X$29072 2774 1865 2891 2315 113 112 3516 AND4_X1
* cell instance $29073 m0 *1 63.84,64.4
X$29073 3353 2170 2413 3418 3187 3283 112 113 3354 OAI33_X1
* cell instance $29074 m0 *1 63.27,64.4
X$29074 2834 2093 112 113 3353 NAND2_X1
* cell instance $29075 m0 *1 65.17,64.4
X$29075 1572 2094 1313 112 3356 113 AOI21_X1
* cell instance $29076 m0 *1 65.93,64.4
X$29076 3357 1879 1871 112 113 3418 NOR3_X1
* cell instance $29077 m0 *1 66.69,64.4
X$29077 2221 2312 112 113 3151 NAND2_X1
* cell instance $29078 m0 *1 67.26,64.4
X$29078 3420 1572 2442 2217 3355 113 112 3358 OAI221_X1
* cell instance $29079 m0 *1 68.4,64.4
X$29079 2102 2296 112 113 2536 NAND2_X2
* cell instance $29080 m0 *1 69.35,64.4
X$29080 2940 3282 3423 113 3360 112 OAI21_X1
* cell instance $29082 r0 *1 63.84,64.4
X$29082 1522 2006 112 113 3457 NOR2_X1
* cell instance $29083 r0 *1 64.41,64.4
X$29083 1115 1807 2098 1899 3356 113 112 3518 OAI221_X1
* cell instance $29084 r0 *1 65.55,64.4
X$29084 3355 1584 2217 112 113 3357 NOR3_X1
* cell instance $29085 r0 *1 66.31,64.4
X$29085 2220 2093 2504 2774 113 3517 112 NOR4_X2
* cell instance $29091 r0 *1 68.59,64.4
X$29091 2774 2093 3458 1586 113 112 3617 AND4_X2
* cell instance $29092 r0 *1 69.92,64.4
X$29092 3323 1350 3521 112 113 3522 MUX2_X1
* cell instance $29094 m0 *1 70.49,64.4
X$29094 3323 3284 2834 3410 3285 112 113 3423 AOI221_X1
* cell instance $29096 r0 *1 72.01,64.4
X$29096 1349 1528 2296 112 113 3521 MUX2_X1
* cell instance $29097 m0 *1 72.2,64.4
X$29097 2412 113 2657 112 BUF_X4
* cell instance $29100 m0 *1 73.72,64.4
X$29100 2657 3424 2730 112 113 3359 OR3_X4
* cell instance $29101 m0 *1 75.81,64.4
X$29101 3189 3100 1647 3191 3361 112 113 3424 AOI221_X1
* cell instance $29105 r0 *1 73.91,64.4
X$29105 1528 113 2102 112 BUF_X4
* cell instance $29107 r0 *1 76,64.4
X$29107 1528 1425 112 113 3361 NAND2_X1
* cell instance $29109 r0 *1 76.76,64.4
X$29109 112 1646 113 3526 BUF_X8
* cell instance $29111 m0 *1 77.33,64.4
X$29111 1647 2290 112 113 3001 NAND2_X2
* cell instance $29113 m0 *1 78.66,64.4
X$29113 112 1479 2324 2231 2784 113 NOR3_X4
* cell instance $29114 r0 *1 79.23,64.4
X$29114 1729 112 113 3526 INV_X2
* cell instance $29118 r0 *1 81.13,64.4
X$29118 3621 3539 112 113 2221 XNOR2_X2
* cell instance $29120 m0 *1 81.7,64.4
X$29120 3325 3246 112 2231 113 NAND2_X4
* cell instance $29121 m0 *1 84.17,64.4
X$29121 3369 3459 112 113 2412 XNOR2_X2
* cell instance $29122 m0 *1 86.07,64.4
X$29122 261 3527 3248 112 113 3325 NAND3_X2
* cell instance $29123 m0 *1 87.4,64.4
X$29123 3466 3362 113 1647 112 XOR2_X2
* cell instance $29125 m0 *1 92.15,64.4
X$29125 3363 3427 113 112 3328 XNOR2_X1
* cell instance $29128 m0 *1 94.24,64.4
X$29128 112 16901 3428 611 3164 113 DFF_X1
* cell instance $29134 r0 *1 84.36,64.4
X$29134 3459 3369 113 2506 112 XOR2_X2
* cell instance $29137 r0 *1 87.02,64.4
X$29137 3362 3466 112 113 2173 XNOR2_X2
* cell instance $29139 r0 *1 89.3,64.4
X$29139 112 17131 3574 1045 3164 113 DFF_X1
* cell instance $29145 r0 *1 98.42,64.4
X$29145 112 3528 3070 17257 3460 113 DFF_X2
* cell instance $29147 m0 *1 101.08,64.4
X$29147 3362 3669 112 113 3430 XOR2_X1
* cell instance $29149 m0 *1 102.41,64.4
X$29149 123 3335 3430 112 113 3364 MUX2_X1
* cell instance $29153 r0 *1 102.41,64.4
X$29153 112 17150 3366 3364 3070 113 DFF_X1
* cell instance $29155 m0 *1 104.88,64.4
X$29155 3367 3431 112 113 3432 XNOR2_X2
* cell instance $29157 m0 *1 107.73,64.4
X$29157 3368 3286 113 112 3003 XNOR2_X1
* cell instance $29159 m0 *1 109.06,64.4
X$29159 131 3335 3529 112 113 3630 MUX2_X1
* cell instance $29162 r0 *1 105.64,64.4
X$29162 3366 112 113 3362 CLKBUF_X3
* cell instance $29163 r0 *1 106.59,64.4
X$29163 3461 3462 113 112 3427 XNOR2_X1
* cell instance $29164 r0 *1 107.73,64.4
X$29164 3368 3463 113 112 3462 XNOR2_X1
* cell instance $29166 r0 *1 109.06,64.4
X$29166 3578 3463 112 113 3529 XOR2_X1
* cell instance $29168 m0 *1 111.72,64.4
X$29168 3194 3435 112 113 3434 XNOR2_X2
* cell instance $29170 m0 *1 113.62,64.4
X$29170 3436 3368 113 177 112 XOR2_X2
* cell instance $29174 r0 *1 112.86,64.4
X$29174 149 3530 112 113 3577 NOR2_X1
* cell instance $29176 r0 *1 113.62,64.4
X$29176 3464 112 113 17185 INV_X2
* cell instance $29177 r0 *1 114.19,64.4
X$29177 3531 3369 113 137 112 XOR2_X2
* cell instance $29178 m0 *1 115.9,64.4
X$29178 258 3105 3370 112 113 3467 MUX2_X1
* cell instance $29182 r0 *1 115.9,64.4
X$29182 112 17140 3534 3467 3464 113 DFF_X1
* cell instance $29184 m0 *1 118.37,64.4
X$29184 112 224 113 3068 BUF_X8
* cell instance $29187 r0 *1 119.51,64.4
X$29187 3534 113 3576 112 BUF_X4
* cell instance $29190 r0 *1 121.41,64.4
X$29190 3535 3468 2021 112 113 NOR2_X4
* cell instance $29191 m0 *1 122.17,64.4
X$29191 112 1543 1126 3371 2677 3259 113 OAI211_X4
* cell instance $29195 r0 *1 123.12,64.4
X$29195 3468 112 113 3371 BUF_X1
* cell instance $29196 r0 *1 123.69,64.4
X$29196 3537 3638 112 3468 113 NAND2_X4
* cell instance $29201 r0 *1 125.78,64.4
X$29201 527 3538 3438 113 112 3539 MUX2_X2
* cell instance $29203 m0 *1 126.54,64.4
X$29203 112 3260 1543 113 BUF_X16
* cell instance $29205 m0 *1 133,64.4
X$29205 112 3373 113 3372 BUF_X8
* cell instance $29206 m0 *1 135.47,64.4
X$29206 420 3374 3438 113 112 3344 MUX2_X2
* cell instance $29207 m0 *1 137.18,64.4
X$29207 3375 4407 113 146 112 XOR2_X2
* cell instance $29209 m0 *1 139.65,64.4
X$29209 3367 3440 112 113 2071 XNOR2_X2
* cell instance $29210 m0 *1 141.55,64.4
X$29210 3439 112 113 3376 BUF_X2
* cell instance $29216 m0 *1 156.94,64.4
X$29216 2518 2467 3293 113 3349 112 OAI21_X1
* cell instance $29217 m0 *1 157.7,64.4
X$29217 2884 2914 2465 112 113 3293 NAND3_X1
* cell instance $29219 m0 *1 158.65,64.4
X$29219 2405 2464 2981 112 113 3550 NOR3_X1
* cell instance $29220 m0 *1 159.41,64.4
X$29220 3291 2643 3348 112 113 3381 NAND3_X1
* cell instance $29221 m0 *1 160.17,64.4
X$29221 3382 3450 2360 113 3380 112 OAI21_X1
* cell instance $29222 m0 *1 160.93,64.4
X$29222 2577 3381 3297 112 3379 113 AOI21_X1
* cell instance $29223 m0 *1 161.69,64.4
X$29223 2570 2467 3377 113 112 3452 OAI21_X2
* cell instance $29224 m0 *1 163.02,64.4
X$29224 2463 2357 112 113 3211 NAND2_X2
* cell instance $29225 m0 *1 163.97,64.4
X$29225 2760 112 113 3007 INV_X1
* cell instance $29226 m0 *1 164.35,64.4
X$29226 112 3270 2689 3292 3384 113 NOR3_X4
* cell instance $29227 m0 *1 167.01,64.4
X$29227 2471 2685 3203 113 3383 112 OAI21_X1
* cell instance $29229 m0 *1 167.96,64.4
X$29229 2797 2467 3296 113 3560 112 OAI21_X1
* cell instance $29236 r0 *1 130.91,64.4
X$29236 3373 3469 113 112 3538 XNOR2_X1
* cell instance $29238 r0 *1 132.81,64.4
X$29238 112 2350 3288 17246 3470 113 DFF_X2
* cell instance $29239 r0 *1 136.42,64.4
X$29239 3288 112 113 16479 CLKBUF_X1
* cell instance $29240 r0 *1 136.99,64.4
X$29240 189 112 113 3288 CLKBUF_X3
* cell instance $29242 r0 *1 138.13,64.4
X$29242 355 3994 3489 113 112 3440 MUX2_X2
* cell instance $29244 r0 *1 140.22,64.4
X$29244 3440 3367 113 1560 112 XOR2_X2
* cell instance $29246 r0 *1 142.12,64.4
X$29246 3376 3541 113 359 112 XOR2_X2
* cell instance $29247 r0 *1 143.83,64.4
X$29247 3471 112 113 3194 CLKBUF_X3
* cell instance $29251 r0 *1 146.87,64.4
X$29251 3290 112 113 3680 BUF_X2
* cell instance $29256 r0 *1 150.48,64.4
X$29256 3291 2643 112 113 3544 NAND2_X1
* cell instance $29257 r0 *1 151.05,64.4
X$29257 3472 3198 2405 112 3547 113 AOI21_X2
* cell instance $29258 r0 *1 152.38,64.4
X$29258 3478 3544 2403 3547 2639 3545 112 113 OAI221_X2
* cell instance $29259 r0 *1 154.47,64.4
X$29259 3292 3270 3548 113 3473 112 NOR3_X2
* cell instance $29260 r0 *1 155.8,64.4
X$29260 3589 2803 3550 3551 3348 3377 113 112 AOI221_X2
* cell instance $29261 r0 *1 157.89,64.4
X$29261 3379 3545 3378 3475 3380 2287 113 112 AOI221_X2
* cell instance $29262 r0 *1 159.98,64.4
X$29262 3473 113 2642 112 BUF_X4
* cell instance $29263 r0 *1 161.31,64.4
X$29263 2643 2357 112 113 3382 NOR2_X2
* cell instance $29264 r0 *1 162.26,64.4
X$29264 2683 3552 3476 113 112 3477 AND3_X1
* cell instance $29265 r0 *1 163.21,64.4
X$29265 3292 3270 2689 113 2917 112 OAI21_X1
* cell instance $29266 r0 *1 163.97,64.4
X$29266 2975 113 3478 112 BUF_X4
* cell instance $29267 r0 *1 165.3,64.4
X$29267 3474 113 2757 112 BUF_X4
* cell instance $29268 r0 *1 166.63,64.4
X$29268 3203 3450 112 113 3559 NAND2_X1
* cell instance $29269 r0 *1 167.2,64.4
X$29269 3296 3383 3479 3382 3560 113 112 3660 OAI221_X1
* cell instance $29270 r0 *1 168.34,64.4
X$29270 3180 2576 3559 113 3758 112 OAI21_X1
* cell instance $29271 m0 *1 169.29,64.4
X$29271 2804 2797 3385 113 3346 112 OAI21_X1
* cell instance $29273 m0 *1 170.05,64.4
X$29273 3340 3561 112 113 3010 NOR2_X1
* cell instance $29274 m0 *1 170.62,64.4
X$29274 3298 3006 3346 112 113 3345 MUX2_X1
* cell instance $29276 m0 *1 172.14,64.4
X$29276 3210 3300 3343 113 112 3449 OAI21_X2
* cell instance $29277 m0 *1 173.47,64.4
X$29277 3299 3207 3116 3386 113 112 3343 OAI22_X2
* cell instance $29281 r0 *1 170.05,64.4
X$29281 3487 3479 112 113 3480 NOR2_X1
* cell instance $29282 r0 *1 170.62,64.4
X$29282 2467 2869 3480 113 3481 112 OAI21_X1
* cell instance $29284 r0 *1 171.57,64.4
X$29284 3451 2643 3203 113 3347 112 OAI21_X1
* cell instance $29285 r0 *1 172.33,64.4
X$29285 3384 2410 2643 112 3447 113 AOI21_X1
* cell instance $29286 r0 *1 173.09,64.4
X$29286 3447 3267 3562 112 113 3386 MUX2_X1
* cell instance $29288 r0 *1 174.8,64.4
X$29288 3012 3301 3478 3482 113 112 3446 OAI22_X1
* cell instance $29289 m0 *1 175.75,64.4
X$29289 3302 2688 3446 112 3387 113 AOI21_X2
* cell instance $29291 m0 *1 177.08,64.4
X$29291 3006 3170 3203 112 3389 113 AOI21_X1
* cell instance $29292 m0 *1 177.84,64.4
X$29292 3389 3211 3297 112 3388 113 AOI21_X1
* cell instance $29295 m0 *1 179.55,64.4
X$29295 3082 3444 3299 3388 3390 112 113 OAI211_X2
* cell instance $29296 m0 *1 181.26,64.4
X$29296 3442 2859 113 201 112 XOR2_X2
* cell instance $29301 m0 *1 193.8,64.4
X$29301 3368 3391 112 113 3305 XNOR2_X2
* cell instance $29302 m0 *1 195.7,64.4
X$29302 3391 3368 113 2482 112 XOR2_X2
* cell instance $29305 m0 *1 198.36,64.4
X$29305 2811 2810 3338 112 3214 113 AOI21_X2
* cell instance $29307 m0 *1 199.88,64.4
X$29307 2379 3147 112 113 3306 NAND2_X2
* cell instance $29308 m0 *1 200.83,64.4
X$29308 3305 3441 3310 1867 113 112 3338 OAI22_X1
* cell instance $29309 m0 *1 201.78,64.4
X$29309 3305 113 2814 112 BUF_X4
* cell instance $29311 m0 *1 203.3,64.4
X$29311 2581 2252 2138 112 113 3437 MUX2_X1
* cell instance $29312 m0 *1 204.63,64.4
X$29312 3392 2156 3437 112 3307 113 AOI21_X1
* cell instance $29313 m0 *1 205.39,64.4
X$29313 2048 3022 2810 112 113 3392 NOR3_X1
* cell instance $29315 m0 *1 206.34,64.4
X$29315 3126 2255 112 113 3308 NOR2_X1
* cell instance $29317 r0 *1 175.75,64.4
X$29317 2689 3340 2688 113 3557 112 OAI21_X1
* cell instance $29318 r0 *1 176.51,64.4
X$29318 2639 112 113 3296 CLKBUF_X3
* cell instance $29319 r0 *1 177.46,64.4
X$29319 3291 2577 112 113 3341 NOR2_X2
* cell instance $29320 r0 *1 178.41,64.4
X$29320 112 3556 3271 2755 2403 113 AOI21_X4
* cell instance $29324 r0 *1 180.88,64.4
X$29324 3211 3553 3450 3556 112 113 3483 AOI22_X2
* cell instance $29325 r0 *1 182.59,64.4
X$29325 2287 3485 112 113 3486 NOR2_X2
* cell instance $29326 r0 *1 183.54,64.4
X$29326 3554 3555 3206 112 113 3488 NOR3_X1
* cell instance $29327 r0 *1 184.3,64.4
X$29327 3487 3006 112 113 3553 NOR2_X1
* cell instance $29332 r0 *1 198.74,64.4
X$29332 3438 113 3489 112 BUF_X4
* cell instance $29334 r0 *1 200.83,64.4
X$29334 3306 2843 3491 113 3490 112 OAI21_X1
* cell instance $29336 r0 *1 202.35,64.4
X$29336 3549 3647 3312 112 113 3491 NAND3_X1
* cell instance $29337 r0 *1 203.11,64.4
X$29337 3492 3124 3546 2044 3308 112 113 3549 AOI221_X1
* cell instance $29339 r0 *1 204.63,64.4
X$29339 3543 2581 112 113 3336 NAND2_X2
* cell instance $29340 r0 *1 205.58,64.4
X$29340 2695 2048 112 113 3542 NOR2_X1
* cell instance $29341 r0 *1 206.15,64.4
X$29341 3494 2048 2493 113 3218 112 OAI21_X1
* cell instance $29342 r0 *1 206.91,64.4
X$29342 2047 2480 112 113 3493 NOR2_X1
* cell instance $29343 m0 *1 208.05,64.4
X$29343 2704 2493 112 113 3309 NAND2_X1
* cell instance $29344 m0 *1 207.29,64.4
X$29344 1942 1867 2495 113 3332 112 OAI21_X1
* cell instance $29345 m0 *1 208.62,64.4
X$29345 2482 2255 112 113 3393 NAND2_X1
* cell instance $29350 r0 *1 209.57,64.4
X$29350 2503 2810 112 113 3495 NOR2_X1
* cell instance $29351 m0 *1 210.14,64.4
X$29351 3326 3307 3234 3394 2698 3433 113 112 AOI221_X2
* cell instance $29352 m0 *1 209.57,64.4
X$29352 3306 2255 112 113 3326 NOR2_X1
* cell instance $29353 m0 *1 212.23,64.4
X$29353 3306 2494 112 113 3394 NOR2_X1
* cell instance $29354 m0 *1 212.8,64.4
X$29354 1943 112 113 3310 INV_X1
* cell instance $29355 m0 *1 213.18,64.4
X$29355 2382 3310 112 113 3429 NOR2_X1
* cell instance $29357 m0 *1 215.27,64.4
X$29357 3324 3429 2596 112 113 3395 NOR3_X1
* cell instance $29358 m0 *1 216.03,64.4
X$29358 3324 1942 2381 112 3396 113 AOI21_X1
* cell instance $29359 m0 *1 216.79,64.4
X$29359 2587 3396 2492 2253 113 112 3313 OAI22_X1
* cell instance $29360 m0 *1 217.74,64.4
X$29360 2846 3130 3314 113 3312 112 NOR3_X2
* cell instance $29361 m0 *1 219.07,64.4
X$29361 3395 3315 3065 113 3397 112 OAI21_X1
* cell instance $29363 m0 *1 220.02,64.4
X$29363 2255 2379 112 113 3425 NAND2_X1
* cell instance $29364 m0 *1 220.59,64.4
X$29364 2255 2377 112 113 3398 NOR2_X2
* cell instance $29368 r0 *1 210.9,64.4
X$29368 3540 2810 3422 2138 3399 3219 113 112 AOI221_X2
* cell instance $29369 r0 *1 212.99,64.4
X$29369 2252 2148 113 112 3540 AND2_X1
* cell instance $29372 r0 *1 214.32,64.4
X$29372 2145 2258 112 113 3496 NOR2_X1
* cell instance $29373 r0 *1 214.89,64.4
X$29373 3496 2394 3308 113 3536 112 OAI21_X1
* cell instance $29375 r0 *1 216.41,64.4
X$29375 3532 2394 2727 113 3533 112 OAI21_X1
* cell instance $29376 r0 *1 217.17,64.4
X$29376 3222 2282 112 113 3422 NOR2_X2
* cell instance $29379 r0 *1 219.26,64.4
X$29379 3425 3497 3397 112 3498 113 AOI21_X1
* cell instance $29380 r0 *1 220.02,64.4
X$29380 2596 3026 3398 2369 2397 113 112 3524 OAI221_X1
* cell instance $29382 r0 *1 221.35,64.4
X$29382 3400 2595 1863 113 3501 112 OAI21_X1
* cell instance $29383 r0 *1 222.11,64.4
X$29383 3021 112 113 2937 INV_X4
* cell instance $29384 m0 *1 222.87,64.4
X$29384 3027 3501 2157 112 3421 113 AOI21_X1
* cell instance $29388 r0 *1 223.44,64.4
X$29388 3021 2260 3506 2258 3399 112 113 3525 AOI221_X1
* cell instance $29389 m0 *1 225.15,64.4
X$29389 3421 3401 3029 112 113 3416 NOR3_X1
* cell instance $29390 m0 *1 224.01,64.4
X$29390 1943 2945 3398 2397 1937 113 112 3523 OAI221_X1
* cell instance $29391 m0 *1 225.91,64.4
X$29391 3419 2491 3314 3221 3408 113 112 3415 OAI221_X1
* cell instance $29392 m0 *1 227.05,64.4
X$29392 2932 3416 3414 3415 3498 3038 112 113 3405 OAI33_X1
* cell instance $29394 m0 *1 228.57,64.4
X$29394 3505 3319 3320 112 113 3402 NAND3_X1
* cell instance $29395 m0 *1 229.33,64.4
X$29395 2042 2396 2595 3220 3222 113 112 3403 OAI221_X1
* cell instance $29397 r0 *1 224.58,64.4
X$29397 2389 3523 3221 3525 113 112 3503 OAI22_X1
* cell instance $29398 r0 *1 225.53,64.4
X$29398 2945 2397 112 113 3399 NAND2_X1
* cell instance $29400 r0 *1 226.48,64.4
X$29400 3422 2042 3399 112 3504 113 AOI21_X1
* cell instance $29402 r0 *1 227.43,64.4
X$29402 3519 3402 3520 113 112 3414 AND3_X1
* cell instance $29404 r0 *1 228.76,64.4
X$29404 3222 1870 112 113 3506 NOR2_X1
* cell instance $29406 r0 *1 229.52,64.4
X$29406 3403 3612 3065 113 3507 112 OAI21_X1
* cell instance $29407 r0 *1 230.28,64.4
X$29407 2720 3132 1937 2397 113 112 3513 OAI22_X1
* cell instance $29408 m0 *1 231.04,64.4
X$29408 2492 3222 2494 3220 2253 113 112 3404 OAI221_X1
* cell instance $29412 r0 *1 231.42,64.4
X$29412 3404 3400 3513 112 3512 113 AOI21_X1
* cell instance $29413 r0 *1 232.18,64.4
X$29413 2381 3133 112 113 3508 NOR2_X1
* cell instance $29414 m0 *1 232.75,64.4
X$29414 3130 3255 3318 2493 112 113 3808 AOI22_X2
* cell instance $29421 r0 *1 233.13,64.4
X$29421 2588 3400 3132 112 3510 113 AOI21_X1
* cell instance $29423 r0 *1 234.65,64.4
X$29423 112 3400 113 2042 BUF_X8
* cell instance $29435 m0 *1 20.9,81.2
X$29435 4776 3661 16486 113 112 4839 HA_X1
* cell instance $29437 m0 *1 22.99,81.2
X$29437 4290 112 113 4348 CLKBUF_X2
* cell instance $29438 m0 *1 23.75,81.2
X$29438 4839 112 113 3975 CLKBUF_X3
* cell instance $29440 m0 *1 24.89,81.2
X$29440 4628 3859 4063 113 112 5058 AND3_X1
* cell instance $29442 m0 *1 26.03,81.2
X$29442 4293 4840 3851 112 113 4777 MUX2_X1
* cell instance $29454 r0 *1 24.51,81.2
X$29454 4180 3851 4062 113 4989 112 OAI21_X1
* cell instance $29456 r0 *1 25.46,81.2
X$29456 4291 4063 4289 112 4990 113 AOI21_X1
* cell instance $29457 r0 *1 26.22,81.2
X$29457 4990 5058 4526 112 113 4951 NOR3_X1
* cell instance $29458 r0 *1 26.98,81.2
X$29458 4180 4293 112 113 4991 NOR2_X1
* cell instance $29459 r0 *1 27.55,81.2
X$29459 4991 4065 4422 5061 4952 113 112 AOI211_X2
* cell instance $29460 m0 *1 28.69,81.2
X$29460 3973 4844 3764 4614 3909 4956 113 112 AOI221_X2
* cell instance $29464 r0 *1 29.26,81.2
X$29464 4951 4952 4955 113 5067 112 OAI21_X1
* cell instance $29467 r0 *1 30.59,81.2
X$29467 3974 5064 4995 4474 4996 4461 112 113 4953 OAI33_X1
* cell instance $29468 r0 *1 31.92,81.2
X$29468 4520 4291 112 113 5064 NOR2_X1
* cell instance $29470 m0 *1 33.44,81.2
X$29470 4778 4957 4847 4958 113 112 4960 OAI22_X2
* cell instance $29471 m0 *1 32.68,81.2
X$29471 4956 4183 4848 113 4778 112 OAI21_X1
* cell instance $29472 m0 *1 35.15,81.2
X$29472 4842 4063 4779 112 113 4893 MUX2_X1
* cell instance $29473 m0 *1 36.48,81.2
X$29473 4894 4141 4893 112 4781 113 AOI21_X1
* cell instance $29474 m0 *1 37.24,81.2
X$29474 4781 4185 5142 112 113 4479 MUX2_X1
* cell instance $29477 r0 *1 32.87,81.2
X$29477 4892 4891 4520 112 4957 113 AOI21_X1
* cell instance $29478 r0 *1 33.63,81.2
X$29478 4413 112 113 4892 INV_X2
* cell instance $29481 r0 *1 35.15,81.2
X$29481 4992 112 113 5072 INV_X1
* cell instance $29482 r0 *1 35.53,81.2
X$29482 5072 4613 4063 113 4999 112 OAI21_X1
* cell instance $29483 r0 *1 36.29,81.2
X$29483 4999 4784 5073 112 113 4958 NOR3_X1
* cell instance $29484 r0 *1 37.05,81.2
X$29484 5057 4069 4961 112 4782 113 AOI21_X1
* cell instance $29485 r0 *1 37.81,81.2
X$29485 112 5001 4892 4298 4300 113 AOI21_X4
* cell instance $29487 m0 *1 39.71,81.2
X$29487 4856 113 3974 112 BUF_X4
* cell instance $29488 r0 *1 40.28,81.2
X$29488 5002 4628 112 113 4895 NOR2_X1
* cell instance $29489 r0 *1 40.85,81.2
X$29489 4348 4520 3810 3863 5076 113 112 5003 OAI221_X1
* cell instance $29490 m0 *1 42.18,81.2
X$29490 4784 4526 4617 112 4962 113 AOI21_X1
* cell instance $29491 m0 *1 41.42,81.2
X$29491 4783 4293 4289 112 5076 113 AOI21_X1
* cell instance $29492 m0 *1 42.94,81.2
X$29492 4783 4791 3856 113 4784 112 NOR3_X2
* cell instance $29494 r0 *1 41.99,81.2
X$29494 4953 5003 4070 112 4896 113 AOI21_X1
* cell instance $29496 r0 *1 43.13,81.2
X$29496 4963 4412 4785 112 113 5080 MUX2_X1
* cell instance $29498 m0 *1 45.6,81.2
X$29498 4848 4859 4786 112 4787 113 AOI21_X1
* cell instance $29499 m0 *1 44.65,81.2
X$29499 4856 3972 112 113 4578 NAND2_X2
* cell instance $29502 r0 *1 45.03,81.2
X$29502 4526 4788 4897 112 5075 113 AOI21_X1
* cell instance $29503 r0 *1 45.79,81.2
X$29503 4298 4300 4413 112 113 4788 NAND3_X2
* cell instance $29504 m0 *1 46.93,81.2
X$29504 3916 3762 4622 113 4859 112 OAI21_X1
* cell instance $29508 r0 *1 47.5,81.2
X$29508 4791 4241 3764 113 4359 112 OAI21_X1
* cell instance $29509 m0 *1 48.26,81.2
X$29509 4788 3916 4422 113 112 4236 OAI21_X2
* cell instance $29511 m0 *1 49.59,81.2
X$29511 4789 4862 4703 112 113 4898 NAND3_X1
* cell instance $29513 m0 *1 50.54,81.2
X$29513 4348 3855 4790 113 4862 112 OAI21_X1
* cell instance $29515 m0 *1 51.49,81.2
X$29515 4578 4788 4790 112 4625 113 AOI21_X1
* cell instance $29516 m0 *1 52.25,81.2
X$29516 4791 4526 112 113 4790 NOR2_X1
* cell instance $29518 r0 *1 48.26,81.2
X$29518 5218 4069 4965 112 5005 113 AOI21_X1
* cell instance $29519 r0 *1 49.02,81.2
X$29519 5082 3863 4302 112 4965 113 AOI21_X1
* cell instance $29521 r0 *1 49.97,81.2
X$29521 4628 3859 4897 113 4302 112 OAI21_X1
* cell instance $29524 r0 *1 51.68,81.2
X$29524 5263 4025 4955 113 4246 112 OAI21_X1
* cell instance $29527 m0 *1 53.39,81.2
X$29527 4702 3763 4613 112 4523 113 AOI21_X1
* cell instance $29530 r0 *1 53.58,81.2
X$29530 4628 4422 5008 113 4792 112 OAI21_X1
* cell instance $29533 m0 *1 54.53,81.2
X$29533 4236 4074 4792 112 113 4971 MUX2_X1
* cell instance $29535 m0 *1 56.81,81.2
X$29535 4898 4793 4025 4081 112 113 4865 NAND4_X1
* cell instance $29537 m0 *1 58.52,81.2
X$29537 112 16737 4975 2831 4795 113 DFF_X1
* cell instance $29540 m0 *1 68.02,81.2
X$29540 4430 4366 4638 113 4798 112 OAI21_X1
* cell instance $29541 m0 *1 68.78,81.2
X$29541 112 3982 5149 4796 4724 113 NOR3_X4
* cell instance $29542 m0 *1 71.44,81.2
X$29542 4529 112 113 5010 BUF_X1
* cell instance $29543 m0 *1 72.01,81.2
X$29543 4899 4978 3987 112 4979 113 AOI21_X1
* cell instance $29544 m0 *1 72.77,81.2
X$29544 112 4869 4305 4637 4366 113 AOI21_X4
* cell instance $29545 m0 *1 75.24,81.2
X$29545 4869 4981 4424 4368 4984 4870 113 112 AOI221_X2
* cell instance $29546 m0 *1 77.33,81.2
X$29546 4798 4260 4805 4489 112 113 4799 AOI22_X1
* cell instance $29548 m0 *1 78.47,81.2
X$29548 4640 4805 113 112 5235 AND2_X1
* cell instance $29550 m0 *1 79.42,81.2
X$29550 4871 4901 4870 113 4884 112 NOR3_X2
* cell instance $29552 r0 *1 55.1,81.2
X$29552 4969 4081 4955 4960 4864 113 112 AOI211_X2
* cell instance $29553 r0 *1 56.81,81.2
X$29553 4962 4955 4971 112 113 5225 MUX2_X1
* cell instance $29555 r0 *1 58.33,81.2
X$29555 4144 4081 4865 5148 5009 4974 112 113 OAI221_X2
* cell instance $29560 r0 *1 64.79,81.2
X$29560 4975 112 113 5371 BUF_X2
* cell instance $29565 r0 *1 68.59,81.2
X$29565 4305 4976 4796 5149 4805 4033 112 113 OAI221_X2
* cell instance $29566 r0 *1 70.68,81.2
X$29566 3922 4797 112 113 5267 NAND2_X1
* cell instance $29567 r0 *1 71.25,81.2
X$29567 4633 112 113 4899 CLKBUF_X3
* cell instance $29568 r0 *1 72.2,81.2
X$29568 5090 5089 4033 112 5088 113 AOI21_X1
* cell instance $29570 r0 *1 73.34,81.2
X$29570 4981 4979 4980 4868 112 113 4902 AOI22_X1
* cell instance $29572 r0 *1 74.48,81.2
X$29572 4630 4900 112 113 4984 NOR2_X2
* cell instance $29573 r0 *1 75.43,81.2
X$29573 4900 4305 3984 4488 4878 113 112 AOI211_X2
* cell instance $29574 r0 *1 77.14,81.2
X$29574 4366 5094 4307 4085 4636 5095 113 112 AOI221_X2
* cell instance $29575 r0 *1 79.23,81.2
X$29575 5095 4800 4878 113 4901 112 NOR3_X2
* cell instance $29577 r0 *1 80.75,81.2
X$29577 4899 4630 4900 113 112 4903 OAI21_X4
* cell instance $29578 m0 *1 82.46,81.2
X$29578 4987 4903 5099 112 113 4801 NAND3_X1
* cell instance $29579 m0 *1 81.13,81.2
X$29579 4900 113 4909 112 BUF_X4
* cell instance $29580 m0 *1 83.22,81.2
X$29580 4375 4801 4874 113 4881 112 OAI21_X1
* cell instance $29582 r0 *1 83.22,81.2
X$29582 4375 4902 4733 4799 113 112 5100 OAI22_X1
* cell instance $29583 r0 *1 84.17,81.2
X$29583 4430 4639 5091 4728 5016 112 113 4985 AOI221_X1
* cell instance $29584 m0 *1 85.12,81.2
X$29584 112 4904 4608 4873 4643 5243 113 NAND4_X4
* cell instance $29585 m0 *1 84.36,81.2
X$29585 4803 4802 4985 113 4874 112 OAI21_X1
* cell instance $29586 m0 *1 88.54,81.2
X$29586 4803 4630 4199 4728 112 113 4806 AOI22_X1
* cell instance $29588 m0 *1 89.68,81.2
X$29588 4806 4807 4642 4809 112 113 4808 NAND4_X1
* cell instance $29589 m0 *1 90.63,81.2
X$29589 5019 4877 4733 112 113 4983 NOR3_X1
* cell instance $29590 m0 *1 91.39,81.2
X$29590 4800 5281 4982 112 4810 113 AOI21_X1
* cell instance $29591 m0 *1 92.15,81.2
X$29591 4640 4880 112 113 4982 NAND2_X1
* cell instance $29593 r0 *1 85.31,81.2
X$29593 4986 4630 112 113 5354 NOR2_X1
* cell instance $29594 r0 *1 85.88,81.2
X$29594 4480 4797 112 113 5015 NOR2_X1
* cell instance $29598 r0 *1 88.92,81.2
X$29598 3772 112 113 5103 BUF_X1
* cell instance $29600 r0 *1 89.87,81.2
X$29600 4904 4983 4809 113 5104 112 OAI21_X1
* cell instance $29602 r0 *1 92.15,81.2
X$29602 4878 4095 5105 112 4905 113 AOI21_X1
* cell instance $29604 m0 *1 93.29,81.2
X$29604 4733 4905 4809 4811 4646 113 112 4906 OAI221_X1
* cell instance $29606 m0 *1 94.43,81.2
X$29606 4430 4195 4800 4091 4648 113 112 4907 OAI221_X1
* cell instance $29608 m0 *1 95.76,81.2
X$29608 4734 4602 4907 113 112 4910 AND3_X1
* cell instance $29611 r0 *1 93.48,81.2
X$29611 4881 4906 4431 113 5113 112 OAI21_X1
* cell instance $29614 r0 *1 94.81,81.2
X$29614 4095 4908 4647 113 5106 112 OAI21_X1
* cell instance $29615 r0 *1 95.57,81.2
X$29615 5020 4497 4909 112 4908 113 AOI21_X1
* cell instance $29618 r0 *1 96.9,81.2
X$29618 5106 4643 112 113 4977 NAND2_X1
* cell instance $29619 m0 *1 97.66,81.2
X$29619 4884 4910 4431 112 113 4911 NOR3_X1
* cell instance $29620 m0 *1 97.09,81.2
X$29620 4433 4649 112 113 4883 NAND2_X1
* cell instance $29624 r0 *1 98.04,81.2
X$29624 5107 5110 4977 5021 4911 4912 112 113 5022 OAI33_X1
* cell instance $29626 m0 *1 98.8,81.2
X$29626 4885 4603 4809 113 4912 112 OAI21_X1
* cell instance $29627 m0 *1 99.75,81.2
X$29627 4913 4497 4431 112 113 4885 NAND3_X1
* cell instance $29630 r0 *1 99.37,81.2
X$29630 4812 4033 4492 112 113 4913 NAND3_X1
* cell instance $29633 r0 *1 100.7,81.2
X$29633 4734 112 113 4871 CLKBUF_X3
* cell instance $29634 r0 *1 101.65,81.2
X$29634 112 17109 5115 5022 4203 113 DFF_X1
* cell instance $29636 m0 *1 103.93,81.2
X$29636 112 4972 4973 4974 4203 113 DFF_X1
* cell instance $29639 r0 *1 105.26,81.2
X$29639 5115 112 113 4269 CLKBUF_X3
* cell instance $29642 r0 *1 107.16,81.2
X$29642 3772 4973 112 113 4915 XNOR2_X2
* cell instance $29644 m0 *1 108.3,81.2
X$29644 4915 4650 112 113 4916 XNOR2_X2
* cell instance $29646 r0 *1 109.06,81.2
X$29646 4914 5024 4916 113 112 341 MUX2_X2
* cell instance $29647 r0 *1 110.77,81.2
X$29647 5122 4917 113 112 4914 AND2_X1
* cell instance $29649 m0 *1 111.34,81.2
X$29649 4972 4917 113 112 4755 XNOR2_X1
* cell instance $29652 r0 *1 111.72,81.2
X$29652 4890 5025 112 113 4917 XNOR2_X2
* cell instance $29655 m0 *1 113.62,81.2
X$29655 112 16910 5126 4651 4652 113 DFF_X1
* cell instance $29656 r0 *1 116.66,81.2
X$29656 5126 113 5025 112 BUF_X4
* cell instance $29657 m0 *1 117.42,81.2
X$29657 4813 4650 113 220 112 XOR2_X2
* cell instance $29661 m0 *1 123.69,81.2
X$29661 4966 3573 113 274 112 XOR2_X2
* cell instance $29663 r0 *1 117.99,81.2
X$29663 5023 3541 112 113 5127 NOR2_X1
* cell instance $29665 r0 *1 118.75,81.2
X$29665 5023 3778 112 113 5129 NOR2_X1
* cell instance $29669 r0 *1 120.65,81.2
X$29669 3635 3778 112 113 5131 NAND2_X1
* cell instance $29670 r0 *1 121.22,81.2
X$29670 4054 3541 112 113 5130 NAND2_X1
* cell instance $29678 r0 *1 124.64,81.2
X$29678 112 17091 5128 4970 4918 113 DFF_X1
* cell instance $29680 m0 *1 125.78,81.2
X$29680 5398 3775 4654 112 4970 113 AOI21_X1
* cell instance $29681 m0 *1 127.11,81.2
X$29681 4887 3775 4888 112 4968 113 AOI21_X1
* cell instance $29683 m0 *1 127.87,81.2
X$29683 112 16842 4886 4968 4918 113 DFF_X1
* cell instance $29684 m0 *1 131.1,81.2
X$29684 4886 113 3646 112 BUF_X4
* cell instance $29687 m0 *1 133.38,81.2
X$29687 4774 4919 113 219 112 XOR2_X2
* cell instance $29689 m0 *1 135.28,81.2
X$29689 4769 4882 112 113 4967 XNOR2_X2
* cell instance $29691 r0 *1 127.87,81.2
X$29691 5128 113 4763 112 BUF_X4
* cell instance $29696 r0 *1 131.86,81.2
X$29696 5546 5123 112 113 3668 XNOR2_X2
* cell instance $29697 r0 *1 133.76,81.2
X$29697 4774 5029 113 112 5123 XNOR2_X1
* cell instance $29699 r0 *1 135.09,81.2
X$29699 250 5030 4508 113 112 4923 MUX2_X2
* cell instance $29700 r0 *1 136.8,81.2
X$29700 4405 5117 113 112 5118 XNOR2_X1
* cell instance $29701 m0 *1 137.75,81.2
X$29701 4966 4510 113 4405 112 XOR2_X2
* cell instance $29706 r0 *1 138.7,81.2
X$29706 3375 4774 113 112 5116 XNOR2_X1
* cell instance $29709 r0 *1 140.79,81.2
X$29709 112 17083 5112 4920 5297 113 DFF_X1
* cell instance $29710 m0 *1 141.55,81.2
X$29710 4815 3775 4814 112 4920 113 AOI21_X1
* cell instance $29714 r0 *1 144.02,81.2
X$29714 5112 113 3541 112 BUF_X4
* cell instance $29734 m0 *1 109.06,235.2
X$29734 112 16815 16368 14050 13585 113 DFF_X1
* cell instance $29760 m0 *1 112.86,235.2
X$29760 112 16785 16409 9500 16355 113 DFF_X1
* cell instance $29762 m0 *1 116.09,235.2
X$29762 112 16788 16389 9704 16355 113 DFF_X1
* cell instance $29766 m0 *1 127.11,235.2
X$29766 112 16791 16358 9837 16311 113 DFF_X1
* cell instance $29768 m0 *1 131.1,235.2
X$29768 112 16790 16413 7337 16311 113 DFF_X1
* cell instance $29775 r0 *1 116.85,235.2
X$29775 16355 112 113 17208 INV_X1
* cell instance $29778 r0 *1 123.5,235.2
X$29778 112 17124 16411 9834 16311 113 DFF_X1
* cell instance $29789 m0 *1 150.1,235.2
X$29789 112 16802 16388 13815 16298 113 DFF_X1
* cell instance $29796 m0 *1 159.22,235.2
X$29796 112 16848 16407 14079 16298 113 DFF_X1
* cell instance $29805 m0 *1 175.94,235.2
X$29805 112 16849 16369 13701 14106 113 DFF_X1
* cell instance $29846 m0 *1 24.89,72.8
X$29846 3973 112 113 3859 CLKBUF_X3
* cell instance $29859 r0 *1 22.61,72.8
X$29859 112 3811 113 4062 BUF_X8
* cell instance $29860 r0 *1 25.08,72.8
X$29860 4063 3859 112 113 4178 NOR2_X1
* cell instance $29861 r0 *1 25.65,72.8
X$29861 4231 4178 4179 113 4232 112 OAI21_X1
* cell instance $29864 r0 *1 26.98,72.8
X$29864 4181 4180 4062 112 113 4231 NOR3_X1
* cell instance $29865 m0 *1 27.17,72.8
X$29865 3974 3859 4125 112 113 4131 NOR3_X1
* cell instance $29870 m0 *1 28.31,72.8
X$29870 3972 112 113 4063 CLKBUF_X3
* cell instance $29871 m0 *1 29.45,72.8
X$29871 4014 3970 4126 4232 112 113 4016 NAND4_X1
* cell instance $29872 m0 *1 30.4,72.8
X$29872 4064 3859 4065 3763 112 113 4126 NAND4_X1
* cell instance $29876 r0 *1 29.07,72.8
X$29876 4182 113 4074 112 BUF_X4
* cell instance $29877 r0 *1 30.4,72.8
X$29877 4181 3973 112 113 3909 NOR2_X1
* cell instance $29878 r0 *1 30.97,72.8
X$29878 4181 113 4064 112 BUF_X4
* cell instance $29879 m0 *1 32.49,72.8
X$29879 3972 4127 3853 112 4066 113 AOI21_X2
* cell instance $29880 m0 *1 31.73,72.8
X$29880 3973 4062 3764 112 4127 113 AOI21_X1
* cell instance $29881 m0 *1 33.82,72.8
X$29881 3764 4015 112 113 3971 NAND2_X1
* cell instance $29882 m0 *1 34.39,72.8
X$29882 4128 4067 4016 112 113 4136 MUX2_X1
* cell instance $29883 m0 *1 35.72,72.8
X$29883 3974 4063 4129 112 4068 113 AOI21_X1
* cell instance $29884 m0 *1 36.48,72.8
X$29884 4063 113 4069 112 BUF_X4
* cell instance $29885 m0 *1 37.81,72.8
X$29885 4131 4069 112 113 4130 NOR2_X1
* cell instance $29887 m0 *1 38.57,72.8
X$29887 4241 3976 4071 112 113 3766 MUX2_X1
* cell instance $29890 m0 *1 40.85,72.8
X$29890 4065 112 113 3863 CLKBUF_X3
* cell instance $29892 r0 *1 32.3,72.8
X$29892 4233 4066 112 113 4237 NAND2_X1
* cell instance $29893 r0 *1 32.87,72.8
X$29893 4064 4074 112 113 4183 NOR2_X1
* cell instance $29894 r0 *1 33.44,72.8
X$29894 4066 4184 4185 4236 4183 3813 113 112 AOI221_X2
* cell instance $29896 r0 *1 35.72,72.8
X$29896 4237 4068 4185 4067 4782 4135 113 112 AOI221_X2
* cell instance $29898 r0 *1 38.57,72.8
X$29898 3977 4130 4185 3865 4242 4145 113 112 AOI221_X2
* cell instance $29899 r0 *1 40.66,72.8
X$29899 3863 4296 3865 4293 3855 113 112 4187 OAI221_X1
* cell instance $29900 r0 *1 41.8,72.8
X$29900 4187 4188 4185 112 113 4190 NAND3_X1
* cell instance $29901 m0 *1 42.37,72.8
X$29901 4135 4025 4019 112 4146 113 AOI21_X2
* cell instance $29905 m0 *1 44.65,72.8
X$29905 4072 4137 4064 3856 3763 112 113 3979 AOI221_X1
* cell instance $29909 r0 *1 44.08,72.8
X$29909 3976 4071 113 112 4189 AND2_X1
* cell instance $29910 r0 *1 44.84,72.8
X$29910 4136 4244 4186 112 113 4080 MUX2_X1
* cell instance $29911 r0 *1 46.17,72.8
X$29911 4299 4022 4244 112 113 4073 NOR3_X1
* cell instance $29912 r0 *1 46.93,72.8
X$29912 4190 4141 112 113 4245 NAND2_X1
* cell instance $29913 r0 *1 47.5,72.8
X$29913 4076 4192 3856 112 113 4357 NAND3_X1
* cell instance $29914 m0 *1 48.45,72.8
X$29914 4142 3810 4075 112 113 4077 MUX2_X1
* cell instance $29915 m0 *1 47.69,72.8
X$29915 4074 4191 3980 113 4142 112 OAI21_X1
* cell instance $29916 m0 *1 49.78,72.8
X$29916 4077 3865 4143 112 113 4078 MUX2_X1
* cell instance $29917 m0 *1 51.11,72.8
X$29917 4080 4081 4146 112 113 3667 MUX2_X1
* cell instance $29918 m0 *1 52.44,72.8
X$29918 4069 113 3865 112 BUF_X4
* cell instance $29921 m0 *1 60.04,72.8
X$29921 112 16831 4193 3665 243 113 DFF_X1
* cell instance $29924 r0 *1 48.64,72.8
X$29924 3976 4076 4192 112 4079 113 AOI21_X2
* cell instance $29925 r0 *1 49.97,72.8
X$29925 4145 4025 4078 112 4144 113 AOI21_X2
* cell instance $29926 r0 *1 51.3,72.8
X$29926 4245 3813 4081 4246 4073 113 112 4248 OAI221_X1
* cell instance $29928 r0 *1 53.2,72.8
X$29928 3715 3762 4067 113 4249 112 OAI21_X1
* cell instance $29931 r0 *1 55.67,72.8
X$29931 4081 4304 4248 113 3927 112 OAI21_X1
* cell instance $29952 r0 *1 25.27,70
X$29952 3763 3762 16666 113 112 4125 HA_X1
* cell instance $29954 r0 *1 27.55,70
X$29954 3851 113 3763 112 BUF_X4
* cell instance $29955 r0 *1 28.88,70
X$29955 3972 3851 112 113 3969 NOR2_X1
* cell instance $29956 r0 *1 29.45,70
X$29956 3969 3861 3811 113 3970 112 OAI21_X1
* cell instance $29958 r0 *1 30.4,70
X$29958 3909 3853 3971 112 113 4014 NAND3_X1
* cell instance $29959 m0 *1 31.35,70
X$29959 3763 3762 16577 113 112 3852 HA_X1
* cell instance $29961 m0 *1 33.25,70
X$29961 3763 3661 16582 113 112 4015 HA_X1
* cell instance $29962 m0 *1 35.15,70
X$29962 3764 113 3765 112 BUF_X4
* cell instance $29965 r0 *1 31.54,70
X$29965 4064 113 3854 112 BUF_X4
* cell instance $29968 r0 *1 34.01,70
X$29968 3853 3971 3855 112 113 3977 NAND3_X1
* cell instance $29970 r0 *1 35.15,70
X$29970 3976 113 3856 112 BUF_X4
* cell instance $30012 r0 *1 116.85,238
X$30012 16414 112 113 9383 CLKBUF_X2
* cell instance $30014 r0 *1 119.13,238
X$30014 16389 112 113 16415 BUF_X1
* cell instance $30016 m0 *1 120.27,238
X$30016 112 16792 16377 9832 16355 113 DFF_X1
* cell instance $30025 r0 *1 130.15,238
X$30025 16397 112 113 8743 CLKBUF_X2
* cell instance $30026 m0 *1 130.91,238
X$30026 16378 112 113 13940 INV_X1
* cell instance $30031 m0 *1 136.61,238
X$30031 112 16806 16381 13609 16361 113 DFF_X1
* cell instance $30032 m0 *1 139.84,238
X$30032 16362 112 113 13316 BUF_X1
* cell instance $30036 r0 *1 131.1,238
X$30036 16379 112 113 9601 CLKBUF_X2
* cell instance $30040 r0 *1 133.95,238
X$30040 16380 112 113 14004 BUF_X1
* cell instance $30043 r0 *1 135.09,238
X$30043 16422 112 113 10964 CLKBUF_X2
* cell instance $30046 r0 *1 136.42,238
X$30046 16453 112 113 14146 BUF_X1
* cell instance $30048 r0 *1 137.75,238
X$30048 16424 112 113 12454 BUF_X1
* cell instance $30050 r0 *1 139.84,238
X$30050 16381 112 113 16382 BUF_X1
* cell instance $30052 r0 *1 140.6,238
X$30052 16455 112 113 16383 BUF_X1
* cell instance $30054 r0 *1 141.36,238
X$30054 16384 112 113 10770 CLKBUF_X2
* cell instance $30055 m0 *1 144.78,238
X$30055 16364 112 113 16375 BUF_X1
* cell instance $30056 m0 *1 141.55,238
X$30056 112 16786 16386 14178 16361 113 DFF_X1
* cell instance $30061 r0 *1 144.02,238
X$30061 16386 112 113 16405 BUF_X1
* cell instance $30064 r0 *1 145.54,238
X$30064 16387 112 113 13482 BUF_X1
* cell instance $30067 m0 *1 146.49,238
X$30067 16365 112 113 13738 BUF_X1
* cell instance $30118 m0 *1 10.64,89.6
X$30118 5511 112 113 5669 BUF_X1
* cell instance $30121 m0 *1 21.09,89.6
X$30121 112 4179 113 4988 BUF_X8
* cell instance $30129 r0 *1 10.45,89.6
X$30129 5668 112 113 5602 BUF_X1
* cell instance $30137 r0 *1 13.87,89.6
X$30137 5775 112 113 5603 BUF_X1
* cell instance $30141 r0 *1 15.77,89.6
X$30141 5512 112 113 5776 BUF_X1
* cell instance $30143 r0 *1 16.72,89.6
X$30143 6050 112 113 5133 CLKBUF_X3
* cell instance $30144 r0 *1 17.67,89.6
X$30144 5133 112 113 17209 INV_X1
* cell instance $30146 r0 *1 19.57,89.6
X$30146 112 17121 5668 5670 5133 113 DFF_X1
* cell instance $30150 r0 *1 25.27,89.6
X$30150 4179 3762 16663 113 112 5513 HA_X1
* cell instance $30151 m0 *1 28.12,89.6
X$30151 5514 4610 5673 112 113 5520 MUX2_X1
* cell instance $30152 m0 *1 26.22,89.6
X$30152 4179 4526 16505 113 112 5514 HA_X1
* cell instance $30153 m0 *1 29.45,89.6
X$30153 4614 3861 4613 5514 112 113 5258 AOI22_X2
* cell instance $30155 m0 *1 31.35,89.6
X$30155 5515 5606 4463 113 5570 112 OAI21_X1
* cell instance $30156 m0 *1 32.11,89.6
X$30156 5606 5256 4997 112 113 5517 NAND3_X1
* cell instance $30157 m0 *1 32.87,89.6
X$30157 5262 5517 113 112 5518 AND2_X1
* cell instance $30158 m0 *1 33.63,89.6
X$30158 3975 5606 5526 112 113 5679 MUX2_X1
* cell instance $30159 m0 *1 34.96,89.6
X$30159 5073 3765 5679 112 5608 113 AOI21_X1
* cell instance $30161 r0 *1 27.17,89.6
X$30161 4411 112 113 3973 CLKBUF_X3
* cell instance $30162 r0 *1 28.12,89.6
X$30162 5439 5605 5516 112 113 5673 MUX2_X1
* cell instance $30163 r0 *1 29.45,89.6
X$30163 5454 112 113 4354 CLKBUF_X3
* cell instance $30165 r0 *1 30.59,89.6
X$30165 5606 5605 112 113 4619 NAND2_X2
* cell instance $30166 r0 *1 31.54,89.6
X$30166 5678 5605 5610 112 113 5607 MUX2_X1
* cell instance $30168 r0 *1 33.06,89.6
X$30168 5607 4613 112 113 5140 NOR2_X1
* cell instance $30171 r0 *1 34.77,89.6
X$30171 5609 3854 5608 112 4128 113 AOI21_X1
* cell instance $30174 r0 *1 36.1,89.6
X$30174 3851 5682 4181 5605 5681 112 113 5609 AOI221_X1
* cell instance $30176 m0 *1 36.1,89.6
X$30176 5518 5684 4301 5520 112 113 5578 AOI22_X1
* cell instance $30178 r0 *1 37.24,89.6
X$30178 5787 3764 5683 112 113 4961 MUX2_X1
* cell instance $30179 m0 *1 38.38,89.6
X$30179 4298 4300 3975 112 113 5364 NAND3_X1
* cell instance $30183 r0 *1 38.57,89.6
X$30183 5610 5606 4192 113 5787 112 OAI21_X1
* cell instance $30184 r0 *1 39.33,89.6
X$30184 3715 5606 4574 113 5683 112 OAI21_X1
* cell instance $30185 r0 *1 40.09,89.6
X$30185 3916 112 113 5678 INV_X1
* cell instance $30186 m0 *1 41.04,89.6
X$30186 5522 4024 5521 112 5523 113 AOI21_X1
* cell instance $30187 m0 *1 40.28,89.6
X$30187 5611 5521 4065 113 5684 112 OAI21_X1
* cell instance $30191 r0 *1 40.66,89.6
X$30191 4015 4298 4300 112 5611 113 AOI21_X1
* cell instance $30192 r0 *1 41.42,89.6
X$30192 5008 5732 112 113 5681 NAND2_X1
* cell instance $30193 r0 *1 41.99,89.6
X$30193 5686 5516 5612 112 4574 113 NAND3_X4
* cell instance $30195 m0 *1 42.94,89.6
X$30195 3975 5605 3715 112 113 5331 MUX2_X1
* cell instance $30196 r0 *1 44.46,89.6
X$30196 112 4702 3975 5612 5686 113 AOI21_X4
* cell instance $30197 m0 *1 44.84,89.6
X$30197 5516 4294 4347 113 112 4897 OAI21_X2
* cell instance $30199 m0 *1 46.17,89.6
X$30199 4294 4347 3767 113 5462 112 OAI21_X1
* cell instance $30202 m0 *1 47.5,89.6
X$30202 5462 4574 5605 112 113 5586 NAND3_X1
* cell instance $30204 m0 *1 48.26,89.6
X$30204 5262 4626 4359 113 112 5613 AND3_X1
* cell instance $30205 m0 *1 49.21,89.6
X$30205 5524 5586 113 112 5614 AND2_X1
* cell instance $30206 m0 *1 49.97,89.6
X$30206 5614 5262 5615 112 113 4242 MUX2_X1
* cell instance $30208 m0 *1 51.49,89.6
X$30208 5226 5617 5590 113 5263 112 OAI21_X1
* cell instance $30209 m0 *1 52.25,89.6
X$30209 3765 4072 112 113 5618 NOR2_X1
* cell instance $30211 r0 *1 47.69,89.6
X$30211 4072 112 113 5526 INV_X1
* cell instance $30212 r0 *1 48.07,89.6
X$30212 4897 5734 3976 112 113 4626 NAND3_X1
* cell instance $30213 r0 *1 48.83,89.6
X$30213 5366 3916 112 113 5264 NOR2_X1
* cell instance $30214 r0 *1 49.4,89.6
X$30214 5735 5146 4460 112 113 5616 NAND3_X1
* cell instance $30215 r0 *1 50.16,89.6
X$30215 4475 5892 5616 113 5615 112 OAI21_X1
* cell instance $30217 r0 *1 51.11,89.6
X$30217 3866 3855 5732 113 5799 112 OAI21_X1
* cell instance $30219 r0 *1 52.06,89.6
X$30219 5618 3863 5799 112 5689 113 AOI21_X1
* cell instance $30233 m0 *1 69.54,224
X$30233 14538 113 15981 112 BUF_X4
* cell instance $30234 m0 *1 70.87,224
X$30234 16255 14980 16254 112 113 16233 MUX2_X1
* cell instance $30235 m0 *1 72.2,224
X$30235 14379 15539 16233 112 15496 113 AOI21_X2
* cell instance $30236 m0 *1 73.53,224
X$30236 14331 112 113 15282 INV_X2
* cell instance $30256 r0 *1 69.54,224
X$30256 14846 14930 16658 113 112 16255 HA_X1
* cell instance $30259 r0 *1 72.58,224
X$30259 15508 16285 112 113 15584 NOR2_X1
* cell instance $30260 r0 *1 73.15,224
X$30260 14980 112 113 15508 CLKBUF_X3
* cell instance $30262 r0 *1 74.29,224
X$30262 16026 16292 112 113 16025 NAND2_X1
* cell instance $30263 m0 *1 74.67,224
X$30263 15508 15539 16284 112 113 16256 NOR3_X1
* cell instance $30266 m0 *1 75.62,224
X$30266 16256 14493 14856 112 113 16263 NOR3_X1
* cell instance $30269 m0 *1 78.09,224
X$30269 16255 14538 16083 112 113 16260 MUX2_X1
* cell instance $30271 m0 *1 79.61,224
X$30271 15329 16083 16026 112 113 16261 NOR3_X1
* cell instance $30273 m0 *1 81.13,224
X$30273 14988 16234 15064 113 112 16235 OAI21_X2
* cell instance $30274 m0 *1 82.46,224
X$30274 14716 14718 15284 112 113 16294 OR3_X1
* cell instance $30275 m0 *1 83.41,224
X$30275 16263 16265 15949 14716 112 113 16240 NOR4_X1
* cell instance $30276 m0 *1 84.36,224
X$30276 14989 16026 15539 113 16237 112 OAI21_X1
* cell instance $30277 m0 *1 85.12,224
X$30277 16237 16238 14444 112 113 16265 NOR3_X1
* cell instance $30278 m0 *1 85.88,224
X$30278 14379 15398 112 113 16238 NAND2_X1
* cell instance $30279 m0 *1 86.45,224
X$30279 15398 14662 112 113 16239 NOR2_X1
* cell instance $30280 m0 *1 87.02,224
X$30280 14989 14713 14127 15723 16187 112 113 16267 AOI221_X1
* cell instance $30281 m0 *1 88.16,224
X$30281 14495 112 113 15542 CLKBUF_X3
* cell instance $30282 m0 *1 89.11,224
X$30282 15533 14213 15437 113 16268 112 OAI21_X1
* cell instance $30283 m0 *1 89.87,224
X$30283 14655 16240 16242 112 15997 113 AOI21_X1
* cell instance $30284 m0 *1 90.63,224
X$30284 16201 16239 112 113 16297 OR2_X1
* cell instance $30285 m0 *1 91.39,224
X$30285 16239 16201 15824 14943 15981 113 112 16272 OAI221_X1
* cell instance $30286 m0 *1 92.53,224
X$30286 15064 16238 14497 16229 113 112 15959 OAI22_X1
* cell instance $30289 r0 *1 75.24,224
X$30289 16026 16285 16291 112 113 16293 NOR3_X1
* cell instance $30291 r0 *1 76.38,224
X$30291 15405 15096 16292 113 112 16291 HA_X1
* cell instance $30292 r0 *1 78.28,224
X$30292 14662 14887 14992 113 16316 112 OAI21_X1
* cell instance $30295 r0 *1 80.18,224
X$30295 16260 14807 112 113 16296 NAND2_X1
* cell instance $30296 r0 *1 80.75,224
X$30296 16293 14607 112 113 16319 NOR2_X1
* cell instance $30297 r0 *1 81.32,224
X$30297 14716 16235 16261 112 113 16295 OR3_X1
* cell instance $30298 r0 *1 82.27,224
X$30298 15824 16235 16236 113 112 15781 AND3_X2
* cell instance $30299 r0 *1 83.41,224
X$30299 15718 16295 16304 16294 113 112 16139 AND4_X2
* cell instance $30304 r0 *1 87.59,224
X$30304 14765 15060 14445 112 16286 113 AOI21_X1
* cell instance $30305 r0 *1 88.35,224
X$30305 16286 16268 15824 113 16287 112 OAI21_X1
* cell instance $30306 r0 *1 89.11,224
X$30306 16287 16296 14859 112 113 15506 NAND3_X1
* cell instance $30308 r0 *1 90.06,224
X$30308 15405 16241 16300 16324 113 112 16299 OAI22_X1
* cell instance $30309 r0 *1 91.01,224
X$30309 16319 16297 15861 16299 112 113 16270 AOI22_X1
* cell instance $30310 r0 *1 91.96,224
X$30310 14807 15333 112 113 16300 NAND2_X1
* cell instance $30311 r0 *1 92.53,224
X$30311 14538 15533 112 113 16191 NAND2_X1
* cell instance $30313 r0 *1 93.29,224
X$30313 15060 15293 15508 113 112 15892 OAI21_X2
* cell instance $30315 m0 *1 93.86,224
X$30315 14497 113 15861 112 BUF_X4
* cell instance $30316 m0 *1 95.38,224
X$30316 15274 14445 14983 16026 113 112 16301 OAI22_X1
* cell instance $30318 m0 *1 96.52,224
X$30318 16271 16228 15718 15927 16245 113 112 16243 OAI221_X1
* cell instance $30319 m0 *1 97.66,224
X$30319 16272 16230 112 113 16273 NAND2_X1
* cell instance $30321 m0 *1 99.75,224
X$30321 16273 16246 14716 113 15599 112 OAI21_X1
* cell instance $30324 m0 *1 105.07,224
X$30324 112 15830 15521 113 BUF_X16
* cell instance $30325 m0 *1 109.82,224
X$30325 14168 14169 16585 113 112 15198 HA_X1
* cell instance $30328 r0 *1 95.38,224
X$30328 15542 113 14765 112 BUF_X4
* cell instance $30329 r0 *1 96.71,224
X$30329 15333 16301 14718 113 16271 112 OAI21_X1
* cell instance $30332 r0 *1 98.04,224
X$30332 14718 113 14859 112 BUF_X4
* cell instance $30338 r0 *1 110.96,224
X$30338 112 15080 14169 113 BUF_X32
* cell instance $30339 m0 *1 114,224
X$30339 14168 14274 16598 113 112 16207 HA_X1
* cell instance $30340 m0 *1 112.1,224
X$30340 15521 14168 16584 113 112 14998 HA_X1
* cell instance $30341 m0 *1 115.9,224
X$30341 112 15830 113 14247 BUF_X8
* cell instance $30343 m0 *1 118.94,224
X$30343 14247 113 15459 112 BUF_X4
* cell instance $30346 m0 *1 120.46,224
X$30346 16288 14620 16247 112 113 16278 MUX2_X1
* cell instance $30347 m0 *1 121.79,224
X$30347 14784 14506 16280 112 113 16289 MUX2_X1
* cell instance $30348 m0 *1 123.12,224
X$30348 14176 112 113 16248 INV_X4
* cell instance $30349 m0 *1 124.07,224
X$30349 16249 14577 16208 112 113 15610 MUX2_X1
* cell instance $30351 m0 *1 126.16,224
X$30351 16280 13695 16588 113 112 14876 HA_X1
* cell instance $30353 m0 *1 128.25,224
X$30353 14142 113 16280 112 BUF_X4
* cell instance $30354 m0 *1 129.58,224
X$30354 15740 113 14506 112 BUF_X4
* cell instance $30356 m0 *1 131.1,224
X$30356 16209 112 113 14784 INV_X2
* cell instance $30358 r0 *1 120.27,224
X$30358 14572 14902 15621 112 113 16247 MUX2_X1
* cell instance $30359 r0 *1 121.6,224
X$30359 16288 14808 16289 112 113 15457 MUX2_X1
* cell instance $30361 r0 *1 123.69,224
X$30361 16280 14274 16249 113 112 16288 HA_X1
* cell instance $30367 r0 *1 126.16,224
X$30367 16280 13695 16634 113 112 16302 HA_X1
* cell instance $30371 r0 *1 130.15,224
X$30371 14169 16101 16636 113 112 16209 HA_X1
* cell instance $30372 m0 *1 132.24,224
X$30372 112 16101 113 14142 BUF_X8
* cell instance $30374 m0 *1 134.71,224
X$30374 112 14389 113 14902 BUF_X8
* cell instance $30378 m0 *1 147.06,224
X$30378 112 15467 16186 113 BUF_X16
* cell instance $30379 m0 *1 151.81,224
X$30379 16281 113 16104 112 BUF_X4
* cell instance $30380 m0 *1 153.14,224
X$30380 14702 113 15140 112 BUF_X4
* cell instance $30381 m0 *1 154.47,224
X$30381 16281 112 113 15364 BUF_X2
* cell instance $30382 m0 *1 155.23,224
X$30382 112 14526 113 15467 BUF_X8
* cell instance $30384 m0 *1 158.46,224
X$30384 16010 112 113 16279 INV_X1
* cell instance $30386 m0 *1 159.03,224
X$30386 14516 16279 15074 112 16276 113 AOI21_X1
* cell instance $30388 m0 *1 159.98,224
X$30388 15366 16290 16276 113 15634 112 OAI21_X1
* cell instance $30389 m0 *1 160.74,224
X$30389 112 16177 14289 15632 15756 113 AOI21_X4
* cell instance $30391 m0 *1 163.4,224
X$30391 112 15311 16104 15632 15756 113 AOI21_X4
* cell instance $30392 m0 *1 165.87,224
X$30392 14702 112 113 14592 CLKBUF_X3
* cell instance $30393 m0 *1 166.82,224
X$30393 15972 14408 14525 113 16266 112 OAI21_X1
* cell instance $30396 r0 *1 132.43,224
X$30396 16159 112 113 15621 INV_X8
* cell instance $30400 r0 *1 143.64,224
X$30400 112 16320 16298 13946 16318 113 DFF_X2
* cell instance $30402 r0 *1 148.77,224
X$30402 16021 112 113 16281 INV_X4
* cell instance $30403 r0 *1 149.72,224
X$30403 15140 16044 16719 113 112 15821 HA_X1
* cell instance $30405 r0 *1 151.81,224
X$30405 15467 15248 14408 113 16282 112 OAI21_X1
* cell instance $30407 r0 *1 152.76,224
X$30407 14262 16044 16716 113 112 15247 HA_X1
* cell instance $30408 r0 *1 154.66,224
X$30408 14289 112 113 14702 CLKBUF_X3
* cell instance $30411 r0 *1 157.51,224
X$30411 15140 16186 16673 113 112 16010 HA_X1
* cell instance $30413 r0 *1 159.79,224
X$30413 15972 14419 14490 113 16290 112 OAI21_X1
* cell instance $30416 r0 *1 166.82,224
X$30416 16186 14419 16619 113 112 14961 HA_X1
* cell instance $30417 m0 *1 168.15,224
X$30417 16104 14707 14961 112 113 16259 MUX2_X1
* cell instance $30421 m0 *1 170.05,224
X$30421 14419 16044 16508 113 112 16216 HA_X1
* cell instance $30423 m0 *1 171.95,224
X$30423 16258 15074 16259 112 113 16219 MUX2_X1
* cell instance $30425 m0 *1 174.04,224
X$30425 15415 16258 16251 112 113 15565 NOR3_X1
* cell instance $30427 r0 *1 170.24,224
X$30427 15140 16186 16700 113 112 16258 HA_X1
* cell instance $30429 m0 *1 175.37,224
X$30429 15415 113 15026 112 BUF_X4
* cell instance $30474 m0 *1 66.69,226.8
X$30474 14846 15208 16589 113 112 16313 HA_X1
* cell instance $30475 m0 *1 68.59,226.8
X$30475 16313 113 15098 112 BUF_X4
* cell instance $30492 r0 *1 67.83,226.8
X$30492 112 14662 14930 113 BUF_X32
* cell instance $30493 m0 *1 71.25,226.8
X$30493 15537 15100 16595 113 112 16285 HA_X1
* cell instance $30495 m0 *1 73.15,226.8
X$30495 15537 15096 16592 113 112 16284 HA_X1
* cell instance $30498 m0 *1 76,226.8
X$30498 14546 14980 14662 112 113 16314 NOR3_X1
* cell instance $30499 m0 *1 76.76,226.8
X$30499 16284 15981 15824 113 16342 112 OAI21_X1
* cell instance $30501 m0 *1 77.71,226.8
X$30501 16316 15500 16314 15329 14445 16315 113 112 AOI221_X2
* cell instance $30504 m0 *1 82.08,226.8
X$30504 15988 14542 14325 112 113 16321 MUX2_X1
* cell instance $30505 m0 *1 83.41,226.8
X$30505 16321 14717 112 113 16305 NOR2_X1
* cell instance $30507 r0 *1 77.14,226.8
X$30507 15823 14887 14444 112 113 16367 MUX2_X1
* cell instance $30508 r0 *1 78.47,226.8
X$30508 15329 16326 14717 112 113 16303 NOR3_X1
* cell instance $30509 r0 *1 79.23,226.8
X$30509 16342 16303 14859 15718 16343 113 112 16351 OAI221_X1
* cell instance $30513 r0 *1 83.03,226.8
X$30513 14444 14379 15723 112 113 16327 NOR3_X1
* cell instance $30514 r0 *1 83.79,226.8
X$30514 16347 16305 14716 113 16304 112 OAI21_X1
* cell instance $30515 m0 *1 84.55,226.8
X$30515 15542 14542 113 112 16323 XNOR2_X1
* cell instance $30517 m0 *1 85.69,226.8
X$30517 15500 16323 15443 14891 15981 16306 112 113 OAI221_X2
* cell instance $30518 m0 *1 87.78,226.8
X$30518 14662 15064 15060 113 16307 112 OAI21_X1
* cell instance $30519 m0 *1 88.54,226.8
X$30519 16307 15405 112 113 16165 NOR2_X1
* cell instance $30521 m0 *1 89.3,226.8
X$30521 14980 112 113 15064 CLKBUF_X3
* cell instance $30523 r0 *1 84.55,226.8
X$30523 16163 16328 14717 113 16348 112 OAI21_X1
* cell instance $30525 r0 *1 85.69,226.8
X$30525 16306 16348 15824 16329 112 15784 113 NAND4_X2
* cell instance $30526 r0 *1 87.4,226.8
X$30526 14856 15405 14846 112 113 16329 NAND3_X1
* cell instance $30529 m0 *1 90.63,226.8
X$30529 14983 15064 15060 113 16324 112 OAI21_X1
* cell instance $30531 r0 *1 91.39,226.8
X$30531 15333 15721 14891 15981 16350 112 113 OAI211_X2
* cell instance $30532 m0 *1 91.96,226.8
X$30532 15098 112 113 14983 CLKBUF_X3
* cell instance $30536 r0 *1 93.1,226.8
X$30536 15824 16350 15405 15892 16325 112 113 OAI211_X2
* cell instance $30537 m0 *1 94.24,226.8
X$30537 15861 16325 15718 16315 16352 112 113 OAI211_X2
* cell instance $30540 m0 *1 96.71,226.8
X$30540 15542 112 113 15333 CLKBUF_X3
* cell instance $30541 m0 *1 97.66,226.8
X$30541 15824 112 113 15718 CLKBUF_X3
* cell instance $30548 r0 *1 95,226.8
X$30548 16352 16351 113 112 16141 AND2_X1
* cell instance $30553 m0 *1 115.14,226.8
X$30553 112 15621 15080 113 BUF_X16
* cell instance $30555 m0 *1 119.89,226.8
X$30555 16248 113 15740 112 BUF_X4
* cell instance $30560 m0 *1 123.12,226.8
X$30560 112 14902 113 16248 BUF_X8
* cell instance $30563 m0 *1 130.34,226.8
X$30563 112 16809 16340 16310 16311 113 DFF_X1
* cell instance $30568 m0 *1 144.4,226.8
X$30568 16318 7895 16317 112 113 16320 MUX2_X1
* cell instance $30573 r0 *1 124.64,226.8
X$30573 16331 112 113 16330 INV_X1
* cell instance $30574 r0 *1 125.02,226.8
X$30574 16353 16332 112 113 16331 NAND2_X1
* cell instance $30577 r0 *1 126.73,226.8
X$30577 5708 16333 16308 113 112 16322 AND3_X1
* cell instance $30578 r0 *1 127.68,226.8
X$30578 16308 16333 3783 113 16353 112 OAI21_X1
* cell instance $30579 r0 *1 128.44,226.8
X$30579 16334 16335 16309 112 113 16308 NOR3_X1
* cell instance $30580 r0 *1 129.2,226.8
X$30580 7895 16333 16309 112 16337 113 AOI21_X1
* cell instance $30583 r0 *1 130.53,226.8
X$30583 16332 112 113 16338 INV_X1
* cell instance $30586 r0 *1 131.48,226.8
X$30586 16349 16338 7974 112 113 16310 NOR3_X1
* cell instance $30587 r0 *1 132.24,226.8
X$30587 16335 112 113 16312 INV_X1
* cell instance $30589 r0 *1 132.81,226.8
X$30589 16340 112 113 16334 BUF_X1
* cell instance $30592 r0 *1 136.8,226.8
X$30592 112 16344 16361 8442 16345 113 DFF_X2
* cell instance $30593 r0 *1 140.41,226.8
X$30593 16345 7895 16383 112 113 16344 MUX2_X1
* cell instance $30597 r0 *1 143.83,226.8
X$30597 10437 7895 16375 112 113 16376 MUX2_X1
* cell instance $30600 r0 *1 145.73,226.8
X$30600 16341 112 113 10437 BUF_X2
* cell instance $30603 m0 *1 155.61,226.8
X$30603 112 14795 16044 113 BUF_X16
* cell instance $30604 m0 *1 153.71,226.8
X$30604 14262 16044 16506 113 112 14970 HA_X1
* cell instance $30608 m0 *1 169.67,226.8
X$30608 14795 113 14598 112 BUF_X4
* cell instance $30696 m0 *1 105.07,232.4
X$30696 112 16795 16391 13630 16355 113 DFF_X1
* cell instance $30703 m0 *1 127.49,232.4
X$30703 112 16819 16309 16356 16311 113 DFF_X1
* cell instance $30704 m0 *1 130.72,232.4
X$30704 112 16807 16360 9839 16311 113 DFF_X1
* cell instance $30709 m0 *1 153.71,232.4
X$30709 8539 112 113 16298 CLKBUF_X3
* cell instance $30710 m0 *1 154.66,232.4
X$30710 16298 112 113 17202 INV_X1
* cell instance $30731 r0 *1 116.85,232.4
X$30731 8133 112 113 16355 CLKBUF_X3
* cell instance $30734 r0 *1 120.08,232.4
X$30734 112 16979 16393 9702 16355 113 DFF_X1
* cell instance $30742 r0 *1 130.15,232.4
X$30742 8539 112 113 16311 CLKBUF_X3
* cell instance $30747 r0 *1 139.65,232.4
X$30747 16361 112 113 16475 CLKBUF_X1
* cell instance $30748 r0 *1 140.22,232.4
X$30748 8539 112 113 16361 CLKBUF_X3
* cell instance $30749 r0 *1 141.17,232.4
X$30749 112 16982 16363 14286 16361 113 DFF_X1
* cell instance $30757 r0 *1 162.45,232.4
X$30757 112 17117 16408 14005 16298 113 DFF_X1
* cell instance $30790 m0 *1 68.78,221.2
X$30790 14800 15533 112 113 16254 NAND2_X1
* cell instance $30791 m0 *1 69.35,221.2
X$30791 112 14943 113 16160 BUF_X8
* cell instance $30792 m0 *1 71.82,221.2
X$30792 14849 16218 16161 16162 15537 113 112 16059 OAI221_X1
* cell instance $30793 m0 *1 72.96,221.2
X$30793 14543 15282 112 113 16195 NOR2_X1
* cell instance $30794 m0 *1 73.53,221.2
X$30794 15508 14127 14934 112 113 16179 NAND3_X1
* cell instance $30796 m0 *1 74.48,221.2
X$30796 16191 16179 113 112 16180 AND2_X1
* cell instance $30815 r0 *1 67.83,221.2
X$30815 14846 15208 16610 113 112 16253 HA_X1
* cell instance $30819 r0 *1 69.73,221.2
X$30819 16253 113 14331 112 BUF_X4
* cell instance $30821 r0 *1 71.25,221.2
X$30821 14543 113 15539 112 BUF_X4
* cell instance $30823 r0 *1 72.77,221.2
X$30823 16195 15539 14161 112 16218 113 AOI21_X1
* cell instance $30825 r0 *1 73.91,221.2
X$30825 14127 113 15824 112 BUF_X4
* cell instance $30826 r0 *1 75.24,221.2
X$30826 16160 14495 14444 112 113 16234 MUX2_X1
* cell instance $30828 m0 *1 75.62,221.2
X$30828 15729 16180 16082 113 16181 112 OAI21_X1
* cell instance $30829 m0 *1 76.57,221.2
X$30829 15950 15688 14807 14856 16220 16182 113 112 AOI221_X2
* cell instance $30830 m0 *1 78.66,221.2
X$30830 14936 113 14717 112 BUF_X4
* cell instance $30832 m0 *1 80.18,221.2
X$30832 14856 16199 16197 113 112 16198 AND3_X1
* cell instance $30833 m0 *1 81.13,221.2
X$30833 16221 16198 15718 112 113 16222 NOR3_X1
* cell instance $30834 m0 *1 81.89,221.2
X$30834 14655 16222 16182 113 15920 112 NOR3_X2
* cell instance $30836 r0 *1 76.57,221.2
X$30836 112 15950 14542 16234 14936 113 AOI21_X4
* cell instance $30837 r0 *1 79.04,221.2
X$30837 15500 14713 16026 16196 112 113 16220 AOI22_X2
* cell instance $30838 r0 *1 80.75,221.2
X$30838 14713 15282 112 113 16197 NAND2_X1
* cell instance $30840 r0 *1 81.51,221.2
X$30840 16262 16197 112 113 15990 NAND2_X1
* cell instance $30842 r0 *1 82.27,221.2
X$30842 15274 14546 14538 113 16262 112 OAI21_X1
* cell instance $30843 r0 *1 83.03,221.2
X$30843 14662 14664 14497 14765 16264 113 112 16236 OAI221_X1
* cell instance $30844 m0 *1 83.79,221.2
X$30844 16225 16164 15405 113 16185 112 NOR3_X2
* cell instance $30847 m0 *1 85.31,221.2
X$30847 14934 14445 15952 113 16187 112 OAI21_X1
* cell instance $30850 r0 *1 84.55,221.2
X$30850 15729 14444 16164 113 16224 112 OAI21_X1
* cell instance $30851 r0 *1 85.31,221.2
X$30851 15722 14331 15508 112 16264 113 AOI21_X1
* cell instance $30852 r0 *1 86.07,221.2
X$30852 15647 113 16225 112 BUF_X4
* cell instance $30853 m0 *1 86.64,221.2
X$30853 15274 15952 15508 15533 14765 16199 112 113 OAI221_X2
* cell instance $30855 m0 *1 88.73,221.2
X$30855 15216 16085 16026 15533 112 113 16241 AOI22_X2
* cell instance $30856 m0 *1 90.44,221.2
X$30856 15722 14377 15729 112 113 16190 NOR3_X1
* cell instance $30857 m0 *1 91.2,221.2
X$30857 14655 15957 16166 113 112 15956 OAI21_X2
* cell instance $30859 r0 *1 87.4,221.2
X$30859 14988 15398 112 113 15443 NAND2_X1
* cell instance $30861 r0 *1 88.16,221.2
X$30861 15714 14546 14543 14662 14713 112 113 16200 AOI221_X1
* cell instance $30862 r0 *1 89.3,221.2
X$30862 14859 16267 16200 112 113 16242 OR3_X1
* cell instance $30864 r0 *1 90.44,221.2
X$30864 14980 14161 112 113 16201 OR2_X1
* cell instance $30865 r0 *1 91.2,221.2
X$30865 16201 15542 16269 112 113 16166 MUX2_X1
* cell instance $30867 r0 *1 92.72,221.2
X$30867 15647 14943 14980 112 16269 113 AOI21_X1
* cell instance $30868 m0 *1 93.67,221.2
X$30868 16190 15537 16137 112 16030 113 AOI21_X1
* cell instance $30869 m0 *1 92.91,221.2
X$30869 15729 14158 16191 112 16228 113 AOI21_X1
* cell instance $30870 m0 *1 94.43,221.2
X$30870 14497 14846 14769 112 16202 113 AOI21_X1
* cell instance $30871 m0 *1 95.19,221.2
X$30871 15508 15274 112 113 16229 NAND2_X1
* cell instance $30872 m0 *1 95.76,221.2
X$30872 16199 15714 16224 16230 113 112 15187 AND4_X1
* cell instance $30877 r0 *1 93.86,221.2
X$30877 16087 16270 16243 112 15788 113 AOI21_X1
* cell instance $30878 r0 *1 94.62,221.2
X$30878 14712 14664 16229 15333 16203 113 112 16244 OAI221_X1
* cell instance $30879 r0 *1 95.76,221.2
X$30879 14377 14983 16026 112 16203 113 AOI21_X1
* cell instance $30881 r0 *1 96.71,221.2
X$30881 16203 15537 112 113 16245 NOR2_X1
* cell instance $30884 r0 *1 98.99,221.2
X$30884 14807 16244 113 112 16246 AND2_X1
* cell instance $30887 m0 *1 106.59,221.2
X$30887 14168 14274 16594 113 112 16204 HA_X1
* cell instance $30889 m0 *1 108.49,221.2
X$30889 13561 16204 112 113 16090 NAND2_X1
* cell instance $30890 m0 *1 109.06,221.2
X$30890 15001 113 13561 112 BUF_X4
* cell instance $30892 m0 *1 111.15,221.2
X$30892 15605 14506 16094 112 113 16193 MUX2_X1
* cell instance $30893 m0 *1 112.48,221.2
X$30893 14176 15357 113 112 16194 XNOR2_X1
* cell instance $30895 m0 *1 113.81,221.2
X$30895 14873 15080 112 113 16167 NOR2_X1
* cell instance $30896 m0 *1 114.38,221.2
X$30896 15550 14730 112 113 16168 OR2_X1
* cell instance $30897 m0 *1 115.14,221.2
X$30897 15830 15001 14168 112 16206 113 AOI21_X1
* cell instance $30898 m0 *1 115.9,221.2
X$30898 16206 16167 15117 16092 14499 113 112 16192 OAI221_X1
* cell instance $30899 m0 *1 117.04,221.2
X$30899 15550 13561 16188 112 113 16095 MUX2_X1
* cell instance $30901 m0 *1 118.56,221.2
X$30901 112 14140 15605 113 BUF_X16
* cell instance $30902 m0 *1 123.31,221.2
X$30902 15008 14902 112 113 14499 NAND2_X2
* cell instance $30903 m0 *1 124.26,221.2
X$30903 15232 15740 15300 113 16208 112 OAI21_X1
* cell instance $30905 r0 *1 108.87,221.2
X$30905 14577 112 113 14620 CLKBUF_X3
* cell instance $30908 r0 *1 110.39,221.2
X$30908 14577 14051 15080 112 113 16205 NOR3_X1
* cell instance $30909 r0 *1 111.15,221.2
X$30909 16194 15080 16205 15307 15605 16077 113 112 AOI221_X2
* cell instance $30911 r0 *1 114,221.2
X$30911 14485 112 113 14808 CLKBUF_X3
* cell instance $30912 r0 *1 114.95,221.2
X$30912 16207 14485 15622 112 113 16154 OR3_X1
* cell instance $30913 r0 *1 115.9,221.2
X$30913 15621 14051 15740 112 113 16274 MUX2_X1
* cell instance $30914 r0 *1 117.23,221.2
X$30914 16207 14730 16274 112 113 16080 MUX2_X1
* cell instance $30915 r0 *1 118.56,221.2
X$30915 15307 15605 112 113 16275 NAND2_X1
* cell instance $30916 r0 *1 119.13,221.2
X$30916 15622 112 113 15117 CLKBUF_X3
* cell instance $30917 r0 *1 120.08,221.2
X$30917 14169 15708 16275 15120 15232 113 112 15744 OAI221_X1
* cell instance $30919 r0 *1 121.41,221.2
X$30919 15357 16248 15307 112 113 NOR2_X4
* cell instance $30920 r0 *1 123.12,221.2
X$30920 15357 112 113 15001 CLKBUF_X3
* cell instance $30924 r0 *1 124.07,221.2
X$30924 16192 15117 16278 113 112 16157 OAI21_X2
* cell instance $30926 m0 *1 125.59,221.2
X$30926 15008 112 113 14577 CLKBUF_X3
* cell instance $30929 r0 *1 125.78,221.2
X$30929 15001 16302 112 113 16042 NAND2_X1
* cell instance $30930 r0 *1 126.35,221.2
X$30930 14730 16189 16042 113 16100 112 OAI21_X1
* cell instance $30931 m0 *1 127.11,221.2
X$30931 14401 14169 14690 112 16151 113 AOI21_X1
* cell instance $30933 m0 *1 127.87,221.2
X$30933 15008 113 14485 112 BUF_X4
* cell instance $30934 m0 *1 129.2,221.2
X$30934 14274 16101 16593 113 112 15550 HA_X1
* cell instance $30936 m0 *1 131.29,221.2
X$30936 14796 14389 14683 112 113 16188 MUX2_X1
* cell instance $30937 m0 *1 132.62,221.2
X$30937 112 14168 113 14683 BUF_X8
* cell instance $30940 m0 *1 141.36,221.2
X$30940 14791 16186 16586 113 112 16232 HA_X1
* cell instance $30941 m0 *1 143.26,221.2
X$30941 16232 112 113 15659 BUF_X2
* cell instance $30943 m0 *1 144.21,221.2
X$30943 16046 112 113 16045 BUF_X2
* cell instance $30944 m0 *1 144.97,221.2
X$30944 14791 16186 16283 113 112 14699 HA_X1
* cell instance $30946 r0 *1 127.11,221.2
X$30946 14906 16075 15876 113 16169 112 OAI21_X1
* cell instance $30948 r0 *1 128.25,221.2
X$30948 15357 14902 112 15120 113 NAND2_X4
* cell instance $30950 r0 *1 130.15,221.2
X$30950 16209 112 113 15812 BUF_X2
* cell instance $30951 r0 *1 130.91,221.2
X$30951 112 14624 113 16209 BUF_X8
* cell instance $30952 r0 *1 133.38,221.2
X$30952 15521 16101 16717 113 112 15463 HA_X1
* cell instance $30953 r0 *1 135.28,221.2
X$30953 15463 112 113 16092 BUF_X1
* cell instance $30957 r0 *1 143.64,221.2
X$30957 7895 113 7974 112 BUF_X4
* cell instance $30958 r0 *1 144.97,221.2
X$30958 16283 113 16021 112 BUF_X4
* cell instance $30959 r0 *1 146.3,221.2
X$30959 14908 112 113 15974 BUF_X2
* cell instance $30960 r0 *1 147.06,221.2
X$30960 112 15011 113 16021 BUF_X8
* cell instance $30961 m0 *1 148.58,221.2
X$30961 16046 112 113 16007 BUF_X1
* cell instance $30962 m0 *1 147.25,221.2
X$30962 15659 113 15259 112 BUF_X4
* cell instance $30963 m0 *1 149.15,221.2
X$30963 14514 16281 14515 112 14594 113 NAND3_X4
* cell instance $30964 m0 *1 151.62,221.2
X$30964 112 14520 14288 15632 15756 113 AOI21_X4
* cell instance $30965 m0 *1 154.09,221.2
X$30965 14600 113 14421 112 BUF_X4
* cell instance $30967 r0 *1 149.53,221.2
X$30967 14515 113 15632 112 BUF_X4
* cell instance $30968 r0 *1 150.86,221.2
X$30968 16021 113 14423 112 BUF_X4
* cell instance $30970 r0 *1 152.57,221.2
X$30970 112 14419 16282 16047 15026 15013 15364 14520 113 AOI222_X2
* cell instance $30973 r0 *1 155.8,221.2
X$30973 14600 113 15415 112 BUF_X4
* cell instance $30974 m0 *1 155.99,221.2
X$30974 14424 15074 16184 113 112 16183 OAI21_X2
* cell instance $30976 m0 *1 157.32,221.2
X$30976 16231 16183 14471 113 16171 112 OAI21_X1
* cell instance $30977 m0 *1 158.08,221.2
X$30977 16170 16171 15023 113 16106 112 OAI21_X1
* cell instance $30978 m0 *1 158.84,221.2
X$30978 16171 16170 112 113 16210 OR2_X1
* cell instance $30980 m0 *1 159.79,221.2
X$30980 15023 16210 16227 16172 113 112 16149 AND4_X1
* cell instance $30981 m0 *1 160.93,221.2
X$30981 16226 14262 16108 112 16227 113 AOI21_X1
* cell instance $30982 m0 *1 161.69,221.2
X$30982 15972 14516 15757 113 16173 112 OAI21_X1
* cell instance $30983 m0 *1 162.45,221.2
X$30983 15479 16173 14962 112 16226 113 AOI21_X1
* cell instance $30986 r0 *1 157.13,221.2
X$30986 15632 15756 14423 112 113 16015 NAND3_X2
* cell instance $30987 r0 *1 158.46,221.2
X$30987 14520 15125 112 113 16277 NAND2_X1
* cell instance $30988 r0 *1 159.03,221.2
X$30988 15089 16044 15015 112 15968 113 AOI21_X1
* cell instance $30989 r0 *1 159.79,221.2
X$30989 15089 16250 16277 112 16170 113 AOI21_X1
* cell instance $30990 r0 *1 160.55,221.2
X$30990 14822 16177 15972 113 16250 112 OAI21_X1
* cell instance $30992 r0 *1 162.07,221.2
X$30992 15366 15259 112 113 16211 NAND2_X1
* cell instance $30993 r0 *1 162.64,221.2
X$30993 14262 16211 16015 112 16212 113 AOI21_X1
* cell instance $30994 r0 *1 163.4,221.2
X$30994 15632 15756 15259 14592 112 113 16257 AOI22_X1
* cell instance $30995 r0 *1 164.35,221.2
X$30995 112 15972 113 14795 BUF_X8
* cell instance $30996 m0 *1 165.3,221.2
X$30996 14423 14412 15089 15479 16174 113 112 16213 OAI221_X1
* cell instance $30998 m0 *1 166.44,221.2
X$30998 15015 14791 14294 112 16214 113 AOI21_X1
* cell instance $30999 m0 *1 167.2,221.2
X$30999 15089 16214 16186 16223 113 112 15842 OAI22_X1
* cell instance $31000 m0 *1 168.15,221.2
X$31000 14822 15248 15304 112 16223 113 AOI21_X1
* cell instance $31001 m0 *1 168.91,221.2
X$31001 15304 15074 14186 16215 16175 16109 113 112 AOI221_X2
* cell instance $31002 m0 *1 171,221.2
X$31002 15304 16186 14791 112 16126 113 AOI21_X1
* cell instance $31003 m0 *1 171.76,221.2
X$31003 15248 14424 112 113 15419 NOR2_X2
* cell instance $31004 m0 *1 172.71,221.2
X$31004 14186 16176 16219 14266 15023 16178 112 113 OAI221_X2
* cell instance $31005 m0 *1 174.8,221.2
X$31005 14423 16177 15089 15140 112 113 15072 AOI22_X2
* cell instance $31008 r0 *1 166.82,221.2
X$31008 16212 16266 16213 113 16114 112 OAI21_X1
* cell instance $31010 r0 *1 167.96,221.2
X$31010 14516 113 14525 112 BUF_X4
* cell instance $31011 r0 *1 169.29,221.2
X$31011 14961 112 113 16215 BUF_X1
* cell instance $31012 r0 *1 169.86,221.2
X$31012 14822 16177 112 113 16175 NOR2_X1
* cell instance $31015 r0 *1 172.14,221.2
X$31015 15248 112 113 15366 CLKBUF_X3
* cell instance $31016 r0 *1 173.09,221.2
X$31016 16257 16216 15026 112 16176 113 AOI21_X1
* cell instance $31017 r0 *1 173.85,221.2
X$31017 16121 15479 15419 112 16217 113 AOI21_X1
* cell instance $31018 r0 *1 174.61,221.2
X$31018 16216 112 113 15414 INV_X1
* cell instance $31020 r0 *1 175.75,221.2
X$31020 15026 16252 112 113 16111 NAND2_X1
* cell instance $31021 r0 *1 176.32,221.2
X$31021 14262 14526 16252 113 112 16251 HA_X1
* cell instance $31022 m0 *1 177.84,221.2
X$31022 16178 112 113 15844 INV_X2
* cell instance $31069 r0 *1 21.85,78.4
X$31069 3811 4776 16605 113 112 4290 HA_X1
* cell instance $31071 m0 *1 23.56,78.4
X$31071 4179 3762 4692 113 112 4609 HA_X1
* cell instance $31072 m0 *1 26.22,78.4
X$31072 4610 4462 4514 112 4693 113 AOI21_X1
* cell instance $31073 m0 *1 26.98,78.4
X$31073 4693 4612 4291 4289 112 113 4568 AOI22_X1
* cell instance $31074 m0 *1 27.93,78.4
X$31074 4568 4067 4515 112 113 4570 MUX2_X1
* cell instance $31075 m0 *1 29.26,78.4
X$31075 4475 3763 112 113 4612 NAND2_X1
* cell instance $31079 r0 *1 25.46,78.4
X$31079 3975 112 113 4628 CLKBUF_X3
* cell instance $31081 r0 *1 26.6,78.4
X$31081 4692 4610 4777 112 113 4842 MUX2_X1
* cell instance $31083 r0 *1 28.12,78.4
X$31083 4614 4074 4612 113 4611 112 OAI21_X1
* cell instance $31086 r0 *1 30.02,78.4
X$31086 4354 112 113 4613 CLKBUF_X3
* cell instance $31087 m0 *1 30.4,78.4
X$31087 4609 4289 4572 113 4571 112 OAI21_X1
* cell instance $31089 m0 *1 31.16,78.4
X$31089 4347 4294 4346 4182 4997 113 112 4572 OAI221_X1
* cell instance $31090 m0 *1 32.3,78.4
X$31090 4065 4293 4294 4347 4064 4573 112 113 OAI221_X2
* cell instance $31092 m0 *1 35.15,78.4
X$31092 4697 4696 3974 112 113 4516 NAND3_X1
* cell instance $31094 m0 *1 37.43,78.4
X$31094 3810 4518 4615 113 4466 112 OAI21_X1
* cell instance $31095 m0 *1 38.19,78.4
X$31095 4628 4619 4519 113 4518 112 OAI21_X1
* cell instance $31097 m0 *1 39.14,78.4
X$31097 4291 4182 4610 113 4519 112 OAI21_X1
* cell instance $31100 m0 *1 40.85,78.4
X$31100 4072 4180 4517 113 4576 112 OAI21_X1
* cell instance $31101 m0 *1 41.61,78.4
X$31101 4576 4182 4578 3916 4137 4618 113 112 AOI221_X2
* cell instance $31102 m0 *1 43.7,78.4
X$31102 4571 4703 4417 4704 4522 4707 113 112 AOI221_X2
* cell instance $31107 r0 *1 31.54,78.4
X$31107 3974 4064 112 113 4474 NAND2_X1
* cell instance $31108 r0 *1 32.11,78.4
X$31108 3852 4891 4414 4573 4185 4847 112 113 OAI221_X2
* cell instance $31109 r0 *1 34.2,78.4
X$31109 4475 4850 112 113 4414 NOR2_X1
* cell instance $31110 r0 *1 34.77,78.4
X$31110 4610 4412 4614 112 113 4696 NAND3_X1
* cell instance $31111 r0 *1 35.53,78.4
X$31111 4015 4180 4517 113 4780 112 OAI21_X1
* cell instance $31115 r0 *1 37.62,78.4
X$31115 4413 112 113 4616 CLKBUF_X2
* cell instance $31118 r0 *1 40.09,78.4
X$31118 3974 4064 112 113 4703 NOR2_X2
* cell instance $31121 r0 *1 41.99,78.4
X$31121 4296 4072 4613 112 4617 113 AOI21_X1
* cell instance $31123 r0 *1 43.13,78.4
X$31123 5004 4614 3861 112 4704 113 AOI21_X1
* cell instance $31124 r0 *1 43.89,78.4
X$31124 4702 4514 4354 112 4785 113 AOI21_X1
* cell instance $31125 r0 *1 44.65,78.4
X$31125 4294 4347 4614 113 4620 112 NOR3_X2
* cell instance $31126 r0 *1 45.98,78.4
X$31126 4787 4706 4621 112 113 4705 NAND3_X1
* cell instance $31128 m0 *1 47.69,78.4
X$31128 4618 4623 4584 112 4706 113 AOI21_X1
* cell instance $31129 m0 *1 46.93,78.4
X$31129 4025 4707 4705 113 4588 112 OAI21_X1
* cell instance $31130 m0 *1 48.45,78.4
X$31130 3866 4619 4710 113 4584 112 OAI21_X1
* cell instance $31132 r0 *1 47.12,78.4
X$31132 3855 4616 3863 112 4622 113 AOI21_X1
* cell instance $31135 m0 *1 49.78,78.4
X$31135 3810 4069 112 113 4623 NOR2_X2
* cell instance $31141 r0 *1 50.73,78.4
X$31141 4624 3865 4570 112 113 4713 MUX2_X1
* cell instance $31142 m0 *1 52.82,78.4
X$31142 3762 4523 3715 4619 113 112 4585 OAI22_X1
* cell instance $31143 m0 *1 51.87,78.4
X$31143 4626 4625 4623 4585 112 113 4627 AOI22_X1
* cell instance $31144 m0 *1 53.77,78.4
X$31144 4628 4422 4574 113 4420 112 OAI21_X1
* cell instance $31145 m0 *1 54.53,78.4
X$31145 4626 4477 4623 4586 112 113 4524 AOI22_X1
* cell instance $31146 m0 *1 55.48,78.4
X$31146 4422 3866 112 113 4525 NAND2_X1
* cell instance $31148 r0 *1 52.06,78.4
X$31148 4861 4627 4713 4025 112 113 4718 AOI22_X2
* cell instance $31150 r0 *1 53.96,78.4
X$31150 4578 4628 4137 112 4716 113 AOI21_X1
* cell instance $31152 r0 *1 55.1,78.4
X$31152 4616 4613 3763 112 113 4715 MUX2_X1
* cell instance $31153 m0 *1 57,78.4
X$31153 4528 4527 4141 112 113 4794 NOR3_X1
* cell instance $31154 m0 *1 56.43,78.4
X$31154 4420 4526 112 113 4528 NOR2_X1
* cell instance $31158 m0 *1 61.75,78.4
X$31158 112 16830 4720 4250 4423 113 DFF_X1
* cell instance $31159 m0 *1 64.98,78.4
X$31159 4719 112 113 5473 BUF_X2
* cell instance $31163 m0 *1 68.21,78.4
X$31163 4529 112 113 4530 INV_X2
* cell instance $31164 m0 *1 68.78,78.4
X$31164 112 4200 4541 113 BUF_X16
* cell instance $31167 r0 *1 56.81,78.4
X$31167 3762 4715 4716 113 4793 112 OAI21_X1
* cell instance $31169 r0 *1 57.95,78.4
X$31169 4864 4081 4718 112 4509 113 AOI21_X2
* cell instance $31174 r0 *1 66.69,78.4
X$31174 4432 3983 16614 113 112 4529 HA_X1
* cell instance $31178 r0 *1 68.59,78.4
X$31178 112 3982 113 4529 BUF_X8
* cell instance $31180 r0 *1 71.25,78.4
X$31180 4867 4026 4637 112 113 NOR2_X4
* cell instance $31181 r0 *1 72.96,78.4
X$31181 4194 113 4797 112 BUF_X4
* cell instance $31182 m0 *1 74.1,78.4
X$31182 4307 4723 4151 4366 4631 4591 112 113 OAI221_X2
* cell instance $31184 m0 *1 76.19,78.4
X$31184 4724 4630 112 113 4147 NOR2_X1
* cell instance $31185 m0 *1 76.76,78.4
X$31185 4533 4387 112 113 4723 NOR2_X2
* cell instance $31186 m0 *1 77.71,78.4
X$31186 4635 4727 4606 4196 4596 4534 113 112 AOI221_X2
* cell instance $31187 m0 *1 79.8,78.4
X$31187 4903 4536 4730 113 112 4596 OAI21_X4
* cell instance $31188 m0 *1 82.27,78.4
X$31188 4638 4599 4380 4260 4601 4603 113 112 AOI221_X2
* cell instance $31189 m0 *1 84.36,78.4
X$31189 4639 4637 4606 4536 4641 112 113 4736 AOI221_X1
* cell instance $31190 m0 *1 85.5,78.4
X$31190 4605 4736 4497 113 4608 112 OAI21_X1
* cell instance $31191 m0 *1 86.26,78.4
X$31191 4875 4539 112 113 4641 NOR2_X1
* cell instance $31192 m0 *1 86.83,78.4
X$31192 4307 4089 112 113 4539 NOR2_X1
* cell instance $31195 r0 *1 74.48,78.4
X$31195 4868 4532 4629 3985 4798 4632 113 112 AOI221_X2
* cell instance $31196 r0 *1 76.57,78.4
X$31196 4631 4530 4639 112 4727 113 AOI21_X1
* cell instance $31197 r0 *1 77.33,78.4
X$31197 3984 4633 4634 4636 112 113 4635 OR4_X1
* cell instance $31198 r0 *1 78.47,78.4
X$31198 4797 4728 4156 4488 4427 112 113 4729 AOI221_X1
* cell instance $31199 r0 *1 79.61,78.4
X$31199 4634 112 113 4535 CLKBUF_X3
* cell instance $31200 r0 *1 80.56,78.4
X$31200 4026 112 113 5094 INV_X2
* cell instance $31202 r0 *1 81.32,78.4
X$31202 4497 4632 4729 112 113 4873 OR3_X2
* cell instance $31203 r0 *1 82.46,78.4
X$31203 4800 4734 112 113 4733 NAND2_X1
* cell instance $31204 r0 *1 83.03,78.4
X$31204 3984 4732 4636 112 113 4744 MUX2_X1
* cell instance $31205 r0 *1 84.36,78.4
X$31205 4083 4640 4091 4745 112 113 4802 AOI22_X1
* cell instance $31206 r0 *1 85.31,78.4
X$31206 4629 4631 112 113 4642 NOR2_X2
* cell instance $31208 r0 *1 86.64,78.4
X$31208 4315 4641 113 112 4804 AND2_X1
* cell instance $31209 r0 *1 87.4,78.4
X$31209 4489 4640 4083 113 4807 112 OAI21_X1
* cell instance $31210 m0 *1 88.54,78.4
X$31210 4606 4540 4644 113 4316 112 OAI21_X1
* cell instance $31211 m0 *1 87.78,78.4
X$31211 4738 4637 112 113 4540 OR2_X1
* cell instance $31212 m0 *1 89.3,78.4
X$31212 4739 4643 4426 112 113 4600 MUX2_X1
* cell instance $31214 r0 *1 88.16,78.4
X$31214 4805 4424 4491 4308 112 113 4644 NAND4_X1
* cell instance $31216 r0 *1 89.3,78.4
X$31216 4488 112 113 4538 CLKBUF_X3
* cell instance $31217 r0 *1 90.25,78.4
X$31217 4387 4535 4157 112 113 4877 NOR3_X1
* cell instance $31218 m0 *1 91.2,78.4
X$31218 4261 4810 4871 112 113 4604 NOR3_X1
* cell instance $31220 m0 *1 91.96,78.4
X$31220 4313 4740 113 112 4741 AND2_X1
* cell instance $31222 m0 *1 92.91,78.4
X$31222 4500 4091 4380 112 113 4742 OR3_X1
* cell instance $31223 m0 *1 93.86,78.4
X$31223 4539 4318 4639 112 113 4646 NOR3_X1
* cell instance $31225 m0 *1 95.38,78.4
X$31225 4095 4541 16567 113 112 4748 HA_X1
* cell instance $31230 r0 *1 91.96,78.4
X$31230 4640 4535 4541 113 4740 112 OAI21_X1
* cell instance $31231 r0 *1 92.72,78.4
X$31231 4156 4148 112 113 4645 NAND2_X1
* cell instance $31232 r0 *1 93.29,78.4
X$31232 4744 4253 4645 4535 4196 4647 113 112 AOI221_X2
* cell instance $31233 r0 *1 95.38,78.4
X$31233 4745 3870 112 113 4648 NOR2_X1
* cell instance $31237 r0 *1 98.42,78.4
X$31237 4747 4748 4538 112 113 4812 OR3_X1
* cell instance $31239 m0 *1 98.42,78.4
X$31239 4157 4541 4649 113 112 4747 HA_X1
* cell instance $31242 m0 *1 102.79,78.4
X$31242 4279 112 113 4203 CLKBUF_X3
* cell instance $31245 m0 *1 108.3,78.4
X$31245 207 3335 4750 112 113 4751 MUX2_X1
* cell instance $31252 r0 *1 106.4,78.4
X$31252 4890 4973 112 113 4750 XOR2_X1
* cell instance $31255 r0 *1 108.11,78.4
X$31255 112 17090 4752 4751 4097 113 DFF_X1
* cell instance $31256 r0 *1 111.34,78.4
X$31256 4752 112 113 4890 BUF_X2
* cell instance $31258 m0 *1 112.48,78.4
X$31258 173 3105 4753 112 113 4756 MUX2_X1
* cell instance $31260 m0 *1 113.81,78.4
X$31260 112 16860 4757 4756 4652 113 DFF_X1
* cell instance $31264 r0 *1 112.48,78.4
X$31264 4650 4755 113 112 4753 XNOR2_X1
* cell instance $31266 r0 *1 114,78.4
X$31266 4754 3776 4755 112 4651 113 AOI21_X1
* cell instance $31268 r0 *1 114.95,78.4
X$31268 214 3530 112 113 4754 NOR2_X1
* cell instance $31271 r0 *1 116.47,78.4
X$31271 4757 112 113 4650 CLKBUF_X3
* cell instance $31272 r0 *1 117.42,78.4
X$31272 112 4761 4543 4509 4652 113 DFF_X1
* cell instance $31274 m0 *1 119.7,78.4
X$31274 3621 4543 112 113 4544 XOR2_X1
* cell instance $31275 m0 *1 122.36,78.4
X$31275 4653 4762 112 113 3626 XNOR2_X2
* cell instance $31276 m0 *1 124.26,78.4
X$31276 4763 3621 113 4653 112 XOR2_X2
* cell instance $31280 r0 *1 121.41,78.4
X$31280 4889 113 1831 112 BUF_X4
* cell instance $31281 r0 *1 122.74,78.4
X$31281 4659 4543 113 112 4762 XNOR2_X1
* cell instance $31286 r0 *1 124.64,78.4
X$31286 4653 4761 113 4654 112 XOR2_X2
* cell instance $31288 m0 *1 130.34,78.4
X$31288 4765 112 113 4322 CLKBUF_X3
* cell instance $31289 m0 *1 127.11,78.4
X$31289 112 16776 4765 4764 4057 113 DFF_X1
* cell instance $31296 m0 *1 131.86,78.4
X$31296 3531 3289 112 113 4594 XOR2_X1
* cell instance $31298 m0 *1 133,78.4
X$31298 4656 4594 113 112 4593 XNOR2_X1
* cell instance $31300 m0 *1 134.9,78.4
X$31300 4769 4657 113 112 3374 XNOR2_X1
* cell instance $31303 m0 *1 137.75,78.4
X$31303 4510 4593 113 112 3994 XNOR2_X1
* cell instance $31305 m0 *1 140.41,78.4
X$31305 4404 4771 113 112 4592 XNOR2_X1
* cell instance $31307 r0 *1 131.86,78.4
X$31307 4655 3289 112 113 4100 XNOR2_X2
* cell instance $31308 r0 *1 133.76,78.4
X$31308 4098 4655 113 112 4657 XNOR2_X1
* cell instance $31309 r0 *1 134.9,78.4
X$31309 4172 3289 113 112 4882 XNOR2_X1
* cell instance $31313 r0 *1 138.7,78.4
X$31313 3736 4658 112 113 4770 XOR2_X1
* cell instance $31314 r0 *1 139.84,78.4
X$31314 4405 4770 113 112 4771 XNOR2_X1
* cell instance $31316 r0 *1 141.74,78.4
X$31316 4658 3747 113 112 4772 XNOR2_X1
* cell instance $31317 m0 *1 142.12,78.4
X$31317 4774 4772 113 112 4402 XNOR2_X1
* cell instance $31322 m0 *1 143.64,78.4
X$31322 4098 3680 113 112 4773 XNOR2_X1
* cell instance $31324 m0 *1 147.06,78.4
X$31324 3945 4546 112 113 4217 XNOR2_X2
* cell instance $31325 m0 *1 148.96,78.4
X$31325 112 4215 2908 113 BUF_X16
* cell instance $31326 m0 *1 153.71,78.4
X$31326 4590 113 4547 112 BUF_X4
* cell instance $31328 m0 *1 155.23,78.4
X$31328 4547 3180 2797 112 113 NOR2_X4
* cell instance $31330 r0 *1 143.64,78.4
X$31330 4658 4773 112 113 4173 XNOR2_X2
* cell instance $31334 r0 *1 146.87,78.4
X$31334 124 3783 112 113 4815 NOR2_X1
* cell instance $31335 r0 *1 147.44,78.4
X$31335 4215 113 4775 112 BUF_X4
* cell instance $31336 r0 *1 148.77,78.4
X$31336 112 4324 4660 4775 2963 113 NOR3_X4
* cell instance $31338 r0 *1 151.62,78.4
X$31338 4103 113 2463 112 BUF_X4
* cell instance $31340 r0 *1 153.14,78.4
X$31340 112 4547 4660 4324 3487 113 NOR3_X4
* cell instance $31341 r0 *1 155.8,78.4
X$31341 112 3272 113 4547 BUF_X8
* cell instance $31342 m0 *1 158.65,78.4
X$31342 3292 113 4438 112 BUF_X4
* cell instance $31343 m0 *1 157.32,78.4
X$31343 4214 113 2804 112 BUF_X4
* cell instance $31345 m0 *1 160.17,78.4
X$31345 2797 4438 4436 113 4818 112 NOR3_X2
* cell instance $31346 m0 *1 161.5,78.4
X$31346 3382 4501 4589 113 4661 112 OAI21_X1
* cell instance $31347 m0 *1 162.26,78.4
X$31347 2574 3267 2976 113 4589 112 OAI21_X1
* cell instance $31350 r0 *1 158.65,78.4
X$31350 3591 2463 3895 113 4876 112 OAI21_X1
* cell instance $31351 r0 *1 159.41,78.4
X$31351 112 3272 4042 113 INV_X16
* cell instance $31352 r0 *1 162.64,78.4
X$31352 4766 4217 4661 112 113 4820 MUX2_X1
* cell instance $31354 m0 *1 163.4,78.4
X$31354 4768 4819 2684 3267 4327 113 112 3891 OAI221_X1
* cell instance $31356 m0 *1 165.49,78.4
X$31356 3292 3270 3657 112 113 4821 NOR3_X1
* cell instance $31357 m0 *1 166.25,78.4
X$31357 3294 4169 112 113 4760 OR2_X1
* cell instance $31359 r0 *1 163.97,78.4
X$31359 3294 4662 112 113 4768 OR2_X1
* cell instance $31361 r0 *1 164.92,78.4
X$31361 2963 113 4663 112 BUF_X4
* cell instance $31362 r0 *1 166.25,78.4
X$31362 4767 3761 3274 112 4766 113 AOI21_X1
* cell instance $31363 r0 *1 167.01,78.4
X$31363 3296 4758 3382 4760 4001 4822 112 113 OAI221_X2
* cell instance $31364 m0 *1 167.58,78.4
X$31364 2471 2403 3659 112 113 4548 MUX2_X1
* cell instance $31366 m0 *1 168.91,78.4
X$31366 4759 113 3339 112 BUF_X4
* cell instance $31367 m0 *1 170.24,78.4
X$31367 2804 2408 112 113 3761 NAND2_X1
* cell instance $31368 m0 *1 170.81,78.4
X$31368 2908 4438 4436 113 112 4330 OAI21_X4
* cell instance $31369 m0 *1 173.28,78.4
X$31369 2475 2804 4549 113 4583 112 OAI21_X1
* cell instance $31370 m0 *1 174.04,78.4
X$31370 4749 4440 2683 113 4550 112 OAI21_X1
* cell instance $31371 m0 *1 174.8,78.4
X$31371 4666 3659 3594 113 4549 112 OAI21_X1
* cell instance $31372 m0 *1 175.56,78.4
X$31372 2464 2517 112 113 4666 NOR2_X1
* cell instance $31373 m0 *1 176.13,78.4
X$31373 2916 4550 2918 4552 112 113 4582 AOI22_X1
* cell instance $31374 m0 *1 177.08,78.4
X$31374 4486 4219 112 113 4581 OR2_X1
* cell instance $31375 m0 *1 177.84,78.4
X$31375 4668 2354 4553 112 4552 113 AOI21_X1
* cell instance $31376 m0 *1 178.6,78.4
X$31376 4737 3339 2576 112 4669 113 AOI21_X1
* cell instance $31377 m0 *1 179.36,78.4
X$31377 4058 4330 3267 112 113 4670 NAND3_X2
* cell instance $31378 m0 *1 180.69,78.4
X$31378 4827 3596 2512 3698 4579 112 113 4731 AOI221_X1
* cell instance $31379 m0 *1 181.83,78.4
X$31379 4731 3087 4577 112 4671 113 AOI21_X1
* cell instance $31380 m0 *1 182.59,78.4
X$31380 4671 4278 112 113 3700 NOR2_X1
* cell instance $31383 r0 *1 169.1,78.4
X$31383 4663 4662 112 4758 113 OR2_X4
* cell instance $31385 r0 *1 171,78.4
X$31385 4438 4436 2472 113 4665 112 OAI21_X1
* cell instance $31386 r0 *1 171.76,78.4
X$31386 3296 4665 4384 112 4749 113 AOI21_X1
* cell instance $31388 r0 *1 172.9,78.4
X$31388 4924 4383 112 113 3210 NOR2_X2
* cell instance $31389 r0 *1 173.85,78.4
X$31389 2471 3482 2918 2354 4746 113 112 4824 OAI221_X1
* cell instance $31390 r0 *1 174.99,78.4
X$31390 3083 3482 3087 2354 4743 113 112 4825 OAI221_X1
* cell instance $31391 r0 *1 176.13,78.4
X$31391 4667 3697 112 113 4746 NOR2_X1
* cell instance $31392 r0 *1 176.7,78.4
X$31392 2806 4664 112 113 4743 NOR2_X1
* cell instance $31395 r0 *1 177.84,78.4
X$31395 4373 4737 3689 112 113 4668 NOR3_X1
* cell instance $31397 r0 *1 178.98,78.4
X$31397 2358 4669 4670 113 4863 112 OAI21_X1
* cell instance $31402 r0 *1 180.12,78.4
X$31402 3200 4670 4735 113 112 3794 AND3_X2
* cell instance $31403 r0 *1 181.26,78.4
X$31403 4664 4662 3450 113 4735 112 OAI21_X1
* cell instance $31405 r0 *1 182.21,78.4
X$31405 4664 4662 3450 112 113 4113 NOR3_X1
* cell instance $31409 r0 *1 186.96,78.4
X$31409 4858 3947 116 112 113 4828 MUX2_X1
* cell instance $31412 m0 *1 189.62,78.4
X$31412 3303 4555 113 112 4442 XNOR2_X1
* cell instance $31414 r0 *1 189.81,78.4
X$31414 4672 3303 113 112 4857 XNOR2_X1
* cell instance $31415 r0 *1 190.95,78.4
X$31415 4269 3303 112 113 4674 XNOR2_X2
* cell instance $31416 m0 *1 192.09,78.4
X$31416 4556 4675 112 2036 113 NAND2_X4
* cell instance $31418 m0 *1 193.8,78.4
X$31418 4675 4556 113 112 4725 AND2_X1
* cell instance $31420 m0 *1 195.32,78.4
X$31420 112 2481 113 4725 BUF_X8
* cell instance $31421 m0 *1 197.79,78.4
X$31421 3465 4557 112 113 4721 NAND2_X1
* cell instance $31424 m0 *1 199.31,78.4
X$31424 4673 113 4223 112 BUF_X4
* cell instance $31426 m0 *1 201.4,78.4
X$31426 4558 4717 2731 112 113 NOR2_X4
* cell instance $31427 m0 *1 203.11,78.4
X$31427 4559 112 113 4560 INV_X1
* cell instance $31429 m0 *1 203.68,78.4
X$31429 112 2148 4223 4714 4560 113 AOI21_X4
* cell instance $31431 r0 *1 192.85,78.4
X$31431 4659 4726 112 113 3314 XNOR2_X2
* cell instance $31432 r0 *1 194.75,78.4
X$31432 4726 4659 113 3147 112 XOR2_X2
* cell instance $31433 r0 *1 196.46,78.4
X$31433 3465 4650 112 113 4722 NAND2_X1
* cell instance $31434 r0 *1 197.03,78.4
X$31434 4676 4557 112 113 4829 NOR2_X1
* cell instance $31435 r0 *1 197.6,78.4
X$31435 4722 4721 4677 113 112 4714 MUX2_X2
* cell instance $31436 r0 *1 199.31,78.4
X$31436 4650 112 113 4557 INV_X1
* cell instance $31439 r0 *1 201.59,78.4
X$31439 4678 4557 112 113 4949 NAND2_X2
* cell instance $31440 r0 *1 202.54,78.4
X$31440 2138 4558 4559 113 112 3807 OAI21_X2
* cell instance $31441 r0 *1 203.87,78.4
X$31441 4559 112 113 4717 BUF_X1
* cell instance $31445 m0 *1 206.53,78.4
X$31445 2257 4714 4560 112 4711 113 AOI21_X1
* cell instance $31448 r0 *1 207.29,78.4
X$31448 2596 2607 16642 113 112 4852 HA_X1
* cell instance $31449 m0 *1 208.43,78.4
X$31449 3065 4679 4561 112 4712 113 AOI21_X1
* cell instance $31450 m0 *1 207.67,78.4
X$31450 4115 3441 2596 112 113 4561 NAND3_X1
* cell instance $31452 r0 *1 209.19,78.4
X$31452 2401 2495 3027 112 113 4679 NAND3_X1
* cell instance $31453 m0 *1 209.76,78.4
X$31453 4562 4712 2927 112 113 4708 NOR3_X1
* cell instance $31455 m0 *1 210.52,78.4
X$31455 2814 113 3234 112 BUF_X4
* cell instance $31456 m0 *1 211.85,78.4
X$31456 4680 2814 112 113 4150 OR2_X1
* cell instance $31457 m0 *1 212.61,78.4
X$31457 4711 3234 2595 112 113 4447 NOR3_X1
* cell instance $31462 r0 *1 210.9,78.4
X$31462 2382 4852 4709 112 113 4445 NOR3_X1
* cell instance $31464 r0 *1 212.04,78.4
X$31464 2950 1862 4680 113 112 4709 HA_X1
* cell instance $31465 r0 *1 213.94,78.4
X$31465 3713 4708 4681 113 4851 112 OAI21_X1
* cell instance $31466 m0 *1 214.7,78.4
X$31466 2257 2401 113 112 4450 AND2_X1
* cell instance $31469 m0 *1 215.65,78.4
X$31469 3234 3314 112 113 4563 NOR2_X1
* cell instance $31471 r0 *1 214.7,78.4
X$31471 3129 3314 112 113 4681 NOR2_X1
* cell instance $31473 r0 *1 215.46,78.4
X$31473 3027 2401 2495 112 4701 113 AOI21_X1
* cell instance $31474 r0 *1 216.22,78.4
X$31474 4849 3034 3533 112 113 4846 MUX2_X1
* cell instance $31475 m0 *1 216.79,78.4
X$31475 4564 4701 3034 113 4565 112 OAI21_X1
* cell instance $31478 m0 *1 219.07,78.4
X$31478 2814 3147 112 113 3800 NAND2_X2
* cell instance $31480 r0 *1 217.55,78.4
X$31480 4565 3145 2926 112 113 4700 NAND3_X1
* cell instance $31481 r0 *1 218.31,78.4
X$31481 3800 3129 112 113 4834 NOR2_X1
* cell instance $31483 r0 *1 219.07,78.4
X$31483 4694 4700 4563 112 113 4835 NAND3_X1
* cell instance $31485 r0 *1 220.21,78.4
X$31485 3800 2926 112 113 4843 NOR2_X1
* cell instance $31487 m0 *1 220.4,78.4
X$31487 3065 3147 112 113 4119 NOR2_X2
* cell instance $31490 r0 *1 221.35,78.4
X$31490 3622 4682 4683 112 4699 113 AOI21_X1
* cell instance $31491 m0 *1 222.3,78.4
X$31491 3129 3918 4695 4569 2607 113 112 4683 OAI221_X1
* cell instance $31492 m0 *1 221.73,78.4
X$31492 3065 3314 112 113 3620 NAND2_X1
* cell instance $31494 m0 *1 223.63,78.4
X$31494 4229 4698 3129 113 4695 112 OAI21_X1
* cell instance $31496 m0 *1 225.15,78.4
X$31496 3027 4566 3317 112 4684 113 AOI21_X1
* cell instance $31497 m0 *1 225.91,78.4
X$31497 2589 4686 3441 112 4685 113 AOI21_X1
* cell instance $31499 r0 *1 222.11,78.4
X$31499 3620 3034 112 113 4682 NOR2_X1
* cell instance $31502 r0 *1 226.1,78.4
X$31502 4684 4685 112 113 4349 NOR2_X1
* cell instance $31505 m0 *1 227.05,78.4
X$31505 2382 1870 112 113 4686 NAND2_X1
* cell instance $31506 m0 *1 227.81,78.4
X$31506 2927 3611 112 113 4687 OR2_X1
* cell instance $31508 r0 *1 227.43,78.4
X$31508 2950 3317 4686 112 4688 113 AOI21_X1
* cell instance $31509 r0 *1 228.19,78.4
X$31509 4687 4688 3129 3034 4691 113 112 4694 OAI221_X1
* cell instance $31511 m0 *1 228.95,78.4
X$31511 2596 1862 16537 113 112 4338 HA_X1
* cell instance $31514 m0 *1 238.64,78.4
X$31514 4838 112 113 4266 BUF_X1
* cell instance $31515 m0 *1 239.21,78.4
X$31515 4690 112 113 4689 BUF_X1
* cell instance $31521 r0 *1 234.84,78.4
X$31521 4837 112 113 4575 BUF_X1
.ENDS aes_cipher_top

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell INV_X32
* pin PWELL,VSS
* pin A
* pin ZN
* pin NWELL,VDD
.SUBCKT INV_X32 1 2 3 4
* net 1 PWELL,VSS
* net 2 A
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 4 4 PMOS_VTL L=0.05U W=20.16U AS=1.43325P AD=1.43325P PS=25.34U
+ PD=25.34U
* device instance $33 r0 *1 0.185,0.2975 NMOS_VTL
M$33 3 2 1 1 NMOS_VTL L=0.05U W=13.28U AS=0.944125P AD=0.944125P PS=18.245U
+ PD=18.245U
.ENDS INV_X32

* cell AOI211_X4
* pin C1
* pin C2
* pin B
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI211_X4 1 2 3 4 8 9 10
* net 1 C1
* net 2 C2
* net 3 B
* net 4 A
* net 8 PWELL,VSS
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 6 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 3 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 11 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 6 9 9 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 5 9 9 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 12 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 8 2 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 6 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 5 6 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 10 5 8 8 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U
+ PD=2.705U
.ENDS AOI211_X4

* cell AND3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AND3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 4 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 3 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 11 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 10 2 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 4 3 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 9 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.12,0.2975 NMOS_VTL
M$16 5 1 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND3_X4

* cell AND2_X4
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT AND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 3 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 8 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.55,0.2975 NMOS_VTL
M$11 7 2 3 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.74,0.2975 NMOS_VTL
M$12 6 1 7 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 3 6 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND2_X4

* cell OR2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT OR2_X4 1 2 3 5 6
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 4 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 4 3 3 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR2_X4

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell OAI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin A2
* pin ZN
* pin A1
* pin NWELL,VDD
.SUBCKT OAI22_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 4 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 8 3 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 3 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 14 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 8 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 15 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 15 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 8 5 16 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 1 3 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 2 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI22_X4

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X8 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell AOI222_X2
* pin PWELL,VSS
* pin C2
* pin C1
* pin ZN
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT AOI222_X2 1 2 3 4 5 6 8 9 16
* net 1 PWELL,VSS
* net 2 C2
* net 3 C1
* net 4 ZN
* net 5 B2
* net 6 B1
* net 8 A1
* net 9 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 17 5 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 15 6 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 4 8 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $11 r0 *1 2.255,0.995 PMOS_VTL
M$11 4 9 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 10 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 4 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.31,0.2975 NMOS_VTL
M$19 14 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.5,0.2975 NMOS_VTL
M$20 1 5 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 4 8 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $22 r0 *1 2.065,0.2975 NMOS_VTL
M$22 11 8 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.255,0.2975 NMOS_VTL
M$23 1 9 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.445,0.2975 NMOS_VTL
M$24 7 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI222_X2

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell OAI222_X2
* pin PWELL,VSS
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT OAI222_X2 1 4 5 6 7 8 9 10 11
* net 1 PWELL,VSS
* net 4 C1
* net 5 C2
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 ZN
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 12 4 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.405,0.995 PMOS_VTL
M$2 11 5 12 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.595,0.995 PMOS_VTL
M$3 13 5 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.785,0.995 PMOS_VTL
M$4 10 4 13 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 14 6 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.165,0.995 PMOS_VTL
M$6 11 7 14 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.355,0.995 PMOS_VTL
M$7 15 7 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.545,0.995 PMOS_VTL
M$8 10 6 15 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0945P PS=0.77U PD=0.93U
* device instance $9 r0 *1 1.895,0.995 PMOS_VTL
M$9 16 8 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0945P AD=0.0441P PS=0.93U PD=0.77U
* device instance $10 r0 *1 2.085,0.995 PMOS_VTL
M$10 11 9 16 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.275,0.995 PMOS_VTL
M$11 17 9 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.465,0.995 PMOS_VTL
M$12 10 8 17 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0693P PS=0.77U PD=1.48U
* device instance $13 r0 *1 1.895,0.2975 NMOS_VTL
M$13 10 8 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $14 r0 *1 2.085,0.2975 NMOS_VTL
M$14 3 9 10 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 0.215,0.2975 NMOS_VTL
M$17 1 4 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $18 r0 *1 0.405,0.2975 NMOS_VTL
M$18 2 5 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 0.975,0.2975 NMOS_VTL
M$21 3 6 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $22 r0 *1 1.165,0.2975 NMOS_VTL
M$22 2 7 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI222_X2

* cell OAI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X2 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 12 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 4 12 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 11 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 6 3 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 7 1 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 5 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 8 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.12,0.2975 NMOS_VTL
M$14 5 4 8 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI22_X2

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell INV_X16
* pin PWELL,VSS
* pin A
* pin ZN
* pin NWELL,VDD
.SUBCKT INV_X16 1 2 3 4
* net 1 PWELL,VSS
* net 2 A
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 4 4 PMOS_VTL L=0.05U W=10.08U AS=0.72765P AD=0.72765P PS=13.02U
+ PD=13.02U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.479325P AD=0.479325P PS=9.365U
+ PD=9.365U
.ENDS INV_X16

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell AND4_X4
* pin PWELL,VSS
* pin A4
* pin A3
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT AND4_X4 1 2 3 4 6 7 14
* net 1 PWELL,VSS
* net 2 A4
* net 3 A3
* net 4 A2
* net 6 A1
* net 7 ZN
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 14 3 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 5 4 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 14 6 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 7 5 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.375,0.2975 NMOS_VTL
M$14 9 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.565,0.2975 NMOS_VTL
M$15 10 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.755,0.2975 NMOS_VTL
M$16 5 6 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 12 6 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 11 4 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 13 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 2 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 7 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND4_X4

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell MUX2_X2
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin Z
.SUBCKT MUX2_X2 1 2 3 6 7 8
* net 1 A
* net 2 B
* net 3 S
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 Z
* device instance $1 r0 *1 1.16,0.995 PMOS_VTL
M$1 8 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.077175P PS=2.24U PD=1.54U
* device instance $3 r0 *1 1.54,1.1525 PMOS_VTL
M$3 9 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $4 r0 *1 0.215,0.995 PMOS_VTL
M$4 6 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $5 r0 *1 0.405,0.995 PMOS_VTL
M$5 5 9 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 0.595,0.995 PMOS_VTL
M$6 4 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.045675P PS=0.77U PD=0.775U
* device instance $7 r0 *1 0.79,0.995 PMOS_VTL
M$7 5 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.045675P AD=0.0693P PS=0.775U PD=1.48U
* device instance $8 r0 *1 1.54,0.195 NMOS_VTL
M$8 9 3 7 7 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.02205P PS=0.555U PD=0.63U
* device instance $9 r0 *1 1.16,0.2975 NMOS_VTL
M$9 8 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.050925P PS=1.595U
+ PD=1.11U
* device instance $11 r0 *1 0.215,0.2975 NMOS_VTL
M$11 11 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.405,0.2975 NMOS_VTL
M$12 7 9 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.595,0.2975 NMOS_VTL
M$13 10 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $14 r0 *1 0.79,0.2975 NMOS_VTL
M$14 4 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.043575P PS=0.56U
+ PD=1.04U
.ENDS MUX2_X2

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell BUF_X16
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X16 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.3528P PS=6.86U PD=6.16U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 4 3 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.7056P AD=0.72765P PS=12.32U PD=13.02U
* device instance $25 r0 *1 0.185,0.2975 NMOS_VTL
M$25 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.2324P PS=4.925U PD=4.44U
* device instance $33 r0 *1 1.705,0.2975 NMOS_VTL
M$33 4 3 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4648P AD=0.479325P PS=8.88U PD=9.365U
.ENDS BUF_X16

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell BUF_X32
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X32 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.729225P AD=0.707175P PS=13.025U
+ PD=12.325U
* device instance $17 r0 *1 3.215,0.995 PMOS_VTL
M$17 4 3 5 5 PMOS_VTL L=0.05U W=20.16U AS=1.4175P AD=1.43955P PS=24.66U
+ PD=25.36U
* device instance $49 r0 *1 0.17,0.2975 NMOS_VTL
M$49 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4803625P AD=0.4658375P PS=9.37U
+ PD=8.885U
* device instance $65 r0 *1 3.215,0.2975 NMOS_VTL
M$65 4 3 1 1 NMOS_VTL L=0.05U W=13.28U AS=0.93375P AD=0.948275P PS=17.78U
+ PD=18.265U
.ENDS BUF_X32
