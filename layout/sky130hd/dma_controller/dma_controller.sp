* cell dma_controller
* pin channel_length[100]
* pin dst_wdata[17]
* pin dst_wdata[20]
* pin channel_length[10]
* pin debug_transfer_count[10]
* pin channel_length[11]
* pin channel_length[104]
* pin debug_transfer_count[82]
* pin dst_wdata[89]
* pin src_rdata[83]
* pin debug_transfer_count[88]
* pin debug_transfer_count[81]
* pin channel_length[88]
* pin dst_wdata[75]
* pin debug_transfer_count[84]
* pin channel_length[90]
* pin debug_transfer_count[83]
* pin dst_wdata[84]
* pin src_rdata[75]
* pin channel_length[79]
* pin dst_wdata[81]
* pin channel_length[103]
* pin dst_addr[89]
* pin src_rdata[81]
* pin src_rdata[77]
* pin channel_length[102]
* pin channel_length[95]
* pin channel_length[76]
* pin debug_transfer_count[78]
* pin src_rdata[74]
* pin channel_length[77]
* pin dst_wdata[85]
* pin channel_length[94]
* pin dst_addr[90]
* pin channel_length[101]
* pin dst_addr[91]
* pin channel_length[93]
* pin dst_wdata[82]
* pin channel_length[72]
* pin channel_length[73]
* pin dst_addr[92]
* pin channel_length[74]
* pin debug_transfer_count[74]
* pin debug_transfer_count[77]
* pin dst_addr[93]
* pin src_rdata[93]
* pin dst_wdata[66]
* pin src_rdata[66]
* pin dst_wdata[90]
* pin debug_transfer_count[75]
* pin debug_transfer_count[85]
* pin dst_wdata[68]
* pin dst_wdata[93]
* pin src_rdata[92]
* pin dst_wdata[94]
* pin dst_wdata[92]
* pin dst_wstrb[11]
* pin src_rdata[68]
* pin src_rdata[94]
* pin dst_wstrb[10]
* pin src_read[2]
* pin dst_wstrb[9]
* pin dst_wstrb[8]
* pin src_rdata[65]
* pin debug_transfer_count[93]
* pin dst_wdata[69]
* pin src_rdata[70]
* pin src_rdata[91]
* pin dst_wdata[91]
* pin src_rvalid[2]
* pin src_rdata[67]
* pin dst_wdata[70]
* pin dst_wdata[67]
* pin dst_wdata[64]
* pin src_rdata[71]
* pin src_rdata[95]
* pin debug_transfer_count[92]
* pin dst_wdata[65]
* pin dst_wdata[71]
* pin src_rready[2]
* pin debug_transfer_count[95]
* pin debug_transfer_count[91]
* pin dst_wdata[95]
* pin src_rdata[72]
* pin src_rdata[90]
* pin src_rdata[73]
* pin src_rdata[78]
* pin dst_wdata[72]
* pin debug_transfer_count[87]
* pin dst_wdata[78]
* pin debug_transfer_count[94]
* pin src_rdata[82]
* pin src_rdata[80]
* pin channel_length[99]
* pin channel_length[92]
* pin src_rdata[85]
* pin dst_wdata[80]
* pin channel_length[75]
* pin debug_transfer_count[89]
* pin dst_wdata[74]
* pin dst_wdata[79]
* pin debug_transfer_count[90]
* pin debug_transfer_count[86]
* pin channel_length[78]
* pin debug_transfer_count[102]
* pin channel_length[87]
* pin channel_length[86]
* pin src_rdata[84]
* pin src_rdata[88]
* pin src_rdata[76]
* pin dst_wdata[88]
* pin dst_wdata[76]
* pin debug_transfer_count[80]
* pin debug_transfer_count[104]
* pin debug_transfer_count[106]
* pin src_rdata[89]
* pin src_rdata[87]
* pin channel_length[91]
* pin channel_length[89]
* pin debug_transfer_count[79]
* pin dst_wdata[87]
* pin dst_wdata[83]
* pin channel_length[106]
* pin channel_length[83]
* pin channel_length[85]
* pin channel_length[84]
* pin channel_length[82]
* pin channel_length[105]
* pin channel_length[80]
* pin channel_length[81]
* pin channel_length[25]
* pin src_rdata[22]
* pin channel_length[22]
* pin src_rdata[14]
* pin channel_length[16]
* pin src_rdata[15]
* pin dst_wdata[15]
* pin debug_transfer_count[15]
* pin debug_transfer_count[19]
* pin debug_transfer_count[16]
* pin debug_transfer_count[20]
* pin debug_transfer_count[17]
* pin debug_transfer_count[18]
* pin debug_transfer_count[21]
* pin debug_transfer_count[23]
* pin channel_length[18]
* pin debug_transfer_count[22]
* pin debug_transfer_count[11]
* pin debug_transfer_count[12]
* pin debug_transfer_count[24]
* pin debug_transfer_count[14]
* pin channel_length[21]
* pin debug_transfer_count[13]
* pin src_rdata[18]
* pin dst_wdata[21]
* pin debug_transfer_count[25]
* pin dst_wdata[19]
* pin channel_length[17]
* pin dst_wdata[18]
* pin channel_length[19]
* pin channel_length[20]
* pin channel_length[12]
* pin dst_wdata[14]
* pin channel_length[23]
* pin src_rdata[20]
* pin channel_length[24]
* pin src_rdata[16]
* pin dst_wdata[16]
* pin dst_wdata[22]
* pin src_rdata[1]
* pin src_rdata[17]
* pin dst_wdata[1]
* pin channel_length[26]
* pin debug_transfer_count[27]
* pin debug_transfer_count[28]
* pin debug_transfer_count[9]
* pin src_rdata[11]
* pin src_rdata[26]
* pin src_rdata[12]
* pin src_rdata[24]
* pin debug_transfer_count[30]
* pin debug_transfer_count[8]
* pin dst_wdata[24]
* pin dst_wdata[13]
* pin dst_wdata[26]
* pin dst_wdata[12]
* pin dst_wdata[11]
* pin debug_transfer_count[26]
* pin dst_wdata[25]
* pin channel_length[30]
* pin src_rdata[23]
* pin channel_length[28]
* pin channel_length[29]
* pin src_rdata[31]
* pin src_rdata[27]
* pin src_rdata[0]
* pin dst_wdata[31]
* pin dst_wdata[23]
* pin channel_length[31]
* pin dst_wdata[0]
* pin debug_transfer_count[29]
* pin debug_channel_state[0]
* pin src_rdata[29]
* pin src_rdata[28]
* pin dst_wdata[27]
* pin src_rdata[7]
* pin channel_start[0]
* pin src_rdata[9]
* pin dst_wdata[29]
* pin dst_wready[0]
* pin debug_transfer_count[1]
* pin dst_wdata[9]
* pin src_rvalid[0]
* pin debug_channel_state[2]
* pin src_rdata[2]
* pin src_addr[6]
* pin channel_error[0]
* pin dst_wdata[7]
* pin debug_transfer_count[2]
* pin dst_wstrb[0]
* pin dst_wdata[10]
* pin dst_wdata[4]
* pin channel_src_addr[6]
* pin channel_src_addr[5]
* pin src_rdata[3]
* pin src_addr[7]
* pin dst_wdata[3]
* pin channel_src_addr[7]
* pin dst_addr[7]
* pin src_rdata[4]
* pin dst_wstrb[1]
* pin channel_src_addr[8]
* pin channel_src_addr[3]
* pin dst_wdata[5]
* pin src_addr[5]
* pin dst_wdata[8]
* pin dst_addr[10]
* pin dst_write[0]
* pin channel_dst_addr[5]
* pin channel_src_addr[2]
* pin channel_dst_addr[11]
* pin dst_addr[5]
* pin src_addr[2]
* pin dst_addr[13]
* pin channel_dst_addr[9]
* pin channel_src_addr[0]
* pin channel_mode[0]
* pin dst_addr[14]
* pin channel_src_addr[10]
* pin channel_dst_addr[14]
* pin src_addr[15]
* pin channel_src_addr[15]
* pin src_rdata[5]
* pin channel_dst_addr[2]
* pin channel_done[0]
* pin channel_src_addr[12]
* pin channel_dst_addr[3]
* pin channel_src_addr[11]
* pin channel_dst_addr[8]
* pin channel_dst_addr[12]
* pin src_addr[16]
* pin debug_channel_state[1]
* pin channel_dst_addr[10]
* pin channel_src_addr[17]
* pin dst_addr[12]
* pin channel_dst_addr[15]
* pin src_addr[17]
* pin channel_dst_addr[18]
* pin dst_wdata[28]
* pin channel_src_addr[14]
* pin channel_dst_addr[19]
* pin channel_src_addr[13]
* pin dst_addr[0]
* pin channel_dst_addr[17]
* pin channel_src_addr[30]
* pin dst_addr[6]
* pin channel_src_addr[22]
* pin channel_dst_addr[30]
* pin channel_src_addr[4]
* pin channel_dst_addr[29]
* pin channel_src_addr[9]
* pin src_addr[14]
* pin dst_addr[19]
* pin channel_src_addr[21]
* pin dst_addr[29]
* pin src_addr[18]
* pin dst_addr[17]
* pin channel_src_addr[20]
* pin dst_addr[30]
* pin dst_addr[8]
* pin channel_dst_addr[28]
* pin channel_mode[1]
* pin dst_addr[20]
* pin dst_addr[4]
* pin src_addr[19]
* pin channel_enable[0]
* pin channel_dst_addr[31]
* pin dst_addr[28]
* pin src_addr[20]
* pin channel_dst_addr[24]
* pin dst_addr[31]
* pin channel_dst_addr[26]
* pin channel_dst_addr[27]
* pin src_addr[22]
* pin channel_dst_addr[23]
* pin dst_addr[16]
* pin dst_addr[1]
* pin src_addr[8]
* pin channel_dst_addr[1]
* pin dst_addr[2]
* pin src_addr[1]
* pin dst_addr[21]
* pin dst_addr[24]
* pin dst_addr[15]
* pin dst_addr[23]
* pin dst_addr[18]
* pin dst_wdata[6]
* pin channel_dst_addr[13]
* pin dst_addr[27]
* pin channel_dst_addr[20]
* pin channel_dst_addr[6]
* pin channel_dst_addr[16]
* pin channel_src_addr[18]
* pin src_rdata[8]
* pin dst_wstrb[2]
* pin src_addr[0]
* pin channel_dst_addr[25]
* pin dst_addr[9]
* pin src_rdata[10]
* pin channel_src_addr[1]
* pin dst_addr[3]
* pin dst_wdata[2]
* pin channel_dst_addr[0]
* pin channel_src_addr[19]
* pin src_addr[9]
* pin debug_transfer_count[0]
* pin dst_addr[11]
* pin dst_addr[22]
* pin channel_dst_addr[4]
* pin src_rdata[6]
* pin channel_dst_addr[22]
* pin debug_transfer_count[31]
* pin channel_busy[0]
* pin dst_wdata[73]
* pin src_rdata[69]
* pin src_rdata[64]
* pin src_rdata[79]
* pin dst_wdata[77]
* pin src_rdata[86]
* pin dst_wdata[86]
* pin src_rdata[19]
* pin src_rdata[21]
* pin src_rdata[13]
* pin channel_length[27]
* pin src_rdata[25]
* pin src_rdata[30]
* pin dst_wdata[30]
* pin channel_dst_addr[7]
* pin dst_wstrb[3]
* pin channel_src_addr[16]
* pin channel_dst_addr[21]
* pin src_rready[0]
* pin VSS
* pin VDD
* pin debug_transfer_count[76]
* pin channel_length[0]
* pin debug_transfer_count[72]
* pin debug_transfer_count[71]
* pin channel_length[14]
* pin debug_transfer_count[73]
* pin channel_length[13]
* pin src_addr[10]
* pin src_addr[13]
* pin debug_transfer_count[3]
* pin debug_transfer_count[4]
* pin debug_transfer_count[5]
* pin channel_length[15]
* pin src_addr[4]
* pin src_addr[11]
* pin channel_length[1]
* pin channel_length[3]
* pin channel_length[2]
* pin channel_length[9]
* pin channel_length[8]
* pin channel_length[7]
* pin channel_length[5]
* pin channel_length[6]
* pin channel_length[4]
* pin debug_transfer_count[65]
* pin debug_transfer_count[69]
* pin channel_dst_addr[64]
* pin channel_src_addr[91]
* pin debug_transfer_count[66]
* pin channel_src_addr[81]
* pin channel_start[2]
* pin dst_addr[94]
* pin dst_addr[70]
* pin dst_addr[64]
* pin debug_transfer_count[70]
* pin channel_dst_addr[79]
* pin channel_src_addr[70]
* pin debug_transfer_count[67]
* pin debug_transfer_count[68]
* pin debug_channel_state[7]
* pin dst_addr[87]
* pin src_addr[12]
* pin dst_addr[81]
* pin dst_addr[75]
* pin channel_src_addr[76]
* pin channel_dst_addr[95]
* pin src_addr[72]
* pin dst_addr[66]
* pin channel_mode[4]
* pin channel_dst_addr[89]
* pin channel_dst_addr[69]
* pin channel_src_addr[72]
* pin src_addr[21]
* pin src_addr[80]
* pin channel_src_addr[71]
* pin channel_src_addr[64]
* pin dst_addr[88]
* pin channel_dst_addr[66]
* pin channel_dst_addr[78]
* pin channel_dst_addr[88]
* pin src_addr[93]
* pin channel_src_addr[67]
* pin debug_transfer_count[64]
* pin channel_src_addr[84]
* pin channel_dst_addr[82]
* pin dst_addr[72]
* pin channel_dst_addr[93]
* pin src_addr[3]
* pin channel_dst_addr[92]
* pin dst_addr[85]
* pin channel_dst_addr[81]
* pin channel_src_addr[93]
* pin dst_wready[2]
* pin channel_dst_addr[65]
* pin dst_addr[79]
* pin channel_dst_addr[83]
* pin debug_channel_state[8]
* pin channel_dst_addr[74]
* pin dst_addr[80]
* pin dst_addr[76]
* pin channel_dst_addr[68]
* pin channel_done[2]
* pin channel_dst_addr[77]
* pin debug_channel_state[6]
* pin rst_n
* pin dst_addr[68]
* pin channel_dst_addr[90]
* pin channel_dst_addr[84]
* pin dst_addr[95]
* pin channel_error[2]
* pin clk
* pin src_addr[81]
* pin dst_addr[82]
* pin src_addr[74]
* pin dst_addr[84]
* pin channel_dst_addr[80]
* pin channel_dst_addr[87]
* pin src_addr[66]
* pin channel_enable[2]
* pin dst_addr[83]
* pin channel_dst_addr[91]
* pin channel_dst_addr[72]
* pin dst_addr[71]
* pin src_addr[82]
* pin dst_addr[86]
* pin channel_dst_addr[86]
* pin dst_addr[69]
* pin channel_dst_addr[75]
* pin channel_src_addr[85]
* pin channel_dst_addr[85]
* pin dst_addr[74]
* pin channel_dst_addr[70]
* pin channel_dst_addr[94]
* pin dst_addr[73]
* pin channel_dst_addr[67]
* pin src_addr[94]
* pin channel_src_addr[69]
* pin dst_addr[78]
* pin channel_src_addr[75]
* pin channel_length[66]
* pin channel_dst_addr[71]
* pin src_addr[67]
* pin dst_addr[67]
* pin channel_src_addr[87]
* pin channel_dst_addr[73]
* pin src_addr[65]
* pin src_addr[75]
* pin channel_dst_addr[76]
* pin dst_addr[77]
* pin dst_addr[25]
* pin channel_src_addr[74]
* pin dst_write[2]
* pin src_addr[76]
* pin dst_addr[65]
* pin dst_addr[26]
* pin channel_src_addr[68]
* pin src_addr[77]
* pin src_addr[68]
* pin src_addr[79]
* pin channel_src_addr[66]
* pin src_addr[71]
* pin channel_busy[2]
* pin channel_src_addr[36]
* pin channel_length[51]
* pin channel_length[56]
* pin channel_src_addr[37]
* pin src_addr[70]
* pin channel_src_addr[65]
* pin channel_length[58]
* pin channel_src_addr[54]
* pin channel_src_addr[55]
* pin channel_src_addr[77]
* pin src_addr[73]
* pin debug_transfer_count[60]
* pin src_addr[37]
* pin channel_src_addr[24]
* pin channel_mode[5]
* pin src_addr[23]
* pin src_addr[53]
* pin channel_src_addr[73]
* pin src_addr[69]
* pin debug_transfer_count[59]
* pin channel_src_addr[23]
* pin channel_src_addr[79]
* pin src_addr[78]
* pin channel_src_addr[80]
* pin channel_src_addr[57]
* pin src_addr[25]
* pin channel_src_addr[78]
* pin channel_src_addr[92]
* pin channel_src_addr[26]
* pin channel_src_addr[25]
* pin channel_src_addr[82]
* pin src_addr[64]
* pin channel_src_addr[95]
* pin src_addr[24]
* pin channel_src_addr[27]
* pin src_addr[95]
* pin channel_src_addr[94]
* pin channel_src_addr[28]
* pin channel_src_addr[29]
* pin channel_length[65]
* pin channel_src_addr[83]
* pin src_addr[29]
* pin src_addr[26]
* pin channel_src_addr[89]
* pin channel_src_addr[31]
* pin channel_src_addr[86]
* pin channel_src_addr[88]
* pin src_addr[30]
* pin src_addr[28]
* pin channel_src_addr[90]
* pin channel_length[64]
* pin src_addr[86]
* pin src_addr[31]
* pin src_addr[27]
* pin src_read[0]
* pin src_addr[56]
* pin src_addr[92]
* pin src_addr[83]
* pin src_addr[87]
* pin channel_length[67]
* pin channel_length[52]
* pin debug_transfer_count[57]
* pin src_addr[57]
* pin src_addr[85]
* pin src_addr[84]
* pin channel_length[53]
* pin channel_src_addr[59]
* pin src_addr[63]
* pin channel_length[54]
* pin src_addr[89]
* pin channel_length[55]
* pin channel_src_addr[63]
* pin channel_length[71]
* pin src_addr[90]
* pin src_addr[88]
* pin debug_transfer_count[53]
* pin debug_transfer_count[54]
* pin channel_length[69]
* pin src_addr[91]
* pin src_addr[60]
* pin src_addr[58]
* pin src_rdata[112]
* pin dst_wdata[127]
* pin dst_wdata[99]
* pin dst_wdata[112]
* pin src_addr[62]
* pin channel_src_addr[58]
* pin src_rdata[107]
* pin debug_transfer_count[52]
* pin debug_transfer_count[51]
* pin src_rdata[124]
* pin dst_wdata[107]
* pin dst_wdata[98]
* pin debug_transfer_count[55]
* pin channel_src_addr[60]
* pin src_addr[59]
* pin src_rdata[126]
* pin src_rdata[113]
* pin debug_transfer_count[56]
* pin channel_src_addr[62]
* pin dst_wdata[126]
* pin src_rdata[111]
* pin debug_transfer_count[62]
* pin src_addr[55]
* pin dst_wdata[121]
* pin dst_wdata[111]
* pin dst_wdata[113]
* pin src_read[1]
* pin src_addr[38]
* pin src_addr[61]
* pin src_addr[39]
* pin src_rdata[125]
* pin src_rdata[121]
* pin channel_src_addr[61]
* pin dst_wdata[116]
* pin src_rdata[109]
* pin src_rdata[116]
* pin debug_transfer_count[58]
* pin channel_src_addr[56]
* pin src_addr[54]
* pin channel_length[70]
* pin src_rdata[102]
* pin dst_wdata[123]
* pin src_rdata[100]
* pin debug_transfer_count[61]
* pin channel_length[59]
* pin channel_src_addr[38]
* pin dst_wdata[118]
* pin src_rdata[118]
* pin src_rdata[117]
* pin src_addr[36]
* pin src_addr[52]
* pin channel_length[57]
* pin dst_wdata[117]
* pin dst_wdata[122]
* pin channel_length[61]
* pin channel_src_addr[39]
* pin src_rdata[110]
* pin src_rdata[114]
* pin channel_src_addr[53]
* pin channel_src_addr[52]
* pin dst_wdata[120]
* pin src_rdata[120]
* pin dst_wdata[124]
* pin channel_length[60]
* pin src_addr[35]
* pin dst_wdata[114]
* pin src_rdata[108]
* pin src_rdata[122]
* pin src_addr[33]
* pin channel_src_addr[40]
* pin channel_src_addr[51]
* pin dst_wdata[109]
* pin dst_wdata[96]
* pin src_addr[51]
* pin src_addr[50]
* pin channel_src_addr[50]
* pin dst_wdata[110]
* pin src_rdata[123]
* pin channel_src_addr[34]
* pin channel_src_addr[48]
* pin src_rdata[115]
* pin dst_wdata[115]
* pin dst_wdata[108]
* pin src_addr[34]
* pin channel_length[62]
* pin channel_mode[3]
* pin channel_length[68]
* pin dst_wdata[125]
* pin src_addr[32]
* pin channel_src_addr[49]
* pin channel_src_addr[41]
* pin dst_addr[37]
* pin channel_src_addr[33]
* pin channel_enable[1]
* pin channel_src_addr[32]
* pin channel_length[63]
* pin src_addr[48]
* pin dst_addr[35]
* pin debug_transfer_count[63]
* pin src_addr[45]
* pin channel_dst_addr[37]
* pin src_addr[40]
* pin channel_src_addr[45]
* pin src_addr[46]
* pin dst_wready[1]
* pin channel_src_addr[47]
* pin debug_channel_state[4]
* pin channel_src_addr[43]
* pin src_addr[41]
* pin channel_dst_addr[41]
* pin channel_start[1]
* pin dst_addr[52]
* pin src_addr[44]
* pin src_addr[49]
* pin dst_addr[36]
* pin dst_addr[34]
* pin channel_dst_addr[53]
* pin channel_dst_addr[35]
* pin dst_addr[53]
* pin channel_dst_addr[48]
* pin channel_dst_addr[57]
* pin src_rready[1]
* pin dst_addr[50]
* pin channel_dst_addr[47]
* pin dst_addr[40]
* pin dst_addr[41]
* pin channel_src_addr[42]
* pin debug_channel_state[3]
* pin src_addr[43]
* pin channel_dst_addr[51]
* pin channel_dst_addr[61]
* pin channel_dst_addr[50]
* pin channel_dst_addr[52]
* pin channel_dst_addr[62]
* pin src_addr[42]
* pin channel_dst_addr[38]
* pin channel_dst_addr[44]
* pin dst_write[1]
* pin dst_addr[62]
* pin dst_addr[39]
* pin channel_mode[2]
* pin debug_channel_state[5]
* pin dst_addr[48]
* pin channel_dst_addr[49]
* pin dst_addr[61]
* pin dst_addr[59]
* pin channel_src_addr[44]
* pin channel_dst_addr[40]
* pin channel_dst_addr[54]
* pin dst_addr[55]
* pin dst_addr[60]
* pin dst_addr[51]
* pin channel_dst_addr[36]
* pin channel_dst_addr[63]
* pin channel_dst_addr[60]
* pin dst_addr[58]
* pin channel_dst_addr[58]
* pin channel_dst_addr[45]
* pin channel_dst_addr[39]
* pin dst_addr[63]
* pin dst_addr[45]
* pin dst_addr[47]
* pin channel_src_addr[46]
* pin channel_dst_addr[59]
* pin dst_addr[38]
* pin channel_dst_addr[42]
* pin dst_addr[56]
* pin channel_dst_addr[34]
* pin channel_dst_addr[46]
* pin dst_addr[54]
* pin channel_dst_addr[55]
* pin channel_src_addr[35]
* pin dst_addr[57]
* pin channel_done[1]
* pin src_addr[47]
* pin channel_dst_addr[56]
* pin debug_transfer_count[6]
* pin debug_transfer_count[7]
* pin src_rdata[96]
* pin dst_addr[46]
* pin channel_length[107]
* pin debug_transfer_count[98]
* pin dst_wdata[100]
* pin debug_transfer_count[100]
* pin dst_addr[43]
* pin debug_transfer_count[99]
* pin channel_length[98]
* pin dst_addr[126]
* pin dst_addr[49]
* pin dst_addr[104]
* pin debug_transfer_count[107]
* pin debug_transfer_count[112]
* pin channel_length[109]
* pin channel_error[3]
* pin debug_transfer_count[97]
* pin debug_transfer_count[101]
* pin debug_transfer_count[105]
* pin debug_transfer_count[114]
* pin debug_transfer_count[110]
* pin src_rdata[98]
* pin dst_addr[42]
* pin debug_transfer_count[109]
* pin channel_length[50]
* pin dst_wdata[102]
* pin dst_write[3]
* pin dst_addr[127]
* pin channel_length[96]
* pin dst_addr[106]
* pin debug_transfer_count[50]
* pin debug_transfer_count[49]
* pin debug_transfer_count[103]
* pin dst_addr[103]
* pin channel_enable[3]
* pin debug_transfer_count[116]
* pin dst_addr[101]
* pin dst_addr[105]
* pin debug_transfer_count[46]
* pin channel_length[97]
* pin debug_transfer_count[96]
* pin channel_length[49]
* pin dst_addr[125]
* pin debug_transfer_count[48]
* pin channel_length[48]
* pin debug_transfer_count[115]
* pin dst_addr[98]
* pin dst_addr[107]
* pin channel_done[3]
* pin dst_addr[121]
* pin debug_transfer_count[47]
* pin debug_transfer_count[45]
* pin channel_error[1]
* pin debug_transfer_count[43]
* pin dst_addr[123]
* pin dst_addr[33]
* pin channel_busy[3]
* pin debug_transfer_count[126]
* pin channel_length[117]
* pin debug_transfer_count[44]
* pin src_rvalid[1]
* pin dst_wdata[35]
* pin debug_transfer_count[113]
* pin debug_transfer_count[125]
* pin debug_transfer_count[124]
* pin channel_length[44]
* pin channel_length[112]
* pin debug_transfer_count[40]
* pin debug_transfer_count[42]
* pin channel_dst_addr[43]
* pin src_rvalid[3]
* pin dst_wdata[38]
* pin src_addr[113]
* pin channel_mode[6]
* pin debug_transfer_count[41]
* pin debug_transfer_count[39]
* pin dst_addr[124]
* pin channel_length[41]
* pin debug_channel_state[10]
* pin debug_channel_state[9]
* pin channel_mode[7]
* pin debug_transfer_count[118]
* pin debug_transfer_count[127]
* pin debug_transfer_count[123]
* pin dst_addr[100]
* pin dst_addr[119]
* pin dst_wdata[40]
* pin channel_busy[1]
* pin dst_addr[120]
* pin dst_addr[102]
* pin debug_transfer_count[119]
* pin debug_transfer_count[121]
* pin channel_length[108]
* pin debug_active_channels[3]
* pin dst_addr[32]
* pin dst_wdata[34]
* pin debug_active_channels[2]
* pin channel_length[120]
* pin debug_transfer_count[38]
* pin dst_addr[99]
* pin dst_addr[109]
* pin channel_dst_addr[105]
* pin channel_dst_addr[106]
* pin dst_addr[122]
* pin dst_wdata[41]
* pin dst_wdata[42]
* pin channel_dst_addr[127]
* pin debug_active_channels[0]
* pin debug_has_active_channels
* pin channel_length[121]
* pin channel_length[119]
* pin debug_transfer_count[120]
* pin debug_transfer_count[33]
* pin dst_addr[108]
* pin channel_dst_addr[109]
* pin channel_dst_addr[104]
* pin channel_dst_addr[125]
* pin debug_active_channels[1]
* pin channel_length[113]
* pin channel_length[114]
* pin channel_length[123]
* pin src_addr[110]
* pin dst_wdata[59]
* pin debug_transfer_count[34]
* pin channel_length[33]
* pin dst_addr[111]
* pin debug_transfer_count[32]
* pin dst_wdata[32]
* pin channel_dst_addr[123]
* pin dst_wdata[61]
* pin dst_wdata[39]
* pin dst_wdata[55]
* pin debug_transfer_count[122]
* pin channel_length[111]
* pin channel_length[122]
* pin debug_transfer_count[37]
* pin debug_transfer_count[35]
* pin channel_length[32]
* pin channel_dst_addr[103]
* pin dst_wdata[103]
* pin src_addr[122]
* pin channel_dst_addr[98]
* pin src_addr[119]
* pin channel_src_addr[100]
* pin channel_dst_addr[99]
* pin channel_dst_addr[122]
* pin dst_wready[3]
* pin dst_wdata[44]
* pin channel_dst_addr[101]
* pin channel_dst_addr[121]
* pin channel_dst_addr[124]
* pin dst_wdata[43]
* pin channel_dst_addr[119]
* pin channel_length[110]
* pin channel_dst_addr[100]
* pin dst_wdata[63]
* pin channel_dst_addr[120]
* pin channel_dst_addr[102]
* pin channel_dst_addr[107]
* pin debug_transfer_count[36]
* pin src_rdata[42]
* pin dst_addr[115]
* pin channel_src_addr[123]
* pin channel_dst_addr[33]
* pin src_rdata[40]
* pin src_rdata[35]
* pin channel_src_addr[124]
* pin dst_wdata[51]
* pin channel_src_addr[111]
* pin channel_length[115]
* pin channel_dst_addr[111]
* pin src_addr[120]
* pin src_addr[98]
* pin src_rdata[46]
* pin channel_length[40]
* pin dst_wdata[46]
* pin dst_addr[117]
* pin dst_wdata[36]
* pin src_rdata[62]
* pin src_addr[123]
* pin src_rdata[47]
* pin src_rdata[106]
* pin channel_src_addr[122]
* pin channel_src_addr[104]
* pin src_rdata[97]
* pin channel_dst_addr[32]
* pin channel_dst_addr[117]
* pin channel_length[36]
* pin dst_addr[118]
* pin channel_length[35]
* pin dst_wdata[97]
* pin dst_wdata[37]
* pin src_rdata[41]
* pin src_rdata[34]
* pin channel_src_addr[121]
* pin src_addr[121]
* pin src_rdata[127]
* pin debug_transfer_count[108]
* pin debug_transfer_count[111]
* pin debug_transfer_count[117]
* pin channel_length[42]
* pin channel_length[38]
* pin channel_src_addr[119]
* pin dst_wdata[54]
* pin channel_length[47]
* pin channel_dst_addr[113]
* pin channel_dst_addr[114]
* pin src_rdata[59]
* pin src_rdata[103]
* pin dst_wdata[33]
* pin src_rdata[61]
* pin src_rdata[32]
* pin channel_src_addr[120]
* pin src_addr[100]
* pin src_rdata[39]
* pin src_rdata[63]
* pin channel_src_addr[103]
* pin channel_src_addr[117]
* pin channel_src_addr[113]
* pin dst_wdata[58]
* pin src_rdata[55]
* pin channel_length[124]
* pin src_addr[104]
* pin src_rdata[45]
* pin channel_dst_addr[112]
* pin src_rdata[105]
* pin src_rdata[119]
* pin dst_wdata[104]
* pin channel_src_addr[107]
* pin channel_src_addr[112]
* pin channel_src_addr[109]
* pin src_rdata[37]
* pin src_rdata[38]
* pin src_rdata[44]
* pin dst_wdata[119]
* pin channel_length[39]
* pin dst_addr[116]
* pin channel_length[43]
* pin dst_wdata[57]
* pin channel_length[34]
* pin channel_src_addr[96]
* pin dst_addr[113]
* pin dst_addr[97]
* pin dst_wdata[56]
* pin dst_wstrb[14]
* pin dst_wstrb[12]
* pin dst_addr[112]
* pin dst_wdata[60]
* pin dst_wstrb[7]
* pin dst_addr[96]
* pin dst_wstrb[6]
* pin channel_src_addr[127]
* pin src_rdata[101]
* pin dst_wdata[62]
* pin dst_wdata[105]
* pin src_rdata[104]
* pin src_rready[3]
* pin dst_wdata[106]
* pin src_addr[125]
* pin channel_src_addr[98]
* pin src_addr[99]
* pin src_addr[126]
* pin src_rdata[43]
* pin channel_src_addr[114]
* pin channel_src_addr[118]
* pin src_addr[118]
* pin src_addr[102]
* pin src_addr[103]
* pin src_rdata[51]
* pin src_addr[114]
* pin src_addr[101]
* pin dst_wdata[53]
* pin src_read[3]
* pin src_addr[116]
* pin src_addr[115]
* pin src_addr[107]
* pin src_addr[106]
* pin channel_length[125]
* pin src_addr[109]
* pin src_addr[105]
* pin src_rdata[99]
* pin channel_src_addr[126]
* pin dst_addr[110]
* pin channel_dst_addr[110]
* pin dst_wstrb[15]
* pin dst_wstrb[13]
* pin channel_dst_addr[118]
* pin channel_dst_addr[97]
* pin channel_dst_addr[116]
* pin channel_dst_addr[96]
* pin channel_dst_addr[108]
* pin src_addr[97]
* pin dst_addr[114]
* pin channel_dst_addr[126]
* pin dst_wdata[101]
* pin channel_dst_addr[115]
* pin src_addr[96]
* pin channel_src_addr[97]
* pin debug_channel_state[11]
* pin channel_src_addr[99]
* pin channel_start[3]
* pin channel_src_addr[102]
* pin src_addr[124]
* pin src_addr[127]
* pin channel_src_addr[125]
* pin channel_src_addr[101]
* pin channel_src_addr[110]
* pin src_addr[117]
* pin channel_src_addr[116]
* pin channel_src_addr[115]
* pin channel_src_addr[105]
* pin channel_src_addr[108]
* pin channel_src_addr[106]
* pin channel_length[126]
* pin src_addr[112]
* pin src_addr[111]
* pin channel_length[127]
* pin src_addr[108]
* pin channel_length[118]
* pin src_rdata[54]
* pin src_rdata[53]
* pin dst_wdata[52]
* pin src_rdata[50]
* pin dst_wdata[50]
* pin src_rdata[57]
* pin src_rdata[49]
* pin src_rdata[56]
* pin src_rdata[48]
* pin dst_wdata[45]
* pin dst_wdata[49]
* pin src_rdata[58]
* pin src_rdata[60]
* pin src_rdata[36]
* pin src_rdata[33]
* pin dst_wstrb[5]
* pin dst_wstrb[4]
* pin dst_addr[44]
* pin dst_wdata[48]
* pin channel_length[46]
* pin dst_wdata[47]
* pin channel_length[45]
* pin channel_length[116]
* pin channel_length[37]
* pin src_rdata[52]
.SUBCKT dma_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48
+ 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74
+ 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 96 97 98 99
+ 100 101 102 103 104 105 106 107 108 109 110 111 112 113 114 115 116 117 118
+ 119 120 121 122 123 124 125 126 127 128 129 130 131 132 133 134 135 136 137
+ 138 139 140 141 142 143 144 145 146 147 148 149 150 151 152 153 154 155 156
+ 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174 175
+ 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192 193 194
+ 195 196 197 198 199 200 201 202 203 204 205 206 207 208 209 210 211 212 213
+ 214 215 216 217 218 219 220 221 222 223 224 225 226 227 228 229 230 231 232
+ 233 234 235 236 237 238 239 240 241 242 243 244 245 246 247 248 249 250 251
+ 252 253 254 255 256 257 258 259 260 261 262 263 264 265 266 267 268 269 270
+ 271 272 273 274 275 276 277 278 279 280 281 282 283 284 285 286 287 288 289
+ 290 291 292 293 294 295 296 297 298 299 300 301 302 303 304 305 306 307 308
+ 309 310 311 312 313 314 315 316 317 318 319 320 321 322 323 324 325 326 327
+ 328 329 330 331 332 333 334 335 336 337 338 339 340 341 342 343 345 348 349
+ 351 352 353 354 355 356 358 359 360 361 362 365 367 368 373 374 375 407 1789
+ 1882 1921 1970 2026 2041 2068 2090 2092 2096 2098 2101 2107 2110 2111 2122
+ 2135 2138 2157 2158 2161 2162 2164 2174 2179 2183 2198 2199 2207 2217 2218
+ 2219 2220 2226 2242 2243 2244 2246 2255 2265 2266 2279 2293 2308 2309 2310
+ 2311 2331 2341 2342 2351 2352 2357 2370 2371 2372 2384 2395 2396 2397 2416
+ 2417 2423 2434 2435 2436 2437 2445 2448 2459 2460 2461 2476 2477 2478 2479
+ 2495 2502 2508 2511 2513 2530 2536 2540 2557 2558 2559 2560 2566 2581 2582
+ 2583 2589 2596 2605 2610 2611 2612 2617 2631 2632 2638 2648 2649 2650 2664
+ 2665 2666 2667 2675 2679 2686 2687 2697 2699 2700 2701 2702 2703 2707 2719
+ 2720 2721 2741 2742 2743 2756 2757 2758 2770 2771 2792 2793 2794 2804 2816
+ 2817 2829 2830 2831 2840 2843 2854 2855 2856 2858 2868 2869 2874 2879 2880
+ 2889 2890 2895 2896 2897 2905 2917 2918 2921 2931 2946 2947 2959 2960 2961
+ 2974 2975 2980 2993 2999 3000 3013 3014 3015 3023 3024 3034 3056 3066 3067
+ 3079 3080 3092 3093 3109 3114 3121 3122 3127 3129 3141 3142 3143 3150 3151
+ 3160 3161 3169 3170 3171 3174 3175 3181 3182 3187 3188 3189 3190 3191 3196
+ 3201 3203 3207 3218 3220 3221 3227 3228 3232 3240 3249 3250 3257 3258 3259
+ 3262 3266 3267 3280 3286 3287 3295 3296 3297 3299 3302 3303 3314 3315 3323
+ 3324 3329 3330 3337 3338 3352 3353 3354 3361 3362 3363 3366 3374 3375 3381
+ 3396 3397 3398 3408 3409 3410 3417 3422 3423 3424 3429 3432 3434 3437 3450
+ 3451 3456 3457 3458 3469 3470 3481 3482 3493 3494 3504 3505 3516 3517 3518
+ 3519 3524 3529 3538 3539 3549 3550 3551 3568 3569 3573 3574 3575 3586 3587
+ 3591 3592 3603 3604 3605 3607 3610 3611 3621 3627 3636 3637 3657 3658 3659
+ 3674 3675 3676 3693 3695 3696 3697 3698 3707 3712 3713 3725 3729 3730 3731
+ 3745 3747 3748 3749 3750 3764 3766 3767 3768 3780 3781 3794 3795 3796 3797
+ 3798 3810 3811 3812 3813 3814 3836 3837 3838 3855 3856 3857 3883 3884 3900
+ 3901 3902 3919 3921 3923 3924 3936 3937 3938 3961 3964 3965 3991 3992 4005
+ 4006 4023 4024 4025 4026 4044 4047 4060 4061 4062 4063 4075 4079 4094 4095
+ 4106 4110 4111 4112 4129 4130 4131 4132 4146 4152 4171 4172 4277 4444 4470
+ 4474 4484 4498 4519 4534 4541 4557 4568 4575 4589 4608 4609 4611 4615 4616
+ 4620 4623 4671 4680 4699 4708 4717 4721 4730 4757 4774 4775 4776 4782 4786
+ 4798 4807 4809 4820 4825 4829 4851 4899 4919 4922 4925 4939 4961 4963 4977
+ 4980 4983 5061 5104 5113 5123 5129 5143 5165 5166 5169 5234 5241 5252 5254
+ 5284 5285 5287 5299 5304 5306 5310 5321 5328 5339 5346 5362 5370 5371 5374
+ 5382 5395 5397 5398 5400 5403 5422 5432 5433 5446 5477 5478 5479 5499 5520
+ 5522 5525 5527 5552 5560 5567 5569 5570 5572 5573 5574 5577 5586 5589 5594
+ 5596 5597 5622 5626 5633 5637 5644 5648 5650 5652 5655 5659 5679 5680 5682
+ 5698 5700 5707 5709 5711 5712 5713 5722 5723 5725 5759 5760 5763 5765 5774
+ 5775 5777 5781 5793 5805 5806 5809 5818 5825 5826 5827 5833 5840 5843 5858
+ 5870 5884 5892 5893 5900 5912 5914 5918 5919 5923 5924 5925 5933 5936 5938
+ 5944 5947 5949 5959 5962 5972 5975 5979 5986 5987 5988 5990 5991 5997 6003
+ 6015 6019 6024 6025 6027 6029 6030 6036 6041 6044 6050 6061 6073 6074 6076
+ 6083 6085 6089 6091 6092 6103 6104 6106 6108 6115 6119 6126 6130 6131 6132
+ 6133 6136 6138 6139 6140 6142 6147 6148 6153 6161 6162 6163 6165 6167 6168
+ 6169 6172 6173 6174 6182 6183 6184 6185 6186 6187 6189 6191 6192 6194 6196
+ 6197 6199 6202 6203 6204 6208 6211 6215 6217 6218 6220 6223 6224 6226 6228
+ 6229 6232 6233 6234 6239 6241 6245 6246 6247 6248 6250 6251 6253 6254 6255
+ 6256 6257 6258 6260 6261 6262 6264 6265 6266 6267 6268 6269 6270 6271 6272
+ 6273 6274 6275 6276 6277 6278 6280 6282 6283 6284 6285 6286 6287 6288 6289
+ 6290 6291 6292 6293 6294 6295 6296 6297 6298 6299 6300 6301 6302 6303 6304
+ 6305 6306 6307 6308 6309 6310 6311 6312 6313 6314 6315 6316 6317 6318 6319
+ 6320 6321 6322 6323 6324 6325 6326 6328 6329
* net 1 channel_length[100]
* net 2 dst_wdata[17]
* net 3 dst_wdata[20]
* net 4 channel_length[10]
* net 5 debug_transfer_count[10]
* net 6 channel_length[11]
* net 7 channel_length[104]
* net 8 debug_transfer_count[82]
* net 9 dst_wdata[89]
* net 10 src_rdata[83]
* net 11 debug_transfer_count[88]
* net 12 debug_transfer_count[81]
* net 13 channel_length[88]
* net 14 dst_wdata[75]
* net 15 debug_transfer_count[84]
* net 16 channel_length[90]
* net 17 debug_transfer_count[83]
* net 18 dst_wdata[84]
* net 19 src_rdata[75]
* net 20 channel_length[79]
* net 21 dst_wdata[81]
* net 22 channel_length[103]
* net 23 dst_addr[89]
* net 24 src_rdata[81]
* net 25 src_rdata[77]
* net 26 channel_length[102]
* net 27 channel_length[95]
* net 28 channel_length[76]
* net 29 debug_transfer_count[78]
* net 30 src_rdata[74]
* net 31 channel_length[77]
* net 32 dst_wdata[85]
* net 33 channel_length[94]
* net 34 dst_addr[90]
* net 35 channel_length[101]
* net 36 dst_addr[91]
* net 37 channel_length[93]
* net 38 dst_wdata[82]
* net 39 channel_length[72]
* net 40 channel_length[73]
* net 41 dst_addr[92]
* net 42 channel_length[74]
* net 43 debug_transfer_count[74]
* net 44 debug_transfer_count[77]
* net 45 dst_addr[93]
* net 46 src_rdata[93]
* net 47 dst_wdata[66]
* net 48 src_rdata[66]
* net 49 dst_wdata[90]
* net 50 debug_transfer_count[75]
* net 51 debug_transfer_count[85]
* net 52 dst_wdata[68]
* net 53 dst_wdata[93]
* net 54 src_rdata[92]
* net 55 dst_wdata[94]
* net 56 dst_wdata[92]
* net 57 dst_wstrb[11]
* net 58 src_rdata[68]
* net 59 src_rdata[94]
* net 60 dst_wstrb[10]
* net 61 src_read[2]
* net 62 dst_wstrb[9]
* net 63 dst_wstrb[8]
* net 64 src_rdata[65]
* net 65 debug_transfer_count[93]
* net 66 dst_wdata[69]
* net 67 src_rdata[70]
* net 68 src_rdata[91]
* net 69 dst_wdata[91]
* net 70 src_rvalid[2]
* net 71 src_rdata[67]
* net 72 dst_wdata[70]
* net 73 dst_wdata[67]
* net 74 dst_wdata[64]
* net 75 src_rdata[71]
* net 76 src_rdata[95]
* net 77 debug_transfer_count[92]
* net 78 dst_wdata[65]
* net 79 dst_wdata[71]
* net 80 src_rready[2]
* net 81 debug_transfer_count[95]
* net 82 debug_transfer_count[91]
* net 83 dst_wdata[95]
* net 84 src_rdata[72]
* net 85 src_rdata[90]
* net 86 src_rdata[73]
* net 87 src_rdata[78]
* net 88 dst_wdata[72]
* net 89 debug_transfer_count[87]
* net 90 dst_wdata[78]
* net 91 debug_transfer_count[94]
* net 92 src_rdata[82]
* net 93 src_rdata[80]
* net 94 channel_length[99]
* net 95 channel_length[92]
* net 96 src_rdata[85]
* net 97 dst_wdata[80]
* net 98 channel_length[75]
* net 99 debug_transfer_count[89]
* net 100 dst_wdata[74]
* net 101 dst_wdata[79]
* net 102 debug_transfer_count[90]
* net 103 debug_transfer_count[86]
* net 104 channel_length[78]
* net 105 debug_transfer_count[102]
* net 106 channel_length[87]
* net 107 channel_length[86]
* net 108 src_rdata[84]
* net 109 src_rdata[88]
* net 110 src_rdata[76]
* net 111 dst_wdata[88]
* net 112 dst_wdata[76]
* net 113 debug_transfer_count[80]
* net 114 debug_transfer_count[104]
* net 115 debug_transfer_count[106]
* net 116 src_rdata[89]
* net 117 src_rdata[87]
* net 118 channel_length[91]
* net 119 channel_length[89]
* net 120 debug_transfer_count[79]
* net 121 dst_wdata[87]
* net 122 dst_wdata[83]
* net 123 channel_length[106]
* net 124 channel_length[83]
* net 125 channel_length[85]
* net 126 channel_length[84]
* net 127 channel_length[82]
* net 128 channel_length[105]
* net 129 channel_length[80]
* net 130 channel_length[81]
* net 131 channel_length[25]
* net 132 src_rdata[22]
* net 133 channel_length[22]
* net 134 src_rdata[14]
* net 135 channel_length[16]
* net 136 src_rdata[15]
* net 137 dst_wdata[15]
* net 138 debug_transfer_count[15]
* net 139 debug_transfer_count[19]
* net 140 debug_transfer_count[16]
* net 141 debug_transfer_count[20]
* net 142 debug_transfer_count[17]
* net 143 debug_transfer_count[18]
* net 144 debug_transfer_count[21]
* net 145 debug_transfer_count[23]
* net 146 channel_length[18]
* net 147 debug_transfer_count[22]
* net 148 debug_transfer_count[11]
* net 149 debug_transfer_count[12]
* net 150 debug_transfer_count[24]
* net 151 debug_transfer_count[14]
* net 152 channel_length[21]
* net 153 debug_transfer_count[13]
* net 154 src_rdata[18]
* net 155 dst_wdata[21]
* net 156 debug_transfer_count[25]
* net 157 dst_wdata[19]
* net 158 channel_length[17]
* net 159 dst_wdata[18]
* net 160 channel_length[19]
* net 161 channel_length[20]
* net 162 channel_length[12]
* net 163 dst_wdata[14]
* net 164 channel_length[23]
* net 165 src_rdata[20]
* net 166 channel_length[24]
* net 167 src_rdata[16]
* net 168 dst_wdata[16]
* net 169 dst_wdata[22]
* net 170 src_rdata[1]
* net 171 src_rdata[17]
* net 172 dst_wdata[1]
* net 173 channel_length[26]
* net 174 debug_transfer_count[27]
* net 175 debug_transfer_count[28]
* net 176 debug_transfer_count[9]
* net 177 src_rdata[11]
* net 178 src_rdata[26]
* net 179 src_rdata[12]
* net 180 src_rdata[24]
* net 181 debug_transfer_count[30]
* net 182 debug_transfer_count[8]
* net 183 dst_wdata[24]
* net 184 dst_wdata[13]
* net 185 dst_wdata[26]
* net 186 dst_wdata[12]
* net 187 dst_wdata[11]
* net 188 debug_transfer_count[26]
* net 189 dst_wdata[25]
* net 190 channel_length[30]
* net 191 src_rdata[23]
* net 192 channel_length[28]
* net 193 channel_length[29]
* net 194 src_rdata[31]
* net 195 src_rdata[27]
* net 196 src_rdata[0]
* net 197 dst_wdata[31]
* net 198 dst_wdata[23]
* net 199 channel_length[31]
* net 200 dst_wdata[0]
* net 201 debug_transfer_count[29]
* net 202 debug_channel_state[0]
* net 203 src_rdata[29]
* net 204 src_rdata[28]
* net 205 dst_wdata[27]
* net 206 src_rdata[7]
* net 207 channel_start[0]
* net 208 src_rdata[9]
* net 209 dst_wdata[29]
* net 210 dst_wready[0]
* net 211 debug_transfer_count[1]
* net 212 dst_wdata[9]
* net 213 src_rvalid[0]
* net 214 debug_channel_state[2]
* net 215 src_rdata[2]
* net 216 src_addr[6]
* net 217 channel_error[0]
* net 218 dst_wdata[7]
* net 219 debug_transfer_count[2]
* net 220 dst_wstrb[0]
* net 221 dst_wdata[10]
* net 222 dst_wdata[4]
* net 223 channel_src_addr[6]
* net 224 channel_src_addr[5]
* net 225 src_rdata[3]
* net 226 src_addr[7]
* net 227 dst_wdata[3]
* net 228 channel_src_addr[7]
* net 229 dst_addr[7]
* net 230 src_rdata[4]
* net 231 dst_wstrb[1]
* net 232 channel_src_addr[8]
* net 233 channel_src_addr[3]
* net 234 dst_wdata[5]
* net 235 src_addr[5]
* net 236 dst_wdata[8]
* net 237 dst_addr[10]
* net 238 dst_write[0]
* net 239 channel_dst_addr[5]
* net 240 channel_src_addr[2]
* net 241 channel_dst_addr[11]
* net 242 dst_addr[5]
* net 243 src_addr[2]
* net 244 dst_addr[13]
* net 245 channel_dst_addr[9]
* net 246 channel_src_addr[0]
* net 247 channel_mode[0]
* net 248 dst_addr[14]
* net 249 channel_src_addr[10]
* net 250 channel_dst_addr[14]
* net 251 src_addr[15]
* net 252 channel_src_addr[15]
* net 253 src_rdata[5]
* net 254 channel_dst_addr[2]
* net 255 channel_done[0]
* net 256 channel_src_addr[12]
* net 257 channel_dst_addr[3]
* net 258 channel_src_addr[11]
* net 259 channel_dst_addr[8]
* net 260 channel_dst_addr[12]
* net 261 src_addr[16]
* net 262 debug_channel_state[1]
* net 263 channel_dst_addr[10]
* net 264 channel_src_addr[17]
* net 265 dst_addr[12]
* net 266 channel_dst_addr[15]
* net 267 src_addr[17]
* net 268 channel_dst_addr[18]
* net 269 dst_wdata[28]
* net 270 channel_src_addr[14]
* net 271 channel_dst_addr[19]
* net 272 channel_src_addr[13]
* net 273 dst_addr[0]
* net 274 channel_dst_addr[17]
* net 275 channel_src_addr[30]
* net 276 dst_addr[6]
* net 277 channel_src_addr[22]
* net 278 channel_dst_addr[30]
* net 279 channel_src_addr[4]
* net 280 channel_dst_addr[29]
* net 281 channel_src_addr[9]
* net 282 src_addr[14]
* net 283 dst_addr[19]
* net 284 channel_src_addr[21]
* net 285 dst_addr[29]
* net 286 src_addr[18]
* net 287 dst_addr[17]
* net 288 channel_src_addr[20]
* net 289 dst_addr[30]
* net 290 dst_addr[8]
* net 291 channel_dst_addr[28]
* net 292 channel_mode[1]
* net 293 dst_addr[20]
* net 294 dst_addr[4]
* net 295 src_addr[19]
* net 296 channel_enable[0]
* net 297 channel_dst_addr[31]
* net 298 dst_addr[28]
* net 299 src_addr[20]
* net 300 channel_dst_addr[24]
* net 301 dst_addr[31]
* net 302 channel_dst_addr[26]
* net 303 channel_dst_addr[27]
* net 304 src_addr[22]
* net 305 channel_dst_addr[23]
* net 306 dst_addr[16]
* net 307 dst_addr[1]
* net 308 src_addr[8]
* net 309 channel_dst_addr[1]
* net 310 dst_addr[2]
* net 311 src_addr[1]
* net 312 dst_addr[21]
* net 313 dst_addr[24]
* net 314 dst_addr[15]
* net 315 dst_addr[23]
* net 316 dst_addr[18]
* net 317 dst_wdata[6]
* net 318 channel_dst_addr[13]
* net 319 dst_addr[27]
* net 320 channel_dst_addr[20]
* net 321 channel_dst_addr[6]
* net 322 channel_dst_addr[16]
* net 323 channel_src_addr[18]
* net 324 src_rdata[8]
* net 325 dst_wstrb[2]
* net 326 src_addr[0]
* net 327 channel_dst_addr[25]
* net 328 dst_addr[9]
* net 329 src_rdata[10]
* net 330 channel_src_addr[1]
* net 331 dst_addr[3]
* net 332 dst_wdata[2]
* net 333 channel_dst_addr[0]
* net 334 channel_src_addr[19]
* net 335 src_addr[9]
* net 336 debug_transfer_count[0]
* net 337 dst_addr[11]
* net 338 dst_addr[22]
* net 339 channel_dst_addr[4]
* net 340 src_rdata[6]
* net 341 channel_dst_addr[22]
* net 342 debug_transfer_count[31]
* net 343 channel_busy[0]
* net 345 dst_wdata[73]
* net 348 src_rdata[69]
* net 349 src_rdata[64]
* net 351 src_rdata[79]
* net 352 dst_wdata[77]
* net 353 src_rdata[86]
* net 354 dst_wdata[86]
* net 355 src_rdata[19]
* net 356 src_rdata[21]
* net 358 src_rdata[13]
* net 359 channel_length[27]
* net 360 src_rdata[25]
* net 361 src_rdata[30]
* net 362 dst_wdata[30]
* net 365 channel_dst_addr[7]
* net 367 dst_wstrb[3]
* net 368 channel_src_addr[16]
* net 373 channel_dst_addr[21]
* net 374 src_rready[0]
* net 375 VSS
* net 407 VDD
* net 1789 debug_transfer_count[76]
* net 1882 channel_length[0]
* net 1921 debug_transfer_count[72]
* net 1970 debug_transfer_count[71]
* net 2026 channel_length[14]
* net 2041 debug_transfer_count[73]
* net 2068 channel_length[13]
* net 2090 src_addr[10]
* net 2092 src_addr[13]
* net 2096 debug_transfer_count[3]
* net 2098 debug_transfer_count[4]
* net 2101 debug_transfer_count[5]
* net 2107 channel_length[15]
* net 2110 src_addr[4]
* net 2111 src_addr[11]
* net 2122 channel_length[1]
* net 2135 channel_length[3]
* net 2138 channel_length[2]
* net 2157 channel_length[9]
* net 2158 channel_length[8]
* net 2161 channel_length[7]
* net 2162 channel_length[5]
* net 2164 channel_length[6]
* net 2174 channel_length[4]
* net 2179 debug_transfer_count[65]
* net 2183 debug_transfer_count[69]
* net 2198 channel_dst_addr[64]
* net 2199 channel_src_addr[91]
* net 2207 debug_transfer_count[66]
* net 2217 channel_src_addr[81]
* net 2218 channel_start[2]
* net 2219 dst_addr[94]
* net 2220 dst_addr[70]
* net 2226 dst_addr[64]
* net 2242 debug_transfer_count[70]
* net 2243 channel_dst_addr[79]
* net 2244 channel_src_addr[70]
* net 2246 debug_transfer_count[67]
* net 2255 debug_transfer_count[68]
* net 2265 debug_channel_state[7]
* net 2266 dst_addr[87]
* net 2279 src_addr[12]
* net 2293 dst_addr[81]
* net 2308 dst_addr[75]
* net 2309 channel_src_addr[76]
* net 2310 channel_dst_addr[95]
* net 2311 src_addr[72]
* net 2331 dst_addr[66]
* net 2341 channel_mode[4]
* net 2342 channel_dst_addr[89]
* net 2351 channel_dst_addr[69]
* net 2352 channel_src_addr[72]
* net 2357 src_addr[21]
* net 2370 src_addr[80]
* net 2371 channel_src_addr[71]
* net 2372 channel_src_addr[64]
* net 2384 dst_addr[88]
* net 2395 channel_dst_addr[66]
* net 2396 channel_dst_addr[78]
* net 2397 channel_dst_addr[88]
* net 2416 src_addr[93]
* net 2417 channel_src_addr[67]
* net 2423 debug_transfer_count[64]
* net 2434 channel_src_addr[84]
* net 2435 channel_dst_addr[82]
* net 2436 dst_addr[72]
* net 2437 channel_dst_addr[93]
* net 2445 src_addr[3]
* net 2448 channel_dst_addr[92]
* net 2459 dst_addr[85]
* net 2460 channel_dst_addr[81]
* net 2461 channel_src_addr[93]
* net 2476 dst_wready[2]
* net 2477 channel_dst_addr[65]
* net 2478 dst_addr[79]
* net 2479 channel_dst_addr[83]
* net 2495 debug_channel_state[8]
* net 2502 channel_dst_addr[74]
* net 2508 dst_addr[80]
* net 2511 dst_addr[76]
* net 2513 channel_dst_addr[68]
* net 2530 channel_done[2]
* net 2536 channel_dst_addr[77]
* net 2540 debug_channel_state[6]
* net 2557 rst_n
* net 2558 dst_addr[68]
* net 2559 channel_dst_addr[90]
* net 2560 channel_dst_addr[84]
* net 2566 dst_addr[95]
* net 2581 channel_error[2]
* net 2582 clk
* net 2583 src_addr[81]
* net 2589 dst_addr[82]
* net 2596 src_addr[74]
* net 2605 dst_addr[84]
* net 2610 channel_dst_addr[80]
* net 2611 channel_dst_addr[87]
* net 2612 src_addr[66]
* net 2617 channel_enable[2]
* net 2631 dst_addr[83]
* net 2632 channel_dst_addr[91]
* net 2638 channel_dst_addr[72]
* net 2648 dst_addr[71]
* net 2649 src_addr[82]
* net 2650 dst_addr[86]
* net 2664 channel_dst_addr[86]
* net 2665 dst_addr[69]
* net 2666 channel_dst_addr[75]
* net 2667 channel_src_addr[85]
* net 2675 channel_dst_addr[85]
* net 2679 dst_addr[74]
* net 2686 channel_dst_addr[70]
* net 2687 channel_dst_addr[94]
* net 2697 dst_addr[73]
* net 2699 channel_dst_addr[67]
* net 2700 src_addr[94]
* net 2701 channel_src_addr[69]
* net 2702 dst_addr[78]
* net 2703 channel_src_addr[75]
* net 2707 channel_length[66]
* net 2719 channel_dst_addr[71]
* net 2720 src_addr[67]
* net 2721 dst_addr[67]
* net 2741 channel_src_addr[87]
* net 2742 channel_dst_addr[73]
* net 2743 src_addr[65]
* net 2756 src_addr[75]
* net 2757 channel_dst_addr[76]
* net 2758 dst_addr[77]
* net 2770 dst_addr[25]
* net 2771 channel_src_addr[74]
* net 2792 dst_write[2]
* net 2793 src_addr[76]
* net 2794 dst_addr[65]
* net 2804 dst_addr[26]
* net 2816 channel_src_addr[68]
* net 2817 src_addr[77]
* net 2829 src_addr[68]
* net 2830 src_addr[79]
* net 2831 channel_src_addr[66]
* net 2840 src_addr[71]
* net 2843 channel_busy[2]
* net 2854 channel_src_addr[36]
* net 2855 channel_length[51]
* net 2856 channel_length[56]
* net 2858 channel_src_addr[37]
* net 2868 src_addr[70]
* net 2869 channel_src_addr[65]
* net 2874 channel_length[58]
* net 2879 channel_src_addr[54]
* net 2880 channel_src_addr[55]
* net 2889 channel_src_addr[77]
* net 2890 src_addr[73]
* net 2895 debug_transfer_count[60]
* net 2896 src_addr[37]
* net 2897 channel_src_addr[24]
* net 2905 channel_mode[5]
* net 2917 src_addr[23]
* net 2918 src_addr[53]
* net 2921 channel_src_addr[73]
* net 2931 src_addr[69]
* net 2946 debug_transfer_count[59]
* net 2947 channel_src_addr[23]
* net 2959 channel_src_addr[79]
* net 2960 src_addr[78]
* net 2961 channel_src_addr[80]
* net 2974 channel_src_addr[57]
* net 2975 src_addr[25]
* net 2980 channel_src_addr[78]
* net 2993 channel_src_addr[92]
* net 2999 channel_src_addr[26]
* net 3000 channel_src_addr[25]
* net 3013 channel_src_addr[82]
* net 3014 src_addr[64]
* net 3015 channel_src_addr[95]
* net 3023 src_addr[24]
* net 3024 channel_src_addr[27]
* net 3034 src_addr[95]
* net 3056 channel_src_addr[94]
* net 3066 channel_src_addr[28]
* net 3067 channel_src_addr[29]
* net 3079 channel_length[65]
* net 3080 channel_src_addr[83]
* net 3092 src_addr[29]
* net 3093 src_addr[26]
* net 3109 channel_src_addr[89]
* net 3114 channel_src_addr[31]
* net 3121 channel_src_addr[86]
* net 3122 channel_src_addr[88]
* net 3127 src_addr[30]
* net 3129 src_addr[28]
* net 3141 channel_src_addr[90]
* net 3142 channel_length[64]
* net 3143 src_addr[86]
* net 3150 src_addr[31]
* net 3151 src_addr[27]
* net 3160 src_read[0]
* net 3161 src_addr[56]
* net 3169 src_addr[92]
* net 3170 src_addr[83]
* net 3171 src_addr[87]
* net 3174 channel_length[67]
* net 3175 channel_length[52]
* net 3181 debug_transfer_count[57]
* net 3182 src_addr[57]
* net 3187 src_addr[85]
* net 3188 src_addr[84]
* net 3189 channel_length[53]
* net 3190 channel_src_addr[59]
* net 3191 src_addr[63]
* net 3196 channel_length[54]
* net 3201 src_addr[89]
* net 3203 channel_length[55]
* net 3207 channel_src_addr[63]
* net 3218 channel_length[71]
* net 3220 src_addr[90]
* net 3221 src_addr[88]
* net 3227 debug_transfer_count[53]
* net 3228 debug_transfer_count[54]
* net 3232 channel_length[69]
* net 3240 src_addr[91]
* net 3249 src_addr[60]
* net 3250 src_addr[58]
* net 3257 src_rdata[112]
* net 3258 dst_wdata[127]
* net 3259 dst_wdata[99]
* net 3262 dst_wdata[112]
* net 3266 src_addr[62]
* net 3267 channel_src_addr[58]
* net 3280 src_rdata[107]
* net 3286 debug_transfer_count[52]
* net 3287 debug_transfer_count[51]
* net 3295 src_rdata[124]
* net 3296 dst_wdata[107]
* net 3297 dst_wdata[98]
* net 3299 debug_transfer_count[55]
* net 3302 channel_src_addr[60]
* net 3303 src_addr[59]
* net 3314 src_rdata[126]
* net 3315 src_rdata[113]
* net 3323 debug_transfer_count[56]
* net 3324 channel_src_addr[62]
* net 3329 dst_wdata[126]
* net 3330 src_rdata[111]
* net 3337 debug_transfer_count[62]
* net 3338 src_addr[55]
* net 3352 dst_wdata[121]
* net 3353 dst_wdata[111]
* net 3354 dst_wdata[113]
* net 3361 src_read[1]
* net 3362 src_addr[38]
* net 3363 src_addr[61]
* net 3366 src_addr[39]
* net 3374 src_rdata[125]
* net 3375 src_rdata[121]
* net 3381 channel_src_addr[61]
* net 3396 dst_wdata[116]
* net 3397 src_rdata[109]
* net 3398 src_rdata[116]
* net 3408 debug_transfer_count[58]
* net 3409 channel_src_addr[56]
* net 3410 src_addr[54]
* net 3417 channel_length[70]
* net 3422 src_rdata[102]
* net 3423 dst_wdata[123]
* net 3424 src_rdata[100]
* net 3429 debug_transfer_count[61]
* net 3432 channel_length[59]
* net 3434 channel_src_addr[38]
* net 3437 dst_wdata[118]
* net 3450 src_rdata[118]
* net 3451 src_rdata[117]
* net 3456 src_addr[36]
* net 3457 src_addr[52]
* net 3458 channel_length[57]
* net 3469 dst_wdata[117]
* net 3470 dst_wdata[122]
* net 3481 channel_length[61]
* net 3482 channel_src_addr[39]
* net 3493 src_rdata[110]
* net 3494 src_rdata[114]
* net 3504 channel_src_addr[53]
* net 3505 channel_src_addr[52]
* net 3516 dst_wdata[120]
* net 3517 src_rdata[120]
* net 3518 dst_wdata[124]
* net 3519 channel_length[60]
* net 3524 src_addr[35]
* net 3529 dst_wdata[114]
* net 3538 src_rdata[108]
* net 3539 src_rdata[122]
* net 3549 src_addr[33]
* net 3550 channel_src_addr[40]
* net 3551 channel_src_addr[51]
* net 3568 dst_wdata[109]
* net 3569 dst_wdata[96]
* net 3573 src_addr[51]
* net 3574 src_addr[50]
* net 3575 channel_src_addr[50]
* net 3586 dst_wdata[110]
* net 3587 src_rdata[123]
* net 3591 channel_src_addr[34]
* net 3592 channel_src_addr[48]
* net 3603 src_rdata[115]
* net 3604 dst_wdata[115]
* net 3605 dst_wdata[108]
* net 3607 src_addr[34]
* net 3610 channel_length[62]
* net 3611 channel_mode[3]
* net 3621 channel_length[68]
* net 3627 dst_wdata[125]
* net 3636 src_addr[32]
* net 3637 channel_src_addr[49]
* net 3657 channel_src_addr[41]
* net 3658 dst_addr[37]
* net 3659 channel_src_addr[33]
* net 3674 channel_enable[1]
* net 3675 channel_src_addr[32]
* net 3676 channel_length[63]
* net 3693 src_addr[48]
* net 3695 dst_addr[35]
* net 3696 debug_transfer_count[63]
* net 3697 src_addr[45]
* net 3698 channel_dst_addr[37]
* net 3707 src_addr[40]
* net 3712 channel_src_addr[45]
* net 3713 src_addr[46]
* net 3725 dst_wready[1]
* net 3729 channel_src_addr[47]
* net 3730 debug_channel_state[4]
* net 3731 channel_src_addr[43]
* net 3745 src_addr[41]
* net 3747 channel_dst_addr[41]
* net 3748 channel_start[1]
* net 3749 dst_addr[52]
* net 3750 src_addr[44]
* net 3764 src_addr[49]
* net 3766 dst_addr[36]
* net 3767 dst_addr[34]
* net 3768 channel_dst_addr[53]
* net 3780 channel_dst_addr[35]
* net 3781 dst_addr[53]
* net 3794 channel_dst_addr[48]
* net 3795 channel_dst_addr[57]
* net 3796 src_rready[1]
* net 3797 dst_addr[50]
* net 3798 channel_dst_addr[47]
* net 3810 dst_addr[40]
* net 3811 dst_addr[41]
* net 3812 channel_src_addr[42]
* net 3813 debug_channel_state[3]
* net 3814 src_addr[43]
* net 3836 channel_dst_addr[51]
* net 3837 channel_dst_addr[61]
* net 3838 channel_dst_addr[50]
* net 3855 channel_dst_addr[52]
* net 3856 channel_dst_addr[62]
* net 3857 src_addr[42]
* net 3883 channel_dst_addr[38]
* net 3884 channel_dst_addr[44]
* net 3900 dst_write[1]
* net 3901 dst_addr[62]
* net 3902 dst_addr[39]
* net 3919 channel_mode[2]
* net 3921 debug_channel_state[5]
* net 3923 dst_addr[48]
* net 3924 channel_dst_addr[49]
* net 3936 dst_addr[61]
* net 3937 dst_addr[59]
* net 3938 channel_src_addr[44]
* net 3961 channel_dst_addr[40]
* net 3964 channel_dst_addr[54]
* net 3965 dst_addr[55]
* net 3991 dst_addr[60]
* net 3992 dst_addr[51]
* net 4005 channel_dst_addr[36]
* net 4006 channel_dst_addr[63]
* net 4023 channel_dst_addr[60]
* net 4024 dst_addr[58]
* net 4025 channel_dst_addr[58]
* net 4026 channel_dst_addr[45]
* net 4044 channel_dst_addr[39]
* net 4047 dst_addr[63]
* net 4060 dst_addr[45]
* net 4061 dst_addr[47]
* net 4062 channel_src_addr[46]
* net 4063 channel_dst_addr[59]
* net 4075 dst_addr[38]
* net 4079 channel_dst_addr[42]
* net 4094 dst_addr[56]
* net 4095 channel_dst_addr[34]
* net 4106 channel_dst_addr[46]
* net 4110 dst_addr[54]
* net 4111 channel_dst_addr[55]
* net 4112 channel_src_addr[35]
* net 4129 dst_addr[57]
* net 4130 channel_done[1]
* net 4131 src_addr[47]
* net 4132 channel_dst_addr[56]
* net 4146 debug_transfer_count[6]
* net 4152 debug_transfer_count[7]
* net 4171 src_rdata[96]
* net 4172 dst_addr[46]
* net 4277 channel_length[107]
* net 4444 debug_transfer_count[98]
* net 4470 dst_wdata[100]
* net 4474 debug_transfer_count[100]
* net 4484 dst_addr[43]
* net 4498 debug_transfer_count[99]
* net 4519 channel_length[98]
* net 4534 dst_addr[126]
* net 4541 dst_addr[49]
* net 4557 dst_addr[104]
* net 4568 debug_transfer_count[107]
* net 4575 debug_transfer_count[112]
* net 4589 channel_length[109]
* net 4608 channel_error[3]
* net 4609 debug_transfer_count[97]
* net 4611 debug_transfer_count[101]
* net 4615 debug_transfer_count[105]
* net 4616 debug_transfer_count[114]
* net 4620 debug_transfer_count[110]
* net 4623 src_rdata[98]
* net 4671 dst_addr[42]
* net 4680 debug_transfer_count[109]
* net 4699 channel_length[50]
* net 4708 dst_wdata[102]
* net 4717 dst_write[3]
* net 4721 dst_addr[127]
* net 4730 channel_length[96]
* net 4757 dst_addr[106]
* net 4774 debug_transfer_count[50]
* net 4775 debug_transfer_count[49]
* net 4776 debug_transfer_count[103]
* net 4782 dst_addr[103]
* net 4786 channel_enable[3]
* net 4798 debug_transfer_count[116]
* net 4807 dst_addr[101]
* net 4809 dst_addr[105]
* net 4820 debug_transfer_count[46]
* net 4825 channel_length[97]
* net 4829 debug_transfer_count[96]
* net 4851 channel_length[49]
* net 4899 dst_addr[125]
* net 4919 debug_transfer_count[48]
* net 4922 channel_length[48]
* net 4925 debug_transfer_count[115]
* net 4939 dst_addr[98]
* net 4961 dst_addr[107]
* net 4963 channel_done[3]
* net 4977 dst_addr[121]
* net 4980 debug_transfer_count[47]
* net 4983 debug_transfer_count[45]
* net 5061 channel_error[1]
* net 5104 debug_transfer_count[43]
* net 5113 dst_addr[123]
* net 5123 dst_addr[33]
* net 5129 channel_busy[3]
* net 5143 debug_transfer_count[126]
* net 5165 channel_length[117]
* net 5166 debug_transfer_count[44]
* net 5169 src_rvalid[1]
* net 5234 dst_wdata[35]
* net 5241 debug_transfer_count[113]
* net 5252 debug_transfer_count[125]
* net 5254 debug_transfer_count[124]
* net 5284 channel_length[44]
* net 5285 channel_length[112]
* net 5287 debug_transfer_count[40]
* net 5299 debug_transfer_count[42]
* net 5304 channel_dst_addr[43]
* net 5306 src_rvalid[3]
* net 5310 dst_wdata[38]
* net 5321 src_addr[113]
* net 5328 channel_mode[6]
* net 5339 debug_transfer_count[41]
* net 5346 debug_transfer_count[39]
* net 5362 dst_addr[124]
* net 5370 channel_length[41]
* net 5371 debug_channel_state[10]
* net 5374 debug_channel_state[9]
* net 5382 channel_mode[7]
* net 5395 debug_transfer_count[118]
* net 5397 debug_transfer_count[127]
* net 5398 debug_transfer_count[123]
* net 5400 dst_addr[100]
* net 5403 dst_addr[119]
* net 5422 dst_wdata[40]
* net 5432 channel_busy[1]
* net 5433 dst_addr[120]
* net 5446 dst_addr[102]
* net 5477 debug_transfer_count[119]
* net 5478 debug_transfer_count[121]
* net 5479 channel_length[108]
* net 5499 debug_active_channels[3]
* net 5520 dst_addr[32]
* net 5522 dst_wdata[34]
* net 5525 debug_active_channels[2]
* net 5527 channel_length[120]
* net 5552 debug_transfer_count[38]
* net 5560 dst_addr[99]
* net 5567 dst_addr[109]
* net 5569 channel_dst_addr[105]
* net 5570 channel_dst_addr[106]
* net 5572 dst_addr[122]
* net 5573 dst_wdata[41]
* net 5574 dst_wdata[42]
* net 5577 channel_dst_addr[127]
* net 5586 debug_active_channels[0]
* net 5589 debug_has_active_channels
* net 5594 channel_length[121]
* net 5596 channel_length[119]
* net 5597 debug_transfer_count[120]
* net 5622 debug_transfer_count[33]
* net 5626 dst_addr[108]
* net 5633 channel_dst_addr[109]
* net 5637 channel_dst_addr[104]
* net 5644 channel_dst_addr[125]
* net 5648 debug_active_channels[1]
* net 5650 channel_length[113]
* net 5652 channel_length[114]
* net 5655 channel_length[123]
* net 5659 src_addr[110]
* net 5679 dst_wdata[59]
* net 5680 debug_transfer_count[34]
* net 5682 channel_length[33]
* net 5698 dst_addr[111]
* net 5700 debug_transfer_count[32]
* net 5707 dst_wdata[32]
* net 5709 channel_dst_addr[123]
* net 5711 dst_wdata[61]
* net 5712 dst_wdata[39]
* net 5713 dst_wdata[55]
* net 5722 debug_transfer_count[122]
* net 5723 channel_length[111]
* net 5725 channel_length[122]
* net 5759 debug_transfer_count[37]
* net 5760 debug_transfer_count[35]
* net 5763 channel_length[32]
* net 5765 channel_dst_addr[103]
* net 5774 dst_wdata[103]
* net 5775 src_addr[122]
* net 5777 channel_dst_addr[98]
* net 5781 src_addr[119]
* net 5793 channel_src_addr[100]
* net 5805 channel_dst_addr[99]
* net 5806 channel_dst_addr[122]
* net 5809 dst_wready[3]
* net 5818 dst_wdata[44]
* net 5825 channel_dst_addr[101]
* net 5826 channel_dst_addr[121]
* net 5827 channel_dst_addr[124]
* net 5833 dst_wdata[43]
* net 5840 channel_dst_addr[119]
* net 5843 channel_length[110]
* net 5858 channel_dst_addr[100]
* net 5870 dst_wdata[63]
* net 5884 channel_dst_addr[120]
* net 5892 channel_dst_addr[102]
* net 5893 channel_dst_addr[107]
* net 5900 debug_transfer_count[36]
* net 5912 src_rdata[42]
* net 5914 dst_addr[115]
* net 5918 channel_src_addr[123]
* net 5919 channel_dst_addr[33]
* net 5923 src_rdata[40]
* net 5924 src_rdata[35]
* net 5925 channel_src_addr[124]
* net 5933 dst_wdata[51]
* net 5936 channel_src_addr[111]
* net 5938 channel_length[115]
* net 5944 channel_dst_addr[111]
* net 5947 src_addr[120]
* net 5949 src_addr[98]
* net 5959 src_rdata[46]
* net 5962 channel_length[40]
* net 5972 dst_wdata[46]
* net 5975 dst_addr[117]
* net 5979 dst_wdata[36]
* net 5986 src_rdata[62]
* net 5987 src_addr[123]
* net 5988 src_rdata[47]
* net 5990 src_rdata[106]
* net 5991 channel_src_addr[122]
* net 5997 channel_src_addr[104]
* net 6003 src_rdata[97]
* net 6015 channel_dst_addr[32]
* net 6019 channel_dst_addr[117]
* net 6024 channel_length[36]
* net 6025 dst_addr[118]
* net 6027 channel_length[35]
* net 6029 dst_wdata[97]
* net 6030 dst_wdata[37]
* net 6036 src_rdata[41]
* net 6041 src_rdata[34]
* net 6044 channel_src_addr[121]
* net 6050 src_addr[121]
* net 6061 src_rdata[127]
* net 6073 debug_transfer_count[108]
* net 6074 debug_transfer_count[111]
* net 6076 debug_transfer_count[117]
* net 6083 channel_length[42]
* net 6085 channel_length[38]
* net 6089 channel_src_addr[119]
* net 6091 dst_wdata[54]
* net 6092 channel_length[47]
* net 6103 channel_dst_addr[113]
* net 6104 channel_dst_addr[114]
* net 6106 src_rdata[59]
* net 6108 src_rdata[103]
* net 6115 dst_wdata[33]
* net 6119 src_rdata[61]
* net 6126 src_rdata[32]
* net 6130 channel_src_addr[120]
* net 6131 src_addr[100]
* net 6132 src_rdata[39]
* net 6133 src_rdata[63]
* net 6136 channel_src_addr[103]
* net 6138 channel_src_addr[117]
* net 6139 channel_src_addr[113]
* net 6140 dst_wdata[58]
* net 6142 src_rdata[55]
* net 6147 channel_length[124]
* net 6148 src_addr[104]
* net 6153 src_rdata[45]
* net 6161 channel_dst_addr[112]
* net 6162 src_rdata[105]
* net 6163 src_rdata[119]
* net 6165 dst_wdata[104]
* net 6167 channel_src_addr[107]
* net 6168 channel_src_addr[112]
* net 6169 channel_src_addr[109]
* net 6172 src_rdata[37]
* net 6173 src_rdata[38]
* net 6174 src_rdata[44]
* net 6182 dst_wdata[119]
* net 6183 channel_length[39]
* net 6184 dst_addr[116]
* net 6185 channel_length[43]
* net 6186 dst_wdata[57]
* net 6187 channel_length[34]
* net 6189 channel_src_addr[96]
* net 6191 dst_addr[113]
* net 6192 dst_addr[97]
* net 6194 dst_wdata[56]
* net 6196 dst_wstrb[14]
* net 6197 dst_wstrb[12]
* net 6199 dst_addr[112]
* net 6202 dst_wdata[60]
* net 6203 dst_wstrb[7]
* net 6204 dst_addr[96]
* net 6208 dst_wstrb[6]
* net 6211 channel_src_addr[127]
* net 6215 src_rdata[101]
* net 6217 dst_wdata[62]
* net 6218 dst_wdata[105]
* net 6220 src_rdata[104]
* net 6223 src_rready[3]
* net 6224 dst_wdata[106]
* net 6226 src_addr[125]
* net 6228 channel_src_addr[98]
* net 6229 src_addr[99]
* net 6232 src_addr[126]
* net 6233 src_rdata[43]
* net 6234 channel_src_addr[114]
* net 6239 channel_src_addr[118]
* net 6241 src_addr[118]
* net 6245 src_addr[102]
* net 6246 src_addr[103]
* net 6247 src_rdata[51]
* net 6248 src_addr[114]
* net 6250 src_addr[101]
* net 6251 dst_wdata[53]
* net 6253 src_read[3]
* net 6254 src_addr[116]
* net 6255 src_addr[115]
* net 6256 src_addr[107]
* net 6257 src_addr[106]
* net 6258 channel_length[125]
* net 6260 src_addr[109]
* net 6261 src_addr[105]
* net 6262 src_rdata[99]
* net 6264 channel_src_addr[126]
* net 6265 dst_addr[110]
* net 6266 channel_dst_addr[110]
* net 6267 dst_wstrb[15]
* net 6268 dst_wstrb[13]
* net 6269 channel_dst_addr[118]
* net 6270 channel_dst_addr[97]
* net 6271 channel_dst_addr[116]
* net 6272 channel_dst_addr[96]
* net 6273 channel_dst_addr[108]
* net 6274 src_addr[97]
* net 6275 dst_addr[114]
* net 6276 channel_dst_addr[126]
* net 6277 dst_wdata[101]
* net 6278 channel_dst_addr[115]
* net 6280 src_addr[96]
* net 6282 channel_src_addr[97]
* net 6283 debug_channel_state[11]
* net 6284 channel_src_addr[99]
* net 6285 channel_start[3]
* net 6286 channel_src_addr[102]
* net 6287 src_addr[124]
* net 6288 src_addr[127]
* net 6289 channel_src_addr[125]
* net 6290 channel_src_addr[101]
* net 6291 channel_src_addr[110]
* net 6292 src_addr[117]
* net 6293 channel_src_addr[116]
* net 6294 channel_src_addr[115]
* net 6295 channel_src_addr[105]
* net 6296 channel_src_addr[108]
* net 6297 channel_src_addr[106]
* net 6298 channel_length[126]
* net 6299 src_addr[112]
* net 6300 src_addr[111]
* net 6301 channel_length[127]
* net 6302 src_addr[108]
* net 6303 channel_length[118]
* net 6304 src_rdata[54]
* net 6305 src_rdata[53]
* net 6306 dst_wdata[52]
* net 6307 src_rdata[50]
* net 6308 dst_wdata[50]
* net 6309 src_rdata[57]
* net 6310 src_rdata[49]
* net 6311 src_rdata[56]
* net 6312 src_rdata[48]
* net 6313 dst_wdata[45]
* net 6314 dst_wdata[49]
* net 6315 src_rdata[58]
* net 6316 src_rdata[60]
* net 6317 src_rdata[36]
* net 6318 src_rdata[33]
* net 6319 dst_wstrb[5]
* net 6320 dst_wstrb[4]
* net 6321 dst_addr[44]
* net 6322 dst_wdata[48]
* net 6323 channel_length[46]
* net 6324 dst_wdata[47]
* net 6325 channel_length[45]
* net 6326 channel_length[116]
* net 6328 channel_length[37]
* net 6329 src_rdata[52]
* cell instance $17 r0 *1 247.94,563.04
X$17 407 1 375 407 4192 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32 m0 *1 199.64,13.6
X$32 407 553 375 407 2 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35 r0 *1 190.9,2.72
X$35 407 378 375 407 3 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38 r0 *1 200.56,24.48
X$38 407 4 375 407 733 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43 m0 *1 283.36,84.32
X$43 407 1780 375 407 5 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48 r0 *1 196.88,89.76
X$48 407 6 375 407 1975 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $58 r0 *1 202.4,563.04
X$58 407 7 375 407 4196 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $85 m0 *1 196.88,24.48
X$85 407 755 375 407 8 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $88 m0 *1 190.9,8.16
X$88 407 465 375 407 9 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $91 r0 *1 197.34,2.72
X$91 407 10 407 415 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $93 r0 *1 200.1,73.44
X$93 407 1676 375 407 11 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $99 r0 *1 196.42,24.48
X$99 407 753 375 407 12 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $104 m0 *1 205.16,24.48
X$104 407 13 375 407 757 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $107 m0 *1 201.02,19.04
X$107 407 599 375 407 14 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $110 r0 *1 204.7,29.92
X$110 407 862 375 407 15 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $113 m0 *1 208.84,29.92
X$113 407 16 375 407 890 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $116 m0 *1 204.24,29.92
X$116 407 797 375 407 17 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $119 r0 *1 187.22,2.72
X$119 407 411 375 407 18 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $124 m0 *1 201.02,8.16
X$124 407 19 407 416 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $127 r0 *1 194.12,8.16
X$127 407 20 375 407 551 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $130 r0 *1 204.7,13.6
X$130 407 531 375 407 21 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $139 r0 *1 216.66,563.04
X$139 407 22 375 407 4189 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $145 m0 *1 94.3,111.52
X$145 407 2093 375 407 23 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $149 r0 *1 204.7,2.72
X$149 407 24 407 381 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $152 r0 *1 212.06,8.16
X$152 407 25 407 488 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $160 r0 *1 224.02,563.04
X$160 407 26 375 407 4191 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $164 m0 *1 222.64,40.8
X$164 407 27 375 407 1012 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $169 r0 *1 188.14,13.6
X$169 407 28 375 407 628 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $174 r0 *1 200.1,46.24
X$174 407 1165 375 407 29 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $177 r0 *1 211.14,2.72
X$177 407 30 407 418 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $182 r0 *1 184.46,13.6
X$182 407 31 375 407 752 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $185 m0 *1 218.5,19.04
X$185 407 633 375 407 32 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $187 r0 *1 223.56,40.8
X$187 407 33 375 407 1196 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $193 m0 *1 95.68,122.4
X$193 407 2132 375 407 34 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $202 r0 *1 229.54,563.04
X$202 407 35 375 407 4190 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $208 m0 *1 85.1,73.44
X$208 407 2105 375 407 36 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $212 r0 *1 227.7,40.8
X$212 407 37 375 407 1073 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $217 m0 *1 236.9,46.24
X$217 407 1147 375 407 38 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $220 r0 *1 227.24,46.24
X$220 407 39 375 407 1198 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $223 r0 *1 229.54,35.36
X$223 407 40 375 407 926 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $232 m0 *1 75.9,111.52
X$232 407 2091 375 407 41 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $235 r0 *1 230.92,46.24
X$235 407 42 375 407 1106 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $244 m0 *1 190.9,84.32
X$244 407 1774 375 407 43 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $253 r0 *1 201.94,51.68
X$253 407 1230 375 407 44 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $258 m0 *1 101.2,116.96
X$258 407 2106 375 407 45 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $263 r0 *1 228.16,2.72
X$263 407 46 407 344 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $266 r0 *1 224.48,2.72
X$266 407 422 375 407 47 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $269 r0 *1 231.84,2.72
X$269 407 48 407 559 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $272 m0 *1 241.5,29.92
X$272 407 799 375 407 49 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $279 r0 *1 183.54,68
X$279 407 1613 375 407 50 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $282 m0 *1 224.02,35.36
X$282 407 925 375 407 51 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $285 m0 *1 240.58,13.6
X$285 407 561 375 407 52 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $288 m0 *1 238.74,8.16
X$288 407 469 375 407 53 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $291 r0 *1 237.82,13.6
X$291 407 54 407 640 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $293 m0 *1 241.04,35.36
X$293 407 1078 375 407 55 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $297 r0 *1 237.82,29.92
X$297 407 822 375 407 56 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $300 r0 *1 238.74,2.72
X$300 407 347 375 407 57 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $303 m0 *1 246.1,8.16
X$303 407 58 407 564 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $306 m0 *1 246.1,19.04
X$306 407 59 407 959 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $309 r0 *1 242.42,2.72
X$309 407 347 375 407 60 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $313 m0 *1 235.06,133.28
X$313 407 2193 375 407 61 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $317 m0 *1 242.42,8.16
X$317 407 347 375 407 62 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $320 r0 *1 248.4,8.16
X$320 407 347 375 407 63 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $323 m0 *1 250.24,13.6
X$323 407 64 407 567 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $326 r0 *1 241.96,51.68
X$326 407 1329 375 407 65 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $329 r0 *1 246.1,2.72
X$329 407 431 375 407 66 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $332 r0 *1 251.16,2.72
X$332 407 67 407 350 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $335 m0 *1 255.3,8.16
X$335 407 68 407 498 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $340 m0 *1 258.98,8.16
X$340 407 499 375 407 69 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $353 r0 *1 100.74,144.16
X$353 407 70 375 407 2256 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $356 m0 *1 255.3,19.04
X$356 407 71 407 698 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $358 r0 *1 258.98,2.72
X$358 407 387 375 407 72 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $361 r0 *1 259.9,35.36
X$361 407 960 375 407 73 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $365 m0 *1 261.74,51.68
X$365 407 1262 375 407 74 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $368 r0 *1 259.9,24.48
X$368 407 75 407 831 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $371 r0 *1 259.9,13.6
X$371 407 76 407 644 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $374 m0 *1 254.38,57.12
X$374 407 1488 375 407 77 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $377 r0 *1 264.04,24.48
X$377 407 763 375 407 78 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $382 r0 *1 271.86,46.24
X$382 407 1206 375 407 79 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $389 m0 *1 258.06,149.6
X$389 407 2283 375 407 80 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $392 m0 *1 250.24,62.56
X$392 407 1450 375 407 81 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $399 m0 *1 242.42,57.12
X$399 407 1381 375 407 82 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $402 m0 *1 269.56,35.36
X$402 407 1084 375 407 83 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $405 m0 *1 277.84,19.04
X$405 407 84 407 702 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $410 m0 *1 277.84,13.6
X$410 407 85 407 574 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $413 r0 *1 266.8,13.6
X$413 407 86 407 766 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $416 r0 *1 273.7,2.72
X$416 407 87 407 388 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $419 r0 *1 279.68,35.36
X$419 407 962 375 407 88 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $423 m0 *1 264.5,68
X$423 407 1587 375 407 89 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $427 m0 *1 277.84,8.16
X$427 407 503 375 407 90 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $430 m0 *1 253.92,68
X$430 407 1583 375 407 91 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $432 m0 *1 280.6,24.48
X$432 407 92 407 771 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $436 r0 *1 279.68,2.72
X$436 407 93 407 443 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $442 r0 *1 279.68,568.48
X$442 407 94 375 407 4206 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $447 r0 *1 278.3,57.12
X$447 407 95 375 407 1384 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $451 m0 *1 281.52,13.6
X$451 407 96 407 575 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $456 r0 *1 287.04,2.72
X$456 407 445 375 407 97 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $461 r0 *1 283.36,57.12
X$461 407 98 375 407 1418 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $468 m0 *1 256.22,73.44
X$468 407 1678 375 407 99 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $471 r0 *1 283.36,2.72
X$471 407 505 375 407 100 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $474 r0 *1 287.5,24.48
X$474 407 773 375 407 101 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $478 m0 *1 246.1,73.44
X$478 407 1652 375 407 102 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $484 r0 *1 245.64,51.68
X$484 407 1171 375 407 103 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $487 r0 *1 283.82,51.68
X$487 407 104 375 407 1278 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $489 m0 *1 290.26,568.48
X$489 407 4225 375 407 105 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $493 r0 *1 287.5,57.12
X$493 407 106 375 407 1328 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $496 r0 *1 276.46,46.24
X$496 407 107 375 407 1173 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $499 r0 *1 293.48,8.16
X$499 407 108 375 407 529 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $501 m0 *1 296.7,13.6
X$501 407 109 407 577 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $504 m0 *1 298.08,24.48
X$504 407 110 407 776 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $510 r0 *1 300.84,35.36
X$510 407 967 375 407 111 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $515 r0 *1 302.68,40.8
X$515 407 1089 375 407 112 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $521 r0 *1 191.82,35.36
X$521 407 949 375 407 113 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $524 m0 *1 299.46,573.92
X$524 407 4259 375 407 114 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $528 r0 *1 301.76,563.04
X$528 407 4198 375 407 115 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $531 r0 *1 297.62,2.72
X$531 407 116 375 407 376 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $533 r0 *1 305.44,8.16
X$533 407 117 407 705 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $537 r0 *1 296.24,57.12
X$537 407 118 375 407 1419 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $540 r0 *1 294.4,68
X$540 407 119 375 407 1732 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $545 r0 *1 201.02,29.92
X$545 407 861 375 407 120 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $548 m0 *1 307.28,24.48
X$548 407 737 375 407 121 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $551 r0 *1 301.76,8.16
X$551 407 470 375 407 122 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $588 m0 *1 312.8,563.04
X$588 407 123 375 407 4227 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $593 r0 *1 307.74,29.92
X$593 407 124 375 407 864 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $598 r0 *1 306.36,40.8
X$598 407 125 375 407 981 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $601 r0 *1 310.96,40.8
X$601 407 126 375 407 984 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $604 r0 *1 304.52,35.36
X$604 407 127 375 407 1023 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $611 r0 *1 315.1,563.04
X$611 407 128 375 407 4202 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $615 m0 *1 301.3,40.8
X$615 407 129 375 407 1113 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $619 m0 *1 312.34,35.36
X$619 407 130 375 407 865 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $622 r0 *1 322.46,40.8
X$622 407 131 375 407 1214 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $625 r0 *1 321.54,2.72
X$625 407 132 407 456 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $628 r0 *1 322.92,29.92
X$628 407 133 375 407 868 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $631 r0 *1 319.24,24.48
X$631 407 134 407 781 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $634 r0 *1 326.6,29.92
X$634 407 135 375 407 906 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $636 r0 *1 324.3,8.16
X$636 407 136 407 516 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $640 m0 *1 319.24,24.48
X$640 407 780 375 407 137 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $646 r0 *1 322.92,73.44
X$646 407 1673 375 407 138 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $650 m0 *1 324.3,40.8
X$650 407 1027 375 407 139 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $652 m0 *1 325.22,68
X$652 407 1653 375 407 140 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $655 r0 *1 326.14,40.8
X$655 407 1092 375 407 141 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $662 r0 *1 326.14,68
X$662 407 1629 375 407 142 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $668 m0 *1 328.44,73.44
X$668 407 1654 375 407 143 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $671 m0 *1 328.9,46.24
X$671 407 1153 375 407 144 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $674 m0 *1 333.04,40.8
X$674 407 1029 375 407 145 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $677 r0 *1 333.04,35.36
X$677 407 146 375 407 1094 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $680 m0 *1 333.5,46.24
X$680 407 1218 375 407 147 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $682 m0 *1 333.04,84.32
X$682 407 1828 375 407 148 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $690 r0 *1 336.26,84.32
X$690 407 1815 375 407 149 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $693 m0 *1 339.94,40.8
X$693 407 1044 375 407 150 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $699 m0 *1 336.72,84.32
X$699 407 1814 375 407 151 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $705 r0 *1 340.4,35.36
X$705 407 152 375 407 1032 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $711 m0 *1 340.4,84.32
X$711 407 1826 375 407 153 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $714 r0 *1 342.7,13.6
X$714 407 154 407 717 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $718 m0 *1 338.1,8.16
X$718 407 471 375 407 155 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $721 r0 *1 342.7,40.8
X$721 407 1540 375 407 156 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $724 r0 *1 342.24,2.72
X$724 407 588 375 407 157 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $727 r0 *1 336.72,35.36
X$727 407 158 375 407 1030 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $729 m0 *1 344.08,24.48
X$729 407 739 375 407 159 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $733 r0 *1 338.56,29.92
X$733 407 160 375 407 1096 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $736 r0 *1 348.22,40.8
X$736 407 161 375 407 1221 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $740 r0 *1 355.12,46.24
X$740 407 162 375 407 1223 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $746 m0 *1 335.34,35.36
X$746 407 869 375 407 163 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $748 r0 *1 351.9,40.8
X$748 407 164 375 407 1158 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $752 r0 *1 328.9,2.72
X$752 407 165 407 460 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $757 m0 *1 353.74,46.24
X$757 407 166 375 407 1270 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $760 m0 *1 356.5,13.6
X$760 407 167 407 593 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $763 m0 *1 354.2,24.48
X$763 407 790 375 407 168 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $766 m0 *1 346.84,19.04
X$766 407 676 375 407 169 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $769 r0 *1 354.2,2.72
X$769 407 170 407 357 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $774 m0 *1 341.78,8.16
X$774 407 171 407 462 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $777 m0 *1 355.12,8.16
X$777 407 520 375 407 172 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $780 r0 *1 360.18,46.24
X$780 407 173 375 407 1325 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $783 m0 *1 361.1,51.68
X$783 407 1324 375 407 174 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $787 m0 *1 367.08,51.68
X$787 407 1268 375 407 175 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $791 m0 *1 361.56,78.88
X$791 407 1738 375 407 176 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $794 r0 *1 365.7,2.72
X$794 407 177 407 457 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $798 m0 *1 369.84,8.16
X$798 407 178 407 455 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $801 r0 *1 368.92,19.04
X$801 407 179 407 972 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $805 m0 *1 368.46,24.48
X$805 407 180 407 793 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $810 m0 *1 371.68,51.68
X$810 407 1267 375 407 181 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $813 m0 *1 368.46,84.32
X$813 407 1817 375 407 182 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $816 m0 *1 368.92,35.36
X$816 407 973 375 407 183 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $819 r0 *1 369.84,8.16
X$819 407 473 375 407 184 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $823 r0 *1 374.44,2.72
X$823 407 396 375 407 185 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $827 r0 *1 374.44,35.36
X$827 407 974 375 407 186 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $830 r0 *1 378.12,2.72
X$830 407 454 375 407 187 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $833 m0 *1 373.06,57.12
X$833 407 1370 375 407 188 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $835 m0 *1 374.9,24.48
X$835 407 794 375 407 189 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $839 r0 *1 378.58,46.24
X$839 407 190 375 407 1226 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $844 m0 *1 388.24,8.16
X$844 407 191 407 452 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $846 m0 *1 379.96,46.24
X$846 407 192 375 407 1161 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $850 r0 *1 382.26,51.68
X$850 407 193 375 407 1425 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $852 r0 *1 382.26,2.72
X$852 407 194 407 453 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $856 m0 *1 384.1,19.04
X$856 407 195 407 725 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $859 m0 *1 388.24,19.04
X$859 407 196 407 726 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $862 r0 *1 384.56,13.6
X$862 407 678 375 407 197 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $865 r0 *1 391.92,2.72
X$865 407 451 375 407 198 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $868 r0 *1 386.4,57.12
X$868 407 199 375 407 1533 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $871 m0 *1 388.24,29.92
X$871 407 856 375 407 200 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $873 r0 *1 386.86,46.24
X$873 407 1287 375 407 201 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $877 m0 *1 395.6,40.8
X$877 407 986 375 407 202 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $880 m0 *1 392.38,19.04
X$880 407 203 407 730 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $883 r0 *1 411.24,2.72
X$883 407 204 407 364 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $886 m0 *1 391.92,46.24
X$886 407 1046 375 407 205 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $889 m0 *1 406.18,8.16
X$889 407 206 407 606 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $894 r0 *1 402.04,24.48
X$894 407 207 407 788 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $897 m0 *1 401.12,13.6
X$897 407 208 407 664 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $902 r0 *1 402.04,29.92
X$902 407 915 375 407 209 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $905 m0 *1 401.58,46.24
X$905 407 210 375 407 1116 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $910 r0 *1 396.98,73.44
X$910 407 1743 375 407 211 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $913 m0 *1 406.18,29.92
X$913 407 858 375 407 212 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $916 r0 *1 405.72,40.8
X$916 407 213 375 407 1102 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $919 r0 *1 402.04,40.8
X$919 407 1047 375 407 214 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $922 r0 *1 421.82,8.16
X$922 407 215 407 578 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $928 r0 *1 403.42,78.88
X$928 407 1781 375 407 216 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $931 m0 *1 402.04,40.8
X$931 407 1115 375 407 217 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $935 r0 *1 407.1,8.16
X$935 407 475 375 407 218 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $943 r0 *1 402.04,84.32
X$943 407 1819 375 407 219 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $949 m0 *1 411.24,8.16
X$949 407 369 375 407 220 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $954 r0 *1 419.52,2.72
X$954 407 363 375 407 221 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $957 m0 *1 408.48,13.6
X$957 407 590 375 407 222 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $962 r0 *1 414,40.8
X$962 407 223 407 1103 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $965 m0 *1 415.84,46.24
X$965 407 224 407 1159 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $968 m0 *1 415.84,13.6
X$968 407 225 407 586 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $970 m0 *1 411.24,73.44
X$970 407 1670 375 407 226 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $974 m0 *1 416.3,24.48
X$974 407 851 375 407 227 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $977 r0 *1 417.22,24.48
X$977 407 228 407 848 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $980 m0 *1 415.84,35.36
X$980 407 977 375 407 229 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $983 m0 *1 419.52,8.16
X$983 407 230 407 398 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $986 r0 *1 415.84,2.72
X$986 407 369 375 407 231 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $990 r0 *1 423.2,73.44
X$990 407 232 375 407 1733 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $994 m0 *1 421.82,51.68
X$994 407 233 407 1263 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $997 m0 *1 419.98,19.04
X$997 407 723 375 407 234 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1002 m0 *1 419.98,68
X$1002 407 1572 375 407 235 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1007 r0 *1 429.64,2.72
X$1007 407 366 375 407 236 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1010 r0 *1 424.12,35.36
X$1010 407 1050 375 407 237 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1014 m0 *1 425.5,51.68
X$1014 407 1362 375 407 238 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1017 r0 *1 425.5,19.04
X$1017 407 239 407 720 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1021 m0 *1 427.8,35.36
X$1021 407 240 407 976 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1024 r0 *1 429.64,24.48
X$1024 407 241 407 1215 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1027 m0 *1 425.96,29.92
X$1027 407 871 375 407 242 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1032 r0 *1 429.64,62.56
X$1032 407 1527 375 407 243 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1037 m0 *1 435.16,51.68
X$1037 407 1261 375 407 244 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1040 r0 *1 438.84,13.6
X$1040 407 245 407 784 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1043 m0 *1 434.24,29.92
X$1043 407 246 407 846 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1046 m0 *1 431.94,46.24
X$1046 407 247 375 407 1120 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1049 r0 *1 433.78,19.04
X$1049 407 786 375 407 248 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1051 r0 *1 436.54,46.24
X$1051 407 249 407 1923 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1057 r0 *1 443.44,2.72
X$1057 407 250 407 439 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1060 r0 *1 437.46,57.12
X$1060 407 1607 375 407 251 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1062 m0 *1 439.3,40.8
X$1062 407 252 407 1100 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1068 m0 *1 443.44,8.16
X$1068 407 253 407 514 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1071 m0 *1 447.12,13.6
X$1071 407 254 407 681 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1078 r0 *1 433.32,62.56
X$1078 407 1503 375 407 255 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1081 r0 *1 446.2,51.68
X$1081 407 256 407 1306 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1085 m0 *1 448.5,29.92
X$1085 407 257 407 841 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1091 m0 *1 446.2,46.24
X$1091 407 258 407 1155 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1094 r0 *1 448.96,19.04
X$1094 407 259 375 407 709 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1097 m0 *1 445.74,24.48
X$1097 407 260 407 782 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1103 m0 *1 446.66,62.56
X$1103 407 1505 375 407 261 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1110 m0 *1 425.96,40.8
X$1110 407 1117 375 407 262 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1114 r0 *1 457.24,2.72
X$1114 407 263 375 407 608 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1117 m0 *1 452.64,35.36
X$1117 407 264 407 1182 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1119 m0 *1 449.88,46.24
X$1119 407 1154 375 407 265 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1123 r0 *1 460.92,2.72
X$1123 407 266 375 407 436 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1128 m0 *1 453.56,62.56
X$1128 407 1470 375 407 267 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1131 m0 *1 458.62,8.16
X$1131 407 268 407 508 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1134 m0 *1 450.8,13.6
X$1134 407 541 375 407 269 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1136 r0 *1 457.7,40.8
X$1136 407 270 407 1761 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1140 r0 *1 464.6,2.72
X$1140 407 271 375 407 379 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1143 m0 *1 459.54,51.68
X$1143 407 272 407 1251 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1148 m0 *1 530.84,13.6
X$1148 407 480 375 407 273 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1153 m0 *1 462.3,8.16
X$1153 407 274 375 407 507 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1162 r0 *1 464.6,296.48
X$1162 407 275 375 407 3012 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1166 m0 *1 456.78,19.04
X$1166 407 607 375 407 276 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1171 m0 *1 466.9,46.24
X$1171 407 277 407 1851 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1175 r0 *1 468.28,13.6
X$1175 407 278 407 652 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1183 m0 *1 443.44,89.76
X$1183 407 279 375 407 1886 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1186 m0 *1 471.04,8.16
X$1186 407 280 407 435 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1188 m0 *1 466.9,40.8
X$1188 407 281 407 1085 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1194 r0 *1 466.44,89.76
X$1194 407 1845 375 407 282 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1201 m0 *1 488.52,8.16
X$1201 407 496 375 407 283 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1204 m0 *1 471.04,40.8
X$1204 407 284 407 1082 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1207 r0 *1 475.18,8.16
X$1207 407 502 375 407 285 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1213 m0 *1 472.42,62.56
X$1213 407 1469 375 407 286 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1217 m0 *1 466.9,8.16
X$1217 407 542 375 407 287 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1219 m0 *1 474.72,35.36
X$1219 407 288 407 875 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1224 r0 *1 478.86,8.16
X$1224 407 403 375 407 289 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1230 m0 *1 466.9,19.04
X$1230 407 609 375 407 290 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1235 r0 *1 488.06,2.72
X$1235 407 291 407 421 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1238 r0 *1 474.26,73.44
X$1238 407 292 375 407 1685 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1242 r0 *1 502.32,2.72
X$1242 407 372 375 407 293 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1246 m0 *1 477.94,13.6
X$1246 407 570 375 407 294 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1249 r0 *1 478.86,62.56
X$1249 407 1521 375 407 295 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1256 r0 *1 425.5,46.24
X$1256 407 296 375 407 1216 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1261 m0 *1 483.92,8.16
X$1261 407 297 375 407 497 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1270 m0 *1 503.7,46.24
X$1270 407 1126 375 407 298 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1273 m0 *1 485.3,62.56
X$1273 407 1467 375 407 299 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1278 r0 *1 498.18,8.16
X$1278 407 300 407 491 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1281 r0 *1 491.74,2.72
X$1281 407 420 375 407 301 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1284 m0 *1 499.56,13.6
X$1284 407 302 407 558 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1289 m0 *1 500.48,19.04
X$1289 407 303 407 691 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1295 r0 *1 485.76,84.32
X$1295 407 1847 375 407 304 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1301 m0 *1 511.06,13.6
X$1301 407 305 407 557 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1304 m0 *1 486.68,29.92
X$1304 407 769 375 407 306 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1311 r0 *1 540.04,8.16
X$1311 407 552 375 407 307 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1314 r0 *1 487.6,78.88
X$1314 407 1754 375 407 308 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1317 r0 *1 512.44,2.72
X$1317 407 309 407 412 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1320 r0 *1 498.64,2.72
X$1320 407 699 375 407 310 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1324 r0 *1 504.16,57.12
X$1324 407 1398 375 407 311 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1328 m0 *1 494.5,19.04
X$1328 407 642 375 407 312 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1332 m0 *1 537.28,29.92
X$1332 407 810 375 407 313 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1335 r0 *1 493.12,57.12
X$1335 407 1293 375 407 314 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1343 r0 *1 525.78,19.04
X$1343 407 686 375 407 315 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1346 m0 *1 498.64,51.68
X$1346 407 1294 375 407 316 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1350 r0 *1 519.8,2.72
X$1350 407 413 375 407 317 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1354 r0 *1 506,2.72
X$1354 407 318 375 407 405 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1361 r0 *1 515.66,46.24
X$1361 407 1186 375 407 319 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1364 r0 *1 501.86,8.16
X$1364 407 320 407 493 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1367 m0 *1 504.16,24.48
X$1367 407 321 407 762 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1370 r0 *1 499.1,13.6
X$1370 407 322 375 407 641 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1373 r0 *1 506,35.36
X$1373 407 323 407 1009 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1376 r0 *1 516.12,2.72
X$1376 407 324 407 487 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1380 r0 *1 450.8,2.72
X$1380 407 369 375 407 325 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1384 m0 *1 504.62,62.56
X$1384 407 1565 375 407 326 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1387 r0 *1 515.66,13.6
X$1387 407 327 407 816 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1390 r0 *1 506.92,40.8
X$1390 407 1133 375 407 328 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1393 m0 *1 508.3,8.16
X$1393 407 329 375 407 370 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1396 m0 *1 513.82,35.36
X$1396 407 330 407 887 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1402 r0 *1 508.3,51.68
X$1402 407 1295 375 407 331 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1406 r0 *1 526.24,2.72
X$1406 407 406 375 407 332 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1411 r0 *1 524.4,8.16
X$1411 407 333 407 555 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1414 r0 *1 512.44,35.36
X$1414 407 334 407 1005 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1417 m0 *1 514.28,73.44
X$1417 407 1660 375 407 335 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1425 r0 *1 408.02,84.32
X$1425 407 1840 375 407 336 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1429 m0 *1 518.42,57.12
X$1429 407 1343 375 407 337 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1432 m0 *1 518.42,19.04
X$1432 407 635 375 407 338 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1436 m0 *1 509.68,46.24
X$1436 407 339 375 407 1125 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1440 m0 *1 529.92,8.16
X$1440 407 340 407 408 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1443 r0 *1 521.64,19.04
X$1443 407 341 375 407 683 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1452 m0 *1 394.68,57.12
X$1452 407 1373 375 407 342 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1459 m0 *1 434.7,68
X$1459 407 1560 375 407 343 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1461 r0 *1 218.5,2.72
X$1461 407 344 375 407 425 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1465 m0 *1 227.7,24.48
X$1465 407 760 375 407 345 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1505 m0 *1 300.84,51.68
X$1505 375 1211 1114 1089 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1507 r0 *1 236.44,2.72
X$1507 407 346 347 495 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $1510 m0 *1 232.76,8.16
X$1510 375 428 386 469 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1513 m0 *1 258.06,57.12
X$1513 375 1358 1233 1262 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1515 r0 *1 270.94,51.68
X$1515 375 1311 1204 1206 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1517 m0 *1 253.46,46.24
X$1517 375 1148 1112 960 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1520 m0 *1 187.22,13.6
X$1520 375 550 549 465 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1522 m0 *1 174.8,13.6
X$1522 375 547 409 411 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1524 m0 *1 195.04,19.04
X$1524 375 685 598 599 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1527 r0 *1 209.76,13.6
X$1527 375 530 632 531 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1529 r0 *1 227.24,24.48
X$1529 375 734 735 760 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1531 r0 *1 228.16,13.6
X$1531 375 688 639 422 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1533 r0 *1 240.58,19.04
X$1533 375 689 670 561 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1535 r0 *1 236.44,40.8
X$1535 375 1077 1017 1078 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1538 m0 *1 233.22,29.92
X$1538 375 821 798 822 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1541 m0 *1 213.44,29.92
X$1541 375 759 696 633 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1543 m0 *1 245.18,29.92
X$1543 375 824 800 799 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1546 r0 *1 300.38,19.04
X$1546 375 650 674 653 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1548 r0 *1 297.16,8.16
X$1548 375 510 466 470 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1550 m0 *1 282.44,40.8
X$1550 375 1087 983 962 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1552 m0 *1 263.58,40.8
X$1552 375 982 961 1084 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1554 m0 *1 286.58,35.36
X$1554 375 802 901 773 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1557 m0 *1 273.24,8.16
X$1557 375 440 384 505 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1559 r0 *1 287.04,8.16
X$1559 375 506 468 446 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1561 r0 *1 303.6,29.92
X$1561 375 736 836 737 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1563 m0 *1 294.4,40.8
X$1563 375 1088 965 967 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1565 r0 *1 264.04,19.04
X$1565 375 672 700 499 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1567 m0 *1 269.1,13.6
X$1567 375 701 534 503 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1569 r0 *1 258.52,29.92
X$1569 375 801 896 763 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1572 m0 *1 286.58,19.04
X$1572 375 703 648 445 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1575 r0 *1 264.5,8.16
X$1575 375 500 501 387 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1577 m0 *1 80.04,122.4
X$1577 375 2136 2137 2093 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1579 r0 *1 74.52,116.96
X$1579 375 2104 2121 2105 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1582 r0 *1 64.86,116.96
X$1582 375 2124 2123 2091 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1585 r0 *1 64.86,122.4
X$1585 407 2133 407 375 346 375 sky130_fd_sc_hd__buf_4
* cell instance $1588 m0 *1 251.16,19.04
X$1588 375 643 600 431 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1591 r0 *1 87.86,116.96
X$1591 375 2112 2125 2106 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1594 r0 *1 86.48,122.4
X$1594 375 2139 2140 2132 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1596 r0 *1 236.44,46.24
X$1596 375 1199 1174 1147 346 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1608 r0 *1 238.28,8.16
X$1608 375 494 347 532 495 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1611 m0 *1 251.62,8.16
X$1611 407 348 407 433 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1614 r0 *1 256.22,24.48
X$1614 407 349 407 828 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1616 r0 *1 264.04,2.72
X$1616 407 350 375 407 438 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1620 m0 *1 285.2,13.6
X$1620 407 351 407 576 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1623 r0 *1 293.94,2.72
X$1623 407 446 375 407 352 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1626 r0 *1 301.3,2.72
X$1626 407 353 407 447 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1629 m0 *1 307.74,13.6
X$1629 407 653 375 407 354 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1631 r0 *1 338.56,2.72
X$1631 407 355 407 392 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1635 m0 *1 334.42,8.16
X$1635 407 356 407 458 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1637 r0 *1 349.6,2.72
X$1637 407 357 375 407 461 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1641 r0 *1 360.64,2.72
X$1641 407 358 407 395 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1643 m0 *1 361.56,46.24
X$1643 407 359 375 407 1224 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1647 m0 *1 369.38,13.6
X$1647 407 360 407 595 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1650 r0 *1 395.6,2.72
X$1650 407 361 407 448 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1654 m0 *1 397.44,13.6
X$1654 407 539 375 407 362 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1659 r0 *1 429.64,8.16
X$1659 375 518 476 363 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1662 m0 *1 424.12,8.16
X$1662 375 371 363 399 518 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1665 r0 *1 423.2,2.72
X$1665 407 364 375 407 583 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1669 m0 *1 425.96,13.6
X$1669 407 365 407 581 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1674 m0 *1 437.46,8.16
X$1674 375 442 400 366 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1676 r0 *1 433.32,2.72
X$1676 375 371 366 399 442 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1679 r0 *1 447.12,2.72
X$1679 407 369 375 407 367 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1682 m0 *1 448.04,35.36
X$1682 407 368 407 904 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1694 r0 *1 412.62,8.16
X$1694 375 371 369 397 587 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1696 m0 *1 412.62,13.6
X$1696 407 377 369 587 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $1704 r0 *1 442.98,8.16
X$1704 375 477 476 370 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $1706 m0 *1 424.58,24.48
X$1706 375 371 786 399 680 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1707 m0 *1 499.1,8.16
X$1707 375 371 400 618 492 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1708 m0 *1 487.6,24.48
X$1708 375 371 699 432 768 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1709 m0 *1 477.94,19.04
X$1709 375 371 402 432 645 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1710 m0 *1 471.5,29.92
X$1710 375 371 746 513 833 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1711 m0 *1 427.8,57.12
X$1711 375 371 1261 1180 1341 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1712 m0 *1 429.64,13.6
X$1712 375 371 541 399 658 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1713 m0 *1 433.78,35.36
X$1713 375 371 872 399 975 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1714 m0 *1 415.84,40.8
X$1714 375 371 1050 397 1037 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1715 m0 *1 504.62,51.68
X$1715 375 371 1126 1244 1188 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1716 m0 *1 509.22,57.12
X$1716 375 371 1343 1244 1351 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1717 m0 *1 376.74,8.16
X$1717 375 371 451 528 527 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1718 m0 *1 378.58,57.12
X$1718 375 371 1287 1337 1374 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1719 m0 *1 421.36,62.56
X$1719 375 371 1462 1180 1461 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1720 m0 *1 499.1,57.12
X$1720 375 371 1295 1244 1297 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1721 m0 *1 350.98,40.8
X$1721 375 371 970 601 1033 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1722 m0 *1 370.76,19.04
X$1722 375 371 454 393 667 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1723 m0 *1 361.56,19.04
X$1723 375 371 604 393 665 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1724 m0 *1 396.98,29.92
X$1724 375 371 915 860 917 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1725 m0 *1 369.84,29.92
X$1725 375 371 794 393 852 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1726 m0 *1 459.54,24.48
X$1726 375 371 610 513 838 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1727 m0 *1 461.38,13.6
X$1727 375 371 542 432 573 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1728 m0 *1 396.98,8.16
X$1728 375 371 474 397 521 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1729 m0 *1 483.92,57.12
X$1729 375 371 1293 874 1301 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1730 m0 *1 513.36,68
X$1730 375 371 1563 1244 1611 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1731 m0 *1 514.28,46.24
X$1731 375 371 945 618 1129 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1732 m0 *1 528.08,19.04
X$1732 375 371 545 479 625 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1733 m0 *1 526.24,29.92
X$1733 375 371 750 479 812 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1734 m0 *1 534.52,8.16
X$1734 375 371 480 479 481 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1735 m0 *1 537.28,19.04
X$1735 375 371 552 479 554 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1736 r0 *1 485.76,13.6
X$1736 375 371 566 432 426 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1737 r0 *1 409.4,29.92
X$1737 375 371 804 397 855 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1738 r0 *1 408.94,35.36
X$1738 375 371 977 397 1038 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1739 r0 *1 512.44,24.48
X$1739 375 371 749 618 748 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1740 r0 *1 356.96,35.36
X$1740 375 371 973 601 1034 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1741 r0 *1 348.68,19.04
X$1741 375 371 602 601 716 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1742 r0 *1 354.2,13.6
X$1742 375 371 473 393 663 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1743 r0 *1 492.66,29.92
X$1743 375 371 877 432 829 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1744 r0 *1 347.76,29.92
X$1744 375 371 790 601 910 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1745 r0 *1 490.82,62.56
X$1745 375 371 1466 1514 1513 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1746 r0 *1 512.44,19.04
X$1746 375 371 635 618 687 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1747 r0 *1 529.46,8.16
X$1747 375 371 546 479 484 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1748 r0 *1 463.68,57.12
X$1748 375 371 1122 1292 1250 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1749 r0 *1 419.98,13.6
X$1749 375 371 540 399 584 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1750 r0 *1 488.98,8.16
X$1750 375 371 420 432 423 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1751 r0 *1 418.6,29.92
X$1751 375 371 871 399 912 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1752 r0 *1 389.16,51.68
X$1752 375 371 986 860 1316 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1753 r0 *1 380.42,40.8
X$1753 375 371 985 860 1035 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1754 r0 *1 475.18,2.72
X$1754 375 371 403 432 430 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1755 r0 *1 502.78,13.6
X$1755 375 371 406 618 562 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1756 r0 *1 502.78,19.04
X$1756 375 371 690 618 694 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1757 r0 *1 385.02,73.44
X$1757 375 371 1373 1337 1704 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1758 r0 *1 502.78,62.56
X$1758 375 371 1398 1244 1564 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1759 r0 *1 498.64,46.24
X$1759 375 371 1133 874 1189 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1760 r0 *1 489.9,51.68
X$1760 375 371 1294 874 1299 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1761 r0 *1 442.52,57.12
X$1761 375 371 1291 1292 1359 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1762 r0 *1 443.44,24.48
X$1762 375 371 742 513 843 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1766 r0 *1 433.78,8.16
X$1766 375 371 476 399 477 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1773 r0 *1 378.12,29.92
X$1773 375 371 854 528 853 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1777 r0 *1 457.7,19.04
X$1777 375 371 609 513 707 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1779 r0 *1 440.22,46.24
X$1779 375 371 1209 1180 1213 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1783 m0 *1 423.66,19.04
X$1783 375 371 679 399 719 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1787 r0 *1 457.24,51.68
X$1787 375 371 1212 1292 1241 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1794 m0 *1 453.56,57.12
X$1794 375 371 1051 1292 1357 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1797 r0 *1 515.2,8.16
X$1797 375 371 413 479 414 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1799 m0 *1 516.58,13.6
X$1799 375 371 544 479 634 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1803 m0 *1 454.94,40.8
X$1803 375 371 682 513 1024 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1810 r0 *1 437,51.68
X$1810 375 371 1154 1180 1260 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1818 r0 *1 438.84,35.36
X$1818 375 371 987 1180 929 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1828 r0 *1 444.36,29.92
X$1828 375 371 837 513 806 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1831 m0 *1 506.92,40.8
X$1831 375 371 953 618 1006 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1833 m0 *1 452.64,29.92
X$1833 375 371 743 513 779 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1837 r0 *1 471.5,19.04
X$1837 375 371 543 513 704 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1844 r0 *1 375.36,19.04
X$1844 375 371 677 528 721 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1850 r0 *1 364.32,51.68
X$1850 375 371 1324 1286 1327 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1853 r0 *1 494.96,68
X$1853 375 371 1565 1514 1566 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1857 m0 *1 368.92,40.8
X$1857 375 371 974 393 1045 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1861 m0 *1 368.92,46.24
X$1861 375 371 1099 1286 1160 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1871 m0 *1 360.64,29.92
X$1871 375 371 791 393 850 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1874 m0 *1 478.4,24.48
X$1874 375 371 769 432 774 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1880 r0 *1 529.46,35.36
X$1880 375 371 883 618 947 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1884 r0 *1 475.18,46.24
X$1884 375 371 711 874 1123 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1888 r0 *1 523.02,46.24
X$1888 375 371 946 618 1063 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1890 r0 *1 409.4,13.6
X$1890 375 371 660 399 661 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1894 m0 *1 378.12,13.6
X$1894 375 371 525 528 596 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1897 r0 *1 528.54,57.12
X$1897 375 371 1345 1244 1344 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1901 r0 *1 529,62.56
X$1901 375 371 1464 1244 1463 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1903 r0 *1 387.78,8.16
X$1903 375 371 539 528 524 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1905 r0 *1 402.04,2.72
X$1905 375 371 475 397 519 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1907 m0 *1 402.96,19.04
X$1907 375 371 590 397 732 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1915 r0 *1 411.24,19.04
X$1915 375 371 723 397 727 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1918 r0 *1 492.2,19.04
X$1918 375 371 642 432 764 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1924 r0 *1 515.2,51.68
X$1924 375 371 1186 1244 1245 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1929 m0 *1 391.46,35.36
X$1929 375 371 916 860 918 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1931 m0 *1 375.82,35.36
X$1931 375 371 856 528 919 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1936 r0 *1 465.98,8.16
X$1936 375 371 502 432 572 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1939 m0 *1 391,24.48
X$1939 375 371 729 528 728 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1943 r0 *1 376.28,24.48
X$1943 375 371 678 528 795 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1945 r0 *1 392.38,24.48
X$1945 375 371 858 528 740 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1949 r0 *1 407.1,24.48
X$1949 375 371 851 397 741 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1954 r0 *1 389.62,40.8
X$1954 375 371 1046 860 1101 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1957 m0 *1 477.48,51.68
X$1957 375 371 873 874 1146 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1961 m0 *1 388.24,13.6
X$1961 375 371 605 528 668 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1964 m0 *1 484.84,40.8
X$1964 375 371 942 874 1014 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1967 m0 *1 529,24.48
X$1967 375 371 686 479 751 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1969 r0 *1 491.74,40.8
X$1969 375 371 372 874 1071 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1973 m0 *1 365.7,68
X$1973 375 371 1268 1286 1588 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1975 r0 *1 472.88,57.12
X$1975 375 371 570 874 1404 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1977 m0 *1 474.72,57.12
X$1977 375 371 1057 874 1247 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1980 m0 *1 446.2,19.04
X$1980 375 371 607 513 656 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1986 r0 *1 392.38,46.24
X$1986 375 371 1115 860 1227 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1988 r0 *1 415.84,57.12
X$1988 375 371 1362 860 1412 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1991 m0 *1 448.04,8.16
X$1991 375 371 511 513 401 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1997 r0 *1 488.52,46.24
X$1997 375 371 496 874 1190 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $1999 r0 *1 530.38,29.92
X$1999 375 371 810 479 885 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $2002 m0 *1 479.32,35.36
X$2002 375 371 876 874 897 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $2004 m0 *1 471.5,68
X$2004 375 371 1521 1292 1562 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $2006 r0 *1 526.24,40.8
X$2006 375 371 996 618 1061 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $2008 r0 *1 366.62,46.24
X$2008 375 380 371 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $2015 m0 *1 494.04,40.8
X$2015 375 1071 877 372 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $2020 m0 *1 507.38,13.6
X$2020 407 373 407 619 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2026 m0 *1 508.76,62.56
X$2026 407 1462 375 407 374 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2743 r0 *1 201.02,2.72
X$2743 407 381 375 407 417 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2748 r0 *1 214.82,2.72
X$2748 407 418 375 407 419 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2756 r0 *1 254.84,2.72
X$2756 407 433 375 407 437 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2763 r0 *1 270.02,2.72
X$2763 407 388 375 407 441 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2774 r0 *1 306.82,2.72
X$2774 375 380 378 391 450 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $2781 r0 *1 325.22,2.72
X$2781 407 458 375 407 459 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2784 r0 *1 334.88,2.72
X$2784 407 392 375 407 659 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2797 r0 *1 369.38,2.72
X$2797 407 455 375 407 594 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2803 r0 *1 388.24,2.72
X$2803 407 452 375 407 449 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2823 r0 *1 471.04,2.72
X$2823 407 435 375 407 434 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2828 r0 *1 485.76,2.72
X$2828 407 429 427 404 569 375 407 426 375 sky130_fd_sc_hd__a31oi_1
* cell instance $2839 r0 *1 529.92,2.72
X$2839 407 408 375 407 623 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3020 m0 *1 169.28,8.16
X$3020 375 464 409 463 482 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3022 m0 *1 180.32,8.16
X$3022 375 464 549 463 548 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3028 m0 *1 197.34,8.16
X$3028 407 415 375 407 382 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3029 m0 *1 204.7,8.16
X$3029 375 486 466 382 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3032 m0 *1 211.14,8.16
X$3032 375 464 384 467 383 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3035 m0 *1 222.64,8.16
X$3035 375 383 384 419 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3037 m0 *1 228.62,8.16
X$3037 375 424 386 425 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3042 m0 *1 262.66,8.16
X$3042 375 380 387 389 500 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3046 m0 *1 281.52,8.16
X$3046 407 443 375 407 444 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3049 m0 *1 286.58,8.16
X$3049 375 380 446 389 506 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3050 m0 *1 295.78,8.16
X$3050 375 380 470 509 510 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3054 m0 *1 308.2,8.16
X$3054 375 450 390 378 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3055 m0 *1 312.34,8.16
X$3055 375 380 390 391 515 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3057 m0 *1 323.38,8.16
X$3057 375 380 471 391 517 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3061 m0 *1 345.46,8.16
X$3061 375 380 520 393 394 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3066 m0 *1 360.64,8.16
X$3066 375 380 396 393 522 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3072 m0 *1 391.92,8.16
X$3072 407 448 375 407 523 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3079 m0 *1 415.84,8.16
X$3079 407 398 375 407 724 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3093 m0 *1 477.48,8.16
X$3093 375 430 402 403 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3097 m0 *1 492.2,8.16
X$3097 375 423 566 420 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3101 m0 *1 511.98,8.16
X$3101 407 487 375 407 489 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3105 m0 *1 518.88,8.16
X$3105 375 414 544 413 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3108 m0 *1 524.4,8.16
X$3108 407 478 617 483 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $3110 m0 *1 526.24,8.16
X$3110 407 412 375 407 410 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3231 r0 *1 171.58,8.16
X$3231 375 464 411 463 547 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3235 r0 *1 184.92,8.16
X$3235 375 464 465 463 550 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3238 r0 *1 199.18,8.16
X$3238 375 464 466 467 486 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3244 r0 *1 215.74,8.16
X$3244 407 488 375 407 490 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3245 r0 *1 219.42,8.16
X$3245 375 556 468 490 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3247 r0 *1 225.4,8.16
X$3247 375 494 386 467 424 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3257 r0 *1 255.3,8.16
X$3257 407 498 375 407 533 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3260 r0 *1 259.44,8.16
X$3260 375 568 501 438 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3266 r0 *1 275.08,8.16
X$3266 375 380 505 389 440 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3276 r0 *1 314.64,8.16
X$3276 375 515 390 580 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3280 r0 *1 320.62,8.16
X$3280 407 456 375 407 582 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3281 r0 *1 327.98,8.16
X$3281 375 517 537 471 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3283 r0 *1 333.96,8.16
X$3283 375 380 588 601 585 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3291 r0 *1 348.22,8.16
X$3291 375 591 538 461 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3294 r0 *1 355.12,8.16
X$3294 375 380 526 393 592 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3295 r0 *1 364.32,8.16
X$3295 375 522 526 396 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3304 r0 *1 377.66,8.16
X$3304 375 596 525 449 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3306 r0 *1 383.64,8.16
X$3306 375 527 525 451 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3309 r0 *1 397.44,8.16
X$3309 375 521 474 666 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3312 r0 *1 402.96,8.16
X$3312 375 519 474 475 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3318 r0 *1 447.58,8.16
X$3318 375 401 511 512 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3326 r0 *1 461.38,8.16
X$3326 407 508 375 407 504 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3331 r0 *1 484.84,8.16
X$3331 407 429 404 427 497 569 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $3334 r0 *1 505.54,8.16
X$3334 375 492 400 489 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3340 r0 *1 528.08,8.16
X$3340 407 483 485 484 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $3472 m0 *1 170.66,13.6
X$3472 375 482 409 529 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3477 m0 *1 183.08,13.6
X$3477 375 548 549 376 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3485 m0 *1 203.78,13.6
X$3485 375 464 531 467 530 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3488 m0 *1 212.98,13.6
X$3488 375 494 468 467 556 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3491 m0 *1 224.48,13.6
X$3491 407 559 375 407 638 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3494 m0 *1 230.46,13.6
X$3494 375 494 469 532 428 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3499 m0 *1 244.72,13.6
X$3499 407 564 375 407 563 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3503 m0 *1 253.92,13.6
X$3503 375 565 600 437 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3507 m0 *1 258.98,13.6
X$3507 375 380 501 389 568 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3509 m0 *1 273.24,13.6
X$3509 375 571 534 441 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3517 m0 *1 301.3,13.6
X$3517 407 447 375 407 535 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3525 m0 *1 315.56,13.6
X$3525 407 460 375 407 580 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3526 m0 *1 319.24,13.6
X$3526 375 380 537 391 536 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3527 m0 *1 328.44,13.6
X$3527 375 536 537 459 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3531 m0 *1 337.64,13.6
X$3531 375 585 589 588 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3536 m0 *1 343.16,13.6
X$3536 375 380 538 393 591 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3537 m0 *1 352.36,13.6
X$3537 375 394 538 520 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3539 m0 *1 360.64,13.6
X$3539 375 592 526 594 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3541 m0 *1 365.7,13.6
X$3541 407 457 375 407 603 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3556 m0 *1 421.36,13.6
X$3556 375 584 540 583 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3560 m0 *1 438.84,13.6
X$3560 407 514 375 407 579 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3563 m0 *1 443.44,13.6
X$3563 407 578 375 407 512 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3571 m0 *1 471.04,13.6
X$3571 375 572 543 502 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3576 m0 *1 481.62,13.6
X$3576 375 626 432 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $3577 m0 *1 490.82,13.6
X$3577 407 566 407 375 404 375 sky130_fd_sc_hd__inv_1
* cell instance $3580 m0 *1 494.5,13.6
X$3580 407 421 375 407 560 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3585 m0 *1 503.24,13.6
X$3585 375 562 511 406 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3588 m0 *1 526.24,13.6
X$3588 407 555 375 407 478 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3593 m0 *1 534.98,13.6
X$3593 375 554 545 552 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3594 m0 *1 539.12,13.6
X$3594 375 481 546 480 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3731 r0 *1 191.82,13.6
X$3731 407 551 407 375 627 375 sky130_fd_sc_hd__inv_1
* cell instance $3733 r0 *1 196.88,13.6
X$3733 407 416 375 407 629 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3739 r0 *1 213.9,13.6
X$3739 375 631 632 417 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3743 r0 *1 223.1,13.6
X$3743 375 637 639 638 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3750 r0 *1 241.5,13.6
X$3750 375 380 431 532 643 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3751 r0 *1 250.7,13.6
X$3751 375 380 600 389 565 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3756 r0 *1 270.48,13.6
X$3756 375 380 534 389 571 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3759 r0 *1 281.98,13.6
X$3759 375 380 648 389 647 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3764 r0 *1 293.94,13.6
X$3764 375 380 653 509 650 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3766 r0 *1 306.82,13.6
X$3766 375 380 553 391 654 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3772 r0 *1 319.7,13.6
X$3772 375 675 391 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $3773 r0 *1 328.9,13.6
X$3773 407 462 375 407 713 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3776 r0 *1 337.18,13.6
X$3776 375 657 589 659 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3782 r0 *1 350.52,13.6
X$3782 407 395 375 407 662 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3785 r0 *1 365.7,13.6
X$3785 375 665 604 603 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3787 r0 *1 369.84,13.6
X$3787 375 667 604 454 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3792 r0 *1 380.88,13.6
X$3792 407 453 375 407 722 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3794 r0 *1 388.7,13.6
X$3794 375 668 605 523 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3795 r0 *1 392.84,13.6
X$3795 375 524 605 539 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3798 r0 *1 397.44,13.6
X$3798 407 664 375 407 731 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3807 r0 *1 429.64,13.6
X$3807 375 675 399 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $3808 r0 *1 442.52,13.6
X$3808 407 439 375 407 715 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3818 r0 *1 462.76,13.6
X$3818 375 573 610 542 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3819 r0 *1 466.9,13.6
X$3819 407 434 427 651 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $3820 r0 *1 471.96,13.6
X$3820 407 652 375 407 649 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $3823 r0 *1 477.48,13.6
X$3823 407 649 427 615 407 614 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $3824 r0 *1 479.32,13.6
X$3824 407 616 614 645 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $3826 r0 *1 481.16,13.6
X$3826 407 611 646 402 543 617 407 616 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $3837 r0 *1 519.8,13.6
X$3837 375 634 544 623 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3839 r0 *1 524.4,13.6
X$3839 407 410 617 624 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $3841 r0 *1 526.7,13.6
X$3841 407 546 427 485 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $3842 r0 *1 528.08,13.6
X$3842 407 624 630 625 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $3843 r0 *1 529.46,13.6
X$3843 375 626 479 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $3980 m0 *1 181.24,19.04
X$3980 375 464 598 463 597 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3981 m0 *1 190.44,19.04
X$3981 375 597 598 629 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $3988 m0 *1 207.46,19.04
X$3988 375 464 632 467 631 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3992 m0 *1 224.48,19.04
X$3992 375 494 639 532 637 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $3997 m0 *1 235.06,19.04
X$3997 375 494 561 532 689 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4003 m0 *1 258.98,19.04
X$4003 375 380 499 389 672 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4004 m0 *1 268.18,19.04
X$4004 375 669 389 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4006 m0 *1 281.52,19.04
X$4006 375 647 648 444 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4011 m0 *1 294.4,19.04
X$4011 375 380 674 509 673 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4018 m0 *1 310.5,19.04
X$4018 375 380 655 391 706 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4022 m0 *1 321.54,19.04
X$4022 375 380 785 391 710 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4026 m0 *1 333.96,19.04
X$4026 375 380 589 601 657 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4030 m0 *1 350.52,19.04
X$4030 375 716 602 662 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4033 m0 *1 356.04,19.04
X$4033 375 663 602 473 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4038 m0 *1 379.96,19.04
X$4038 375 721 677 722 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4044 m0 *1 396.52,19.04
X$4044 407 606 375 407 666 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4051 m0 *1 415.84,19.04
X$4051 375 661 660 724 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4054 m0 *1 432.86,19.04
X$4054 375 658 540 541 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4063 m0 *1 455.4,19.04
X$4063 407 608 427 708 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4064 m0 *1 460.46,19.04
X$4064 375 707 682 609 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4069 m0 *1 471.96,19.04
X$4069 407 611 612 651 543 613 407 704 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $4070 m0 *1 475.18,19.04
X$4070 407 611 612 617 543 375 613 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $4073 m0 *1 487.14,19.04
X$4073 407 612 543 402 611 407 429 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $4081 m0 *1 504.16,19.04
X$4081 407 619 375 407 620 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4082 m0 *1 507.84,19.04
X$4082 407 620 427 693 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4085 m0 *1 510.6,19.04
X$4085 407 491 375 407 622 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4086 m0 *1 514.28,19.04
X$4086 407 621 377 636 407 687 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $4088 m0 *1 516.58,19.04
X$4088 407 635 377 636 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $4093 m0 *1 526.7,19.04
X$4093 407 545 427 630 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $4230 r0 *1 181.7,19.04
X$4230 407 628 407 375 684 375 sky130_fd_sc_hd__inv_1
* cell instance $4234 r0 *1 192.28,19.04
X$4234 375 464 599 463 685 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4242 r0 *1 210.68,19.04
X$4242 375 669 467 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4247 r0 *1 226.78,19.04
X$4247 375 494 422 532 688 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4253 r0 *1 246.56,19.04
X$4253 375 380 696 389 695 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4256 r0 *1 258.52,19.04
X$4256 375 697 700 533 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4262 r0 *1 270.94,19.04
X$4262 375 380 503 389 701 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4264 r0 *1 281.98,19.04
X$4264 375 380 445 389 703 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4269 r0 *1 296.24,19.04
X$4269 375 673 674 535 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4270 r0 *1 304.52,19.04
X$4270 407 705 375 407 968 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4273 r0 *1 310.5,19.04
X$4273 375 654 655 553 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4275 r0 *1 314.64,19.04
X$4275 375 706 655 713 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4278 r0 *1 319.7,19.04
X$4278 375 391 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $4281 r0 *1 327.06,19.04
X$4281 375 380 676 391 712 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4286 r0 *1 342.7,19.04
X$4286 407 717 375 407 718 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4290 r0 *1 358.8,19.04
X$4290 375 675 393 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4297 r0 *1 384.56,19.04
X$4297 375 675 528 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4300 r0 *1 395.6,19.04
X$4300 375 728 729 731 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4303 r0 *1 402.04,19.04
X$4303 375 732 660 590 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4304 r0 *1 406.18,19.04
X$4304 375 397 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $4305 r0 *1 420.44,19.04
X$4305 375 727 679 723 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4309 r0 *1 429.64,19.04
X$4309 375 719 679 579 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4311 r0 *1 441.14,19.04
X$4311 407 681 375 407 805 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4312 r0 *1 444.82,19.04
X$4312 407 715 427 714 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4316 r0 *1 452.64,19.04
X$4316 375 656 711 607 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4322 r0 *1 480.7,19.04
X$4322 407 646 543 402 611 407 615 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $4323 r0 *1 483,19.04
X$4323 407 432 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4332 r0 *1 529.46,19.04
X$4332 375 479 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $4470 m0 *1 178.94,24.48
X$4470 407 463 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $4471 m0 *1 180.78,24.48
X$4471 375 669 463 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4481 m0 *1 209.3,24.48
X$4481 375 494 633 467 759 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4491 m0 *1 234.14,24.48
X$4491 407 532 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4492 m0 *1 235.52,24.48
X$4492 375 494 670 532 671 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4493 m0 *1 244.72,24.48
X$4493 375 671 670 563 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4496 m0 *1 250.24,24.48
X$4496 375 695 696 770 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4498 m0 *1 255.3,24.48
X$4498 375 380 700 389 697 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4503 m0 *1 267.26,24.48
X$4503 375 380 735 389 765 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4514 m0 *1 294.4,24.48
X$4514 407 577 375 407 964 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4525 m0 *1 322.92,24.48
X$4525 375 710 785 582 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4528 m0 *1 328.44,24.48
X$4528 375 712 785 676 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4531 m0 *1 334.88,24.48
X$4531 375 380 739 601 787 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4538 m0 *1 358.8,24.48
X$4538 407 393 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4542 m0 *1 364.78,24.48
X$4542 407 595 375 407 792 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4549 m0 *1 380.88,24.48
X$4549 375 795 677 678 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4550 m0 *1 385.02,24.48
X$4550 407 528 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4558 m0 *1 400.2,24.48
X$4558 375 740 729 858 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4560 m0 *1 406.18,24.48
X$4560 375 675 397 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4563 m0 *1 419.98,24.48
X$4563 407 586 375 407 849 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4567 m0 *1 433.78,24.48
X$4567 375 680 743 786 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4579 m0 *1 455.4,24.48
X$4579 407 513 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4581 m0 *1 457.7,24.48
X$4581 407 507 427 777 407 778 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $4592 m0 *1 499.56,24.48
X$4592 407 641 427 745 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4598 m0 *1 507.84,24.48
X$4598 407 690 646 747 692 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $4600 m0 *1 510.6,24.48
X$4600 407 692 621 427 683 761 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $4604 m0 *1 522.1,24.48
X$4604 407 557 375 407 754 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4744 r0 *1 181.24,24.48
X$4744 407 752 407 375 811 375 sky130_fd_sc_hd__inv_1
* cell instance $4755 r0 *1 208.84,24.48
X$4755 407 757 407 375 815 375 sky130_fd_sc_hd__inv_1
* cell instance $4757 r0 *1 210.68,24.48
X$4757 375 467 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $4759 r0 *1 217.58,24.48
X$4759 375 494 760 467 734 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4763 r0 *1 232.3,24.48
X$4763 407 640 375 407 820 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4765 r0 *1 236.44,24.48
X$4765 375 669 532 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4773 r0 *1 267.72,24.48
X$4773 375 765 735 767 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4774 r0 *1 271.86,24.48
X$4774 407 766 375 407 767 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4775 r0 *1 275.54,24.48
X$4775 407 574 375 407 832 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4777 r0 *1 280.14,24.48
X$4777 407 575 375 407 770 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4778 r0 *1 283.82,24.48
X$4778 407 576 375 407 772 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4783 r0 *1 294.4,24.48
X$4783 375 509 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $4785 r0 *1 300.38,24.48
X$4785 375 380 737 509 736 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4786 r0 *1 309.58,24.48
X$4786 375 380 867 509 903 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $4789 r0 *1 322.92,24.48
X$4789 407 516 375 407 783 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4794 r0 *1 338.1,24.48
X$4794 375 787 738 739 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4796 r0 *1 342.24,24.48
X$4796 375 844 738 718 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4799 r0 *1 348.68,24.48
X$4799 375 909 911 789 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4801 r0 *1 353.28,24.48
X$4801 407 593 375 407 789 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4805 r0 *1 363.4,24.48
X$4805 375 850 791 792 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4808 r0 *1 368,24.48
X$4808 375 852 791 794 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4812 r0 *1 385.48,24.48
X$4812 407 726 375 407 857 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4826 r0 *1 427.8,24.48
X$4826 407 399 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $4830 r0 *1 437.46,24.48
X$4830 407 784 375 407 842 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4834 r0 *1 452.64,24.48
X$4834 407 834 744 840 743 714 407 779 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $4837 r0 *1 457.24,24.48
X$4837 375 626 513 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $4839 r0 *1 470.12,24.48
X$4839 407 775 744 900 746 745 407 833 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $4844 r0 *1 479.32,24.48
X$4844 375 774 746 769 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4849 r0 *1 487.6,24.48
X$4849 375 768 742 699 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4851 r0 *1 495.42,24.48
X$4851 375 764 690 642 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $4853 r0 *1 500.48,24.48
X$4853 407 493 375 407 825 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $4855 r0 *1 504.16,24.48
X$4855 407 747 612 823 690 693 407 694 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $4858 r0 *1 509.68,24.48
X$4858 407 692 427 621 761 375 407 748 375 sky130_fd_sc_hd__a31oi_1
* cell instance $4860 r0 *1 521.64,24.48
X$4860 407 749 407 375 621 375 sky130_fd_sc_hd__inv_1
* cell instance $4861 r0 *1 523.02,24.48
X$4861 407 809 750 758 814 375 812 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $4862 r0 *1 525.78,24.48
X$4862 407 622 427 756 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4863 r0 *1 527.16,24.48
X$4863 407 754 427 758 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $4866 r0 *1 530.38,24.48
X$4866 375 751 750 686 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5009 m0 *1 195.04,29.92
X$5009 375 464 797 467 888 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5020 m0 *1 229.08,29.92
X$5020 375 818 798 820 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5029 m0 *1 253,29.92
X$5029 407 567 375 407 827 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5031 m0 *1 257.14,29.92
X$5031 375 380 763 826 801 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5040 m0 *1 285.2,29.92
X$5040 375 380 773 509 802 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5044 m0 *1 295.32,29.92
X$5044 375 380 836 509 902 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5052 m0 *1 313.26,29.92
X$5052 375 380 780 803 839 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5058 m0 *1 333.04,29.92
X$5058 375 380 738 601 844 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5062 m0 *1 342.7,29.92
X$5062 375 675 601 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $5071 m0 *1 383.64,29.92
X$5071 375 853 854 857 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5073 m0 *1 391.92,29.92
X$5073 407 730 375 407 859 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5080 m0 *1 411.24,29.92
X$5080 375 855 804 849 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5082 m0 *1 415.84,29.92
X$5082 375 741 804 851 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5089 m0 *1 430.56,29.92
X$5089 407 581 375 407 847 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5094 m0 *1 443.44,29.92
X$5094 375 930 805 843 845 742 617 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $5095 m0 *1 447.12,29.92
X$5095 407 842 427 905 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5099 m0 *1 461.84,29.92
X$5099 407 807 778 838 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5100 m0 *1 463.22,29.92
X$5100 407 835 746 610 775 407 777 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5101 m0 *1 465.52,29.92
X$5101 407 775 835 610 746 617 407 807 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $5114 m0 *1 498.64,29.92
X$5114 407 830 427 825 407 829 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $5119 m0 *1 504.16,29.92
X$5119 407 747 612 617 690 375 823 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5122 m0 *1 512.44,29.92
X$5122 407 691 375 407 819 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5124 m0 *1 516.58,29.92
X$5124 407 558 375 407 817 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5125 m0 *1 520.26,29.92
X$5125 407 816 375 407 813 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5126 m0 *1 523.94,29.92
X$5126 407 750 617 809 814 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $5270 r0 *1 191.82,29.92
X$5270 375 464 755 463 1065 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5276 r0 *1 212.06,29.92
X$5276 407 890 407 375 889 375 sky130_fd_sc_hd__inv_1
* cell instance $5281 r0 *1 226.32,29.92
X$5281 375 494 798 532 818 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5287 r0 *1 241.5,29.92
X$5287 375 380 799 532 824 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5291 r0 *1 253.92,29.92
X$5291 375 893 896 827 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5296 r0 *1 264.04,29.92
X$5296 407 644 375 407 1083 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5297 r0 *1 267.72,29.92
X$5297 375 380 800 826 866 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5298 r0 *1 276.92,29.92
X$5298 375 866 800 832 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5300 r0 *1 281.98,29.92
X$5300 375 380 901 509 899 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5305 r0 *1 294.4,29.92
X$5305 375 669 509 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $5310 r0 *1 314.64,29.92
X$5310 375 839 867 780 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5318 r0 *1 342.7,29.92
X$5318 407 601 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $5325 r0 *1 361.56,29.92
X$5325 407 733 407 375 913 375 sky130_fd_sc_hd__inv_1
* cell instance $5327 r0 *1 366.62,29.92
X$5327 407 793 375 407 914 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5335 r0 *1 393.76,29.92
X$5335 375 918 916 859 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5344 r0 *1 429.64,29.92
X$5344 407 720 375 407 908 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5346 r0 *1 434.24,29.92
X$5346 407 847 427 907 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5349 r0 *1 442.98,29.92
X$5349 407 742 879 845 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5351 r0 *1 453.56,29.92
X$5351 407 834 744 617 743 375 840 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5357 r0 *1 465.06,29.92
X$5357 407 610 746 837 682 375 407 969 375 sky130_fd_sc_hd__and4_1
* cell instance $5358 r0 *1 468.28,29.92
X$5358 375 873 775 743 834 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $5359 r0 *1 470.58,29.92
X$5359 407 504 427 808 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5361 r0 *1 475.64,29.92
X$5361 407 646 898 1018 876 808 407 897 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $5366 r0 *1 484.84,29.92
X$5366 407 379 427 894 407 895 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $5370 r0 *1 501.86,29.92
X$5370 407 879 957 747 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5373 r0 *1 505.08,29.92
X$5373 407 560 427 956 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5374 r0 *1 506.46,29.92
X$5374 407 621 879 880 882 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $5375 r0 *1 508.3,29.92
X$5375 407 612 882 809 407 375 375 sky130_fd_sc_hd__and2_0
* cell instance $5380 r0 *1 513.36,29.92
X$5380 407 618 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $5381 r0 *1 514.74,29.92
X$5381 375 626 618 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $5515 m0 *1 174.8,35.36
X$5515 375 464 861 463 884 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5520 m0 *1 185.38,35.36
X$5520 375 464 753 463 886 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5523 m0 *1 196.88,35.36
X$5523 407 951 796 797 1003 375 407 888 375 sky130_fd_sc_hd__a31oi_1
* cell instance $5525 m0 *1 199.64,35.36
X$5525 375 464 862 467 1132 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5531 m0 *1 213.9,35.36
X$5531 407 920 863 796 407 955 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $5532 m0 *1 215.74,35.36
X$5532 407 863 925 407 892 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $5534 m0 *1 219.42,35.36
X$5534 407 864 407 375 891 375 sky130_fd_sc_hd__inv_1
* cell instance $5543 m0 *1 230.92,35.36
X$5543 375 494 822 532 821 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5552 m0 *1 250.7,35.36
X$5552 375 380 896 826 893 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5564 m0 *1 282.44,35.36
X$5564 375 899 901 772 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5570 m0 *1 293.94,35.36
X$5570 375 963 965 964 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5571 m0 *1 298.08,35.36
X$5571 375 902 836 968 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5582 m0 *1 316.48,35.36
X$5582 375 903 867 783 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5584 m0 *1 321.54,35.36
X$5584 375 380 869 391 1025 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5586 m0 *1 331.2,35.36
X$5586 407 868 407 375 870 375 sky130_fd_sc_hd__inv_1
* cell instance $5593 m0 *1 342.7,35.36
X$5593 375 380 911 601 909 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5594 m0 *1 351.9,35.36
X$5594 375 910 911 790 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5614 m0 *1 400.66,35.36
X$5614 375 917 916 915 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5624 m0 *1 423.2,35.36
X$5624 375 912 872 871 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5631 m0 *1 446.2,35.36
X$5631 407 905 971 835 806 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $5639 m0 *1 468.28,35.36
X$5639 407 834 743 873 969 407 938 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5642 m0 *1 471.96,35.36
X$5642 407 746 940 966 375 407 900 375 sky130_fd_sc_hd__a21oi_1
* cell instance $5649 m0 *1 489.9,35.36
X$5649 407 898 876 942 612 407 894 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5652 m0 *1 493.58,35.36
X$5652 407 898 876 942 646 407 878 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5656 m0 *1 498.64,35.36
X$5656 375 830 877 958 878 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $5657 m0 *1 502.32,35.36
X$5657 407 877 876 942 690 407 880 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5660 m0 *1 504.62,35.36
X$5660 375 611 621 879 880 881 407 407 375 sky130_fd_sc_hd__nor4_2
* cell instance $5661 m0 *1 509.22,35.36
X$5661 407 646 882 943 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $5664 m0 *1 517.5,35.36
X$5664 407 819 427 995 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5666 m0 *1 519.8,35.36
X$5666 407 817 427 950 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5670 m0 *1 526.24,35.36
X$5670 407 943 750 883 617 375 948 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5676 m0 *1 534.06,35.36
X$5676 375 885 883 810 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5812 r0 *1 183.08,35.36
X$5812 407 920 921 796 407 999 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $5813 r0 *1 184.92,35.36
X$5813 407 921 949 861 920 375 407 1001 375 sky130_fd_sc_hd__a31oi_1
* cell instance $5814 r0 *1 187.22,35.36
X$5814 407 753 920 922 978 407 375 886 375 sky130_fd_sc_hd__o31ai_1
* cell instance $5818 r0 *1 196.88,35.36
X$5818 407 952 923 951 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $5820 r0 *1 199.18,35.36
X$5820 375 921 863 862 924 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $5821 r0 *1 201.48,35.36
X$5821 407 923 797 1010 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $5827 r0 *1 210.22,35.36
X$5827 375 1008 1007 891 1010 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $5829 r0 *1 215.28,35.36
X$5829 375 494 925 467 1011 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5841 r0 *1 243.34,35.36
X$5841 407 865 407 375 1015 375 sky130_fd_sc_hd__inv_1
* cell instance $5844 r0 *1 246.1,35.36
X$5844 407 959 375 407 1079 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5848 r0 *1 256.22,35.36
X$5848 407 698 375 407 1019 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5852 r0 *1 264.5,35.36
X$5852 375 380 961 826 1020 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5855 r0 *1 276,35.36
X$5855 407 702 375 407 1086 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5861 r0 *1 291.64,35.36
X$5861 375 380 965 509 963 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $5867 r0 *1 315.1,35.36
X$5867 407 781 375 407 1091 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5871 r0 *1 321.54,35.36
X$5871 375 1025 1026 869 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5875 r0 *1 330.74,35.36
X$5875 407 906 407 375 1028 375 sky130_fd_sc_hd__inv_1
* cell instance $5884 r0 *1 352.82,35.36
X$5884 375 1033 970 914 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5888 r0 *1 368.46,35.36
X$5888 407 972 375 407 1098 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5893 r0 *1 379.5,35.36
X$5893 407 725 375 407 1036 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $5894 r0 *1 383.18,35.36
X$5894 375 919 854 856 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5907 r0 *1 418.14,35.36
X$5907 375 1038 987 977 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $5915 r0 *1 431.02,35.36
X$5915 407 872 988 927 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $5917 r0 *1 432.86,35.36
X$5917 375 927 928 872 427 908 975 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $5918 r0 *1 437,35.36
X$5918 407 930 898 990 375 407 928 375 sky130_fd_sc_hd__a21oi_1
* cell instance $5919 r0 *1 448.04,35.36
X$5919 407 837 931 971 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5921 r0 *1 449.42,35.36
X$5921 407 930 898 932 375 407 931 375 sky130_fd_sc_hd__a21oi_1
* cell instance $5922 r0 *1 451.26,35.36
X$5922 407 682 1031 932 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $5923 r0 *1 452.64,35.36
X$5923 375 933 934 682 427 709 1024 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $5926 r0 *1 457.7,35.36
X$5926 407 930 898 935 375 407 934 375 sky130_fd_sc_hd__a21oi_1
* cell instance $5928 r0 *1 463.22,35.36
X$5928 407 682 837 936 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $5929 r0 *1 464.6,35.36
X$5929 407 879 939 936 835 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $5930 r0 *1 466.44,35.36
X$5930 407 743 834 937 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $5931 r0 *1 467.82,35.36
X$5931 407 939 936 937 1022 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $5932 r0 *1 469.66,35.36
X$5932 407 743 873 834 993 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $5933 r0 *1 471.5,35.36
X$5933 407 1021 993 898 407 966 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $5934 r0 *1 473.34,35.36
X$5934 407 939 938 612 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5935 r0 *1 474.72,35.36
X$5935 407 935 938 898 407 941 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $5937 r0 *1 476.56,35.36
X$5937 407 876 940 941 375 407 1018 375 sky130_fd_sc_hd__a21oi_1
* cell instance $5939 r0 *1 478.86,35.36
X$5939 407 935 938 646 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5944 r0 *1 485.76,35.36
X$5944 407 1013 895 1014 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5945 r0 *1 487.14,35.36
X$5945 407 612 898 942 876 617 407 1013 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $5950 r0 *1 499.1,35.36
X$5950 407 877 617 958 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5952 r0 *1 500.94,35.36
X$5952 407 876 942 877 957 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $5955 r0 *1 503.24,35.36
X$5955 407 611 646 956 1004 375 1006 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5959 r0 *1 516.12,35.36
X$5959 407 954 943 617 953 375 1004 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5960 r0 *1 518.88,35.36
X$5960 407 953 946 945 944 407 881 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $5961 r0 *1 521.18,35.36
X$5961 407 944 943 617 946 375 1002 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $5963 r0 *1 524.86,35.36
X$5963 407 813 427 998 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $5964 r0 *1 526.24,35.36
X$5964 407 943 883 948 750 756 407 947 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $6097 m0 *1 175.26,40.8
X$6097 375 464 949 463 997 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6102 m0 *1 185.84,40.8
X$6102 407 1000 1001 753 407 978 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6104 m0 *1 188.6,40.8
X$6104 407 861 949 921 922 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6106 m0 *1 190.9,40.8
X$6106 407 755 753 949 861 375 407 979 375 sky130_fd_sc_hd__and4_1
* cell instance $6109 m0 *1 195.04,40.8
X$6109 407 921 979 923 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6110 m0 *1 196.42,40.8
X$6110 407 979 921 952 797 375 407 1003 375 sky130_fd_sc_hd__a31oi_1
* cell instance $6111 m0 *1 198.72,40.8
X$6111 407 797 979 924 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $6113 m0 *1 201.94,40.8
X$6113 375 862 980 797 925 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $6118 m0 *1 209.76,40.8
X$6118 407 1007 1008 1069 375 407 1192 375 sky130_fd_sc_hd__a21oi_1
* cell instance $6121 m0 *1 214.36,40.8
X$6121 407 863 1072 925 955 375 1011 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $6122 m0 *1 217.58,40.8
X$6122 407 925 920 1072 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6127 m0 *1 226.32,40.8
X$6127 407 1012 407 375 1074 375 sky130_fd_sc_hd__inv_1
* cell instance $6133 m0 *1 232.76,40.8
X$6133 375 380 1078 532 1077 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6136 m0 *1 244.26,40.8
X$6136 375 1016 1017 1079 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6140 m0 *1 250.24,40.8
X$6140 375 380 960 826 1148 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6143 m0 *1 259.44,40.8
X$6143 375 1020 961 1083 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6144 m0 *1 267.72,40.8
X$6144 375 380 1084 826 982 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6148 m0 *1 278.3,40.8
X$6148 375 1043 983 1086 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6163 m0 *1 314.18,40.8
X$6163 375 380 1026 803 1090 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6175 m0 *1 345,40.8
X$6175 407 1032 407 375 1097 375 sky130_fd_sc_hd__inv_1
* cell instance $6179 m0 *1 360.64,40.8
X$6179 375 1034 970 973 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6187 m0 *1 383.18,40.8
X$6187 375 1035 985 1036 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6190 m0 *1 388.24,40.8
X$6190 375 1101 985 1046 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6207 m0 *1 433.32,40.8
X$6207 407 992 988 989 907 375 929 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $6208 m0 *1 436.08,40.8
X$6208 407 988 711 617 872 987 407 989 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $6213 m0 *1 446.66,40.8
X$6213 407 872 711 987 991 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6217 m0 *1 449.42,40.8
X$6217 407 990 991 1031 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6218 m0 *1 450.8,40.8
X$6218 407 682 837 1054 1021 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6220 m0 *1 453.1,40.8
X$6220 407 682 898 1054 933 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6222 m0 *1 464.6,40.8
X$6222 407 992 990 939 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $6224 m0 *1 474.72,40.8
X$6224 407 427 879 940 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6229 m0 *1 477.48,40.8
X$6229 407 872 711 1075 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6239 m0 *1 516.12,40.8
X$6239 407 994 407 375 954 375 sky130_fd_sc_hd__inv_1
* cell instance $6240 m0 *1 517.5,40.8
X$6240 407 946 945 944 994 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6243 m0 *1 520.72,40.8
X$6243 407 944 943 950 946 1002 407 1063 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $6247 m0 *1 526.7,40.8
X$6247 407 809 883 617 750 996 407 1060 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $6248 m0 *1 529.92,40.8
X$6248 375 883 944 750 996 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $6388 r0 *1 181.7,40.8
X$6388 407 861 1127 1062 407 884 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6389 r0 *1 183.54,40.8
X$6389 407 952 921 1127 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6390 r0 *1 184.92,40.8
X$6390 407 861 999 1062 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6392 r0 *1 186.76,40.8
X$6392 407 922 753 1040 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $6393 r0 *1 189.98,40.8
X$6393 407 861 949 753 1128 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6394 r0 *1 191.82,40.8
X$6394 407 755 1039 1064 407 1065 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6396 r0 *1 194.12,40.8
X$6396 407 755 1130 1064 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6398 r0 *1 195.96,40.8
X$6398 407 1066 755 407 1070 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $6400 r0 *1 199.64,40.8
X$6400 407 862 1134 1068 407 1132 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6401 r0 *1 201.48,40.8
X$6401 407 862 1041 1068 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6406 r0 *1 208.84,40.8
X$6406 375 1137 1069 1042 1070 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $6407 r0 *1 213.44,40.8
X$6407 375 1139 1142 1015 1040 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $6411 r0 *1 231.38,40.8
X$6411 407 984 407 375 1076 375 sky130_fd_sc_hd__inv_1
* cell instance $6414 r0 *1 234.6,40.8
X$6414 407 1023 407 375 1042 375 sky130_fd_sc_hd__inv_1
* cell instance $6416 r0 *1 240.58,40.8
X$6416 375 380 1017 532 1016 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6419 r0 *1 252.54,40.8
X$6419 375 380 1112 826 1080 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6425 r0 *1 265.42,40.8
X$6425 375 826 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $6428 r0 *1 272.78,40.8
X$6428 375 380 983 826 1043 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6429 r0 *1 281.98,40.8
X$6429 375 380 962 826 1087 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6433 r0 *1 293.48,40.8
X$6433 375 380 967 509 1088 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6436 r0 *1 314.64,40.8
X$6436 375 1090 1026 1091 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6444 r0 *1 335.8,40.8
X$6444 407 1094 407 375 1093 375 sky130_fd_sc_hd__inv_1
* cell instance $6447 r0 *1 338.56,40.8
X$6447 407 1030 407 375 1156 375 sky130_fd_sc_hd__inv_1
* cell instance $6451 r0 *1 341.32,40.8
X$6451 407 1096 407 375 1095 375 sky130_fd_sc_hd__inv_1
* cell instance $6461 r0 *1 369.38,40.8
X$6461 375 1160 1099 1098 472 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6464 r0 *1 374.44,40.8
X$6464 375 1045 1099 974 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6471 r0 *1 411.24,40.8
X$6471 407 1048 407 375 377 375 sky130_fd_sc_hd__buf_4
* cell instance $6473 r0 *1 418.6,40.8
X$6473 407 1048 407 375 1049 375 sky130_fd_sc_hd__buf_4
* cell instance $6474 r0 *1 421.36,40.8
X$6474 375 1037 1051 1050 377 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6481 r0 *1 436.08,40.8
X$6481 407 879 990 988 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6484 r0 *1 440.22,40.8
X$6484 375 711 992 872 987 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $6485 r0 *1 442.52,40.8
X$6485 407 617 898 930 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6487 r0 *1 444.82,40.8
X$6487 407 782 375 407 1052 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6488 r0 *1 448.5,40.8
X$6488 407 1052 427 1053 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6491 r0 *1 450.8,40.8
X$6491 407 1056 991 1054 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6493 r0 *1 452.64,40.8
X$6493 407 879 1021 744 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6494 r0 *1 454.02,40.8
X$6494 407 744 1051 708 1151 375 1357 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $6498 r0 *1 465.06,40.8
X$6498 407 1057 1081 992 935 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6501 r0 *1 469.2,40.8
X$6501 407 436 427 1055 407 1150 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6502 r0 *1 471.04,40.8
X$6502 407 873 898 1022 1055 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6503 r0 *1 472.88,40.8
X$6503 407 879 1022 940 407 1149 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6505 r0 *1 475.64,40.8
X$6505 407 1057 1081 872 1058 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6507 r0 *1 477.48,40.8
X$6507 407 898 1058 1140 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6508 r0 *1 478.86,40.8
X$6508 375 427 1145 1059 1075 1056 879 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $6517 r0 *1 502.78,40.8
X$6517 407 762 375 407 1059 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6525 r0 *1 515.2,40.8
X$6525 407 954 809 995 1067 375 1129 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $6526 r0 *1 517.96,40.8
X$6526 407 944 809 945 946 617 407 1067 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $6529 r0 *1 523.48,40.8
X$6529 407 944 809 998 1060 375 1061 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $6667 m0 *1 183.08,46.24
X$6667 407 1000 1187 949 407 1104 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6668 m0 *1 184.92,46.24
X$6668 407 949 920 1166 1104 407 375 997 375 sky130_fd_sc_hd__o31ai_1
* cell instance $6672 m0 *1 190.9,46.24
X$6672 407 1131 1167 1128 1066 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $6673 m0 *1 192.74,46.24
X$6673 407 920 1066 796 407 1130 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6676 m0 *1 195.5,46.24
X$6676 407 952 1066 1039 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6679 m0 *1 199.64,46.24
X$6679 407 952 1105 1134 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6680 m0 *1 201.02,46.24
X$6680 407 920 1105 796 407 1041 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $6681 m0 *1 202.86,46.24
X$6681 407 1105 862 407 1135 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $6684 m0 *1 206.08,46.24
X$6684 375 1136 1107 1076 1135 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $6686 m0 *1 211.14,46.24
X$6686 407 1108 1107 1138 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6688 m0 *1 214.36,46.24
X$6688 375 1141 1108 1143 892 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $6694 m0 *1 223.56,46.24
X$6694 407 981 407 375 1143 375 sky130_fd_sc_hd__inv_1
* cell instance $6708 m0 *1 257.6,46.24
X$6708 375 1080 1112 1019 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6711 m0 *1 261.74,46.24
X$6711 407 831 375 407 1203 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6712 m0 *1 265.42,46.24
X$6712 375 669 826 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $6718 m0 *1 280.14,46.24
X$6718 407 771 375 407 1111 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6725 m0 *1 292.56,46.24
X$6725 375 380 1114 509 1208 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6735 m0 *1 314.64,46.24
X$6735 375 380 1092 803 1152 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6744 m0 *1 340.86,46.24
X$6744 375 380 1044 601 1157 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $6763 m0 *1 405.26,46.24
X$6763 375 1047 986 1117 1119 1116 407 407 375 sky130_fd_sc_hd__nand4bb_4
* cell instance $6765 m0 *1 419.52,46.24
X$6765 407 1047 1117 986 1048 375 407 375 sky130_fd_sc_hd__nand3b_1
* cell instance $6771 m0 *1 430.56,46.24
X$6771 407 1120 1119 898 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6781 m0 *1 456.32,46.24
X$6781 407 1051 1121 1151 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6782 m0 *1 457.7,46.24
X$6782 407 930 898 1021 375 407 1121 375 sky130_fd_sc_hd__a21oi_1
* cell instance $6785 m0 *1 465.06,46.24
X$6785 407 742 1122 1057 990 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6788 m0 *1 471.96,46.24
X$6788 407 1150 1194 1149 375 407 1146 375 sky130_fd_sc_hd__a21oi_1
* cell instance $6790 m0 *1 474.26,46.24
X$6790 407 1057 1081 1056 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $6791 m0 *1 475.64,46.24
X$6791 407 1124 1145 1123 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $6794 m0 *1 477.02,46.24
X$6794 407 711 940 1140 375 407 1124 375 sky130_fd_sc_hd__a21oi_1
* cell instance $6795 m0 *1 478.86,46.24
X$6795 407 879 1056 427 1125 1144 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $6799 m0 *1 488.98,46.24
X$6799 375 1190 942 496 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6805 m0 *1 499.56,46.24
X$6805 375 1189 837 1133 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6956 r0 *1 182.62,46.24
X$6956 407 1164 861 1165 920 375 407 1187 375 sky130_fd_sc_hd__a31oi_1
* cell instance $6958 r0 *1 185.38,46.24
X$6958 407 1165 861 1164 1166 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6960 r0 *1 188.14,46.24
X$6960 407 1166 949 1170 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $6964 r0 *1 197.34,46.24
X$6964 407 1167 1131 924 1105 375 407 375 sky130_fd_sc_hd__nor3b_1
* cell instance $6968 r0 *1 206.54,46.24
X$6968 407 1136 1008 1137 1191 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6970 r0 *1 208.84,46.24
X$6970 407 1192 1136 1356 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $6972 r0 *1 212.06,46.24
X$6972 407 1141 1109 1139 1193 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $6974 r0 *1 214.36,46.24
X$6974 407 1142 1139 1172 375 407 1254 375 sky130_fd_sc_hd__a21oi_1
* cell instance $6975 r0 *1 216.2,46.24
X$6975 375 1109 1172 1110 1170 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $6978 r0 *1 223.1,46.24
X$6978 407 1173 407 375 1195 375 sky130_fd_sc_hd__inv_1
* cell instance $6981 r0 *1 225.86,46.24
X$6981 407 1196 407 375 1197 375 sky130_fd_sc_hd__inv_1
* cell instance $6987 r0 *1 241.04,46.24
X$6987 407 1113 407 375 1110 375 sky130_fd_sc_hd__inv_1
* cell instance $6989 r0 *1 246.1,46.24
X$6989 375 1200 1174 1111 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $6995 r0 *1 259.9,46.24
X$6995 407 828 375 407 1264 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6998 r0 *1 267.72,46.24
X$6998 375 1205 1204 1203 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7007 r0 *1 295.78,46.24
X$7007 375 1208 1114 1210 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7008 r0 *1 299.92,46.24
X$7008 375 380 1089 803 1211 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7019 r0 *1 326.14,46.24
X$7019 407 1214 407 375 1219 375 sky130_fd_sc_hd__inv_1
* cell instance $7022 r0 *1 333.04,46.24
X$7022 375 380 1218 1286 1217 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7030 r0 *1 350.06,46.24
X$7030 407 1221 407 375 1220 375 sky130_fd_sc_hd__inv_1
* cell instance $7032 r0 *1 352.36,46.24
X$7032 407 1158 407 375 1222 375 sky130_fd_sc_hd__inv_1
* cell instance $7038 r0 *1 364.32,46.24
X$7038 407 1224 407 375 1225 375 sky130_fd_sc_hd__inv_1
* cell instance $7049 r0 *1 402.04,46.24
X$7049 407 1115 1314 986 407 1227 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $7051 r0 *1 405.26,46.24
X$7051 407 1117 1116 1366 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7053 r0 *1 407.56,46.24
X$7053 407 1179 407 375 472 375 sky130_fd_sc_hd__buf_4
* cell instance $7056 r0 *1 411.7,46.24
X$7056 375 1118 1116 1047 1117 986 407 407 375 sky130_fd_sc_hd__nor4bb_4
* cell instance $7059 r0 *1 422.74,46.24
X$7059 407 1118 407 375 1236 375 sky130_fd_sc_hd__buf_4
* cell instance $7061 r0 *1 429.64,46.24
X$7061 407 1215 375 407 1309 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7063 r0 *1 433.78,46.24
X$7063 407 1118 1120 879 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $7067 r0 *1 451.26,46.24
X$7067 407 879 1021 1207 1181 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $7068 r0 *1 453.1,46.24
X$7068 407 841 375 407 1183 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7072 r0 *1 461.38,46.24
X$7072 407 1183 617 1201 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7073 r0 *1 462.76,46.24
X$7073 407 1122 427 1202 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7074 r0 *1 464.14,46.24
X$7074 407 930 1184 1185 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7075 r0 *1 465.52,46.24
X$7075 407 1081 879 1184 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7077 r0 *1 467.36,46.24
X$7077 375 1248 1081 742 1122 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7079 r0 *1 472.42,46.24
X$7079 407 873 407 375 1194 375 sky130_fd_sc_hd__inv_1
* cell instance $7087 r0 *1 507.84,46.24
X$7087 375 1188 953 1126 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7224 m0 *1 171.12,51.68
X$7224 375 464 1165 1228 1162 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7227 m0 *1 180.32,51.68
X$7227 407 1165 1163 1246 407 1162 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7228 m0 *1 182.16,51.68
X$7228 407 952 1164 1163 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7229 m0 *1 183.54,51.68
X$7229 407 1165 1229 1246 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7231 m0 *1 185.38,51.68
X$7231 407 920 1164 796 407 1229 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7234 m0 *1 189.52,51.68
X$7234 407 921 861 407 1353 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $7238 m0 *1 195.5,51.68
X$7238 407 980 979 1168 920 375 407 1169 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7239 m0 *1 197.8,51.68
X$7239 407 1000 1169 1171 407 1249 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7240 m0 *1 199.64,51.68
X$7240 375 494 1171 1228 1303 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7243 m0 *1 208.84,51.68
X$7243 407 1191 1193 1252 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7244 m0 *1 210.22,51.68
X$7244 407 1191 1254 1138 407 1253 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7254 m0 *1 229.54,51.68
X$7254 407 1073 407 375 1258 375 sky130_fd_sc_hd__inv_1
* cell instance $7256 m0 *1 231.38,51.68
X$7256 375 380 1147 1232 1199 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7259 m0 *1 240.58,51.68
X$7259 375 380 1174 1232 1200 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7263 m0 *1 257.6,51.68
X$7263 375 1259 1233 1264 385 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7266 m0 *1 265.42,51.68
X$7266 375 380 1204 826 1205 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7278 m0 *1 297.16,51.68
X$7278 407 776 375 407 1210 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7285 m0 *1 313.26,51.68
X$7285 375 380 1153 803 1271 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7287 m0 *1 323.38,51.68
X$7287 407 1092 1234 1175 407 1152 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7288 m0 *1 325.22,51.68
X$7288 407 1281 1176 1092 407 1175 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7289 m0 *1 327.06,51.68
X$7289 407 1119 1235 1176 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7290 m0 *1 328.44,51.68
X$7290 407 1236 1235 1234 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7297 m0 *1 336.26,51.68
X$7297 407 1218 1177 1315 407 1217 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7299 m0 *1 338.56,51.68
X$7299 407 1236 1237 1177 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7300 m0 *1 339.94,51.68
X$7300 407 1218 1029 1237 1178 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $7303 m0 *1 341.78,51.68
X$7303 407 1044 1119 1178 1317 407 375 1157 375 sky130_fd_sc_hd__o31ai_1
* cell instance $7306 m0 *1 346.84,51.68
X$7306 407 1178 1044 1320 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $7309 m0 *1 355.58,51.68
X$7309 407 1270 407 375 1269 375 sky130_fd_sc_hd__inv_1
* cell instance $7323 m0 *1 381.34,51.68
X$7323 407 1226 407 375 1266 375 sky130_fd_sc_hd__inv_1
* cell instance $7331 m0 *1 394.22,51.68
X$7331 407 788 375 407 1338 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7334 m0 *1 397.9,51.68
X$7334 375 675 860 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $7335 m0 *1 407.1,51.68
X$7335 375 1102 1179 1117 1239 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $7341 m0 *1 417.68,51.68
X$7341 407 848 375 407 1265 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7348 m0 *1 438.84,51.68
X$7348 375 1260 1209 1154 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7351 m0 *1 443.9,51.68
X$7351 375 1213 1209 617 1181 1240 407 407 375 sky130_fd_sc_hd__o31a_1
* cell instance $7352 m0 *1 447.12,51.68
X$7352 375 1212 1256 1051 1209 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $7355 m0 *1 449.42,51.68
X$7355 407 1053 1209 1181 375 407 1240 375 sky130_fd_sc_hd__a21oi_1
* cell instance $7356 m0 *1 451.26,51.68
X$7356 407 1051 1212 1207 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7358 m0 *1 453.1,51.68
X$7358 407 835 1051 1212 617 375 1255 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $7361 m0 *1 464.14,51.68
X$7361 407 1202 1201 879 1242 375 407 1250 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7362 m0 *1 466.44,51.68
X$7362 407 1248 879 1242 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7366 m0 *1 471.04,51.68
X$7366 407 1057 1185 1243 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7369 m0 *1 475.18,51.68
X$7369 407 1243 1144 1247 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7373 m0 *1 486.68,51.68
X$7373 375 626 874 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $7383 m0 *1 515.2,51.68
X$7383 375 1245 945 1186 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7523 r0 *1 172.96,51.68
X$7523 407 952 1296 1000 375 407 1272 375 sky130_fd_sc_hd__a21o_1
* cell instance $7526 r0 *1 177.1,51.68
X$7526 407 1230 1272 1298 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7533 r0 *1 183.54,51.68
X$7533 407 1164 1165 407 1350 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $7534 r0 *1 186.76,51.68
X$7534 407 1131 1273 1164 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7536 r0 *1 189.06,51.68
X$7536 407 1274 1230 1273 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7537 r0 *1 190.44,51.68
X$7537 407 1274 1230 1165 1167 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $7538 r0 *1 192.28,51.68
X$7538 375 1230 1300 1274 1165 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $7541 r0 *1 196.88,51.68
X$7541 407 1168 979 980 1302 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $7543 r0 *1 199.18,51.68
X$7543 407 1171 920 1302 1249 407 375 1303 375 sky130_fd_sc_hd__o31ai_1
* cell instance $7553 r0 *1 219.42,51.68
X$7553 407 920 1275 796 407 1231 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7554 r0 *1 221.26,51.68
X$7554 407 1329 920 1305 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7555 r0 *1 222.64,51.68
X$7555 407 1275 1305 1329 1231 375 1307 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $7557 r0 *1 227.7,51.68
X$7557 407 1198 407 375 1257 375 sky130_fd_sc_hd__inv_1
* cell instance $7568 r0 *1 252.08,51.68
X$7568 375 380 1233 1232 1259 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7579 r0 *1 282.44,51.68
X$7579 407 1278 407 375 1276 375 sky130_fd_sc_hd__inv_1
* cell instance $7595 r0 *1 319.7,51.68
X$7595 407 1153 407 375 1313 375 sky130_fd_sc_hd__inv_1
* cell instance $7596 r0 *1 321.08,51.68
X$7596 407 1313 1312 1279 407 1271 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7597 r0 *1 322.92,51.68
X$7597 407 1153 1119 1280 1279 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $7598 r0 *1 325.22,51.68
X$7598 407 1281 1236 1280 375 407 1312 375 sky130_fd_sc_hd__a21oi_1
* cell instance $7600 r0 *1 328.9,51.68
X$7600 407 1235 1092 407 1319 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $7604 r0 *1 337.18,51.68
X$7604 407 1281 1283 1218 407 1315 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7605 r0 *1 339.02,51.68
X$7605 407 1119 1237 1283 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7608 r0 *1 340.86,51.68
X$7608 407 1237 1029 1218 1119 375 407 1284 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7609 r0 *1 343.16,51.68
X$7609 407 1281 1284 1044 407 1317 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $7613 r0 *1 346.84,51.68
X$7613 375 1318 1285 1220 1319 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7615 r0 *1 353.28,51.68
X$7615 375 1322 1323 1269 1320 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7618 r0 *1 362.02,51.68
X$7618 407 1325 407 375 1326 375 sky130_fd_sc_hd__inv_1
* cell instance $7626 r0 *1 380.88,51.68
X$7626 407 1161 407 375 1321 375 sky130_fd_sc_hd__inv_1
* cell instance $7628 r0 *1 387.78,51.68
X$7628 407 1281 1288 1316 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7630 r0 *1 398.36,51.68
X$7630 407 860 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $7634 r0 *1 402.5,51.68
X$7634 407 1371 1117 1047 1238 375 407 1314 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7635 r0 *1 404.8,51.68
X$7635 407 1289 986 1047 1179 375 407 1288 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7636 r0 *1 407.1,51.68
X$7636 407 1047 1290 1238 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7637 r0 *1 408.48,51.68
X$7637 407 1216 1289 1290 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $7640 r0 *1 411.24,51.68
X$7640 407 1047 986 1239 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7641 r0 *1 412.62,51.68
X$7641 375 1239 1289 1216 407 427 407 375 sky130_fd_sc_hd__nand3_4
* cell instance $7643 r0 *1 419.52,51.68
X$7643 407 1265 427 1310 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7651 r0 *1 431.94,51.68
X$7651 407 1309 427 1304 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7652 r0 *1 433.32,51.68
X$7652 407 846 375 407 1308 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $7654 r0 *1 449.88,51.68
X$7654 407 1291 1209 1212 1051 375 407 834 375 sky130_fd_sc_hd__and4_1
* cell instance $7656 r0 *1 453.56,51.68
X$7656 407 835 1212 1304 1051 1255 407 1241 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $7668 r0 *1 485.3,51.68
X$7668 375 1301 873 1293 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7672 r0 *1 500.48,51.68
X$7672 375 1297 1122 1295 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7811 m0 *1 167.44,57.12
X$7811 375 464 1230 1228 1346 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7812 m0 *1 176.64,57.12
X$7812 407 1230 920 1296 1298 407 375 1346 375 sky130_fd_sc_hd__o31ai_1
* cell instance $7815 m0 *1 179.4,57.12
X$7815 375 1349 1376 684 1347 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7817 m0 *1 184.92,57.12
X$7817 375 1348 1400 1276 1350 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7818 m0 *1 189.52,57.12
X$7818 375 1352 1483 627 1353 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7821 m0 *1 195.04,57.12
X$7821 407 979 1171 1300 980 407 1354 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $7822 m0 *1 197.34,57.12
X$7822 407 1131 1167 1168 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $7826 m0 *1 201.94,57.12
X$7826 407 1302 1171 1355 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $7831 m0 *1 209.76,57.12
X$7831 407 1377 1356 1108 1141 1253 1522 407 375 375 sky130_fd_sc_hd__o221ai_1
* cell instance $7834 m0 *1 217.58,57.12
X$7834 407 1275 1329 407 1277 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $7840 m0 *1 224.02,57.12
X$7840 375 1471 1414 1258 1277 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7843 m0 *1 230.92,57.12
X$7843 375 380 1329 1232 1307 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7857 m0 *1 268.18,57.12
X$7857 375 380 1206 826 1311 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $7877 m0 *1 314.18,57.12
X$7877 375 675 803 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $7879 m0 *1 325.22,57.12
X$7879 407 1280 1153 1282 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $7880 m0 *1 328.44,57.12
X$7880 375 1092 1361 1027 1153 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $7889 m0 *1 343.16,57.12
X$7889 375 1331 1434 1097 1282 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7892 m0 *1 349.14,57.12
X$7892 375 1363 1333 1219 1365 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $7894 m0 *1 355.58,57.12
X$7894 407 1333 1363 1323 375 407 1438 375 sky130_fd_sc_hd__a21oi_1
* cell instance $7899 m0 *1 362.48,57.12
X$7899 407 1335 1324 1441 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $7900 m0 *1 365.7,57.12
X$7900 407 1324 1119 1335 1368 407 375 1327 375 sky130_fd_sc_hd__o31ai_1
* cell instance $7906 m0 *1 377.2,57.12
X$7906 407 1287 407 375 1372 375 sky130_fd_sc_hd__inv_1
* cell instance $7916 m0 *1 401.58,57.12
X$7916 407 1338 407 375 1371 375 sky130_fd_sc_hd__inv_1
* cell instance $7917 m0 *1 402.96,57.12
X$7917 407 1371 986 1047 1339 375 407 1369 375 sky130_fd_sc_hd__a31oi_1
* cell instance $7919 m0 *1 405.72,57.12
X$7919 407 1366 1117 1338 375 407 1367 375 sky130_fd_sc_hd__a21oi_1
* cell instance $7920 m0 *1 407.56,57.12
X$7920 375 1216 1339 1338 1239 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $7921 m0 *1 409.86,57.12
X$7921 407 1216 1289 1239 375 407 617 375 sky130_fd_sc_hd__and3_2
* cell instance $7930 m0 *1 424.12,57.12
X$7930 407 427 407 375 1340 375 sky130_fd_sc_hd__buf_4
* cell instance $7932 m0 *1 437,57.12
X$7932 375 1341 1291 1261 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7937 m0 *1 444.82,57.12
X$7937 407 1256 835 617 1291 375 1360 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $7938 m0 *1 447.58,57.12
X$7938 407 1256 835 1360 1291 1342 407 1359 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $7950 m0 *1 493.12,57.12
X$7950 375 1299 876 1294 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $7962 m0 *1 529.46,57.12
X$7962 375 1344 946 1345 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $8097 r0 *1 173.42,57.12
X$8097 407 1131 1274 1347 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8098 r0 *1 176.64,57.12
X$8098 407 1296 1230 1396 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8103 r0 *1 182.16,57.12
X$8103 407 1349 1376 1375 407 1403 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8106 r0 *1 185.38,57.12
X$8106 407 1348 1400 1352 407 1399 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8112 r0 *1 202.4,57.12
X$8112 407 1328 407 375 1405 375 sky130_fd_sc_hd__inv_1
* cell instance $8113 r0 *1 203.78,57.12
X$8113 375 1447 1406 1195 1355 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8118 r0 *1 211.6,57.12
X$8118 407 1378 1381 1524 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8120 r0 *1 215.28,57.12
X$8120 407 1330 1409 1408 1410 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $8122 r0 *1 218.04,57.12
X$8122 375 375 1275 407 1378 1411 407 sky130_fd_sc_hd__nor2_2
* cell instance $8123 r0 *1 220.34,57.12
X$8123 407 1381 1488 1411 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8125 r0 *1 222.18,57.12
X$8125 407 1382 1413 1383 407 1379 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8128 r0 *1 225.4,57.12
X$8128 375 1383 1330 1074 1416 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8135 r0 *1 240.12,57.12
X$8135 407 1232 407 375 375 sky130_fd_sc_hd__clkinvlp_4
* cell instance $8136 r0 *1 242.88,57.12
X$8136 407 1384 407 375 1417 375 sky130_fd_sc_hd__inv_1
* cell instance $8141 r0 *1 254.38,57.12
X$8141 375 380 1262 1232 1358 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $8163 r0 *1 313.72,57.12
X$8163 375 803 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $8168 r0 *1 322.46,57.12
X$8168 407 1027 1119 1421 1423 407 375 1422 375 sky130_fd_sc_hd__o31ai_1
* cell instance $8169 r0 *1 325.22,57.12
X$8169 407 1424 1027 1092 1475 407 1280 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8173 r0 *1 333.5,57.12
X$8173 375 1428 1430 1095 1427 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8177 r0 *1 340.86,57.12
X$8177 407 1218 407 375 1432 375 sky130_fd_sc_hd__inv_1
* cell instance $8179 r0 *1 342.7,57.12
X$8179 375 1029 1385 1218 1044 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $8180 r0 *1 345,57.12
X$8180 407 1318 1331 1387 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8183 r0 *1 347.3,57.12
X$8183 407 1434 1331 1285 375 407 1386 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8184 r0 *1 349.14,57.12
X$8184 407 1332 1386 1435 407 1364 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8186 r0 *1 351.9,57.12
X$8186 407 1332 1387 1436 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8189 r0 *1 354.66,57.12
X$8189 407 1388 1438 1437 407 1544 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8190 r0 *1 356.5,57.12
X$8190 407 1363 1389 1322 1334 407 1546 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8191 r0 *1 358.8,57.12
X$8191 407 1389 1334 1388 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8192 r0 *1 360.18,57.12
X$8192 375 1334 1439 1326 1440 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8194 r0 *1 365.24,57.12
X$8194 407 1370 1390 1335 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8200 r0 *1 375.36,57.12
X$8200 407 1281 1236 1336 375 407 1431 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8201 r0 *1 377.2,57.12
X$8201 407 1372 1431 1392 407 1374 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8203 r0 *1 379.5,57.12
X$8203 407 1287 1119 1336 1392 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $8206 r0 *1 384.1,57.12
X$8206 407 1425 407 375 1426 375 sky130_fd_sc_hd__inv_1
* cell instance $8209 r0 *1 391,57.12
X$8209 375 375 1281 407 617 1236 407 sky130_fd_sc_hd__nor2_2
* cell instance $8216 r0 *1 402.96,57.12
X$8216 407 1117 1338 1289 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $8217 r0 *1 405.26,57.12
X$8217 375 1420 1117 1289 1047 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $8219 r0 *1 412.62,57.12
X$8219 407 1102 407 375 1415 375 sky130_fd_sc_hd__inv_1
* cell instance $8220 r0 *1 414,57.12
X$8220 407 1117 1394 1049 407 1412 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8225 r0 *1 429.64,57.12
X$8225 375 1180 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $8245 r0 *1 496.8,57.12
X$8245 407 405 1340 1342 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8253 r0 *1 512.44,57.12
X$8253 407 1244 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $8254 r0 *1 514.28,57.12
X$8254 375 626 1244 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $8265 r0 *1 546.94,57.12
X$8265 407 1345 375 407 2804 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8394 m0 *1 177.56,62.56
X$8394 375 1375 1442 811 1396 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8395 m0 *1 182.16,62.56
X$8395 407 1442 1375 1376 375 407 1397 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8396 m0 *1 184,62.56
X$8396 407 1400 1442 1443 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8397 m0 *1 185.38,62.56
X$8397 407 1352 1348 1465 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8398 m0 *1 186.76,62.56
X$8398 407 1399 1403 1443 375 407 1401 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8405 m0 *1 199.18,62.56
X$8405 375 1446 1445 1405 1619 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8407 m0 *1 204.24,62.56
X$8407 407 1445 1446 1406 375 407 1449 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8411 m0 *1 206.54,62.56
X$8411 407 1446 1447 1448 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8413 m0 *1 208.38,62.56
X$8413 407 1468 1407 1448 1377 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $8414 m0 *1 210.22,62.56
X$8414 407 1468 1407 1449 1408 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $8418 m0 *1 218.5,62.56
X$8418 407 1380 1379 1409 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8423 m0 *1 223.1,62.56
X$8423 375 1382 1413 1197 1582 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8424 m0 *1 227.7,62.56
X$8424 407 1526 1471 1413 1414 375 1380 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $8426 m0 *1 230.92,62.56
X$8426 375 380 1450 1232 1472 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $8429 m0 *1 240.12,62.56
X$8429 375 669 1232 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $8457 m0 *1 312.8,62.56
X$8457 375 380 1027 803 1422 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $8462 m0 *1 324.3,62.56
X$8462 407 1281 1532 1027 407 1423 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8463 m0 *1 326.14,62.56
X$8463 407 1424 1475 1421 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8465 m0 *1 327.98,62.56
X$8465 407 1421 1027 1427 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8470 m0 *1 333.5,62.56
X$8470 375 1451 1452 1093 1477 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8471 m0 *1 338.1,62.56
X$8471 407 1430 1428 1452 375 407 1539 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8475 m0 *1 340.4,62.56
X$8475 407 1237 1432 1433 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8476 m0 *1 343.62,62.56
X$8476 375 1479 1453 870 1433 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8477 m0 *1 348.22,62.56
X$8477 407 1480 1479 1332 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8479 m0 *1 350.52,62.56
X$8479 407 1481 1480 1453 375 407 1435 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8483 m0 *1 358.34,62.56
X$8483 407 1455 1389 1439 375 407 1437 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8486 m0 *1 361.56,62.56
X$8486 375 1389 1455 1225 1441 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8487 m0 *1 366.16,62.56
X$8487 407 1119 1370 1390 375 407 1391 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8490 m0 *1 368,62.56
X$8490 407 1281 1391 1324 407 1368 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8493 m0 *1 372.6,62.56
X$8493 407 1268 1370 1324 1390 407 1336 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8496 m0 *1 377.2,62.56
X$8496 407 1336 1287 1429 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8497 m0 *1 380.42,62.56
X$8497 375 1456 1478 1426 1429 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8503 m0 *1 391,62.56
X$8503 407 1236 1457 1476 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8510 m0 *1 401.12,62.56
X$8510 407 1503 1369 1117 407 1457 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $8513 m0 *1 405.26,62.56
X$8513 407 1420 1458 1367 1394 1393 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $8514 m0 *1 407.56,62.56
X$8514 407 1458 1117 1338 1459 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $8515 m0 *1 409.4,62.56
X$8515 407 1474 1459 1528 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8516 m0 *1 410.78,62.56
X$8516 407 986 407 375 1458 375 sky130_fd_sc_hd__inv_1
* cell instance $8517 m0 *1 412.16,62.56
X$8517 407 1047 1458 1394 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8518 m0 *1 413.54,62.56
X$8518 407 1458 1117 1415 1460 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $8521 m0 *1 416.3,62.56
X$8521 407 1047 1473 1460 375 407 1461 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8527 m0 *1 430.56,62.56
X$8527 375 675 1180 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $8530 m0 *1 441.14,62.56
X$8530 407 1308 617 1395 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8551 m0 *1 476.1,62.56
X$8551 375 1404 1057 570 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $8557 m0 *1 491.28,62.56
X$8557 407 1395 1402 1513 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8560 m0 *1 494.04,62.56
X$8560 407 1466 1340 1402 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8570 m0 *1 512.44,62.56
X$8570 375 1351 1212 1343 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $8577 m0 *1 528.54,62.56
X$8577 375 1463 996 1464 1049 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $8712 r0 *1 174.8,62.56
X$8712 375 1482 1594 1257 1507 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8714 r0 *1 179.4,62.56
X$8714 407 926 407 375 1508 375 sky130_fd_sc_hd__inv_1
* cell instance $8717 r0 *1 181.7,62.56
X$8717 407 1511 1510 1570 375 407 1509 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8719 r0 *1 184.46,62.56
X$8719 407 1397 1465 1512 407 1511 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8720 r0 *1 186.3,62.56
X$8720 407 1400 1352 1483 1574 375 1512 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $8722 r0 *1 189.98,62.56
X$8722 407 1483 1401 1518 407 375 375 sky130_fd_sc_hd__or2_2
* cell instance $8724 r0 *1 195.96,62.56
X$8724 375 1647 1517 1518 1444 1252 1377 407 407 375 sky130_fd_sc_hd__a41oi_1
* cell instance $8731 r0 *1 209.3,62.56
X$8731 407 1468 1578 1410 1522 1444 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $8732 r0 *1 212.06,62.56
X$8732 375 1551 1579 1486 1524 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8735 r0 *1 221.26,62.56
X$8735 407 1471 1383 1485 1382 407 1468 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8736 r0 *1 223.56,62.56
X$8736 375 1485 1526 1417 1623 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8737 r0 *1 228.16,62.56
X$8737 407 1487 1450 1416 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8738 r0 *1 231.38,62.56
X$8738 407 1450 920 1487 1584 407 375 1472 375 sky130_fd_sc_hd__o31ai_1
* cell instance $8757 r0 *1 274.16,62.56
X$8757 407 1418 407 375 1484 375 sky130_fd_sc_hd__inv_1
* cell instance $8761 r0 *1 280.6,62.56
X$8761 407 1419 407 375 1486 375 sky130_fd_sc_hd__inv_1
* cell instance $8781 r0 *1 324.3,62.56
X$8781 407 1119 1424 1475 375 407 1532 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8783 r0 *1 327.06,62.56
X$8783 407 1027 1475 1489 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8784 r0 *1 328.44,62.56
X$8784 407 1491 1489 1235 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8788 r0 *1 333.04,62.56
X$8788 407 1428 1451 1490 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8789 r0 *1 334.42,62.56
X$8789 407 1535 1428 1537 1451 407 1543 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8790 r0 *1 336.72,62.56
X$8790 407 1490 1492 1539 407 1541 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $8795 r0 *1 341.78,62.56
X$8795 407 1491 1493 1237 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8797 r0 *1 344.08,62.56
X$8797 407 1331 1480 1318 1479 407 1542 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $8799 r0 *1 346.84,62.56
X$8799 375 1480 1481 1222 1589 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8801 r0 *1 352.36,62.56
X$8801 407 1541 1436 1544 1364 375 1494 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $8802 r0 *1 355.12,62.56
X$8802 407 1454 1543 1546 1542 375 1545 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $8803 r0 *1 357.42,62.56
X$8803 407 1544 1546 1495 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $8804 r0 *1 359.72,62.56
X$8804 407 1454 1494 1495 1496 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $8805 r0 *1 361.56,62.56
X$8805 407 1555 1370 407 1440 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $8810 r0 *1 368,62.56
X$8810 407 1268 1119 1497 1645 407 375 1588 375 sky130_fd_sc_hd__o31ai_1
* cell instance $8811 r0 *1 370.76,62.56
X$8811 407 1370 1324 1555 1497 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $8815 r0 *1 374.44,62.56
X$8815 407 1497 1268 1538 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $8817 r0 *1 378.58,62.56
X$8817 375 1585 1500 1321 1538 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $8818 r0 *1 383.18,62.56
X$8818 407 1499 1498 1536 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $8819 r0 *1 385.48,62.56
X$8819 407 1478 1456 1500 375 407 1499 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8821 r0 *1 389.16,62.56
X$8821 407 1533 407 375 1534 375 sky130_fd_sc_hd__inv_1
* cell instance $8822 r0 *1 390.54,62.56
X$8822 407 1476 1531 1636 375 407 1501 375 sky130_fd_sc_hd__a21oi_1
* cell instance $8823 r0 *1 392.38,62.56
X$8823 375 1504 1503 860 1501 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $8827 r0 *1 402.96,62.56
X$8827 407 1117 1394 1530 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $8830 r0 *1 405.72,62.56
X$8830 407 1117 986 407 1529 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $8831 r0 *1 408.94,62.56
X$8831 375 1504 1117 860 1528 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $8832 r0 *1 418.14,62.56
X$8832 407 986 1117 1473 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $8844 r0 *1 447.58,62.56
X$8844 407 904 375 407 1525 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8847 r0 *1 453.1,62.56
X$8847 407 1182 375 407 1523 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8851 r0 *1 460,62.56
X$8851 375 626 1292 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $8855 r0 *1 475.18,62.56
X$8855 407 875 375 407 1520 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8859 r0 *1 484.84,62.56
X$8859 375 1519 1467 1516 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $8867 r0 *1 513.82,62.56
X$8867 407 887 375 407 1506 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8868 r0 *1 517.5,62.56
X$8868 407 1506 617 1612 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $8878 r0 *1 543.72,62.56
X$8878 407 1464 375 407 2770 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $9006 m0 *1 175.26,68
X$9006 375 1567 1593 1508 1568 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9010 m0 *1 180.78,68
X$9010 407 1569 1547 1571 375 407 1570 375 sky130_fd_sc_hd__a21o_1
* cell instance $9011 m0 *1 183.54,68
X$9011 375 1510 1574 1484 1573 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9012 m0 *1 188.14,68
X$9012 407 1228 375 407 375 sky130_fd_sc_hd__clkinv_4
* cell instance $9017 m0 *1 195.04,68
X$9017 407 952 1378 1548 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9018 m0 *1 196.42,68
X$9018 407 1548 796 1381 1549 375 407 1575 375 sky130_fd_sc_hd__a31oi_1
* cell instance $9019 m0 *1 198.72,68
X$9019 407 1381 1550 1549 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9020 m0 *1 200.1,68
X$9020 407 920 1378 1550 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9027 m0 *1 213.44,68
X$9027 407 1622 1551 1579 1668 375 1578 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $9033 m0 *1 224.48,68
X$9033 407 1580 1583 1582 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9036 m0 *1 230,68
X$9036 407 920 1487 1450 1552 1584 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $9040 m0 *1 233.68,68
X$9040 375 380 1488 1232 1628 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9080 m0 *1 333.04,68
X$9080 375 1537 1553 1028 1591 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9081 m0 *1 337.64,68
X$9081 407 1592 1535 1553 375 407 1492 375 sky130_fd_sc_hd__a21oi_1
* cell instance $9086 m0 *1 340.86,68
X$9086 407 1475 1361 1493 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9089 m0 *1 344.54,68
X$9089 407 1590 1029 407 1589 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $9097 m0 *1 361.1,68
X$9097 407 1491 1554 1555 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9099 m0 *1 362.94,68
X$9099 407 1236 1555 1640 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9104 m0 *1 374.9,68
X$9104 407 1287 1268 1324 1370 375 407 1586 375 sky130_fd_sc_hd__and4_1
* cell instance $9106 m0 *1 379.04,68
X$9106 407 1456 1556 1585 1498 407 1454 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $9107 m0 *1 381.34,68
X$9107 407 1642 1536 1556 407 1558 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9108 m0 *1 383.18,68
X$9108 375 1556 1557 1534 1644 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9111 m0 *1 388.7,68
X$9111 407 1558 1557 1604 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $9112 m0 *1 391,68
X$9112 375 1502 1531 1393 1530 1559 407 407 375 sky130_fd_sc_hd__a2bb2oi_1
* cell instance $9113 m0 *1 394.22,68
X$9113 375 1504 1047 1337 1502 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9116 m0 *1 403.42,68
X$9116 407 1047 1576 1529 407 1577 375 375 sky130_fd_sc_hd__a21oi_2
* cell instance $9117 m0 *1 406.64,68
X$9117 407 1216 1560 1576 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9119 m0 *1 408.48,68
X$9119 407 1529 1047 1474 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $9123 m0 *1 415.84,68
X$9123 375 1473 1630 1047 407 407 375 sky130_fd_sc_hd__nor2_4
* cell instance $9128 m0 *1 425.96,68
X$9128 375 1606 1527 1714 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9134 m0 *1 443.44,68
X$9134 375 1504 1505 1292 1627 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9138 m0 *1 453.56,68
X$9138 375 1561 1470 1697 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9139 m0 *1 457.7,68
X$9139 375 1504 1470 1292 1561 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9147 m0 *1 483.46,68
X$9147 375 1504 1467 1514 1519 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9151 m0 *1 498.64,68
X$9151 375 1566 1565 1466 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9156 m0 *1 508.3,68
X$9156 375 1564 1398 1563 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9299 r0 *1 175.26,68
X$9299 407 1567 1594 1593 375 407 1547 375 sky130_fd_sc_hd__a21o_1
* cell instance $9302 r0 *1 178.48,68
X$9302 407 1567 1510 1482 1569 407 1595 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $9304 r0 *1 181.24,68
X$9304 407 1595 2146 1509 407 1517 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9308 r0 *1 188.6,68
X$9308 375 494 1381 1228 1575 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9310 r0 *1 198.26,68
X$9310 407 1596 1648 1619 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9318 r0 *1 209.76,68
X$9318 375 1620 1622 889 1621 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9321 r0 *1 217.12,68
X$9321 407 1597 1329 1488 1381 375 407 1581 375 sky130_fd_sc_hd__and4_1
* cell instance $9324 r0 *1 221.72,68
X$9324 407 1598 1581 1580 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9325 r0 *1 223.1,68
X$9325 407 1381 1598 1597 1599 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $9326 r0 *1 224.94,68
X$9326 407 1599 1488 1623 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9327 r0 *1 228.16,68
X$9327 407 920 1599 1488 1552 1600 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $9328 r0 *1 230.92,68
X$9328 407 1488 920 1599 1600 407 375 1628 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9372 r0 *1 333.96,68
X$9372 375 1535 1592 1156 1706 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9376 r0 *1 340.86,68
X$9376 407 1361 1540 1475 1385 407 1554 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $9377 r0 *1 343.16,68
X$9377 407 1493 1634 1432 1633 375 1590 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $9382 r0 *1 348.22,68
X$9382 407 1540 1119 1601 1635 407 375 1637 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9383 r0 *1 350.98,68
X$9383 407 1601 1540 1365 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9385 r0 *1 355.12,68
X$9385 375 1634 1390 1633 1554 407 407 375 sky130_fd_sc_hd__nor3_4
* cell instance $9387 r0 *1 361.56,68
X$9387 407 1119 1555 1638 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9389 r0 *1 363.4,68
X$9389 407 1370 1640 1641 407 1639 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9390 r0 *1 365.24,68
X$9390 407 1555 1324 1370 1119 375 407 1602 375 sky130_fd_sc_hd__a31oi_1
* cell instance $9394 r0 *1 368.92,68
X$9394 407 1281 1602 1268 407 1645 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9399 r0 *1 374.44,68
X$9399 407 1555 1586 1603 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9400 r0 *1 375.82,68
X$9400 407 1603 1267 1646 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9401 r0 *1 379.04,68
X$9401 375 1498 1642 1266 1646 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9402 r0 *1 383.64,68
X$9402 407 1643 1373 1644 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9405 r0 *1 391,68
X$9405 407 1496 1604 1393 1559 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $9406 r0 *1 392.84,68
X$9406 407 1457 1496 1604 1636 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $9408 r0 *1 394.68,68
X$9408 407 1496 1604 1605 1631 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $9410 r0 *1 396.98,68
X$9410 407 1531 1631 1236 1605 407 1632 375 375 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $9415 r0 *1 402.5,68
X$9415 407 1560 617 1605 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9421 r0 *1 417.22,68
X$9421 407 1630 407 375 1515 375 sky130_fd_sc_hd__buf_4
* cell instance $9422 r0 *1 419.98,68
X$9422 375 1504 1527 1180 1606 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9427 r0 *1 431.94,68
X$9427 375 1504 1607 1180 1608 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9428 r0 *1 441.14,68
X$9428 375 1608 1607 1700 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9430 r0 *1 446.2,68
X$9430 375 1627 1505 1625 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9432 r0 *1 450.34,68
X$9432 407 1525 1340 1626 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9437 r0 *1 457.24,68
X$9437 407 1523 1340 1624 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9442 r0 *1 465.52,68
X$9442 375 1504 1469 1292 1609 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9446 r0 *1 476.1,68
X$9446 375 1562 1521 1615 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9447 r0 *1 480.24,68
X$9447 407 1520 1340 1618 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9453 r0 *1 488.98,68
X$9453 375 1615 1614 1616 1617 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $9458 r0 *1 506.46,68
X$9458 407 1005 375 407 1659 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $9463 r0 *1 514.74,68
X$9463 407 1563 1340 1610 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9464 r0 *1 516.12,68
X$9464 407 1612 1610 1611 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9600 m0 *1 174.8,73.44
X$9600 407 1661 1613 1573 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9604 m0 *1 178.94,73.44
X$9604 375 1569 1571 1663 1662 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9606 m0 *1 184,73.44
X$9606 407 1106 407 375 1663 375 sky130_fd_sc_hd__inv_1
* cell instance $9607 m0 *1 185.38,73.44
X$9607 375 669 1228 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $9609 m0 *1 195.04,73.44
X$9609 407 1666 1665 1354 1596 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $9610 m0 *1 196.88,73.44
X$9610 375 1648 1598 1131 1354 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $9611 m0 *1 200.56,73.44
X$9611 407 1587 407 375 1648 375 sky130_fd_sc_hd__inv_1
* cell instance $9618 m0 *1 208.84,73.44
X$9618 407 1693 1551 1692 1620 407 1407 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $9621 m0 *1 212.52,73.44
X$9621 407 1551 1620 1649 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9623 m0 *1 214.82,73.44
X$9623 407 1695 1649 1668 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9624 m0 *1 216.2,73.44
X$9624 407 1650 1652 1621 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9626 m0 *1 220.34,73.44
X$9626 407 1000 1696 1583 407 1651 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9628 m0 *1 222.64,73.44
X$9628 407 1583 920 1580 1651 407 375 1671 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9630 m0 *1 226.32,73.44
X$9630 407 1596 1587 1583 1581 407 1487 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $9637 m0 *1 235.52,73.44
X$9637 375 380 1583 1232 1671 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9672 m0 *1 316.02,73.44
X$9672 375 380 1629 803 1672 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9673 m0 *1 325.22,73.44
X$9673 407 1654 1629 1653 1673 375 407 1475 375 sky130_fd_sc_hd__and4_1
* cell instance $9682 m0 *1 345,73.44
X$9682 375 1601 1385 1493 1633 1634 407 407 375 sky130_fd_sc_hd__or4b_4
* cell instance $9684 m0 *1 350.98,73.44
X$9684 375 1504 1540 1286 1637 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9686 m0 *1 360.64,73.44
X$9686 375 675 1286 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $9690 m0 *1 371.68,73.44
X$9690 407 1119 1555 1586 375 407 1655 375 sky130_fd_sc_hd__a21oi_1
* cell instance $9691 m0 *1 373.52,73.44
X$9691 407 1281 1655 1267 407 1707 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9693 m0 *1 376.28,73.44
X$9693 407 1267 1390 1586 1643 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $9695 m0 *1 378.58,73.44
X$9695 407 1586 1390 1267 1119 375 407 1705 375 sky130_fd_sc_hd__a31oi_1
* cell instance $9706 m0 *1 396.06,73.44
X$9706 375 1504 1560 1337 1632 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9714 m0 *1 418.14,73.44
X$9714 375 1504 1572 1180 1669 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9718 m0 *1 427.8,73.44
X$9718 407 976 375 407 1702 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $9722 m0 *1 439.3,73.44
X$9722 407 1100 375 407 1730 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $9727 m0 *1 446.66,73.44
X$9727 375 1504 1625 1292 1667 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9730 m0 *1 455.86,73.44
X$9730 375 1504 1697 1292 1699 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9734 m0 *1 471.04,73.44
X$9734 375 1609 1469 1616 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $9739 m0 *1 476.56,73.44
X$9739 407 1656 1686 1618 1657 375 1664 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $9740 m0 *1 479.32,73.44
X$9740 375 1504 1516 1514 1664 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9742 m0 *1 488.98,73.44
X$9742 375 1504 1615 1514 1658 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9745 m0 *1 500.48,73.44
X$9745 407 1659 1340 1689 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9891 r0 *1 166.98,73.44
X$9891 375 464 1613 1688 1674 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9896 r0 *1 181.24,73.44
X$9896 407 1274 920 1131 1675 407 375 1722 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9897 r0 *1 184,73.44
X$9897 407 1000 1690 1274 407 1675 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9899 r0 *1 189.52,73.44
X$9899 375 1666 921 1665 1167 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $9902 r0 *1 195.96,73.44
X$9902 375 1691 1378 1354 1665 1666 407 407 375 sky130_fd_sc_hd__or4_4
* cell instance $9903 r0 *1 203.78,73.44
X$9903 407 1598 1676 407 1727 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $9905 r0 *1 207,73.44
X$9905 407 1587 1597 1691 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9907 r0 *1 208.84,73.44
X$9907 375 1692 1677 815 1727 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $9909 r0 *1 215.28,73.44
X$9909 407 1694 1693 1677 375 407 1695 375 sky130_fd_sc_hd__a21oi_1
* cell instance $9912 r0 *1 218.5,73.44
X$9912 375 1678 1597 1676 1652 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $9913 r0 *1 220.8,73.44
X$9913 407 1676 1678 1598 1650 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $9915 r0 *1 223.56,73.44
X$9915 407 920 1598 1581 375 407 1696 375 sky130_fd_sc_hd__a21oi_1
* cell instance $9958 r0 *1 327.06,73.44
X$9958 407 1673 1653 1424 1679 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $9959 r0 *1 328.9,73.44
X$9959 407 1679 1629 1706 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $9960 r0 *1 332.12,73.44
X$9960 407 1740 1654 407 1477 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $9963 r0 *1 339.48,73.44
X$9963 407 1029 1680 1681 407 1736 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9965 r0 *1 341.32,73.44
X$9965 407 1281 1682 1029 407 1681 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9966 r0 *1 343.16,73.44
X$9966 407 1236 1590 1680 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9967 r0 *1 344.54,73.44
X$9967 407 1119 1590 1682 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $9971 r0 *1 347.76,73.44
X$9971 407 1540 1683 1635 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $9972 r0 *1 349.14,73.44
X$9972 407 1236 1601 1281 375 407 1683 375 sky130_fd_sc_hd__a21o_1
* cell instance $9977 r0 *1 361.56,73.44
X$9977 407 1281 1638 1370 407 1641 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9978 r0 *1 363.4,73.44
X$9978 375 1504 1370 1286 1639 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9983 r0 *1 374.44,73.44
X$9983 407 1267 1119 1603 1707 407 375 1737 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9987 r0 *1 380.42,73.44
X$9987 407 1281 1705 1373 407 1684 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $9988 r0 *1 382.26,73.44
X$9988 407 1373 1119 1643 1684 407 375 1704 375 sky130_fd_sc_hd__o31ai_1
* cell instance $9996 r0 *1 409.4,73.44
X$9996 375 1504 1670 860 1735 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $9997 r0 *1 418.6,73.44
X$9997 375 1669 1572 1703 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $10006 r0 *1 438.84,73.44
X$10006 375 1504 1700 1701 1731 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10013 r0 *1 457.24,73.44
X$10013 407 1624 1698 1617 1699 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $10016 r0 *1 466.44,73.44
X$10016 407 1085 375 407 1726 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10018 r0 *1 470.58,73.44
X$10018 407 1082 375 407 1725 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10020 r0 *1 477.94,73.44
X$10020 407 1686 1615 1687 1616 1516 407 1657 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $10022 r0 *1 482.08,73.44
X$10022 375 1615 1656 1616 1516 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $10024 r0 *1 484.84,73.44
X$10024 375 626 1514 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $10027 r0 *1 495.42,73.44
X$10027 375 1504 1660 1514 1719 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10029 r0 *1 504.62,73.44
X$10029 407 1009 375 407 1718 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10172 m0 *1 170.66,78.88
X$10172 407 1613 920 1661 1720 407 375 1674 375 sky130_fd_sc_hd__o31ai_1
* cell instance $10173 m0 *1 173.42,78.88
X$10173 407 1709 1708 1661 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10174 m0 *1 174.8,78.88
X$10174 407 1709 1613 1274 1708 407 1296 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $10179 m0 *1 181.24,78.88
X$10179 407 1613 1708 1665 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10181 m0 *1 183.08,78.88
X$10181 407 952 1131 1690 407 375 375 sky130_fd_sc_hd__and2_0
* cell instance $10188 m0 *1 197.34,78.88
X$10188 407 920 1598 796 407 1755 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10189 m0 *1 199.18,78.88
X$10189 407 952 1598 1756 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10195 m0 *1 211.6,78.88
X$10195 375 1693 1694 1739 1757 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $10197 m0 *1 219.88,78.88
X$10197 407 1598 1678 1676 920 375 407 1710 375 sky130_fd_sc_hd__a31oi_1
* cell instance $10199 m0 *1 222.64,78.88
X$10199 407 1000 1710 1652 407 1711 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10200 m0 *1 224.48,78.88
X$10200 407 1652 920 1650 1711 407 375 1728 375 sky130_fd_sc_hd__o31ai_1
* cell instance $10201 m0 *1 227.24,78.88
X$10201 375 380 1652 1832 1728 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10222 m0 *1 277.84,78.88
X$10222 407 1732 407 375 1739 375 sky130_fd_sc_hd__inv_1
* cell instance $10241 m0 *1 325.68,78.88
X$10241 407 1629 1119 1679 1712 407 375 1672 375 sky130_fd_sc_hd__o31ai_1
* cell instance $10242 m0 *1 328.44,78.88
X$10242 407 1713 1764 1629 407 1712 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10243 m0 *1 330.28,78.88
X$10243 407 1673 1653 1629 1766 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $10248 m0 *1 337.64,78.88
X$10248 375 380 1029 1286 1736 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10254 m0 *1 351.9,78.88
X$10254 407 1236 1634 1768 407 375 375 sky130_fd_sc_hd__and2_0
* cell instance $10263 m0 *1 368.92,78.88
X$10263 407 1281 407 375 1713 375 sky130_fd_sc_hd__buf_4
* cell instance $10265 m0 *1 373.52,78.88
X$10265 375 1504 1267 1286 1737 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10273 m0 *1 391.46,78.88
X$10273 375 1504 1743 1337 1772 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10281 m0 *1 411.24,78.88
X$10281 375 1735 1670 1769 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $10287 m0 *1 423.2,78.88
X$10287 407 1703 1782 1769 1734 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $10290 m0 *1 427.8,78.88
X$10290 375 1504 1714 1701 1767 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10291 m0 *1 437,78.88
X$10291 407 617 407 375 1687 375 sky130_fd_sc_hd__buf_4
* cell instance $10293 m0 *1 440.22,78.88
X$10293 407 1785 1340 1730 407 1731 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $10297 m0 *1 448.04,78.88
X$10297 375 1625 1763 1700 1697 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $10300 m0 *1 450.34,78.88
X$10300 407 1715 1729 1762 1625 1626 407 1667 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $10302 m0 *1 454.02,78.88
X$10302 407 1715 1716 1697 1625 375 407 1617 375 sky130_fd_sc_hd__and4_1
* cell instance $10303 m0 *1 457.24,78.88
X$10303 407 1715 1716 1697 1625 1687 407 1698 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $10306 m0 *1 464.6,78.88
X$10306 407 1717 1759 1716 1758 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $10308 m0 *1 467.36,78.88
X$10308 407 1726 1340 1717 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10316 m0 *1 479.32,78.88
X$10316 407 1616 1724 1752 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10317 m0 *1 480.7,78.88
X$10317 407 1686 1616 1753 1752 375 1723 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $10319 m0 *1 483.92,78.88
X$10319 375 1504 1616 1514 1723 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10320 m0 *1 493.12,78.88
X$10320 407 1617 1616 1615 1687 375 1721 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $10321 m0 *1 495.88,78.88
X$10321 407 1689 1721 1614 1658 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $10325 m0 *1 499.1,78.88
X$10325 375 1719 1660 1751 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $10328 m0 *1 503.24,78.88
X$10328 407 1718 1340 1753 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10470 r0 *1 163.3,78.88
X$10470 407 1274 375 407 1789 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10473 r0 *1 171.12,78.88
X$10473 407 1000 1773 1613 407 1720 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10474 r0 *1 172.96,78.88
X$10474 407 920 1709 1708 375 407 1773 375 sky130_fd_sc_hd__a21oi_1
* cell instance $10482 r0 *1 182.62,78.88
X$10482 375 464 1274 1228 1722 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10486 r0 *1 198.26,78.88
X$10486 407 1676 1755 1775 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10487 r0 *1 199.64,78.88
X$10487 407 1676 1756 1775 407 1796 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10497 r0 *1 213.9,78.88
X$10497 407 1797 1678 1757 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $10498 r0 *1 217.12,78.88
X$10498 407 1596 1676 1587 920 375 407 1777 375 sky130_fd_sc_hd__a31oi_1
* cell instance $10499 r0 *1 219.42,78.88
X$10499 407 1000 1777 1678 407 1760 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10541 r0 *1 324.76,78.88
X$10541 407 1424 1653 1673 1119 375 407 1764 375 sky130_fd_sc_hd__a31oi_1
* cell instance $10543 r0 *1 327.98,78.88
X$10543 407 1119 1740 1804 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10545 r0 *1 330.28,78.88
X$10545 407 1236 1740 1803 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10547 r0 *1 332.12,78.88
X$10547 407 1491 1766 1740 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10553 r0 *1 342.24,78.88
X$10553 375 1633 1424 1634 407 407 375 sky130_fd_sc_hd__nor2_4
* cell instance $10556 r0 *1 350.52,78.88
X$10556 407 1738 1119 1634 1741 407 375 1807 375 sky130_fd_sc_hd__o31ai_1
* cell instance $10557 r0 *1 353.28,78.88
X$10557 407 1713 1768 1738 407 1741 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10569 r0 *1 385.48,78.88
X$10569 407 1577 407 375 1809 375 sky130_fd_sc_hd__buf_4
* cell instance $10573 r0 *1 391.46,78.88
X$10573 407 617 1771 1808 407 1772 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10574 r0 *1 393.3,78.88
X$10574 407 1742 1236 1808 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10576 r0 *1 394.68,78.88
X$10576 407 1743 1119 1771 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10583 r0 *1 407.56,78.88
X$10583 375 1504 1781 1180 1770 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10584 r0 *1 416.76,78.88
X$10584 375 1504 1769 1701 1805 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10587 r0 *1 427.8,78.88
X$10587 407 1714 1744 1745 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10589 r0 *1 429.64,78.88
X$10589 375 1748 1702 1767 1745 1714 1687 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $10590 r0 *1 433.32,78.88
X$10590 407 1744 1746 1747 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10591 r0 *1 434.7,78.88
X$10591 407 1748 1747 1802 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10593 r0 *1 437,78.88
X$10593 375 1504 1750 1701 1801 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10596 r0 *1 447.58,78.88
X$10596 407 617 1765 1748 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10600 r0 *1 451.26,78.88
X$10600 407 1715 1729 1687 1625 375 1762 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $10601 r0 *1 454.02,78.88
X$10601 375 1751 1716 1750 1749 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $10604 r0 *1 457.24,78.88
X$10604 407 1761 375 407 1795 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10606 r0 *1 461.38,78.88
X$10606 407 1749 1750 1751 1687 375 1759 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $10607 r0 *1 464.14,78.88
X$10607 375 1504 1751 1292 1758 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10608 r0 *1 473.34,78.88
X$10608 407 1725 1340 1792 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10609 r0 *1 474.72,78.88
X$10609 375 1794 1754 1750 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $10613 r0 *1 481.62,78.88
X$10613 407 1656 1617 1687 1788 375 1790 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $10615 r0 *1 484.84,78.88
X$10615 407 1514 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $10765 m0 *1 171.12,84.32
X$10765 407 920 1822 1791 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10766 m0 *1 172.5,84.32
X$10766 407 1811 1613 1823 1708 407 1131 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $10769 m0 *1 177.1,84.32
X$10769 407 1793 1774 407 1662 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $10780 m0 *1 197.8,84.32
X$10780 407 952 1596 1812 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10781 m0 *1 199.18,84.32
X$10781 407 920 1596 796 407 1858 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10783 m0 *1 201.48,84.32
X$10783 407 1587 1812 1859 407 1776 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10785 m0 *1 203.78,84.32
X$10785 375 380 1587 1228 1776 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10790 m0 *1 215.28,84.32
X$10790 407 1587 1676 1596 1797 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $10791 m0 *1 217.12,84.32
X$10791 407 1678 920 1797 1760 407 375 1799 375 sky130_fd_sc_hd__o31ai_1
* cell instance $10837 m0 *1 318.32,84.32
X$10837 375 380 1654 803 1778 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10838 m0 *1 327.52,84.32
X$10838 407 1713 1804 1654 407 1779 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10839 m0 *1 329.36,84.32
X$10839 407 1654 1803 1779 407 1778 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10848 m0 *1 349.14,84.32
X$10848 407 1738 1780 1816 1633 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $10849 m0 *1 350.98,84.32
X$10849 375 1504 1738 1286 1807 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10860 m0 *1 382.26,84.32
X$10860 407 380 407 375 1504 375 sky130_fd_sc_hd__buf_4
* cell instance $10864 m0 *1 388.24,84.32
X$10864 407 1337 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $10865 m0 *1 389.62,84.32
X$10865 375 675 1337 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $10873 m0 *1 411.24,84.32
X$10873 375 1770 1781 1782 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $10875 m0 *1 415.84,84.32
X$10875 407 1103 375 407 1806 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $10876 m0 *1 419.52,84.32
X$10876 407 1703 1782 1820 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10877 m0 *1 420.9,84.32
X$10877 407 1783 1820 1765 407 1829 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $10880 m0 *1 422.74,84.32
X$10880 407 1749 1310 1827 1805 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $10882 m0 *1 425.5,84.32
X$10882 407 1236 1685 1744 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $10883 m0 *1 427.8,84.32
X$10883 407 1734 1119 1685 1783 375 1749 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $10884 m0 *1 430.1,84.32
X$10884 407 1685 1119 1765 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $10886 m0 *1 432.4,84.32
X$10886 407 1750 1765 1746 1784 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $10887 m0 *1 434.24,84.32
X$10887 375 1784 1802 1750 1340 1733 1801 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $10892 m0 *1 444.36,84.32
X$10892 407 1750 1751 1800 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $10895 m0 *1 448.5,84.32
X$10895 407 1748 1765 1798 375 407 1724 375 sky130_fd_sc_hd__a21oi_1
* cell instance $10898 m0 *1 450.34,84.32
X$10898 407 1786 1716 1700 1825 375 407 1785 375 sky130_fd_sc_hd__a31oi_1
* cell instance $10900 m0 *1 453.1,84.32
X$10900 375 1700 1715 1853 1824 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $10909 m0 *1 473.8,84.32
X$10909 375 1504 1754 1514 1794 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $10912 m0 *1 483,84.32
X$10912 407 1656 1617 1792 1788 1790 407 1787 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $10914 m0 *1 486.68,84.32
X$10914 375 1504 1788 1514 1787 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11062 r0 *1 161.92,84.32
X$11062 375 464 1810 1688 1850 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11063 r0 *1 171.12,84.32
X$11063 375 1823 1822 1873 1811 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $11065 r0 *1 173.88,84.32
X$11065 375 1854 1793 1810 1822 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $11066 r0 *1 176.18,84.32
X$11066 407 920 1793 796 407 1857 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11077 r0 *1 198.26,84.32
X$11077 375 494 1676 1228 1796 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11086 r0 *1 219.42,84.32
X$11086 375 380 1678 1832 1799 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11127 r0 *1 325.68,84.32
X$11127 407 1236 1813 1861 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11128 r0 *1 327.06,84.32
X$11128 407 1713 1833 1653 407 1903 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11129 r0 *1 328.9,84.32
X$11129 407 1119 1813 1833 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11131 r0 *1 330.74,84.32
X$11131 407 1813 1653 407 1591 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $11137 r0 *1 342.7,84.32
X$11137 375 1834 1813 1673 1816 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $11142 r0 *1 347.3,84.32
X$11142 407 1815 1119 1925 1865 407 375 1896 375 sky130_fd_sc_hd__o31ai_1
* cell instance $11143 r0 *1 350.06,84.32
X$11143 407 1119 1828 1834 375 407 1864 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11148 r0 *1 358.8,84.32
X$11148 375 1504 1780 1286 1868 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11152 r0 *1 370.76,84.32
X$11152 407 1817 407 375 1870 375 sky130_fd_sc_hd__inv_1
* cell instance $11153 r0 *1 372.14,84.32
X$11153 407 1870 1838 1872 407 1818 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11155 r0 *1 374.44,84.32
X$11155 375 1504 1817 1286 1818 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11157 r0 *1 384.56,84.32
X$11157 407 1713 1869 1819 407 1839 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11158 r0 *1 386.4,84.32
X$11158 375 1504 1819 1337 1867 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11167 r0 *1 412.62,84.32
X$11167 375 1504 1782 1701 1863 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11170 r0 *1 422.74,84.32
X$11170 375 1340 1862 1806 1820 1842 1744 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $11178 r0 *1 432.86,84.32
X$11178 407 1842 1734 1746 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11181 r0 *1 437,84.32
X$11181 407 1783 1734 1843 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11184 r0 *1 440.68,84.32
X$11184 407 1842 1734 1800 1821 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $11186 r0 *1 443.44,84.32
X$11186 407 1744 1821 1860 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11188 r0 *1 445.74,84.32
X$11188 407 1765 1750 1751 1843 407 1844 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $11192 r0 *1 449.42,84.32
X$11192 407 1821 1786 1763 1798 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11193 r0 *1 451.26,84.32
X$11193 407 1786 1716 1687 1700 375 1825 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $11194 r0 *1 454.02,84.32
X$11194 407 1786 1729 1855 1856 375 1893 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $11197 r0 *1 458.16,84.32
X$11197 407 1795 1340 1855 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11200 r0 *1 460.92,84.32
X$11200 375 1504 1845 1514 1852 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11201 r0 *1 470.12,84.32
X$11201 407 1851 375 407 1849 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $11354 m0 *1 164.22,89.76
X$11354 407 1810 920 1830 1889 407 375 1850 375 sky130_fd_sc_hd__o31ai_1
* cell instance $11356 m0 *1 167.44,89.76
X$11356 407 1873 1823 1811 1830 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11357 m0 *1 169.28,89.76
X$11357 407 1830 1810 1507 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $11358 m0 *1 172.5,89.76
X$11358 407 1774 1854 1810 1873 375 407 1708 375 sky130_fd_sc_hd__and4_1
* cell instance $11359 m0 *1 175.72,89.76
X$11359 407 1793 1892 1774 1857 375 1831 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $11362 m0 *1 178.94,89.76
X$11362 375 464 1774 1832 1831 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11369 m0 *1 199.18,89.76
X$11369 407 1587 1858 1859 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11370 m0 *1 200.56,89.76
X$11370 375 669 1832 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $11373 m0 *1 209.76,89.76
X$11373 407 1552 920 796 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11422 m0 *1 322.46,89.76
X$11422 375 380 1653 803 1894 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11430 m0 *1 340.86,89.76
X$11430 407 1814 1826 1815 1828 375 407 1816 375 sky130_fd_sc_hd__and4_1
* cell instance $11432 m0 *1 344.54,89.76
X$11432 375 380 1815 1874 1896 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11435 m0 *1 355.12,89.76
X$11435 407 1738 1780 1835 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11437 m0 *1 357.42,89.76
X$11437 407 1780 1119 1875 1898 407 375 1868 375 sky130_fd_sc_hd__o31ai_1
* cell instance $11439 m0 *1 360.64,89.76
X$11439 375 1816 1491 1835 1876 407 407 1836 375 sky130_fd_sc_hd__or4b_1
* cell instance $11440 m0 *1 364.32,89.76
X$11440 407 1738 1837 1875 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11441 m0 *1 365.7,89.76
X$11441 407 1876 1836 1837 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11442 m0 *1 367.08,89.76
X$11442 407 1817 1738 1780 1899 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11446 m0 *1 369.38,89.76
X$11446 407 1878 1817 1871 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $11447 m0 *1 372.6,89.76
X$11447 407 1817 1119 1878 1872 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $11448 m0 *1 374.9,89.76
X$11448 407 1713 1236 1878 375 407 1838 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11452 m0 *1 383.18,89.76
X$11452 407 1879 1819 1880 1817 407 1836 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $11454 m0 *1 385.94,89.76
X$11454 407 1819 1866 1839 407 1867 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11456 m0 *1 388.24,89.76
X$11456 407 1880 1236 1866 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11457 m0 *1 389.62,89.76
X$11457 407 1879 375 407 4152 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $11462 m0 *1 394.68,89.76
X$11462 375 1742 1880 1840 1743 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $11463 m0 *1 399.28,89.76
X$11463 375 1504 1840 1337 1897 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11471 m0 *1 415.84,89.76
X$11471 407 1159 375 407 1884 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $11473 m0 *1 419.98,89.76
X$11473 407 1841 1862 1863 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11474 m0 *1 421.36,89.76
X$11474 407 1769 1883 1829 375 407 1827 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11478 m0 *1 423.66,89.76
X$11478 407 1782 1883 1895 375 407 1841 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11479 m0 *1 425.5,89.76
X$11479 407 1340 1744 1883 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11485 m0 *1 440.68,89.76
X$11485 407 1744 1842 1340 1886 1943 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $11490 m0 *1 448.96,89.76
X$11490 407 1765 1821 1729 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $11491 m0 *1 451.26,89.76
X$11491 407 1786 1763 1887 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11492 m0 *1 452.64,89.76
X$11492 407 1853 1824 1786 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $11493 m0 *1 454.94,89.76
X$11493 375 1504 1853 1701 1893 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11494 m0 *1 464.14,89.76
X$11494 375 1852 1845 1853 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $11500 m0 *1 472.42,89.76
X$11500 375 1844 1891 1887 1846 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $11504 m0 *1 477.02,89.76
X$11504 407 1849 1340 1890 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11507 m0 *1 480.7,89.76
X$11507 407 1788 1888 1656 1846 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11510 m0 *1 484.84,89.76
X$11510 375 1848 1847 1888 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $11658 r0 *1 156.4,89.76
X$11658 407 1000 1901 1873 407 1930 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11659 r0 *1 158.24,89.76
X$11659 407 920 1709 1901 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11662 r0 *1 161,89.76
X$11662 407 1810 375 407 1921 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $11665 r0 *1 169.28,89.76
X$11665 407 1000 1791 1810 407 1889 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11666 r0 *1 171.12,89.76
X$11666 375 1810 1902 1873 1709 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $11669 r0 *1 174.8,89.76
X$11669 407 1902 1854 407 1568 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $11671 r0 *1 178.02,89.76
X$11671 407 1774 920 1892 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11680 r0 *1 200.56,89.76
X$11680 375 1832 407 407 375 sky130_fd_sc_hd__inv_8
* cell instance $11731 r0 *1 325.68,89.76
X$11731 407 1653 1861 1903 407 1894 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11733 r0 *1 327.98,89.76
X$11733 375 380 1673 1904 1954 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11740 r0 *1 347.3,89.76
X$11740 407 1828 1834 1925 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11742 r0 *1 349.14,89.76
X$11742 407 1713 1864 1815 407 1865 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11743 r0 *1 350.98,89.76
X$11743 407 1119 1906 1937 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11746 r0 *1 353.74,89.76
X$11746 407 1634 1835 1906 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11750 r0 *1 358.34,89.76
X$11750 407 1713 1907 1780 407 1898 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11751 r0 *1 360.18,89.76
X$11751 407 1875 1780 1987 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $11752 r0 *1 363.4,89.76
X$11752 407 1119 1738 1837 375 407 1907 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11753 r0 *1 365.24,89.76
X$11753 407 1634 1738 1927 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $11756 r0 *1 368.92,89.76
X$11756 407 1899 1877 1909 1876 375 1834 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $11757 r0 *1 371.22,89.76
X$11757 407 1909 1870 1908 1876 1634 407 375 375 sky130_fd_sc_hd__or4_1
* cell instance $11759 r0 *1 374.44,89.76
X$11759 407 1909 1877 1876 1878 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $11761 r0 *1 377.2,89.76
X$11761 407 1879 407 375 1909 375 sky130_fd_sc_hd__inv_1
* cell instance $11762 r0 *1 378.58,89.76
X$11762 407 1879 1962 1961 407 1900 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11766 r0 *1 383.64,89.76
X$11766 407 1819 1880 1877 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11767 r0 *1 385.02,89.76
X$11767 407 1880 1119 1869 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11770 r0 *1 388.7,89.76
X$11770 407 1713 1881 1910 407 1929 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11771 r0 *1 390.54,89.76
X$11771 407 1119 1911 1881 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11772 r0 *1 391.92,89.76
X$11772 407 1819 1880 1910 2025 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11773 r0 *1 393.76,89.76
X$11773 375 1743 1911 1840 1819 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $11775 r0 *1 396.06,89.76
X$11775 375 1908 1840 1743 1819 407 407 375 sky130_fd_sc_hd__nand3_2
* cell instance $11776 r0 *1 399.74,89.76
X$11776 407 1840 1119 1959 407 1897 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $11785 r0 *1 419.98,89.76
X$11785 407 1703 1883 1912 375 407 1928 375 sky130_fd_sc_hd__a21oi_1
* cell instance $11787 r0 *1 421.82,89.76
X$11787 407 1765 1783 1912 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11788 r0 *1 423.2,89.76
X$11788 407 1783 1913 1340 1884 1926 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $11789 r0 *1 425.5,89.76
X$11789 407 1703 1765 1913 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11791 r0 *1 427.34,89.76
X$11791 407 1765 1914 1895 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11794 r0 *1 429.64,89.76
X$11794 407 1915 1885 1703 1914 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $11796 r0 *1 432.4,89.76
X$11796 407 1915 1885 1842 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11797 r0 *1 433.78,89.76
X$11797 407 1885 1744 1916 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11798 r0 *1 435.16,89.76
X$11798 407 1748 1916 1924 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11799 r0 *1 436.54,89.76
X$11799 407 1923 375 407 1922 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $11800 r0 *1 440.22,89.76
X$11800 375 626 1701 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $11802 r0 *1 449.42,89.76
X$11802 407 1765 1821 1917 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11805 r0 *1 453.56,89.76
X$11805 407 1824 1729 1687 1853 375 1856 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $11813 r0 *1 472.42,89.76
X$11813 407 1917 1887 1686 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $11814 r0 *1 473.8,89.76
X$11814 375 1917 1918 1887 1846 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $11816 r0 *1 477.48,89.76
X$11816 407 1890 1920 1918 1949 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $11818 r0 *1 480.24,89.76
X$11818 407 1656 1686 1888 1788 1687 407 1920 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $11821 r0 *1 484.84,89.76
X$11821 375 1504 1847 1919 1848 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11963 m0 *1 155.02,95.2
X$11963 407 1873 920 1666 1930 407 375 1952 375 sky130_fd_sc_hd__o31ai_1
* cell instance $11964 m0 *1 157.78,95.2
X$11964 375 464 1931 1688 1952 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $11966 m0 *1 167.44,95.2
X$11966 407 1931 407 375 1873 375 sky130_fd_sc_hd__buf_4
* cell instance $11969 m0 *1 172.5,95.2
X$11969 407 952 1902 1972 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $11970 m0 *1 173.88,95.2
X$11970 407 920 1902 796 407 1974 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12036 m0 *1 325.68,95.2
X$12036 407 1236 1424 1933 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12037 m0 *1 327.06,95.2
X$12037 407 1673 1933 1934 407 1954 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12038 m0 *1 328.9,95.2
X$12038 407 1713 1935 1673 407 1934 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12039 m0 *1 330.74,95.2
X$12039 407 1119 1424 1935 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12048 m0 *1 342.7,95.2
X$12048 407 1424 1673 407 2054 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $12049 m0 *1 345.92,95.2
X$12049 407 1828 1980 1905 407 1936 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12050 m0 *1 347.76,95.2
X$12050 407 1713 1937 1828 407 1905 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12052 m0 *1 350.06,95.2
X$12052 407 1925 1815 1958 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $12055 m0 *1 355.58,95.2
X$12055 375 1960 1983 1984 1958 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12063 m0 *1 372.6,95.2
X$12063 407 1908 1876 1938 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12064 m0 *1 373.98,95.2
X$12064 407 1938 1909 1965 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $12066 m0 *1 377.66,95.2
X$12066 407 1236 1938 1962 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12068 m0 *1 379.96,95.2
X$12068 407 1119 1938 1939 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12069 m0 *1 381.34,95.2
X$12069 407 1713 1939 1879 407 1961 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12073 m0 *1 388.24,95.2
X$12073 375 380 1910 1337 1994 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12076 m0 *1 397.44,95.2
X$12076 407 1840 1713 1959 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12077 m0 *1 398.82,95.2
X$12077 407 1880 1819 407 1957 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $12080 m0 *1 403.42,95.2
X$12080 407 1956 1940 2047 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $12081 m0 *1 405.72,95.2
X$12081 375 1956 1940 1955 1840 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12090 m0 *1 417.22,95.2
X$12090 375 1504 1703 1904 1992 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12094 m0 *1 428.26,95.2
X$12094 407 1953 1765 1988 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12095 m0 *1 429.64,95.2
X$12095 375 1953 1885 1714 1941 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12096 m0 *1 434.24,95.2
X$12096 407 1714 1941 1915 1783 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $12097 m0 *1 436.08,95.2
X$12097 407 1915 1924 1942 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12098 m0 *1 437.46,95.2
X$12098 407 1943 1942 1981 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12101 m0 *1 440.22,95.2
X$12101 407 1922 1340 1945 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12102 m0 *1 441.6,95.2
X$12102 407 1945 1944 2012 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12104 m0 *1 443.44,95.2
X$12104 407 1947 1748 1860 1946 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $12105 m0 *1 445.28,95.2
X$12105 407 1946 1947 1917 375 407 1944 375 sky130_fd_sc_hd__a21oi_1
* cell instance $12107 m0 *1 447.58,95.2
X$12107 407 1155 375 407 1979 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12112 m0 *1 453.56,95.2
X$12112 375 1504 1951 1701 1978 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12114 m0 *1 463.22,95.2
X$12114 407 1716 1824 1950 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12124 m0 *1 476.1,95.2
X$12124 375 1504 1888 1919 1949 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12131 m0 *1 502.32,95.2
X$12131 375 1969 1948 1788 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $12240 r0 *1 75.9,95.2
X$12240 407 1647 407 375 2083 375 sky130_fd_sc_hd__buf_4
* cell instance $12263 r0 *1 135.24,95.2
X$12263 407 1873 375 407 1970 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12264 r0 *1 138.92,95.2
X$12264 407 1666 1873 1971 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $12273 r0 *1 161.46,95.2
X$12273 375 669 1688 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $12275 r0 *1 171.58,95.2
X$12275 407 1854 1972 1973 407 2006 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12276 r0 *1 173.42,95.2
X$12276 407 1854 1974 1973 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12291 r0 *1 204.7,95.2
X$12291 407 1975 407 375 1932 375 sky130_fd_sc_hd__inv_1
* cell instance $12346 r0 *1 337.18,95.2
X$12346 407 1713 1963 1814 407 2010 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12347 r0 *1 339.02,95.2
X$12347 407 1119 1964 1963 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12349 r0 *1 340.4,95.2
X$12349 407 1834 1826 1815 1828 375 407 1964 375 sky130_fd_sc_hd__and4_1
* cell instance $12353 r0 *1 346.84,95.2
X$12353 407 1236 1906 1980 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12354 r0 *1 348.22,95.2
X$12354 375 1815 2014 1828 1906 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $12355 r0 *1 350.52,95.2
X$12355 407 1906 1828 407 1982 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $12356 r0 *1 353.74,95.2
X$12356 375 1985 2018 1932 1982 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12357 r0 *1 358.34,95.2
X$12357 407 1223 407 375 1984 375 sky130_fd_sc_hd__inv_1
* cell instance $12359 r0 *1 360.64,95.2
X$12359 375 1986 1989 913 1987 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12360 r0 *1 365.24,95.2
X$12360 375 1998 2022 1991 1927 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12364 r0 *1 371.22,95.2
X$12364 407 1990 2024 2080 1545 407 375 1531 375 sky130_fd_sc_hd__o31ai_1
* cell instance $12367 r0 *1 378.12,95.2
X$12367 375 380 1879 1337 1900 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12368 r0 *1 387.32,95.2
X$12368 407 1910 1119 1908 1929 407 375 1994 375 sky130_fd_sc_hd__o31ai_1
* cell instance $12376 r0 *1 402.5,95.2
X$12376 407 1995 2046 2020 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12377 r0 *1 403.88,95.2
X$12377 375 1995 2017 1993 1742 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12386 r0 *1 419.52,95.2
X$12386 407 1926 1928 1992 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12389 r0 *1 422.74,95.2
X$12389 407 1263 375 407 1966 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12391 r0 *1 427.34,95.2
X$12391 407 1765 1967 1988 407 2013 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12393 r0 *1 429.64,95.2
X$12393 375 1967 1941 1966 1687 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $12396 r0 *1 436.08,95.2
X$12396 375 1504 1915 1701 1981 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12401 r0 *1 451.26,95.2
X$12401 407 1979 1340 2009 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12402 r0 *1 452.64,95.2
X$12402 407 1716 1951 2009 1947 1977 407 1978 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $12407 r0 *1 459.54,95.2
X$12407 407 1251 375 407 1976 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12408 r0 *1 463.22,95.2
X$12408 407 1976 1340 1950 407 2007 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12409 r0 *1 465.06,95.2
X$12409 375 1504 2002 1919 1968 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12413 r0 *1 481.62,95.2
X$12413 407 1918 407 375 2709 375 sky130_fd_sc_hd__buf_4
* cell instance $12420 r0 *1 500.02,95.2
X$12420 375 1504 1948 1919 1969 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12560 m0 *1 161.46,100.64
X$12560 375 1688 407 407 375 sky130_fd_sc_hd__inv_8
* cell instance $12564 m0 *1 167.44,100.64
X$12564 375 464 1854 1832 2006 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12637 m0 *1 337.64,100.64
X$12637 407 1814 2070 2010 407 2011 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12638 m0 *1 339.48,100.64
X$12638 375 380 1828 1874 1936 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12642 m0 *1 349.14,100.64
X$12642 407 2014 1826 407 2015 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $12646 m0 *1 354.66,100.64
X$12646 375 2016 2019 1996 2015 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12650 m0 *1 361.1,100.64
X$12650 407 2018 1997 2078 407 375 2076 375 sky130_fd_sc_hd__o21bai_1
* cell instance $12652 m0 *1 364.78,100.64
X$12652 407 2000 1998 1989 2022 375 1997 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $12656 m0 *1 369.38,100.64
X$12656 375 2023 2000 1999 1871 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12661 m0 *1 385.94,100.64
X$12661 407 1910 2001 1911 2100 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $12665 m0 *1 391,100.64
X$12665 407 2025 2001 2021 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $12669 m0 *1 396.06,100.64
X$12669 407 1908 1910 2050 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $12672 m0 *1 400.66,100.64
X$12672 375 675 1904 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $12674 m0 *1 411.7,100.64
X$12674 407 1882 375 407 1955 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12682 m0 *1 424.58,100.64
X$12682 375 1504 1941 1904 2013 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12687 m0 *1 443.44,100.64
X$12687 375 1504 1947 1701 2012 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12691 m0 *1 453.1,100.64
X$12691 407 1729 1951 1687 1947 2008 407 2043 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $12692 m0 *1 456.32,100.64
X$12692 407 1716 1947 1951 1687 375 1977 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $12696 m0 *1 462.3,100.64
X$12696 407 2002 2008 1951 1947 375 407 1824 375 sky130_fd_sc_hd__and4_1
* cell instance $12697 m0 *1 465.52,100.64
X$12697 375 2094 2005 1947 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $12700 m0 *1 471.04,100.64
X$12700 407 2007 2042 2003 375 407 1968 375 sky130_fd_sc_hd__a21oi_1
* cell instance $12703 m0 *1 474.26,100.64
X$12703 407 1891 407 375 2004 375 sky130_fd_sc_hd__buf_4
* cell instance $12707 m0 *1 477.94,100.64
X$12707 375 626 1919 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $12869 r0 *1 163.3,100.64
X$12869 407 1854 375 407 2041 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12948 r0 *1 333.96,100.64
X$12948 375 380 1814 1874 2011 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12952 r0 *1 343.16,100.64
X$12952 407 1964 1814 407 2048 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $12955 r0 *1 347.76,100.64
X$12955 407 1236 2015 1826 1713 375 2072 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $12960 r0 *1 355.12,100.64
X$12960 375 675 1874 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $12961 r0 *1 364.32,100.64
X$12961 407 1998 1985 2023 1986 407 2027 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $12962 r0 *1 366.62,100.64
X$12962 407 2058 2027 2028 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12966 r0 *1 368,100.64
X$12966 407 1960 2028 2029 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $12968 r0 *1 371.22,100.64
X$12968 407 2031 2030 2086 2029 375 2024 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $12971 r0 *1 374.9,100.64
X$12971 375 380 2052 1874 2051 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12972 r0 *1 384.1,100.64
X$12972 407 1877 2082 2053 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $12973 r0 *1 385.48,100.64
X$12973 375 380 2001 1337 2032 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $12977 r0 *1 394.68,100.64
X$12977 407 2063 2049 2033 2031 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $12978 r0 *1 396.52,100.64
X$12978 375 2049 2081 2034 2050 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $12981 r0 *1 402.04,100.64
X$12981 407 1904 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $12982 r0 *1 405.26,100.64
X$12982 407 2047 2020 2035 407 2033 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $12983 r0 *1 407.1,100.64
X$12983 407 2079 2046 2017 375 407 2035 375 sky130_fd_sc_hd__a21oi_1
* cell instance $13001 r0 *1 445.28,100.64
X$13001 407 1306 375 407 2045 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13006 r0 *1 450.8,100.64
X$13006 407 2036 1340 2045 407 2044 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $13007 r0 *1 453.56,100.64
X$13007 375 2036 2008 1951 2043 1729 1947 407 407 375 sky130_fd_sc_hd__a41oi_1
* cell instance $13010 r0 *1 460.92,100.64
X$13010 407 2008 1947 1951 1716 407 2003 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $13011 r0 *1 463.22,100.64
X$13011 375 626 407 407 375 sky130_fd_sc_hd__clkinv_8
* cell instance $13012 r0 *1 469.2,100.64
X$13012 407 2002 1687 2042 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $13016 r0 *1 473.8,100.64
X$13016 375 2040 2039 1951 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $13020 r0 *1 477.94,100.64
X$13020 407 1919 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $13030 r0 *1 488.06,100.64
X$13030 375 2038 2037 2002 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $13045 r0 *1 515.66,100.64
X$13045 407 1948 375 407 2357 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13204 m0 *1 235.52,106.08
X$13204 375 2165 380 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $13242 m0 *1 338.56,106.08
X$13242 407 1236 1964 2070 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $13244 m0 *1 341.78,106.08
X$13244 375 380 1826 1874 2072 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13247 m0 *1 353.74,106.08
X$13247 375 2055 2056 2074 2054 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $13248 m0 *1 358.34,106.08
X$13248 407 2056 2055 2075 375 407 2060 375 sky130_fd_sc_hd__a21oi_1
* cell instance $13250 m0 *1 360.64,106.08
X$13250 407 1983 1960 2076 375 407 2057 375 sky130_fd_sc_hd__a21oi_1
* cell instance $13251 m0 *1 362.48,106.08
X$13251 407 1986 1989 1985 407 2078 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $13254 m0 *1 365.7,106.08
X$13254 407 2058 2057 1990 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $13257 m0 *1 368.46,106.08
X$13257 375 380 2062 1874 2059 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13258 m0 *1 377.66,106.08
X$13258 407 2053 2062 407 2061 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $13259 m0 *1 380.88,106.08
X$13259 375 2062 2052 2001 1910 407 1876 407 375 sky130_fd_sc_hd__nand4_2
* cell instance $13260 m0 *1 385.48,106.08
X$13260 407 1910 2001 2052 2082 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $13265 m0 *1 389.62,106.08
X$13265 407 1236 2021 2001 1713 375 2032 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $13266 m0 *1 392.84,106.08
X$13266 375 2063 2064 2141 2021 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $13267 m0 *1 397.44,106.08
X$13267 407 2064 2063 2081 375 407 2030 375 sky130_fd_sc_hd__a21oi_1
* cell instance $13269 m0 *1 401.12,106.08
X$13269 375 2046 2079 2077 1957 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $13274 m0 *1 412.62,106.08
X$13274 407 2073 407 375 1993 375 sky130_fd_sc_hd__inv_1
* cell instance $13283 m0 *1 434.24,106.08
X$13283 375 2071 2065 1941 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $13287 m0 *1 443.44,106.08
X$13287 375 2069 2066 1915 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $13289 m0 *1 451.26,106.08
X$13289 375 1504 2008 1701 2044 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13291 m0 *1 461.38,106.08
X$13291 375 2067 626 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $13294 m0 *1 471.96,106.08
X$13294 375 1504 2039 1919 2040 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13300 m0 *1 488.98,106.08
X$13300 375 1504 2037 1919 2038 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13534 r0 *1 348.22,106.08
X$13534 407 2055 2016 2084 2058 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $13535 r0 *1 350.06,106.08
X$13535 407 1874 407 375 375 sky130_fd_sc_hd__clkinvlp_4
* cell instance $13537 r0 *1 353.74,106.08
X$13537 375 2084 2085 2097 2048 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $13538 r0 *1 358.34,106.08
X$13538 407 2084 2019 2085 375 407 2075 375 sky130_fd_sc_hd__a21o_1
* cell instance $13546 r0 *1 371.22,106.08
X$13546 407 2029 2129 2060 407 2080 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $13550 r0 *1 375.36,106.08
X$13550 407 1236 2061 2062 1713 375 2059 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $13551 r0 *1 378.58,106.08
X$13551 407 1236 2087 2052 1713 375 2051 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $13552 r0 *1 381.8,106.08
X$13552 407 2100 2052 2087 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $13556 r0 *1 391.46,106.08
X$13556 407 2001 375 407 2098 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13565 r0 *1 405.72,106.08
X$13565 407 1910 375 407 2096 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13569 r0 *1 412.62,106.08
X$13569 375 2067 675 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $13578 r0 *1 432.4,106.08
X$13578 375 1504 2065 1904 2071 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13579 r0 *1 441.6,106.08
X$13579 375 1504 2066 1701 2069 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13591 r0 *1 464.14,106.08
X$13591 375 1504 2005 1919 2094 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $13607 r0 *1 500.48,106.08
X$13607 407 2037 375 407 2092 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13964 m0 *1 353.74,111.52
X$13964 407 2099 407 375 2097 375 sky130_fd_sc_hd__inv_1
* cell instance $13980 r0 *1 374.44,111.52
X$13980 407 2117 2108 2118 2086 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $13982 r0 *1 376.28,111.52
X$13982 375 2117 2109 1965 2144 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $13987 m0 *1 382.26,111.52
X$13987 407 2052 375 407 2101 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $13989 r0 *1 385.48,111.52
X$13989 407 2062 375 407 4146 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14017 m0 *1 417.68,111.52
X$14017 407 2088 407 375 2077 375 sky130_fd_sc_hd__inv_1
* cell instance $14027 m0 *1 428.72,111.52
X$14027 407 2122 375 407 2073 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14033 m0 *1 434.7,111.52
X$14033 407 2095 407 375 2034 375 sky130_fd_sc_hd__inv_1
* cell instance $14042 r0 *1 442.98,111.52
X$14042 407 2065 375 407 2445 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14056 r0 *1 459.54,111.52
X$14056 407 2066 375 407 2110 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14059 m0 *1 461.38,111.52
X$14059 375 1504 2113 1919 2114 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $14060 r0 *1 463.22,111.52
X$14060 375 2114 2113 2008 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $14063 r0 *1 470.12,111.52
X$14063 407 2113 375 407 2279 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14071 m0 *1 479.32,111.52
X$14071 407 2089 407 375 1996 375 sky130_fd_sc_hd__inv_1
* cell instance $14077 m0 *1 482.08,111.52
X$14077 407 2005 375 407 2090 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14084 r0 *1 486.22,111.52
X$14084 407 2039 375 407 2111 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14281 m0 *1 63.94,116.96
X$14281 375 2102 2091 2103 2124 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $14291 m0 *1 74.06,116.96
X$14291 375 2102 2105 2103 2104 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $14292 r0 *1 78.66,116.96
X$14292 375 2102 2093 2103 2136 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $14296 m0 *1 85.56,116.96
X$14296 375 2102 2106 2131 2112 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $14521 m0 *1 352.82,116.96
X$14521 407 2026 375 407 2099 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14530 r0 *1 365.7,116.96
X$14530 407 2130 407 375 1991 375 sky130_fd_sc_hd__inv_1
* cell instance $14540 m0 *1 373.06,116.96
X$14540 407 2120 407 375 2119 375 sky130_fd_sc_hd__inv_1
* cell instance $14543 m0 *1 374.44,116.96
X$14543 375 2118 2128 2119 2061 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $14546 r0 *1 375.82,116.96
X$14546 407 2109 2117 2127 375 407 2129 375 sky130_fd_sc_hd__a21oi_1
* cell instance $14547 r0 *1 377.66,116.96
X$14547 407 2118 2126 2128 375 407 2127 375 sky130_fd_sc_hd__a21o_1
* cell instance $14549 m0 *1 379.5,116.96
X$14549 375 2108 2126 2115 2087 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $14556 m0 *1 388.7,116.96
X$14556 407 2116 407 375 2115 375 sky130_fd_sc_hd__inv_1
* cell instance $14599 m0 *1 439.3,116.96
X$14599 407 2138 375 407 2088 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14602 m0 *1 443.44,116.96
X$14602 407 2135 375 407 2095 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14636 m0 *1 481.16,116.96
X$14636 407 2068 375 407 2089 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $14872 m0 *1 86.02,122.4
X$14872 375 2102 2132 2131 2139 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15097 m0 *1 353.74,122.4
X$15097 407 2145 407 375 2074 375 sky130_fd_sc_hd__inv_1
* cell instance $15105 m0 *1 361.56,122.4
X$15105 407 2157 375 407 2130 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15112 m0 *1 368.92,122.4
X$15112 407 2164 375 407 2120 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15119 m0 *1 378.12,122.4
X$15119 407 2143 407 375 2144 375 sky130_fd_sc_hd__inv_1
* cell instance $15128 m0 *1 389.16,122.4
X$15128 407 2174 375 407 2142 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15129 m0 *1 392.84,122.4
X$15129 407 2142 407 375 2141 375 sky130_fd_sc_hd__inv_1
* cell instance $15170 m0 *1 441.6,122.4
X$15170 407 2134 407 375 1999 375 sky130_fd_sc_hd__inv_1
* cell instance $15195 m0 *1 471.04,122.4
X$15195 407 2162 375 407 2116 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15375 r0 *1 1.84,127.84
X$15375 407 2171 2147 2172 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $15376 r0 *1 3.22,127.84
X$15376 375 2102 2173 2170 2188 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15421 m0 *1 58.42,127.84
X$15421 375 2102 2150 2103 2148 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15422 r0 *1 58.42,127.84
X$15422 375 2102 2149 2103 2176 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15423 r0 *1 67.62,127.84
X$15423 407 2150 2149 2178 2180 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $15425 m0 *1 68.08,127.84
X$15425 407 2149 920 2159 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $15430 m0 *1 69.46,127.84
X$15430 407 2150 920 2160 407 2148 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $15433 r0 *1 71.3,127.84
X$15433 407 1811 2151 2149 2150 375 407 1709 375 sky130_fd_sc_hd__and4_1
* cell instance $15434 m0 *1 71.3,127.84
X$15434 407 2150 1000 2160 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $15437 m0 *1 74.06,127.84
X$15437 407 2150 2149 2151 2152 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $15438 r0 *1 74.52,127.84
X$15438 407 2151 2150 2149 1811 407 2156 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $15440 m0 *1 76.36,127.84
X$15440 407 1000 2153 2154 407 2155 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $15442 r0 *1 77.28,127.84
X$15442 375 2102 2154 2103 2181 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15443 m0 *1 78.2,127.84
X$15443 407 2154 920 2152 2155 407 375 2181 375 sky130_fd_sc_hd__o31ai_1
* cell instance $15445 m0 *1 81.42,127.84
X$15445 407 2156 407 375 1666 375 sky130_fd_sc_hd__buf_4
* cell instance $15449 m0 *1 86.48,127.84
X$15449 407 2154 2163 1811 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $15450 r0 *1 87.4,127.84
X$15450 375 2131 407 407 375 sky130_fd_sc_hd__inv_8
* cell instance $15452 r0 *1 91.54,127.84
X$15452 407 2163 2197 2215 407 2182 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $15473 m0 *1 113.62,127.84
X$15473 407 2165 407 375 464 375 sky130_fd_sc_hd__buf_4
* cell instance $15672 m0 *1 351.44,127.84
X$15672 407 2107 375 407 2145 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15756 m0 *1 450.8,127.84
X$15756 407 2158 375 407 2134 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15767 m0 *1 463.22,127.84
X$15767 407 2161 375 407 2143 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15949 m0 *1 1.38,133.28
X$15949 375 2102 2184 2170 2172 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15951 r0 *1 1.84,133.28
X$15951 407 2198 407 2203 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $15953 r0 *1 6.44,133.28
X$15953 375 2188 2184 2173 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $15964 r0 *1 17.02,133.28
X$15964 375 2189 2185 2191 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $15968 r0 *1 24.84,133.28
X$15968 407 2185 2190 2192 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $15971 r0 *1 27.14,133.28
X$15971 375 2102 2137 2170 2186 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15991 r0 *1 53.36,133.28
X$15991 375 2102 2178 2103 2177 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $15996 m0 *1 58.88,133.28
X$15996 407 2167 952 2166 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $15997 m0 *1 60.26,133.28
X$15997 407 2175 2159 2166 407 2176 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $15998 m0 *1 62.1,133.28
X$15998 407 2178 2209 2208 407 2177 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $15999 r0 *1 62.56,133.28
X$15999 375 2167 2194 2150 2149 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $16000 m0 *1 63.94,133.28
X$16000 407 2149 375 407 2179 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16001 r0 *1 67.16,133.28
X$16001 407 2187 2211 2194 2178 375 407 1823 375 sky130_fd_sc_hd__and4_1
* cell instance $16002 m0 *1 67.62,133.28
X$16002 407 2103 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $16006 m0 *1 69.46,133.28
X$16006 375 2196 2103 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $16009 r0 *1 71.76,133.28
X$16009 407 2210 407 375 1000 375 sky130_fd_sc_hd__buf_4
* cell instance $16012 r0 *1 75.9,133.28
X$16012 407 2152 2154 2292 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $16013 m0 *1 78.66,133.28
X$16013 407 2151 2149 2150 920 375 407 2153 375 sky130_fd_sc_hd__a31oi_1
* cell instance $16014 r0 *1 79.12,133.28
X$16014 407 2154 375 407 2183 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16016 m0 *1 82.8,133.28
X$16016 407 920 2168 2169 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $16017 r0 *1 82.8,133.28
X$16017 375 2102 2163 2131 2182 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $16020 m0 *1 85.1,133.28
X$16020 407 2154 1823 2168 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $16021 m0 *1 87.4,133.28
X$16021 375 669 2131 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $16023 r0 *1 92.92,133.28
X$16023 407 952 2168 2197 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $16077 r0 *1 157.32,133.28
X$16077 375 464 2193 1688 2195 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $16514 m0 *1 1.84,138.72
X$16514 407 2200 2175 2171 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $16515 m0 *1 3.22,138.72
X$16515 407 2203 375 407 2200 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16516 m0 *1 6.9,138.72
X$16516 407 2184 2201 2147 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $16519 m0 *1 13.8,138.72
X$16519 375 2102 2191 2170 2189 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $16523 m0 *1 23.46,138.72
X$16523 407 2190 2230 2175 2185 375 2232 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $16524 m0 *1 26.22,138.72
X$16524 407 2205 2204 2221 2206 375 2186 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $16535 m0 *1 49.22,138.72
X$16535 407 2178 375 407 2207 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16540 m0 *1 62.56,138.72
X$16540 407 2194 952 2209 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $16541 m0 *1 63.94,138.72
X$16541 407 2194 920 2202 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $16543 m0 *1 65.78,138.72
X$16543 407 2210 2202 2178 407 2208 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $16544 m0 *1 67.62,138.72
X$16544 375 2211 2151 2178 2187 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $16547 m0 *1 69.92,138.72
X$16547 375 2212 2214 2213 2150 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $16548 m0 *1 74.52,138.72
X$16548 407 2150 375 407 2423 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16554 m0 *1 85.56,138.72
X$16554 407 2168 2163 407 2216 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $16556 m0 *1 89.24,138.72
X$16556 407 1000 2169 2163 407 2215 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $16814 r0 *1 1.38,138.72
X$16814 407 2199 375 407 2776 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16816 r0 *1 6.9,138.72
X$16816 407 2173 375 407 2226 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16819 r0 *1 13.34,138.72
X$16819 407 2170 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $16822 r0 *1 15.64,138.72
X$16822 407 2228 2201 2221 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $16825 r0 *1 18.4,138.72
X$16825 375 2102 2185 2170 2229 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $16828 r0 *1 28.98,138.72
X$16828 407 2217 375 407 2233 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $16838 r0 *1 51.52,138.72
X$16838 375 2102 2187 2222 2236 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $16841 r0 *1 63.48,138.72
X$16841 407 2178 2194 2211 2237 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $16843 r0 *1 67.16,138.72
X$16843 407 2194 2178 407 2238 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $16847 r0 *1 71.76,138.72
X$16847 407 2212 2214 2241 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $16849 r0 *1 77.74,138.72
X$16849 407 2163 375 407 2242 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17088 m0 *1 1.38,144.16
X$17088 407 2295 375 407 2228 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17089 m0 *1 5.06,144.16
X$17089 375 2102 2227 2170 2281 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17090 m0 *1 14.26,144.16
X$17090 375 2196 2170 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $17093 m0 *1 23.46,144.16
X$17093 407 2190 2230 2231 2185 2232 407 2229 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $17098 m0 *1 29.9,144.16
X$17098 375 2102 2140 2170 2284 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17100 m0 *1 40.02,144.16
X$17100 375 2102 2125 2222 2235 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17103 m0 *1 49.22,144.16
X$17103 407 2234 375 407 2220 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17104 m0 *1 52.9,144.16
X$17104 407 2187 375 407 2255 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17106 m0 *1 57.04,144.16
X$17106 407 2187 1552 920 2223 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $17107 m0 *1 58.88,144.16
X$17107 407 952 2239 2224 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17108 m0 *1 60.26,144.16
X$17108 407 2224 2223 2236 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17111 m0 *1 63.02,144.16
X$17111 407 2237 2187 2239 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $17114 m0 *1 67.62,144.16
X$17114 407 2211 375 407 2246 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17119 m0 *1 74.06,144.16
X$17119 375 2261 2264 2240 2239 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $17123 m0 *1 81.88,144.16
X$17123 407 2260 2263 2225 375 407 2146 375 sky130_fd_sc_hd__a21oi_1
* cell instance $17127 m0 *1 85.56,144.16
X$17127 375 2259 2258 3370 2216 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $17387 r0 *1 2.3,144.16
X$17387 407 2243 407 2251 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $17388 r0 *1 5.98,144.16
X$17388 407 2251 375 407 2245 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17391 r0 *1 11.04,144.16
X$17391 375 2281 2252 2227 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $17395 r0 *1 17.48,144.16
X$17395 407 2191 375 407 2219 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17398 r0 *1 23.46,144.16
X$17398 407 2204 2294 2175 2252 2137 407 2206 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $17399 r0 *1 26.68,144.16
X$17399 407 2218 407 2253 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $17402 r0 *1 32.66,144.16
X$17402 407 2270 2125 2123 2121 375 407 2190 375 sky130_fd_sc_hd__and4_1
* cell instance $17403 r0 *1 35.88,144.16
X$17403 407 2190 2204 2328 2286 375 2235 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17405 r0 *1 39.1,144.16
X$17405 407 2244 375 407 2254 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17409 r0 *1 45.08,144.16
X$17409 375 2102 2234 2222 2288 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17410 r0 *1 54.28,144.16
X$17410 407 2322 375 407 2265 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17411 r0 *1 57.96,144.16
X$17411 375 2102 2211 2222 2257 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17412 r0 *1 67.16,144.16
X$17412 407 2180 2211 2273 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $17417 r0 *1 74.98,144.16
X$17417 407 2261 2276 2262 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17419 r0 *1 76.82,144.16
X$17419 407 2248 2262 2277 2225 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $17421 r0 *1 79.12,144.16
X$17421 407 2290 2276 2264 375 407 2247 375 sky130_fd_sc_hd__a21oi_1
* cell instance $17423 r0 *1 81.42,144.16
X$17423 407 2247 2248 2278 407 2260 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $17425 r0 *1 83.72,144.16
X$17425 407 2249 2259 2248 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17426 r0 *1 85.1,144.16
X$17426 375 2249 2250 2841 1971 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $17428 r0 *1 90.16,144.16
X$17428 407 2250 2249 2258 375 407 2278 375 sky130_fd_sc_hd__a21oi_1
* cell instance $17437 r0 *1 106.26,144.16
X$17437 375 2165 494 407 407 375 sky130_fd_sc_hd__buf_16
* cell instance $17664 m0 *1 3.22,149.6
X$17664 407 2280 375 407 2293 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17666 m0 *1 10.58,149.6
X$17666 407 2227 375 407 2266 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17670 m0 *1 14.72,149.6
X$17670 407 2267 2201 2231 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $17671 m0 *1 16.1,149.6
X$17671 375 2102 2252 2170 2268 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $17673 m0 *1 26.22,149.6
X$17673 407 2270 2230 2282 2269 375 2284 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17675 m0 *1 29.44,149.6
X$17675 407 2140 2137 2294 2252 375 407 2270 375 sky130_fd_sc_hd__and4_1
* cell instance $17678 m0 *1 34.04,149.6
X$17678 407 2121 2270 2285 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $17679 m0 *1 36.34,149.6
X$17679 407 2285 2204 2125 2123 2175 407 2286 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $17685 m0 *1 46,149.6
X$17685 375 2288 2287 2234 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $17688 m0 *1 52.9,149.6
X$17688 407 2253 375 407 2302 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $17693 m0 *1 62.1,149.6
X$17693 407 2211 1552 920 2271 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $17694 m0 *1 63.94,149.6
X$17694 407 2272 2271 2257 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17697 m0 *1 66.7,149.6
X$17697 407 952 2273 2272 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $17701 m0 *1 69.92,149.6
X$17701 407 2275 2274 2277 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $17703 m0 *1 72.22,149.6
X$17703 375 375 2210 407 2175 952 407 sky130_fd_sc_hd__nor2_2
* cell instance $17706 m0 *1 75.9,149.6
X$17706 375 2276 2290 2291 2292 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $17711 m0 *1 90.16,149.6
X$17711 407 2289 407 375 385 375 sky130_fd_sc_hd__buf_4
* cell instance $17967 r0 *1 1.38,149.6
X$17967 407 2342 407 2295 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $17971 r0 *1 8.28,149.6
X$17971 375 2296 2399 2280 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $17974 r0 *1 13.8,149.6
X$17974 407 2245 2201 2297 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $17980 r0 *1 16.1,149.6
X$17980 407 2204 2252 2324 2298 375 2268 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17981 r0 *1 18.86,149.6
X$17981 407 2252 2175 2204 2298 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $17984 r0 *1 25.3,149.6
X$17984 407 2516 2201 2282 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $17985 r0 *1 26.68,149.6
X$17985 375 2294 2205 2252 2137 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $17986 r0 *1 28.98,149.6
X$17986 407 2205 2230 2175 2140 375 2269 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17988 r0 *1 32.2,149.6
X$17988 407 2270 2204 2175 2121 375 2300 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17989 r0 *1 34.96,149.6
X$17989 407 2285 2204 2299 2300 375 2301 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $17997 r0 *1 43.24,149.6
X$17997 375 2102 2121 2222 2301 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18000 r0 *1 53.82,149.6
X$18000 375 2222 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $18002 r0 *1 65.78,149.6
X$18002 375 2275 2274 2306 2273 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $18008 r0 *1 72.68,149.6
X$18008 407 2241 2307 2338 407 2263 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $18011 r0 *1 80.04,149.6
X$18011 407 2305 2256 2304 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18012 r0 *1 81.42,149.6
X$18012 375 2303 2305 2304 2322 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $18014 r0 *1 85.56,149.6
X$18014 375 464 2283 2131 2340 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18297 m0 *1 2.76,155.04
X$18297 375 2102 2280 2170 2296 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18299 m0 *1 12.88,155.04
X$18299 407 2313 2201 2324 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18303 m0 *1 20.7,155.04
X$18303 375 2294 2325 2252 2230 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $18304 m0 *1 23,155.04
X$18304 407 2230 2252 2294 2175 375 2315 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $18309 m0 *1 29.44,155.04
X$18309 407 2327 2201 2299 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18311 m0 *1 34.5,155.04
X$18311 407 2285 2230 2175 2123 375 2329 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $18312 m0 *1 37.26,155.04
X$18312 375 2102 2123 2317 2319 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18319 m0 *1 57.5,155.04
X$18319 407 1552 407 375 2201 375 sky130_fd_sc_hd__buf_4
* cell instance $18320 m0 *1 60.26,155.04
X$18320 375 2321 2320 2332 2167 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $18323 m0 *1 66.24,155.04
X$18323 407 2321 2333 2307 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $18325 m0 *1 69.46,155.04
X$18325 407 2320 2333 2335 2274 375 2338 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $18326 m0 *1 72.22,155.04
X$18326 407 2210 2337 2339 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $18327 m0 *1 73.6,155.04
X$18327 375 464 2305 2103 2339 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18328 m0 *1 82.8,155.04
X$18328 407 2323 2303 2340 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18549 r0 *1 3.68,155.04
X$18549 407 2312 375 407 2373 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18550 m0 *1 3.68,160.48
X$18550 407 2353 375 407 2311 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18552 r0 *1 7.36,155.04
X$18552 407 2309 407 2312 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $18555 m0 *1 10.58,160.48
X$18555 407 2310 407 2343 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $18557 m0 *1 14.26,160.48
X$18557 407 2346 375 407 2344 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18564 r0 *1 16.1,155.04
X$18564 407 2314 375 407 2308 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18567 m0 *1 19.78,160.48
X$18567 407 2344 2201 2326 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18568 r0 *1 20.24,155.04
X$18568 407 2326 2315 2325 2316 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $18569 m0 *1 21.16,160.48
X$18569 375 2359 2294 2360 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $18570 r0 *1 22.08,155.04
X$18570 375 2102 2294 2317 2316 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18576 m0 *1 31.74,160.48
X$18576 407 2347 375 407 2318 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18578 r0 *1 34.04,155.04
X$18578 407 2285 2230 2348 2123 2329 407 2319 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $18579 m0 *1 35.42,160.48
X$18579 407 2362 2201 2348 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18581 r0 *1 37.26,155.04
X$18581 407 2318 2201 2328 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $18584 m0 *1 39.1,160.48
X$18584 407 2341 375 407 2349 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18590 m0 *1 42.78,160.48
X$18590 375 2350 2330 2317 2364 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18593 r0 *1 45.54,155.04
X$18593 407 2330 375 407 2331 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18597 r0 *1 53.82,155.04
X$18597 375 2196 2222 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $18605 r0 *1 65.78,155.04
X$18605 375 2333 2335 2334 2238 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $18611 m0 *1 69.46,160.48
X$18611 375 2350 2345 2222 2367 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $18613 r0 *1 70.84,155.04
X$18613 407 2336 2302 2305 2289 375 407 2337 375 sky130_fd_sc_hd__a31oi_1
* cell instance $18617 r0 *1 78.66,155.04
X$18617 375 2289 2256 2322 2305 2323 407 407 375 sky130_fd_sc_hd__nor4bb_4
* cell instance $19118 r0 *1 1.84,160.48
X$19118 375 2102 2353 2317 2354 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19119 m0 *1 5.06,165.92
X$19119 375 2102 2358 2317 2383 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19120 r0 *1 11.04,160.48
X$19120 375 2354 2353 2355 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $19127 m0 *1 16.1,165.92
X$19127 407 2360 375 407 2384 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19128 r0 *1 17.48,160.48
X$19128 375 2102 2360 2317 2359 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19129 m0 *1 19.78,165.92
X$19129 407 2371 407 2388 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $19130 m0 *1 23.46,165.92
X$19130 407 2317 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $19131 m0 *1 25.3,165.92
X$19131 407 2420 375 407 2387 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19134 r0 *1 28.06,160.48
X$19134 407 2343 375 407 2361 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19137 m0 *1 30.36,165.92
X$19137 407 2450 375 407 2362 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19139 r0 *1 32.2,160.48
X$19139 375 2102 2314 2317 2363 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19141 m0 *1 34.5,165.92
X$19141 375 2363 2390 2314 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $19151 r0 *1 43.7,160.48
X$19151 375 2364 2365 2330 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $19163 m0 *1 58.88,165.92
X$19163 375 2305 2322 2356 407 2133 407 375 sky130_fd_sc_hd__nand3_4
* cell instance $19166 r0 *1 65.32,160.48
X$19166 407 2083 2369 2368 407 2366 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $19167 m0 *1 65.32,165.92
X$19167 407 2322 2393 2336 2394 407 2368 375 375 sky130_fd_sc_hd__a22oi_1
* cell instance $19169 r0 *1 67.62,160.48
X$19169 407 2323 407 375 2356 375 sky130_fd_sc_hd__inv_1
* cell instance $19177 m0 *1 70.38,165.92
X$19177 407 2356 2322 2336 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $19179 r0 *1 70.84,160.48
X$19179 407 920 2083 2175 2345 2367 375 407 375 sky130_fd_sc_hd__o22a_1
* cell instance $19182 m0 *1 73.14,165.92
X$19182 407 920 2083 2379 407 2381 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $19184 r0 *1 74.52,160.48
X$19184 375 2350 2323 2103 2366 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19185 m0 *1 74.98,165.92
X$19185 375 2350 2382 2222 2381 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $19686 r0 *1 1.84,165.92
X$19686 407 2372 407 2409 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $19688 r0 *1 6.44,165.92
X$19688 407 2410 2175 2398 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $19690 r0 *1 8.28,165.92
X$19690 375 2383 2374 2358 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $19691 r0 *1 12.42,165.92
X$19691 407 2375 2374 2297 2386 375 2385 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $19697 r0 *1 16.1,165.92
X$19697 407 2352 375 407 2494 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19698 r0 *1 19.78,165.92
X$19698 407 2351 407 2376 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $19699 r0 *1 23.46,165.92
X$19699 375 2196 2317 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $19701 r0 *1 33.58,165.92
X$19701 407 2361 2201 2389 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $19703 r0 *1 38.64,165.92
X$19703 407 2388 375 407 2391 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19710 r0 *1 46.92,165.92
X$19710 407 2376 375 407 2489 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19714 r0 *1 55.66,165.92
X$19714 407 2392 375 407 2370 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $19718 r0 *1 62.56,165.92
X$19718 407 2356 2322 2305 2369 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $19719 r0 *1 64.86,165.92
X$19719 375 2393 2305 2377 2323 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $19726 r0 *1 70.84,165.92
X$19726 407 2305 2431 2377 2378 2356 2380 375 407 375 sky130_fd_sc_hd__a32oi_1
* cell instance $19728 r0 *1 74.52,165.92
X$19728 407 2322 2380 2382 407 2379 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $20015 m0 *1 3.22,171.36
X$20015 407 2409 375 407 2410 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20017 m0 *1 7.36,171.36
X$20017 375 2102 2399 2317 2411 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20018 m0 *1 16.56,171.36
X$20018 375 2102 2374 2317 2385 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20019 m0 *1 25.76,171.36
X$20019 407 2374 2400 2386 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20020 m0 *1 27.14,171.36
X$20020 407 2415 2412 2192 2402 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $20024 m0 *1 30.82,171.36
X$20024 407 2401 375 407 2406 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20025 m0 *1 34.5,171.36
X$20025 407 2402 2403 2414 2389 375 407 2413 375 sky130_fd_sc_hd__a31oi_1
* cell instance $20026 m0 *1 36.8,171.36
X$20026 407 2404 2403 2415 375 407 2400 375 sky130_fd_sc_hd__a21oi_1
* cell instance $20030 m0 *1 41.86,171.36
X$20030 375 2404 2406 2407 2405 2365 2175 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $20031 m0 *1 45.54,171.36
X$20031 375 2350 2365 2222 2407 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20037 m0 *1 64.86,171.36
X$20037 407 2305 2302 2377 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $20038 m0 *1 67.16,171.36
X$20038 375 2377 2426 2378 407 1552 407 375 sky130_fd_sc_hd__nand3_4
* cell instance $20261 r0 *1 1.84,171.36
X$20261 407 2358 375 407 2478 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20263 r0 *1 5.98,171.36
X$20263 407 2427 2201 2428 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20264 r0 *1 7.36,171.36
X$20264 407 2397 407 2346 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20266 r0 *1 11.5,171.36
X$20266 407 2396 407 2420 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20271 r0 *1 15.64,171.36
X$20271 407 2395 407 2401 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20272 r0 *1 19.32,171.36
X$20272 375 2419 2471 2374 2399 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $20275 r0 *1 26.22,171.36
X$20275 375 2421 2204 2415 2412 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $20278 r0 *1 31.28,171.36
X$20278 375 2350 2414 2430 2422 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20280 r0 *1 41.4,171.36
X$20280 407 2365 2421 2405 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20288 r0 *1 51.06,171.36
X$20288 375 2350 2418 2424 2433 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20291 r0 *1 62.56,171.36
X$20291 407 2305 2443 2425 407 2394 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $20292 r0 *1 64.4,171.36
X$20292 407 2305 2302 2425 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $20293 r0 *1 65.78,171.36
X$20293 407 2322 2431 2426 2378 2302 2548 375 407 375 sky130_fd_sc_hd__a32oi_1
* cell instance $20297 r0 *1 69,171.36
X$20297 407 2356 2302 2431 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20301 r0 *1 72.22,171.36
X$20301 407 2356 2444 2322 2377 375 2408 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $20302 r0 *1 75.44,171.36
X$20302 375 2350 2322 2424 2408 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20585 m0 *1 1.38,176.8
X$20585 407 2418 375 407 2436 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20586 m0 *1 5.06,176.8
X$20586 407 2446 375 407 2427 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20587 m0 *1 8.74,176.8
X$20587 407 2375 2419 2175 2374 2399 407 2449 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $20588 m0 *1 11.96,176.8
X$20588 375 2350 2419 2430 2429 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $20591 m0 *1 25.76,176.8
X$20591 407 2421 2415 2375 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20596 m0 *1 34.04,176.8
X$20596 407 2413 2439 2454 375 407 2422 375 sky130_fd_sc_hd__a21boi_0
* cell instance $20597 m0 *1 36.8,176.8
X$20597 407 2414 407 375 2439 375 sky130_fd_sc_hd__inv_1
* cell instance $20598 m0 *1 38.18,176.8
X$20598 407 2421 2402 2432 407 2454 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $20601 m0 *1 42.78,176.8
X$20601 407 2201 2421 2432 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $20602 m0 *1 44.16,176.8
X$20602 407 952 2349 2421 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $20606 m0 *1 52.44,176.8
X$20606 375 2433 2458 2418 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $20610 m0 *1 59.34,176.8
X$20610 375 952 2443 2323 2305 2322 407 407 375 sky130_fd_sc_hd__and4bb_2
* cell instance $20613 m0 *1 68.08,176.8
X$20613 407 2323 2322 2426 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20614 m0 *1 69.46,176.8
X$20614 407 2378 2426 2377 375 407 2175 375 sky130_fd_sc_hd__and3_2
* cell instance $20618 m0 *1 75.44,176.8
X$20618 407 2382 375 407 2530 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20840 r0 *1 4.14,176.8
X$20840 407 2435 407 2447 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20841 r0 *1 7.82,176.8
X$20841 407 2447 375 407 2480 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20842 r0 *1 11.5,176.8
X$20842 407 2448 407 2450 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20848 r0 *1 16.1,176.8
X$20848 407 2437 407 2347 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $20849 r0 *1 19.78,176.8
X$20849 407 2438 2374 2419 2175 375 2493 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $20852 r0 *1 24.84,176.8
X$20852 407 2472 375 407 2451 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $20856 r0 *1 33.58,176.8
X$20856 375 2452 2414 2440 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $20857 r0 *1 37.72,176.8
X$20857 407 2175 2403 2404 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20860 r0 *1 41.4,176.8
X$20860 407 2349 920 2403 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $20867 r0 *1 44.62,176.8
X$20867 407 2349 2441 920 2455 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $20869 r0 *1 47.84,176.8
X$20869 375 2349 2456 2442 2457 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $20872 r0 *1 52.9,176.8
X$20872 407 2442 407 375 920 375 sky130_fd_sc_hd__buf_4
* cell instance $20875 r0 *1 57.04,176.8
X$20875 375 2323 2322 2305 2442 2443 407 407 375 sky130_fd_sc_hd__nand4bb_4
* cell instance $20877 r0 *1 68.08,176.8
X$20877 407 2305 2426 2453 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $20883 r0 *1 72.68,176.8
X$20883 407 2305 2322 407 2444 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $21168 m0 *1 1.84,182.24
X$21168 407 2462 375 407 2469 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21169 m0 *1 5.52,182.24
X$21169 407 2460 407 2446 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $21170 m0 *1 9.2,182.24
X$21170 407 2471 2375 2428 2449 375 2411 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $21171 m0 *1 11.96,182.24
X$21171 407 2417 407 2472 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $21172 m0 *1 15.64,182.24
X$21172 407 2465 375 407 2459 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21174 m0 *1 19.78,182.24
X$21174 375 2102 2465 2430 2473 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21178 m0 *1 30.82,182.24
X$21178 375 2350 2440 2430 2452 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21180 m0 *1 43.7,182.24
X$21180 375 2350 2467 2424 2474 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21183 m0 *1 57.04,182.24
X$21183 407 2476 375 407 2443 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21188 m0 *1 69.46,182.24
X$21188 407 2378 2345 2468 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $21189 m0 *1 70.84,182.24
X$21189 407 2453 407 375 2195 375 sky130_fd_sc_hd__buf_4
* cell instance $21190 m0 *1 73.6,182.24
X$21190 407 2323 2468 2444 407 2475 375 375 sky130_fd_sc_hd__a21oi_2
* cell instance $21409 r0 *1 1.38,182.24
X$21409 407 2479 407 2462 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $21411 r0 *1 5.52,182.24
X$21411 375 2490 2419 2470 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $21413 r0 *1 10.12,182.24
X$21413 407 2492 2491 2463 2481 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $21414 r0 *1 11.96,182.24
X$21414 407 2438 2419 2493 2374 2464 407 2429 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $21419 r0 *1 15.64,182.24
X$21419 375 2350 2482 2430 2481 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21420 r0 *1 24.84,182.24
X$21420 375 2473 2504 2465 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $21425 r0 *1 39.1,182.24
X$21425 407 2498 2201 2466 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $21427 r0 *1 40.94,182.24
X$21427 407 2484 2456 2466 2474 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $21433 r0 *1 43.7,182.24
X$21433 407 2467 2432 2455 375 407 2484 375 sky130_fd_sc_hd__a21oi_1
* cell instance $21435 r0 *1 46,182.24
X$21435 407 2403 2501 2488 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $21437 r0 *1 47.84,182.24
X$21437 407 2287 2432 2488 375 407 2500 375 sky130_fd_sc_hd__a21oi_1
* cell instance $21439 r0 *1 50.14,182.24
X$21439 407 2467 2441 2457 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $21441 r0 *1 51.98,182.24
X$21441 375 2350 2487 2424 2496 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21443 r0 *1 62.1,182.24
X$21443 407 2323 375 407 2495 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21454 r0 *1 77.74,182.24
X$21454 407 2475 407 375 2607 375 sky130_fd_sc_hd__buf_4
* cell instance $21739 m0 *1 1.84,187.68
X$21739 375 2102 2470 2537 2490 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $21740 m0 *1 11.04,187.68
X$21740 407 2480 2201 2492 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $21741 m0 *1 12.42,187.68
X$21741 407 2471 2438 2175 2482 375 2491 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $21742 m0 *1 15.18,187.68
X$21742 375 2438 2463 2482 2471 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $21747 m0 *1 27.14,187.68
X$21747 407 2430 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $21751 m0 *1 31.74,187.68
X$21751 407 2483 375 407 2498 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21752 m0 *1 35.42,187.68
X$21752 407 2456 2505 2497 2518 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $21755 m0 *1 44.62,187.68
X$21755 407 2404 2403 2486 375 407 2485 375 sky130_fd_sc_hd__a21oi_1
* cell instance $21756 m0 *1 46.46,187.68
X$21756 407 2467 2441 2487 2501 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $21757 m0 *1 48.3,187.68
X$21757 375 2499 2485 2487 2201 2489 2496 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $21987 r0 *1 3.22,187.68
X$21987 407 2470 375 407 2508 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21991 r0 *1 10.12,187.68
X$21991 407 2469 2201 2526 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $21993 r0 *1 11.96,187.68
X$21993 407 2471 2375 2503 2482 2175 407 2527 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $22000 r0 *1 18.4,187.68
X$22000 375 2350 2504 2430 2509 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22001 r0 *1 27.6,187.68
X$22001 375 2196 2430 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $22002 r0 *1 36.8,187.68
X$22002 375 2505 2438 2456 2497 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $22003 r0 *1 39.1,187.68
X$22003 407 2510 2505 2497 2415 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22010 r0 *1 45.08,187.68
X$22010 407 2421 2486 2506 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $22011 r0 *1 46.46,187.68
X$22011 407 2365 2507 2467 2486 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22013 r0 *1 49.22,187.68
X$22013 407 2487 2506 2499 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $22198 r0 *1 439.3,187.68
X$22198 375 2523 2067 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $22311 m0 *1 1.84,193.12
X$22311 407 2477 407 2524 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $22313 m0 *1 5.98,193.12
X$22313 407 2165 407 375 2102 375 sky130_fd_sc_hd__buf_4
* cell instance $22314 m0 *1 8.74,193.12
X$22314 407 2502 407 2514 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $22316 m0 *1 13.34,193.12
X$22316 407 2512 2375 2526 2527 375 2528 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $22317 m0 *1 16.1,193.12
X$22317 407 2513 407 2483 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $22318 m0 *1 19.78,193.12
X$22318 407 2514 375 407 2517 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22320 m0 *1 23.92,193.12
X$22320 375 2201 2546 2529 2515 2415 2421 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $22321 m0 *1 27.14,193.12
X$22321 407 2539 2504 2512 2515 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22323 m0 *1 29.44,193.12
X$22323 407 2518 2515 2532 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $22324 m0 *1 30.82,193.12
X$22324 407 2518 2412 2230 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $22325 m0 *1 32.2,193.12
X$22325 375 2551 2519 2520 2201 2517 2552 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $22327 m0 *1 37.26,193.12
X$22327 407 2404 2403 2521 375 407 2519 375 sky130_fd_sc_hd__a21oi_1
* cell instance $22328 m0 *1 39.1,193.12
X$22328 407 2520 2510 2505 2555 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22331 m0 *1 42.32,193.12
X$22331 407 2467 2441 2505 2521 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22332 m0 *1 44.16,193.12
X$22332 375 2507 2510 2365 2467 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $22333 m0 *1 46.46,193.12
X$22333 407 2533 2421 2534 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $22337 m0 *1 51.06,193.12
X$22337 375 2533 2441 2365 2507 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $22340 m0 *1 57.04,193.12
X$22340 375 2553 2467 2531 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $22566 r0 *1 2.76,193.12
X$22566 407 2560 407 2544 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $22568 r0 *1 6.9,193.12
X$22568 375 2543 2482 2525 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $22570 r0 *1 11.96,193.12
X$22570 375 2503 2512 2482 2471 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $22576 r0 *1 15.64,193.12
X$22576 375 2350 2503 2430 2528 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22577 r0 *1 24.84,193.12
X$22577 407 2545 2546 2509 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $22578 r0 *1 26.22,193.12
X$22578 407 2608 2539 2504 2512 407 2412 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $22581 r0 *1 32.66,193.12
X$22581 375 2350 2520 2430 2552 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22587 r0 *1 43.24,193.12
X$22587 407 2507 2201 2541 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $22588 r0 *1 44.62,193.12
X$22588 407 2541 2535 2421 2534 375 407 2522 375 sky130_fd_sc_hd__a31oi_1
* cell instance $22589 r0 *1 46.92,193.12
X$22589 375 2350 2507 2424 2522 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22591 r0 *1 56.58,193.12
X$22591 375 2350 2531 2424 2553 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22885 m0 *1 2.3,198.56
X$22885 375 2102 2525 2537 2543 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $22886 m0 *1 11.5,198.56
X$22886 407 2538 375 407 2511 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22887 m0 *1 15.18,198.56
X$22887 407 2536 407 2547 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $22889 m0 *1 20.7,198.56
X$22889 407 2512 2375 2504 2539 2175 407 2545 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $22896 m0 *1 32.2,198.56
X$22896 407 2520 2565 2551 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $22900 m0 *1 38.64,198.56
X$22900 407 2404 2403 2555 375 407 2554 375 sky130_fd_sc_hd__a21oi_1
* cell instance $22902 m0 *1 44.16,198.56
X$22902 407 2404 2403 2542 375 407 2556 375 sky130_fd_sc_hd__a21oi_1
* cell instance $22903 m0 *1 46,198.56
X$22903 407 2458 2510 2587 2542 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $22907 m0 *1 51.06,198.56
X$22907 407 2305 375 407 2540 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $22910 m0 *1 57.04,198.56
X$22910 375 2196 2424 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $22911 m0 *1 66.24,198.56
X$22911 407 2549 2548 2305 407 2550 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $23134 r0 *1 1.84,198.56
X$23134 407 2561 2201 2562 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $23135 r0 *1 3.22,198.56
X$23135 407 2524 375 407 2573 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23136 r0 *1 6.9,198.56
X$23136 407 2557 407 2572 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $23137 r0 *1 10.58,198.56
X$23137 407 2544 375 407 2561 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23143 r0 *1 15.64,198.56
X$23143 407 2463 2539 2562 2503 2574 407 2564 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $23144 r0 *1 18.86,198.56
X$23144 375 2350 2539 2537 2564 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $23146 r0 *1 29.9,198.56
X$23146 407 2547 375 407 2576 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23147 r0 *1 33.58,198.56
X$23147 407 2440 375 407 2566 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23148 r0 *1 37.26,198.56
X$23148 407 2390 2554 2575 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $23150 r0 *1 39.1,198.56
X$23150 407 2576 2201 2569 407 2577 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $23158 r0 *1 45.54,198.56
X$23158 407 2456 2287 2570 2487 2500 407 2571 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $23159 r0 *1 48.76,198.56
X$23159 375 2350 2287 2424 2571 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $23163 r0 *1 61.18,198.56
X$23163 375 2350 2549 2424 2550 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $23457 m0 *1 4.6,204
X$23457 375 2572 2165 407 407 375 sky130_fd_sc_hd__buf_8
* cell instance $23458 m0 *1 10.12,204
X$23458 407 2590 375 407 2516 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23459 m0 *1 13.8,204
X$23459 407 2563 2201 2464 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $23460 m0 *1 15.18,204
X$23460 407 2463 2503 2539 2175 375 2574 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $23462 m0 *1 19.78,204
X$23462 375 2350 2538 2537 2591 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $23467 m0 *1 35.42,204
X$23467 407 2456 2505 2565 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $23469 m0 *1 38.64,204
X$23469 407 2506 2505 2568 2569 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $23470 m0 *1 40.48,204
X$23470 407 2579 2577 2578 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $23473 m0 *1 47.38,204
X$23473 375 2350 2458 2424 2580 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $23477 m0 *1 59.34,204
X$23477 407 2531 375 407 2558 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23479 m0 *1 64.86,204
X$23479 407 2549 375 407 2581 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23516 m0 *1 167.44,204
X$23516 375 2588 669 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $23702 r0 *1 4.14,204
X$23702 407 2559 407 2590 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $23703 r0 *1 7.82,204
X$23703 407 2525 375 407 2589 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $23711 r0 *1 23,204
X$23711 375 2591 2567 2538 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $23714 r0 *1 29.9,204
X$23714 407 2387 2201 2592 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $23715 r0 *1 31.28,204
X$23715 407 2568 2565 2592 2584 2594 407 2593 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $23717 r0 *1 34.96,204
X$23717 375 2584 2497 2585 2586 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $23718 r0 *1 37.26,204
X$23718 407 2585 2586 2568 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $23719 r0 *1 39.56,204
X$23719 407 2586 2505 2175 2506 2585 407 2579 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $23725 r0 *1 46.92,204
X$23725 407 2587 2456 2595 2458 2627 407 2580 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $23726 r0 *1 50.14,204
X$23726 407 2587 2456 2175 2458 375 2595 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $23780 r0 *1 165.14,204
X$23780 375 669 407 407 375 sky130_fd_sc_hd__clkinv_16
* cell instance $24022 m0 *1 3.22,209.44
X$24022 407 2610 407 2603 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $24023 m0 *1 6.9,209.44
X$24023 407 2603 375 407 2563 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24025 m0 *1 11.5,209.44
X$24025 375 2599 2597 2537 2606 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24027 m0 *1 22.54,209.44
X$24027 407 2532 2608 2659 2622 375 2623 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $24030 m0 *1 29.44,209.44
X$24030 375 2599 2584 2537 2593 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24031 m0 *1 38.64,209.44
X$24031 375 2599 2585 2430 2578 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24032 m0 *1 47.84,209.44
X$24032 407 2506 2287 2175 2487 2602 407 2600 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $24033 m0 *1 51.06,209.44
X$24033 375 2287 2587 2487 2602 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $24039 m0 *1 58.88,209.44
X$24039 375 2609 2487 2630 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $24041 m0 *1 63.94,209.44
X$24041 407 2617 375 407 2378 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24264 r0 *1 3.22,209.44
X$24264 407 2461 407 2618 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $24265 r0 *1 6.9,209.44
X$24265 407 2604 2201 2620 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $24267 r0 *1 9.2,209.44
X$24267 407 2597 375 407 2605 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24268 r0 *1 12.88,209.44
X$24268 407 2573 2598 2621 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $24275 r0 *1 16.1,209.44
X$24275 375 2606 2539 2597 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $24276 r0 *1 20.24,209.44
X$24276 375 2196 2537 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $24280 r0 *1 32.66,209.44
X$24280 407 2568 2565 2598 2584 375 2594 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $24282 r0 *1 37.26,209.44
X$24282 375 2390 2586 2520 2567 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $24283 r0 *1 39.56,209.44
X$24283 407 2506 2505 2626 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $24291 r0 *1 44.62,209.44
X$24291 375 2615 2505 2458 2587 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $24292 r0 *1 46.92,209.44
X$24292 407 2587 2506 2601 2600 375 2628 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $24295 r0 *1 55.2,209.44
X$24295 375 2350 2630 2424 2609 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24590 m0 *1 3.22,214.88
X$24590 407 2611 407 2619 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $24591 m0 *1 6.9,214.88
X$24591 407 2619 375 407 2313 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24594 m0 *1 16.1,214.88
X$24594 375 2599 2608 2537 2623 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24595 m0 *1 25.3,214.88
X$24595 407 2608 2598 2532 2622 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $24599 m0 *1 29.9,214.88
X$24599 407 2165 407 375 2350 375 sky130_fd_sc_hd__buf_4
* cell instance $24600 m0 *1 32.66,214.88
X$24600 375 2599 2567 2537 2625 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24603 m0 *1 47.38,214.88
X$24603 375 2350 2602 2424 2628 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $24606 m0 *1 57.5,214.88
X$24606 375 2629 2602 2644 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $24831 r0 *1 1.84,214.88
X$24831 407 2635 375 407 2416 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24832 r0 *1 5.52,214.88
X$24832 407 2613 375 407 2631 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24833 r0 *1 9.2,214.88
X$24833 407 2621 2620 2636 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $24835 r0 *1 11.04,214.88
X$24835 375 2637 2503 2613 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $24844 r0 *1 22.54,214.88
X$24844 407 2638 407 2624 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $24845 r0 *1 26.22,214.88
X$24845 407 2642 375 407 2327 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24847 r0 *1 30.82,214.88
X$24847 407 2643 2633 2614 2625 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $24848 r0 *1 32.66,214.88
X$24848 407 2565 2390 2598 2520 2567 407 2633 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $24850 r0 *1 36.34,214.88
X$24850 407 2565 2567 2390 2520 375 407 2614 375 sky130_fd_sc_hd__and4_1
* cell instance $24860 r0 *1 44.62,214.88
X$24860 407 2624 375 407 2616 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24862 r0 *1 48.76,214.88
X$24862 407 2616 2201 2627 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $24866 r0 *1 56.12,214.88
X$24866 375 2350 2644 2424 2629 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25161 m0 *1 1.84,220.32
X$25161 375 2639 2604 2652 2636 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25162 m0 *1 11.04,220.32
X$25162 375 2639 2613 2537 2637 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25164 m0 *1 22.08,220.32
X$25164 375 2640 2608 2641 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25171 m0 *1 35.42,220.32
X$25171 407 2575 2634 2647 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $25172 m0 *1 36.8,220.32
X$25172 407 2626 2645 2201 2662 2634 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $25173 m0 *1 39.1,220.32
X$25173 407 2520 2390 2645 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $25175 m0 *1 41.4,220.32
X$25175 375 2626 2556 2615 2201 2717 2646 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $25176 m0 *1 45.54,220.32
X$25176 375 2599 2615 2654 2646 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25406 m0 *1 1.84,225.76
X$25406 407 2651 375 407 2794 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25407 r0 *1 2.3,220.32
X$25407 375 2639 2651 2652 2656 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25408 m0 *1 5.52,225.76
X$25408 375 2656 2604 2651 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25409 m0 *1 9.66,225.76
X$25409 375 2639 2635 2537 2657 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25410 r0 *1 11.5,220.32
X$25410 407 2632 407 2642 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25418 m0 *1 18.86,225.76
X$25418 407 2666 407 2653 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25419 r0 *1 18.86,220.32
X$25419 375 2599 2641 2537 2640 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25420 m0 *1 22.54,225.76
X$25420 407 2680 2201 2659 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $25421 m0 *1 23.92,225.76
X$25421 407 2641 375 407 2650 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25426 m0 *1 29.44,225.76
X$25426 375 2660 2520 2661 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25428 r0 *1 33.58,220.32
X$25428 375 2599 2390 2537 2647 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25429 m0 *1 33.58,225.76
X$25429 407 2653 375 407 2662 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25440 m0 *1 47.38,225.76
X$25440 375 2599 2655 2654 2663 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25441 r0 *1 50.6,220.32
X$25441 375 2663 2615 2655 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25446 r0 *1 59.34,220.32
X$25446 407 2644 375 407 2648 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25965 r0 *1 2.3,225.76
X$25965 407 2668 2201 2673 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $25966 m0 *1 2.3,231.2
X$25966 407 2687 407 2674 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25967 r0 *1 3.68,225.76
X$25967 407 2669 375 407 2596 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25968 m0 *1 5.98,231.2
X$25968 407 2674 375 407 2267 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25969 r0 *1 7.36,225.76
X$25969 407 2664 407 2676 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25970 m0 *1 9.66,231.2
X$25970 407 2675 407 2677 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25971 r0 *1 11.04,225.76
X$25971 375 2657 2635 2658 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25972 m0 *1 13.34,231.2
X$25972 407 2676 375 407 2680 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25978 m0 *1 17.02,231.2
X$25978 407 2667 407 2678 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $25980 r0 *1 17.94,225.76
X$25980 407 2677 375 407 2529 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25982 r0 *1 21.62,225.76
X$25982 407 2681 375 407 2649 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25984 m0 *1 22.08,231.2
X$25984 407 2661 375 407 2679 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $25985 r0 *1 25.3,225.76
X$25985 375 2599 2661 2654 2660 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $25994 m0 *1 35.42,231.2
X$25994 375 2682 2584 2670 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $25996 m0 *1 39.56,231.2
X$25996 375 2599 2671 2654 2683 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $26002 r0 *1 43.24,225.76
X$26002 375 2683 2585 2671 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $26006 r0 *1 50.14,225.76
X$26006 375 2599 2672 2654 2684 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $26009 m0 *1 51.98,231.2
X$26009 375 2684 2507 2672 2133 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $26013 r0 *1 59.34,225.76
X$26013 407 2630 375 407 2665 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26015 r0 *1 63.02,225.76
X$26015 407 2369 2133 2685 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $26532 r0 *1 1.38,231.2
X$26532 407 2398 2673 2688 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $26534 r0 *1 2.76,231.2
X$26534 375 2639 2668 2652 2688 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $26535 m0 *1 5.06,236.64
X$26535 375 2692 2689 2668 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $26536 m0 *1 9.2,236.64
X$26536 375 2652 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $26544 r0 *1 15.64,231.2
X$26544 375 2599 2669 2654 2711 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $26547 m0 *1 21.62,236.64
X$26547 407 2686 407 2690 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $26549 m0 *1 25.3,236.64
X$26549 407 2693 375 407 2612 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26551 r0 *1 26.22,231.2
X$26551 407 2434 375 407 2694 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26555 m0 *1 33.12,236.64
X$26555 407 2678 375 407 2695 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26556 r0 *1 33.58,231.2
X$26556 375 2599 2670 2654 2682 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $26558 m0 *1 37.26,236.64
X$26558 407 2716 2175 2535 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $26559 m0 *1 38.64,236.64
X$26559 375 2196 2654 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $26564 r0 *1 43.24,231.2
X$26564 407 2391 2201 2698 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $26565 r0 *1 44.62,231.2
X$26565 407 2690 375 407 2691 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26567 m0 *1 48.3,236.64
X$26567 407 2718 2201 2601 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $26568 r0 *1 48.3,231.2
X$26568 407 2691 2201 2570 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $26569 r0 *1 49.68,231.2
X$26569 407 2655 375 407 2697 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $26581 r0 *1 63.48,231.2
X$26581 407 2696 407 375 2334 375 sky130_fd_sc_hd__inv_1
* cell instance $27099 m0 *1 1.84,242.08
X$27099 407 2703 407 2708 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $27100 r0 *1 2.3,236.64
X$27100 375 2639 2689 2652 2692 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $27101 m0 *1 5.52,242.08
X$27101 407 2618 375 407 2710 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27102 m0 *1 9.2,242.08
X$27102 375 2196 2652 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $27109 r0 *1 16.56,236.64
X$27109 375 2711 2669 2712 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $27113 r0 *1 22.08,236.64
X$27113 375 2599 2693 2652 2713 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $27116 m0 *1 24.84,242.08
X$27116 375 2713 2693 2704 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $27121 m0 *1 31.74,242.08
X$27121 407 2735 2201 2643 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $27123 r0 *1 32.66,236.64
X$27123 407 2694 2201 2714 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $27125 r0 *1 34.04,236.64
X$27125 407 2670 375 407 2702 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27126 m0 *1 36.8,242.08
X$27126 407 2715 375 407 2716 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27127 r0 *1 37.72,236.64
X$27127 375 2654 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $27128 m0 *1 40.48,242.08
X$27128 407 2705 375 407 2717 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27133 r0 *1 43.24,236.64
X$27133 407 2671 375 407 2758 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27134 m0 *1 44.16,242.08
X$27134 407 2706 375 407 2718 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27135 r0 *1 46.92,236.64
X$27135 407 2175 407 375 2598 375 sky130_fd_sc_hd__buf_4
* cell instance $27139 r0 *1 53.36,236.64
X$27139 407 2672 375 407 2721 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27145 m0 *1 57.96,242.08
X$27145 407 2707 375 407 2696 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27664 m0 *1 1.38,247.52
X$27664 407 2731 375 407 2700 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27665 r0 *1 3.22,242.08
X$27665 407 2708 375 407 2733 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27667 m0 *1 5.98,247.52
X$27667 375 2722 2732 2748 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $27669 r0 *1 8.74,242.08
X$27669 407 2710 2598 2882 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $27671 r0 *1 10.12,242.08
X$27671 407 2373 2201 2734 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $27672 r0 *1 11.5,242.08
X$27672 407 2701 407 2727 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $27674 m0 *1 12.42,247.52
X$27674 407 2733 2201 2744 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $27675 m0 *1 13.8,247.52
X$27675 375 2599 2712 2652 2723 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $27683 r0 *1 18.86,242.08
X$27683 407 2699 407 2715 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $27684 r0 *1 22.54,242.08
X$27684 407 2719 407 2706 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $27685 m0 *1 23,247.52
X$27685 407 2355 2724 2725 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $27686 m0 *1 24.38,247.52
X$27686 375 2725 2726 2355 2201 2494 2751 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $27690 r0 *1 28.52,242.08
X$27690 407 2451 2598 2739 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $27692 m0 *1 29.44,247.52
X$27692 407 2773 375 407 2735 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27693 r0 *1 29.9,242.08
X$27693 407 2727 375 407 2769 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27696 m0 *1 33.58,247.52
X$27696 407 2728 2739 2729 2752 375 407 2753 375 sky130_fd_sc_hd__a31oi_1
* cell instance $27697 r0 *1 34.04,242.08
X$27697 407 2165 407 375 2599 375 sky130_fd_sc_hd__buf_4
* cell instance $27698 m0 *1 35.88,247.52
X$27698 407 2749 2201 2728 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $27702 m0 *1 38.64,247.52
X$27702 407 952 2730 2729 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $27704 r0 *1 39.1,242.08
X$27704 407 2736 375 407 2720 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $27705 m0 *1 40.94,247.52
X$27705 407 2730 920 2740 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $27713 r0 *1 44.16,242.08
X$27713 375 2599 2736 2654 2738 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $27714 m0 *1 45.08,247.52
X$27714 375 2738 2736 2749 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $27717 m0 *1 51.52,247.52
X$27717 407 2737 375 407 2583 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28242 r0 *1 1.38,247.52
X$28242 375 2639 2732 2652 2722 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28244 r0 *1 12.42,247.52
X$28244 407 2763 2724 2745 2750 375 2723 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $28251 r0 *1 17.02,247.52
X$28251 407 2724 2746 2598 2355 2712 407 2745 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $28253 r0 *1 20.7,247.52
X$28253 407 2742 407 2705 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $28254 r0 *1 24.38,247.52
X$28254 375 2599 2355 2654 2751 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28255 r0 *1 33.58,247.52
X$28255 375 2599 2749 2654 2753 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28264 r0 *1 50.14,247.52
X$28264 375 2599 2737 2755 2754 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28560 m0 *1 2.76,252.96
X$28560 407 2759 375 407 2761 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28561 m0 *1 6.44,252.96
X$28561 407 2732 375 407 2756 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $28563 m0 *1 10.58,252.96
X$28563 407 2761 2201 2750 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $28564 m0 *1 11.96,252.96
X$28564 407 2762 2763 2747 2748 2744 407 2772 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $28565 m0 *1 15.18,252.96
X$28565 407 2757 407 2773 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $28566 m0 *1 18.86,252.96
X$28566 407 2762 2763 2598 2748 375 2747 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $28567 m0 *1 21.62,252.96
X$28567 375 2746 2763 2355 2712 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $28570 m0 *1 25.3,252.96
X$28570 407 2765 2766 2764 375 407 2726 375 sky130_fd_sc_hd__a21oi_1
* cell instance $28572 m0 *1 27.6,252.96
X$28572 407 2175 2766 2765 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $28576 m0 *1 34.04,252.96
X$28576 407 2774 2729 2752 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $28580 m0 *1 40.48,252.96
X$28580 407 2740 407 375 2766 375 sky130_fd_sc_hd__buf_4
* cell instance $28584 m0 *1 51.52,252.96
X$28584 375 2754 2737 2873 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $28813 r0 *1 1.84,252.96
X$28813 407 2771 407 2759 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $28815 r0 *1 6.44,252.96
X$28815 375 2782 2777 2760 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $28818 r0 *1 11.96,252.96
X$28818 407 2763 2724 2760 2748 2598 407 2786 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $28823 r0 *1 15.64,252.96
X$28823 375 2599 2748 2652 2772 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28824 r0 *1 24.84,252.96
X$28824 407 2729 2764 2724 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $28828 r0 *1 34.04,252.96
X$28828 375 2774 2790 2704 2749 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $28829 r0 *1 38.64,252.96
X$28829 375 2791 2767 2768 2201 2769 2775 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $28835 r0 *1 44.16,252.96
X$28835 375 2599 2768 2755 2775 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $28837 r0 *1 54.28,252.96
X$28837 375 2599 2814 2755 2685 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29133 m0 *1 1.84,258.4
X$29133 375 2639 2777 2784 2782 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29135 m0 *1 11.96,258.4
X$29135 407 2778 2762 2598 2783 375 2787 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $29136 m0 *1 14.72,258.4
X$29136 375 2599 2760 2784 2785 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29138 m0 *1 24.84,258.4
X$29138 375 2765 2779 2808 2805 2704 2598 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $29144 m0 *1 35.88,258.4
X$29144 407 2704 2749 2789 2780 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $29145 m0 *1 37.72,258.4
X$29145 407 2768 2781 2791 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $29146 m0 *1 39.1,258.4
X$29146 407 2765 2766 2780 375 407 2767 375 sky130_fd_sc_hd__a21oi_1
* cell instance $29150 m0 *1 44.16,258.4
X$29150 407 2799 2781 2811 2698 375 2810 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $29160 m0 *1 66.7,258.4
X$29160 407 2788 407 375 2291 375 sky130_fd_sc_hd__inv_1
* cell instance $29385 r0 *1 5.52,258.4
X$29385 407 2777 375 407 2793 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29386 r0 *1 9.2,258.4
X$29386 407 2741 407 2796 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $29387 r0 *1 12.88,258.4
X$29387 375 2760 2778 2748 2763 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $29392 r0 *1 15.64,258.4
X$29392 407 2778 2724 2734 2786 375 2785 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $29395 r0 *1 20.7,258.4
X$29395 407 2783 2748 2760 2763 407 2807 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $29398 r0 *1 25.3,258.4
X$29398 407 2704 2729 2805 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29400 r0 *1 27.14,258.4
X$29400 375 2599 2704 2784 2808 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29401 r0 *1 36.34,258.4
X$29401 407 2789 2790 2799 2764 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $29403 r0 *1 39.1,258.4
X$29403 407 2729 2780 2781 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29404 r0 *1 40.48,258.4
X$29404 375 2801 2799 2768 2802 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $29409 r0 *1 43.24,258.4
X$29409 407 2781 2801 2598 2768 2802 407 2811 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $29412 r0 *1 47.84,258.4
X$29412 375 2599 2802 2755 2810 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29414 r0 *1 60.72,258.4
X$29414 407 2814 375 407 2792 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29709 m0 *1 3.22,263.84
X$29709 407 2795 375 407 2817 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29710 m0 *1 6.9,263.84
X$29710 375 2803 2795 2783 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $29711 m0 *1 11.04,263.84
X$29711 407 2783 2762 2778 2818 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $29712 m0 *1 12.88,263.84
X$29712 375 2639 2783 2784 2797 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29715 m0 *1 23.46,263.84
X$29715 407 2806 375 407 2779 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29716 m0 *1 27.14,263.84
X$29716 407 2729 2798 2762 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29721 m0 *1 36.8,263.84
X$29721 407 2799 2780 2798 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $29723 m0 *1 39.56,263.84
X$29723 407 2780 2800 2809 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29726 m0 *1 43.24,263.84
X$29726 375 2599 2801 2755 2828 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29727 m0 *1 52.44,263.84
X$29727 375 2812 2813 2802 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $29731 m0 *1 64.4,263.84
X$29731 407 2815 407 375 2306 375 sky130_fd_sc_hd__inv_1
* cell instance $29735 m0 *1 70.84,263.84
X$29735 375 2588 2196 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $29957 r0 *1 2.76,263.84
X$29957 375 2639 2795 2784 2803 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29960 m0 *1 4.6,269.28
X$29960 407 2835 375 407 2743 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29961 m0 *1 8.28,269.28
X$29961 407 2816 407 2821 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $29962 r0 *1 11.96,263.84
X$29962 407 2819 2201 2818 407 2820 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $29963 m0 *1 11.96,269.28
X$29963 407 2831 407 2806 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $29964 r0 *1 13.8,263.84
X$29964 407 2787 2820 2797 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29971 m0 *1 16.1,269.28
X$29971 407 2826 375 407 2829 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29973 r0 *1 18.4,263.84
X$29973 407 2821 375 407 2822 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29974 m0 *1 19.78,269.28
X$29974 375 2196 2784 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $29975 r0 *1 22.08,263.84
X$29975 375 2639 2826 2784 2836 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $29978 m0 *1 30.36,269.28
X$29978 407 2789 407 375 2838 375 sky130_fd_sc_hd__inv_1
* cell instance $29980 r0 *1 31.74,263.84
X$29980 407 2729 2823 2201 2822 2864 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $29982 r0 *1 34.04,263.84
X$29982 407 2789 2790 2823 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $29984 r0 *1 35.42,263.84
X$29984 407 2729 2823 2827 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $29985 r0 *1 36.8,263.84
X$29985 407 2768 2801 2827 2824 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $29986 m0 *1 37.26,269.28
X$29986 407 2765 2766 2832 375 407 2825 375 sky130_fd_sc_hd__a21oi_1
* cell instance $29987 r0 *1 38.64,263.84
X$29987 375 2824 2825 2801 2201 2254 2828 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $29988 m0 *1 39.1,269.28
X$29988 407 2789 2790 2768 2832 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $29999 r0 *1 46.46,263.84
X$29999 407 2768 2801 2802 2800 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $30000 m0 *1 46.92,269.28
X$30000 375 2599 2833 2755 2839 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30003 r0 *1 50.6,263.84
X$30003 407 2755 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $30004 r0 *1 51.98,263.84
X$30004 375 2196 2755 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $30007 m0 *1 57.04,269.28
X$30007 407 2813 375 407 2840 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30031 m0 *1 86.02,269.28
X$30031 407 2842 407 375 2841 375 sky130_fd_sc_hd__inv_1
* cell instance $30528 m0 *1 1.38,274.72
X$30528 407 2833 375 407 2868 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $30530 r0 *1 2.76,269.28
X$30530 375 2639 2835 2784 2834 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30531 m0 *1 5.06,274.72
X$30531 375 2834 2835 2847 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $30532 m0 *1 9.2,274.72
X$30532 375 2639 2847 2784 2857 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30543 r0 *1 19.78,269.28
X$30543 407 2784 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $30547 r0 *1 22.54,269.28
X$30547 407 2766 2355 2746 2809 407 2860 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $30549 r0 *1 24.84,269.28
X$30549 375 2836 2826 2789 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $30550 m0 *1 24.84,274.72
X$30550 375 2860 2849 2746 2201 2850 2862 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $30552 r0 *1 28.98,269.28
X$30552 407 2729 2355 2809 375 407 2837 375 sky130_fd_sc_hd__a21oi_1
* cell instance $30553 m0 *1 29.44,274.72
X$30553 407 2765 2837 2849 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $30556 r0 *1 31.74,269.28
X$30556 375 2639 2789 2784 2863 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30557 m0 *1 32.66,274.72
X$30557 407 2864 2838 2851 375 407 2863 375 sky130_fd_sc_hd__a21oi_1
* cell instance $30558 m0 *1 34.5,274.72
X$30558 407 2790 2729 2872 407 2851 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $30561 m0 *1 37.72,274.72
X$30561 375 2639 2866 2784 2865 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30571 r0 *1 48.3,269.28
X$30571 375 2839 2833 2801 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $30573 r0 *1 52.44,269.28
X$30573 375 2599 2813 2755 2812 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $30579 m0 *1 59.34,274.72
X$30579 407 2888 375 407 2830 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31098 r0 *1 3.22,274.72
X$31098 407 2881 375 407 2844 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31101 r0 *1 8.28,274.72
X$31101 407 2844 2598 2846 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $31102 r0 *1 9.66,274.72
X$31102 407 2846 2845 2857 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $31103 r0 *1 11.04,274.72
X$31103 407 2847 2201 2845 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $31112 r0 *1 17.94,274.72
X$31112 407 2796 375 407 2848 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31113 r0 *1 21.62,274.72
X$31113 407 2848 2201 2861 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $31116 r0 *1 27.14,274.72
X$31116 375 2639 2746 2784 2862 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31118 r0 *1 37.26,274.72
X$31118 407 2233 2201 2852 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $31119 r0 *1 38.64,274.72
X$31119 375 2865 2866 2768 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $31129 r0 *1 53.82,274.72
X$31129 375 2599 2392 2755 2867 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31131 r0 *1 63.48,274.72
X$31131 407 2345 375 407 2843 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31336 r0 *1 490.36,274.72
X$31336 407 2855 375 407 2907 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31416 r0 *1 661.48,274.72
X$31416 407 2854 375 407 2853 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31423 r0 *1 668.38,274.72
X$31423 407 2858 375 407 2859 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31428 m0 *1 1.84,280.16
X$31428 407 2869 407 2881 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $31431 m0 *1 12.88,280.16
X$31431 375 2886 2870 2883 2871 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31433 m0 *1 23,280.16
X$31433 407 2884 375 407 2850 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31439 m0 *1 31.74,280.16
X$31439 407 2201 2729 2872 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $31442 m0 *1 35.42,280.16
X$31442 407 2905 375 407 2730 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31450 m0 *1 57.04,280.16
X$31450 375 2867 2392 2887 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $31665 m0 *1 654.12,280.16
X$31665 407 2004 2875 2885 2904 375 2902 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $31671 m0 *1 664.24,280.16
X$31671 375 2900 2877 2875 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $31673 m0 *1 670.22,280.16
X$31673 407 2878 375 407 2896 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31674 m0 *1 673.9,280.16
X$31674 407 2877 375 407 2917 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31679 m0 *1 3.68,285.6
X$31679 407 2889 407 2899 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $31682 m0 *1 7.36,285.6
X$31682 407 2899 375 407 2819 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31684 r0 *1 8.28,280.16
X$31684 407 2870 375 407 2890 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31688 m0 *1 12.42,285.6
X$31688 375 2639 2658 2883 2923 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31695 r0 *1 15.64,280.16
X$31695 375 2871 2870 2746 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $31698 r0 *1 21.62,280.16
X$31698 375 2639 2681 2883 2903 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31701 m0 *1 24.84,285.6
X$31701 375 2903 2681 2933 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $31705 m0 *1 30.82,285.6
X$31705 407 2599 407 375 2886 375 sky130_fd_sc_hd__buf_4
* cell instance $31707 r0 *1 31.28,280.16
X$31707 407 2866 375 407 2931 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $31711 m0 *1 36.34,285.6
X$31711 407 2729 2798 2807 2892 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $31713 r0 *1 37.26,280.16
X$31713 407 2599 407 375 2639 375 sky130_fd_sc_hd__buf_4
* cell instance $31715 m0 *1 38.64,285.6
X$31715 407 2873 2891 2913 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $31718 m0 *1 40.48,285.6
X$31718 407 2891 2892 2598 2873 375 2908 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $31724 m0 *1 43.24,285.6
X$31724 407 2891 2892 2908 2873 2852 407 2910 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $31727 r0 *1 45.54,280.16
X$31727 375 2599 2873 2755 2910 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31729 m0 *1 47.38,285.6
X$31729 375 2599 2914 2755 2957 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31730 r0 *1 54.74,280.16
X$31730 375 2599 2888 2755 2911 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $31732 m0 *1 57.04,285.6
X$31732 375 2911 2888 2914 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $32089 r0 *1 488.52,280.16
X$32089 407 2907 407 375 2909 375 sky130_fd_sc_hd__inv_1
* cell instance $32114 r0 *1 518.42,280.16
X$32114 407 2856 375 407 2906 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32136 r0 *1 542.8,280.16
X$32136 407 2874 375 407 2935 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32231 r0 *1 653.66,280.16
X$32231 375 2876 2875 2929 2902 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32232 m0 *1 653.66,285.6
X$32232 407 2875 1687 2004 2904 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $32233 m0 *1 655.5,285.6
X$32233 407 2709 2875 2943 1687 375 2901 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $32235 m0 *1 658.72,285.6
X$32235 407 2893 1340 2885 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $32237 r0 *1 662.86,280.16
X$32237 375 2876 2877 2929 2900 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32239 m0 *1 664.24,285.6
X$32239 407 2898 375 407 2893 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32245 m0 *1 670.68,285.6
X$32245 407 2947 407 2898 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32248 r0 *1 673.44,280.16
X$32248 407 2894 375 407 2975 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32249 m0 *1 674.36,285.6
X$32249 407 2897 407 2916 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32253 r0 *1 1.84,285.6
X$32253 375 2639 2731 2883 2919 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32255 r0 *1 11.5,285.6
X$32255 407 2921 407 2884 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32263 r0 *1 23.46,285.6
X$32263 407 2967 2766 2927 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $32265 r0 *1 25.3,285.6
X$32265 407 2912 2807 2798 2913 375 2928 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $32266 r0 *1 27.6,285.6
X$32266 407 2798 2807 2913 2912 2930 407 375 375 sky130_fd_sc_hd__or4_1
* cell instance $32267 r0 *1 30.36,285.6
X$32267 375 3086 2729 2764 2807 2913 407 407 375 sky130_fd_sc_hd__nor4_2
* cell instance $32268 r0 *1 34.96,285.6
X$32268 407 2729 2764 2807 2934 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $32269 r0 *1 36.8,285.6
X$32269 407 2764 2807 2942 407 375 375 sky130_fd_sc_hd__or2_2
* cell instance $32271 r0 *1 40.02,285.6
X$32271 407 2873 2891 2936 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $32278 r0 *1 45.08,285.6
X$32278 407 2892 2915 2914 2598 375 2956 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $32280 r0 *1 48.76,285.6
X$32280 407 2887 2915 2914 2934 407 2937 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $32282 r0 *1 51.98,285.6
X$32282 375 2914 2891 2915 2887 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $32516 r0 *1 545.56,285.6
X$32516 407 2935 407 375 2932 375 sky130_fd_sc_hd__inv_1
* cell instance $32567 r0 *1 654.12,285.6
X$32567 375 2876 2924 2929 2989 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32573 r0 *1 666.08,285.6
X$32573 407 2925 375 407 2918 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32574 r0 *1 669.76,285.6
X$32574 407 2916 375 407 2922 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32576 r0 *1 673.9,285.6
X$32576 407 3000 407 2920 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32578 m0 *1 1.38,291.04
X$32578 407 2689 375 407 3014 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32580 m0 *1 5.52,291.04
X$32580 375 2919 2731 2949 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $32583 m0 *1 11.96,291.04
X$32583 375 2658 2923 2950 2939 2938 2882 407 407 375 sky130_fd_sc_hd__o311ai_0
* cell instance $32584 m0 *1 15.18,291.04
X$32584 407 2939 2938 2658 2201 2950 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $32585 m0 *1 17.94,291.04
X$32585 407 2951 2953 2940 2952 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $32586 m0 *1 19.78,291.04
X$32586 407 2766 2928 2939 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $32587 m0 *1 21.16,291.04
X$32587 407 2766 2928 3037 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $32588 m0 *1 23.46,291.04
X$32588 407 2930 2941 2927 2953 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $32589 m0 *1 25.3,291.04
X$32589 407 2765 2766 2930 375 407 3051 375 sky130_fd_sc_hd__a21oi_1
* cell instance $32590 m0 *1 27.14,291.04
X$32590 407 2930 2941 2766 407 2954 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $32595 m0 *1 37.72,291.04
X$32595 407 2942 2913 2766 407 2955 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $32598 m0 *1 45.08,291.04
X$32598 407 2892 2914 2956 2915 2986 407 2957 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $32599 m0 *1 48.3,291.04
X$32599 407 2934 2914 2598 2915 2887 407 2958 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $32818 m0 *1 646.3,291.04
X$32818 375 2876 2943 2929 2926 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32819 m0 *1 655.5,291.04
X$32819 407 2004 2943 1687 2875 2924 407 2988 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $32820 m0 *1 658.72,291.04
X$32820 407 2709 2943 2944 2875 2901 407 2926 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $32823 m0 *1 664.24,291.04
X$32823 375 2876 2894 2929 2945 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $32825 m0 *1 674.36,291.04
X$32825 407 2999 407 2948 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32827 r0 *1 3.22,291.04
X$32827 407 2959 407 2976 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $32828 r0 *1 6.9,291.04
X$32828 407 2976 375 407 2965 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32831 r0 *1 13.34,291.04
X$32831 407 2658 2949 2963 2941 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $32836 r0 *1 15.64,291.04
X$32836 407 2966 375 407 2960 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32837 r0 *1 19.32,291.04
X$32837 375 2196 2883 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $32839 r0 *1 28.98,291.04
X$32839 407 2967 2872 2954 375 407 2940 375 sky130_fd_sc_hd__a21oi_1
* cell instance $32842 r0 *1 35.42,291.04
X$32842 407 2933 2872 2955 375 407 2983 375 sky130_fd_sc_hd__a21oi_1
* cell instance $32844 r0 *1 37.72,291.04
X$32844 407 2765 2766 2942 375 407 2985 375 sky130_fd_sc_hd__a21oi_1
* cell instance $32846 r0 *1 40.02,291.04
X$32846 407 2965 2201 2986 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $32856 r0 *1 48.3,291.04
X$32856 407 2987 2201 2937 407 2971 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $32858 r0 *1 51.06,291.04
X$32858 407 2958 2971 2990 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $32860 r0 *1 52.9,291.04
X$32860 375 2599 2887 2972 2990 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33143 r0 *1 651.82,291.04
X$33143 375 2992 2929 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $33144 r0 *1 661.02,291.04
X$33144 375 2943 2982 2875 2924 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $33145 r0 *1 663.32,291.04
X$33145 407 2922 1340 2944 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33147 r0 *1 665.62,291.04
X$33147 375 2945 2894 2924 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $33152 r0 *1 670.22,291.04
X$33152 407 2920 375 407 2978 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33153 r0 *1 673.9,291.04
X$33153 407 2973 375 407 3023 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33156 m0 *1 1.84,296.48
X$33156 375 2639 2949 2883 2962 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33157 m0 *1 11.04,296.48
X$33157 407 2963 2964 2949 2658 2598 407 2977 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $33159 m0 *1 15.18,296.48
X$33159 407 2980 407 2968 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33161 m0 *1 19.78,296.48
X$33161 375 2886 2967 2883 2952 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33163 m0 *1 29.44,296.48
X$33163 407 2968 375 407 2970 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33167 m0 *1 38.18,296.48
X$33167 407 2984 375 407 2987 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33168 m0 *1 41.86,296.48
X$33168 375 2969 2985 2915 2201 2970 3010 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $33208 m0 *1 145.82,296.48
X$33208 375 2523 2588 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $33390 m0 *1 649.06,296.48
X$33390 407 2982 2004 2991 2988 375 2989 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33391 m0 *1 651.82,296.48
X$33391 375 2929 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $33394 m0 *1 664.24,296.48
X$33394 375 2981 2973 2943 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $33397 m0 *1 670.68,296.48
X$33397 407 2948 375 407 2979 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33398 m0 *1 674.36,296.48
X$33398 407 2879 407 3002 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33400 r0 *1 1.84,296.48
X$33400 407 3015 407 3001 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33401 r0 *1 5.52,296.48
X$33401 407 3001 375 407 3004 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33402 r0 *1 9.2,296.48
X$33402 407 2994 2964 3027 2977 375 2962 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33404 r0 *1 12.42,296.48
X$33404 407 2941 407 375 2994 375 sky130_fd_sc_hd__inv_1
* cell instance $33405 r0 *1 13.8,296.48
X$33405 407 3004 2201 2951 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33410 r0 *1 15.64,296.48
X$33410 407 2961 407 2984 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33411 r0 *1 19.32,296.48
X$33411 375 2883 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $33412 r0 *1 24.38,296.48
X$33412 375 3005 3006 2967 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $33415 r0 *1 34.04,296.48
X$33415 407 2936 2934 2983 2933 3031 407 3007 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $33418 r0 *1 41.4,296.48
X$33418 407 2915 2934 2969 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $33425 r0 *1 44.62,296.48
X$33425 375 2599 2915 2995 3010 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33705 r0 *1 646.3,296.48
X$33705 407 3022 2709 3030 2996 3011 407 3032 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $33709 r0 *1 652.28,296.48
X$33709 407 2982 2709 1687 2997 375 2998 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33710 r0 *1 655.04,296.48
X$33710 407 2982 2709 3008 2997 2998 407 3009 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $33711 r0 *1 658.26,296.48
X$33711 407 2978 1340 2991 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33712 r0 *1 659.64,296.48
X$33712 407 2979 1340 3008 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33715 r0 *1 662.4,296.48
X$33715 375 2876 2973 2929 2981 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33719 r0 *1 671.6,296.48
X$33719 407 2880 407 3003 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33724 m0 *1 2.3,301.92
X$33724 407 3056 407 3025 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33725 m0 *1 5.98,301.92
X$33725 407 3025 375 407 3016 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33726 m0 *1 9.66,301.92
X$33726 407 3016 2201 3027 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33730 m0 *1 16.1,301.92
X$33730 375 2886 3006 2883 3005 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33731 m0 *1 25.3,301.92
X$33731 407 3018 375 407 3020 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33735 m0 *1 30.82,301.92
X$33735 407 3020 2201 3031 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33736 m0 *1 32.2,301.92
X$33736 375 2639 2933 2883 3007 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33737 m0 *1 41.4,301.92
X$33737 375 2599 2966 2995 3021 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33738 m0 *1 50.6,301.92
X$33738 375 3021 2966 2915 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $33952 m0 *1 640.32,301.92
X$33952 375 2876 2996 2929 3032 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33953 m0 *1 649.52,301.92
X$33953 407 3022 2709 1687 2996 375 3011 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33954 m0 *1 652.28,301.92
X$33954 407 3028 1340 3030 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33956 m0 *1 654.58,301.92
X$33956 375 2876 2997 3029 3009 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $33959 m0 *1 664.7,301.92
X$33959 407 3026 375 407 3028 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33962 m0 *1 670.68,301.92
X$33962 407 3024 407 3046 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33963 m0 *1 674.36,301.92
X$33963 407 3095 375 407 3044 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33966 r0 *1 4.14,301.92
X$33966 407 3068 375 407 3082 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33967 r0 *1 7.82,301.92
X$33967 407 3006 375 407 3034 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $33968 r0 *1 11.5,301.92
X$33968 407 3013 407 3018 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $33973 r0 *1 15.64,301.92
X$33973 407 3036 3035 3017 2938 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $33975 r0 *1 19.32,301.92
X$33975 407 3017 3037 2598 3036 375 3058 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33977 r0 *1 23,301.92
X$33977 407 3037 3019 2861 3050 375 3074 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $33979 r0 *1 26.22,301.92
X$33979 407 3019 3051 3050 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $33992 r0 *1 51.52,301.92
X$33992 407 3053 407 375 2332 375 sky130_fd_sc_hd__inv_1
* cell instance $34240 r0 *1 575.92,301.92
X$34240 407 3012 1340 3033 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34265 r0 *1 623.76,301.92
X$34265 407 3038 2709 3033 3041 3040 407 3039 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34266 r0 *1 626.98,301.92
X$34266 407 3038 2709 1687 3041 375 3040 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $34269 r0 *1 634.34,301.92
X$34269 407 3038 2004 3055 3041 1687 407 3054 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34277 r0 *1 646.3,301.92
X$34277 407 3022 2004 3052 2996 1687 407 3042 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34281 r0 *1 652.28,301.92
X$34281 375 3043 3022 2997 2982 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $34282 r0 *1 654.58,301.92
X$34282 407 2982 2004 3043 2997 1687 407 3049 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34285 r0 *1 662.4,301.92
X$34285 407 3046 375 407 3048 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34289 r0 *1 666.08,301.92
X$34289 375 3047 3045 2997 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $34291 r0 *1 672.06,301.92
X$34291 407 3066 407 3026 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $34295 m0 *1 2.3,307.36
X$34295 407 2993 407 3068 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $34297 m0 *1 6.44,307.36
X$34297 375 3035 2963 3036 3017 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $34298 m0 *1 8.74,307.36
X$34298 407 2963 2964 3097 3070 375 3096 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $34300 m0 *1 11.96,307.36
X$34300 407 3017 2964 3035 3036 2598 407 3070 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34302 m0 *1 16.1,307.36
X$34302 407 2939 3072 2201 2776 3057 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $34303 m0 *1 18.4,307.36
X$34303 407 3058 3057 3099 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34304 m0 *1 19.78,307.36
X$34304 375 2886 3019 2883 3074 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34309 m0 *1 35.42,307.36
X$34309 407 2892 2933 3059 2936 407 3104 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $34311 m0 *1 38.18,307.36
X$34311 407 2695 2201 3105 407 3062 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $34312 m0 *1 40.02,307.36
X$34312 407 3060 2936 2598 2892 3061 407 3063 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34313 m0 *1 43.24,307.36
X$34313 407 3063 3062 3076 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34317 m0 *1 47.84,307.36
X$34317 407 3079 375 407 3053 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34526 m0 *1 623.76,307.36
X$34526 375 2876 3041 3108 3039 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34527 m0 *1 632.96,307.36
X$34527 407 3038 2004 3055 3041 375 407 3077 375 sky130_fd_sc_hd__and4_1
* cell instance $34529 m0 *1 636.64,307.36
X$34529 407 3075 3054 3077 3078 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $34532 m0 *1 639.86,307.36
X$34532 407 3044 1340 3075 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34533 m0 *1 641.24,307.36
X$34533 375 2876 3052 2929 3064 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34534 m0 *1 650.44,307.36
X$34534 375 3052 3038 2996 3022 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $34535 m0 *1 652.74,307.36
X$34535 407 3065 1340 3102 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34537 m0 *1 654.58,307.36
X$34537 407 3022 2004 3073 3049 375 3101 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $34540 m0 *1 658.72,307.36
X$34540 407 3048 1340 3073 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34541 m0 *1 660.1,307.36
X$34541 407 3071 375 407 3065 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34543 m0 *1 664.24,307.36
X$34543 375 2876 3045 3029 3047 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34544 m0 *1 673.44,307.36
X$34544 407 2974 407 3069 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $34547 r0 *1 2.3,307.36
X$34547 407 3094 375 407 3098 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34548 r0 *1 5.98,307.36
X$34548 407 3080 407 3083 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $34550 r0 *1 10.12,307.36
X$34550 407 3082 2201 3097 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34551 r0 *1 11.5,307.36
X$34551 407 3083 375 407 3084 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34556 r0 *1 15.64,307.36
X$34556 407 3036 3017 3072 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $34557 r0 *1 17.02,307.36
X$34557 375 2639 3036 2883 3099 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34560 r0 *1 31.74,307.36
X$34560 407 2714 3103 3087 3148 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $34562 r0 *1 35.42,307.36
X$34562 407 3084 2201 3104 407 3106 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $34563 r0 *1 37.26,307.36
X$34563 407 2936 3061 2892 3060 407 3105 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $34564 r0 *1 39.56,307.36
X$34564 407 2936 2892 3059 2933 2598 407 3090 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34569 r0 *1 43.24,307.36
X$34569 375 2639 3061 2995 3076 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34844 r0 *1 632.04,307.36
X$34844 375 2876 3055 2929 3078 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34850 r0 *1 645.84,307.36
X$34850 407 3038 2004 3102 3042 375 3064 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $34855 r0 *1 654.12,307.36
X$34855 375 2876 3043 3029 3101 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34862 r0 *1 669.76,307.36
X$34862 407 3067 407 3071 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $34864 r0 *1 673.9,307.36
X$34864 407 3045 375 407 3093 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34868 m0 *1 2.76,312.8
X$34868 407 3081 375 407 3116 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $34870 m0 *1 7.36,312.8
X$34870 375 2639 3035 3130 3096 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $34873 m0 *1 17.94,312.8
X$34873 407 2939 3085 2201 3098 3124 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $34875 m0 *1 21.16,312.8
X$34875 407 3037 3110 2598 3019 3111 407 3135 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34879 m0 *1 27.6,312.8
X$34879 407 3088 3112 2912 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $34882 m0 *1 29.9,312.8
X$34882 407 3112 3086 2598 3088 375 3125 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $34884 m0 *1 33.12,312.8
X$34884 407 3086 3059 2598 2933 3089 407 3103 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $34885 m0 *1 36.34,312.8
X$34885 375 3059 3060 2933 3089 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $34887 m0 *1 40.48,312.8
X$34887 407 3090 3106 3107 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $34888 m0 *1 41.86,312.8
X$34888 375 2639 3059 2995 3107 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35099 m0 *1 626.98,312.8
X$35099 375 2876 3126 3108 3120 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35101 m0 *1 636.64,312.8
X$35101 375 3119 3118 3055 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35105 m0 *1 649.98,312.8
X$35105 375 3117 3091 3052 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35108 m0 *1 659.64,312.8
X$35108 375 3100 3115 3043 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35112 m0 *1 668.84,312.8
X$35112 407 3091 375 407 3092 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35114 m0 *1 674.36,312.8
X$35114 407 3114 407 3095 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $35116 r0 *1 1.84,312.8
X$35116 407 3122 407 3081 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $35117 r0 *1 5.52,312.8
X$35117 407 3109 407 3094 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $35118 r0 *1 9.2,312.8
X$35118 407 2964 3019 3110 2598 375 3132 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $35119 r0 *1 11.96,312.8
X$35119 407 2964 3110 3132 3019 3133 407 3134 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $35124 r0 *1 16.1,312.8
X$35124 407 3123 2201 3113 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $35126 r0 *1 17.94,312.8
X$35126 407 3019 3110 3111 3085 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $35128 r0 *1 20.24,312.8
X$35128 375 2886 3111 2995 3137 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35129 r0 *1 29.44,312.8
X$35129 407 3112 3086 3125 3088 3113 407 3138 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $35130 r0 *1 32.66,312.8
X$35130 407 3086 3089 3059 2933 375 407 3087 375 sky130_fd_sc_hd__and4_1
* cell instance $35131 r0 *1 35.88,312.8
X$35131 407 3061 3089 3059 2933 375 407 3112 375 sky130_fd_sc_hd__and4_1
* cell instance $35136 r0 *1 43.24,312.8
X$35136 375 2995 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $35389 r0 *1 629.28,312.8
X$35389 375 3120 3126 3041 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35390 r0 *1 633.42,312.8
X$35390 375 2876 3118 3108 3119 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35396 r0 *1 645.84,312.8
X$35396 375 3140 3128 2996 1515 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35398 r0 *1 650.44,312.8
X$35398 375 3139 3091 3029 3117 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35399 r0 *1 659.64,312.8
X$35399 375 3139 3115 3029 3100 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35404 r0 *1 671.6,312.8
X$35404 407 3128 375 407 3129 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35409 m0 *1 3.22,318.24
X$35409 407 3121 407 3131 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $35410 m0 *1 6.9,318.24
X$35410 407 3131 375 407 3123 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35411 m0 *1 10.58,318.24
X$35411 407 3116 2201 3133 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $35413 m0 *1 12.42,318.24
X$35413 375 2886 3110 3130 3134 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35415 m0 *1 21.62,318.24
X$35415 407 3135 3124 3137 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $35417 m0 *1 26.68,318.24
X$35417 375 3086 2964 3088 3112 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $35420 m0 *1 29.9,318.24
X$35420 375 2886 3088 2995 3138 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35422 m0 *1 40.94,318.24
X$35422 375 2196 2995 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $35431 m0 *1 63.02,318.24
X$35431 407 3142 375 407 2213 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35661 m0 *1 637.56,318.24
X$35661 407 3126 375 407 3127 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35666 m0 *1 644.46,318.24
X$35666 375 3139 3128 3029 3140 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35668 m0 *1 654.58,318.24
X$35668 375 2992 3029 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $35670 m0 *1 664.24,318.24
X$35670 375 3139 3136 3029 1515 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35673 m0 *1 674.36,318.24
X$35673 407 3115 375 407 3151 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35675 r0 *1 1.84,318.24
X$35675 407 3141 407 3152 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $35676 r0 *1 5.52,318.24
X$35676 407 3152 375 407 3144 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35678 r0 *1 10.12,318.24
X$35678 407 2964 3017 2201 3144 407 3145 375 375 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $35683 r0 *1 17.48,318.24
X$35683 407 3145 3147 3146 375 407 3183 375 sky130_fd_sc_hd__a21oi_1
* cell instance $35685 r0 *1 19.78,318.24
X$35685 407 3111 3019 3110 2964 407 3147 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $35686 r0 *1 22.08,318.24
X$35686 407 3168 2598 3146 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $35691 r0 *1 30.36,318.24
X$35691 375 2886 3089 2995 3148 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35697 r0 *1 43.24,318.24
X$35697 375 2639 3156 2995 3154 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35934 r0 *1 642.16,318.24
X$35934 407 3118 375 407 3150 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35939 r0 *1 652.28,318.24
X$35939 407 3029 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $35940 r0 *1 653.66,318.24
X$35940 375 3139 2925 3029 3155 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35943 r0 *1 666.54,318.24
X$35943 407 3069 375 407 3149 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35944 r0 *1 670.22,318.24
X$35944 407 3002 375 407 3153 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35945 r0 *1 673.9,318.24
X$35945 407 3136 375 407 3160 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35948 r0 *1 1.38,323.68
X$35948 375 2639 3163 3130 3162 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35949 m0 *1 1.84,323.68
X$35949 407 3163 375 407 3169 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35950 m0 *1 5.52,323.68
X$35950 375 3162 3163 3035 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35951 m0 *1 9.66,323.68
X$35951 375 2639 3166 3130 3157 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35953 r0 *1 11.04,323.68
X$35953 375 3157 3166 3019 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35959 r0 *1 16.1,323.68
X$35959 375 2886 3168 3130 3183 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35961 m0 *1 19.78,323.68
X$35961 407 3168 3111 3110 3019 375 407 3017 375 sky130_fd_sc_hd__and4_1
* cell instance $35963 r0 *1 25.3,323.68
X$35963 375 2886 3158 3130 3173 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $35967 m0 *1 29.44,323.68
X$35967 407 3158 375 407 3143 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $35969 r0 *1 34.5,323.68
X$35969 375 3173 3158 3088 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35971 r0 *1 38.64,323.68
X$35971 375 3184 3172 3061 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35978 m0 *1 44.16,323.68
X$35978 375 3154 3156 3059 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $35979 r0 *1 44.16,323.68
X$35979 407 3156 375 407 3170 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36470 r0 *1 636.18,323.68
X$36470 375 3108 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $36471 m0 *1 636.64,323.68
X$36471 375 2992 3108 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $36475 m0 *1 645.84,323.68
X$36475 375 2876 3167 3108 3186 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36480 r0 *1 652.28,323.68
X$36480 375 3139 3159 3029 3185 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36481 m0 *1 655.04,323.68
X$36481 375 3155 2925 3165 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $36487 r0 *1 663.78,323.68
X$36487 407 3003 375 407 3164 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36492 r0 *1 667.46,323.68
X$36492 407 3167 375 407 3182 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36497 r0 *1 673.44,323.68
X$36497 407 3159 375 407 3250 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36503 m0 *1 2.3,329.12
X$36503 407 3166 375 407 3171 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36507 m0 *1 14.26,329.12
X$36507 375 2196 3130 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $36514 m0 *1 30.36,329.12
X$36514 407 3172 375 407 3187 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36516 m0 *1 37.72,329.12
X$36516 375 2886 3172 2995 3184 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36525 m0 *1 57.5,329.12
X$36525 407 3174 375 407 2815 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36776 m0 *1 636.64,329.12
X$36776 375 2876 3177 3108 3176 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36779 m0 *1 645.84,329.12
X$36779 375 3186 3167 3197 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $36782 m0 *1 652.28,329.12
X$36782 407 3177 375 407 3161 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36783 m0 *1 655.96,329.12
X$36783 375 3185 3159 3216 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $36786 m0 *1 664.24,329.12
X$36786 375 3139 3180 3029 3179 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36789 m0 *1 673.44,329.12
X$36789 407 3180 375 407 3191 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $36794 r0 *1 9.66,329.12
X$36794 375 3229 3222 3110 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $36799 r0 *1 15.64,329.12
X$36799 375 3130 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $36802 r0 *1 23,329.12
X$36802 375 2886 3195 3130 3193 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $36804 r0 *1 34.04,329.12
X$36804 375 3215 3217 3089 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $36989 r0 *1 497.72,329.12
X$36989 407 3189 375 407 3237 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37000 r0 *1 518.42,329.12
X$37000 407 3175 375 407 3200 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37046 r0 *1 632.5,329.12
X$37046 375 2876 2878 3108 3199 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37048 r0 *1 641.7,329.12
X$37048 375 3176 3177 3198 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37055 r0 *1 658.72,329.12
X$37055 375 3139 3194 3029 3213 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37057 r0 *1 667.92,329.12
X$37057 375 3179 3180 3194 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37059 r0 *1 672.52,329.12
X$37059 407 3231 375 407 3192 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37066 m0 *1 4.6,334.56
X$37066 375 3202 3208 3036 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37073 m0 *1 15.64,334.56
X$37073 375 2886 3211 3130 3230 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37074 m0 *1 24.84,334.56
X$37074 375 3193 3195 3168 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37077 m0 *1 31.28,334.56
X$37077 375 2886 3217 2995 3215 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37093 m0 *1 71.76,334.56
X$37093 407 3218 375 407 2842 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37340 m0 *1 637.1,334.56
X$37340 375 3199 2878 3219 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37346 m0 *1 647.68,334.56
X$37346 375 2876 3216 3108 3204 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37349 m0 *1 659.18,334.56
X$37349 407 3205 3214 3210 3194 3212 407 3213 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $37354 m0 *1 665.16,334.56
X$37354 407 3206 375 407 3233 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37358 m0 *1 670.68,334.56
X$37358 407 3192 3209 3210 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $37359 m0 *1 672.06,334.56
X$37359 407 3190 407 3206 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $37362 r0 *1 1.38,334.56
X$37362 375 2639 3208 3130 3202 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37364 r0 *1 11.5,334.56
X$37364 407 3222 375 407 3221 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37369 r0 *1 18.4,334.56
X$37369 375 3230 3211 3111 2195 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37371 r0 *1 23,334.56
X$37371 407 3195 375 407 3220 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37373 r0 *1 27.6,334.56
X$37373 407 3217 375 407 3188 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37560 r0 *1 497.72,334.56
X$37560 407 3237 407 375 3238 375 sky130_fd_sc_hd__inv_1
* cell instance $37565 r0 *1 508.3,334.56
X$37565 407 3196 375 407 3241 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37569 r0 *1 515.2,334.56
X$37569 407 3200 407 375 3239 375 sky130_fd_sc_hd__inv_1
* cell instance $37571 r0 *1 520.26,334.56
X$37571 407 3203 375 407 3278 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37616 r0 *1 635.72,334.56
X$37616 375 2876 3197 3108 3236 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37618 r0 *1 644.92,334.56
X$37618 407 3223 3214 3313 3235 375 3236 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $37624 r0 *1 653.2,334.56
X$37624 407 3149 3209 3235 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $37625 r0 *1 654.58,334.56
X$37625 407 3223 3214 3226 3216 3234 407 3275 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $37626 r0 *1 657.8,334.56
X$37626 407 3164 3209 3225 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $37628 r0 *1 659.64,334.56
X$37628 407 3205 3214 3234 3194 375 3212 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $37629 r0 *1 662.4,334.56
X$37629 407 3233 3209 3246 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $37635 r0 *1 673.9,334.56
X$37635 407 3207 407 3231 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $37638 m0 *1 3.22,340
X$37638 407 3208 375 407 3240 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37640 m0 *1 8.74,340
X$37640 375 2639 3222 3130 3229 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37645 m0 *1 19.32,340
X$37645 407 3211 375 407 3201 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37664 m0 *1 62.56,340
X$37664 407 3232 375 407 2788 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37915 m0 *1 636.64,340
X$37915 375 2876 3243 3108 3242 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37920 m0 *1 648.6,340
X$37920 407 3223 3254 3234 3216 375 3244 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $37921 m0 *1 651.36,340
X$37921 407 3223 3254 3224 3216 3244 407 3204 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $37922 m0 *1 654.58,340
X$37922 375 2876 3226 3029 3253 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37924 m0 *1 664.24,340
X$37924 375 3252 3247 3226 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $37928 m0 *1 669.3,340
X$37928 407 3248 3209 3224 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $37929 m0 *1 670.68,340
X$37929 407 3251 375 407 3248 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37930 m0 *1 674.36,340
X$37930 407 3267 407 3251 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $37932 r0 *1 3.22,340
X$37932 375 2639 3263 3261 3268 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $37939 r0 *1 17.94,340
X$37939 407 3270 375 407 3271 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37942 r0 *1 24.38,340
X$37942 375 2886 3274 2972 3291 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38065 r0 *1 334.42,340
X$38065 375 2582 2523 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $38134 r0 *1 509.22,340
X$38134 407 3241 407 375 3279 375 sky130_fd_sc_hd__inv_1
* cell instance $38135 r0 *1 510.6,340
X$38135 407 3278 407 375 3264 375 sky130_fd_sc_hd__inv_1
* cell instance $38183 r0 *1 630.2,340
X$38183 375 2876 3256 3273 3265 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38187 r0 *1 641.7,340
X$38187 407 3214 3256 3225 3277 375 3265 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $38188 r0 *1 644.46,340
X$38188 375 3242 3243 3255 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $38194 r0 *1 652.74,340
X$38194 375 3226 3245 3216 3223 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $38195 r0 *1 655.04,340
X$38195 407 3245 3214 3246 3275 375 3253 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $38197 r0 *1 661.48,340
X$38197 407 3153 3209 3416 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $38198 r0 *1 662.86,340
X$38198 375 3139 3247 3273 3252 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38201 r0 *1 672.52,340
X$38201 407 3243 375 407 3249 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38206 m0 *1 3.22,345.44
X$38206 375 3268 3263 3288 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $38209 m0 *1 8.74,345.44
X$38209 375 2639 3290 3261 3289 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38213 m0 *1 18.86,345.44
X$38213 375 3272 3283 3271 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $38216 m0 *1 25.3,345.44
X$38216 407 3274 375 407 3262 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38486 m0 *1 644,345.44
X$38486 375 3198 3223 3256 3197 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $38490 m0 *1 651.36,345.44
X$38490 407 3245 3254 3234 3255 375 3276 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $38501 m0 *1 672.52,345.44
X$38501 407 3269 375 407 3266 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38503 r0 *1 1.38,345.44
X$38503 407 3281 375 407 3288 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38505 r0 *1 5.98,345.44
X$38505 407 3257 407 3270 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $38506 r0 *1 9.66,345.44
X$38506 375 3289 3263 3290 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $38513 r0 *1 17.02,345.44
X$38513 375 2886 3283 3261 3272 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38514 r0 *1 26.22,345.44
X$38514 375 3291 3283 3274 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $38518 r0 *1 35.42,345.44
X$38518 407 2972 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $38762 r0 *1 640.78,345.44
X$38762 375 2876 3255 3273 3284 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38765 r0 *1 650.9,345.44
X$38765 407 3245 3254 3293 3255 3276 407 3284 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $38766 r0 *1 654.12,345.44
X$38766 407 3255 3245 3294 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $38767 r0 *1 656.42,345.44
X$38767 407 3294 3254 3319 3285 3234 407 3311 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $38770 r0 *1 661.94,345.44
X$38770 407 3321 3209 3292 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $38771 r0 *1 663.32,345.44
X$38771 375 3139 3269 3273 3306 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38773 r0 *1 672.52,345.44
X$38773 407 3247 375 407 3303 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38777 m0 *1 1.38,350.88
X$38777 407 3280 407 3281 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $38779 m0 *1 5.52,350.88
X$38779 407 3290 375 407 3296 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38782 m0 *1 10.58,350.88
X$38782 375 2886 3305 3261 3304 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $38791 m0 *1 33.58,350.88
X$38791 407 3307 375 407 3308 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $38792 m0 *1 37.26,350.88
X$38792 375 2886 3312 2972 3309 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39058 m0 *1 643.54,350.88
X$39058 407 3256 3372 3277 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $39059 m0 *1 644.92,350.88
X$39059 407 3197 3298 3350 375 407 3313 375 sky130_fd_sc_hd__a21oi_1
* cell instance $39060 m0 *1 646.76,350.88
X$39060 407 3273 407 375 375 sky130_fd_sc_hd__clkinvlp_4
* cell instance $39061 m0 *1 649.52,350.88
X$39061 375 2992 3273 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $39062 m0 *1 658.72,350.88
X$39062 407 3205 3254 3292 3311 375 3310 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $39063 m0 *1 661.48,350.88
X$39063 407 3300 3209 3293 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $39067 m0 *1 664.7,350.88
X$39067 375 3306 3269 3319 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39072 m0 *1 673.44,350.88
X$39072 407 3301 375 407 3300 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39076 r0 *1 3.68,350.88
X$39076 407 3341 375 407 3316 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39077 r0 *1 7.36,350.88
X$39077 407 3295 407 3364 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39078 r0 *1 11.04,350.88
X$39078 375 3304 3305 3316 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39082 r0 *1 16.56,350.88
X$39082 375 3325 3305 3317 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39086 r0 *1 23.92,350.88
X$39086 375 2886 3326 2972 3344 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39088 r0 *1 33.58,350.88
X$39088 375 2196 2972 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $39091 r0 *1 43.24,350.88
X$39091 375 3309 3312 3308 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39324 r0 *1 629.28,350.88
X$39324 375 2876 3334 3273 3318 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39325 r0 *1 638.48,350.88
X$39325 375 2876 3198 3273 3328 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39330 r0 *1 650.44,350.88
X$39330 407 3255 3245 3327 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $39331 r0 *1 651.82,350.88
X$39331 407 3294 3214 3347 3285 3320 407 3348 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $39332 r0 *1 655.04,350.88
X$39332 375 3319 3205 3285 3294 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $39333 r0 *1 657.34,350.88
X$39333 375 3139 3319 3273 3310 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39336 r0 *1 670.22,350.88
X$39336 407 3322 375 407 3321 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39337 r0 *1 673.9,350.88
X$39337 407 3302 407 3301 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39340 m0 *1 1.84,356.32
X$39340 407 3314 407 3341 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39341 m0 *1 5.52,356.32
X$39341 375 3340 3339 3342 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39344 m0 *1 11.04,356.32
X$39344 407 3317 375 407 3329 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39347 m0 *1 14.72,356.32
X$39347 375 2886 3317 3261 3325 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39349 m0 *1 24.84,356.32
X$39349 375 3344 3326 3345 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39351 m0 *1 29.44,356.32
X$39351 375 2886 3331 2972 3368 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39353 m0 *1 39.56,356.32
X$39353 375 2886 3332 2972 3346 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39613 m0 *1 637.1,356.32
X$39613 375 3318 3334 3256 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39617 m0 *1 642.16,356.32
X$39617 407 3256 3198 3336 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $39618 m0 *1 643.54,356.32
X$39618 407 3254 3198 3371 3256 3351 407 3328 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $39620 m0 *1 647.22,356.32
X$39620 407 3335 3336 3333 407 3350 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $39623 m0 *1 650.44,356.32
X$39623 407 3285 3298 3349 375 407 3347 375 sky130_fd_sc_hd__a21oi_1
* cell instance $39624 m0 *1 652.28,356.32
X$39624 375 2876 3285 3358 3348 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39626 m0 *1 662.4,356.32
X$39626 407 3383 3209 3320 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $39628 m0 *1 664.24,356.32
X$39628 375 3139 3343 3273 3178 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39632 m0 *1 674.36,356.32
X$39632 407 3324 407 3322 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39634 r0 *1 1.84,356.32
X$39634 375 2639 3342 3261 3340 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39636 r0 *1 11.5,356.32
X$39636 407 3364 375 407 3365 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39641 r0 *1 17.02,356.32
X$39641 407 3330 407 3307 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39642 r0 *1 20.7,356.32
X$39642 407 3385 375 407 3345 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39645 r0 *1 26.68,356.32
X$39645 407 3331 375 407 3354 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39646 r0 *1 30.36,356.32
X$39646 375 3368 3326 3331 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39649 r0 *1 36.8,356.32
X$39649 407 3332 375 407 3353 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39654 r0 *1 43.24,356.32
X$39654 375 3346 3312 3332 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39886 r0 *1 628.36,356.32
X$39886 375 3373 3356 3355 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39888 r0 *1 634.34,356.32
X$39888 407 3234 3333 3357 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $39893 r0 *1 643.54,356.32
X$39893 407 3254 3256 3198 3234 375 3371 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $39894 r0 *1 646.3,356.32
X$39894 407 3357 3333 3335 375 407 3372 375 sky130_fd_sc_hd__a21oi_1
* cell instance $39895 r0 *1 648.14,356.32
X$39895 407 3335 3327 3333 407 3349 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $39900 r0 *1 658.26,356.32
X$39900 375 2876 3360 3358 3367 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39905 r0 *1 673.44,356.32
X$39905 407 3334 375 407 3338 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $39910 r0 *1 2.3,361.76
X$39910 375 2639 3339 3261 3382 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39911 m0 *1 3.22,361.76
X$39911 375 3382 3339 3411 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39914 m0 *1 9.66,361.76
X$39914 375 2196 3261 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $39915 r0 *1 11.5,361.76
X$39915 407 3315 407 3385 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $39920 r0 *1 15.64,361.76
X$39920 375 3384 3387 3365 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39923 r0 *1 20.24,361.76
X$39923 375 3386 3387 3388 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $39928 r0 *1 28.06,361.76
X$39928 375 2886 3401 2972 3390 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $39975 m0 *1 86.48,361.76
X$39975 407 3369 407 375 3370 375 sky130_fd_sc_hd__inv_1
* cell instance $40426 m0 *1 623.3,361.76
X$40426 375 2876 3356 3403 3373 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40429 m0 *1 632.5,361.76
X$40429 407 3356 375 407 3366 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40430 r0 *1 633.88,361.76
X$40430 407 3219 3395 3394 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $40431 r0 *1 635.26,361.76
X$40431 407 3357 3333 3376 375 407 3377 375 sky130_fd_sc_hd__a21oi_1
* cell instance $40433 m0 *1 636.64,361.76
X$40433 375 2876 3219 3358 3393 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40434 r0 *1 637.1,361.76
X$40434 375 3394 3377 3219 3392 2859 3393 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $40440 m0 *1 645.84,361.76
X$40440 407 3405 3335 3214 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $40441 m0 *1 647.22,361.76
X$40441 407 3378 3209 3351 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $40447 m0 *1 649.98,361.76
X$40447 375 2876 3359 3358 3391 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40448 r0 *1 650.44,361.76
X$40448 375 3391 3359 3379 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $40451 m0 *1 659.18,361.76
X$40451 375 3367 3360 3285 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $40453 r0 *1 661.02,361.76
X$40453 407 3389 375 407 3378 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40462 m0 *1 666.54,361.76
X$40462 407 3359 375 407 3362 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40463 r0 *1 668.38,361.76
X$40463 407 3380 375 407 3383 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40467 m0 *1 672.52,361.76
X$40467 407 3343 375 407 3361 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40468 r0 *1 672.52,361.76
X$40468 407 3360 375 407 3363 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40474 m0 *1 1.84,367.2
X$40474 407 3342 375 407 3352 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40475 m0 *1 5.52,367.2
X$40475 407 3412 375 407 3411 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40477 m0 *1 9.66,367.2
X$40477 375 2886 3387 3261 3384 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40480 m0 *1 18.86,367.2
X$40480 375 2886 3388 3261 3386 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40483 m0 *1 29.44,367.2
X$40483 375 3390 3401 3413 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $40485 m0 *1 35.42,367.2
X$40485 375 3414 3401 3402 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $40490 m0 *1 41.86,367.2
X$40490 407 3402 375 407 3396 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40501 m0 *1 69.92,367.2
X$40501 407 3417 375 407 3369 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40743 m0 *1 624.22,367.2
X$40743 375 2876 3355 3403 3421 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40744 m0 *1 633.42,367.2
X$40744 407 3404 3446 3421 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $40745 m0 *1 634.8,367.2
X$40745 407 3405 3376 3395 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $40747 m0 *1 636.64,367.2
X$40747 407 3395 3379 3234 3219 3355 407 3404 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $40752 m0 *1 644,367.2
X$40752 375 2876 3379 3358 3419 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40755 m0 *1 654.58,367.2
X$40755 375 3139 3407 3358 3418 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40757 m0 *1 664.24,367.2
X$40757 375 3139 3435 3358 3415 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $40761 m0 *1 673.9,367.2
X$40761 407 3381 407 3380 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $40764 r0 *1 1.84,367.2
X$40764 407 3375 407 3412 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $40765 r0 *1 5.52,367.2
X$40765 407 3374 407 3436 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $40768 r0 *1 11.5,367.2
X$40768 407 3398 407 3399 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $40771 r0 *1 15.64,367.2
X$40771 407 3397 407 3400 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $40773 r0 *1 23,367.2
X$40773 407 3399 375 407 3413 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40777 r0 *1 29.9,367.2
X$40777 407 3400 375 407 3442 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $40778 r0 *1 33.58,367.2
X$40778 375 2886 3402 2972 3414 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41013 r0 *1 623.3,367.2
X$41013 375 2876 3448 3403 3449 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41015 r0 *1 634.34,367.2
X$41015 375 3392 3446 3447 3425 3376 3405 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $41016 r0 *1 637.56,367.2
X$41016 407 3219 3379 3355 3425 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $41019 r0 *1 640.32,367.2
X$41019 407 3405 3443 3420 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $41020 r0 *1 641.7,367.2
X$41020 407 3219 3379 3420 3428 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $41022 r0 *1 644,367.2
X$41022 375 3428 3444 3379 3392 3406 3419 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $41026 r0 *1 651.36,367.2
X$41026 407 3358 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $41027 r0 *1 652.74,367.2
X$41027 375 2992 3358 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $41028 r0 *1 661.94,367.2
X$41028 407 3416 3440 3433 3418 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $41032 r0 *1 666.54,367.2
X$41032 375 3415 3435 3407 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41033 r0 *1 670.68,367.2
X$41033 407 3409 407 3389 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $41038 m0 *1 1.38,372.64
X$41038 375 2639 3471 3261 3483 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41040 m0 *1 11.04,372.64
X$41040 407 3438 375 407 3437 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41045 m0 *1 17.02,372.64
X$41045 375 2886 3452 3261 3461 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41049 m0 *1 29.44,372.64
X$41049 407 3441 375 407 3423 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41052 m0 *1 37.72,372.64
X$41052 375 2886 3453 2972 3465 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41308 m0 *1 623.3,372.64
X$41308 407 3403 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $41310 m0 *1 626.98,372.64
X$41310 375 2876 3426 3358 3445 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41315 m0 *1 640.32,372.64
X$41315 407 3426 3455 3219 3427 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $41316 m0 *1 642.16,372.64
X$41316 407 3405 3443 3392 2853 3467 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $41317 m0 *1 644.46,372.64
X$41317 407 3357 3333 3427 375 407 3444 375 sky130_fd_sc_hd__a21oi_1
* cell instance $41320 m0 *1 651.82,372.64
X$41320 375 3407 3466 3165 3431 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $41321 m0 *1 654.12,372.64
X$41321 407 3431 3430 3407 3165 375 407 3433 375 sky130_fd_sc_hd__and4_1
* cell instance $41322 m0 *1 657.34,372.64
X$41322 407 3431 3430 3407 3165 3234 407 3440 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $41331 m0 *1 666.54,372.64
X$41331 407 3439 375 407 3406 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41335 m0 *1 673.44,372.64
X$41335 407 3435 375 407 3410 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41338 r0 *1 2.3,372.64
X$41338 407 3436 375 407 3459 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41339 r0 *1 5.98,372.64
X$41339 375 2639 3438 3261 3484 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41344 r0 *1 18.4,372.64
X$41344 375 3461 3452 3486 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41347 r0 *1 23.92,372.64
X$41347 375 2886 3472 3462 3488 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41350 r0 *1 38.64,372.64
X$41350 375 3465 3453 3442 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41377 r0 *1 99.82,372.64
X$41377 407 3422 375 407 4432 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41381 r0 *1 109.48,372.64
X$41381 407 3424 375 407 4245 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41547 r0 *1 524.4,372.64
X$41547 407 3432 375 407 3491 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41588 r0 *1 623.3,372.64
X$41588 375 2992 3403 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $41589 r0 *1 632.5,372.64
X$41589 407 3448 375 407 3456 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41591 r0 *1 638.02,372.64
X$41591 407 3426 407 375 3468 375 sky130_fd_sc_hd__inv_1
* cell instance $41593 r0 *1 639.4,372.64
X$41593 407 3467 3468 3454 375 407 3445 375 sky130_fd_sc_hd__a21oi_1
* cell instance $41594 r0 *1 641.24,372.64
X$41594 407 3455 3405 3298 407 3454 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $41600 r0 *1 650.44,372.64
X$41600 375 3139 3165 3358 3464 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41602 r0 *1 663.32,372.64
X$41602 375 3139 3460 3358 3489 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $41605 r0 *1 672.98,372.64
X$41605 407 3434 407 3439 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $41609 m0 *1 2.3,378.08
X$41609 375 3483 3471 3506 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41612 m0 *1 7.82,378.08
X$41612 375 3484 3471 3438 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41615 m0 *1 14.26,378.08
X$41615 407 3487 375 407 3486 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41619 m0 *1 18.86,378.08
X$41619 407 3472 375 407 3469 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41622 m0 *1 24.84,378.08
X$41622 375 3488 3452 3472 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41837 m0 *1 519.34,378.08
X$41837 407 3491 407 375 3492 375 sky130_fd_sc_hd__inv_1
* cell instance $41886 m0 *1 628.36,378.08
X$41886 375 3449 3448 3426 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41889 m0 *1 633.88,378.08
X$41889 407 3490 3498 3426 3376 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $41893 m0 *1 637.56,378.08
X$41893 407 3376 3425 3475 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $41897 m0 *1 639.4,378.08
X$41897 407 3426 3455 3443 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $41900 m0 *1 644.92,378.08
X$41900 407 3476 3475 3520 3466 407 3335 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $41904 m0 *1 653.66,378.08
X$41904 407 3431 3463 3479 3165 3477 407 3464 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $41905 m0 *1 656.88,378.08
X$41905 407 3431 3463 3234 3165 375 3477 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $41908 m0 *1 661.02,378.08
X$41908 407 3480 3209 3479 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $41912 m0 *1 664.24,378.08
X$41912 375 3489 3460 3485 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $41916 m0 *1 668.84,378.08
X$41916 407 3528 375 407 3480 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41917 m0 *1 672.52,378.08
X$41917 407 3460 375 407 3457 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41920 r0 *1 1.84,378.08
X$41920 407 3552 375 407 3506 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41922 r0 *1 7.36,378.08
X$41922 407 3451 407 3487 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $41923 r0 *1 11.04,378.08
X$41923 407 3597 375 407 3509 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41927 r0 *1 15.64,378.08
X$41927 407 3510 375 407 3495 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41931 r0 *1 27.6,378.08
X$41931 407 3473 375 407 3470 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $41932 r0 *1 31.28,378.08
X$41932 375 2886 3473 3462 3512 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42130 r0 *1 529.92,378.08
X$42130 407 3481 375 407 3566 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42170 r0 *1 623.76,378.08
X$42170 375 2876 3498 3403 3474 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42171 r0 *1 632.96,378.08
X$42171 375 3515 3455 3490 3498 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $42175 r0 *1 640.32,378.08
X$42175 407 3443 3425 3501 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $42177 r0 *1 642.16,378.08
X$42177 407 3443 3425 3514 407 375 375 sky130_fd_sc_hd__or2_2
* cell instance $42178 r0 *1 644.46,378.08
X$42178 407 3466 3476 3502 3501 375 407 3254 375 sky130_fd_sc_hd__and4_1
* cell instance $42185 r0 *1 655.5,378.08
X$42185 407 3431 3430 3478 3513 375 3511 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $42186 r0 *1 658.26,378.08
X$42186 375 3139 3485 3358 3511 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42188 r0 *1 667.46,378.08
X$42188 407 3508 3209 3478 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $42191 r0 *1 670.22,378.08
X$42191 407 3482 407 3507 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $42192 r0 *1 673.9,378.08
X$42192 407 3507 375 407 3447 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42197 m0 *1 4.6,383.52
X$42197 375 3527 3496 3495 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42198 m0 *1 8.74,383.52
X$42198 407 3497 375 407 3529 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42199 m0 *1 12.42,383.52
X$42199 375 2886 3532 3462 3530 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42203 m0 *1 22.54,383.52
X$42203 407 3388 375 407 3518 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42207 m0 *1 29.44,383.52
X$42207 407 3579 375 407 3533 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42209 m0 *1 33.58,383.52
X$42209 375 3512 3534 3473 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42466 m0 *1 621.46,383.52
X$42466 375 2876 3564 3403 3537 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42467 m0 *1 630.66,383.52
X$42467 407 3498 3392 3499 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $42468 m0 *1 632.04,383.52
X$42468 407 3499 3536 3405 3500 375 407 3474 375 sky130_fd_sc_hd__a31oi_1
* cell instance $42469 m0 *1 634.34,383.52
X$42469 407 3515 3405 3500 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $42478 m0 *1 645.38,383.52
X$42478 375 3502 3463 3475 3476 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $42479 m0 *1 647.68,383.52
X$42479 375 3502 3430 3501 3476 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $42483 m0 *1 653.2,383.52
X$42483 375 3503 3555 3521 3463 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $42484 m0 *1 655.5,383.52
X$42484 375 3503 3431 3521 3485 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $42485 m0 *1 657.8,383.52
X$42485 407 3430 3503 3234 3521 3485 407 3513 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $42494 m0 *1 669.3,383.52
X$42494 407 3505 407 3526 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $42495 m0 *1 672.98,383.52
X$42495 407 3526 375 407 3508 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42499 r0 *1 1.84,383.52
X$42499 375 2639 3496 3462 3527 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42500 r0 *1 11.04,383.52
X$42500 375 3530 3532 3509 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42505 r0 *1 17.02,383.52
X$42505 375 3554 3532 3497 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42506 r0 *1 21.16,383.52
X$42506 375 3462 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $42509 r0 *1 28.52,383.52
X$42509 375 2886 3534 3462 3557 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42511 r0 *1 38.64,383.52
X$42511 375 3558 3453 3535 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42703 r0 *1 515.2,383.52
X$42703 375 2523 3540 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $42707 r0 *1 529.46,383.52
X$42707 407 3566 407 375 3567 375 sky130_fd_sc_hd__inv_1
* cell instance $42716 r0 *1 547.4,383.52
X$42716 407 3519 375 407 3565 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42750 r0 *1 627.9,383.52
X$42750 375 3537 3564 3498 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42756 r0 *1 638.94,383.52
X$42756 407 3564 375 407 3524 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42757 r0 *1 642.62,383.52
X$42757 407 3531 375 407 3562 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42758 r0 *1 646.3,383.52
X$42758 407 3476 3520 3501 3405 375 407 3559 375 sky130_fd_sc_hd__a31oi_1
* cell instance $42759 r0 *1 648.6,383.52
X$42759 407 3521 3430 3560 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $42763 r0 *1 651.82,383.52
X$42763 407 3463 3521 3503 3234 375 3556 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $42765 r0 *1 655.5,383.52
X$42765 407 3523 3556 3555 3522 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $42766 r0 *1 657.34,383.52
X$42766 375 3139 3503 3547 3522 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42770 r0 *1 668.84,383.52
X$42770 407 3525 3209 3523 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $42771 r0 *1 670.22,383.52
X$42771 407 3553 375 407 3525 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42772 r0 *1 673.9,383.52
X$42772 407 3504 407 3528 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $42774 m0 *1 1.38,388.96
X$42774 407 3450 407 3552 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $42776 m0 *1 5.98,388.96
X$42776 375 3576 3496 3577 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42778 m0 *1 10.58,388.96
X$42778 375 2886 3497 3462 3554 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $42781 m0 *1 19.78,388.96
X$42781 375 2196 3462 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $42784 m0 *1 30.36,388.96
X$42784 375 3557 3534 3533 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $42788 m0 *1 37.72,388.96
X$42788 375 2886 3535 3571 3558 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43044 m0 *1 623.3,388.96
X$43044 375 2876 3490 3589 3541 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43045 m0 *1 632.5,388.96
X$43045 375 3357 3602 3541 3542 3490 3234 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $43048 m0 *1 637.56,388.96
X$43048 407 3543 3234 3536 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $43052 m0 *1 639.4,388.96
X$43052 407 3544 3333 3501 3545 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $43053 m0 *1 641.24,388.96
X$43053 375 3545 3546 3544 3392 3562 3563 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $43054 m0 *1 645.38,388.96
X$43054 407 3357 3333 3514 375 407 3546 375 sky130_fd_sc_hd__a21oi_1
* cell instance $43055 m0 *1 647.22,388.96
X$43055 407 3357 3559 3561 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $43056 m0 *1 648.6,388.96
X$43056 375 3139 3521 3547 3583 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43059 m0 *1 660.1,388.96
X$43059 407 3550 407 3531 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43062 m0 *1 665.16,388.96
X$43062 375 3578 3548 3503 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43067 m0 *1 673.44,388.96
X$43067 407 3548 375 407 3573 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43071 r0 *1 3.68,388.96
X$43071 375 2639 3577 3462 3576 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43076 r0 *1 15.64,388.96
X$43076 407 3539 407 3579 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43078 r0 *1 23,388.96
X$43078 375 2886 3441 3462 3570 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43079 r0 *1 32.2,388.96
X$43079 375 3570 3580 3441 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43080 r0 *1 36.34,388.96
X$43080 407 3535 375 407 3568 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43281 r0 *1 537.28,388.96
X$43281 407 3565 407 375 3585 375 sky130_fd_sc_hd__inv_1
* cell instance $43320 r0 *1 629.28,388.96
X$43320 375 3584 3572 3490 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43321 r0 *1 633.42,388.96
X$43321 407 3490 3405 3542 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $43322 r0 *1 634.8,388.96
X$43322 375 2876 3544 3358 3563 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43325 r0 *1 645.84,388.96
X$43325 375 3560 3561 3521 3209 3594 3583 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $43330 r0 *1 655.5,388.96
X$43330 375 3582 3581 3521 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43332 r0 *1 663.32,388.96
X$43332 375 3139 3548 3547 3578 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43336 r0 *1 673.9,388.96
X$43336 407 3551 407 3553 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43341 m0 *1 4.6,394.4
X$43341 375 3595 3612 3459 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43342 m0 *1 8.74,394.4
X$43342 407 3494 407 3597 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43347 m0 *1 15.18,394.4
X$43347 375 3598 3588 3617 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43349 m0 *1 20.24,394.4
X$43349 407 3600 375 407 3586 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43354 m0 *1 29.44,394.4
X$43354 375 2886 3580 3462 3601 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43612 m0 *1 625.6,394.4
X$43612 375 2876 3572 3589 3584 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43617 m0 *1 638.48,394.4
X$43617 407 3599 375 407 3602 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43621 m0 *1 644,394.4
X$43621 407 3392 3405 3298 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $43622 m0 *1 645.38,394.4
X$43622 407 3405 3590 3502 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $43626 m0 *1 653.2,394.4
X$43626 375 3139 3581 3547 3582 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43630 m0 *1 664.24,394.4
X$43630 375 3139 3615 3547 3596 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43633 m0 *1 673.44,394.4
X$43633 407 3593 375 407 3594 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43635 r0 *1 1.38,394.4
X$43635 375 2639 3612 3606 3595 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43637 r0 *1 11.5,394.4
X$43637 407 3614 375 407 3617 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43640 r0 *1 15.64,394.4
X$43640 375 2886 3588 3462 3598 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43644 r0 *1 29.9,394.4
X$43644 375 3601 3580 3619 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43842 r0 *1 519.34,394.4
X$43842 407 3458 375 407 3649 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43888 r0 *1 638.02,394.4
X$43888 407 3572 375 407 3607 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43890 r0 *1 641.7,394.4
X$43890 407 3646 3392 3626 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $43891 r0 *1 643.08,394.4
X$43891 407 3590 407 375 3520 375 sky130_fd_sc_hd__inv_1
* cell instance $43892 r0 *1 644.46,394.4
X$43892 375 3475 3625 3333 3520 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $43895 r0 *1 648.14,394.4
X$43895 407 3623 3298 3624 375 407 3622 375 sky130_fd_sc_hd__a21oi_1
* cell instance $43900 r0 *1 659.64,394.4
X$43900 375 3139 3616 3547 3618 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43902 r0 *1 668.84,394.4
X$43902 375 3596 3615 3616 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43904 r0 *1 673.44,394.4
X$43904 407 3615 375 407 3549 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43908 m0 *1 1.84,399.84
X$43908 407 3517 407 3510 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43911 m0 *1 6.9,399.84
X$43911 375 3613 3612 3639 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $43912 m0 *1 11.04,399.84
X$43912 407 3493 407 3614 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $43916 m0 *1 15.64,399.84
X$43916 375 2886 3600 3606 3641 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $43939 m0 *1 69.46,399.84
X$43939 407 3621 375 407 3620 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $43942 m0 *1 74.52,399.84
X$43942 407 3620 407 375 2240 375 sky130_fd_sc_hd__inv_1
* cell instance $44183 m0 *1 626.52,399.84
X$44183 407 3611 375 407 3647 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44190 m0 *1 638.02,399.84
X$44190 407 3475 3333 3608 3544 3234 407 3632 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $44193 m0 *1 641.24,399.84
X$44193 407 3544 3608 3590 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $44194 m0 *1 642.62,399.84
X$44194 375 3475 3631 3333 3520 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $44196 m0 *1 645.38,399.84
X$44196 407 3514 3590 3333 407 3624 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $44198 m0 *1 647.68,399.84
X$44198 375 2876 3623 3547 3644 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44200 m0 *1 658.72,399.84
X$44200 407 3591 407 3599 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44204 m0 *1 664.24,399.84
X$44204 407 3638 375 407 3642 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44207 m0 *1 667.92,399.84
X$44207 407 3640 3609 3618 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $44208 m0 *1 669.3,399.84
X$44208 407 3616 3209 3609 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $44209 m0 *1 670.68,399.84
X$44209 407 3581 375 407 3574 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44210 m0 *1 674.36,399.84
X$44210 407 3575 407 3593 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44211 r0 *1 1.38,399.84
X$44211 407 3577 375 407 3516 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44212 r0 *1 5.06,399.84
X$44212 375 2639 3639 3606 3613 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44218 r0 *1 17.94,399.84
X$44218 375 3641 3588 3600 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $44419 r0 *1 521.18,399.84
X$44419 407 3649 407 375 3650 375 sky130_fd_sc_hd__inv_1
* cell instance $44424 r0 *1 530.84,399.84
X$44424 407 3610 375 407 3668 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44463 r0 *1 626.52,399.84
X$44463 407 3647 3648 3333 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $44464 r0 *1 627.9,399.84
X$44464 407 3628 3647 3405 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $44465 r0 *1 630.2,399.84
X$44465 375 2876 3608 3589 3629 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44468 r0 *1 639.86,399.84
X$44468 407 3630 375 407 3646 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44469 r0 *1 643.54,399.84
X$44469 407 3626 3632 3631 3629 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $44471 r0 *1 645.84,399.84
X$44471 407 3645 3623 3633 3622 375 3644 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $44477 r0 *1 653.2,399.84
X$44477 407 3634 3392 3643 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $44480 r0 *1 657.34,399.84
X$44480 375 2992 3547 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $44483 r0 *1 667,399.84
X$44483 407 3635 3234 3640 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $44484 r0 *1 668.38,399.84
X$44484 407 3683 375 407 3635 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44485 r0 *1 672.06,399.84
X$44485 407 3637 407 3638 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44489 m0 *1 1.84,405.28
X$44489 407 3538 407 3660 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44490 m0 *1 5.52,405.28
X$44490 407 3587 407 3680 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44491 m0 *1 9.2,405.28
X$44491 375 2196 3606 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $44494 m0 *1 18.4,405.28
X$44494 375 2639 3652 3606 3682 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44719 m0 *1 532.22,405.28
X$44719 407 3668 407 375 3669 375 sky130_fd_sc_hd__inv_1
* cell instance $44761 m0 *1 626.98,405.28
X$44761 375 2876 3667 3589 3687 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44764 m0 *1 637.56,405.28
X$44764 375 2876 3666 3589 3653 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44767 m0 *1 646.76,405.28
X$44767 407 3463 3655 3654 3653 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $44768 m0 *1 648.6,405.28
X$44768 407 3656 3645 3643 3672 3686 407 3665 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $44771 m0 *1 656.42,405.28
X$44771 407 3642 3392 3654 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $44773 m0 *1 659.64,405.28
X$44773 407 3657 407 3630 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $44776 m0 *1 664.24,405.28
X$44776 375 3139 3662 3547 3664 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $44779 m0 *1 673.44,405.28
X$44779 407 3661 375 407 3634 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44781 r0 *1 1.38,405.28
X$44781 407 3606 407 375 375 sky130_fd_sc_hd__clkinvlp_4
* cell instance $44782 r0 *1 4.14,405.28
X$44782 407 3660 375 407 3681 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44783 r0 *1 7.82,405.28
X$44783 407 3651 375 407 3604 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44784 r0 *1 11.5,405.28
X$44784 407 3680 375 407 3619 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44787 r0 *1 15.64,405.28
X$44787 407 3652 375 407 3605 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $44788 r0 *1 19.32,405.28
X$44788 375 3682 3670 3652 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45032 r0 *1 632.96,405.28
X$45032 375 3589 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $45034 r0 *1 644,405.28
X$45034 407 3405 3514 3590 3645 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $45036 r0 *1 646.76,405.28
X$45036 407 3656 3625 3666 3672 3234 407 3655 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $45038 r0 *1 650.44,405.28
X$45038 375 2876 3672 3547 3665 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45041 r0 *1 661.94,405.28
X$45041 375 3139 3663 3547 3685 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45043 r0 *1 671.14,405.28
X$45043 375 3664 3662 3663 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45050 m0 *1 4.6,410.72
X$45050 375 3677 3699 3679 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45051 m0 *1 8.74,410.72
X$45051 407 3603 407 3678 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $45052 m0 *1 12.42,410.72
X$45052 375 3671 3670 3681 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45055 m0 *1 16.56,410.72
X$45055 375 2639 3670 3606 3671 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45321 m0 *1 632.04,410.72
X$45321 375 3687 3667 3544 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45323 m0 *1 636.64,410.72
X$45323 375 2992 3589 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $45328 m0 *1 648.14,410.72
X$45328 407 3656 3645 3234 3672 375 3686 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $45332 m0 *1 654.12,410.72
X$45332 375 3139 3702 3547 3704 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45337 m0 *1 665.62,410.72
X$45337 407 3684 3673 3685 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $45340 m0 *1 667,410.72
X$45340 407 3694 3234 3684 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $45342 m0 *1 669.3,410.72
X$45342 407 3663 3209 3673 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $45343 m0 *1 670.68,410.72
X$45343 407 3659 407 3683 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $45344 m0 *1 674.36,410.72
X$45344 407 3592 407 3661 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $45346 r0 *1 1.84,410.72
X$45346 375 2639 3699 3606 3677 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45347 r0 *1 11.04,410.72
X$45347 375 3700 3699 3651 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45555 r0 *1 532.68,410.72
X$45555 407 3676 375 407 3739 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45595 r0 *1 628.36,410.72
X$45595 375 2876 3689 3589 3688 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $45596 r0 *1 637.56,410.72
X$45596 375 3688 3689 3690 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45598 r0 *1 641.7,410.72
X$45598 407 3667 375 407 3707 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45599 r0 *1 645.38,410.72
X$45599 375 3706 3705 3690 3672 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $45600 r0 *1 647.68,410.72
X$45600 375 3692 3476 3666 3705 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $45604 r0 *1 655.96,410.72
X$45604 375 3704 3702 3672 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $45608 r0 *1 665.16,410.72
X$45608 407 3702 375 407 3693 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45611 r0 *1 669.76,410.72
X$45611 407 3675 407 3701 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $45612 r0 *1 673.44,410.72
X$45612 407 3662 375 407 3636 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45615 m0 *1 1.38,416.16
X$45615 407 3639 375 407 3627 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45617 m0 *1 5.06,416.16
X$45617 407 3678 375 407 3679 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45619 m0 *1 8.74,416.16
X$45619 375 2639 3651 3606 3700 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46108 m0 *1 594.78,416.16
X$46108 375 3540 2992 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $46140 m0 *1 636.64,416.16
X$46140 375 2876 3706 3589 3691 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46146 r0 *1 638.94,416.16
X$46146 407 3714 375 407 3719 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46148 r0 *1 644.46,416.16
X$46148 407 3692 3631 3706 3690 3234 407 3718 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $46149 m0 *1 645.84,416.16
X$46149 375 3706 3656 3690 3692 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $46152 m0 *1 648.6,416.16
X$46152 407 3656 3625 3708 3718 375 3691 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $46156 r0 *1 650.9,416.16
X$46156 407 3692 3625 3715 3717 375 3716 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $46159 r0 *1 653.66,416.16
X$46159 407 3723 3631 3234 3703 375 3717 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $46160 m0 *1 654.12,416.16
X$46160 375 3139 3703 3589 3716 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46163 r0 *1 657.8,416.16
X$46163 407 3709 3209 3715 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $46164 r0 *1 659.18,416.16
X$46164 407 3698 407 3714 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $46168 m0 *1 664.24,416.16
X$46168 375 3728 3711 3703 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $46169 r0 *1 664.7,416.16
X$46169 407 3710 375 407 3709 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46174 r0 *1 668.38,416.16
X$46174 407 3732 3209 3708 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $46175 m0 *1 668.84,416.16
X$46175 407 3689 375 407 3713 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46177 m0 *1 672.52,416.16
X$46177 407 3701 375 407 3694 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46179 r0 *1 673.9,416.16
X$46179 407 3711 375 407 3697 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46627 m0 *1 535.44,421.6
X$46627 407 3739 407 375 3740 375 sky130_fd_sc_hd__inv_1
* cell instance $46694 r0 *1 615.48,421.6
X$46694 407 3725 375 407 3757 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46707 r0 *1 629.74,421.6
X$46707 375 2876 3690 3589 3720 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46716 r0 *1 638.94,421.6
X$46716 375 3741 3738 3608 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $46719 r0 *1 643.54,421.6
X$46719 407 3692 3645 3721 3690 3737 407 3720 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $46720 m0 *1 644,421.6
X$46720 407 3692 3645 3234 3690 375 3737 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $46722 m0 *1 646.76,421.6
X$46722 375 2876 3724 3547 3726 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46727 r0 *1 650.9,421.6
X$46727 375 3724 3723 3623 3722 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $46728 r0 *1 653.2,421.6
X$46728 407 3703 3722 3724 3623 375 407 3692 375 sky130_fd_sc_hd__and4_1
* cell instance $46729 m0 *1 655.96,421.6
X$46729 407 3625 3724 3736 3623 3735 407 3726 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $46730 r0 *1 656.42,421.6
X$46730 407 3631 3623 3724 3234 375 3736 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $46733 r0 *1 661.02,421.6
X$46733 407 3727 3209 3735 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $46736 r0 *1 662.86,421.6
X$46736 407 3734 375 407 3727 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $46738 m0 *1 664.24,421.6
X$46738 375 3139 3711 3547 3728 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $46743 r0 *1 670.22,421.6
X$46743 407 3729 407 3733 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $46744 m0 *1 673.44,421.6
X$46744 407 3712 407 3710 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $46745 r0 *1 673.9,421.6
X$46745 407 3733 375 407 3732 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47017 m0 *1 615.94,427.04
X$47017 407 3757 407 375 3758 375 sky130_fd_sc_hd__buf_4
* cell instance $47025 m0 *1 636.64,427.04
X$47025 375 2876 3738 3754 3741 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47030 m0 *1 649.98,427.04
X$47030 407 3645 3722 3724 3623 375 407 3752 375 sky130_fd_sc_hd__and4_1
* cell instance $47034 m0 *1 659.64,427.04
X$47034 375 3751 3744 3722 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47040 m0 *1 666.54,427.04
X$47040 407 3742 375 407 3730 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47042 m0 *1 671.14,427.04
X$47042 407 3731 407 3734 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $47297 r0 *1 624.22,427.04
X$47297 375 2876 3756 3754 3755 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47303 r0 *1 646.3,427.04
X$47303 407 3738 375 407 3745 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47306 r0 *1 651.36,427.04
X$47306 375 3139 3722 3743 3753 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47307 r0 *1 660.56,427.04
X$47307 375 3139 3744 3743 3751 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47309 r0 *1 669.76,427.04
X$47309 407 3746 3209 3721 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $47310 r0 *1 671.14,427.04
X$47310 407 3744 375 407 3750 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47832 r0 *1 622.84,432.48
X$47832 375 2876 3760 3754 3788 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47834 m0 *1 624.22,432.48
X$47834 407 3762 375 407 3775 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47835 m0 *1 627.9,432.48
X$47835 375 3755 3789 3756 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47839 r0 *1 634.8,432.48
X$47839 375 2876 3773 3743 3774 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47842 m0 *1 636.64,432.48
X$47842 375 3774 3761 3773 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47848 m0 *1 644.46,432.48
X$47848 407 3760 375 407 3766 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47849 r0 *1 644.92,432.48
X$47849 375 3784 3763 3666 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47850 m0 *1 648.14,432.48
X$47850 407 3747 407 3762 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $47854 m0 *1 651.82,432.48
X$47854 407 3763 375 407 3764 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47856 r0 *1 653.2,432.48
X$47856 375 3783 3778 3724 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47857 m0 *1 655.5,432.48
X$47857 407 3645 3724 3234 3623 3722 407 3771 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $47859 m0 *1 658.72,432.48
X$47859 407 3772 3771 3752 3753 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $47860 r0 *1 659.18,432.48
X$47860 407 3782 3209 3772 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $47863 r0 *1 662.4,432.48
X$47863 375 3139 3765 3743 3769 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $47868 m0 *1 665.16,432.48
X$47868 375 3769 3770 3765 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $47874 m0 *1 671.6,432.48
X$47874 407 3756 375 407 3695 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $47877 r0 *1 673.9,432.48
X$47877 407 3765 375 407 3749 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48402 r0 *1 625.6,437.92
X$48402 407 3789 3209 3790 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $48403 m0 *1 625.6,437.92
X$48403 407 3787 3759 3786 407 3788 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $48404 r0 *1 626.98,437.92
X$48404 407 3790 3785 3808 3824 375 407 3791 375 sky130_fd_sc_hd__a31oi_1
* cell instance $48405 m0 *1 627.44,437.92
X$48405 407 3760 3759 3786 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $48409 m0 *1 631.12,437.92
X$48409 407 3776 3234 3785 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $48410 m0 *1 632.5,437.92
X$48410 407 3777 375 407 3776 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48412 r0 *1 633.88,437.92
X$48412 375 3139 3792 3754 3807 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48420 m0 *1 641.7,437.92
X$48420 375 2876 3763 3743 3784 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48421 r0 *1 643.08,437.92
X$48421 407 3792 375 407 3767 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48428 m0 *1 651.82,437.92
X$48428 375 3139 3778 3743 3783 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48429 r0 *1 652.28,437.92
X$48429 375 2992 3743 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $48431 r0 *1 661.48,437.92
X$48431 407 3780 407 3777 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $48435 r0 *1 665.16,437.92
X$48435 407 3800 3209 3804 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $48441 m0 *1 667,437.92
X$48441 407 3816 3209 3633 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $48444 m0 *1 668.84,437.92
X$48444 407 3779 375 407 3782 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48445 r0 *1 668.84,437.92
X$48445 407 3793 375 407 3781 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48447 m0 *1 672.52,437.92
X$48447 407 3773 375 407 3658 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48449 r0 *1 673.9,437.92
X$48449 407 3768 407 3799 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $48967 r0 *1 616.86,443.36
X$48967 375 3828 3827 3825 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $48972 m0 *1 622.38,443.36
X$48972 375 2876 3789 3754 3791 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48975 r0 *1 623.76,443.36
X$48975 407 3822 3808 3824 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $48976 r0 *1 625.14,443.36
X$48976 375 2992 3754 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $48978 r0 *1 634.34,443.36
X$48978 375 3139 3761 3754 3845 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48981 m0 *1 636.64,443.36
X$48981 375 3807 3806 3792 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $48987 m0 *1 643.08,443.36
X$48987 375 2876 3805 3743 3821 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48990 r0 *1 644.92,443.36
X$48990 375 3821 3805 3706 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $48994 r0 *1 652.28,443.36
X$48994 375 3743 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $48997 m0 *1 654.58,443.36
X$48997 375 3139 3793 3743 3820 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $48999 r0 *1 657.8,443.36
X$48999 375 3820 3819 3793 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $49001 r0 *1 662.4,443.36
X$49001 375 3139 3801 3743 3803 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49003 m0 *1 664.24,443.36
X$49003 375 3803 3802 3801 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $49008 r0 *1 671.6,443.36
X$49008 407 3778 375 407 3814 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49010 m0 *1 672.52,443.36
X$49010 407 3799 375 407 3800 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49054 m0 *1 45.54,448.8
X$49054 375 3571 407 407 375 sky130_fd_sc_hd__inv_8
* cell instance $49055 r0 *1 45.54,448.8
X$49055 375 3858 3571 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $49469 m0 *1 543.72,448.8
X$49469 407 3823 375 407 3796 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49529 m0 *1 612.26,448.8
X$49529 375 2876 3825 3754 3828 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49533 m0 *1 621.46,448.8
X$49533 407 3826 375 407 3810 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49538 r0 *1 625.14,448.8
X$49538 407 3825 375 407 3811 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49539 m0 *1 625.14,448.8
X$49539 375 3754 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $49540 r0 *1 628.82,448.8
X$49540 407 3897 3787 3848 375 407 3849 375 sky130_fd_sc_hd__a21oi_1
* cell instance $49541 m0 *1 630.2,448.8
X$49541 375 3822 3851 3806 3789 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $49543 r0 *1 631.12,448.8
X$49543 407 3806 3789 3829 3852 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $49545 r0 *1 633.42,448.8
X$49545 375 3846 3847 3761 3209 3719 3845 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $49552 m0 *1 638.02,448.8
X$49552 407 3818 375 407 3809 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49558 m0 *1 642.16,448.8
X$49558 407 3867 407 375 3178 375 sky130_fd_sc_hd__buf_4
* cell instance $49566 r0 *1 650.44,448.8
X$49566 375 3139 3817 3743 3844 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49568 m0 *1 651.82,448.8
X$49568 375 3844 3817 3623 3178 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $49571 m0 *1 658.72,448.8
X$49571 407 3798 407 3818 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $49572 r0 *1 659.64,448.8
X$49572 375 3139 3802 3743 3863 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49577 m0 *1 665.16,448.8
X$49577 407 3812 375 407 3816 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49581 m0 *1 668.84,448.8
X$49581 407 3794 407 3815 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $49584 r0 *1 670.22,448.8
X$49584 407 3835 375 407 3839 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49586 m0 *1 672.98,448.8
X$49586 407 3801 375 407 3797 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49587 r0 *1 673.9,448.8
X$49587 407 3795 407 3835 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $49858 m0 *1 611.8,454.24
X$49858 375 2876 3826 3754 3870 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49861 m0 *1 622.38,454.24
X$49861 375 2876 3829 3754 3849 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $49862 m0 *1 631.58,454.24
X$49862 407 3829 407 375 3787 375 sky130_fd_sc_hd__inv_1
* cell instance $49864 m0 *1 633.88,454.24
X$49864 407 3761 3830 3846 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $49871 m0 *1 640.78,454.24
X$49871 375 3867 3831 3742 3832 407 407 375 sky130_fd_sc_hd__nor3b_2
* cell instance $49875 m0 *1 653.2,454.24
X$49875 407 3832 375 407 3813 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49876 m0 *1 656.88,454.24
X$49876 407 3802 3843 3833 3865 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $49877 m0 *1 658.72,454.24
X$49877 407 3815 375 407 3864 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49881 m0 *1 664.24,454.24
X$49881 407 3878 3833 3841 3842 375 3862 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $49884 m0 *1 667,454.24
X$49884 407 3859 3209 3841 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $49885 m0 *1 668.38,454.24
X$49885 407 3834 3209 3860 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $49886 m0 *1 669.76,454.24
X$49886 407 3840 375 407 3834 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $49887 m0 *1 673.44,454.24
X$49887 407 3817 375 407 3857 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50135 r0 *1 615.94,454.24
X$50135 375 3870 3869 3826 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $50141 r0 *1 626.98,454.24
X$50141 407 3851 3808 3896 407 3848 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $50143 r0 *1 629.74,454.24
X$50143 407 3829 3851 3868 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $50144 r0 *1 631.12,454.24
X$50144 407 3829 3851 3761 3853 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $50146 r0 *1 634.8,454.24
X$50146 407 3808 3852 3830 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $50157 r0 *1 655.5,454.24
X$50157 407 3878 3879 3804 3819 3866 407 3886 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $50158 r0 *1 658.72,454.24
X$50158 407 3833 3802 3860 3865 375 3863 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $50159 r0 *1 661.48,454.24
X$50159 375 3139 3770 3854 3862 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $50164 r0 *1 673.9,454.24
X$50164 407 3838 407 3840 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $50433 m0 *1 613.64,459.68
X$50433 375 2876 3827 3754 3871 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $50436 m0 *1 624.22,459.68
X$50436 375 3872 3891 3827 3209 3775 3871 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $50440 m0 *1 631.58,459.68
X$50440 407 3850 3889 3853 375 407 3874 375 sky130_fd_sc_hd__a21oi_1
* cell instance $50441 m0 *1 633.42,459.68
X$50441 407 3850 3889 3852 375 407 3847 375 sky130_fd_sc_hd__a21oi_1
* cell instance $50444 m0 *1 636.64,459.68
X$50444 375 3888 3874 3875 3209 3876 3887 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $50449 m0 *1 643.08,459.68
X$50449 407 3885 375 407 3876 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50450 m0 *1 646.76,459.68
X$50450 375 3139 3819 3854 3886 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $50452 m0 *1 656.42,459.68
X$50452 407 3878 3879 3843 3819 375 3866 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $50454 m0 *1 659.64,459.68
X$50454 407 3833 3861 3843 3802 3770 407 3842 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $50457 m0 *1 664.24,459.68
X$50457 375 3861 3878 3802 3770 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $50461 m0 *1 667.46,459.68
X$50461 407 3881 3209 3880 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $50462 m0 *1 668.84,459.68
X$50462 407 3837 407 3904 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $50463 m0 *1 672.52,459.68
X$50463 407 3882 375 407 3859 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50715 r0 *1 623.76,459.68
X$50715 407 3850 3893 3891 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $50716 r0 *1 625.14,459.68
X$50716 407 3808 3869 3873 375 407 3893 375 sky130_fd_sc_hd__a21oi_1
* cell instance $50717 r0 *1 626.98,459.68
X$50717 407 3852 3894 3873 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $50719 r0 *1 628.82,459.68
X$50719 407 3808 3868 3209 3972 3897 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $50721 r0 *1 632.96,459.68
X$50721 407 3808 3868 3890 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $50722 r0 *1 634.34,459.68
X$50722 407 3761 3875 3890 3888 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $50723 r0 *1 636.18,459.68
X$50723 375 3139 3875 3854 3887 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $50726 r0 *1 645.84,459.68
X$50726 375 3909 3899 3877 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $50732 r0 *1 657.34,459.68
X$50732 407 3879 3861 3907 3802 3880 407 3908 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $50734 r0 *1 661.02,459.68
X$50734 407 3883 407 3885 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $50738 r0 *1 666.08,459.68
X$50738 407 3877 375 407 3902 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50739 r0 *1 669.76,459.68
X$50739 407 3904 375 407 3920 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $50741 r0 *1 673.9,459.68
X$50741 407 3855 407 3882 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $51011 m0 *1 615.02,465.12
X$51011 375 2876 3869 3754 3892 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51013 m0 *1 624.68,465.12
X$51013 407 3912 3889 3911 3869 3895 407 3892 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $51014 m0 *1 627.9,465.12
X$51014 407 3869 3896 3898 375 407 3895 375 sky130_fd_sc_hd__a21oi_1
* cell instance $51015 m0 *1 629.74,465.12
X$51015 407 3868 3894 3889 407 3898 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $51018 m0 *1 634.34,465.12
X$51018 407 3761 3875 3899 3894 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $51020 m0 *1 636.64,465.12
X$51020 407 3830 3875 3234 3761 3899 407 3910 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $51026 m0 *1 644.92,465.12
X$51026 375 3139 3877 3854 3909 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51028 m0 *1 654.58,465.12
X$51028 375 3139 3861 3854 3908 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51032 m0 *1 665.62,465.12
X$51032 375 3906 3861 3903 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $51036 m0 *1 670.68,465.12
X$51036 407 3905 375 407 3900 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51037 m0 *1 674.36,465.12
X$51037 407 3836 407 3922 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $51289 r0 *1 624.22,465.12
X$51289 407 3869 3827 3912 3931 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $51290 r0 *1 626.06,465.12
X$51290 407 3869 3827 3914 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $51291 r0 *1 627.44,465.12
X$51291 407 3868 3894 3912 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51295 r0 *1 632.04,465.12
X$51295 407 3868 3894 3914 3916 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $51297 r0 *1 634.8,465.12
X$51297 375 3139 3899 3854 3932 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51301 r0 *1 646.76,465.12
X$51301 407 3854 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $51307 r0 *1 654.58,465.12
X$51307 407 3831 375 407 3921 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51310 r0 *1 660.56,465.12
X$51310 407 3879 3802 3861 3843 375 3907 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $51312 r0 *1 664.24,465.12
X$51312 375 3139 3903 3941 3906 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51315 r0 *1 673.9,465.12
X$51315 407 3922 375 407 3881 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51332 m0 *1 36.34,470.56
X$51332 407 3925 375 407 3258 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51583 m0 *1 611.34,470.56
X$51583 375 3930 3758 3831 3742 3832 407 407 375 sky130_fd_sc_hd__nand4bb_2
* cell instance $51588 m0 *1 619.62,470.56
X$51588 407 3929 375 407 3923 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51591 m0 *1 627.9,470.56
X$51591 407 3889 3913 3872 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $51592 m0 *1 629.28,470.56
X$51592 407 3973 3209 3911 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51594 m0 *1 631.12,470.56
X$51594 407 3852 3894 3914 3913 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $51595 m0 *1 632.96,470.56
X$51595 375 3209 3915 3933 3894 3852 3808 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $51597 m0 *1 636.64,470.56
X$51597 407 3910 3915 3932 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51602 m0 *1 643.54,470.56
X$51602 375 3916 3833 3889 3935 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $51604 m0 *1 646.76,470.56
X$51604 375 2992 3854 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $51606 m0 *1 656.88,470.56
X$51606 407 3878 3833 3918 3819 3843 407 3942 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $51607 m0 *1 660.1,470.56
X$51607 375 3918 3917 3819 3878 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $51608 m0 *1 662.4,470.56
X$51608 407 3920 3209 3928 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51615 m0 *1 669.3,470.56
X$51615 407 3939 3209 3960 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51616 m0 *1 670.68,470.56
X$51616 407 3926 375 407 3927 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51617 m0 *1 674.36,470.56
X$51617 407 3856 407 3926 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $51816 r0 *1 496.8,470.56
X$51816 375 3947 407 407 375 sky130_fd_sc_hd__inv_16
* cell instance $51860 r0 *1 609.04,470.56
X$51860 375 2876 3929 3997 3948 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51862 r0 *1 618.24,470.56
X$51862 407 3930 407 375 3648 375 sky130_fd_sc_hd__buf_4
* cell instance $51863 r0 *1 621,470.56
X$51863 407 3934 3930 3889 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51865 r0 *1 622.84,470.56
X$51865 407 3919 375 407 3934 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51868 r0 *1 629.28,470.56
X$51868 407 3864 3392 3951 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $51872 r0 *1 635.72,470.56
X$51872 407 3392 407 375 3209 375 sky130_fd_sc_hd__buf_4
* cell instance $51876 r0 *1 644,470.56
X$51876 407 3917 3935 3916 3889 375 407 3945 375 sky130_fd_sc_hd__and4_1
* cell instance $51877 r0 *1 647.22,470.56
X$51877 407 3742 3946 3759 407 3944 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $51881 r0 *1 654.12,470.56
X$51881 407 3927 3209 3970 407 3943 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $51883 r0 *1 656.42,470.56
X$51883 375 3139 3918 3941 3969 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $51884 r0 *1 665.62,470.56
X$51884 375 3940 3959 3962 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $51887 r0 *1 670.22,470.56
X$51887 407 3993 375 407 3939 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51888 r0 *1 673.9,470.56
X$51888 407 3938 407 3779 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $51906 m0 *1 40.02,476
X$51906 375 2886 3925 3571 3966 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52104 m0 *1 498.64,476
X$52104 375 3540 3947 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $52155 m0 *1 613.64,476
X$52155 375 3948 3950 3929 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $52158 m0 *1 622.38,476
X$52158 407 3952 3934 3808 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $52161 m0 *1 626.06,476
X$52161 407 3392 3808 3896 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $52164 m0 *1 631.58,476
X$52164 407 3955 375 407 3973 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52172 m0 *1 639.86,476
X$52172 407 3234 3889 3850 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52175 m0 *1 643.54,476
X$52175 407 3924 407 3949 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $52176 m0 *1 647.22,476
X$52176 375 3139 3905 3854 3944 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52178 m0 *1 656.88,476
X$52178 407 3945 3958 3959 3957 407 3970 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $52179 m0 *1 659.18,476
X$52179 407 3960 3942 3945 3969 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $52183 m0 *1 664.24,476
X$52183 375 3139 3962 3941 3940 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52187 m0 *1 674.36,476
X$52187 407 3962 375 407 3901 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52207 r0 *1 44.16,476
X$52207 375 3966 3967 3925 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $52430 r0 *1 609.04,476
X$52430 407 3949 375 407 3974 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52435 r0 *1 619.16,476
X$52435 407 3976 3975 3979 3950 3951 407 3977 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $52438 r0 *1 623.76,476
X$52438 407 3950 3896 3953 375 407 3979 375 sky130_fd_sc_hd__a21oi_1
* cell instance $52441 r0 *1 626.98,476
X$52441 407 3931 3978 3889 407 3953 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $52444 r0 *1 630.2,476
X$52444 407 3954 375 407 3972 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52445 r0 *1 633.88,476
X$52445 375 3139 3806 3854 3996 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52449 r0 *1 644.46,476
X$52449 407 3831 3832 3946 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $52451 r0 *1 648.6,476
X$52451 407 3956 3943 3971 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52454 r0 *1 651.36,476
X$52454 407 3957 3945 3959 3958 3843 407 3956 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $52455 r0 *1 654.58,476
X$52455 407 3884 407 3968 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $52456 r0 *1 658.26,476
X$52456 407 3961 407 3955 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $52459 r0 *1 663.32,476
X$52459 375 3139 3963 3941 3994 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52462 r0 *1 673.44,476
X$52462 407 3963 375 407 3936 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $52479 m0 *1 40.48,481.44
X$52479 375 2886 3967 3571 3980 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52483 m0 *1 50.14,481.44
X$52483 375 3980 3967 6086 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $52732 m0 *1 615.48,481.44
X$52732 375 2876 3950 3997 3977 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52733 m0 *1 624.68,481.44
X$52733 407 3808 3931 3975 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52734 m0 *1 626.06,481.44
X$52734 407 3982 3981 3978 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $52735 m0 *1 627.44,481.44
X$52735 407 3983 4018 3935 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52737 m0 *1 629.28,481.44
X$52737 407 3872 3978 3392 3809 3984 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $52738 m0 *1 631.58,481.44
X$52738 407 3982 3985 4037 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52740 m0 *1 634.8,481.44
X$52740 407 3806 3808 3986 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $52742 m0 *1 636.64,481.44
X$52742 375 3850 3995 3996 3986 3806 3843 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $52746 m0 *1 641.24,481.44
X$52746 407 3913 3935 3917 4035 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $52747 m0 *1 643.08,481.44
X$52747 407 3917 3935 3913 3889 375 407 3987 375 sky130_fd_sc_hd__and4_1
* cell instance $52750 m0 *1 647.68,481.44
X$52750 375 3139 3959 3854 3971 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $52751 m0 *1 656.88,481.44
X$52751 407 3957 3987 3928 3958 3989 407 3988 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $52752 m0 *1 660.1,481.44
X$52752 407 3957 3987 3843 3958 375 3989 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $52755 m0 *1 664.24,481.44
X$52755 375 3994 3958 3963 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $52761 m0 *1 674.36,481.44
X$52761 407 3964 407 3993 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $53005 r0 *1 610.88,481.44
X$53005 407 3974 3392 3998 407 4038 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $53007 r0 *1 612.72,481.44
X$53007 407 4015 3950 3999 3976 407 3998 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $53012 r0 *1 623.76,481.44
X$53012 407 3808 3931 3983 4040 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $53013 r0 *1 625.6,481.44
X$53013 407 3889 3913 4015 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $53015 r0 *1 628.36,481.44
X$53015 407 3808 3913 3981 375 407 4013 375 sky130_fd_sc_hd__a21oi_1
* cell instance $53016 r0 *1 630.2,481.44
X$53016 375 3139 3982 4001 4012 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53020 r0 *1 640.78,481.44
X$53020 375 3139 3990 3854 4011 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53023 r0 *1 650.9,481.44
X$53023 407 4008 3392 4003 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $53024 r0 *1 652.28,481.44
X$53024 407 4005 407 3954 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $53025 r0 *1 655.96,481.44
X$53025 375 3139 3958 3941 3988 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53026 r0 *1 665.16,481.44
X$53026 407 3990 375 407 3991 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53031 r0 *1 673.9,481.44
X$53031 407 3903 375 407 3992 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53300 m0 *1 611.8,486.88
X$53300 407 4016 4038 4017 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $53301 m0 *1 613.18,486.88
X$53301 407 3976 4015 3999 3950 3843 407 4016 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $53304 m0 *1 619.16,486.88
X$53304 407 3982 3981 3976 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $53305 m0 *1 621.46,486.88
X$53305 407 3950 4000 3982 3999 407 4018 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $53306 m0 *1 623.76,486.88
X$53306 407 4000 3843 4040 4051 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $53308 m0 *1 626.06,486.88
X$53308 407 3850 3889 3931 375 407 4014 375 sky130_fd_sc_hd__a21oi_1
* cell instance $53309 m0 *1 627.9,486.88
X$53309 407 3872 3983 4018 3879 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $53310 m0 *1 629.74,486.88
X$53310 407 3850 4013 3985 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $53311 m0 *1 631.12,486.88
X$53311 407 4037 3984 4012 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $53312 m0 *1 632.5,486.88
X$53312 407 4020 375 407 3933 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53317 m0 *1 640.32,486.88
X$53317 407 3850 3889 4035 375 407 4010 375 sky130_fd_sc_hd__a21oi_1
* cell instance $53319 m0 *1 644,486.88
X$53319 375 3139 4009 3941 4002 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53320 m0 *1 653.2,486.88
X$53320 407 4009 4033 3957 407 375 375 sky130_fd_sc_hd__and2_0
* cell instance $53321 m0 *1 655.5,486.88
X$53321 407 3957 3987 3959 3958 375 407 4004 375 sky130_fd_sc_hd__and4_1
* cell instance $53322 m0 *1 658.72,486.88
X$53322 375 3941 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $53324 m0 *1 664.24,486.88
X$53324 407 4004 4030 4021 4007 375 4029 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $53331 m0 *1 673.9,486.88
X$53331 407 4006 407 4022 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $53422 r0 *1 224.48,486.88
X$53422 375 2523 4031 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $53578 r0 *1 613.18,486.88
X$53578 375 2876 3999 3997 4017 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53581 r0 *1 623.3,486.88
X$53581 375 2876 4000 4001 4039 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53585 r0 *1 638.48,486.88
X$53585 375 4036 3982 4034 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $53590 r0 *1 645.84,486.88
X$53590 375 4011 4009 3990 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $53594 r0 *1 651.82,486.88
X$53594 407 4033 3945 3843 4009 375 4032 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $53595 r0 *1 654.58,486.88
X$53595 407 4026 407 4043 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $53598 r0 *1 659.64,486.88
X$53598 375 2992 3941 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $53600 r0 *1 668.84,486.88
X$53600 407 4022 375 407 4028 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53601 r0 *1 672.52,486.88
X$53601 407 4027 375 407 4008 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53876 m0 *1 623.3,492.32
X$53876 407 3981 3975 4050 4051 375 4039 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $53879 m0 *1 627.44,492.32
X$53879 407 3872 3983 3392 4042 4019 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $53881 m0 *1 630.2,492.32
X$53881 407 4043 375 407 4042 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53886 m0 *1 637.1,492.32
X$53886 375 3139 4034 4001 4036 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53889 m0 *1 646.3,492.32
X$53889 407 4034 375 407 4061 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53891 m0 *1 650.9,492.32
X$53891 407 4044 407 4020 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $53892 m0 *1 654.58,492.32
X$53892 375 3139 4030 3941 4029 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $53894 m0 *1 664.24,492.32
X$53894 407 4028 3392 4021 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $53895 m0 *1 665.62,492.32
X$53895 375 4048 4030 4046 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $53899 m0 *1 670.68,492.32
X$53899 407 4045 375 407 3937 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $53900 m0 *1 674.36,492.32
X$53900 407 4023 407 4027 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $54150 r0 *1 622.84,492.32
X$54150 407 4000 407 375 4041 375 sky130_fd_sc_hd__inv_1
* cell instance $54151 r0 *1 624.22,492.32
X$54151 407 4041 3983 3981 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $54154 r0 *1 630.2,492.32
X$54154 407 3968 375 407 4069 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54160 r0 *1 640.78,492.32
X$54160 375 3139 4049 4001 4067 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $54164 r0 *1 652.74,492.32
X$54164 375 3139 4045 3941 4064 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $54167 r0 *1 663.32,492.32
X$54167 375 3139 4046 3941 4048 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $54169 r0 *1 672.52,492.32
X$54169 407 4046 375 407 4047 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54687 r0 *1 619.16,497.76
X$54687 407 3975 4052 3843 4054 4053 407 4072 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $54689 m0 *1 621,497.76
X$54689 407 3975 4053 4052 4054 375 407 4073 375 sky130_fd_sc_hd__and4_1
* cell instance $54691 r0 *1 622.84,497.76
X$54691 407 4070 4072 4073 4086 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $54692 m0 *1 624.22,497.76
X$54692 407 4053 4054 4052 4015 407 4056 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $54693 r0 *1 624.68,497.76
X$54693 407 4053 4054 4052 4055 407 3983 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $54696 m0 *1 626.98,497.76
X$54696 407 4019 4056 4071 375 407 4068 375 sky130_fd_sc_hd__a21oi_1
* cell instance $54697 r0 *1 627.9,497.76
X$54697 407 4055 3843 4071 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $54698 m0 *1 628.82,497.76
X$54698 407 4069 3392 4070 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $54702 r0 *1 630.66,497.76
X$54702 375 3139 4055 4001 4068 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $54706 m0 *1 636.64,497.76
X$54706 375 2992 4001 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $54711 r0 *1 640.32,497.76
X$54711 375 4067 4055 4049 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $54713 r0 *1 645.38,497.76
X$54713 407 4066 375 407 4075 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54717 m0 *1 649.98,497.76
X$54717 407 4049 375 407 4060 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54721 r0 *1 651.82,497.76
X$54721 407 4033 3987 4057 4084 375 4065 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $54723 m0 *1 654.58,497.76
X$54723 375 4064 4083 4045 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $54724 r0 *1 654.58,497.76
X$54724 407 3957 3945 4003 4032 375 4002 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $54725 r0 *1 657.34,497.76
X$54725 375 3139 4074 3941 4081 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $54726 m0 *1 658.72,497.76
X$54726 407 4030 3843 4004 4007 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $54727 m0 *1 660.56,497.76
X$54727 407 4058 3392 4082 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $54730 m0 *1 664.24,497.76
X$54730 407 4059 375 407 4058 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54736 m0 *1 669.76,497.76
X$54736 407 4062 375 407 3746 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54738 m0 *1 673.44,497.76
X$54738 407 4025 407 4059 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $55011 m0 *1 615.94,503.2
X$55011 375 3139 4053 4001 4086 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55012 m0 *1 625.14,503.2
X$55012 407 4085 3392 4050 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $55018 m0 *1 636.64,503.2
X$55018 407 4001 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $55023 m0 *1 639.86,503.2
X$55023 375 4099 3875 4066 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $55026 m0 *1 646.76,503.2
X$55026 375 3139 4083 4001 4065 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55027 m0 *1 655.96,503.2
X$55027 375 4083 4033 4074 4076 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $55029 m0 *1 659.18,503.2
X$55029 407 4076 3945 4082 4074 4080 407 4081 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $55033 m0 *1 664.24,503.2
X$55033 375 3139 4078 3941 4077 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55036 m0 *1 673.44,503.2
X$55036 407 4078 375 407 4024 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55288 r0 *1 623.76,503.2
X$55288 407 3975 4054 4100 4101 375 4102 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $55289 r0 *1 626.52,503.2
X$55289 407 4054 4014 4101 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $55291 r0 *1 628.82,503.2
X$55291 407 4087 3392 4100 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $55294 r0 *1 631.58,503.2
X$55294 407 4089 375 407 4087 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55296 r0 *1 637.1,503.2
X$55296 375 3139 4066 4001 4099 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55301 r0 *1 652.28,503.2
X$55301 407 4076 3987 4083 4074 3843 407 4084 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $55302 r0 *1 655.5,503.2
X$55302 407 4079 407 4089 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $55303 r0 *1 659.18,503.2
X$55303 407 4091 3392 4057 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $55304 r0 *1 660.56,503.2
X$55304 407 4076 3945 3843 4074 375 4080 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $55307 r0 *1 665.62,503.2
X$55307 375 4077 4074 4078 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $55311 r0 *1 672.52,503.2
X$55311 407 4093 375 407 4091 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55399 r0 *1 103.04,508.64
X$55399 375 2165 4104 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $55403 r0 *1 110.4,508.64
X$55403 375 4104 4096 4114 4115 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55408 m0 *1 114.54,508.64
X$55408 407 4096 375 407 3297 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55825 m0 *1 611.8,508.64
X$55825 375 4103 2876 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $55830 m0 *1 621,508.64
X$55830 375 3139 4054 4001 4102 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55836 m0 *1 630.2,508.64
X$55836 407 4088 375 407 4085 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55848 m0 *1 641.24,508.64
X$55848 407 4090 375 407 3995 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55851 r0 *1 644.46,508.64
X$55851 375 4140 4010 4107 3392 4117 4123 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $55861 m0 *1 654.58,508.64
X$55861 375 3139 4092 4001 4122 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55863 r0 *1 655.5,508.64
X$55863 375 4122 4107 4092 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $55865 r0 *1 660.1,508.64
X$55865 375 4118 4076 4107 4108 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $55866 r0 *1 662.4,508.64
X$55866 375 3139 4097 4119 4098 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55868 m0 *1 664.24,508.64
X$55868 375 4098 3918 4097 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $55877 r0 *1 673.9,508.64
X$55877 407 4092 375 407 3965 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55878 m0 *1 674.36,508.64
X$55878 407 4063 407 4093 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $55949 m0 *1 85.56,514.08
X$55949 407 4113 375 407 3259 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $55953 r0 *1 88.78,514.08
X$55953 375 4104 4113 4114 4133 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55971 r0 *1 112.24,514.08
X$55971 375 4104 4116 4114 4125 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $55974 m0 *1 114.54,514.08
X$55974 375 4115 4116 4096 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $55976 r0 *1 121.44,514.08
X$55976 375 4125 4116 4137 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $56391 m0 *1 612.26,514.08
X$56391 407 3748 407 4124 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $56393 r0 *1 613.18,514.08
X$56393 375 2992 3997 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $56394 m0 *1 615.94,514.08
X$56394 375 4103 3139 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $56413 m0 *1 642.62,514.08
X$56413 375 3139 4107 3997 4123 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $56415 r0 *1 645.84,514.08
X$56415 407 4107 3987 4140 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $56420 m0 *1 651.82,514.08
X$56420 407 4076 3987 4105 4121 375 4120 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $56422 r0 *1 652.74,514.08
X$56422 407 3945 4107 4118 3843 375 4138 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $56423 m0 *1 654.58,514.08
X$56423 407 4106 407 4088 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $56425 r0 *1 655.96,514.08
X$56425 375 3139 4108 4119 4120 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $56427 m0 *1 658.72,514.08
X$56427 407 3839 3392 4121 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $56428 m0 *1 660.1,514.08
X$56428 407 4095 407 4090 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $56430 m0 *1 664.24,514.08
X$56430 407 3987 4118 3843 4107 4108 407 4105 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $56431 r0 *1 665.16,514.08
X$56431 407 3805 375 407 4131 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56438 m0 *1 669.76,514.08
X$56438 407 4109 375 407 4117 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56440 r0 *1 670.22,514.08
X$56440 407 4135 375 407 4127 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56441 m0 *1 673.44,514.08
X$56441 407 4097 375 407 4110 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56442 r0 *1 673.9,514.08
X$56442 407 4112 375 407 3543 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56484 m0 *1 91.54,519.52
X$56484 375 4104 4143 4114 4134 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $56494 m0 *1 118.22,519.52
X$56494 407 4114 375 407 375 sky130_fd_sc_hd__clkinv_4
* cell instance $56496 m0 *1 121.9,519.52
X$56496 407 4153 375 407 4137 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $56714 m0 *1 615.48,519.52
X$56714 407 3997 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $56730 m0 *1 652.74,519.52
X$56730 407 3945 4118 4126 4107 4138 407 4139 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $56731 m0 *1 655.96,519.52
X$56731 407 4127 3392 4126 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $56734 m0 *1 659.64,519.52
X$56734 375 4128 4118 4136 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $56737 m0 *1 664.7,519.52
X$56737 375 3139 4136 4119 4128 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $56741 m0 *1 674.36,519.52
X$56741 407 4111 407 4109 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $56781 r0 *1 93.38,519.52
X$56781 375 4133 4143 4113 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $56787 r0 *1 99.36,519.52
X$56787 375 4134 4143 6330 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $56792 r0 *1 116.38,519.52
X$56792 375 3858 4114 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $57025 r0 *1 650.9,519.52
X$57025 375 3139 4118 4119 4139 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $57029 r0 *1 663.32,519.52
X$57029 375 3139 4142 4119 4144 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $57034 r0 *1 673.9,519.52
X$57034 407 4132 407 4135 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $57142 r0 *1 138,524.96
X$57142 375 4104 4141 4114 4145 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $57149 m0 *1 146.28,524.96
X$57149 407 4141 375 407 3569 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57567 m0 *1 666.08,524.96
X$57567 375 4144 4108 4142 3759 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $57570 m0 *1 670.68,524.96
X$57570 407 4136 375 407 4094 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57572 m0 *1 674.36,524.96
X$57572 407 4142 375 407 4129 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57692 r0 *1 139.84,530.4
X$57692 375 4104 4147 4114 4150 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $57695 m0 *1 145.82,530.4
X$57695 375 4145 4147 4141 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $58089 m0 *1 614.1,530.4
X$58089 407 4148 407 375 3759 375 sky130_fd_sc_hd__buf_4
* cell instance $58261 m0 *1 146.28,535.84
X$58261 375 4150 4147 4151 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $58646 r0 *1 607.66,535.84
X$58646 407 3831 3742 3832 4148 375 407 375 sky130_fd_sc_hd__nand3b_1
* cell instance $58661 r0 *1 622.84,535.84
X$58661 407 4149 407 375 3843 375 sky130_fd_sc_hd__buf_4
* cell instance $58663 m0 *1 624.22,535.84
X$58663 407 4149 407 375 3234 375 sky130_fd_sc_hd__buf_4
* cell instance $58682 m0 *1 645.38,535.84
X$58682 375 2992 4119 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $58683 r0 *1 645.38,535.84
X$58683 407 4119 375 407 375 sky130_fd_sc_hd__clkinv_4
* cell instance $58885 m0 *1 211.14,541.28
X$58885 407 4171 375 407 4151 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59215 r0 *1 608.58,541.28
X$59215 407 4148 407 375 4156 375 sky130_fd_sc_hd__buf_4
* cell instance $59681 r0 *1 486.22,546.72
X$59681 375 4162 3999 4155 4156 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $59684 r0 *1 492.2,546.72
X$59684 375 4165 4157 4154 4166 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $59686 m0 *1 494.96,546.72
X$59686 407 4041 4156 4167 407 4166 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $59706 m0 *1 517.04,546.72
X$59706 407 4163 375 407 3228 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $59784 r0 *1 610.88,546.72
X$59784 407 4015 4052 4161 4054 4158 407 4159 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $59791 m0 *1 614.1,546.72
X$59791 407 4015 4054 4052 3843 375 4158 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $60211 r0 *1 445.28,552.16
X$60211 407 4157 375 407 4172 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60242 m0 *1 482.54,552.16
X$60242 375 4165 4155 4154 4162 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $60252 m0 *1 495.88,552.16
X$60252 407 4157 4156 4167 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $60263 m0 *1 506.46,552.16
X$60263 407 4226 375 407 3286 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60268 m0 *1 511.52,552.16
X$60268 407 4164 375 407 3227 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60284 m0 *1 528.54,552.16
X$60284 407 4179 375 407 3181 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60351 m0 *1 609.04,552.16
X$60351 375 4160 4052 3997 4159 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $60821 r0 *1 495.42,557.6
X$60821 375 4165 4164 4154 4187 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $60833 m0 *1 506.92,557.6
X$60833 375 4165 4168 4154 4183 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $60834 r0 *1 507.38,557.6
X$60834 407 3952 4173 4184 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $60835 r0 *1 508.76,557.6
X$60835 407 4168 4184 4182 407 4183 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $60842 r0 *1 516.58,557.6
X$60842 375 4165 4179 4154 4201 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $60850 m0 *1 527.62,557.6
X$60850 407 4168 375 407 3323 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60857 m0 *1 534.98,557.6
X$60857 375 4160 3823 4170 4169 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $61132 r0 *1 191.36,563.04
X$61132 375 4031 3858 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $61184 m0 *1 257.14,563.04
X$61184 375 4031 4194 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $61373 r0 *1 486.68,563.04
X$61373 375 4165 4185 4154 4290 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $61375 m0 *1 493.12,563.04
X$61375 375 4154 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $61376 r0 *1 495.88,563.04
X$61376 375 3947 4154 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $61378 m0 *1 498.64,563.04
X$61378 407 4164 4235 4188 407 4187 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $61379 m0 *1 500.48,563.04
X$61379 407 4164 4186 4188 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61381 m0 *1 502.78,563.04
X$61381 407 4185 375 407 3287 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61387 m0 *1 508.3,563.04
X$61387 407 3648 4173 4175 407 4174 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $61390 m0 *1 510.14,563.04
X$61390 407 4168 4174 4182 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61391 r0 *1 510.14,563.04
X$61391 407 4168 407 375 4203 375 sky130_fd_sc_hd__inv_1
* cell instance $61396 m0 *1 512.44,563.04
X$61396 407 3648 4176 4175 407 4178 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $61397 r0 *1 512.9,563.04
X$61397 407 4176 4179 407 4200 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $61398 m0 *1 514.28,563.04
X$61398 407 3952 4176 4177 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61399 m0 *1 515.66,563.04
X$61399 407 4179 4178 4180 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61401 r0 *1 516.58,563.04
X$61401 375 4199 4197 3650 4200 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $61402 m0 *1 517.04,563.04
X$61402 407 4179 4177 4180 407 4201 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $61404 r0 *1 521.18,563.04
X$61404 407 2906 407 375 4195 375 sky130_fd_sc_hd__inv_1
* cell instance $61408 r0 *1 523.94,563.04
X$61408 407 4168 4179 4193 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $61422 m0 *1 535.9,563.04
X$61422 407 3831 4181 4169 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $61678 m0 *1 314.64,568.48
X$61678 407 4227 407 375 4229 375 sky130_fd_sc_hd__inv_1
* cell instance $61679 m0 *1 316.02,568.48
X$61679 407 4207 4228 4231 375 407 4232 375 sky130_fd_sc_hd__a21o_1
* cell instance $61680 m0 *1 318.78,568.48
X$61680 407 4202 407 375 4234 375 sky130_fd_sc_hd__inv_1
* cell instance $61756 m0 *1 494.96,568.48
X$61756 407 3952 4209 4235 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61757 m0 *1 496.34,568.48
X$61757 407 3648 4209 4175 407 4186 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $61760 m0 *1 499.56,568.48
X$61760 375 4165 4163 4154 4331 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $61765 m0 *1 510.14,568.48
X$61765 407 4173 4203 4211 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $61769 m0 *1 516.58,568.48
X$61769 407 4224 4199 4223 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $61770 m0 *1 517.96,568.48
X$61770 375 4224 4220 4211 4195 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $61776 m0 *1 527.16,568.48
X$61776 375 4160 4214 4170 4217 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $61780 m0 *1 538.2,568.48
X$61780 407 4213 375 407 2946 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61781 m0 *1 541.88,568.48
X$61781 407 4214 375 407 3429 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61788 m0 *1 556.6,568.48
X$61788 407 4216 375 407 2895 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $61919 r0 *1 191.36,568.48
X$61919 375 3858 407 407 375 sky130_fd_sc_hd__clkinv_8
* cell instance $61934 r0 *1 225.86,568.48
X$61934 407 4189 407 375 4218 375 sky130_fd_sc_hd__inv_1
* cell instance $61935 r0 *1 227.24,568.48
X$61935 407 4191 407 375 4238 375 sky130_fd_sc_hd__inv_1
* cell instance $61940 r0 *1 233.68,568.48
X$61940 407 4190 407 375 4249 375 sky130_fd_sc_hd__inv_1
* cell instance $61952 r0 *1 258.98,568.48
X$61952 407 4192 407 375 4248 375 sky130_fd_sc_hd__inv_1
* cell instance $61959 r0 *1 266.34,568.48
X$61959 375 4251 4205 4238 4204 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $61960 r0 *1 270.94,568.48
X$61960 407 4221 4222 4205 375 407 4285 375 sky130_fd_sc_hd__a21oi_1
* cell instance $61963 r0 *1 276.92,568.48
X$61963 407 4206 407 375 4253 375 sky130_fd_sc_hd__inv_1
* cell instance $61976 r0 *1 302.22,568.48
X$61976 375 4104 4198 4257 4261 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $61977 r0 *1 311.42,568.48
X$61977 407 4196 407 375 4230 375 sky130_fd_sc_hd__inv_1
* cell instance $61980 r0 *1 314.18,568.48
X$61980 375 4208 4228 4230 4260 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $61982 r0 *1 319.24,568.48
X$61982 407 4207 4339 4208 4233 407 4264 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $62052 r0 *1 493.58,568.48
X$62052 407 4209 4210 4268 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $62055 r0 *1 498.18,568.48
X$62055 407 4164 407 375 4210 375 sky130_fd_sc_hd__inv_1
* cell instance $62059 r0 *1 502.78,568.48
X$62059 407 4163 4164 4226 4185 375 407 4265 375 sky130_fd_sc_hd__and4_1
* cell instance $62067 r0 *1 519.8,568.48
X$62067 407 4197 4199 4220 375 407 4263 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62070 r0 *1 524.4,568.48
X$62070 407 4219 4212 4240 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $62072 r0 *1 526.24,568.48
X$62072 407 4213 4216 4212 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62073 r0 *1 527.62,568.48
X$62073 407 4240 4214 407 4241 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $62104 r0 *1 598,568.48
X$62104 375 4246 4053 4215 4156 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $62248 m0 *1 258.98,573.92
X$62248 375 4236 4237 4248 4347 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62251 m0 *1 265.88,573.92
X$62251 407 4236 4282 4252 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62252 m0 *1 267.26,573.92
X$62252 407 4284 4282 4237 375 407 4250 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62255 m0 *1 270.48,573.92
X$62255 407 4222 4251 4270 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62257 m0 *1 272.78,573.92
X$62257 375 4222 4221 4218 4239 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62265 m0 *1 286.58,573.92
X$62265 375 4104 4225 4254 4255 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62270 m0 *1 305.9,573.92
X$62270 407 4258 4259 407 4260 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $62274 m0 *1 313.72,573.92
X$62274 375 4207 4231 4234 4262 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62276 m0 *1 318.78,573.92
X$62276 407 4233 4232 4292 375 407 4293 375 sky130_fd_sc_hd__a21o_1
* cell instance $62351 m0 *1 477.94,573.92
X$62351 375 4165 4226 4154 4345 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62355 m0 *1 493.58,573.92
X$62355 375 4269 4267 3238 4268 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62362 m0 *1 509.68,573.92
X$62362 407 4247 4266 4286 4219 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $62365 m0 *1 513.82,573.92
X$62365 407 3952 4219 4283 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62369 m0 *1 523.02,573.92
X$62369 407 4214 3648 4219 4212 4242 407 375 375 sky130_fd_sc_hd__or4_1
* cell instance $62371 m0 *1 526.24,573.92
X$62371 407 4214 3952 4256 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62373 m0 *1 528.08,573.92
X$62373 407 4240 4256 4242 4243 4217 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $62377 m0 *1 531.3,573.92
X$62377 407 4214 4244 4243 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62380 m0 *1 537.28,573.92
X$62380 407 4247 375 407 3408 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62392 m0 *1 560.28,573.92
X$62392 407 4280 375 407 3299 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62407 m0 *1 593.86,573.92
X$62407 375 4160 4215 3997 4246 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62549 r0 *1 264.96,573.92
X$62549 375 4282 4284 4249 4273 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62550 r0 *1 269.56,573.92
X$62550 407 4250 4270 4285 407 4326 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62551 r0 *1 271.4,573.92
X$62551 407 4270 4252 4271 4301 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $62552 r0 *1 273.24,573.92
X$62552 407 4287 4272 4271 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $62553 r0 *1 274.62,573.92
X$62553 375 4287 4272 4253 4289 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62559 r0 *1 287.96,573.92
X$62559 407 4274 4225 4204 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $62564 r0 *1 294.86,573.92
X$62564 375 4104 4259 4257 4329 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62567 r0 *1 305.44,573.92
X$62567 407 4198 4275 4335 407 4261 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62568 r0 *1 307.28,573.92
X$62568 407 4308 4276 4275 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62569 r0 *1 308.66,573.92
X$62569 407 4276 4198 407 4291 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $62572 r0 *1 313.72,573.92
X$62572 375 4233 4292 4229 4291 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62576 r0 *1 322.92,573.92
X$62576 407 4277 375 407 4295 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $62577 r0 *1 326.6,573.92
X$62577 407 4295 407 375 4294 375 sky130_fd_sc_hd__inv_1
* cell instance $62581 r0 *1 333.96,573.92
X$62581 375 4104 4296 4297 4341 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62643 r0 *1 485.3,573.92
X$62643 407 4185 3648 4336 4278 407 375 4290 375 sky130_fd_sc_hd__o31ai_1
* cell instance $62644 r0 *1 488.06,573.92
X$62644 407 4244 4334 4185 407 4278 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62652 r0 *1 508.76,573.92
X$62652 407 4288 4193 4286 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $62657 r0 *1 513.82,573.92
X$62657 407 4283 4175 4213 4325 375 407 4279 375 sky130_fd_sc_hd__a31oi_1
* cell instance $62658 r0 *1 516.12,573.92
X$62658 375 4165 4213 4170 4279 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62660 r0 *1 527.16,573.92
X$62660 375 4281 4322 3567 4241 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62771 m0 *1 118.22,579.36
X$62771 375 4298 4299 4245 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $62772 m0 *1 122.36,579.36
X$62772 375 4104 4299 4300 4298 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62836 m0 *1 270.94,579.36
X$62836 407 4326 4327 4301 375 407 4303 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62840 m0 *1 277.84,579.36
X$62840 375 4104 4302 4254 4328 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62844 m0 *1 287.96,579.36
X$62844 407 4225 4330 4274 4373 407 375 4255 375 sky130_fd_sc_hd__o31ai_1
* cell instance $62848 m0 *1 299,579.36
X$62848 407 4259 4304 4307 407 4329 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62849 m0 *1 300.84,579.36
X$62849 407 4305 4306 4259 407 4307 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62850 m0 *1 302.68,579.36
X$62850 407 4308 4258 4304 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62854 m0 *1 305.9,579.36
X$62854 407 4330 4276 4353 407 4309 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62855 m0 *1 307.74,579.36
X$62855 407 4198 4309 4335 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62856 m0 *1 309.12,579.36
X$62856 407 4310 4330 4312 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $62857 m0 *1 310.5,579.36
X$62857 407 4311 4312 4310 4313 375 4338 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $62862 m0 *1 316.02,579.36
X$62862 407 4311 4310 407 4314 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $62864 m0 *1 319.7,579.36
X$62864 407 4264 4303 4315 407 4340 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62865 m0 *1 321.54,579.36
X$62865 407 4316 4339 4293 375 407 4315 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62866 m0 *1 323.38,579.36
X$62866 375 4339 4342 4294 4314 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $62872 m0 *1 335.34,579.36
X$62872 407 4296 4343 4344 407 4341 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62873 m0 *1 337.18,579.36
X$62873 407 4296 4317 4344 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62878 m0 *1 343.16,579.36
X$62878 375 4104 4318 4297 4346 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $62936 m0 *1 477.48,579.36
X$62936 407 4226 3648 4337 4378 407 375 4345 375 sky130_fd_sc_hd__o31ai_1
* cell instance $62938 m0 *1 482.08,579.36
X$62938 407 4185 4377 4319 4337 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $62940 m0 *1 484.84,579.36
X$62940 407 4266 4319 4336 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62941 m0 *1 486.22,579.36
X$62941 407 4336 4185 4333 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $62942 m0 *1 489.44,579.36
X$62942 407 3648 4266 4319 375 407 4334 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62950 m0 *1 500.02,579.36
X$62950 407 4163 4375 4332 407 4331 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $62951 m0 *1 501.86,579.36
X$62951 407 4163 4374 4332 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $62956 m0 *1 507.38,579.36
X$62956 407 4280 4319 4265 4288 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $62960 m0 *1 515.2,579.36
X$62960 407 4213 3952 4320 375 407 4325 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62967 m0 *1 528.08,579.36
X$62967 375 4216 4324 4213 4214 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $62971 m0 *1 530.84,579.36
X$62971 407 4322 4281 4367 375 407 4323 375 sky130_fd_sc_hd__a21oi_1
* cell instance $62984 m0 *1 559.36,579.36
X$62984 407 4321 375 407 3696 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63089 r0 *1 131.56,579.36
X$63089 375 4398 4299 4397 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $63113 r0 *1 189.98,579.36
X$63113 375 2165 4103 407 407 375 sky130_fd_sc_hd__buf_12
* cell instance $63140 r0 *1 261.74,579.36
X$63140 407 4369 4368 4330 4402 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63143 r0 *1 264.5,579.36
X$63143 407 4370 4369 4347 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63145 r0 *1 268.18,579.36
X$63145 407 4348 4440 4403 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63146 r0 *1 269.56,579.36
X$63146 407 4308 4289 4348 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63148 r0 *1 271.4,579.36
X$63148 375 4382 4407 4349 4409 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63150 r0 *1 276.46,579.36
X$63150 407 4351 4302 407 4409 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63151 r0 *1 279.68,579.36
X$63151 407 4302 4350 4384 407 4328 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63152 r0 *1 281.52,579.36
X$63152 407 4305 4385 4302 407 4384 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63153 r0 *1 283.36,579.36
X$63153 407 4302 4351 4383 4370 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63154 r0 *1 285.2,579.36
X$63154 407 4351 4308 4350 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63158 r0 *1 289.34,579.36
X$63158 407 4305 4411 4225 407 4373 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63161 r0 *1 292.1,579.36
X$63161 407 4376 4225 4458 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63164 r0 *1 295.78,579.36
X$63164 407 4330 4258 4306 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63165 r0 *1 297.16,579.36
X$63165 407 4257 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $63166 r0 *1 300.38,579.36
X$63166 407 4198 4352 4259 4413 375 407 4414 375 sky130_fd_sc_hd__and4_1
* cell instance $63168 r0 *1 304.06,579.36
X$63168 375 4352 4276 4259 4258 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $63170 r0 *1 306.82,579.36
X$63170 407 4423 4352 407 4262 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63172 r0 *1 310.96,579.36
X$63172 407 4330 4311 4353 407 4313 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63180 r0 *1 326.6,579.36
X$63180 407 4354 4388 4355 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63181 r0 *1 327.98,579.36
X$63181 407 4418 4355 4419 407 4316 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63183 r0 *1 330.28,579.36
X$63183 407 4380 4356 4574 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63185 r0 *1 332.58,579.36
X$63185 407 4391 4296 407 4420 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63186 r0 *1 335.8,579.36
X$63186 407 4308 4391 4343 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63188 r0 *1 337.64,579.36
X$63188 407 4330 4391 4353 407 4317 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63191 r0 *1 341.32,579.36
X$63191 407 4330 4357 4353 407 4358 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63192 r0 *1 343.16,579.36
X$63192 407 4318 4358 4381 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63193 r0 *1 344.54,579.36
X$63193 407 4318 4359 4381 407 4346 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63195 r0 *1 346.84,579.36
X$63195 407 4308 4357 4359 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63198 r0 *1 349.6,579.36
X$63198 407 4379 407 375 4421 375 sky130_fd_sc_hd__inv_1
* cell instance $63250 r0 *1 478.86,579.36
X$63250 407 4244 4392 4226 407 4378 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63251 r0 *1 480.7,579.36
X$63251 407 4319 4377 4185 3648 375 407 4392 375 sky130_fd_sc_hd__a31oi_1
* cell instance $63252 r0 *1 483,579.36
X$63252 407 4362 4393 4377 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63254 r0 *1 484.84,579.36
X$63254 407 4337 4226 4417 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63258 r0 *1 493.12,579.36
X$63258 407 4185 4226 4319 4360 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63259 r0 *1 494.96,579.36
X$63259 407 4372 4393 4360 4209 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $63260 r0 *1 496.8,579.36
X$63260 407 4360 4362 4210 4393 375 4361 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $63261 r0 *1 499.1,579.36
X$63261 407 3952 4361 4375 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63263 r0 *1 500.94,579.36
X$63263 407 3648 4361 4175 407 4374 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63268 r0 *1 506,579.36
X$63268 407 4362 4393 4288 4173 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $63269 r0 *1 507.84,579.36
X$63269 407 4288 4372 4203 4393 375 4176 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $63273 r0 *1 516.12,579.36
X$63273 407 4288 4394 4363 4371 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $63276 r0 *1 520.72,579.36
X$63276 407 4321 3648 4439 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63279 r0 *1 523.48,579.36
X$63279 407 4321 4244 4408 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63282 r0 *1 527.16,579.36
X$63282 407 4365 4193 4324 4363 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63283 r0 *1 529,579.36
X$63283 375 4405 4367 3585 4401 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63285 r0 *1 533.6,579.36
X$63285 407 4400 4216 4401 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63286 r0 *1 536.82,579.36
X$63286 407 3648 4400 4216 3392 4399 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $63289 r0 *1 540.5,579.36
X$63289 375 4160 4321 4170 4366 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63294 r0 *1 558.9,579.36
X$63294 407 4365 375 407 3337 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63313 r0 *1 602.6,579.36
X$63313 375 4396 4052 4364 4156 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $63399 m0 *1 130.18,584.8
X$63399 375 4104 4397 4300 4398 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63451 m0 *1 254.84,584.8
X$63451 375 4104 4369 4257 4437 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63454 m0 *1 264.04,584.8
X$63454 375 4104 4383 4254 4403 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63455 m0 *1 273.24,584.8
X$63455 407 4441 4382 4407 4272 375 4443 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $63459 m0 *1 277.84,584.8
X$63459 407 4302 375 407 4444 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63460 m0 *1 281.52,584.8
X$63460 375 4383 4386 4302 4369 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $63461 m0 *1 283.82,584.8
X$63461 407 4351 4330 4385 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63462 m0 *1 285.2,584.8
X$63462 407 4369 4383 4351 4302 375 407 4387 375 sky130_fd_sc_hd__and4_1
* cell instance $63467 m0 *1 289.8,584.8
X$63467 407 4330 4376 4387 375 407 4411 375 sky130_fd_sc_hd__a21oi_1
* cell instance $63469 m0 *1 292.56,584.8
X$63469 407 4412 4413 4239 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63470 m0 *1 295.78,584.8
X$63470 375 4194 4257 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $63472 m0 *1 305.44,584.8
X$63472 407 4330 4423 4415 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63474 m0 *1 307.28,584.8
X$63474 375 4198 4311 4352 4423 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $63476 m0 *1 311.42,584.8
X$63476 375 4104 4310 4257 4338 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63481 m0 *1 326.14,584.8
X$63481 407 4452 4389 4390 407 4453 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63482 m0 *1 327.98,584.8
X$63482 407 4356 4390 4389 375 407 4418 375 sky130_fd_sc_hd__a21oi_1
* cell instance $63483 m0 *1 329.82,584.8
X$63483 407 4380 4354 4463 4342 375 4419 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $63485 m0 *1 333.04,584.8
X$63485 375 4388 4380 4421 4420 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63490 m0 *1 340.4,584.8
X$63490 407 4391 4318 4296 4330 375 407 4450 375 sky130_fd_sc_hd__a31oi_1
* cell instance $63492 m0 *1 343.16,584.8
X$63492 375 4104 4425 4297 4449 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63494 m0 *1 353.28,584.8
X$63494 407 4305 4448 4445 407 4446 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63561 m0 *1 500.94,584.8
X$63561 407 4361 4163 407 4416 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63566 m0 *1 508.3,584.8
X$63566 407 4265 4280 4319 4193 407 4426 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $63568 m0 *1 511.52,584.8
X$63568 407 4426 4394 4320 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $63570 m0 *1 513.82,584.8
X$63570 407 4320 4213 407 4410 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63571 m0 *1 517.04,584.8
X$63571 375 4427 4442 3492 4410 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63572 m0 *1 521.64,584.8
X$63572 407 4371 4439 4395 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63573 m0 *1 523.02,584.8
X$63573 407 4371 4438 4408 4395 4366 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $63576 m0 *1 526.7,584.8
X$63576 407 4281 4436 4405 4429 407 4406 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $63578 m0 *1 529.46,584.8
X$63578 375 4436 4434 3740 4404 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63582 m0 *1 534.52,584.8
X$63582 407 4247 4213 4435 4400 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63584 m0 *1 537.28,584.8
X$63584 407 4216 3648 4400 4399 407 375 4433 375 sky130_fd_sc_hd__o31ai_1
* cell instance $63586 m0 *1 540.5,584.8
X$63586 375 4160 4216 4170 4433 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63609 m0 *1 598.46,584.8
X$63609 375 4160 4364 4119 4396 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63685 r0 *1 102.58,584.8
X$63685 375 4468 4469 4432 3260 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $63696 r0 *1 128.34,584.8
X$63696 407 4300 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $63700 r0 *1 140.76,584.8
X$63700 407 4397 375 407 4470 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63723 r0 *1 191.82,584.8
X$63723 375 4104 4495 4471 4556 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63745 r0 *1 255.76,584.8
X$63745 407 4369 375 407 4474 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63749 r0 *1 260.82,584.8
X$63749 407 4454 4402 4437 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63750 r0 *1 262.2,584.8
X$63750 407 4308 4347 4454 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63753 r0 *1 264.96,584.8
X$63753 407 4476 407 375 4349 375 sky130_fd_sc_hd__inv_1
* cell instance $63754 r0 *1 266.34,584.8
X$63754 407 4383 4368 4330 4440 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63756 r0 *1 269.1,584.8
X$63756 375 4478 4441 4479 4455 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63757 r0 *1 273.7,584.8
X$63757 375 4194 4254 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $63759 r0 *1 283.36,584.8
X$63759 407 4459 4383 4289 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63761 r0 *1 286.58,584.8
X$63761 407 4383 4369 4457 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63762 r0 *1 287.96,584.8
X$63762 407 4376 4387 4274 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63765 r0 *1 291.64,584.8
X$63765 407 4422 4457 4459 4458 375 4423 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $63766 r0 *1 293.94,584.8
X$63766 407 4376 4225 4501 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $63767 r0 *1 296.24,584.8
X$63767 407 4413 4259 4422 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63769 r0 *1 298.54,584.8
X$63769 407 4308 4423 4482 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63770 r0 *1 299.92,584.8
X$63770 375 4104 4352 4257 4483 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63773 r0 *1 310.5,584.8
X$63773 407 4310 4485 4311 4451 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $63777 r0 *1 313.72,584.8
X$63777 407 4305 4486 4424 407 4460 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63778 r0 *1 315.56,584.8
X$63778 407 4424 4330 4451 4460 407 375 4487 375 sky130_fd_sc_hd__o31ai_1
* cell instance $63782 r0 *1 319.7,584.8
X$63782 407 4451 4424 4461 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63783 r0 *1 322.92,584.8
X$63783 407 4485 4424 4491 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63784 r0 *1 324.3,584.8
X$63784 375 4390 4356 4462 4461 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63785 r0 *1 328.9,584.8
X$63785 407 4297 407 375 375 sky130_fd_sc_hd__inv_6
* cell instance $63786 r0 *1 332.12,584.8
X$63786 375 4194 4297 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $63788 r0 *1 341.32,584.8
X$63788 407 4357 4318 407 4492 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63789 r0 *1 344.54,584.8
X$63789 407 4305 4450 4425 407 4493 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $63794 r0 *1 350.06,584.8
X$63794 407 4357 4425 4318 4330 375 407 4448 375 sky130_fd_sc_hd__a31oi_1
* cell instance $63796 r0 *1 352.82,584.8
X$63796 375 4104 4445 4297 4447 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63830 r0 *1 444.82,584.8
X$63830 407 4364 375 407 4484 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63833 r0 *1 450.34,584.8
X$63833 407 4155 375 407 4541 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63834 r0 *1 454.02,584.8
X$63834 407 4103 407 375 4165 375 sky130_fd_sc_hd__buf_4
* cell instance $63856 r0 *1 506.46,584.8
X$63856 407 4319 4265 4812 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63857 r0 *1 507.84,584.8
X$63857 375 4362 4435 4393 4426 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $63863 r0 *1 518.88,584.8
X$63863 407 4442 4427 4428 375 407 4480 375 sky130_fd_sc_hd__a21oi_1
* cell instance $63865 r0 *1 521.18,584.8
X$63865 407 4321 3952 4438 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63866 r0 *1 522.56,584.8
X$63866 407 4371 4321 407 4404 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $63869 r0 *1 527.16,584.8
X$63869 407 4436 4429 4475 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $63870 r0 *1 528.54,584.8
X$63870 407 4434 4436 4430 375 407 4473 375 sky130_fd_sc_hd__a21oi_1
* cell instance $63872 r0 *1 530.38,584.8
X$63872 375 4429 4430 4431 3669 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $63873 r0 *1 534.98,584.8
X$63873 407 4472 4365 4431 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $63974 m0 *1 100.28,590.24
X$63974 375 4104 4469 4300 4468 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $63986 m0 *1 128.34,590.24
X$63986 375 3858 4300 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $64010 m0 *1 185.38,590.24
X$64010 375 4512 4514 4494 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64029 m0 *1 227.24,590.24
X$64029 375 4104 4496 4471 4560 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64034 m0 *1 238.74,590.24
X$64034 407 4580 407 375 3260 375 sky130_fd_sc_hd__buf_4
* cell instance $64039 m0 *1 250.24,590.24
X$64039 375 4104 4518 4297 4516 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64042 m0 *1 259.44,590.24
X$64042 407 4519 375 407 4476 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64045 m0 *1 268.64,590.24
X$64045 407 4478 4382 4523 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64047 m0 *1 270.48,590.24
X$64047 407 4455 4308 4522 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64048 m0 *1 271.86,590.24
X$64048 407 4524 4523 4443 407 4327 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64049 m0 *1 273.7,590.24
X$64049 407 4383 375 407 4498 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64052 m0 *1 278.3,590.24
X$64052 375 4455 4351 4456 4499 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64054 m0 *1 283.36,590.24
X$64054 407 4456 4499 4302 4459 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64058 m0 *1 287.04,590.24
X$64058 407 4564 4376 4273 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $64062 m0 *1 293.48,590.24
X$64062 407 4459 4457 4458 4412 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $64064 m0 *1 297.62,590.24
X$64064 375 4387 4258 4413 4501 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $64066 m0 *1 300.84,590.24
X$64066 407 4352 4482 4481 407 4483 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64067 m0 *1 302.68,590.24
X$64067 407 4305 4415 4352 407 4481 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64070 m0 *1 305.44,590.24
X$64070 407 4501 4310 4387 4414 407 4488 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $64074 m0 *1 310.96,590.24
X$64074 407 4311 4485 4310 4330 375 407 4486 375 sky130_fd_sc_hd__a31oi_1
* cell instance $64077 m0 *1 313.26,590.24
X$64077 375 4104 4424 4257 4487 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64078 m0 *1 322.46,590.24
X$64078 407 4488 4485 4490 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $64079 m0 *1 325.68,590.24
X$64079 375 4452 4389 4530 4490 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64080 m0 *1 330.28,590.24
X$64080 407 4463 4531 4532 407 375 375 sky130_fd_sc_hd__or2_2
* cell instance $64082 m0 *1 333.04,590.24
X$64082 407 4388 4380 4354 407 4529 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64084 m0 *1 335.34,590.24
X$64084 375 4354 4463 4538 4492 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64088 m0 *1 340.4,590.24
X$64088 407 4296 4318 4391 4464 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64089 m0 *1 342.24,590.24
X$64089 407 4425 4330 4464 4493 407 375 4449 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64090 m0 *1 345,590.24
X$64090 407 4464 4425 4528 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $64093 m0 *1 350.52,590.24
X$64093 407 4318 4425 4357 4489 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64095 m0 *1 352.82,590.24
X$64095 407 4445 4330 4489 4446 407 375 4447 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64154 m0 *1 486.22,590.24
X$64154 375 4527 4505 2909 4333 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64155 m0 *1 490.82,590.24
X$64155 375 4506 4465 3239 4417 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64156 m0 *1 495.42,590.24
X$64156 407 4465 4269 4509 4267 375 4525 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $64166 m0 *1 516.12,590.24
X$64166 407 4406 4466 4223 4508 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $64167 m0 *1 517.96,590.24
X$64167 407 4263 4466 4480 407 4521 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64168 m0 *1 519.8,590.24
X$64168 407 4427 4467 4466 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64169 m0 *1 521.18,590.24
X$64169 375 4467 4428 2932 4477 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64172 m0 *1 528.08,590.24
X$64172 407 4324 4435 4247 3648 375 407 4515 375 sky130_fd_sc_hd__a31oi_1
* cell instance $64175 m0 *1 530.38,590.24
X$64175 407 4247 4435 4324 4472 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64177 m0 *1 533.14,590.24
X$64177 375 3947 4170 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $64178 m0 *1 542.34,590.24
X$64178 375 4160 4365 4170 4513 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64202 m0 *1 604.44,590.24
X$64202 375 4511 4054 4543 4156 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64278 r0 *1 106.26,590.24
X$64278 375 4104 4601 4300 4555 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64307 r0 *1 181.24,590.24
X$64307 375 4104 4494 4300 4512 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64308 r0 *1 190.44,590.24
X$64308 407 4494 375 407 4557 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64309 r0 *1 194.12,590.24
X$64309 375 4556 4627 4495 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64310 r0 *1 198.26,590.24
X$64310 407 4495 375 407 4809 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64320 r0 *1 217.58,590.24
X$64320 375 4104 4559 4471 4558 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64321 r0 *1 226.78,590.24
X$64321 375 4560 4533 4496 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64330 r0 *1 241.5,590.24
X$64330 407 4496 375 407 4534 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64334 r0 *1 253.46,590.24
X$64334 375 4104 4535 4254 4517 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64339 r0 *1 265.88,590.24
X$64339 407 4368 4330 4353 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64342 r0 *1 271.4,590.24
X$64342 407 4584 4497 4522 407 4562 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64344 r0 *1 273.7,590.24
X$64344 407 4254 375 407 375 sky130_fd_sc_hd__clkinv_4
* cell instance $64346 r0 *1 277.38,590.24
X$64346 407 4499 4330 4497 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64348 r0 *1 280.6,590.24
X$64348 407 4456 4499 4386 4564 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64349 r0 *1 282.44,590.24
X$64349 407 4386 4499 4456 4330 375 407 4536 375 sky130_fd_sc_hd__a31oi_1
* cell instance $64350 r0 *1 284.74,590.24
X$64350 407 4305 4536 4376 407 4500 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64352 r0 *1 286.58,590.24
X$64352 407 4376 4330 4564 4500 407 375 4565 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64361 r0 *1 309.12,590.24
X$64361 407 4352 375 407 4615 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64362 r0 *1 312.8,590.24
X$64362 407 4310 375 407 4568 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64364 r0 *1 316.48,590.24
X$64364 407 4310 4414 4502 4569 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64367 r0 *1 319.24,590.24
X$64367 375 4424 4502 4485 4296 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $64370 r0 *1 326.14,590.24
X$64370 407 4573 407 375 4462 375 sky130_fd_sc_hd__inv_1
* cell instance $64371 r0 *1 327.52,590.24
X$64371 407 4572 407 375 4530 375 sky130_fd_sc_hd__inv_1
* cell instance $64372 r0 *1 328.9,590.24
X$64372 407 4529 4453 4574 375 407 4531 375 sky130_fd_sc_hd__a21oi_1
* cell instance $64375 r0 *1 333.5,590.24
X$64375 407 4488 4491 4391 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $64380 r0 *1 342.7,590.24
X$64380 407 4425 375 407 4575 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64385 r0 *1 350.06,590.24
X$64385 407 4318 4425 4445 4576 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64388 r0 *1 354.2,590.24
X$64388 407 4489 4445 5127 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $64390 r0 *1 357.88,590.24
X$64390 375 4104 4540 4297 4619 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64433 r0 *1 466.44,590.24
X$64433 375 4165 4544 4154 4503 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64437 r0 *1 479.78,590.24
X$64437 375 4504 4547 4542 4546 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64441 r0 *1 487.6,590.24
X$64441 407 4505 4527 4547 375 407 4548 375 sky130_fd_sc_hd__a21oi_1
* cell instance $64442 r0 *1 489.44,590.24
X$64442 407 4527 4506 4269 4504 407 4526 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $64443 r0 *1 491.74,590.24
X$64443 407 4506 4269 4507 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64444 r0 *1 493.12,590.24
X$64444 407 4507 4548 4549 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $64447 r0 *1 496.8,590.24
X$64447 407 4508 4570 4571 4509 4549 4520 407 375 375 sky130_fd_sc_hd__o221ai_1
* cell instance $64454 r0 *1 512.44,590.24
X$64454 407 3648 4435 4175 407 4510 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64455 r0 *1 514.28,590.24
X$64455 407 4247 4510 4563 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64458 r0 *1 518.42,590.24
X$64458 407 4435 4247 407 4477 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $64460 r0 *1 522.1,590.24
X$64460 407 4521 4406 4561 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $64461 r0 *1 524.4,590.24
X$64461 407 4561 4520 4473 4475 4323 407 4552 375 375 sky130_fd_sc_hd__o2111ai_1
* cell instance $64465 r0 *1 532.22,590.24
X$64465 407 4244 4515 4365 407 4554 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64466 r0 *1 534.06,590.24
X$64466 407 4170 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $64467 r0 *1 535.44,590.24
X$64467 407 4365 3648 4472 4554 407 375 4513 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64495 r0 *1 602.6,590.24
X$64495 375 4160 4543 4119 4511 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64569 m0 *1 107.64,595.68
X$64569 375 4555 4469 4601 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64616 m0 *1 218.04,595.68
X$64616 375 4558 4579 4559 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $64619 m0 *1 223.1,595.68
X$64619 375 4104 4579 4471 4578 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64632 m0 *1 256.68,595.68
X$64632 407 4535 4583 4518 407 4517 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $64636 m0 *1 261.28,595.68
X$64636 407 4535 375 407 4608 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64640 m0 *1 268.18,595.68
X$64640 375 4104 4499 4254 4562 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64644 m0 *1 279.22,595.68
X$64644 407 4499 375 407 4609 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64646 m0 *1 283.82,595.68
X$64646 407 4376 375 407 4611 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64649 m0 *1 287.5,595.68
X$64649 375 4104 4376 4254 4565 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64651 m0 *1 297.62,595.68
X$64651 407 4413 4330 4412 4587 407 375 4613 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64652 m0 *1 300.38,595.68
X$64652 407 4305 4677 4413 407 4587 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64658 m0 *1 307.74,595.68
X$64658 407 4485 4330 4488 4614 407 375 4567 375 sky130_fd_sc_hd__o31ai_1
* cell instance $64660 m0 *1 311.42,595.68
X$64660 375 4104 4485 4588 4567 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64664 m0 *1 321.08,595.68
X$64664 407 4485 4424 4296 4537 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64670 m0 *1 333.04,595.68
X$64670 407 4296 375 407 4620 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64676 m0 *1 343.16,595.68
X$64676 407 4318 375 407 6074 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64679 m0 *1 349.14,595.68
X$64679 407 4540 4445 4425 4318 375 407 4622 375 sky130_fd_sc_hd__and4_1
* cell instance $64680 m0 *1 352.36,595.68
X$64680 407 4488 4537 4576 4539 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $64681 m0 *1 354.2,595.68
X$64681 407 4330 4539 4353 407 4621 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64683 m0 *1 356.5,595.68
X$64683 407 4445 375 407 5241 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64694 m0 *1 383.64,595.68
X$64694 407 4156 407 375 4618 375 sky130_fd_sc_hd__buf_4
* cell instance $64723 m0 *1 444.36,595.68
X$64723 407 4617 407 375 4542 375 sky130_fd_sc_hd__inv_1
* cell instance $64737 m0 *1 473.8,595.68
X$64737 407 4544 4545 4577 407 4503 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64741 m0 *1 476.1,595.68
X$64741 407 3952 4593 4545 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64743 m0 *1 477.94,595.68
X$64743 407 4544 4612 4577 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64745 m0 *1 481.16,595.68
X$64745 407 4593 4544 407 4546 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $64750 m0 *1 494.04,595.68
X$64750 407 4526 4595 4607 4525 4570 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $64755 m0 *1 499.1,595.68
X$64755 407 4596 4566 4597 407 4571 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $64757 m0 *1 502.32,595.68
X$64757 375 4597 4566 3279 4416 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64762 m0 *1 512.44,595.68
X$64762 407 3952 4435 4551 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64763 m0 *1 513.82,595.68
X$64763 407 4247 4551 4563 407 4606 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64765 m0 *1 516.58,595.68
X$64765 375 4160 4247 4550 4606 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64768 m0 *1 526.7,595.68
X$64768 375 4160 4553 4170 4599 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64775 m0 *1 546.02,595.68
X$64775 407 4553 375 407 4130 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64779 m0 *1 555.68,595.68
X$64779 375 3628 3758 4600 3742 3832 407 407 375 sky130_fd_sc_hd__nor4bb_4
* cell instance $64803 m0 *1 611.34,595.68
X$64803 407 3628 407 375 3952 375 sky130_fd_sc_hd__buf_4
* cell instance $64899 r0 *1 164.68,595.68
X$64899 375 4104 4654 4652 4653 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64910 r0 *1 188.14,595.68
X$64910 375 4104 4602 4657 4656 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64912 r0 *1 199.18,595.68
X$64912 375 4104 4627 4657 4659 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64917 r0 *1 210.22,595.68
X$64917 407 4603 375 407 4663 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64920 r0 *1 218.5,595.68
X$64920 375 3858 4471 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $64921 r0 *1 227.7,595.68
X$64921 407 4579 4605 4666 4631 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $64922 r0 *1 229.54,595.68
X$64922 407 4579 4666 4631 4669 4578 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $64928 r0 *1 237.82,595.68
X$64928 407 4580 407 375 4736 375 sky130_fd_sc_hd__buf_4
* cell instance $64929 r0 *1 240.58,595.68
X$64929 375 4580 4581 4582 4518 4633 407 407 375 sky130_fd_sc_hd__nor4bb_4
* cell instance $64932 r0 *1 251.16,595.68
X$64932 407 4518 4582 407 4688 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $64933 r0 *1 254.38,595.68
X$64933 375 4104 4582 4844 4672 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64936 r0 *1 264.04,595.68
X$64936 407 4368 407 375 4605 375 sky130_fd_sc_hd__buf_4
* cell instance $64940 r0 *1 273.24,595.68
X$64940 407 4584 4308 4585 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $64941 r0 *1 274.62,595.68
X$64941 407 4585 407 375 4305 375 sky130_fd_sc_hd__buf_4
* cell instance $64944 r0 *1 279.68,595.68
X$64944 407 4456 4330 4727 407 4674 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64947 r0 *1 282.9,595.68
X$64947 407 4610 4586 4524 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $64951 r0 *1 286.58,595.68
X$64951 375 4610 4586 4676 4456 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $64956 r0 *1 294.86,595.68
X$64956 375 4104 4413 4588 4613 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64958 r0 *1 307.74,595.68
X$64958 407 4305 4678 4485 407 4614 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64964 r0 *1 319.24,595.68
X$64964 407 4424 375 407 4680 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64966 r0 *1 323.84,595.68
X$64966 407 4589 375 407 4573 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $64968 r0 *1 331.2,595.68
X$64968 375 4104 4590 4588 4679 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $64970 r0 *1 340.4,595.68
X$64970 407 4590 407 375 4637 375 sky130_fd_sc_hd__inv_1
* cell instance $64976 r0 *1 350.98,595.68
X$64976 407 4539 4540 407 4639 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $64977 r0 *1 354.2,595.68
X$64977 407 4308 4539 4591 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64978 r0 *1 355.58,595.68
X$64978 407 4540 4621 4641 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $64980 r0 *1 357.88,595.68
X$64980 407 4540 4591 4641 407 4619 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $64991 r0 *1 376.74,595.68
X$64991 407 4540 375 407 4616 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65015 r0 *1 438.84,595.68
X$65015 407 4543 375 407 4671 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65028 r0 *1 466.9,595.68
X$65028 375 4165 4643 4592 4668 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65030 r0 *1 476.1,595.68
X$65030 407 3648 4593 4175 407 4612 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65032 r0 *1 481.62,595.68
X$65032 407 4362 4393 4667 4593 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65038 r0 *1 493.12,595.68
X$65038 407 4662 4594 4719 375 407 4595 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65039 r0 *1 494.96,595.68
X$65039 407 4526 4646 4718 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65040 r0 *1 496.34,595.68
X$65040 407 4594 4596 4701 4597 407 4646 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $65041 r0 *1 498.64,595.68
X$65041 407 4596 4566 4607 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65046 r0 *1 506.46,595.68
X$65046 375 4596 4509 4658 3264 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $65055 r0 *1 526.7,595.68
X$65055 407 4604 4156 4650 375 407 4598 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65056 r0 *1 528.54,595.68
X$65056 375 4160 4600 4170 4598 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65064 r0 *1 548.78,595.68
X$65064 407 3674 375 407 4648 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65066 r0 *1 556.14,595.68
X$65066 407 4600 407 375 3831 375 sky130_fd_sc_hd__buf_4
* cell instance $65184 m0 *1 161,601.12
X$65184 407 4623 407 4153 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $65189 m0 *1 169.28,601.12
X$65189 375 4653 4602 4654 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $65191 m0 *1 177.1,601.12
X$65191 375 4103 4713 4711 4712 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65194 m0 *1 186.3,601.12
X$65194 407 4625 4624 4655 4602 375 4682 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $65195 m0 *1 189.06,601.12
X$65195 407 4625 4624 4626 4602 4682 407 4656 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $65197 m0 *1 193.2,601.12
X$65197 407 4664 4605 4626 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65201 m0 *1 196.42,601.12
X$65201 375 4627 4625 4514 4628 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $65202 m0 *1 198.72,601.12
X$65202 407 4628 4681 4627 4514 4655 407 4660 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $65203 m0 *1 201.94,601.12
X$65203 407 4625 4681 4661 4660 375 4659 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $65209 m0 *1 211.14,601.12
X$65209 407 4663 4605 4661 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65210 m0 *1 212.52,601.12
X$65210 407 4787 375 407 4664 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65212 m0 *1 217.12,601.12
X$65212 407 4471 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $65213 m0 *1 218.5,601.12
X$65213 407 4716 375 407 4717 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65215 m0 *1 222.64,601.12
X$65215 407 4559 375 407 4721 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65217 m0 *1 226.78,601.12
X$65217 407 4683 4630 4533 4629 407 4666 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $65219 m0 *1 230.92,601.12
X$65219 375 4104 4630 4471 4684 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65224 m0 *1 242.42,601.12
X$65224 407 4632 4655 4669 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65225 m0 *1 243.8,601.12
X$65225 407 4687 375 407 4632 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65227 m0 *1 248.4,601.12
X$65227 407 4633 407 375 4670 375 sky130_fd_sc_hd__inv_1
* cell instance $65230 m0 *1 251.16,601.12
X$65230 407 4819 4633 4688 375 407 4638 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65232 m0 *1 253.46,601.12
X$65232 407 4670 4688 4582 4690 375 4672 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $65234 m0 *1 257.6,601.12
X$65234 407 4582 4673 4634 4689 4691 4583 375 407 375 sky130_fd_sc_hd__a32oi_1
* cell instance $65237 m0 *1 260.82,601.12
X$65237 375 4368 4689 4634 4690 407 407 375 sky130_fd_sc_hd__nand3_2
* cell instance $65242 m0 *1 273.24,601.12
X$65242 407 4726 407 375 4479 375 sky130_fd_sc_hd__inv_1
* cell instance $65246 m0 *1 277.84,601.12
X$65246 375 4104 4456 4254 4674 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65249 m0 *1 287.04,601.12
X$65249 407 4730 375 407 4676 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65253 m0 *1 296.7,601.12
X$65253 407 4308 4412 4677 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $65259 m0 *1 307.28,601.12
X$65259 407 4308 4488 4678 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $65265 m0 *1 317.4,601.12
X$65265 375 375 4357 407 4412 4569 407 sky130_fd_sc_hd__nor2_2
* cell instance $65268 m0 *1 321.08,601.12
X$65268 407 4485 375 407 6073 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65274 m0 *1 333.5,601.12
X$65274 407 4305 4308 4636 375 407 4635 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65275 m0 *1 335.34,601.12
X$65275 407 4731 4636 4635 4637 4679 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $65276 m0 *1 337.64,601.12
X$65276 407 4637 4308 4731 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65277 m0 *1 339.02,601.12
X$65277 407 4590 4622 4693 4692 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $65283 m0 *1 344.08,601.12
X$65283 407 4357 4622 4728 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65286 m0 *1 350.98,601.12
X$65286 407 4696 4622 4640 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65287 m0 *1 352.36,601.12
X$65287 407 4488 4537 4640 4675 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65293 m0 *1 361.1,601.12
X$65293 407 2607 4645 1809 4638 375 5161 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $65327 m0 *1 439.3,601.12
X$65327 407 4699 375 407 4617 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65336 m0 *1 457.24,601.12
X$65336 375 4165 4642 4592 4724 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65345 m0 *1 477.48,601.12
X$65345 407 4544 4643 4642 4644 375 407 4319 375 sky130_fd_sc_hd__and4_1
* cell instance $65346 m0 *1 480.7,601.12
X$65346 407 4644 4642 4643 4667 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $65348 m0 *1 483,601.12
X$65348 407 4722 4723 4668 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65350 m0 *1 484.84,601.12
X$65350 407 4752 4643 407 4665 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $65352 m0 *1 488.52,601.12
X$65352 375 4594 4662 4751 4665 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $65355 m0 *1 495.42,601.12
X$65355 407 4508 4718 4720 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65367 m0 *1 517.5,601.12
X$65367 407 4703 4149 4715 407 4702 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $65369 m0 *1 522.1,601.12
X$65369 407 4552 4647 3952 407 4703 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65370 m0 *1 523.94,601.12
X$65370 407 4648 4715 4714 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65374 m0 *1 526.7,601.12
X$65374 407 4714 3831 4649 375 407 4645 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65379 m0 *1 533.14,601.12
X$65379 407 3742 3832 407 4649 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $65381 m0 *1 536.82,601.12
X$65381 407 4649 3831 4651 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $65384 m0 *1 541.42,601.12
X$65384 407 4651 4710 4709 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65388 m0 *1 548.78,601.12
X$65388 407 4124 375 407 4706 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65498 r0 *1 126.96,601.12
X$65498 407 4601 375 407 4708 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65513 r0 *1 172.04,601.12
X$65513 407 4654 375 407 4757 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65519 r0 *1 181.24,601.12
X$65519 375 4712 4835 4713 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $65523 r0 *1 188.6,601.12
X$65523 407 4625 4681 4733 4602 4655 407 4758 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $65526 r0 *1 195.96,601.12
X$65526 375 4627 4760 4514 4602 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $65535 r0 *1 211.14,601.12
X$65535 375 4104 4716 4471 4770 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65536 r0 *1 220.34,601.12
X$65536 375 4104 4533 4471 4764 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65538 r0 *1 230,601.12
X$65538 407 4683 4629 4766 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65539 r0 *1 231.38,601.12
X$65539 375 4767 4630 4765 4766 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $65545 r0 *1 240.58,601.12
X$65545 407 4686 4685 4770 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65548 r0 *1 244.26,601.12
X$65548 375 4518 4582 4670 407 4685 407 375 sky130_fd_sc_hd__nand3_4
* cell instance $65551 r0 *1 253,601.12
X$65551 407 4518 4673 4690 4689 4670 4773 375 407 375 sky130_fd_sc_hd__a32oi_1
* cell instance $65553 r0 *1 256.68,601.12
X$65553 407 4670 4691 4673 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65556 r0 *1 259.9,601.12
X$65556 407 4633 4582 4634 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65557 r0 *1 261.28,601.12
X$65557 375 4634 4584 4689 4690 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $65561 r0 *1 268.64,601.12
X$65561 407 4584 407 375 4655 375 sky130_fd_sc_hd__buf_4
* cell instance $65565 r0 *1 280.6,601.12
X$65565 407 4456 4305 4727 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65573 r0 *1 299,601.12
X$65573 407 4413 375 407 4776 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65577 r0 *1 307.74,601.12
X$65577 375 4104 4739 4588 4777 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65579 r0 *1 316.94,601.12
X$65579 407 4412 4569 4692 4742 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65582 r0 *1 320.16,601.12
X$65582 375 4488 4732 4537 4692 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $65584 r0 *1 324.3,601.12
X$65584 375 4104 4744 4588 4778 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65586 r0 *1 334.42,601.12
X$65586 407 4636 4590 4781 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $65587 r0 *1 337.64,601.12
X$65587 407 4357 4622 4693 4636 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $65588 r0 *1 339.48,601.12
X$65588 407 4330 4357 4622 375 407 4745 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65590 r0 *1 341.32,601.12
X$65590 407 4305 4745 4696 407 4694 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65591 r0 *1 343.16,601.12
X$65591 407 4696 4330 4728 4694 407 375 4780 375 sky130_fd_sc_hd__o31ai_1
* cell instance $65595 r0 *1 347.76,601.12
X$65595 407 4488 4537 4746 4729 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65596 r0 *1 349.6,601.12
X$65596 407 4695 4696 4747 4622 407 4746 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $65597 r0 *1 351.9,601.12
X$65597 407 4330 4675 4353 407 4697 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65598 r0 *1 353.74,601.12
X$65598 407 4308 4675 4698 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65599 r0 *1 355.12,601.12
X$65599 407 4747 4697 4748 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65600 r0 *1 356.5,601.12
X$65600 407 4747 4698 4748 407 4725 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65601 r0 *1 358.34,601.12
X$65601 375 4104 4747 4793 4725 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65637 r0 *1 455.4,601.12
X$65637 407 4642 4749 4700 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65640 r0 *1 458.16,601.12
X$65640 407 4642 3648 4750 4700 407 375 4724 375 sky130_fd_sc_hd__o31ai_1
* cell instance $65641 r0 *1 460.92,601.12
X$65641 407 3952 4750 4244 375 407 4749 375 sky130_fd_sc_hd__a21o_1
* cell instance $65643 r0 *1 464.14,601.12
X$65643 407 4643 375 407 4775 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65644 r0 *1 467.82,601.12
X$65644 407 4544 375 407 4774 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65649 r0 *1 476.56,601.12
X$65649 407 4750 4642 4771 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $65651 r0 *1 481.62,601.12
X$65651 407 4643 4752 3952 4723 375 407 375 sky130_fd_sc_hd__nand3b_1
* cell instance $65653 r0 *1 484.84,601.12
X$65653 407 4643 4772 4722 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65656 r0 *1 487.6,601.12
X$65656 375 4701 4719 4768 4771 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $65659 r0 *1 496.34,601.12
X$65659 407 4372 4393 4266 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65670 r0 *1 515.2,601.12
X$65670 375 4160 4715 4550 4702 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65673 r0 *1 525.78,601.12
X$65673 407 4704 4703 4599 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65678 r0 *1 530.38,601.12
X$65678 407 4756 4705 3758 375 407 4761 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65680 r0 *1 532.68,601.12
X$65680 407 4759 3832 4705 375 407 4181 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65681 r0 *1 534.52,601.12
X$65681 407 3742 4806 4553 407 4704 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65683 r0 *1 536.82,601.12
X$65683 407 3832 4706 3742 4710 375 407 375 sky130_fd_sc_hd__nand3b_1
* cell instance $65685 r0 *1 540.04,601.12
X$65685 375 4160 4707 4170 4709 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65686 r0 *1 549.24,601.12
X$65686 407 4707 407 375 3742 375 sky130_fd_sc_hd__buf_4
* cell instance $65813 m0 *1 174.34,606.56
X$65813 375 4104 4733 4657 4734 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65818 m0 *1 185.84,606.56
X$65818 407 4713 375 407 4782 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65819 m0 *1 189.52,606.56
X$65819 407 4758 4783 4734 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65826 m0 *1 201.94,606.56
X$65826 375 4104 4762 4471 4784 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65830 m0 *1 212.98,606.56
X$65830 375 4104 4813 4471 4763 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65833 m0 *1 224.48,606.56
X$65833 407 4735 4814 4764 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65834 m0 *1 225.86,606.56
X$65834 407 4629 4788 4533 4630 4655 407 4735 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $65836 m0 *1 230,606.56
X$65836 407 4630 4605 4765 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65840 m0 *1 231.84,606.56
X$65840 375 4104 4769 4471 4816 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65841 m0 *1 241.04,606.56
X$65841 407 4789 375 407 4817 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65844 m0 *1 247.48,606.56
X$65844 407 4670 4582 4518 4686 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $65847 m0 *1 251.16,606.56
X$65847 407 4670 4582 4737 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65849 m0 *1 253,606.56
X$65849 407 4736 4353 4518 4691 4737 4516 375 407 375 sky130_fd_sc_hd__a311o_1
* cell instance $65851 m0 *1 257.14,606.56
X$65851 407 4518 4691 4690 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $65855 m0 *1 260.36,606.56
X$65855 407 4518 4634 4821 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $65857 m0 *1 263.58,606.56
X$65857 407 4821 407 375 4884 375 sky130_fd_sc_hd__buf_4
* cell instance $65860 m0 *1 273.7,606.56
X$65860 407 4825 375 407 4726 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65864 m0 *1 280.14,606.56
X$65864 407 4456 375 407 4829 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $65880 m0 *1 313.26,606.56
X$65880 407 4308 4732 4738 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65881 m0 *1 314.64,606.56
X$65881 407 4739 4738 4740 407 4777 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65882 m0 *1 316.48,606.56
X$65882 407 4330 4732 4353 407 4741 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65883 m0 *1 318.32,606.56
X$65883 407 4739 4741 4740 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65886 m0 *1 323.84,606.56
X$65886 407 4330 4739 4742 375 407 4743 375 sky130_fd_sc_hd__a21oi_1
* cell instance $65887 m0 *1 325.68,606.56
X$65887 407 4305 4743 4744 407 4792 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65888 m0 *1 327.52,606.56
X$65888 407 4744 4330 4779 4792 407 375 4778 375 sky130_fd_sc_hd__o31ai_1
* cell instance $65895 m0 *1 339.48,606.56
X$65895 375 4104 4696 4793 4780 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65899 m0 *1 349.6,606.56
X$65899 407 4357 4696 4747 4622 407 4794 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $65901 m0 *1 352.36,606.56
X$65901 407 4675 4747 407 4850 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $65902 m0 *1 355.58,606.56
X$65902 407 4695 4330 4794 4828 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65905 m0 *1 358.8,606.56
X$65905 407 4695 407 375 4796 375 sky130_fd_sc_hd__inv_1
* cell instance $65932 m0 *1 416.76,606.56
X$65932 407 4823 407 375 4768 375 sky130_fd_sc_hd__inv_1
* cell instance $65942 m0 *1 437.92,606.56
X$65942 407 4822 407 375 4751 375 sky130_fd_sc_hd__inv_1
* cell instance $65958 m0 *1 471.96,606.56
X$65958 375 4165 4799 4592 4818 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $65962 m0 *1 482.08,606.56
X$65962 407 4644 4642 4802 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $65963 m0 *1 483.46,606.56
X$65963 407 3648 4752 4175 407 4772 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65964 m0 *1 485.3,606.56
X$65964 407 4372 4393 4802 4752 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65975 m0 *1 507.38,606.56
X$65975 407 4372 4393 4812 4753 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $65977 m0 *1 509.68,606.56
X$65977 407 4753 4280 407 4658 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $65982 m0 *1 522.56,606.56
X$65982 375 3832 4604 3831 4552 4647 4761 407 407 375 sky130_fd_sc_hd__a2111oi_0
* cell instance $65985 m0 *1 527.16,606.56
X$65985 407 4754 4755 3831 407 4650 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $65986 m0 *1 529,606.56
X$65986 407 3832 4756 4755 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65990 m0 *1 530.84,606.56
X$65990 407 4705 4706 4756 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $65992 m0 *1 532.68,606.56
X$65992 407 3742 4706 4754 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $66114 r0 *1 150.42,606.56
X$66114 407 4685 407 375 3282 375 sky130_fd_sc_hd__buf_4
* cell instance $66122 r0 *1 167.9,606.56
X$66122 375 4103 4834 4711 4863 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66128 r0 *1 183.54,606.56
X$66128 407 4834 375 407 4807 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66130 r0 *1 189.06,606.56
X$66130 375 4104 4514 4657 4808 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66131 r0 *1 198.26,606.56
X$66131 375 4810 4868 4733 4762 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $66134 r0 *1 201.94,606.56
X$66134 407 4839 4681 4762 4810 4655 407 4785 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $66136 r0 *1 205.16,606.56
X$66136 407 4785 4870 4784 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66139 r0 *1 208.84,606.56
X$66139 407 4872 4605 4838 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66143 r0 *1 213.44,606.56
X$66143 375 4763 5121 4813 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66146 r0 *1 224.94,606.56
X$66146 407 4874 4605 4841 407 4814 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66147 r0 *1 226.78,606.56
X$66147 407 4788 4630 4533 4629 407 4841 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $66150 r0 *1 232.76,606.56
X$66150 407 4817 4655 4767 375 407 4684 375 sky130_fd_sc_hd__a21o_1
* cell instance $66153 r0 *1 236.44,606.56
X$66153 375 4816 4630 4769 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66155 r0 *1 241.5,606.56
X$66155 407 4786 375 407 4689 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66159 r0 *1 250.24,606.56
X$66159 407 4689 4880 4819 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66161 r0 *1 252.08,606.56
X$66161 407 4582 4843 4737 4882 407 4881 375 375 sky130_fd_sc_hd__a22oi_1
* cell instance $66162 r0 *1 254.84,606.56
X$66162 375 4843 4518 4690 4633 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66170 r0 *1 271.86,606.56
X$66170 375 4886 4824 4826 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66173 r0 *1 280.14,606.56
X$66173 375 4104 4901 4845 4827 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66179 r0 *1 293.02,606.56
X$66179 375 4104 4888 4845 4830 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66180 r0 *1 302.22,606.56
X$66180 375 4104 4790 4845 4889 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66183 r0 *1 312.8,606.56
X$66183 407 4790 4330 4890 4791 407 375 4889 375 sky130_fd_sc_hd__o31ai_1
* cell instance $66185 r0 *1 315.56,606.56
X$66185 407 4305 4848 4790 407 4791 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66189 r0 *1 319.24,606.56
X$66189 407 4330 4732 4891 375 407 4848 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66190 r0 *1 321.08,606.56
X$66190 407 4732 4891 4890 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66192 r0 *1 324.3,606.56
X$66192 407 4305 4892 4849 407 4893 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66195 r0 *1 328.44,606.56
X$66195 407 4739 4742 4779 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66198 r0 *1 332.12,606.56
X$66198 407 4779 4744 5002 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $66202 r0 *1 342.7,606.56
X$66202 407 4728 4696 4832 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $66208 r0 *1 350.06,606.56
X$66208 407 4831 4695 4747 4696 375 407 4693 375 sky130_fd_sc_hd__and4_1
* cell instance $66210 r0 *1 353.74,606.56
X$66210 407 4305 4308 4794 375 407 4795 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66212 r0 *1 356.04,606.56
X$66212 407 4828 4796 4795 407 375 4797 375 sky130_fd_sc_hd__o21bai_1
* cell instance $66213 r0 *1 358.8,606.56
X$66213 375 4104 4695 4793 4797 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66216 r0 *1 368.46,606.56
X$66216 407 4747 375 407 4798 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66250 r0 *1 449.42,606.56
X$66250 407 4642 375 407 4919 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66258 r0 *1 469.66,606.56
X$66258 407 4799 4887 4858 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66259 r0 *1 471.04,606.56
X$66259 407 4799 375 407 4820 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66260 r0 *1 474.72,606.56
X$66260 407 4799 4800 4858 407 4818 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66262 r0 *1 476.56,606.56
X$66262 407 4885 4799 407 4883 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $66263 r0 *1 479.78,606.56
X$66263 375 4854 4799 4859 4801 407 4393 407 375 sky130_fd_sc_hd__nand4_2
* cell instance $66267 r0 *1 487.6,606.56
X$66267 407 4879 4815 4878 4803 4720 407 4647 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $66269 r0 *1 492.66,606.56
X$66269 407 3952 4266 4876 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66270 r0 *1 494.04,606.56
X$66270 407 4644 4876 4910 407 4875 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66271 r0 *1 495.88,606.56
X$66271 407 3648 4266 4175 407 4907 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66274 r0 *1 501.86,606.56
X$66274 407 4801 4859 4247 4804 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66277 r0 *1 504.16,606.56
X$66277 407 4372 4873 4804 4394 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $66280 r0 *1 510.6,606.56
X$66280 407 3952 4753 4869 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66282 r0 *1 512.44,606.56
X$66282 407 4280 4869 4867 407 4811 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66283 r0 *1 514.28,606.56
X$66283 375 4160 4280 4550 4811 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66286 r0 *1 529,606.56
X$66286 407 3742 407 375 4705 375 sky130_fd_sc_hd__inv_1
* cell instance $66289 r0 *1 531.3,606.56
X$66289 407 3832 4705 4861 4759 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $66290 r0 *1 533.14,606.56
X$66290 407 4864 4648 4706 4805 375 407 4806 375 sky130_fd_sc_hd__a31oi_1
* cell instance $66293 r0 *1 536.82,606.56
X$66293 407 4706 4862 4805 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66294 r0 *1 538.2,606.56
X$66294 407 3831 3832 4862 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66419 m0 *1 162.84,612
X$66419 375 4909 4733 4894 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66423 m0 *1 170.2,612
X$66423 375 4863 4833 4834 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66424 m0 *1 174.34,612
X$66424 375 4103 4835 4711 4865 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66427 m0 *1 183.54,612
X$66427 407 4681 4896 4655 4833 4835 407 4897 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $66428 m0 *1 186.76,612
X$66428 407 4897 4836 4865 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66430 m0 *1 189.06,612
X$66430 407 4628 4624 4965 4514 4838 407 4808 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $66437 m0 *1 198.26,612
X$66437 375 4628 4839 4733 4760 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $66438 m0 *1 200.56,612
X$66438 407 4681 4810 4762 4839 407 4840 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $66439 m0 *1 202.86,612
X$66439 407 5266 375 407 4871 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66442 m0 *1 206.54,612
X$66442 407 4871 4605 4840 407 4870 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66444 m0 *1 209.3,612
X$66444 407 5568 375 407 4872 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66447 m0 *1 215.28,612
X$66447 375 4913 4934 4898 3282 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66452 m0 *1 224.48,612
X$66452 407 4914 375 407 4874 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66460 m0 *1 238.74,612
X$66460 407 4769 375 407 4899 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66462 m0 *1 244.26,612
X$66462 407 4330 4842 4655 4880 4916 375 407 375 sky130_fd_sc_hd__o22a_1
* cell instance $66464 m0 *1 247.94,612
X$66464 407 4582 4773 4877 407 4979 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66467 m0 *1 251.16,612
X$66467 407 4842 4686 4881 407 4920 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66473 m0 *1 258.98,612
X$66473 375 4103 4924 4844 4900 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66474 m0 *1 268.18,612
X$66474 375 4104 4824 4845 4886 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66478 m0 *1 280.6,612
X$66478 407 4826 407 375 4927 375 sky130_fd_sc_hd__inv_1
* cell instance $66483 m0 *1 286.12,612
X$66483 375 4104 4929 4845 4990 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66484 m0 *1 295.32,612
X$66484 375 4830 4888 4846 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66489 m0 *1 306.36,612
X$66489 407 4103 407 375 4926 375 sky130_fd_sc_hd__buf_4
* cell instance $66491 m0 *1 310.04,612
X$66491 407 4305 4847 4903 407 4930 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66492 m0 *1 311.88,612
X$66492 407 4330 4732 4904 375 407 4847 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66495 m0 *1 313.72,612
X$66495 375 4588 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $66498 m0 *1 326.14,612
X$66498 407 4732 4744 4739 4330 375 407 4892 375 sky130_fd_sc_hd__a31oi_1
* cell instance $66499 m0 *1 328.44,612
X$66499 407 4849 4330 4946 4893 407 375 4928 375 sky130_fd_sc_hd__o31ai_1
* cell instance $66504 m0 *1 333.96,612
X$66504 375 4926 4849 4793 4928 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66507 m0 *1 343.16,612
X$66507 407 4696 375 407 4925 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66512 m0 *1 353.74,612
X$66512 407 4794 4695 4923 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $66538 m0 *1 408.94,612
X$66538 407 4922 375 407 4823 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66549 m0 *1 426.42,612
X$66549 407 4851 375 407 4822 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66562 m0 *1 454.02,612
X$66562 375 4165 4856 4592 4852 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66563 m0 *1 463.22,612
X$66563 407 4856 4853 4855 407 4852 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66564 m0 *1 465.06,612
X$66564 407 3952 4951 4853 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66565 m0 *1 466.44,612
X$66565 407 4244 4915 4856 407 4855 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66566 m0 *1 468.28,612
X$66566 407 4857 4799 4644 4854 407 4750 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $66569 m0 *1 471.96,612
X$66569 375 4592 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $66572 m0 *1 477.02,612
X$66572 407 4857 4854 4885 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $66574 m0 *1 479.78,612
X$66574 375 4912 4911 5359 4883 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $66575 m0 *1 484.38,612
X$66575 407 4799 4854 4873 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66576 m0 *1 485.76,612
X$66576 407 4266 4644 407 4974 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $66577 m0 *1 488.98,612
X$66577 375 4165 4644 4592 4875 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66586 m0 *1 509.22,612
X$66586 407 3648 4753 4175 407 4860 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66587 m0 *1 511.06,612
X$66587 407 4280 4860 4867 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66589 m0 *1 514.28,612
X$66589 375 3947 4550 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $66591 m0 *1 523.94,612
X$66591 407 4967 3831 4756 375 407 4866 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66595 m0 *1 529,612
X$66595 407 4648 4754 4864 375 407 4149 375 sky130_fd_sc_hd__and3_2
* cell instance $66600 m0 *1 533.14,612
X$66600 407 3831 3832 4864 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66727 r0 *1 155.94,612
X$66727 407 4894 375 407 4961 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66728 r0 *1 159.62,612
X$66728 375 4104 4894 4652 4909 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66729 r0 *1 168.82,612
X$66729 375 4103 4833 4711 4895 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66731 r0 *1 178.02,612
X$66731 407 4681 4833 4964 5007 375 4895 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $66734 r0 *1 182.16,612
X$66734 407 4896 4837 5173 375 407 4931 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66735 r0 *1 184,612
X$66735 375 4896 4628 4833 4835 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $66736 r0 *1 186.3,612
X$66736 407 4833 4896 4835 4932 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66739 r0 *1 189.52,612
X$66739 407 4514 4837 4966 375 407 4965 375 sky130_fd_sc_hd__a21oi_1
* cell instance $66742 r0 *1 195.5,612
X$66742 407 4733 4628 4760 4968 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66743 r0 *1 197.34,612
X$66743 407 4628 4760 4868 4970 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66744 r0 *1 199.18,612
X$66744 375 3858 4657 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $66749 r0 *1 214.36,612
X$66749 375 4104 4898 4471 4913 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66752 r0 *1 226.32,612
X$66752 407 4898 375 407 4939 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66756 r0 *1 232.3,612
X$66756 407 4813 375 407 4977 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66761 r0 *1 241.5,612
X$66761 375 4104 4880 4938 4916 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66762 r0 *1 250.7,612
X$66762 375 4104 4633 4844 4920 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66768 r0 *1 265.42,612
X$66768 375 4104 4940 4844 4985 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66770 r0 *1 275.08,612
X$66770 375 4104 4826 4845 4987 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66774 r0 *1 287.04,612
X$66774 375 4990 4929 4901 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $66776 r0 *1 291.64,612
X$66776 375 4104 4846 4845 4902 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66777 r0 *1 300.84,612
X$66777 375 4104 4903 4845 4944 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66778 r0 *1 310.04,612
X$66778 407 4903 4330 4997 4930 407 375 4944 375 sky130_fd_sc_hd__o31ai_1
* cell instance $66782 r0 *1 314.18,612
X$66782 407 4732 4904 4997 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66783 r0 *1 315.56,612
X$66783 407 4890 4790 5004 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $66785 r0 *1 319.24,612
X$66785 375 5003 4945 5006 5004 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $66787 r0 *1 324.3,612
X$66787 407 4732 4739 407 5001 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $66789 r0 *1 328.44,612
X$66789 407 4739 4744 4732 4946 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66791 r0 *1 331.2,612
X$66791 375 4842 4340 4532 5135 4905 4948 407 407 375 sky130_fd_sc_hd__a41oi_1
* cell instance $66794 r0 *1 335.8,612
X$66794 375 5005 4998 4999 5001 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $66803 r0 *1 350.06,612
X$66803 407 4994 5070 4996 5100 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $66804 r0 *1 351.9,612
X$66804 375 4994 4993 4991 4850 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $66806 r0 *1 356.96,612
X$66806 407 4695 375 407 6076 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66843 r0 *1 447.58,612
X$66843 375 4165 4918 4592 4921 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $66846 r0 *1 457.24,612
X$66846 407 4856 4906 4918 4917 375 407 4854 375 sky130_fd_sc_hd__and4_1
* cell instance $66847 r0 *1 460.46,612
X$66847 407 4856 375 407 4983 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66848 r0 *1 464.14,612
X$66848 407 4981 4906 4918 3648 375 407 4915 375 sky130_fd_sc_hd__a31oi_1
* cell instance $66849 r0 *1 466.44,612
X$66849 407 4644 375 407 4980 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66850 r0 *1 470.12,612
X$66850 407 3648 4885 4175 407 4887 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $66851 r0 *1 471.96,612
X$66851 375 3947 4592 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $66853 r0 *1 481.16,612
X$66853 407 3952 4885 4800 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66857 r0 *1 485.76,612
X$66857 375 4954 4972 4973 4974 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $66861 r0 *1 495.42,612
X$66861 407 4644 4907 4910 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66870 r0 *1 514.28,612
X$66870 407 4550 375 407 375 sky130_fd_sc_hd__clkinv_4
* cell instance $66873 r0 *1 520.26,612
X$66873 407 4958 4866 3832 407 4969 375 375 sky130_fd_sc_hd__o21a_1
* cell instance $66875 r0 *1 523.48,612
X$66875 407 3831 4908 4967 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $66876 r0 *1 524.86,612
X$66876 407 4648 4754 4908 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66878 r0 *1 526.7,612
X$66878 407 4754 3832 3831 5043 375 407 4959 375 sky130_fd_sc_hd__a31oi_1
* cell instance $66879 r0 *1 529,612
X$66879 407 3742 4861 4864 375 407 5044 375 sky130_fd_sc_hd__and3_2
* cell instance $66881 r0 *1 531.76,612
X$66881 407 4244 4959 4962 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $66882 r0 *1 533.14,612
X$66882 375 4864 4754 4648 407 3392 407 375 sky130_fd_sc_hd__nand3_4
* cell instance $66886 r0 *1 542.8,612
X$66886 407 4960 407 375 3832 375 sky130_fd_sc_hd__buf_4
* cell instance $67008 m0 *1 161.92,617.44
X$67008 375 5045 4975 5046 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67013 m0 *1 168.82,617.44
X$67013 407 4877 375 407 4963 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67015 m0 *1 174.34,617.44
X$67015 375 4711 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $67020 m0 *1 186.76,617.44
X$67020 407 5051 4932 4605 5117 4836 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $67021 m0 *1 189.06,617.44
X$67021 407 5008 4932 4933 407 4966 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67024 m0 *1 193.2,617.44
X$67024 407 4934 4837 4935 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67026 m0 *1 195.04,617.44
X$67026 407 4934 4933 4935 407 5012 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67028 m0 *1 197.8,617.44
X$67028 375 5145 4936 4934 4971 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67029 m0 *1 202.4,617.44
X$67029 407 4657 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $67033 m0 *1 204.7,617.44
X$67033 407 5013 5012 4937 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67034 m0 *1 206.08,617.44
X$67034 375 4104 4934 4657 4937 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67041 m0 *1 223.56,617.44
X$67041 375 4976 4629 4975 5054 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $67044 m0 *1 230.46,617.44
X$67044 375 4104 4975 4938 5055 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67049 m0 *1 245.18,617.44
X$67049 407 4330 4842 4979 407 5056 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67055 m0 *1 255.76,617.44
X$67055 407 4518 5057 4982 407 4882 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67056 m0 *1 257.6,617.44
X$67056 407 4518 4691 4982 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67060 m0 *1 259.44,617.44
X$67060 375 4194 4844 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $67061 m0 *1 268.64,617.44
X$67061 407 5058 5134 5015 5060 375 407 4985 375 sky130_fd_sc_hd__a31oi_1
* cell instance $67063 m0 *1 271.86,617.44
X$67063 375 5059 4942 5016 4940 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67067 m0 *1 278.3,617.44
X$67067 407 5015 4988 4605 5065 4941 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $67068 m0 *1 280.6,617.44
X$67068 407 4941 4927 5066 375 407 4987 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67069 m0 *1 282.44,617.44
X$67069 407 4826 4942 4846 5069 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67074 m0 *1 291.64,617.44
X$67074 375 4926 5074 4845 5255 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67081 m0 *1 311.42,617.44
X$67081 407 4308 4943 5076 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $67084 m0 *1 313.72,617.44
X$67084 375 4194 4588 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $67085 m0 *1 322.92,617.44
X$67085 407 5003 4945 5026 407 5154 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67088 m0 *1 329.36,617.44
X$67088 407 4946 4849 5133 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $67090 m0 *1 333.04,617.44
X$67090 375 5075 4947 5028 5002 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67091 m0 *1 337.64,617.44
X$67091 407 4947 5075 4998 375 407 5097 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67095 m0 *1 340.4,617.44
X$67095 407 5024 5000 5073 4948 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $67097 m0 *1 342.7,617.44
X$67097 407 4948 5030 4992 5031 4949 5072 407 375 375 sky130_fd_sc_hd__o221ai_1
* cell instance $67098 m0 *1 345.92,617.44
X$67098 375 5070 5071 4995 4832 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67099 m0 *1 350.52,617.44
X$67099 375 4996 5068 5067 4639 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67101 m0 *1 355.58,617.44
X$67101 375 5031 4992 5064 4923 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67109 m0 *1 373.52,617.44
X$67109 407 4950 407 375 4991 375 sky130_fd_sc_hd__inv_1
* cell instance $67129 m0 *1 417.22,617.44
X$67129 407 4958 375 407 5061 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67133 m0 *1 422.74,617.44
X$67133 375 4926 4989 5034 5035 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67141 m0 *1 448.5,617.44
X$67141 375 4165 4906 4592 4986 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67145 m0 *1 458.16,617.44
X$67145 407 4906 3648 5037 5053 407 375 4986 375 sky130_fd_sc_hd__o31ai_1
* cell instance $67147 m0 *1 461.38,617.44
X$67147 407 4918 5038 4984 407 4921 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67149 m0 *1 463.68,617.44
X$67149 375 4906 4951 4918 4981 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $67151 m0 *1 466.44,617.44
X$67151 407 4951 4856 407 4978 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $67156 m0 *1 473.34,617.44
X$67156 375 5039 4952 5052 4978 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67160 m0 *1 478.4,617.44
X$67160 407 4952 5039 5040 375 407 4955 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67161 m0 *1 480.24,617.44
X$67161 375 4878 5039 5041 4953 4912 4954 407 407 375 sky130_fd_sc_hd__a41oi_1
* cell instance $67162 m0 *1 483.46,617.44
X$67162 407 4954 4912 4956 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67163 m0 *1 484.84,617.44
X$67163 407 4955 4956 4957 407 4953 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67165 m0 *1 487.14,617.44
X$67165 407 4972 4954 4911 375 407 4957 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67170 m0 *1 498.64,617.44
X$67170 407 3952 4362 5047 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $67176 m0 *1 509.22,617.44
X$67176 407 3392 3648 4175 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67180 m0 *1 513.82,617.44
X$67180 375 4160 4958 4550 4969 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67185 m0 *1 528.08,617.44
X$67185 407 5044 407 375 5043 375 sky130_fd_sc_hd__buf_4
* cell instance $67191 m0 *1 534.06,617.44
X$67191 375 4160 4960 4170 4962 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67315 r0 *1 157.32,617.44
X$67315 375 494 5046 4652 5045 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67319 r0 *1 171.58,617.44
X$67319 375 3858 4711 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $67322 r0 *1 181.24,617.44
X$67322 407 5048 375 407 5115 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67323 r0 *1 184.92,617.44
X$67323 407 4624 4896 4931 4833 5050 407 5114 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $67324 r0 *1 188.14,617.44
X$67324 407 4833 4837 5009 375 407 5007 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67325 r0 *1 189.98,617.44
X$67325 407 5010 5008 4624 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67326 r0 *1 191.36,617.44
X$67326 407 4933 5011 5009 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67327 r0 *1 192.74,617.44
X$67327 407 4934 4971 5079 5011 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67329 r0 *1 198.26,617.44
X$67329 375 4104 4971 4657 5081 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67336 r0 *1 219.88,617.44
X$67336 407 5014 4655 5013 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67337 r0 *1 221.26,617.44
X$67337 375 4104 4976 4938 5122 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67343 r0 *1 238.28,617.44
X$67343 407 4880 375 407 5129 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67346 r0 *1 243.34,617.44
X$67346 375 4104 4877 4844 5056 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67348 r0 *1 256.22,617.44
X$67348 407 6285 375 407 4691 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67350 r0 *1 259.9,617.44
X$67350 407 4844 407 375 375 sky130_fd_sc_hd__clkinvlp_4
* cell instance $67353 r0 *1 264.04,617.44
X$67353 375 4900 4924 4940 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67354 r0 *1 268.18,617.44
X$67354 407 4940 4605 5058 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67355 r0 *1 269.56,617.44
X$67355 407 5059 5015 5060 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67359 r0 *1 274.16,617.44
X$67359 407 5016 4940 4826 5017 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67360 r0 *1 276,617.44
X$67360 407 5063 375 407 5065 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67361 r0 *1 279.68,617.44
X$67361 407 4826 4942 4988 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67362 r0 *1 281.06,617.44
X$67362 407 4942 5015 5018 407 5066 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67363 r0 *1 282.9,617.44
X$67363 407 5020 5069 5139 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67365 r0 *1 284.74,617.44
X$67365 407 5017 5019 5020 407 5088 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67367 r0 *1 286.58,617.44
X$67367 407 4846 4901 5019 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67368 r0 *1 287.96,617.44
X$67368 407 4605 5015 5018 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67369 r0 *1 289.34,617.44
X$67369 407 5021 5018 5088 375 407 5140 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67372 r0 *1 292.1,617.44
X$67372 375 4194 4845 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $67374 r0 *1 302.22,617.44
X$67374 375 4104 5142 4845 5141 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67377 r0 *1 313.26,617.44
X$67377 407 4997 4903 5138 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $67378 r0 *1 316.48,617.44
X$67378 407 5022 5026 5023 5003 407 5024 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $67380 r0 *1 319.24,617.44
X$67380 375 5023 5025 5249 5138 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67381 r0 *1 323.84,617.44
X$67381 407 5025 5022 4945 5136 375 5201 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $67384 r0 *1 330.74,617.44
X$67384 375 5077 5132 5595 5133 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67385 r0 *1 335.34,617.44
X$67385 407 5075 5027 5005 5077 407 5000 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $67386 r0 *1 337.64,617.44
X$67386 407 5024 5000 5029 5093 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $67390 r0 *1 344.08,617.44
X$67390 407 5100 5131 4905 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67395 r0 *1 348.22,617.44
X$67395 407 5032 4994 5030 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $67396 r0 *1 350.52,617.44
X$67396 407 5071 5070 5068 375 407 5032 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67397 r0 *1 352.36,617.44
X$67397 407 4992 4993 5128 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67401 r0 *1 356.96,617.44
X$67401 375 4793 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $67410 r0 *1 382.72,617.44
X$67410 407 5033 407 375 5064 375 sky130_fd_sc_hd__inv_1
* cell instance $67422 r0 *1 407.1,617.44
X$67422 375 4926 5125 5034 5062 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67426 r0 *1 419.52,617.44
X$67426 375 4926 5036 5034 5124 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67430 r0 *1 429.64,617.44
X$67430 375 5035 5036 4989 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67441 r0 *1 457.7,617.44
X$67441 407 4857 4918 4917 3648 375 407 5105 375 sky130_fd_sc_hd__a31oi_1
* cell instance $67444 r0 *1 461.38,617.44
X$67444 407 4244 5105 4906 407 5053 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67445 r0 *1 463.22,617.44
X$67445 407 5037 4906 5120 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $67447 r0 *1 467.36,617.44
X$67447 407 4981 4918 407 5119 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $67449 r0 *1 471.04,617.44
X$67449 375 5041 5040 5106 5120 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67452 r0 *1 476.56,617.44
X$67452 375 5042 5118 5684 5119 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67453 r0 *1 481.16,617.44
X$67453 375 5118 4879 5042 5116 4953 5223 407 407 375 sky130_fd_sc_hd__a2111oi_0
* cell instance $67458 r0 *1 490.82,617.44
X$67458 407 4801 3648 4362 5112 407 375 5049 375 sky130_fd_sc_hd__o31ai_1
* cell instance $67459 r0 *1 493.58,617.44
X$67459 375 4160 4801 4592 5049 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67597 m0 *1 150.42,622.88
X$67597 375 494 5111 4652 5078 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67598 m0 *1 159.62,622.88
X$67598 375 5078 4971 5111 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67603 m0 *1 167.44,622.88
X$67603 407 5046 375 407 5113 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67606 m0 *1 175.72,622.88
X$67606 375 4103 4896 4711 5114 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67609 m0 *1 184.92,622.88
X$67609 407 5259 375 407 5117 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67610 m0 *1 188.6,622.88
X$67610 407 5079 4936 4833 5174 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67611 m0 *1 190.44,622.88
X$67611 407 4605 5010 4837 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67613 m0 *1 192.28,622.88
X$67613 407 5010 5011 4681 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67616 m0 *1 195.04,622.88
X$67616 407 5080 4330 5011 5051 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $67617 m0 *1 197.34,622.88
X$67617 407 4971 4605 5144 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67618 m0 *1 198.72,622.88
X$67618 407 5144 5179 5010 5180 375 407 5081 375 sky130_fd_sc_hd__a31oi_1
* cell instance $67620 m0 *1 201.48,622.88
X$67620 407 4308 5080 5010 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $67621 m0 *1 203.78,622.88
X$67621 375 4104 5121 4657 5182 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67629 m0 *1 223.1,622.88
X$67629 407 4629 4788 5242 5185 375 5122 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $67632 m0 *1 227.24,622.88
X$67632 407 5054 4683 4655 4975 375 5083 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $67633 m0 *1 230,622.88
X$67633 407 5054 4683 5082 4975 5083 407 5055 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $67636 m0 *1 233.22,622.88
X$67636 407 5186 375 407 5014 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67637 m0 *1 236.9,622.88
X$67637 407 5149 4605 5082 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67640 m0 *1 241.04,622.88
X$67640 407 5189 375 407 5149 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67641 m0 *1 244.72,622.88
X$67641 407 4518 4581 5130 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67642 m0 *1 246.1,622.88
X$67642 375 5150 4518 5130 4582 407 407 375 sky130_fd_sc_hd__mux2i_1
* cell instance $67646 m0 *1 254.84,622.88
X$67646 375 5151 5057 4633 4518 4582 407 407 375 sky130_fd_sc_hd__nor4bb_4
* cell instance $67650 m0 *1 264.5,622.88
X$67650 407 5084 4655 5134 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67651 m0 *1 265.88,622.88
X$67651 407 5151 407 375 4308 375 sky130_fd_sc_hd__buf_4
* cell instance $67654 m0 *1 272.78,622.88
X$67654 407 5151 5085 5015 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $67658 m0 *1 277.84,622.88
X$67658 375 4605 5086 5194 5019 4988 5015 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $67659 m0 *1 281.06,622.88
X$67659 407 5087 5086 4827 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67660 m0 *1 282.44,622.88
X$67660 407 4901 5018 5139 375 407 5087 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67661 m0 *1 284.28,622.88
X$67661 407 5015 5017 5152 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67662 m0 *1 285.66,622.88
X$67662 375 5153 5089 4846 4605 5090 4902 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $67665 m0 *1 289.8,622.88
X$67665 375 4926 5021 4845 5197 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67672 m0 *1 306.82,622.88
X$67672 407 4790 375 407 5143 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67675 m0 *1 311.88,622.88
X$67675 407 5076 4353 5142 5091 375 407 5141 375 sky130_fd_sc_hd__a31oi_1
* cell instance $67678 m0 *1 314.18,622.88
X$67678 407 5142 4308 4943 375 407 5091 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67679 m0 *1 316.02,622.88
X$67679 407 4943 5142 407 5092 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $67681 m0 *1 319.7,622.88
X$67681 375 5022 5136 5137 5092 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67683 m0 *1 327.98,622.88
X$67683 407 5202 5155 5093 5094 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $67684 m0 *1 329.82,622.88
X$67684 407 5024 5095 5072 5094 5135 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $67686 m0 *1 333.04,622.88
X$67686 407 5027 5077 5156 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67689 m0 *1 335.8,622.88
X$67689 407 5132 5027 5245 5096 375 5095 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $67690 m0 *1 338.56,622.88
X$67690 407 5097 5156 5096 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67691 m0 *1 339.94,622.88
X$67691 407 5098 5157 5073 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67694 m0 *1 341.32,622.88
X$67694 407 5158 5098 5198 375 407 5029 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67696 m0 *1 343.62,622.88
X$67696 407 5031 5199 5099 5131 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67698 m0 *1 345.92,622.88
X$67698 375 5199 5101 5159 4528 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67700 m0 *1 350.98,622.88
X$67700 407 5100 5102 5128 407 4949 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67701 m0 *1 352.82,622.88
X$67701 407 5160 5099 5101 375 407 5102 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67703 m0 *1 355.12,622.88
X$67703 375 5099 5160 5196 5127 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $67706 m0 *1 360.64,622.88
X$67706 375 4926 5195 4793 5240 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67722 m0 *1 399.28,622.88
X$67722 407 5193 407 375 5159 375 sky130_fd_sc_hd__inv_1
* cell instance $67724 m0 *1 402.5,622.88
X$67724 375 4926 5163 5126 5192 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67732 m0 *1 422.28,622.88
X$67732 407 5191 5103 5124 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67735 m0 *1 426.42,622.88
X$67735 407 5036 3392 5103 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67737 m0 *1 429.64,622.88
X$67737 407 4989 375 407 5123 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67740 m0 *1 438.84,622.88
X$67740 407 5165 375 407 5033 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67744 m0 *1 444.36,622.88
X$67744 407 5187 407 375 5106 375 sky130_fd_sc_hd__inv_1
* cell instance $67750 m0 *1 450.8,622.88
X$67750 407 4918 375 407 5104 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67753 m0 *1 455.86,622.88
X$67753 407 5302 3392 4161 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67755 m0 *1 458.16,622.88
X$67755 407 4917 4918 4857 5037 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67758 m0 *1 461.38,622.88
X$67758 407 3952 4981 5038 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67759 m0 *1 462.76,622.88
X$67759 407 4918 5167 4984 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67761 m0 *1 465.06,622.88
X$67761 407 3648 4981 4175 407 5167 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67762 m0 *1 466.9,622.88
X$67762 407 4859 4917 5168 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67763 m0 *1 468.28,622.88
X$67763 407 5109 5168 4981 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67771 m0 *1 477.02,622.88
X$67771 407 5042 5107 5108 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67772 m0 *1 478.4,622.88
X$67772 407 5107 5171 5226 5042 375 407 5175 375 sky130_fd_sc_hd__and4_1
* cell instance $67773 m0 *1 481.62,622.88
X$67773 407 5108 5177 5116 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67775 m0 *1 483.92,622.88
X$67775 407 3952 5109 5176 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $67776 m0 *1 486.22,622.88
X$67776 407 4244 5176 4859 407 5110 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67778 m0 *1 488.98,622.88
X$67778 407 4859 3648 5109 5110 407 375 5172 375 sky130_fd_sc_hd__o31ai_1
* cell instance $67783 m0 *1 498.64,622.88
X$67783 407 4244 5047 4801 407 5112 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67794 m0 *1 522.1,622.88
X$67794 407 5169 375 407 4861 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67927 r0 *1 155.02,622.88
X$67927 407 5111 375 407 5560 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67928 r0 *1 158.7,622.88
X$67928 375 4652 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $67929 r0 *1 169.74,622.88
X$67929 375 4103 5079 4711 5227 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67931 r0 *1 178.94,622.88
X$67931 407 5079 407 375 5204 375 sky130_fd_sc_hd__inv_1
* cell instance $67935 r0 *1 181.7,622.88
X$67935 407 5115 4605 4964 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67937 r0 *1 184.92,622.88
X$67937 407 5294 4605 5050 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67938 r0 *1 186.3,622.88
X$67938 407 4933 5174 5173 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67940 r0 *1 188.6,622.88
X$67940 407 4936 5010 4837 407 5231 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $67941 r0 *1 190.44,622.88
X$67941 407 5079 4936 5008 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67944 r0 *1 194.58,622.88
X$67944 407 5080 4330 4933 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67947 r0 *1 198.72,622.88
X$67947 407 5206 4655 5179 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67948 r0 *1 200.1,622.88
X$67948 407 5145 5010 5180 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67952 r0 *1 205.62,622.88
X$67952 407 5183 5181 5182 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67956 r0 *1 208.84,622.88
X$67956 375 4104 5184 4657 5146 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67957 r0 *1 218.04,622.88
X$67957 375 5146 4976 5184 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67960 r0 *1 223.56,622.88
X$67960 407 5054 4788 4976 4975 4655 407 5185 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $67962 r0 *1 228.62,622.88
X$67962 407 5270 5148 4605 5147 5247 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $67970 r0 *1 238.74,622.88
X$67970 407 5188 407 375 5148 375 sky130_fd_sc_hd__inv_1
* cell instance $67972 r0 *1 243.8,622.88
X$67972 407 4633 5150 5190 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67973 r0 *1 245.18,622.88
X$67973 375 4104 5251 4938 5190 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67975 r0 *1 256.22,622.88
X$67975 375 5211 5057 4633 4518 4582 407 407 375 sky130_fd_sc_hd__nand4bb_2
* cell instance $67982 r0 *1 268.18,622.88
X$67982 375 4104 5016 4844 5257 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67985 r0 *1 284.74,622.88
X$67985 407 4846 5152 5153 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $67987 r0 *1 286.12,622.88
X$67987 407 5213 5020 5017 375 407 5089 375 sky130_fd_sc_hd__a21oi_1
* cell instance $67988 r0 *1 287.96,622.88
X$67988 407 4846 4901 5021 5256 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $67989 r0 *1 289.8,622.88
X$67989 407 5140 5390 5197 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $67992 r0 *1 292.56,622.88
X$67992 375 5255 5074 5021 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $67994 r0 *1 297.62,622.88
X$67994 407 4903 375 407 5254 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67995 r0 *1 301.3,622.88
X$67995 375 4926 5214 4588 5253 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $67996 r0 *1 310.5,622.88
X$67996 407 5142 375 407 5252 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $67998 r0 *1 314.18,622.88
X$67998 375 4742 4943 4903 4904 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $67999 r0 *1 316.48,622.88
X$67999 375 5142 4891 4903 4904 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $68001 r0 *1 319.24,622.88
X$68001 375 4742 5215 4790 4891 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $68003 r0 *1 322,622.88
X$68003 407 5201 5154 5155 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68004 r0 *1 323.38,622.88
X$68004 375 5026 5202 5203 5248 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68009 r0 *1 336.72,622.88
X$68009 375 5098 5158 5200 4781 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68011 r0 *1 341.32,622.88
X$68011 375 5157 5198 5656 5243 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68014 r0 *1 346.84,622.88
X$68014 407 4729 4831 407 5243 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68019 r0 *1 356.96,622.88
X$68019 375 4194 4793 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $68024 r0 *1 369.38,622.88
X$68024 407 5161 5319 5237 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68033 r0 *1 384.56,622.88
X$68033 375 4926 5218 5126 5236 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68041 r0 *1 406.18,622.88
X$68041 375 5192 5163 5162 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68042 r0 *1 410.32,622.88
X$68042 375 5062 5163 5125 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68043 r0 *1 414.46,622.88
X$68043 407 5125 375 407 5234 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68047 r0 *1 423.66,622.88
X$68047 407 5164 4149 5191 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68063 r0 *1 457.7,622.88
X$68063 407 4244 5221 4917 407 5232 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68064 r0 *1 459.54,622.88
X$68064 407 4906 375 407 5166 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68067 r0 *1 467.82,622.88
X$68067 407 4857 4917 407 5228 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68069 r0 *1 471.5,622.88
X$68069 407 5109 4859 5230 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $68071 r0 *1 475.18,622.88
X$68071 375 5107 5223 5178 5228 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68074 r0 *1 480.24,622.88
X$68074 407 5170 5171 5224 375 407 5177 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68079 r0 *1 488.52,622.88
X$68079 407 5175 5358 4803 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68080 r0 *1 489.9,622.88
X$68080 375 4160 4859 4592 5172 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68221 m0 *1 157.78,628.32
X$68221 375 3858 4652 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $68223 m0 *1 167.44,628.32
X$68223 407 5204 4685 5225 407 5291 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68224 m0 *1 169.28,628.32
X$68224 407 5258 4685 5225 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68226 m0 *1 171.12,628.32
X$68226 407 5292 5204 5231 375 407 5227 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68228 m0 *1 176.64,628.32
X$68228 375 4103 5208 4711 5205 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68231 m0 *1 185.84,628.32
X$68231 407 5260 4933 5296 375 407 5205 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68234 m0 *1 189.98,628.32
X$68234 407 5051 4968 4605 5262 4783 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $68238 m0 *1 195.04,628.32
X$68238 407 5080 4330 5008 5293 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $68239 m0 *1 197.34,628.32
X$68239 375 5293 4788 4970 5264 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $68240 m0 *1 201.02,628.32
X$68240 407 4970 5264 5207 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68242 m0 *1 202.86,628.32
X$68242 407 4681 5207 5235 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68246 m0 *1 204.7,628.32
X$68246 407 5235 5209 4605 5265 5181 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $68247 m0 *1 207,628.32
X$68247 407 4683 5208 4655 5210 5121 407 5183 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $68248 m0 *1 210.22,628.32
X$68248 407 5210 4655 4683 5238 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $68249 m0 *1 212.06,628.32
X$68249 407 5210 5208 5121 5209 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $68250 m0 *1 213.9,628.32
X$68250 407 5303 375 407 5206 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68251 m0 *1 217.58,628.32
X$68251 407 5301 375 407 5269 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68254 m0 *1 222.64,628.32
X$68254 407 5269 4605 5242 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68257 m0 *1 225.4,628.32
X$68257 407 5148 5209 5054 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68258 m0 *1 226.78,628.32
X$68258 407 4788 5209 5270 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $68260 m0 *1 230,628.32
X$68260 375 4938 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $68264 m0 *1 241.5,628.32
X$68264 407 5306 375 407 4581 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68270 m0 *1 254.84,628.32
X$68270 407 5809 375 407 5057 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68275 m0 *1 261.28,628.32
X$68275 407 5211 407 375 4330 375 sky130_fd_sc_hd__buf_4
* cell instance $68278 m0 *1 269.56,628.32
X$68278 407 5016 5015 5212 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68279 m0 *1 270.94,628.32
X$68279 375 5213 5272 5257 5212 5016 4655 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $68282 m0 *1 276,628.32
X$68282 407 5085 5211 5020 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68286 m0 *1 280.14,628.32
X$68286 407 4655 5020 5213 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68287 m0 *1 281.52,628.32
X$68287 407 5015 5017 5256 5313 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $68296 m0 *1 300.84,628.32
X$68296 375 5253 5214 5274 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68300 m0 *1 308.2,628.32
X$68300 407 5214 375 407 5321 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68305 m0 *1 316.02,628.32
X$68305 407 4308 5215 5250 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $68306 m0 *1 318.32,628.32
X$68306 407 5277 4308 5215 375 407 5276 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68308 m0 *1 321.08,628.32
X$68308 407 5323 407 375 5249 375 sky130_fd_sc_hd__inv_1
* cell instance $68309 m0 *1 322.46,628.32
X$68309 407 5215 5277 407 5248 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68310 m0 *1 325.68,628.32
X$68310 407 5280 4849 4744 4739 375 407 4904 375 sky130_fd_sc_hd__and4_1
* cell instance $68311 m0 *1 328.9,628.32
X$68311 407 4742 4849 4744 4739 375 407 5279 375 sky130_fd_sc_hd__and4_1
* cell instance $68316 m0 *1 335.8,628.32
X$68316 375 5027 5245 5326 5246 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68322 m0 *1 345.46,628.32
X$68322 407 4308 4729 5244 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68323 m0 *1 346.84,628.32
X$68323 407 4831 5244 5216 407 5325 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68324 m0 *1 348.68,628.32
X$68324 407 4330 4729 4353 407 5217 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68325 m0 *1 350.52,628.32
X$68325 407 4831 5217 5216 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68330 m0 *1 360.64,628.32
X$68330 407 5195 5161 5240 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68332 m0 *1 362.94,628.32
X$68332 375 6347 5320 5195 5239 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68336 m0 *1 368.46,628.32
X$68336 375 4926 5317 4793 5237 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68340 m0 *1 383.64,628.32
X$68340 375 5314 5312 5316 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68342 m0 *1 388.24,628.32
X$68342 375 5236 5312 5218 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68344 m0 *1 393.3,628.32
X$68344 407 5218 375 407 5310 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68348 m0 *1 397.9,628.32
X$68348 375 4926 5308 5126 5309 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68349 m0 *1 407.1,628.32
X$68349 407 5307 375 407 5162 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68354 m0 *1 419.52,628.32
X$68354 407 5219 375 407 5164 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68357 m0 *1 423.2,628.32
X$68357 407 5465 5220 5305 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68360 m0 *1 426.88,628.32
X$68360 407 5283 3392 5220 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68361 m0 *1 428.26,628.32
X$68361 407 5284 375 407 5187 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68362 m0 *1 431.94,628.32
X$68362 375 5034 407 407 375 sky130_fd_sc_hd__clkbuf_8
* cell instance $68368 m0 *1 445.28,628.32
X$68368 407 5285 375 407 5193 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68371 m0 *1 448.96,628.32
X$68371 375 4165 4917 5034 5233 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68372 m0 *1 458.16,628.32
X$68372 407 3648 4857 5221 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68373 m0 *1 459.54,628.32
X$68373 407 4917 375 407 5299 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68377 m0 *1 466.44,628.32
X$68377 407 5298 407 375 5229 375 sky130_fd_sc_hd__inv_1
* cell instance $68382 m0 *1 471.96,628.32
X$68382 375 5171 5170 5229 5230 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68386 m0 *1 478.4,628.32
X$68386 375 5226 5224 5295 5222 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68387 m0 *1 483,628.32
X$68387 407 4362 4801 5222 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $68537 r0 *1 161.46,628.32
X$68537 375 494 5258 4652 5291 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68538 r0 *1 170.66,628.32
X$68538 407 5354 4605 5293 407 5292 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68546 r0 *1 183.54,628.32
X$68546 407 5823 375 407 5294 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68548 r0 *1 188.14,628.32
X$68548 407 5261 5208 407 5296 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68549 r0 *1 191.36,628.32
X$68549 407 5210 5079 4936 5263 407 5261 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $68550 r0 *1 193.66,628.32
X$68550 407 4968 5297 5264 5263 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $68552 r0 *1 195.96,628.32
X$68552 407 4810 4762 5297 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68554 r0 *1 197.8,628.32
X$68554 375 5051 4683 4970 5264 407 407 375 sky130_fd_sc_hd__nor3_4
* cell instance $68556 r0 *1 204.24,628.32
X$68556 407 5210 5207 5300 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68559 r0 *1 206.08,628.32
X$68559 407 5051 5300 4605 5268 5267 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $68562 r0 *1 209.76,628.32
X$68562 407 5238 5267 5360 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68566 r0 *1 217.12,628.32
X$68566 407 5184 375 407 5362 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68569 r0 *1 223.1,628.32
X$68569 407 5836 375 407 5268 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68570 r0 *1 226.78,628.32
X$68570 375 4194 4938 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $68574 r0 *1 237.36,628.32
X$68574 407 4582 375 407 5371 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68576 r0 *1 244.72,628.32
X$68576 407 4518 375 407 5374 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68579 r0 *1 250.7,628.32
X$68579 407 4633 375 407 6283 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68580 r0 *1 254.38,628.32
X$68580 375 4103 5271 4844 5376 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68583 r0 *1 264.04,628.32
X$68583 375 5376 5271 5016 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68588 r0 *1 275.08,628.32
X$68588 375 5017 5273 5085 5211 5256 407 407 375 sky130_fd_sc_hd__nor4_4
* cell instance $68589 r0 *1 282.9,628.32
X$68589 407 4988 5256 5488 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68591 r0 *1 284.74,628.32
X$68591 407 4988 5256 5315 407 375 375 sky130_fd_sc_hd__or2_2
* cell instance $68595 r0 *1 288.42,628.32
X$68595 407 5213 5020 5315 375 407 5392 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68600 r0 *1 295.78,628.32
X$68600 375 4926 5274 4845 5599 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68603 r0 *1 307.28,628.32
X$68603 375 4926 5277 4588 5275 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68605 r0 *1 316.48,628.32
X$68605 407 5250 4353 5277 5276 375 407 5275 375 sky130_fd_sc_hd__a31oi_1
* cell instance $68607 r0 *1 319.24,628.32
X$68607 407 5277 375 407 5397 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68609 r0 *1 323.84,628.32
X$68609 375 4926 5280 4588 5278 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68610 r0 *1 333.04,628.32
X$68610 407 4308 5279 5324 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $68611 r0 *1 335.34,628.32
X$68611 407 5324 4353 5280 5281 375 407 5278 375 sky130_fd_sc_hd__a31oi_1
* cell instance $68612 r0 *1 337.64,628.32
X$68612 407 5280 4308 5279 375 407 5281 375 sky130_fd_sc_hd__a21oi_1
* cell instance $68620 r0 *1 347.3,628.32
X$68620 375 4926 4831 4793 5325 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68622 r0 *1 356.96,628.32
X$68622 375 4926 5239 4793 5322 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68624 r0 *1 366.62,628.32
X$68624 407 5317 5320 5319 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $68627 r0 *1 370.76,628.32
X$68627 407 5161 5388 5387 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68632 r0 *1 377.2,628.32
X$68632 407 4103 407 375 5318 375 sky130_fd_sc_hd__buf_4
* cell instance $68636 r0 *1 383.18,628.32
X$68636 375 4926 5312 5126 5314 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68637 r0 *1 392.38,628.32
X$68637 375 4926 5282 5126 5311 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68641 r0 *1 402.5,628.32
X$68641 375 5309 5282 5308 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68644 r0 *1 408.94,628.32
X$68644 375 4926 5378 5126 5381 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68646 r0 *1 419.98,628.32
X$68646 375 4926 5283 5034 5305 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68651 r0 *1 431.94,628.32
X$68651 375 3947 5034 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $68652 r0 *1 441.14,628.32
X$68652 375 5318 5343 5034 5372 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68654 r0 *1 450.34,628.32
X$68654 407 5304 375 407 5302 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68659 r0 *1 458.16,628.32
X$68659 407 4917 5286 5232 407 5233 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68660 r0 *1 460,628.32
X$68660 407 3952 4857 5286 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68665 r0 *1 470.12,628.32
X$68665 407 4859 375 407 5339 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68666 r0 *1 473.8,628.32
X$68666 407 4801 375 407 5287 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68668 r0 *1 477.48,628.32
X$68668 407 5363 407 375 4857 375 sky130_fd_sc_hd__buf_4
* cell instance $68669 r0 *1 480.24,628.32
X$68669 407 4801 4859 5361 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68674 r0 *1 486.68,628.32
X$68674 407 5290 5289 5288 4372 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $68675 r0 *1 488.52,628.32
X$68675 407 5289 5290 4801 5288 407 5109 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $68677 r0 *1 491.74,628.32
X$68677 375 4160 5290 4550 5357 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68815 m0 *1 153.18,633.76
X$68815 375 494 5399 4652 5431 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68819 m0 *1 167.44,633.76
X$68819 407 5352 375 407 5354 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68821 m0 *1 174.8,633.76
X$68821 375 4103 5327 4711 5435 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68824 m0 *1 184,633.76
X$68824 407 4837 5208 4605 5355 5260 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $68826 m0 *1 186.76,633.76
X$68826 407 5356 375 407 5262 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68827 m0 *1 190.44,633.76
X$68827 407 5439 375 407 5265 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68830 m0 *1 195.04,633.76
X$68830 407 5293 4968 5441 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68833 m0 *1 201.94,633.76
X$68833 407 5328 375 407 5080 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68838 m0 *1 208.38,633.76
X$68838 375 4104 5210 4657 5360 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68839 m0 *1 217.58,633.76
X$68839 375 5450 5210 5364 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68845 m0 *1 225.86,633.76
X$68845 407 5365 375 407 5147 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68846 m0 *1 229.54,633.76
X$68846 375 4104 5188 4938 5369 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68859 m0 *1 260.36,633.76
X$68859 375 4103 5379 4844 5375 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68862 m0 *1 272.32,633.76
X$68862 407 5382 375 407 5085 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68863 m0 *1 276,633.76
X$68863 407 5331 5020 5383 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68865 m0 *1 277.84,633.76
X$68865 375 4605 5384 5467 5385 5383 5386 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $68868 m0 *1 285.66,633.76
X$68868 407 5389 4605 5313 407 5390 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68872 m0 *1 289.34,633.76
X$68872 407 5469 5468 5391 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $68873 m0 *1 290.72,633.76
X$68873 375 4926 5333 4845 5391 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68887 m0 *1 328.44,633.76
X$68887 407 5280 375 407 5398 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68891 m0 *1 333.96,633.76
X$68891 407 5279 5280 407 5246 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68893 m0 *1 338.1,633.76
X$68893 407 5396 407 375 4999 375 sky130_fd_sc_hd__inv_1
* cell instance $68900 m0 *1 349.6,633.76
X$68900 407 4831 375 407 5395 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68903 m0 *1 357.88,633.76
X$68903 407 5161 5394 5322 375 407 375 sky130_fd_sc_hd__nor2b_1
* cell instance $68905 m0 *1 360.64,633.76
X$68905 375 5394 5393 5471 5474 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $68907 m0 *1 366.16,633.76
X$68907 407 5195 5317 5239 5336 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $68910 m0 *1 368,633.76
X$68910 407 5336 5337 407 5388 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $68912 m0 *1 371.68,633.76
X$68912 375 4926 5337 4793 5387 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68916 m0 *1 384.1,633.76
X$68916 407 5832 375 407 5316 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68920 m0 *1 392.84,633.76
X$68920 375 3947 5126 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $68926 m0 *1 411.24,633.76
X$68926 375 5381 5378 5380 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68928 m0 *1 415.84,633.76
X$68928 375 5377 5378 5340 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68934 m0 *1 423.2,633.76
X$68934 375 4926 5341 5034 5463 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $68937 m0 *1 436.54,633.76
X$68937 375 5373 5343 5342 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68942 m0 *1 443.9,633.76
X$68942 375 5372 5343 5457 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $68950 m0 *1 461.38,633.76
X$68950 407 5370 375 407 5298 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68952 m0 *1 468.74,633.76
X$68952 407 5447 5428 5444 407 5368 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68954 m0 *1 471.04,633.76
X$68954 375 5367 5366 4815 5344 5345 5368 407 407 375 sky130_fd_sc_hd__a221o_1
* cell instance $68961 m0 *1 481.62,633.76
X$68961 407 5361 5348 5349 5347 375 5363 407 375 sky130_fd_sc_hd__nor4_1
* cell instance $68963 m0 *1 484.84,633.76
X$68963 407 5175 5350 5344 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $68964 m0 *1 486.22,633.76
X$68964 407 5290 407 375 5349 375 sky130_fd_sc_hd__inv_1
* cell instance $68965 m0 *1 487.6,633.76
X$68965 407 5290 375 407 5346 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $68968 m0 *1 492.66,633.76
X$68968 407 5290 5436 5351 407 5357 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68970 m0 *1 495.42,633.76
X$68970 407 4244 5434 5290 407 5351 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $68981 m0 *1 520.72,633.76
X$68981 375 375 5353 407 4149 3952 407 sky130_fd_sc_hd__nor2_2
* cell instance $68982 m0 *1 523.02,633.76
X$68982 407 5353 407 375 4244 375 sky130_fd_sc_hd__buf_4
* cell instance $69115 r0 *1 157.78,633.76
X$69115 375 5431 5208 5399 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69119 r0 *1 165.14,633.76
X$69119 407 5399 375 407 5433 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69122 r0 *1 173.42,633.76
X$69122 407 5258 375 407 5400 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69126 r0 *1 181.24,633.76
X$69126 375 5435 4896 5327 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69127 r0 *1 185.38,633.76
X$69127 407 5293 4970 5437 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69128 r0 *1 186.76,633.76
X$69128 407 5008 4970 4933 407 5564 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69129 r0 *1 188.6,633.76
X$69129 407 5008 4970 5401 4933 407 375 5440 375 sky130_fd_sc_hd__o31ai_1
* cell instance $69133 r0 *1 194.58,633.76
X$69133 407 5441 4810 5449 5442 375 5519 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69134 r0 *1 197.34,633.76
X$69134 407 4810 4655 5441 5442 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $69137 r0 *1 200.56,633.76
X$69137 407 5327 375 407 5446 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69144 r0 *1 211.14,633.76
X$69144 407 5402 4605 5449 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69146 r0 *1 213.44,633.76
X$69146 407 4103 407 375 5329 375 sky130_fd_sc_hd__buf_4
* cell instance $69147 r0 *1 216.2,633.76
X$69147 375 5329 5364 4938 5450 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69149 r0 *1 227.24,633.76
X$69149 407 5364 375 407 5403 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69150 r0 *1 230.92,633.76
X$69150 407 5270 4605 5148 5247 375 407 5369 375 sky130_fd_sc_hd__a31oi_1
* cell instance $69152 r0 *1 233.22,633.76
X$69152 407 5148 4685 5455 407 5454 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69155 r0 *1 236.44,633.76
X$69155 407 5456 4685 5455 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69157 r0 *1 238.28,633.76
X$69157 375 5329 5407 5404 5330 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69158 r0 *1 247.48,633.76
X$69158 407 5464 5459 5405 5330 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $69160 r0 *1 250.24,633.76
X$69160 407 5462 375 407 5410 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69161 r0 *1 253.92,633.76
X$69161 407 5410 4605 5464 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69168 r0 *1 264.96,633.76
X$69168 375 5375 5379 5331 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69170 r0 *1 270.02,633.76
X$69170 375 4103 5331 5485 5332 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69171 r0 *1 279.22,633.76
X$69171 407 5384 5412 5332 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69172 r0 *1 280.6,633.76
X$69172 407 5386 5385 5020 407 5413 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69174 r0 *1 283.36,633.76
X$69174 407 5331 5018 5413 375 407 5412 375 sky130_fd_sc_hd__a21oi_1
* cell instance $69177 r0 *1 286.12,633.76
X$69177 375 4605 5468 5411 5414 5315 5015 407 407 375 sky130_fd_sc_hd__o32ai_1
* cell instance $69178 r0 *1 289.34,633.76
X$69178 407 5315 5470 5020 407 5416 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69180 r0 *1 291.64,633.76
X$69180 407 5333 5018 5416 375 407 5469 375 sky130_fd_sc_hd__a21oi_1
* cell instance $69182 r0 *1 295.32,633.76
X$69182 407 5313 5414 5417 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69184 r0 *1 298.54,633.76
X$69184 407 5334 4655 5417 5472 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $69185 r0 *1 300.38,633.76
X$69185 375 4103 5334 4588 5473 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69186 r0 *1 309.58,633.76
X$69186 375 5475 5419 5334 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69196 r0 *1 326.14,633.76
X$69196 407 5479 375 407 4572 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69197 r0 *1 329.82,633.76
X$69197 407 4744 375 407 5478 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69201 r0 *1 336.72,633.76
X$69201 407 4590 375 407 5477 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69204 r0 *1 340.86,633.76
X$69204 407 5476 407 375 5028 375 sky130_fd_sc_hd__inv_1
* cell instance $69211 r0 *1 351.9,633.76
X$69211 375 4926 5526 5420 5317 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69213 r0 *1 361.56,633.76
X$69213 407 5239 407 375 5474 375 sky130_fd_sc_hd__inv_1
* cell instance $69214 r0 *1 362.94,633.76
X$69214 407 5195 407 375 5471 375 sky130_fd_sc_hd__inv_1
* cell instance $69215 r0 *1 364.32,633.76
X$69215 407 5393 5421 5335 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69216 r0 *1 365.7,633.76
X$69216 407 5317 5337 5421 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69227 r0 *1 386.4,633.76
X$69227 375 4926 5338 5126 5337 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69231 r0 *1 396.98,633.76
X$69231 375 5311 5282 5466 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69238 r0 *1 408.94,633.76
X$69238 407 5308 375 407 5422 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69239 r0 *1 412.62,633.76
X$69239 375 4926 5340 5579 5377 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69242 r0 *1 423.66,633.76
X$69242 407 5461 4149 5465 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69243 r0 *1 425.04,633.76
X$69243 375 5463 5283 5341 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69247 r0 *1 433.78,633.76
X$69247 375 5318 5342 5034 5373 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69249 r0 *1 443.9,633.76
X$69249 407 5458 375 407 5457 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69253 r0 *1 454.94,633.76
X$69253 407 5517 5516 5423 407 5367 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69255 r0 *1 457.24,633.76
X$69255 407 4149 5424 5452 407 5453 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69258 r0 *1 460.46,633.76
X$69258 375 5423 5426 5451 5425 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $69260 r0 *1 466.9,633.76
X$69260 375 5447 5428 5443 5448 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $69261 r0 *1 471.5,633.76
X$69261 407 5426 5429 5428 5345 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $69263 r0 *1 473.8,633.76
X$69263 407 5429 407 375 5366 375 sky130_fd_sc_hd__inv_1
* cell instance $69269 r0 *1 482.08,633.76
X$69269 407 5349 5348 5347 4362 407 375 375 sky130_fd_sc_hd__or3_1
* cell instance $69271 r0 *1 484.84,633.76
X$69271 407 5430 5349 5438 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $69274 r0 *1 492.66,633.76
X$69274 407 3952 5430 5436 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69275 r0 *1 494.04,633.76
X$69275 407 3648 5430 5434 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69285 r0 *1 513.82,633.76
X$69285 407 4715 375 407 5432 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69307 r0 *1 569.02,633.76
X$69307 407 4103 407 375 4160 375 sky130_fd_sc_hd__buf_4
* cell instance $69418 m0 *1 160.54,639.2
X$69418 375 5508 4810 5509 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69422 m0 *1 167.44,639.2
X$69422 407 5886 375 407 5355 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69424 m0 *1 174.8,639.2
X$69424 375 494 5513 5511 5512 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69429 m0 *1 186.3,639.2
X$69429 407 5051 4970 5515 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69430 m0 *1 187.68,639.2
X$69430 375 5051 5518 4970 5401 407 407 375 sky130_fd_sc_hd__nor3_2
* cell instance $69435 m0 *1 195.04,639.2
X$69435 375 5329 4810 5511 5519 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69436 m0 *1 204.24,639.2
X$69436 375 5329 5480 4938 5445 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69441 m0 *1 215.74,639.2
X$69441 407 5481 375 407 5402 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69448 m0 *1 225.86,639.2
X$69448 375 5524 5482 5483 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69450 m0 *1 230.46,639.2
X$69450 375 5329 5456 4938 5454 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69455 m0 *1 244.26,639.2
X$69455 407 5484 5406 4655 5407 375 5459 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69456 m0 *1 247.02,639.2
X$69456 407 5484 5486 5408 5460 375 5409 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69458 m0 *1 250.24,639.2
X$69458 375 5329 5483 5485 5409 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69461 m0 *1 259.44,639.2
X$69461 407 5533 4605 5408 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69465 m0 *1 264.04,639.2
X$69465 407 5271 375 407 5949 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69469 m0 *1 273.7,639.2
X$69469 407 5534 375 407 5467 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69472 m0 *1 278.3,639.2
X$69472 375 375 5406 407 5313 5386 407 sky130_fd_sc_hd__nor2_2
* cell instance $69473 m0 *1 280.6,639.2
X$69473 407 5488 5535 5385 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69475 m0 *1 283.82,639.2
X$69475 407 5545 5488 5015 5415 375 5537 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69478 m0 *1 286.58,639.2
X$69478 407 5415 5018 5538 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69479 m0 *1 287.96,639.2
X$69479 407 5015 5315 5536 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69482 m0 *1 294.86,639.2
X$69482 407 5333 5490 5489 5414 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $69484 m0 *1 297.62,639.2
X$69484 407 5490 5489 5470 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69485 m0 *1 299,639.2
X$69485 407 5532 5273 5418 5472 375 5473 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69488 m0 *1 303.14,639.2
X$69488 407 5600 4605 5418 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69491 m0 *1 305.44,639.2
X$69491 407 5489 5490 5334 5333 375 407 5532 375 sky130_fd_sc_hd__and4_1
* cell instance $69494 m0 *1 310.04,639.2
X$69494 375 4103 5419 5531 5475 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69498 m0 *1 321.08,639.2
X$69498 407 5530 407 375 5137 375 sky130_fd_sc_hd__inv_1
* cell instance $69499 m0 *1 322.46,639.2
X$69499 375 5529 5494 5333 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69507 m0 *1 338.1,639.2
X$69507 407 5528 407 375 5200 375 sky130_fd_sc_hd__inv_1
* cell instance $69508 m0 *1 339.48,639.2
X$69508 407 5527 375 407 5396 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69513 m0 *1 345.46,639.2
X$69513 375 4926 5590 5420 5335 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69517 m0 *1 360.64,639.2
X$69517 407 5526 375 407 5525 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69519 m0 *1 364.78,639.2
X$69519 375 4926 5585 5420 5195 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69524 m0 *1 378.58,639.2
X$69524 375 4926 5496 5126 5550 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69531 m0 *1 396.06,639.2
X$69531 375 5318 5498 5126 5581 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69532 m0 *1 405.26,639.2
X$69532 407 5497 375 407 5466 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69535 m0 *1 411.7,639.2
X$69535 407 5523 375 407 5380 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69538 m0 *1 419.52,639.2
X$69538 407 5340 375 407 5522 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69541 m0 *1 423.2,639.2
X$69541 407 5521 375 407 5461 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69542 m0 *1 426.88,639.2
X$69542 407 5341 375 407 5520 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69554 m0 *1 452.64,639.2
X$69554 375 4165 5514 5034 5453 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69555 m0 *1 461.84,639.2
X$69555 407 5425 3952 5452 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69558 m0 *1 465.98,639.2
X$69558 407 5427 5500 407 5448 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $69559 m0 *1 469.2,639.2
X$69559 407 5500 5427 5348 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69561 m0 *1 471.04,639.2
X$69561 375 5444 5429 5896 5510 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $69567 m0 *1 481.62,639.2
X$69567 407 5502 5347 5430 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69569 m0 *1 483.46,639.2
X$69569 407 5506 5504 5503 5557 375 407 5288 375 sky130_fd_sc_hd__and4_1
* cell instance $69572 m0 *1 488.98,639.2
X$69572 375 4160 5506 5507 5505 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69716 r0 *1 155.48,639.2
X$69716 375 494 5509 4652 5508 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69721 r0 *1 174.8,639.2
X$69721 407 5437 5513 5561 5562 375 5512 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69730 r0 *1 186.3,639.2
X$69730 407 5513 4837 5564 375 407 5562 375 sky130_fd_sc_hd__a21oi_1
* cell instance $69734 r0 *1 191.36,639.2
X$69734 375 4103 5540 5511 5566 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69735 r0 *1 200.56,639.2
X$69735 407 5480 375 407 5567 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69736 r0 *1 204.24,639.2
X$69736 375 5445 4762 5480 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69741 r0 *1 211.6,639.2
X$69741 407 5569 407 4603 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $69743 r0 *1 215.74,639.2
X$69743 407 5570 407 4787 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $69746 r0 *1 220.8,639.2
X$69746 375 5329 5482 4938 5524 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69749 r0 *1 231.84,639.2
X$69749 407 5456 375 407 5572 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69754 r0 *1 241.96,639.2
X$69754 375 5406 5405 5407 5484 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $69755 r0 *1 244.26,639.2
X$69755 407 5483 5542 5484 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $69756 r0 *1 246.56,639.2
X$69756 407 5577 407 4687 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $69757 r0 *1 250.24,639.2
X$69757 407 5542 5486 4655 5483 375 5460 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69758 r0 *1 253,639.2
X$69758 375 5407 5535 5483 5542 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $69761 r0 *1 257.6,639.2
X$69761 407 5583 375 407 5533 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69768 r0 *1 268.18,639.2
X$69768 407 5379 375 407 6287 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69772 r0 *1 280.14,639.2
X$69772 407 5532 5487 5588 5386 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $69773 r0 *1 281.98,639.2
X$69773 375 4103 5415 5485 5591 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69778 r0 *1 293.02,639.2
X$69778 375 5532 5491 5273 5487 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $69780 r0 *1 296.24,639.2
X$69780 407 5547 4605 5491 5598 375 5599 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $69783 r0 *1 301.76,639.2
X$69783 407 5492 5274 5487 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $69784 r0 *1 304.06,639.2
X$69784 375 5547 5492 5334 5274 5493 5333 407 407 375 sky130_fd_sc_hd__a41oi_1
* cell instance $69785 r0 *1 307.28,639.2
X$69785 375 4103 5492 5531 5601 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69792 r0 *1 320.62,639.2
X$69792 375 4103 5494 5531 5529 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69794 r0 *1 330.28,639.2
X$69794 407 4739 375 407 5597 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69796 r0 *1 334.88,639.2
X$69796 407 5596 375 407 5528 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69797 r0 *1 338.56,639.2
X$69797 407 5594 375 407 5476 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69799 r0 *1 342.24,639.2
X$69799 407 5593 407 375 5326 375 sky130_fd_sc_hd__inv_1
* cell instance $69805 r0 *1 352.36,639.2
X$69805 407 5592 407 375 5067 375 sky130_fd_sc_hd__inv_1
* cell instance $69806 r0 *1 353.74,639.2
X$69806 407 5590 375 407 5589 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69809 r0 *1 358.8,639.2
X$69809 375 4926 5587 5420 5239 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69813 r0 *1 370.3,639.2
X$69813 407 5585 375 407 5586 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69817 r0 *1 375.82,639.2
X$69817 375 4926 5495 5549 5584 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69818 r0 *1 385.02,639.2
X$69818 375 5550 5495 5496 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69821 r0 *1 390.54,639.2
X$69821 375 5318 5580 5126 5582 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69825 r0 *1 402.04,639.2
X$69825 375 5581 5580 5498 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $69826 r0 *1 406.18,639.2
X$69826 375 5318 5618 5579 5578 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69827 r0 *1 415.38,639.2
X$69827 375 5318 5575 5551 5576 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69830 r0 *1 425.5,639.2
X$69830 407 5342 375 407 5574 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69832 r0 *1 429.64,639.2
X$69832 375 5318 5571 5551 5705 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $69837 r0 *1 448.5,639.2
X$69837 407 5338 375 407 5499 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69839 r0 *1 452.18,639.2
X$69839 375 5517 5554 5761 5555 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $69841 r0 *1 457.24,639.2
X$69841 407 5554 407 375 5516 375 sky130_fd_sc_hd__inv_1
* cell instance $69843 r0 *1 459.08,639.2
X$69843 407 5514 3648 5424 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $69845 r0 *1 460.92,639.2
X$69845 375 5425 5427 5555 5514 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $69846 r0 *1 465.52,639.2
X$69846 375 5514 5289 5555 5500 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $69849 r0 *1 470.12,639.2
X$69849 407 5502 5557 5510 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $69852 r0 *1 477.02,639.2
X$69852 407 4244 5501 5557 407 5563 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $69853 r0 *1 478.86,639.2
X$69853 407 3648 5289 5501 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $69855 r0 *1 481.16,639.2
X$69855 407 5504 5557 5503 5506 407 5347 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $69860 r0 *1 486.22,639.2
X$69860 407 5557 5503 5289 5690 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $69863 r0 *1 490.36,639.2
X$69863 407 3952 5559 5506 4244 375 5505 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $70004 m0 *1 156.86,644.64
X$70004 375 5624 5513 5689 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70007 m0 *1 163.3,644.64
X$70007 407 5509 375 407 5626 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70012 m0 *1 173.88,644.64
X$70012 375 494 5539 5511 5630 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70016 m0 *1 184.92,644.64
X$70016 407 5539 5513 5540 5604 407 5401 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70017 m0 *1 187.22,644.64
X$70017 407 5515 5513 5540 4655 375 5565 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70018 m0 *1 189.98,644.64
X$70018 407 5515 5540 5565 5513 5541 407 5566 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70024 m0 *1 197.8,644.64
X$70024 375 5631 5540 5632 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70026 m0 *1 202.4,644.64
X$70026 407 5633 407 5266 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70029 m0 *1 206.08,644.64
X$70029 407 5607 4605 5541 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70033 m0 *1 210.68,644.64
X$70033 407 5637 407 5568 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70034 m0 *1 214.36,644.64
X$70034 407 5982 375 407 5607 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70040 m0 *1 225.4,644.64
X$70040 407 6276 407 4914 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70046 m0 *1 235.06,644.64
X$70046 375 5329 5543 5404 5641 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70048 m0 *1 245.18,644.64
X$70048 407 5542 5406 5846 5610 375 5609 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70052 m0 *1 250.7,644.64
X$70052 407 5644 407 4789 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70053 m0 *1 254.38,644.64
X$70053 375 5612 5542 5543 5611 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $70058 m0 *1 259.44,644.64
X$70058 375 5653 5673 5485 5646 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70062 m0 *1 271.86,644.64
X$70062 407 5536 5544 5486 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $70069 m0 *1 280.6,644.64
X$70069 375 5487 5544 5532 5588 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $70070 m0 *1 282.9,644.64
X$70070 407 5532 5487 5545 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $70071 m0 *1 285.2,644.64
X$70071 407 5660 5537 5538 5591 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $70076 m0 *1 289.8,644.64
X$70076 407 5614 5536 5546 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $70077 m0 *1 291.18,644.64
X$70077 375 5546 5392 5614 4605 5730 5663 407 407 375 sky130_fd_sc_hd__o221a_2
* cell instance $70079 m0 *1 296.24,644.64
X$70079 407 5731 4605 5598 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70081 m0 *1 301.3,644.64
X$70081 407 5665 375 407 5600 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70084 m0 *1 305.9,644.64
X$70084 407 5532 5536 4655 5492 375 5664 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70087 m0 *1 312.8,644.64
X$70087 375 4103 5615 5531 5662 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70093 m0 *1 327.06,644.64
X$70093 407 5494 375 407 5659 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70098 m0 *1 334.42,644.64
X$70098 407 5657 407 375 5595 375 sky130_fd_sc_hd__inv_1
* cell instance $70102 m0 *1 339.02,644.64
X$70102 407 5616 407 375 4538 375 sky130_fd_sc_hd__inv_1
* cell instance $70105 m0 *1 340.4,644.64
X$70105 407 5655 375 407 5593 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70109 m0 *1 349.14,644.64
X$70109 407 5652 375 407 5592 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70112 m0 *1 355.12,644.64
X$70112 407 5548 407 375 5196 375 sky130_fd_sc_hd__inv_1
* cell instance $70113 m0 *1 356.5,644.64
X$70113 407 5650 375 407 5548 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70116 m0 *1 364.32,644.64
X$70116 407 5587 375 407 5648 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70119 m0 *1 368,644.64
X$70119 375 5318 5617 5549 5645 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70122 m0 *1 379.96,644.64
X$70122 375 5584 5495 5714 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70131 m0 *1 396.98,644.64
X$70131 375 5582 5580 5643 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70136 m0 *1 409.86,644.64
X$70136 375 5578 5575 5618 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70141 m0 *1 416.76,644.64
X$70141 375 5576 5575 5710 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70146 m0 *1 426.42,644.64
X$70146 375 5318 5620 5551 5619 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70147 m0 *1 435.62,644.64
X$70147 407 5571 375 407 5573 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70150 m0 *1 443.44,644.64
X$70150 375 5639 5681 5638 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70152 m0 *1 448.04,644.64
X$70152 375 4165 5555 5621 5553 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70155 m0 *1 457.24,644.64
X$70155 407 5555 3648 5634 407 5553 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70156 m0 *1 459.08,644.64
X$70156 407 5555 4244 5634 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $70159 m0 *1 462.76,644.64
X$70159 407 5555 5514 5500 5502 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $70161 m0 *1 465.52,644.64
X$70161 407 4244 5556 5500 407 5695 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70162 m0 *1 467.36,644.64
X$70162 407 5427 3648 5556 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70168 m0 *1 474.26,644.64
X$70168 407 5557 3648 5502 5563 407 375 5628 375 sky130_fd_sc_hd__o31ai_1
* cell instance $70173 m0 *1 479.32,644.64
X$70173 407 5506 375 407 5552 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70174 m0 *1 483,644.64
X$70174 407 5557 5503 5504 5558 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $70175 m0 *1 484.84,644.64
X$70175 407 5348 5558 5625 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70176 m0 *1 486.22,644.64
X$70176 407 5625 5506 407 5559 375 375 sky130_fd_sc_hd__xor2_1
* cell instance $70325 r0 *1 155.94,644.64
X$70325 375 494 5689 5688 5624 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70327 r0 *1 165.6,644.64
X$70327 375 494 5604 5511 5627 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70328 r0 *1 174.8,644.64
X$70328 407 5629 4605 5561 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70329 r0 *1 176.18,644.64
X$70329 407 5667 5602 5630 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70331 r0 *1 177.56,644.64
X$70331 407 5437 5540 4655 5513 5539 407 5667 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70333 r0 *1 181.24,644.64
X$70333 407 6193 4605 5603 407 5602 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70334 r0 *1 183.08,644.64
X$70334 407 5539 5513 5540 5437 407 5603 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70335 r0 *1 185.38,644.64
X$70335 407 5515 5539 5540 5513 375 407 5605 375 sky130_fd_sc_hd__and4_1
* cell instance $70336 r0 *1 188.6,644.64
X$70336 407 5605 5604 5606 5694 375 5627 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70337 r0 *1 191.36,644.64
X$70337 407 5604 4655 5605 5694 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $70340 r0 *1 195.96,644.64
X$70340 375 4103 5632 5511 5631 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70348 r0 *1 211.6,644.64
X$70348 375 5699 5636 5635 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70351 r0 *1 217.12,644.64
X$70351 375 5329 5702 5608 5640 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70352 r0 *1 226.32,644.64
X$70352 407 5482 375 407 5775 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70358 r0 *1 236.44,644.64
X$70358 407 5406 5543 5692 5706 375 5641 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70359 r0 *1 239.2,644.64
X$70359 407 5543 4655 5406 5706 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $70361 r0 *1 242.88,644.64
X$70361 375 5329 5611 5404 5609 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70364 r0 *1 253.46,644.64
X$70364 407 5486 5543 5612 4655 375 5784 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70369 r0 *1 261.28,644.64
X$70369 407 5486 5331 5647 5535 407 5717 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70371 r0 *1 264.04,644.64
X$70371 375 5646 5673 5651 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70372 r0 *1 268.18,644.64
X$70372 407 5651 5331 5647 5535 407 5721 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70374 r0 *1 270.94,644.64
X$70374 375 5653 5647 5485 5726 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70375 r0 *1 280.14,644.64
X$70375 407 5588 5331 5491 5535 407 5674 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70376 r0 *1 282.44,644.64
X$70376 407 5675 4605 5613 407 5660 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70377 r0 *1 284.28,644.64
X$70377 407 5415 5536 5545 5613 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $70384 r0 *1 293.48,644.64
X$70384 375 4103 5614 5748 5663 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70387 r0 *1 305.44,644.64
X$70387 407 5532 5536 5735 5492 5664 407 5601 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70388 r0 *1 308.66,644.64
X$70388 407 5736 4605 5735 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70392 r0 *1 314.18,644.64
X$70392 375 5662 5615 5492 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70395 r0 *1 319.24,644.64
X$70395 407 5661 407 375 5006 375 sky130_fd_sc_hd__inv_1
* cell instance $70399 r0 *1 328.44,644.64
X$70399 375 5789 5727 5658 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70402 r0 *1 339.94,644.64
X$70402 407 4849 375 407 5722 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70404 r0 *1 343.62,644.64
X$70404 407 5654 407 375 5656 375 sky130_fd_sc_hd__inv_1
* cell instance $70410 r0 *1 349.6,644.64
X$70410 375 4194 5420 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $70412 r0 *1 360.64,644.64
X$70412 375 5783 5678 5649 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70417 r0 *1 369.84,644.64
X$70417 375 5645 5719 5617 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70424 r0 *1 387.78,644.64
X$70424 407 5496 375 407 5713 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70429 r0 *1 397.9,644.64
X$70429 407 5642 375 407 5643 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70434 r0 *1 407.1,644.64
X$70434 407 5498 375 407 5712 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70435 r0 *1 410.78,644.64
X$70435 407 5618 375 407 5711 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70444 r0 *1 431.94,644.64
X$70444 375 5705 5620 5571 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70447 r0 *1 438.38,644.64
X$70447 375 5318 5638 5621 5639 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70448 r0 *1 447.58,644.64
X$70448 407 5555 375 407 5700 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70455 r0 *1 460,644.64
X$70455 407 5514 375 407 5622 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70457 r0 *1 464.6,644.64
X$70457 407 5500 5623 5695 407 5696 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70458 r0 *1 466.44,644.64
X$70458 407 5427 3952 5623 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $70460 r0 *1 468.74,644.64
X$70460 407 5500 5427 5557 5693 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $70463 r0 *1 473.34,644.64
X$70463 375 4165 5557 5507 5628 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70469 r0 *1 486.22,644.64
X$70469 407 5690 5504 5686 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $70612 m0 *1 155.94,650.08
X$70612 407 5689 375 407 6265 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70616 m0 *1 167.44,650.08
X$70616 375 5691 5604 5738 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70619 m0 *1 173.88,650.08
X$70619 407 5666 4605 5692 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70624 m0 *1 179.86,650.08
X$70624 407 5604 5539 5540 5513 375 407 5668 375 sky130_fd_sc_hd__and4_1
* cell instance $70625 m0 *1 183.08,650.08
X$70625 375 3858 5511 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $70626 m0 *1 192.28,650.08
X$70626 407 5669 4837 5440 375 407 5697 375 sky130_fd_sc_hd__a21oi_1
* cell instance $70629 m0 *1 195.04,650.08
X$70629 407 5899 4605 5606 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70634 m0 *1 203.32,650.08
X$70634 407 5632 375 407 5698 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70639 m0 *1 209.3,650.08
X$70639 375 5329 5636 5608 5699 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70644 m0 *1 224.94,650.08
X$70644 407 6214 375 407 5779 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70646 m0 *1 229.08,650.08
X$70646 375 5329 5671 5404 5670 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70649 m0 *1 238.28,650.08
X$70649 375 5670 5671 5543 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70651 m0 *1 242.88,650.08
X$70651 407 5709 407 5189 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70652 m0 *1 246.56,650.08
X$70652 407 5406 5612 4655 5543 5611 407 5610 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70657 m0 *1 258.52,650.08
X$70657 407 5716 5718 5717 375 407 5672 375 sky130_fd_sc_hd__a21oi_1
* cell instance $70660 m0 *1 260.36,650.08
X$70660 375 5653 5651 5485 5672 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70661 m0 *1 269.56,650.08
X$70661 407 5485 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $70663 m0 *1 271.86,650.08
X$70663 407 5536 5544 5724 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $70665 m0 *1 274.16,650.08
X$70665 407 5728 5647 4605 5674 5726 407 375 375 sky130_fd_sc_hd__a31o_2
* cell instance $70667 m0 *1 277.84,650.08
X$70667 407 5647 5674 5852 407 5728 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $70670 m0 *1 283.82,650.08
X$70670 407 5536 5545 5794 407 375 375 sky130_fd_sc_hd__and2_1
* cell instance $70675 m0 *1 290.26,650.08
X$70675 407 5996 375 407 5730 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70676 m0 *1 293.94,650.08
X$70676 407 5732 375 407 5731 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70680 m0 *1 305.44,650.08
X$70680 407 5734 375 407 5736 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70686 m0 *1 315.1,650.08
X$70686 407 5848 4605 5733 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70687 m0 *1 316.48,650.08
X$70687 407 5676 5733 5493 5677 375 407 375 sky130_fd_sc_hd__nor3_1
* cell instance $70688 m0 *1 318.32,650.08
X$70688 407 5729 5273 4655 5658 375 5676 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70690 m0 *1 321.54,650.08
X$70690 375 4103 5658 5531 5677 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70694 m0 *1 333.5,650.08
X$70694 407 5725 375 407 5657 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70697 m0 *1 338.56,650.08
X$70697 407 6303 375 407 5654 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70700 m0 *1 342.24,650.08
X$70700 407 5723 375 407 5616 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70704 m0 *1 349.14,650.08
X$70704 375 5420 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $70706 m0 *1 360.64,650.08
X$70706 375 5720 5678 5841 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70712 m0 *1 368,650.08
X$70712 375 5318 5719 5549 5782 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70715 m0 *1 381.8,650.08
X$70715 407 5715 375 407 5714 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70726 m0 *1 398.82,650.08
X$70726 375 5318 5755 5126 5771 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70731 m0 *1 416.76,650.08
X$70731 407 6117 375 407 5710 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70733 m0 *1 420.9,650.08
X$70733 407 5708 375 407 5707 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70739 m0 *1 427.8,650.08
X$70739 407 5638 375 407 5679 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70740 m0 *1 431.48,650.08
X$70740 375 5619 5620 5703 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70741 m0 *1 435.62,650.08
X$70741 407 5704 375 407 5703 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70745 m0 *1 443.9,650.08
X$70745 375 5701 5681 5820 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70750 m0 *1 450.34,650.08
X$70750 407 5682 375 407 5683 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70751 m0 *1 454.02,650.08
X$70751 407 5500 375 407 5680 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70753 m0 *1 458.16,650.08
X$70753 407 5683 407 375 5451 375 sky130_fd_sc_hd__inv_1
* cell instance $70755 m0 *1 460,650.08
X$70755 375 4165 5500 5507 5696 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70763 m0 *1 478.4,650.08
X$70763 407 5693 5503 5685 407 375 375 sky130_fd_sc_hd__xnor2_1
* cell instance $70764 m0 *1 481.62,650.08
X$70764 407 3952 5685 5503 4244 375 5757 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $70766 m0 *1 485.76,650.08
X$70766 407 3952 5686 5504 4244 375 5687 407 375 sky130_fd_sc_hd__a22o_1
* cell instance $70767 m0 *1 488.98,650.08
X$70767 375 4103 5504 5507 5687 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70913 r0 *1 162.84,650.08
X$70913 375 494 5738 4652 5691 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70914 r0 *1 172.04,650.08
X$70914 407 5758 5669 5741 5518 407 5756 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $70918 r0 *1 178.94,650.08
X$70918 407 5511 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $70920 r0 *1 181.24,650.08
X$70920 407 5762 5668 4655 5437 5740 407 5764 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70921 r0 *1 184.46,650.08
X$70921 407 5765 407 5259 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70922 r0 *1 188.14,650.08
X$70922 375 4103 5669 5511 5766 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70929 r0 *1 210.68,650.08
X$70929 407 5769 375 407 5635 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70931 r0 *1 218.04,650.08
X$70931 375 5640 5636 5702 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70933 r0 *1 224.02,650.08
X$70933 407 5702 375 407 5774 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70935 r0 *1 228.16,650.08
X$70935 407 5777 407 5186 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70937 r0 *1 231.84,650.08
X$70937 375 5776 5807 5612 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70939 r0 *1 236.44,650.08
X$70939 407 5671 375 407 5781 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70940 r0 *1 240.12,650.08
X$70940 375 5780 5742 5407 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70941 r0 *1 244.26,650.08
X$70941 375 5329 5612 5485 5743 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70942 r0 *1 253.46,650.08
X$70942 407 5543 5612 5744 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $70943 r0 *1 254.84,650.08
X$70943 407 5784 5785 5743 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $70945 r0 *1 257.14,650.08
X$70945 407 5724 5744 4605 5745 5785 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $70948 r0 *1 259.9,650.08
X$70948 407 5786 375 407 5745 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70950 r0 *1 264.04,650.08
X$70950 407 5746 5721 5790 4605 5791 407 375 375 sky130_fd_sc_hd__o211ai_1
* cell instance $70951 r0 *1 266.8,650.08
X$70951 375 4194 5485 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $70953 r0 *1 276.46,650.08
X$70953 407 5793 407 5063 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70955 r0 *1 281.06,650.08
X$70955 375 5653 5796 5748 5795 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70961 r0 *1 293.02,650.08
X$70961 407 5491 5415 5747 4655 375 5749 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70962 r0 *1 295.78,650.08
X$70962 407 5491 5747 5797 5415 5749 407 5798 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $70970 r0 *1 316.48,650.08
X$70970 375 5273 5493 5658 5729 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $70972 r0 *1 319.24,650.08
X$70972 407 5729 5536 5751 5847 375 5792 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $70973 r0 *1 322,650.08
X$70973 375 5788 5489 5750 5658 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $70976 r0 *1 327.06,650.08
X$70976 375 4103 5727 5420 5789 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70984 r0 *1 348.68,650.08
X$70984 407 5787 407 375 4995 375 sky130_fd_sc_hd__inv_1
* cell instance $70985 r0 *1 350.06,650.08
X$70985 375 4103 5678 5420 5720 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70986 r0 *1 359.26,650.08
X$70986 375 4103 5649 5752 5783 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70990 r0 *1 369.84,650.08
X$70990 375 5782 5719 5837 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70993 r0 *1 378.12,650.08
X$70993 375 5318 5778 5549 5835 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $70994 r0 *1 387.32,650.08
X$70994 375 5961 5778 5753 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $70997 r0 *1 393.76,650.08
X$70997 407 5754 375 407 5772 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $70999 r0 *1 397.44,650.08
X$70999 375 5773 5770 5772 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71001 r0 *1 402.04,650.08
X$71001 375 5771 5770 5755 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71005 r0 *1 409.4,650.08
X$71005 375 5318 5768 5579 5830 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71006 r0 *1 418.6,650.08
X$71006 375 5318 5708 5551 5767 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71008 r0 *1 427.8,650.08
X$71008 407 5551 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $71010 r0 *1 429.64,650.08
X$71010 375 3947 5551 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71011 r0 *1 438.84,650.08
X$71011 375 5318 5681 5551 5701 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71016 r0 *1 453.1,650.08
X$71016 407 5763 375 407 5761 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71021 r0 *1 468.28,650.08
X$71021 407 5557 375 407 5760 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71022 r0 *1 471.96,650.08
X$71022 407 5504 375 407 5759 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71171 m0 *1 152.72,655.52
X$71171 375 494 5758 5688 5737 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71173 m0 *1 165.6,655.52
X$71173 407 5758 407 375 5802 375 sky130_fd_sc_hd__inv_1
* cell instance $71176 m0 *1 168.36,655.52
X$71176 407 5800 4605 5885 407 5799 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $71178 m0 *1 170.66,655.52
X$71178 407 5801 4605 5802 5821 375 407 5737 375 sky130_fd_sc_hd__a31oi_1
* cell instance $71179 m0 *1 172.96,655.52
X$71179 407 5801 5802 4605 6190 5821 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $71184 m0 *1 178.02,655.52
X$71184 407 5437 5669 5741 5668 407 5801 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $71186 m0 *1 181.24,655.52
X$71186 407 5825 407 5048 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71187 m0 *1 184.92,655.52
X$71187 407 5826 407 5439 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71188 m0 *1 188.6,655.52
X$71188 407 5740 5668 5762 5264 407 375 375 sky130_fd_sc_hd__nand3_1
* cell instance $71190 m0 *1 190.9,655.52
X$71190 407 5827 407 5301 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71192 m0 *1 195.04,655.52
X$71192 407 5668 5437 5697 5669 5829 407 5766 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71195 m0 *1 199.64,655.52
X$71195 407 5518 5741 5903 5669 5902 407 5804 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71197 m0 *1 203.32,655.52
X$71197 375 4103 5741 5831 5804 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71201 m0 *1 213.44,655.52
X$71201 407 5805 407 5303 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71202 m0 *1 217.12,655.52
X$71202 375 5910 5741 5838 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71206 m0 *1 223.1,655.52
X$71206 407 5840 407 5836 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71207 m0 *1 226.78,655.52
X$71207 375 5329 5807 5608 5776 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71211 m0 *1 237.82,655.52
X$71211 375 5329 5742 5404 5780 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71212 m0 *1 247.02,655.52
X$71212 407 5915 4605 5846 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71216 m0 *1 250.24,655.52
X$71216 375 5916 5808 5611 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71218 m0 *1 258.06,655.52
X$71218 407 5724 5721 4605 5739 5716 375 407 375 sky130_fd_sc_hd__o22ai_1
* cell instance $71222 m0 *1 261.28,655.52
X$71222 407 5651 4655 5718 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71223 m0 *1 262.66,655.52
X$71223 375 5653 5790 5485 5850 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71226 m0 *1 276,655.52
X$71226 407 5273 5544 5746 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71229 m0 *1 278.76,655.52
X$71229 407 6343 4655 5852 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71231 m0 *1 281.98,655.52
X$71231 375 5926 5588 5796 5810 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $71233 m0 *1 285.2,655.52
X$71233 407 5810 5491 5853 5796 5854 407 5795 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71237 m0 *1 290.26,655.52
X$71237 375 5747 5810 5415 5811 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $71238 m0 *1 292.56,655.52
X$71238 407 5794 5747 4655 5415 5811 407 5851 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71239 m0 *1 295.78,655.52
X$71239 375 5653 5747 5748 5798 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71241 m0 *1 305.44,655.52
X$71241 375 5935 5812 5747 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71244 m0 *1 312.34,655.52
X$71244 407 5849 375 407 5848 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71247 m0 *1 316.02,655.52
X$71247 375 5788 5729 5750 5490 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $71248 m0 *1 318.32,655.52
X$71248 407 5490 5536 5788 5750 4655 407 5847 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71250 m0 *1 322,655.52
X$71250 375 4103 5788 5531 5792 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71256 m0 *1 337.64,655.52
X$71256 375 4103 5844 5420 5813 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71261 m0 *1 349.14,655.52
X$71261 407 5843 375 407 4379 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71263 m0 *1 356.5,655.52
X$71263 407 5842 375 407 5841 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71271 m0 *1 369.38,655.52
X$71271 407 5839 375 407 5837 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71272 m0 *1 373.06,655.52
X$71272 407 5617 375 407 6313 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71274 m0 *1 377.66,655.52
X$71274 407 5549 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $71275 m0 *1 379.04,655.52
X$71275 375 5835 5778 5834 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71279 m0 *1 388.24,655.52
X$71279 407 5753 375 407 5833 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71284 m0 *1 396.06,655.52
X$71284 375 5318 5770 5579 5773 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71286 m0 *1 405.72,655.52
X$71286 407 5755 375 407 5870 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71288 m0 *1 411.24,655.52
X$71288 375 5830 5768 5828 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71291 m0 *1 417.68,655.52
X$71291 375 5767 5768 5708 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71296 m0 *1 423.2,655.52
X$71296 375 4103 5815 5551 5824 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71297 m0 *1 432.4,655.52
X$71297 375 5822 5815 5816 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71300 m0 *1 439.3,655.52
X$71300 407 5816 375 407 5818 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71304 m0 *1 445.74,655.52
X$71304 407 5817 375 407 5820 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71307 m0 *1 449.42,655.52
X$71307 375 4103 5906 5621 5909 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71318 m0 *1 477.48,655.52
X$71318 375 4103 5503 5507 5757 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71459 r0 *1 139.84,655.52
X$71459 375 494 5855 5688 5875 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71460 r0 *1 149.04,655.52
X$71460 375 5879 5758 5877 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71466 r0 *1 158.7,655.52
X$71466 375 494 5857 5688 5856 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71467 r0 *1 167.9,655.52
X$71467 407 5858 407 5352 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71469 r0 *1 172.04,655.52
X$71469 407 5857 5758 5741 5669 375 407 5762 375 sky130_fd_sc_hd__and4_1
* cell instance $71470 r0 *1 175.26,655.52
X$71470 407 5518 5762 5885 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71472 r0 *1 177.1,655.52
X$71472 407 5764 5803 5889 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71474 r0 *1 178.48,655.52
X$71474 407 5668 5740 5437 5762 407 5860 375 375 sky130_fd_sc_hd__nand4_1
* cell instance $71476 r0 *1 181.24,655.52
X$71476 407 5891 4605 5860 407 5803 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $71477 r0 *1 183.08,655.52
X$71477 407 5892 407 5823 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71478 r0 *1 186.76,655.52
X$71478 407 5893 407 5356 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71480 r0 *1 190.9,655.52
X$71480 407 5895 375 407 5899 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71481 r0 *1 194.58,655.52
X$71481 407 5898 4605 5829 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71485 r0 *1 199.18,655.52
X$71485 407 5518 5669 5741 4655 375 5903 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $71487 r0 *1 202.86,655.52
X$71487 407 5905 4605 5902 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71492 r0 *1 208.84,655.52
X$71492 375 5907 5669 5863 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71495 r0 *1 215.74,655.52
X$71495 375 4103 5838 5608 5910 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71498 r0 *1 226.32,655.52
X$71498 407 5806 407 5365 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71499 r0 *1 230,655.52
X$71499 407 5838 375 407 5914 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71504 r0 *1 236.44,655.52
X$71504 407 5779 4655 5864 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71506 r0 *1 238.74,655.52
X$71506 375 4194 5404 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71507 r0 *1 247.94,655.52
X$71507 375 5329 5808 5404 5916 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71511 r0 *1 259.44,655.52
X$71511 375 5920 5921 5647 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71514 r0 *1 264.96,655.52
X$71514 375 5790 5850 5791 5746 5721 5864 407 407 375 sky130_fd_sc_hd__o311ai_0
* cell instance $71516 r0 *1 271.86,655.52
X$71516 375 5653 5926 5485 5931 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71518 r0 *1 282.9,655.52
X$71518 407 5588 5794 5930 5929 375 5931 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $71521 r0 *1 286.12,655.52
X$71521 407 5810 5491 4655 5796 375 5854 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $71526 r0 *1 293.48,655.52
X$71526 375 5653 5811 5748 5932 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71527 r0 *1 302.68,655.52
X$71527 407 5937 4605 5797 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71529 r0 *1 304.52,655.52
X$71529 375 5653 5812 5748 5935 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71531 r0 *1 313.72,655.52
X$71531 407 6145 4605 5751 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71534 r0 *1 319.24,655.52
X$71534 407 5531 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $71535 r0 *1 321.08,655.52
X$71535 375 4194 5531 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71538 r0 *1 333.04,655.52
X$71538 375 5813 5844 5788 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71539 r0 *1 337.18,655.52
X$71539 375 4103 5845 5420 5939 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71543 r0 *1 347.3,655.52
X$71543 407 5938 375 407 5787 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71545 r0 *1 352.82,655.52
X$71545 375 4103 5867 5752 5934 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71548 r0 *1 364.78,655.52
X$71548 407 5649 375 407 5933 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71554 r0 *1 376.28,655.52
X$71554 407 5868 375 407 5834 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71555 r0 *1 379.96,655.52
X$71555 375 3947 5549 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71556 r0 *1 389.16,655.52
X$71556 407 6173 407 5832 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71557 r0 *1 392.84,655.52
X$71557 407 6135 375 407 5814 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71565 r0 *1 404.8,655.52
X$71565 407 5579 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $71566 r0 *1 406.18,655.52
X$71566 375 4103 5983 5579 5922 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71567 r0 *1 415.38,655.52
X$71567 407 5917 375 407 5828 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71568 r0 *1 419.06,655.52
X$71568 407 5919 407 5219 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71571 r0 *1 424.58,655.52
X$71571 375 5824 5815 5814 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71575 r0 *1 430.56,655.52
X$71575 375 4103 5816 5551 5822 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71576 r0 *1 439.76,655.52
X$71576 375 4103 5911 5621 5913 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71580 r0 *1 450.34,655.52
X$71580 375 5909 5906 5974 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71584 r0 *1 457.24,655.52
X$71584 375 5908 5906 5871 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71589 r0 *1 468.28,655.52
X$71589 407 5503 375 407 5900 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71593 r0 *1 479.32,655.52
X$71593 407 5507 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $71595 r0 *1 481.62,655.52
X$71595 407 5890 407 375 5887 375 sky130_fd_sc_hd__inv_1
* cell instance $71596 r0 *1 483,655.52
X$71596 407 5874 5872 5819 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71598 r0 *1 484.84,655.52
X$71598 375 5888 5876 5887 5685 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $71599 r0 *1 489.44,655.52
X$71599 375 5874 5878 5881 5438 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $71736 m0 *1 142.6,660.96
X$71736 375 5875 5940 5855 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71737 m0 *1 146.74,660.96
X$71737 375 494 5877 5688 5879 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71741 m0 *1 157.78,660.96
X$71741 375 494 5942 5688 5973 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71743 m0 *1 167.44,660.96
X$71743 407 5884 407 5886 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71744 m0 *1 171.12,660.96
X$71744 407 5799 5756 5859 375 407 5856 375 sky130_fd_sc_hd__a21oi_1
* cell instance $71745 m0 *1 172.96,660.96
X$71745 407 5857 4655 5859 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71751 m0 *1 180.32,660.96
X$71751 375 494 5740 5511 5889 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71754 m0 *1 190.9,660.96
X$71754 407 5897 375 407 5898 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71757 m0 *1 195.96,660.96
X$71757 375 4103 5862 5831 5904 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71760 m0 *1 205.16,660.96
X$71760 407 5862 4605 5981 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71762 m0 *1 207.46,660.96
X$71762 375 4103 5863 5831 5907 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71764 m0 *1 218.5,660.96
X$71764 407 5863 375 407 6275 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71766 m0 *1 222.64,660.96
X$71766 375 3858 5608 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71771 m0 *1 234.6,660.96
X$71771 407 5807 375 407 5947 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71773 m0 *1 239.2,660.96
X$71773 407 5948 4605 6042 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $71775 m0 *1 242.42,660.96
X$71775 407 5404 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $71776 m0 *1 244.26,660.96
X$71776 407 6043 375 407 5915 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71780 m0 *1 252.08,660.96
X$71780 407 5918 407 5462 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71783 m0 *1 258.06,660.96
X$71783 375 5653 5921 5485 5920 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71789 m0 *1 273.7,660.96
X$71789 407 5925 407 5534 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71791 m0 *1 277.84,660.96
X$71791 375 5994 5950 5926 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71792 m0 *1 281.98,660.96
X$71792 407 5810 5794 5926 5796 4655 407 5929 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71794 m0 *1 285.66,660.96
X$71794 407 5951 4605 5853 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71797 m0 *1 287.04,660.96
X$71797 407 5810 5794 5865 5851 375 5932 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $71798 m0 *1 289.8,660.96
X$71798 375 5995 6006 5415 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71799 m0 *1 293.94,660.96
X$71799 375 5748 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $71801 m0 *1 305.44,660.96
X$71801 407 5936 407 5665 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71803 m0 *1 310.96,660.96
X$71803 407 6149 4605 5866 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $71808 m0 *1 315.1,660.96
X$71808 407 5490 5273 4655 5750 375 5955 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $71809 m0 *1 317.86,660.96
X$71809 407 5490 5273 5866 5750 5955 407 5957 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $71812 m0 *1 323.38,660.96
X$71812 375 4103 5750 5531 5957 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71816 m0 *1 334.42,660.96
X$71816 375 5939 5845 5750 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71825 m0 *1 356.04,660.96
X$71825 375 5934 5867 5992 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71833 m0 *1 370.76,660.96
X$71833 375 5318 5960 5752 5869 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71834 m0 *1 379.96,660.96
X$71834 375 5869 5928 5960 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71837 m0 *1 388.24,660.96
X$71837 375 5318 5985 5549 5927 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71840 m0 *1 397.44,660.96
X$71840 375 5318 5963 5549 6049 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71842 m0 *1 407.1,660.96
X$71842 407 5924 407 5307 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71843 m0 *1 410.78,660.96
X$71843 407 5923 407 5497 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71846 m0 *1 415.84,660.96
X$71846 375 5984 5983 5964 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71851 m0 *1 422.74,660.96
X$71851 375 4103 5966 5551 6037 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71852 m0 *1 431.94,660.96
X$71852 375 4103 5967 5551 5977 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71855 m0 *1 443.44,660.96
X$71855 375 5913 5967 5911 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $71856 m0 *1 447.58,660.96
X$71856 407 5912 407 5458 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $71861 m0 *1 454.02,660.96
X$71861 375 4103 5871 5621 5908 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $71862 m0 *1 463.22,660.96
X$71862 407 5871 375 407 5972 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $71865 m0 *1 469.2,660.96
X$71865 407 5901 407 375 5896 375 sky130_fd_sc_hd__inv_1
* cell instance $71869 m0 *1 475.18,660.96
X$71869 407 5894 407 375 5052 375 sky130_fd_sc_hd__inv_1
* cell instance $71874 m0 *1 479.32,660.96
X$71874 375 3947 5507 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $71875 m0 *1 488.52,660.96
X$71875 375 5969 5873 5883 5686 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $71876 m0 *1 493.12,660.96
X$71876 407 5873 5969 5876 375 407 5880 375 sky130_fd_sc_hd__a21oi_1
* cell instance $71877 m0 *1 494.96,660.96
X$71877 407 5878 5874 5970 375 407 5882 375 sky130_fd_sc_hd__a21oi_1
* cell instance $72015 r0 *1 137.54,660.96
X$72015 375 494 5940 5688 5941 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72016 r0 *1 146.74,660.96
X$72016 375 5941 5940 6018 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72021 r0 *1 153.64,660.96
X$72021 375 3858 5688 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72023 r0 *1 163.3,660.96
X$72023 375 5973 5857 5942 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72025 r0 *1 167.9,660.96
X$72025 407 5942 375 407 5975 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72026 r0 *1 171.58,660.96
X$72026 375 494 5978 5511 5943 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72029 r0 *1 181.24,660.96
X$72029 375 5943 5740 5978 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72032 r0 *1 187.68,660.96
X$72032 375 6026 5539 5980 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72036 r0 *1 197.8,660.96
X$72036 375 4103 6031 5831 5861 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72038 r0 *1 207,660.96
X$72038 407 6107 5981 5904 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72041 r0 *1 212.52,660.96
X$72041 407 5944 407 5982 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72042 r0 *1 216.2,660.96
X$72042 407 6273 407 5481 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72044 r0 *1 220.34,660.96
X$72044 407 5608 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $72045 r0 *1 222.18,660.96
X$72045 375 5329 5946 5608 5945 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72046 r0 *1 231.38,660.96
X$72046 375 5945 5946 5948 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72050 r0 *1 236.44,660.96
X$72050 375 5329 5948 5404 6040 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72051 r0 *1 245.64,660.96
X$72051 407 5742 375 407 5987 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72053 r0 *1 253,660.96
X$72053 407 5990 407 5989 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72055 r0 *1 257.6,660.96
X$72055 407 5991 407 5583 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72062 r0 *1 266.8,660.96
X$72062 375 6052 5993 5790 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72063 r0 *1 270.94,660.96
X$72063 375 5653 5950 5485 5994 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72066 r0 *1 282.44,660.96
X$72066 407 6242 4605 5930 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $72067 r0 *1 283.82,660.96
X$72067 407 6137 375 407 5951 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72069 r0 *1 287.5,660.96
X$72069 407 5997 407 5996 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72072 r0 *1 292.56,660.96
X$72072 407 6243 4605 5865 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $72073 r0 *1 293.94,660.96
X$72073 375 4194 5748 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72077 r0 *1 306.36,660.96
X$72077 375 6058 6007 5614 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72078 r0 *1 310.5,660.96
X$72078 407 6345 375 407 5952 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72080 r0 *1 314.18,660.96
X$72080 407 5952 4605 5953 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $72082 r0 *1 316.02,660.96
X$72082 407 5490 5536 5953 6059 375 5954 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $72084 r0 *1 319.24,660.96
X$72084 407 5536 6008 4655 5614 5956 407 6059 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $72086 r0 *1 326.14,660.96
X$72086 375 4103 5956 5531 5954 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72096 r0 *1 355.58,660.96
X$72096 375 4103 6012 5752 5958 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72097 r0 *1 364.78,660.96
X$72097 375 4103 6011 5752 6154 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72100 r0 *1 374.44,660.96
X$72100 407 5959 375 407 5974 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72101 r0 *1 378.12,660.96
X$72101 407 5988 375 407 6053 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72102 r0 *1 381.8,660.96
X$72102 375 5318 5753 5549 5961 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72105 r0 *1 393.76,660.96
X$72105 407 5986 407 6051 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72107 r0 *1 397.44,660.96
X$72107 375 6049 5985 5963 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72109 r0 *1 402.04,660.96
X$72109 375 4103 5965 5579 6046 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72112 r0 *1 414,660.96
X$72112 375 4103 5964 5579 5984 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72116 r0 *1 424.58,660.96
X$72116 375 6037 5965 5966 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72119 r0 *1 429.64,660.96
X$72119 407 5966 375 407 5979 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72120 r0 *1 433.32,660.96
X$72120 375 5977 5967 5976 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72124 r0 *1 445.74,660.96
X$72124 407 5621 375 407 375 sky130_fd_sc_hd__clkbuf_1
* cell instance $72125 r0 *1 447.12,660.96
X$72125 375 3947 5621 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72130 r0 *1 458.16,660.96
X$72130 375 5968 5867 5971 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72131 r0 *1 462.3,660.96
X$72131 375 4103 5971 5507 5968 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72139 r0 *1 485.3,660.96
X$72139 407 5872 5969 5888 5874 375 407 5350 375 sky130_fd_sc_hd__and4_1
* cell instance $72140 r0 *1 488.52,660.96
X$72140 375 5872 5970 6020 5559 407 407 375 sky130_fd_sc_hd__ha_1
* cell instance $72277 m0 *1 146.28,666.4
X$72277 407 5999 375 407 6018 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72282 m0 *1 154.56,666.4
X$72282 375 494 6000 5688 5998 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72283 m0 *1 163.76,666.4
X$72283 407 6000 4605 6001 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72285 m0 *1 165.6,666.4
X$72285 407 6002 6001 5998 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72287 m0 *1 167.44,666.4
X$72287 407 6019 407 6021 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72295 m0 *1 181.7,666.4
X$72295 407 5978 375 407 6025 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72296 m0 *1 185.38,666.4
X$72296 375 494 5980 5831 6026 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72299 m0 *1 195.96,666.4
X$72299 375 5831 407 407 375 sky130_fd_sc_hd__bufinv_16
* cell instance $72302 m0 *1 207,666.4
X$72302 375 5861 5862 6031 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72304 m0 *1 212.98,666.4
X$72304 407 6033 375 407 6035 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72305 m0 *1 216.66,666.4
X$72305 407 5946 375 407 6274 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72309 m0 *1 226.32,666.4
X$72309 375 5329 6039 5608 6116 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72314 m0 *1 239.66,666.4
X$72314 407 6121 6042 6040 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72316 m0 *1 244.72,666.4
X$72316 407 6044 407 6043 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72322 m0 *1 251.62,666.4
X$72322 375 6048 6070 6129 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72325 m0 *1 258.06,666.4
X$72325 407 5808 375 407 6050 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72329 m0 *1 263.58,666.4
X$72329 375 5653 5993 5485 6052 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72333 m0 *1 277.84,666.4
X$72333 407 4103 407 375 5653 375 sky130_fd_sc_hd__buf_4
* cell instance $72339 m0 *1 286.58,666.4
X$72339 375 5653 6006 5748 5995 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72340 m0 *1 295.78,666.4
X$72340 375 5653 6057 5748 6141 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72342 m0 *1 305.44,666.4
X$72342 375 5653 6007 5748 6058 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72346 m0 *1 315.56,666.4
X$72346 407 5273 5614 6008 4655 375 6009 407 375 sky130_fd_sc_hd__a211oi_1
* cell instance $72347 m0 *1 318.32,666.4
X$72347 407 5273 6008 6060 5614 6009 407 6010 375 375 sky130_fd_sc_hd__a311oi_1
* cell instance $72348 m0 *1 321.54,666.4
X$72348 375 5653 6008 5531 6010 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72352 m0 *1 334.88,666.4
X$72352 375 5653 6056 5420 6155 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72356 m0 *1 347.76,666.4
X$72356 375 5653 6054 5752 6055 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72357 m0 *1 356.96,666.4
X$72357 407 5752 407 375 375 sky130_fd_sc_hd__clkinv_2
* cell instance $72361 m0 *1 360.64,666.4
X$72361 375 5958 6011 6012 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72362 m0 *1 364.78,666.4
X$72362 375 4103 6078 5752 6013 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72367 m0 *1 376.74,666.4
X$72367 375 5318 5928 5549 6150 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72370 m0 *1 388.24,666.4
X$72370 407 6014 375 407 6227 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72372 m0 *1 393.76,666.4
X$72372 375 5927 5985 6134 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72375 m0 *1 397.9,666.4
X$72375 407 6047 375 407 5976 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72377 m0 *1 402.04,666.4
X$72377 375 6046 5965 6045 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72378 m0 *1 406.18,666.4
X$72378 375 3947 5579 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72380 m0 *1 415.84,666.4
X$72380 407 6041 407 5523 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72381 m0 *1 419.52,666.4
X$72381 407 4618 6016 6038 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $72384 m0 *1 421.82,666.4
X$72384 407 6015 407 5521 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72389 m0 *1 435.16,666.4
X$72389 407 6036 407 5704 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72390 m0 *1 438.84,666.4
X$72390 375 6034 6032 6110 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72394 m0 *1 447.58,666.4
X$72394 407 5911 375 407 6030 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72397 m0 *1 451.26,666.4
X$72397 375 4103 6028 5621 6105 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72400 m0 *1 462.76,666.4
X$72400 407 6027 375 407 5901 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72404 m0 *1 471.04,666.4
X$72404 407 6325 375 407 5894 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72408 m0 *1 478.4,666.4
X$72408 407 6024 375 407 5890 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72411 m0 *1 486.22,666.4
X$72411 407 6023 407 375 4973 375 sky130_fd_sc_hd__inv_1
* cell instance $72413 m0 *1 488.52,666.4
X$72413 407 6022 407 375 5881 375 sky130_fd_sc_hd__inv_1
* cell instance $72415 m0 *1 490.36,666.4
X$72415 407 6017 407 375 6020 375 sky130_fd_sc_hd__inv_1
* cell instance $72416 m0 *1 491.74,666.4
X$72416 407 5880 5819 5882 407 5358 375 375 sky130_fd_sc_hd__o21ai_0
* cell instance $72553 r0 *1 137.08,666.4
X$72553 375 494 6062 5688 6087 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72562 r0 *1 155.02,666.4
X$72562 407 5855 375 407 6029 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72564 r0 *1 159.16,666.4
X$72564 375 494 6063 5688 6090 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72565 r0 *1 168.36,666.4
X$72565 407 6003 407 5999 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72567 r0 *1 172.5,666.4
X$72567 407 6064 4655 6094 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72568 r0 *1 173.88,666.4
X$72568 407 6065 4605 6066 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72569 r0 *1 175.26,666.4
X$72569 407 6094 6066 6095 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72573 r0 *1 178.94,666.4
X$72573 407 6067 4655 6002 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72577 r0 *1 183.08,666.4
X$72577 407 6161 407 6160 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72579 r0 *1 187.22,666.4
X$72579 407 6100 375 407 6067 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72582 r0 *1 192.28,666.4
X$72582 407 6103 407 5895 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72583 r0 *1 195.96,666.4
X$72583 375 3858 5831 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72586 r0 *1 207,666.4
X$72586 407 6035 4655 6107 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72590 r0 *1 211.14,666.4
X$72590 407 6108 407 5769 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72592 r0 *1 215.74,666.4
X$72592 375 5329 6114 5608 6004 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72595 r0 *1 226.32,666.4
X$72595 375 6116 6039 6065 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72600 r0 *1 236.44,666.4
X$72600 375 6118 6069 6120 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72602 r0 *1 241.04,666.4
X$72602 407 6124 4655 6121 407 375 375 sky130_fd_sc_hd__nand2_1
* cell instance $72604 r0 *1 242.88,666.4
X$72604 375 6123 6069 6127 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72607 r0 *1 249.78,666.4
X$72607 375 5329 6129 5404 6048 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72610 r0 *1 259.9,666.4
X$72610 407 6130 407 5786 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72614 r0 *1 266.8,666.4
X$72614 407 4824 375 407 6131 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72615 r0 *1 270.48,666.4
X$72615 407 5993 375 407 6288 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72618 r0 *1 276.92,666.4
X$72618 375 5653 6005 5748 6071 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72620 r0 *1 286.12,666.4
X$72620 375 6071 6005 5796 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72624 r0 *1 293.48,666.4
X$72624 407 6139 407 5732 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72627 r0 *1 299.46,666.4
X$72627 375 6141 6057 5811 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72630 r0 *1 304.98,666.4
X$72630 407 6168 407 5734 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72631 r0 *1 308.66,666.4
X$72631 407 6007 375 407 6148 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72632 r0 *1 312.34,666.4
X$72632 407 6146 375 407 6145 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72634 r0 *1 316.02,666.4
X$72634 407 6259 4605 6060 375 407 375 sky130_fd_sc_hd__nor2_1
* cell instance $72638 r0 *1 319.24,666.4
X$72638 375 6008 5490 5614 5956 407 407 375 sky130_fd_sc_hd__and3_1
* cell instance $72640 r0 *1 322,666.4
X$72640 375 6151 6072 6008 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72641 r0 *1 326.14,666.4
X$72641 407 6152 407 375 5203 375 sky130_fd_sc_hd__inv_1
* cell instance $72645 r0 *1 335.8,666.4
X$72645 375 6155 6056 5956 4884 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72651 r0 *1 346.84,666.4
X$72651 375 5653 6075 5752 6156 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72653 r0 *1 356.96,666.4
X$72653 375 4194 5752 407 407 375 sky130_fd_sc_hd__clkbuf_16
* cell instance $72654 r0 *1 366.16,666.4
X$72654 375 6154 6011 6077 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72656 r0 *1 370.3,666.4
X$72656 407 6153 407 5839 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72660 r0 *1 377.2,666.4
X$72660 407 6079 375 407 6144 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72661 r0 *1 380.88,666.4
X$72661 375 6150 5928 6144 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72662 r0 *1 385.02,666.4
X$72662 407 6142 407 5715 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72663 r0 *1 388.7,666.4
X$72663 407 5960 375 407 6140 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72665 r0 *1 393.3,666.4
X$72665 407 6051 375 407 6134 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72667 r0 *1 396.98,666.4
X$72667 407 6133 407 5754 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72670 r0 *1 402.04,666.4
X$72670 407 6132 407 5642 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72671 r0 *1 405.72,666.4
X$72671 407 6128 375 407 6045 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72673 r0 *1 409.86,666.4
X$72673 375 5922 5983 6125 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72674 r0 *1 414,666.4
X$72674 407 6081 375 407 6125 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72675 r0 *1 417.68,666.4
X$72675 407 6126 407 5917 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72676 r0 *1 421.36,666.4
X$72676 407 6119 407 6117 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72678 r0 *1 425.04,666.4
X$72678 407 5964 375 407 6115 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72684 r0 *1 434.7,666.4
X$72684 407 6113 375 407 6110 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72686 r0 *1 439.3,666.4
X$72686 375 5318 6032 5621 6034 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72687 r0 *1 448.5,666.4
X$72687 407 6106 407 5817 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72689 r0 *1 452.18,666.4
X$72689 375 6105 6032 6028 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72693 r0 *1 460.92,666.4
X$72693 375 4103 6097 5507 6099 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72696 r0 *1 471.5,666.4
X$72696 407 5962 375 407 6084 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72697 r0 *1 475.18,666.4
X$72697 407 5971 375 407 6091 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72701 r0 *1 480.24,666.4
X$72701 407 6084 407 375 5295 375 sky130_fd_sc_hd__inv_1
* cell instance $72705 r0 *1 484.84,666.4
X$72705 407 6085 375 407 6017 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72706 r0 *1 488.52,666.4
X$72706 407 6088 407 375 5883 375 sky130_fd_sc_hd__inv_1
* cell instance $72805 m0 *1 57.96,671.84
X$72805 407 6061 375 407 6086 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72842 m0 *1 143.98,671.84
X$72842 375 6179 6062 6157 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72847 m0 *1 152.26,671.84
X$72847 407 4685 6158 6181 375 407 375 sky130_fd_sc_hd__nand2b_1
* cell instance $72848 m0 *1 154.56,671.84
X$72848 407 6089 375 407 5666 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72849 m0 *1 158.24,671.84
X$72849 407 5877 375 407 6184 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72850 m0 *1 161.92,671.84
X$72850 375 6090 6000 6063 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72854 m0 *1 167.9,671.84
X$72854 407 6063 375 407 6192 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72856 m0 *1 172.04,671.84
X$72856 407 6332 375 407 5629 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72857 m0 *1 175.72,671.84
X$72857 375 4103 6065 5831 6095 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72862 m0 *1 187.22,671.84
X$72862 407 6102 375 407 5891 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72863 m0 *1 190.9,671.84
X$72863 407 6104 407 5897 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72867 m0 *1 196.42,671.84
X$72867 407 6101 375 407 6198 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72868 m0 *1 200.1,671.84
X$72868 407 6031 375 407 6204 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72869 m0 *1 203.78,671.84
X$72869 375 4103 6164 5831 6206 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72872 m0 *1 212.98,671.84
X$72872 375 5329 6068 5608 6210 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72874 m0 *1 222.64,671.84
X$72874 375 6004 6068 6114 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72876 m0 *1 230.46,671.84
X$72876 375 5329 6120 5608 6118 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72879 m0 *1 239.66,671.84
X$72879 375 5329 6069 5404 6123 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72884 m0 *1 251.62,671.84
X$72884 375 6221 6070 6338 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72890 m0 *1 258.98,671.84
X$72890 407 6129 375 407 6224 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72891 m0 *1 262.66,671.84
X$72891 407 5921 375 407 6226 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72893 m0 *1 267.26,671.84
X$72893 407 5673 375 407 6232 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72894 m0 *1 270.94,671.84
X$72894 407 6231 375 407 5272 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72899 m0 *1 278.3,671.84
X$72899 407 6342 375 407 5411 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72900 m0 *1 281.98,671.84
X$72900 407 6136 375 407 5389 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72901 m0 *1 285.66,671.84
X$72901 407 6138 407 6137 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72904 m0 *1 289.34,671.84
X$72904 407 4929 375 407 6245 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72905 m0 *1 293.02,671.84
X$72905 407 6006 375 407 6248 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72906 m0 *1 296.7,671.84
X$72906 407 6346 375 407 5937 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72908 m0 *1 301.3,671.84
X$72908 407 6057 375 407 6254 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72913 m0 *1 308.66,671.84
X$72913 407 6143 375 407 6149 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72914 m0 *1 312.34,671.84
X$72914 407 6147 375 407 5323 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72917 m0 *1 316.02,671.84
X$72917 407 5419 375 407 6300 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72919 m0 *1 323.38,671.84
X$72919 375 5653 6072 5531 6151 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72923 m0 *1 335.8,671.84
X$72923 375 5653 6252 5752 4884 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72930 m0 *1 351.9,671.84
X$72930 375 6055 6075 6054 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72931 m0 *1 356.04,671.84
X$72931 375 6156 6075 6249 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72933 m0 *1 360.64,671.84
X$72933 375 4103 6171 5752 6244 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72936 m0 *1 369.84,671.84
X$72936 375 6013 6171 6078 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72937 m0 *1 373.98,671.84
X$72937 407 6078 375 407 6314 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72939 m0 *1 378.58,671.84
X$72939 375 5318 6109 5549 6236 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72942 m0 *1 388.7,671.84
X$72942 375 6225 6112 6227 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72943 m0 *1 392.84,671.84
X$72943 407 6174 407 6135 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $72947 m0 *1 396.98,671.84
X$72947 375 5318 6080 5579 6222 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72949 m0 *1 406.64,671.84
X$72949 375 6219 6080 6207 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72950 m0 *1 410.78,671.84
X$72950 407 5963 375 407 6217 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72954 m0 *1 416.3,671.84
X$72954 375 6122 6082 6213 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72956 m0 *1 421.36,671.84
X$72956 375 5318 6016 5551 6038 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72960 m0 *1 431.48,671.84
X$72960 407 6207 375 407 6202 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72962 m0 *1 436.08,671.84
X$72962 375 6111 6112 6176 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72968 m0 *1 444.82,671.84
X$72968 375 6201 6109 6177 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72973 m0 *1 453.1,671.84
X$72973 375 4103 6178 5621 6195 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $72974 m0 *1 462.3,671.84
X$72974 375 6099 6178 6097 4618 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $72976 m0 *1 468.28,671.84
X$72976 407 6098 407 375 5443 375 sky130_fd_sc_hd__inv_1
* cell instance $72981 m0 *1 472.42,671.84
X$72981 407 6083 375 407 6096 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72984 m0 *1 476.1,671.84
X$72984 407 6096 407 375 5178 375 sky130_fd_sc_hd__inv_1
* cell instance $72985 m0 *1 477.48,671.84
X$72985 407 6093 407 375 5684 375 sky130_fd_sc_hd__inv_1
* cell instance $72986 m0 *1 478.86,671.84
X$72986 407 6092 375 407 6023 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72987 m0 *1 482.54,671.84
X$72987 407 6328 375 407 6088 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72988 m0 *1 486.22,671.84
X$72988 375 4103 6082 5507 6180 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73128 r0 *1 140.3,671.84
X$73128 375 494 6157 5688 6179 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73129 r0 *1 149.5,671.84
X$73129 407 6157 375 407 6182 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73132 r0 *1 153.64,671.84
X$73132 375 494 6158 5688 6181 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73136 r0 *1 166.06,671.84
X$73136 407 6189 407 6188 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73137 r0 *1 169.74,671.84
X$73137 407 5738 375 407 6191 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73138 r0 *1 173.42,671.84
X$73138 407 6159 375 407 6190 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73139 r0 *1 177.1,671.84
X$73139 407 6160 375 407 6193 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73144 r0 *1 184,671.84
X$73144 407 6158 375 407 6196 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73146 r0 *1 188.6,671.84
X$73146 407 6158 375 407 6197 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73148 r0 *1 193.2,671.84
X$73148 407 5980 375 407 6199 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73149 r0 *1 196.88,671.84
X$73149 407 6162 407 6101 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73150 r0 *1 200.56,671.84
X$73150 375 6200 6205 6198 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73152 r0 *1 204.7,671.84
X$73152 407 6209 375 407 5905 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73154 r0 *1 208.84,671.84
X$73154 375 6206 6205 6164 4685 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73157 r0 *1 215.28,671.84
X$73157 375 6210 6068 6212 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73158 r0 *1 219.42,671.84
X$73158 407 6211 407 6214 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73159 r0 *1 223.1,671.84
X$73159 407 6215 407 6216 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73161 r0 *1 228.62,671.84
X$73161 407 6164 375 407 6218 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73163 r0 *1 232.3,671.84
X$73163 407 6120 375 407 6165 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73165 r0 *1 236.44,671.84
X$73165 407 6166 375 407 6127 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73166 r0 *1 240.12,671.84
X$73166 407 6220 407 6166 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73167 r0 *1 243.8,671.84
X$73167 407 5251 375 407 6223 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73168 r0 *1 247.48,671.84
X$73168 375 5329 6070 5404 6221 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73173 r0 *1 259.9,671.84
X$73173 407 4924 375 407 6229 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73177 r0 *1 265.42,671.84
X$73177 407 6228 407 6231 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73178 r0 *1 269.1,671.84
X$73178 407 6234 407 6230 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73179 r0 *1 272.78,671.84
X$73179 407 5950 375 407 6241 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73180 r0 *1 276.46,671.84
X$73180 407 6239 407 6237 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73181 r0 *1 280.14,671.84
X$73181 407 6237 375 407 6242 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73182 r0 *1 283.82,671.84
X$73182 407 5074 375 407 6246 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73184 r0 *1 287.5,671.84
X$73184 407 6344 375 407 6243 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73188 r0 *1 294.4,671.84
X$73188 407 4888 375 407 6250 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73189 r0 *1 298.08,671.84
X$73189 407 6167 407 6143 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73190 r0 *1 301.76,671.84
X$73190 407 5812 375 407 6255 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73191 r0 *1 305.44,671.84
X$73191 407 6169 407 5849 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73194 r0 *1 311.42,671.84
X$73194 407 6170 375 407 6259 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73196 r0 *1 315.1,671.84
X$73196 407 6258 375 407 5530 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73201 r0 *1 322.46,671.84
X$73201 407 6072 375 407 6261 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73203 r0 *1 326.6,671.84
X$73203 407 5727 375 407 6260 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73204 r0 *1 330.28,671.84
X$73204 407 6056 375 407 6257 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73205 r0 *1 333.96,671.84
X$73205 407 5845 375 407 6256 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73206 r0 *1 337.64,671.84
X$73206 407 6252 375 407 6253 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73214 r0 *1 352.36,671.84
X$73214 407 6054 375 407 6251 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73216 r0 *1 356.5,671.84
X$73216 407 6340 375 407 6249 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73217 r0 *1 360.18,671.84
X$73217 407 6247 407 5842 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73221 r0 *1 367.08,671.84
X$73221 375 6244 6171 6240 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73226 r0 *1 374.44,671.84
X$73226 407 6238 375 407 6240 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73228 r0 *1 379.04,671.84
X$73228 375 6236 6109 6235 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73229 r0 *1 383.18,671.84
X$73229 407 6233 407 5868 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73231 r0 *1 387.78,671.84
X$73231 375 5318 6112 5549 6225 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73234 r0 *1 397.44,671.84
X$73234 375 6222 6080 6175 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73236 r0 *1 402.04,671.84
X$73236 407 6172 407 6047 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73237 r0 *1 405.72,671.84
X$73237 375 5318 6207 5579 6219 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73238 r0 *1 414.92,671.84
X$73238 375 5318 6213 5579 6122 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73240 r0 *1 424.12,671.84
X$73240 407 6016 375 407 6208 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73244 r0 *1 429.64,671.84
X$73244 407 6016 375 407 6203 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73247 r0 *1 434.7,671.84
X$73247 375 4103 6176 5621 6111 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73248 r0 *1 443.9,671.84
X$73248 375 4103 6177 5621 6201 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73250 r0 *1 453.1,671.84
X$73250 407 6177 375 407 6194 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73252 r0 *1 457.24,671.84
X$73252 375 6195 6178 6053 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73254 r0 *1 461.84,671.84
X$73254 407 6028 375 407 6186 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73256 r0 *1 466.44,671.84
X$73256 407 6187 375 407 6098 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73258 r0 *1 473.8,671.84
X$73258 407 6185 375 407 6093 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73266 r0 *1 485.3,671.84
X$73266 407 6183 375 407 6022 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73267 r0 *1 488.98,671.84
X$73267 375 6180 6082 6333 5043 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73311 r0 *1 597.54,671.84
X$73311 407 4215 375 407 6321 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73396 m0 *1 101.66,677.28
X$73396 407 6262 375 407 6330 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73417 m0 *1 144.44,677.28
X$73417 375 6087 6062 6331 4736 407 407 375 sky130_fd_sc_hd__mux2_2
* cell instance $73419 m0 *1 149.5,677.28
X$73419 407 6263 375 407 6331 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73425 m0 *1 155.94,677.28
X$73425 407 6264 375 407 5739 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73426 m0 *1 159.62,677.28
X$73426 407 6021 375 407 5800 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73427 m0 *1 163.3,677.28
X$73427 407 6188 375 407 6064 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73431 m0 *1 169.74,677.28
X$73431 407 6266 407 6332 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73432 m0 *1 173.42,677.28
X$73432 407 6158 375 407 6267 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73433 m0 *1 177.1,677.28
X$73433 407 6163 407 6263 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73439 m0 *1 183.54,677.28
X$73439 407 6158 375 407 6268 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73440 m0 *1 187.22,677.28
X$73440 407 6271 407 6159 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73441 m0 *1 190.9,677.28
X$73441 407 6269 407 6102 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73444 m0 *1 195.5,677.28
X$73444 375 4103 6205 5831 6200 407 407 375 sky130_fd_sc_hd__dfrtp_1
* cell instance $73447 m0 *1 204.7,677.28
X$73447 407 6270 407 6100 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73451 m0 *1 211.14,677.28
X$73451 407 6272 407 6033 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73452 m0 *1 214.82,677.28
X$73452 407 6278 407 6209 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73453 m0 *1 218.5,677.28
X$73453 407 6216 375 407 6212 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73457 m0 *1 224.02,677.28
X$73457 407 6114 375 407 6277 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73459 m0 *1 228.62,677.28
X$73459 407 6039 375 407 6280 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73462 m0 *1 232.3,677.28
X$73462 407 6279 375 407 6124 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73466 m0 *1 238.74,677.28
X$73466 407 5989 375 407 6338 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73467 m0 *1 242.42,677.28
X$73467 407 6282 407 6279 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73468 m0 *1 246.1,677.28
X$73468 407 6281 375 407 5084 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73472 m0 *1 252.54,677.28
X$73472 407 6284 407 6281 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73473 m0 *1 256.22,677.28
X$73473 407 6286 407 6339 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73476 m0 *1 259.9,677.28
X$73476 407 6339 375 407 5194 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73480 m0 *1 266.34,677.28
X$73480 407 6230 375 407 5675 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73481 m0 *1 270.02,677.28
X$73481 407 6289 375 407 6343 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73482 m0 *1 273.7,677.28
X$73482 407 6291 407 6342 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73486 m0 *1 280.14,677.28
X$73486 407 6290 375 407 5090 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73487 m0 *1 283.82,677.28
X$73487 407 6005 375 407 6292 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73490 m0 *1 287.5,677.28
X$73490 407 6293 407 6344 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73494 m0 *1 293.94,677.28
X$73494 407 6294 407 6346 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73495 m0 *1 297.62,677.28
X$73495 407 6295 407 6170 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73496 m0 *1 301.3,677.28
X$73496 407 6296 407 6146 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73501 m0 *1 308.66,677.28
X$73501 407 6297 407 6345 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73506 m0 *1 315.1,677.28
X$73506 407 6298 375 407 5661 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73508 m0 *1 319.24,677.28
X$73508 407 5615 375 407 6299 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73509 m0 *1 322.92,677.28
X$73509 407 6301 375 407 6152 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73515 m0 *1 333.96,677.28
X$73515 407 5844 375 407 6302 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73526 m0 *1 352.82,677.28
X$73526 407 6341 375 407 5992 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73527 m0 *1 356.5,677.28
X$73527 407 6304 407 6341 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73529 m0 *1 360.64,677.28
X$73529 407 6305 407 6340 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73530 m0 *1 364.32,677.28
X$73530 407 6012 375 407 6308 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73533 m0 *1 368,677.28
X$73533 407 6307 407 6337 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73537 m0 *1 374.44,677.28
X$73537 407 6337 375 407 6077 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73538 m0 *1 378.12,677.28
X$73538 407 6310 407 6238 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73539 m0 *1 381.8,677.28
X$73539 407 6311 407 6336 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73543 m0 *1 388.24,677.28
X$73543 407 6336 375 407 6235 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73544 m0 *1 391.92,677.28
X$73544 407 6315 407 6079 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73547 m0 *1 395.6,677.28
X$73547 407 6312 407 6014 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73551 m0 *1 402.04,677.28
X$73551 407 6316 407 6335 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73552 m0 *1 405.72,677.28
X$73552 407 6335 375 407 6175 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73553 m0 *1 409.4,677.28
X$73553 407 6317 407 6128 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73557 m0 *1 415.84,677.28
X$73557 407 6309 407 6113 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73558 m0 *1 419.52,677.28
X$73558 407 6213 375 407 6306 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73561 m0 *1 423.2,677.28
X$73561 407 6318 407 6081 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73565 m0 *1 429.64,677.28
X$73565 407 6016 375 407 6319 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73566 m0 *1 433.32,677.28
X$73566 407 6016 375 407 6320 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73576 m0 *1 449.42,677.28
X$73576 407 6176 375 407 6322 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73583 m0 *1 466.9,677.28
X$73583 407 6097 375 407 6324 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73585 m0 *1 471.04,677.28
X$73585 407 6323 375 407 6327 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73586 m0 *1 474.72,677.28
X$73586 407 6326 375 407 4950 375 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $73589 m0 *1 478.4,677.28
X$73589 407 6327 407 375 5359 375 sky130_fd_sc_hd__inv_1
* cell instance $73595 m0 *1 486.22,677.28
X$73595 407 6329 407 6334 375 375 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $73596 m0 *1 489.9,677.28
X$73596 407 6334 375 407 6333 375 sky130_fd_sc_hd__clkdlybuf4s50_1
.ENDS dma_controller

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__or4b_4
* pin VGND
* pin X
* pin D_N
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4b_4 1 4 5 6 7 8 9 10 14
* net 1 VGND
* net 4 X
* net 5 D_N
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 11 2 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.94,1.985 pfet_01v8_hvt
M$2 13 6 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 2.36,1.985 pfet_01v8_hvt
M$3 12 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 2.78,1.985 pfet_01v8_hvt
M$4 9 8 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 3.31,1.985 pfet_01v8_hvt
M$5 4 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=665000000000P PS=5190000U PD=6330000U
* device instance $9 r0 *1 0.47,2.275 pfet_01v8_hvt
M$9 2 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $10 r0 *1 1.41,0.56 nfet_01v8
M$10 3 2 1 14 nfet_01v8 L=150000U W=650000U AS=165350000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $11 r0 *1 1.94,0.56 nfet_01v8
M$11 1 6 3 14 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $12 r0 *1 2.36,0.56 nfet_01v8
M$12 3 7 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $13 r0 *1 2.78,0.56 nfet_01v8
M$13 1 8 3 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $14 r0 *1 3.31,0.56 nfet_01v8
M$14 4 3 1 14 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
* device instance $18 r0 *1 0.47,0.675 nfet_01v8
M$18 2 5 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or4b_4

* cell sky130_fd_sc_hd__a2bb2oi_1
* pin VGND
* pin Y
* pin B2
* pin A1_N
* pin A2_N
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 1 3 4 5 6 7 10 11 13
* net 1 VGND
* net 3 Y
* net 4 B2
* net 5 A1_N
* net 6 A2_N
* net 7 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.91,1.985 pfet_01v8_hvt
M$1 9 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=135000000000P PS=2680000U PD=1270000U
* device instance $2 r0 *1 2.33,1.985 pfet_01v8_hvt
M$2 10 4 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 12 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $5 r0 *1 0.83,1.985 pfet_01v8_hvt
M$5 2 6 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 5 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 1 6 2 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=282750000000P
+ PS=920000U PD=1520000U
* device instance $8 r0 *1 1.91,0.56 nfet_01v8
M$8 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=282750000000P AD=87750000000P
+ PS=1520000U PD=920000U
* device instance $9 r0 *1 2.33,0.56 nfet_01v8
M$9 8 4 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 1 7 8 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__a2bb2oi_1

* cell sky130_fd_sc_hd__nor2_4
* pin VGND
* pin B
* pin Y
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor2_4 1 2 3 4 6 7 8
* net 1 VGND
* net 2 B
* net 3 Y
* net 4 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 4 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 3 2 5 7 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=675000000000P PS=5080000U PD=6350000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 4 1 8 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $13 r0 *1 2.17,0.56 nfet_01v8
M$13 3 2 1 8 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor2_4

* cell sky130_fd_sc_hd__or4b_1
* pin VGND
* pin D_N
* pin X
* pin C
* pin A
* pin VPWR
* pin VPB
* pin B
* pin
.SUBCKT sky130_fd_sc_hd__or4b_1 1 2 5 6 7 8 9 10 14
* net 1 VGND
* net 2 D_N
* net 5 X
* net 6 C
* net 7 A
* net 8 VPWR
* net 9 VPB
* net 10 B
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 3 4 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=68250000000P
+ PS=1360000U PD=745000U
* device instance $2 r0 *1 1.885,1.695 pfet_01v8_hvt
M$2 13 6 11 9 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=45150000000P
+ PS=745000U PD=635000U
* device instance $3 r0 *1 2.25,1.695 pfet_01v8_hvt
M$3 12 10 13 9 pfet_01v8_hvt L=150000U W=420000U AS=45150000000P
+ AD=64050000000P PS=635000U PD=725000U
* device instance $4 r0 *1 2.705,1.695 pfet_01v8_hvt
M$4 8 7 12 9 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P AD=148250000000P
+ PS=725000U PD=1340000U
* device instance $5 r0 *1 3.195,1.985 pfet_01v8_hvt
M$5 5 4 8 9 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $6 r0 *1 0.47,1.695 pfet_01v8_hvt
M$6 3 2 8 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $7 r0 *1 1.41,0.475 nfet_01v8
M$7 4 3 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=64050000000P
+ PS=1360000U PD=725000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 1 6 4 14 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=56700000000P
+ PS=725000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 4 10 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 4 7 1 14 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 3.195,0.56 nfet_01v8
M$11 5 4 1 14 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=178750000000P
+ PS=990000U PD=1850000U
* device instance $12 r0 *1 0.47,0.475 nfet_01v8
M$12 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or4b_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__and4bb_2
* pin VGND
* pin X
* pin C
* pin D
* pin B_N
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4bb_2 1 3 5 6 7 11 13 14 15
* net 1 VGND
* net 3 X
* net 5 C
* net 6 D
* net 7 B_N
* net 11 A_N
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 11 13 14 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 3 4 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=275750000000P
+ AD=465750000000P PS=2595000U PD=2975000U
* device instance $4 r0 *1 2.22,2.275 pfet_01v8_hvt
M$4 4 2 13 14 pfet_01v8_hvt L=150000U W=420000U AS=330750000000P
+ AD=67200000000P PS=1705000U PD=740000U
* device instance $5 r0 *1 2.69,2.275 pfet_01v8_hvt
M$5 13 12 4 14 pfet_01v8_hvt L=150000U W=420000U AS=67200000000P
+ AD=58800000000P PS=740000U PD=700000U
* device instance $6 r0 *1 3.12,2.275 pfet_01v8_hvt
M$6 4 5 13 14 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $7 r0 *1 3.54,2.275 pfet_01v8_hvt
M$7 13 6 4 14 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=92400000000P
+ PS=690000U PD=860000U
* device instance $8 r0 *1 4.13,2.275 pfet_01v8_hvt
M$8 12 7 13 14 pfet_01v8_hvt L=150000U W=420000U AS=92400000000P
+ AD=109200000000P PS=860000U PD=1360000U
* device instance $9 r0 *1 2.305,0.445 nfet_01v8
M$9 10 2 4 15 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $10 r0 *1 2.665,0.445 nfet_01v8
M$10 9 12 10 15 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=64050000000P
+ PS=630000U PD=725000U
* device instance $11 r0 *1 3.12,0.445 nfet_01v8
M$11 8 5 9 15 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=56700000000P
+ PS=725000U PD=690000U
* device instance $12 r0 *1 3.54,0.445 nfet_01v8
M$12 1 6 8 15 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=92400000000P
+ PS=690000U PD=860000U
* device instance $13 r0 *1 4.13,0.445 nfet_01v8
M$13 12 7 1 15 nfet_01v8 L=150000U W=420000U AS=92400000000P AD=109200000000P
+ PS=860000U PD=1360000U
* device instance $14 r0 *1 0.47,0.445 nfet_01v8
M$14 1 11 2 15 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $15 r0 *1 0.945,0.56 nfet_01v8
M$15 3 4 1 15 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=256750000000P
+ PS=1895000U PD=2740000U
.ENDS sky130_fd_sc_hd__and4bb_2

* cell sky130_fd_sc_hd__nand4bb_4
* pin VGND
* pin D
* pin A_N
* pin B_N
* pin Y
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4bb_4 1 2 3 5 8 10 12 13 14
* net 1 VGND
* net 2 D
* net 3 A_N
* net 5 B_N
* net 8 Y
* net 10 C
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 2.495,1.985 pfet_01v8_hvt
M$1 8 4 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 4.175,1.985 pfet_01v8_hvt
M$5 8 6 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=960000000000P PS=5080000U PD=5920000U
* device instance $9 r0 *1 6.695,1.985 pfet_01v8_hvt
M$9 8 10 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=960000000000P
+ AD=540000000000P PS=5920000U PD=5080000U
* device instance $13 r0 *1 8.375,1.985 pfet_01v8_hvt
M$13 8 2 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=680000000000P PS=5080000U PD=6360000U
* device instance $17 r0 *1 0.47,1.985 pfet_01v8_hvt
M$17 12 3 4 13 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $18 r0 *1 0.89,1.985 pfet_01v8_hvt
M$18 6 5 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=495000000000P PS=1270000U PD=2990000U
* device instance $19 r0 *1 6.695,0.56 nfet_01v8
M$19 9 10 11 14 nfet_01v8 L=150000U W=2600000U AS=451750000000P
+ AD=351000000000P PS=4640000U PD=3680000U
* device instance $23 r0 *1 8.375,0.56 nfet_01v8
M$23 1 2 11 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=442000000000P
+ PS=3680000U PD=4610000U
* device instance $27 r0 *1 0.47,0.56 nfet_01v8
M$27 1 3 4 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $28 r0 *1 0.89,0.56 nfet_01v8
M$28 6 5 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=321750000000P
+ PS=920000U PD=2290000U
* device instance $29 r0 *1 2.495,0.56 nfet_01v8
M$29 8 4 7 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $33 r0 *1 4.175,0.56 nfet_01v8
M$33 9 6 7 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4bb_4

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__buf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 2 3 6 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.08e+12P AD=1.205e+12P
+ PS=10160000U PD=11410000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 2 3 7 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $15 r0 *1 1.73,0.56 nfet_01v8
M$15 4 3 1 7 nfet_01v8 L=150000U W=5200000U AS=702000000000P AD=783250000000P
+ PS=7360000U PD=8260000U
.ENDS sky130_fd_sc_hd__buf_8

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__clkinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_16 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=24000000U AS=3.59e+12P AD=3.58e+12P
+ PS=32180000U PD=32160000U
* device instance $25 r0 *1 2.205,0.445 nfet_01v8
M$25 3 2 1 6 nfet_01v8 L=150000U W=6720000U AS=1.0332e+12P AD=1.0332e+12P
+ PS=12060000U PD=12060000U
.ENDS sky130_fd_sc_hd__clkinv_16

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__clkinv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_8 1 3 4 5 6
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 4 5 pfet_01v8_hvt L=150000U W=12000000U AS=1.7475e+12P AD=1.7475e+12P
+ PS=16495000U PD=16495000U
* device instance $13 r0 *1 1.415,0.445 nfet_01v8
M$13 2 3 1 6 nfet_01v8 L=150000U W=3360000U AS=522900000000P AD=522900000000P
+ PS=6270000U PD=6270000U
.ENDS sky130_fd_sc_hd__clkinv_8

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 0.89,0.56 nfet_01v8
M$8 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $9 r0 *1 1.85,0.56 nfet_01v8
M$9 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 2.27,0.56 nfet_01v8
M$10 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__nor3_4
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_4 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 7 2 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $8 r0 *1 3.43,1.985 pfet_01v8_hvt
M$8 3 5 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 3 2 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $17 r0 *1 2.17,0.56 nfet_01v8
M$17 3 4 1 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $20 r0 *1 3.43,0.56 nfet_01v8
M$20 1 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__nor3_4

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__nor4_4
* pin VGND
* pin C
* pin Y
* pin A
* pin B
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_4 1 2 3 4 6 7 8 11 12
* net 1 VGND
* net 2 C
* net 3 Y
* net 4 A
* net 6 B
* net 7 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.37,1.985 pfet_01v8_hvt
M$1 9 2 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.05,1.985 pfet_01v8_hvt
M$5 3 7 10 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 8 4 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 5 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 3 4 1 12 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 3 6 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $25 r0 *1 4.37,0.56 nfet_01v8
M$25 3 2 1 12 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $29 r0 *1 6.05,0.56 nfet_01v8
M$29 3 7 1 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4_4

* cell sky130_fd_sc_hd__o311ai_0
* pin VGND
* pin A1
* pin Y
* pin C1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_0 1 2 4 5 7 8 9 10 11 14
* net 1 VGND
* net 2 A1
* net 4 Y
* net 5 C1
* net 7 A2
* net 8 A3
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,2.165 pfet_01v8_hvt
M$1 12 2 10 11 pfet_01v8_hvt L=150000U W=640000U AS=179200000000P
+ AD=86400000000P PS=1840000U PD=910000U
* device instance $2 r0 *1 1.035,2.165 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=86400000000P PS=910000U PD=910000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 4 8 13 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=144000000000P PS=910000U PD=1090000U
* device instance $4 r0 *1 2.055,2.165 pfet_01v8_hvt
M$4 10 9 4 11 pfet_01v8_hvt L=150000U W=640000U AS=144000000000P
+ AD=118400000000P PS=1090000U PD=1010000U
* device instance $5 r0 *1 2.575,2.165 pfet_01v8_hvt
M$5 4 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=118400000000P
+ AD=198400000000P PS=1010000U PD=1900000U
* device instance $6 r0 *1 0.615,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $7 r0 *1 1.035,0.445 nfet_01v8
M$7 1 7 3 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 1.455,0.445 nfet_01v8
M$8 3 8 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=128100000000P
+ PS=690000U PD=1030000U
* device instance $9 r0 *1 2.215,0.445 nfet_01v8
M$9 6 9 3 14 nfet_01v8 L=150000U W=420000U AS=128100000000P AD=44100000000P
+ PS=1030000U PD=630000U
* device instance $10 r0 *1 2.575,0.445 nfet_01v8
M$10 4 5 6 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=117600000000P
+ PS=630000U PD=1400000U
.ENDS sky130_fd_sc_hd__o311ai_0

* cell sky130_fd_sc_hd__a31o_2
* pin VPB
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a31o_2 1 2 3 4 5 6 7 8 11
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 10 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 7 4 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $5 r0 *1 2.21,1.985 pfet_01v8_hvt
M$5 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $6 r0 *1 2.69,1.985 pfet_01v8_hvt
M$6 10 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 6 10 8 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $9 r0 *1 1.31,0.56 nfet_01v8
M$9 13 5 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 1.73,0.56 nfet_01v8
M$10 12 4 13 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $11 r0 *1 2.21,0.56 nfet_01v8
M$11 10 3 12 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $12 r0 *1 2.75,0.56 nfet_01v8
M$12 8 2 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=169000000000P
+ PS=1040000U PD=1820000U
.ENDS sky130_fd_sc_hd__a31o_2

* cell sky130_fd_sc_hd__a311o_1
* pin VPB
* pin C1
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a311o_1 1 2 3 4 5 6 7 8 10 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 X
* net 8 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 11 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=142500000000P PS=2570000U PD=1285000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 9 6 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=142500000000P
+ AD=165000000000P PS=1285000U PD=1330000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 10 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=305000000000P PS=1330000U PD=1610000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 9 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=162500000000P PS=1610000U PD=1325000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 13 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=207500000000P PS=1325000U PD=1415000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 11 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=207500000000P
+ AD=260000000000P PS=1415000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 8 11 7 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112125000000P
+ PS=1820000U PD=995000U
* device instance $8 r0 *1 0.965,0.56 nfet_01v8
M$8 15 6 8 12 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=125125000000P
+ PS=995000U PD=1035000U
* device instance $9 r0 *1 1.5,0.56 nfet_01v8
M$9 14 5 15 12 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=169000000000P
+ PS=1035000U PD=1170000U
* device instance $10 r0 *1 2.17,0.56 nfet_01v8
M$10 11 4 14 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1170000U PD=975000U
* device instance $11 r0 *1 2.645,0.56 nfet_01v8
M$11 8 3 11 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=134875000000P
+ PS=975000U PD=1065000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 11 2 8 12 nfet_01v8 L=150000U W=650000U AS=134875000000P AD=169000000000P
+ PS=1065000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311o_1

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__or2_2
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or2_2 1 2 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 4 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.53,1.695 pfet_01v8_hvt
M$1 9 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.89,1.695 pfet_01v8_hvt
M$2 6 2 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=155750000000P
+ PS=630000U PD=1355000U
* device instance $3 r0 *1 1.395,1.985 pfet_01v8_hvt
M$3 5 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=290750000000P
+ AD=395000000000P PS=2625000U PD=3790000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 3 4 7 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.89,0.445 nfet_01v8
M$6 7 2 3 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=106750000000P
+ PS=690000U PD=1005000U
* device instance $7 r0 *1 1.395,0.56 nfet_01v8
M$7 5 3 7 8 nfet_01v8 L=150000U W=1300000U AS=194500000000P AD=256750000000P
+ PS=1925000U PD=2740000U
.ENDS sky130_fd_sc_hd__or2_2

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__nand4bb_2
* pin VGND
* pin Y
* pin C
* pin D
* pin B_N
* pin A_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4bb_2 1 5 8 9 10 11 12 13 14
* net 1 VGND
* net 5 Y
* net 8 C
* net 9 D
* net 10 B_N
* net 11 A_N
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 2.04,1.985 pfet_01v8_hvt
M$1 5 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 2.88,1.985 pfet_01v8_hvt
M$3 5 2 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=530000000000P PS=2540000U PD=3060000U
* device instance $5 r0 *1 4.24,1.985 pfet_01v8_hvt
M$5 5 8 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=530000000000P
+ AD=270000000000P PS=3060000U PD=2540000U
* device instance $7 r0 *1 5.08,1.985 pfet_01v8_hvt
M$7 5 9 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 0.47,2.275 pfet_01v8_hvt
M$9 12 10 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $10 r0 *1 0.89,2.275 pfet_01v8_hvt
M$10 3 11 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=197400000000P PS=690000U PD=1780000U
* device instance $11 r0 *1 4.24,0.56 nfet_01v8
M$11 6 8 7 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $13 r0 *1 5.08,0.56 nfet_01v8
M$13 1 9 7 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $15 r0 *1 2.04,0.56 nfet_01v8
M$15 5 3 4 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $17 r0 *1 2.88,0.56 nfet_01v8
M$17 6 2 4 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $19 r0 *1 0.47,0.445 nfet_01v8
M$19 1 10 2 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $20 r0 *1 0.89,0.445 nfet_01v8
M$20 3 11 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=197400000000P
+ PS=690000U PD=1780000U
.ENDS sky130_fd_sc_hd__nand4bb_2

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__inv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_16 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.535,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=16000000U AS=2.285e+12P AD=2.285e+12P
+ PS=21570000U PD=21570000U
* device instance $17 r0 *1 0.535,0.56 nfet_01v8
M$17 3 2 1 6 nfet_01v8 L=150000U W=10400000U AS=1.48525e+12P AD=1.48525e+12P
+ PS=15620000U PD=15620000U
.ENDS sky130_fd_sc_hd__inv_16

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__a221o_1
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_1 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $6 r0 *1 1.31,1.985 pfet_01v8_hvt
M$6 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $7 r0 *1 2.25,0.56 nfet_01v8
M$7 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $8 r0 *1 2.73,0.56 nfet_01v8
M$8 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $9 r0 *1 3.195,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $11 r0 *1 0.95,0.56 nfet_01v8
M$11 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 1.31,0.56 nfet_01v8
M$12 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__o221ai_1
* pin VPB
* pin C1
* pin B1
* pin A2
* pin A1
* pin B2
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o221ai_1 1 2 3 4 5 6 8 10 11 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 B2
* net 8 Y
* net 10 VPWR
* net 11 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=380000000000P PS=2560000U PD=1760000U
* device instance $2 r0 *1 1.4,1.985 pfet_01v8_hvt
M$2 14 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=380000000000P
+ AD=120000000000P PS=1760000U PD=1240000U
* device instance $3 r0 *1 1.79,1.985 pfet_01v8_hvt
M$3 8 6 14 1 pfet_01v8_hvt L=150000U W=1000000U AS=120000000000P
+ AD=225000000000P PS=1240000U PD=1450000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 13 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=105000000000P PS=1450000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.4,0.56 nfet_01v8
M$6 9 3 7 12 nfet_01v8 L=150000U W=650000U AS=165200000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.82,0.56 nfet_01v8
M$7 7 6 9 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=117000000000P
+ PS=920000U PD=1010000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 11 4 7 12 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=87750000000P
+ PS=1010000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 5 11 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 9 2 8 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=165400000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221ai_1

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__a2111oi_0
* pin VGND
* pin D1
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a2111oi_0 1 2 3 4 6 7 8 9 10 14
* net 1 VGND
* net 2 D1
* net 3 Y
* net 4 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPB
* net 10 VPWR
* device instance $1 r0 *1 0.77,2.165 pfet_01v8_hvt
M$1 12 2 3 9 pfet_01v8_hvt L=150000U W=640000U AS=188800000000P AD=67200000000P
+ PS=1870000U PD=850000U
* device instance $2 r0 *1 1.13,2.165 pfet_01v8_hvt
M$2 13 6 12 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=67200000000P
+ PS=850000U PD=850000U
* device instance $3 r0 *1 1.49,2.165 pfet_01v8_hvt
M$3 11 7 13 9 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P AD=89600000000P
+ PS=850000U PD=920000U
* device instance $4 r0 *1 1.92,2.165 pfet_01v8_hvt
M$4 10 4 11 9 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P
+ AD=121600000000P PS=920000U PD=1020000U
* device instance $5 r0 *1 2.45,2.165 pfet_01v8_hvt
M$5 11 8 10 9 pfet_01v8_hvt L=150000U W=640000U AS=121600000000P
+ AD=195200000000P PS=1020000U PD=1890000U
* device instance $6 r0 *1 0.7,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=126000000000P AD=58800000000P
+ PS=1440000U PD=700000U
* device instance $7 r0 *1 1.13,0.445 nfet_01v8
M$7 1 6 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=73500000000P
+ PS=700000U PD=770000U
* device instance $8 r0 *1 1.63,0.445 nfet_01v8
M$8 3 7 1 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=58800000000P
+ PS=770000U PD=700000U
* device instance $9 r0 *1 2.06,0.445 nfet_01v8
M$9 5 4 3 14 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=44100000000P
+ PS=700000U PD=630000U
* device instance $10 r0 *1 2.42,0.445 nfet_01v8
M$10 1 8 5 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=119700000000P
+ PS=630000U PD=1410000U
.ENDS sky130_fd_sc_hd__a2111oi_0

* cell sky130_fd_sc_hd__nor2_2
* pin VGND
* pin
* pin Y
* pin VPB
* pin A
* pin B
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nor2_2 1 2 3 4 5 6 8
* net 1 VGND
* net 3 Y
* net 4 VPB
* net 5 A
* net 6 B
* net 8 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 8 5 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 1.33,1.985 pfet_01v8_hvt
M$3 3 6 7 4 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,0.56 nfet_01v8
M$5 3 5 1 2 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $7 r0 *1 1.33,0.56 nfet_01v8
M$7 3 6 1 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor2_2

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 4.35,0.56 nfet_01v8
M$13 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.15,0.56 nfet_01v8
M$21 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__and3_2
* pin VPB
* pin A
* pin B
* pin C
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and3_2 1 2 3 4 6 7 8 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.375,1.695 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=150750000000P
+ PS=815000U PD=1345000U
* device instance $2 r0 *1 0.48,1.765 pfet_01v8_hvt
M$2 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 0.9,1.765 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 1.87,1.985 pfet_01v8_hvt
M$4 8 5 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=285750000000P
+ AD=395000000000P PS=2615000U PD=3790000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 11 2 5 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 0.845,0.475 nfet_01v8
M$7 10 3 11 9 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 1.25,0.475 nfet_01v8
M$8 10 4 6 9 nfet_01v8 L=150000U W=420000U AS=130400000000P AD=53550000000P
+ PS=1105000U PD=675000U
* device instance $9 r0 *1 1.855,0.56 nfet_01v8
M$9 8 5 6 9 nfet_01v8 L=150000U W=1300000U AS=218150000000P AD=266500000000P
+ PS=2025000U PD=2770000U
.ENDS sky130_fd_sc_hd__and3_2

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__o2111ai_1
* pin VPB
* pin D1
* pin C1
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 D1
* net 3 C1
* net 4 B1
* net 5 A2
* net 6 A1
* net 8 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.1,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=195000000000P PS=1280000U PD=1390000U
* device instance $3 r0 *1 1.64,1.985 pfet_01v8_hvt
M$3 9 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=202500000000P PS=1390000U PD=1405000U
* device instance $4 r0 *1 2.195,1.985 pfet_01v8_hvt
M$4 12 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=202500000000P
+ AD=195000000000P PS=1405000U PD=1390000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 8 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=265000000000P PS=1390000U PD=2530000U
* device instance $6 r0 *1 0.74,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=68250000000P
+ PS=1830000U PD=860000U
* device instance $7 r0 *1 1.1,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=126750000000P
+ PS=860000U PD=1040000U
* device instance $8 r0 *1 1.64,0.56 nfet_01v8
M$8 7 4 13 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=131625000000P
+ PS=1040000U PD=1055000U
* device instance $9 r0 *1 2.195,0.56 nfet_01v8
M$9 10 5 7 11 nfet_01v8 L=150000U W=650000U AS=131625000000P AD=126750000000P
+ PS=1055000U PD=1040000U
* device instance $10 r0 *1 2.735,0.56 nfet_01v8
M$10 7 6 10 11 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=172250000000P
+ PS=1040000U PD=1830000U
.ENDS sky130_fd_sc_hd__o2111ai_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__nor4bb_4
* pin VGND
* pin Y
* pin C_N
* pin D_N
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4bb_4 1 4 5 6 7 9 10 13 14
* net 1 VGND
* net 4 Y
* net 5 C_N
* net 6 D_N
* net 7 B
* net 9 A
* net 10 VPWR
* net 13 VPB
* device instance $1 r0 *1 5.77,1.985 pfet_01v8_hvt
M$1 12 7 8 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 7.45,1.985 pfet_01v8_hvt
M$5 10 9 8 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 10 5 2 13 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=135000000000P PS=2560000U PD=1270000U
* device instance $10 r0 *1 0.91,1.985 pfet_01v8_hvt
M$10 3 6 10 13 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $11 r0 *1 1.89,1.985 pfet_01v8_hvt
M$11 4 3 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $15 r0 *1 3.57,1.985 pfet_01v8_hvt
M$15 12 2 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $19 r0 *1 0.49,0.56 nfet_01v8
M$19 1 5 2 14 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=87750000000P
+ PS=1850000U PD=920000U
* device instance $20 r0 *1 0.91,0.56 nfet_01v8
M$20 3 6 1 14 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $21 r0 *1 1.89,0.56 nfet_01v8
M$21 4 3 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 3.57,0.56 nfet_01v8
M$25 4 2 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $29 r0 *1 5.77,0.56 nfet_01v8
M$29 4 7 1 14 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $33 r0 *1 7.45,0.56 nfet_01v8
M$33 4 9 1 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=445250000000P
+ PS=3680000U PD=4620000U
.ENDS sky130_fd_sc_hd__nor4bb_4

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__buf_12
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_12 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 4 3 5 6 pfet_01v8_hvt L=150000U W=12000000U AS=1.62e+12P AD=1.865e+12P
+ PS=15240000U PD=16730000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 7 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.15,0.56 nfet_01v8
M$21 4 3 1 7 nfet_01v8 L=150000U W=7800000U AS=1.053e+12P AD=1.21225e+12P
+ PS=11040000U PD=12180000U
.ENDS sky130_fd_sc_hd__buf_12

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__o221a_2
* pin VGND
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o221a_2 1 2 5 7 8 9 10 11 12 15
* net 1 VGND
* net 2 C1
* net 5 B1
* net 7 B2
* net 8 A2
* net 9 A1
* net 10 X
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 0.63,1.985 pfet_01v8_hvt
M$1 12 2 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=325000000000P
+ AD=165000000000P PS=2650000U PD=1330000U
* device instance $2 r0 *1 1.11,1.985 pfet_01v8_hvt
M$2 13 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=112500000000P PS=1330000U PD=1225000U
* device instance $3 r0 *1 1.485,1.985 pfet_01v8_hvt
M$3 3 7 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=387500000000P PS=1225000U PD=1775000U
* device instance $4 r0 *1 2.41,1.985 pfet_01v8_hvt
M$4 14 8 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=387500000000P
+ AD=105000000000P PS=1775000U PD=1210000U
* device instance $5 r0 *1 2.77,1.985 pfet_01v8_hvt
M$5 12 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.25,1.985 pfet_01v8_hvt
M$6 10 3 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=395000000000P PS=2600000U PD=3790000U
* device instance $8 r0 *1 2.41,0.56 nfet_01v8
M$8 6 8 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $9 r0 *1 2.83,0.56 nfet_01v8
M$9 1 9 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $10 r0 *1 3.25,0.56 nfet_01v8
M$10 10 3 1 15 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $12 r0 *1 0.63,0.56 nfet_01v8
M$12 4 2 3 15 nfet_01v8 L=150000U W=650000U AS=237250000000P AD=87750000000P
+ PS=2030000U PD=920000U
* device instance $13 r0 *1 1.05,0.56 nfet_01v8
M$13 6 5 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $14 r0 *1 1.47,0.56 nfet_01v8
M$14 4 7 6 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_2

* cell sky130_fd_sc_hd__nor3_2
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_2 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=395000000000P PS=3790000U PD=3790000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 7 2 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 3 5 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 3 2 1 10 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 3 4 1 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3_2

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__clkdlybuf4s50_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 2.465,2.075 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=500000U W=820000U AS=155750000000P AD=217300000000P
+ PS=1325000U PD=2170000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=155750000000P
+ AD=355000000000P PS=1325000U PD=2710000U
* device instance $3 r0 *1 0.48,1.985 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=170100000000P PS=2540000U PD=1360000U
* device instance $4 r0 *1 1.165,2.075 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=500000U W=820000U AS=170100000000P AD=217300000000P
+ PS=1360000U PD=2170000U
* device instance $5 r0 *1 3.115,0.445 nfet_01v8
M$5 8 6 4 9 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=149100000000P
+ PS=975000U PD=1550000U
* device instance $6 r0 *1 2.465,0.56 nfet_01v8
M$6 4 5 6 9 nfet_01v8 L=500000U W=650000U AS=172250000000P AD=97000000000P
+ PS=1830000U PD=975000U
* device instance $7 r0 *1 0.48,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=113400000000P AD=104350000000P
+ PS=1380000U PD=1010000U
* device instance $8 r0 *1 1.165,0.56 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=500000U W=650000U AS=104350000000P AD=169000000000P
+ PS=1010000U PD=1820000U
.ENDS sky130_fd_sc_hd__clkdlybuf4s50_1

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 2.64,0.415 nfet_01v8
M$16 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $17 r0 *1 3.12,0.415 nfet_01v8
M$17 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $18 r0 *1 5.465,0.415 nfet_01v8
M$18 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $19 r0 *1 6.01,0.415 nfet_01v8
M$19 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $20 r0 *1 2.165,0.445 nfet_01v8
M$20 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $21 r0 *1 3.95,0.445 nfet_01v8
M$21 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $22 r0 *1 4.31,0.445 nfet_01v8
M$22 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $23 r0 *1 6.49,0.445 nfet_01v8
M$23 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $24 r0 *1 7.235,0.445 nfet_01v8
M$24 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $25 r0 *1 7.69,0.445 nfet_01v8
M$25 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $26 r0 *1 4.97,0.555 nfet_01v8
M$26 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
* device instance $27 r0 *1 0.47,0.445 nfet_01v8
M$27 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $28 r0 *1 0.89,0.445 nfet_01v8
M$28 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 0.47,0.56 nfet_01v8
M$11 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $12 r0 *1 1.41,0.445 nfet_01v8
M$12 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $13 r0 *1 1.83,0.445 nfet_01v8
M$13 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $14 r0 *1 2.25,0.445 nfet_01v8
M$14 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1
