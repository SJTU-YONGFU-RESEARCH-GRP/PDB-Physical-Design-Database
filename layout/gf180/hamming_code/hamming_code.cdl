* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT hamming_code corrected_code[0] corrected_code[1] corrected_code[2]
+ corrected_code[3] corrected_code[4] corrected_code[5] corrected_code[6]
+ data_in[0] data_in[1] data_in[2] data_in[3] data_out[0] data_out[1]
+ data_out[2] data_out[3] encoded_out[0] encoded_out[1] encoded_out[2]
+ encoded_out[3] encoded_out[4] encoded_out[5] encoded_out[6]
+ received_in[0] received_in[1] received_in[2] received_in[3]
+ received_in[4] received_in[5] received_in[6] single_bit_error
X_075_ net10 _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_076_ _004_ net8 _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_077_ net11 _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_078_ net9 _006_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_079_ _005_ _007_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_080_ _005_ _007_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_081_ net7 net5 _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_082_ _010_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_083_ _008_ _009_ _011_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_084_ net7 net6 _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_085_ net11 net10 _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_086_ _013_ _014_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_087_ _012_ _015_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_088_ net5 _016_ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_089_ net7 _014_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_090_ net7 net5 _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_091_ _018_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_092_ _008_ _009_ _019_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_093_ net6 _017_ _020_ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_094_ net6 _014_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_095_ net7 _021_ _012_ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_096_ net8 _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_097_ _013_ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_098_ _019_ _023_ _022_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_099_ _022_ _011_ _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_100_ _004_ _024_ _025_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_101_ _006_ _027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_102_ net7 net6 _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_103_ net8 _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_104_ _019_ _028_ _029_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_105_ _004_ _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_106_ _031_ _011_ _032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_107_ _006_ _030_ _032_ _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_108_ _022_ _023_ _026_ _027_ _033_ _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_109_ _019_ _028_ _022_ _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_110_ _004_ _035_ _025_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_111_ _019_ _013_ _029_ _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_112_ _027_ _032_ _037_ _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_113_ _022_ _028_ _036_ _006_ _038_ _039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_114_ _034_ _039_ net9 net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_115_ _029_ _013_ _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_116_ net9 _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_117_ _041_ _031_ _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_118_ _040_ _042_ _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_119_ _031_ _022_ _019_ _023_ _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_120_ _041_ _019_ _045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_121_ _029_ _023_ _041_ _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_122_ _022_ _011_ _013_ _047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_123_ _046_ _047_ _031_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_124_ _043_ _044_ _045_ _048_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_125_ _011_ _023_ _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_126_ _029_ _050_ _040_ net9 _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_127_ _022_ _018_ _013_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_128_ _046_ _052_ _004_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_129_ _041_ _011_ _051_ _004_ _053_ _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_130_ _049_ _054_ _006_ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_131_ _029_ _019_ _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_132_ net9 _031_ _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_133_ _041_ _029_ _011_ _023_ _057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_134_ _004_ _023_ _055_ _056_ _057_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_135_ _031_ _025_ _059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_136_ _052_ _059_ net9 _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_137_ net9 net8 _010_ _028_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_138_ _004_ _028_ _055_ _042_ _061_ _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_139_ net9 _031_ _025_ _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_140_ net9 _029_ _011_ _023_ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_141_ _006_ _062_ _063_ _064_ _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_142_ _027_ _058_ _060_ _065_ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_143_ _031_ _023_ _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_144_ _031_ _029_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_145_ _067_ _019_ _006_ _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_146_ _067_ _050_ _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_147_ _019_ _023_ _006_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_148_ _004_ _022_ _070_ _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_149_ _041_ _068_ _069_ _071_ _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_150_ _011_ _013_ _006_ _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_151_ _004_ _029_ _073_ _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_152_ _031_ _022_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_153_ _011_ _000_ _006_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_154_ net9 _044_ _074_ _001_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_155_ _027_ _066_ _072_ _002_ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_156_ net4 net2 _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_157_ net1 _003_ p1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_158_ net4 net1 net3 p2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
X_159_ net3 _003_ p3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_160_ _015_ _020_ net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_161_ net14 net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_162_ net16 net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_163_ net17 net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_164_ net18 net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_165_ p1 net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_166_ p2 net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_167_ net1 net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_168_ p3 net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_169_ net2 net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_170_ net3 net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_171_ net4 net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 data_in[0] net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput2 data_in[1] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 data_in[2] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 data_in[3] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 received_in[0] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 received_in[1] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput7 received_in[2] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput8 received_in[3] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput9 received_in[4] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xinput10 received_in[5] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 received_in[6] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net12 corrected_code[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net13 corrected_code[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net14 corrected_code[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net15 corrected_code[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net16 corrected_code[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net17 corrected_code[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net18 corrected_code[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput19 net19 data_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput20 net20 data_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput21 net21 data_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput22 net22 data_out[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput23 net23 encoded_out[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput24 net24 encoded_out[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput25 net25 encoded_out[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput26 net26 encoded_out[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput27 net27 encoded_out[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput28 net28 encoded_out[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput29 net29 encoded_out[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput30 net30 single_bit_error VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS hamming_code
