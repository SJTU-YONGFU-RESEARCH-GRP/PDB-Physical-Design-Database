* cell performance_counter
* pin all_counts[47]
* pin all_counts[48]
* pin all_counts[41]
* pin all_counts[42]
* pin all_counts[39]
* pin all_counts[37]
* pin all_counts[38]
* pin counter_sel[1]
* pin all_counts[40]
* pin all_counts[49]
* pin all_counts[32]
* pin all_counts[82]
* pin all_counts[0]
* pin all_counts[18]
* pin all_counts[4]
* pin all_counts[3]
* pin all_counts[50]
* pin all_counts[17]
* pin all_counts[5]
* pin all_counts[6]
* pin all_counts[7]
* pin all_counts[83]
* pin all_counts[51]
* pin all_counts[1]
* pin all_counts[2]
* pin event_inc[0]
* pin all_counts[34]
* pin all_counts[35]
* pin event_inc[1]
* pin all_counts[36]
* pin all_counts[33]
* pin all_counts[19]
* pin all_counts[67]
* pin all_counts[66]
* pin all_counts[65]
* pin event_inc[2]
* pin all_counts[64]
* pin all_counts[121]
* pin all_counts[52]
* pin all_counts[84]
* pin all_counts[53]
* pin all_counts[54]
* pin all_counts[26]
* pin all_counts[27]
* pin all_counts[55]
* pin all_counts[56]
* pin all_counts[28]
* pin all_counts[57]
* pin all_counts[58]
* pin all_counts[59]
* pin all_counts[60]
* pin all_counts[61]
* pin all_counts[29]
* pin all_counts[62]
* pin all_counts[30]
* pin all_counts[31]
* pin all_counts[63]
* pin clear
* pin all_counts[94]
* pin all_counts[95]
* pin all_counts[90]
* pin all_counts[91]
* pin all_counts[92]
* pin all_counts[93]
* pin rst_n
* pin all_counts[43]
* pin all_counts[44]
* pin all_counts[46]
* pin all_counts[45]
* pin all_counts[89]
* pin counter_sel[2]
* pin all_counts[69]
* pin all_counts[71]
* pin all_counts[70]
* pin all_counts[68]
* pin all_counts[87]
* pin all_counts[85]
* pin all_counts[253]
* pin all_counts[86]
* pin all_counts[88]
* pin all_counts[252]
* pin all_counts[72]
* pin all_counts[251]
* pin all_counts[79]
* pin all_counts[23]
* pin all_counts[215]
* pin all_counts[77]
* pin all_counts[81]
* pin all_counts[254]
* pin all_counts[250]
* pin all_counts[249]
* pin all_counts[25]
* pin all_counts[80]
* pin all_counts[8]
* pin all_counts[78]
* pin all_counts[21]
* pin all_counts[24]
* pin counter_sel[0]
* pin all_counts[22]
* pin all_counts[20]
* pin all_counts[219]
* pin all_counts[73]
* pin all_counts[75]
* pin all_counts[74]
* pin all_counts[255]
* pin all_counts[222]
* pin count_value[31]
* pin all_counts[223]
* pin all_counts[16]
* pin all_counts[221]
* pin all_counts[76]
* pin all_counts[220]
* pin count_value[29]
* pin all_counts[216]
* pin all_counts[248]
* pin all_counts[247]
* pin count_value[30]
* pin all_counts[12]
* pin all_counts[246]
* pin all_counts[217]
* pin all_counts[245]
* pin all_counts[13]
* pin all_counts[9]
* pin all_counts[11]
* pin all_counts[127]
* pin all_counts[125]
* pin all_counts[126]
* pin all_counts[218]
* pin all_counts[242]
* pin all_counts[15]
* pin counter_sel[3]
* pin all_counts[10]
* pin all_counts[14]
* pin event_inc[7]
* pin count_value[28]
* pin count_value[26]
* pin count_value[27]
* pin all_counts[243]
* pin clk
* pin all_counts[213]
* pin count_value[25]
* pin all_counts[214]
* pin count_value[23]
* pin count_value[24]
* pin count_value[22]
* pin all_counts[212]
* pin all_counts[122]
* pin all_counts[211]
* pin event_inc[3]
* pin all_counts[97]
* pin all_counts[195]
* pin all_counts[196]
* pin all_counts[99]
* pin all_counts[123]
* pin all_counts[96]
* pin all_counts[119]
* pin all_counts[198]
* pin all_counts[197]
* pin all_counts[210]
* pin all_counts[114]
* pin all_counts[117]
* pin all_counts[113]
* pin all_counts[112]
* pin all_counts[118]
* pin all_counts[110]
* pin all_counts[120]
* pin all_counts[193]
* pin all_counts[209]
* pin all_counts[115]
* pin all_counts[116]
* pin all_counts[206]
* pin all_counts[208]
* pin all_counts[108]
* pin all_counts[101]
* pin all_counts[98]
* pin all_counts[100]
* pin all_counts[192]
* pin all_counts[207]
* pin all_counts[111]
* pin all_counts[159]
* pin all_counts[103]
* pin all_counts[105]
* pin all_counts[109]
* pin all_counts[102]
* pin all_counts[104]
* pin all_counts[204]
* pin all_counts[194]
* pin all_counts[107]
* pin all_counts[203]
* pin all_counts[205]
* pin all_counts[106]
* pin event_inc[6]
* pin counter_sel[4]
* pin all_counts[199]
* pin all_counts[128]
* pin all_counts[129]
* pin all_counts[200]
* pin all_counts[202]
* pin all_counts[201]
* pin counter_sel[6]
* pin all_counts[136]
* pin all_counts[137]
* pin counter_sel[5]
* pin all_counts[138]
* pin all_counts[187]
* pin all_counts[191]
* pin all_counts[189]
* pin all_counts[188]
* pin all_counts[135]
* pin all_counts[190]
* pin all_counts[226]
* pin all_counts[162]
* pin count_value[9]
* pin all_counts[234]
* pin enable
* pin all_counts[179]
* pin event_inc[5]
* pin all_counts[160]
* pin all_counts[161]
* pin all_counts[177]
* pin all_counts[224]
* pin all_counts[173]
* pin count_value[13]
* pin count_value[20]
* pin count_value[1]
* pin count_value[14]
* pin count_value[15]
* pin count_value[0]
* pin count_value[11]
* pin all_counts[228]
* pin all_counts[230]
* pin all_counts[167]
* pin all_counts[232]
* pin count_value[2]
* pin all_counts[176]
* pin counter_sel[7]
* pin all_counts[237]
* pin all_counts[231]
* pin count_value[17]
* pin all_counts[244]
* pin all_counts[168]
* pin all_counts[171]
* pin all_counts[142]
* pin all_counts[172]
* pin all_counts[235]
* pin all_counts[184]
* pin all_counts[139]
* pin count_value[5]
* pin count_value[6]
* pin all_counts[169]
* pin all_counts[185]
* pin all_counts[175]
* pin all_counts[141]
* pin all_counts[239]
* pin all_counts[186]
* pin all_counts[133]
* pin all_counts[132]
* pin event_inc[4]
* pin all_counts[150]
* pin all_counts[152]
* pin all_counts[158]
* pin all_counts[182]
* pin count_value[16]
* pin all_counts[154]
* pin all_counts[153]
* pin all_counts[163]
* pin all_counts[178]
* pin all_counts[124]
* pin count_value[18]
* pin all_counts[225]
* pin all_counts[227]
* pin count_value[4]
* pin all_counts[233]
* pin count_value[12]
* pin all_counts[236]
* pin all_counts[166]
* pin all_counts[140]
* pin all_counts[143]
* pin all_counts[144]
* pin all_counts[134]
* pin all_counts[145]
* pin all_counts[131]
* pin all_counts[146]
* pin all_counts[147]
* pin all_counts[148]
* pin all_counts[130]
* pin all_counts[149]
* pin all_counts[157]
* pin all_counts[151]
* pin all_counts[155]
* pin all_counts[156]
* pin count_value[7]
* pin all_counts[165]
* pin count_value[3]
* pin all_counts[164]
* pin all_counts[229]
* pin count_value[8]
* pin all_counts[170]
* pin count_value[10]
* pin all_counts[174]
* pin all_counts[241]
* pin all_counts[240]
* pin count_value[19]
* pin all_counts[238]
* pin count_value[21]
* pin all_counts[180]
* pin all_counts[183]
* pin all_counts[181]
* pin NWELL
* pin PWELL,gf180mcu_gnd
.SUBCKT performance_counter 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46
+ 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 122 317 318 319 320 350
+ 362 419 420 421 440 454 455 484 501 502 528 538 556 562 584 585 597 598 613
+ 614 615 616 624 625 626 639 640 652 672 673 674 680 681 710 726 727 747 749
+ 762 783 786 794 841 843 844 845 846 854 875 876 877 878 879 880 896 897 922
+ 923 944 951 952 953 954 969 971 987 988 989 1000 1017 1018 1019 1020 1021
+ 1049 1050 1060 1079 1097 1120 1143 1144 1155 1156 1172 1173 1188 1189 1190
+ 1202 1203 1204 1228 1256 1257 1258 1279 1280 1291 1292 1307 1308 1320 1321
+ 1322 1323 1346 1347 1358 1359 1390 1391 1392 1393 1394 1417 1418 1426 1444
+ 1445 1462 1480 1533 1573 1588 1589 1609 1610 1611 1642 1651 1652 1653 1681
+ 1694 1695 1723 1724 1735 1750 1909 1915 1924 1927 1930 1951 1952 1960 1962
+ 1966 1967 1968 1975 1982 1986 1987 1988 1990 1991 1992 2003 2004 2005 2007
+ 2010 2015 2018 2020 2021 2022 2023 2024 2025 2029 2030 2032 2033 2035 2036
+ 2037 2039 2040 2041 2042 2043 2044 2045 2046 2047 2048 2049 2050 2051 2052
+ 2053 2054 2055 2056 2057 2058 2059 2061 2062 2063 2064 2065 2066 2067 2068
+ 2069 2070 2071 2072 2073 2074 2075 2076 2077 2078 2079 2080 2081 2082 2083
+ 2084 2085 2086 2087 2088 2089 2090 2091 2092 2093 2094 2095 2096 2097 2098
+ 2099
* net 1 all_counts[47]
* net 2 all_counts[48]
* net 3 all_counts[41]
* net 4 all_counts[42]
* net 5 all_counts[39]
* net 6 all_counts[37]
* net 7 all_counts[38]
* net 8 counter_sel[1]
* net 9 all_counts[40]
* net 10 all_counts[49]
* net 11 all_counts[32]
* net 12 all_counts[82]
* net 13 all_counts[0]
* net 14 all_counts[18]
* net 15 all_counts[4]
* net 16 all_counts[3]
* net 17 all_counts[50]
* net 18 all_counts[17]
* net 19 all_counts[5]
* net 20 all_counts[6]
* net 21 all_counts[7]
* net 22 all_counts[83]
* net 23 all_counts[51]
* net 24 all_counts[1]
* net 25 all_counts[2]
* net 26 event_inc[0]
* net 27 all_counts[34]
* net 28 all_counts[35]
* net 29 event_inc[1]
* net 30 all_counts[36]
* net 31 all_counts[33]
* net 32 all_counts[19]
* net 33 all_counts[67]
* net 34 all_counts[66]
* net 35 all_counts[65]
* net 36 event_inc[2]
* net 37 all_counts[64]
* net 38 all_counts[121]
* net 39 all_counts[52]
* net 40 all_counts[84]
* net 41 all_counts[53]
* net 42 all_counts[54]
* net 43 all_counts[26]
* net 44 all_counts[27]
* net 45 all_counts[55]
* net 46 all_counts[56]
* net 47 all_counts[28]
* net 48 all_counts[57]
* net 49 all_counts[58]
* net 50 all_counts[59]
* net 51 all_counts[60]
* net 52 all_counts[61]
* net 53 all_counts[29]
* net 54 all_counts[62]
* net 55 all_counts[30]
* net 56 all_counts[31]
* net 57 all_counts[63]
* net 58 clear
* net 59 all_counts[94]
* net 60 all_counts[95]
* net 61 all_counts[90]
* net 62 all_counts[91]
* net 63 all_counts[92]
* net 64 all_counts[93]
* net 122 rst_n
* net 317 all_counts[43]
* net 318 all_counts[44]
* net 319 all_counts[46]
* net 320 all_counts[45]
* net 350 all_counts[89]
* net 362 counter_sel[2]
* net 419 all_counts[69]
* net 420 all_counts[71]
* net 421 all_counts[70]
* net 440 all_counts[68]
* net 454 all_counts[87]
* net 455 all_counts[85]
* net 484 all_counts[253]
* net 501 all_counts[86]
* net 502 all_counts[88]
* net 528 all_counts[252]
* net 538 all_counts[72]
* net 556 all_counts[251]
* net 562 all_counts[79]
* net 584 all_counts[23]
* net 585 all_counts[215]
* net 597 all_counts[77]
* net 598 all_counts[81]
* net 613 all_counts[254]
* net 614 all_counts[250]
* net 615 all_counts[249]
* net 616 all_counts[25]
* net 624 all_counts[80]
* net 625 all_counts[8]
* net 626 all_counts[78]
* net 639 all_counts[21]
* net 640 all_counts[24]
* net 652 counter_sel[0]
* net 672 all_counts[22]
* net 673 all_counts[20]
* net 674 all_counts[219]
* net 680 all_counts[73]
* net 681 all_counts[75]
* net 710 all_counts[74]
* net 726 all_counts[255]
* net 727 all_counts[222]
* net 747 count_value[31]
* net 749 all_counts[223]
* net 762 all_counts[16]
* net 783 all_counts[221]
* net 786 all_counts[76]
* net 794 all_counts[220]
* net 841 count_value[29]
* net 843 all_counts[216]
* net 844 all_counts[248]
* net 845 all_counts[247]
* net 846 count_value[30]
* net 854 all_counts[12]
* net 875 all_counts[246]
* net 876 all_counts[217]
* net 877 all_counts[245]
* net 878 all_counts[13]
* net 879 all_counts[9]
* net 880 all_counts[11]
* net 896 all_counts[127]
* net 897 all_counts[125]
* net 922 all_counts[126]
* net 923 all_counts[218]
* net 944 all_counts[242]
* net 951 all_counts[15]
* net 952 counter_sel[3]
* net 953 all_counts[10]
* net 954 all_counts[14]
* net 969 event_inc[7]
* net 971 count_value[28]
* net 987 count_value[26]
* net 988 count_value[27]
* net 989 all_counts[243]
* net 1000 clk
* net 1017 all_counts[213]
* net 1018 count_value[25]
* net 1019 all_counts[214]
* net 1020 count_value[23]
* net 1021 count_value[24]
* net 1049 count_value[22]
* net 1050 all_counts[212]
* net 1060 all_counts[122]
* net 1079 all_counts[211]
* net 1097 event_inc[3]
* net 1120 all_counts[97]
* net 1143 all_counts[195]
* net 1144 all_counts[196]
* net 1155 all_counts[99]
* net 1156 all_counts[123]
* net 1172 all_counts[96]
* net 1173 all_counts[119]
* net 1188 all_counts[198]
* net 1189 all_counts[197]
* net 1190 all_counts[210]
* net 1202 all_counts[114]
* net 1203 all_counts[117]
* net 1204 all_counts[113]
* net 1228 all_counts[112]
* net 1256 all_counts[118]
* net 1257 all_counts[110]
* net 1258 all_counts[120]
* net 1279 all_counts[193]
* net 1280 all_counts[209]
* net 1291 all_counts[115]
* net 1292 all_counts[116]
* net 1307 all_counts[206]
* net 1308 all_counts[208]
* net 1320 all_counts[108]
* net 1321 all_counts[101]
* net 1322 all_counts[98]
* net 1323 all_counts[100]
* net 1346 all_counts[192]
* net 1347 all_counts[207]
* net 1358 all_counts[111]
* net 1359 all_counts[159]
* net 1390 all_counts[103]
* net 1391 all_counts[105]
* net 1392 all_counts[109]
* net 1393 all_counts[102]
* net 1394 all_counts[104]
* net 1417 all_counts[204]
* net 1418 all_counts[194]
* net 1426 all_counts[107]
* net 1444 all_counts[203]
* net 1445 all_counts[205]
* net 1462 all_counts[106]
* net 1480 event_inc[6]
* net 1533 counter_sel[4]
* net 1573 all_counts[199]
* net 1588 all_counts[128]
* net 1589 all_counts[129]
* net 1609 all_counts[200]
* net 1610 all_counts[202]
* net 1611 all_counts[201]
* net 1642 counter_sel[6]
* net 1651 all_counts[136]
* net 1652 all_counts[137]
* net 1653 counter_sel[5]
* net 1681 all_counts[138]
* net 1694 all_counts[187]
* net 1695 all_counts[191]
* net 1723 all_counts[189]
* net 1724 all_counts[188]
* net 1735 all_counts[135]
* net 1750 all_counts[190]
* net 1909 all_counts[226]
* net 1915 all_counts[162]
* net 1924 count_value[9]
* net 1927 all_counts[234]
* net 1930 enable
* net 1951 all_counts[179]
* net 1952 event_inc[5]
* net 1960 all_counts[160]
* net 1962 all_counts[161]
* net 1966 all_counts[177]
* net 1967 all_counts[224]
* net 1968 all_counts[173]
* net 1975 count_value[13]
* net 1982 count_value[20]
* net 1986 count_value[1]
* net 1987 count_value[14]
* net 1988 count_value[15]
* net 1990 count_value[0]
* net 1991 count_value[11]
* net 1992 all_counts[228]
* net 2003 all_counts[230]
* net 2004 all_counts[167]
* net 2005 all_counts[232]
* net 2007 count_value[2]
* net 2010 all_counts[176]
* net 2015 counter_sel[7]
* net 2018 all_counts[237]
* net 2020 all_counts[231]
* net 2021 count_value[17]
* net 2022 all_counts[244]
* net 2023 all_counts[168]
* net 2024 all_counts[171]
* net 2025 all_counts[142]
* net 2029 all_counts[172]
* net 2030 all_counts[235]
* net 2032 all_counts[184]
* net 2033 all_counts[139]
* net 2035 count_value[5]
* net 2036 count_value[6]
* net 2037 all_counts[169]
* net 2039 all_counts[185]
* net 2040 all_counts[175]
* net 2041 all_counts[141]
* net 2042 all_counts[239]
* net 2043 all_counts[186]
* net 2044 all_counts[133]
* net 2045 all_counts[132]
* net 2046 event_inc[4]
* net 2047 all_counts[150]
* net 2048 all_counts[152]
* net 2049 all_counts[158]
* net 2050 all_counts[182]
* net 2051 count_value[16]
* net 2052 all_counts[154]
* net 2053 all_counts[153]
* net 2054 all_counts[163]
* net 2055 all_counts[178]
* net 2056 all_counts[124]
* net 2057 count_value[18]
* net 2058 all_counts[225]
* net 2059 all_counts[227]
* net 2061 count_value[4]
* net 2062 all_counts[233]
* net 2063 count_value[12]
* net 2064 all_counts[236]
* net 2065 all_counts[166]
* net 2066 all_counts[140]
* net 2067 all_counts[143]
* net 2068 all_counts[144]
* net 2069 all_counts[134]
* net 2070 all_counts[145]
* net 2071 all_counts[131]
* net 2072 all_counts[146]
* net 2073 all_counts[147]
* net 2074 all_counts[148]
* net 2075 all_counts[130]
* net 2076 all_counts[149]
* net 2077 all_counts[157]
* net 2078 all_counts[151]
* net 2079 all_counts[155]
* net 2080 all_counts[156]
* net 2081 count_value[7]
* net 2082 all_counts[165]
* net 2083 count_value[3]
* net 2084 all_counts[164]
* net 2085 all_counts[229]
* net 2086 count_value[8]
* net 2087 all_counts[170]
* net 2088 count_value[10]
* net 2089 all_counts[174]
* net 2090 all_counts[241]
* net 2091 all_counts[240]
* net 2092 count_value[19]
* net 2093 all_counts[238]
* net 2094 count_value[21]
* net 2095 all_counts[180]
* net 2096 all_counts[183]
* net 2097 all_counts[181]
* net 2098 NWELL
* net 2099 PWELL,gf180mcu_gnd
* cell instance $3 m0 *1 42,15.12
X$3 105 2098 2099 1 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7 r0 *1 48.16,5.04
X$7 66 2098 2099 2 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12 r0 *1 39.76,5.04
X$12 65 2098 2099 3 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15 m0 *1 78.4,25.2
X$15 129 2098 2099 4 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $20 r0 *1 56.56,5.04
X$20 69 2098 2099 5 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $24 m0 *1 84,15.12
X$24 74 2098 2099 6 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27 m0 *1 89.6,25.2
X$27 130 2098 2099 7 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31 m0 *1 94.64,35.28
X$31 2099 2098 8 292 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $35 m0 *1 74.48,15.12
X$35 107 2098 2099 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39 m0 *1 124.32,35.28
X$39 184 2098 2099 10 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $43 r0 *1 113.68,15.12
X$43 134 2098 2099 11 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47 r0 *1 115.92,25.2
X$47 183 2098 2099 12 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52 r0 *1 92.4,15.12
X$52 71 2098 2099 13 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55 r0 *1 64.96,5.04
X$55 97 2098 2099 14 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $59 m0 *1 123.2,25.2
X$59 160 2098 2099 15 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63 r0 *1 105.28,15.12
X$63 133 2098 2099 16 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68 r0 *1 109.2,5.04
X$68 73 2098 2099 17 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71 r0 *1 128.24,35.28
X$71 197 2098 2099 18 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75 r0 *1 117.6,5.04
X$75 75 2098 2099 19 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $80 m0 *1 114.8,25.2
X$80 150 2098 2099 20 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82 r0 *1 73.36,5.04
X$82 68 2098 2099 21 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $87 m0 *1 132.16,25.2
X$87 135 2098 2099 22 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $92 m0 *1 126,15.12
X$92 110 2098 2099 23 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96 m0 *1 93.52,15.12
X$96 98 2098 2099 24 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 r0 *1 141.12,15.12
X$99 136 2098 2099 25 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $104 r0 *1 126,5.04
X$104 26 2098 2099 100 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $107 r0 *1 149.52,15.12
X$107 137 2098 2099 27 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $112 r0 *1 142.8,5.04
X$112 78 2098 2099 28 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $118 r0 *1 169.68,15.12
X$118 29 2098 2099 139 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $121 r0 *1 157.92,15.12
X$121 111 2098 2099 30 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $126 r0 *1 134.4,5.04
X$126 76 2098 2099 31 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $130 m0 *1 176.96,25.2
X$130 163 2098 2099 32 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $133 m0 *1 158.48,25.2
X$133 138 2098 2099 33 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $137 r0 *1 151.2,5.04
X$137 185 2098 2099 34 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $141 r0 *1 179.2,15.12
X$141 140 2098 2099 35 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $146 r0 *1 184.8,5.04
X$146 2099 103 36 2098 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $150 r0 *1 159.6,5.04
X$150 79 2098 2099 37 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $154 r0 *1 168,5.04
X$154 101 2098 2099 38 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $158 m0 *1 188.72,15.12
X$158 113 2098 2099 39 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $162 r0 *1 176.4,5.04
X$162 102 2098 2099 40 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $166 m0 *1 202.16,15.12
X$166 82 2098 2099 41 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $169 m0 *1 211.12,15.12
X$169 116 2098 2099 42 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $173 m0 *1 219.52,15.12
X$173 126 2098 2099 43 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $177 r0 *1 224,5.04
X$177 85 2098 2099 44 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $181 r0 *1 215.04,15.12
X$181 84 2098 2099 45 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $186 r0 *1 232.4,5.04
X$186 87 2098 2099 46 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $189 m0 *1 229.04,25.2
X$189 171 2098 2099 47 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $193 r0 *1 240.8,5.04
X$193 88 2098 2099 48 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $197 m0 *1 238.56,25.2
X$197 173 2098 2099 49 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $202 r0 *1 249.2,5.04
X$202 90 2098 2099 50 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $205 r0 *1 249.2,15.12
X$205 141 2098 2099 51 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $210 r0 *1 282.8,5.04
X$210 93 2098 2099 52 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $214 r0 *1 257.6,5.04
X$214 104 2098 2099 53 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $218 r0 *1 274.4,5.04
X$218 92 2098 2099 54 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $222 m0 *1 266,15.12
X$222 119 2098 2099 55 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $225 r0 *1 266,5.04
X$225 91 2098 2099 56 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $229 m0 *1 258.72,35.28
X$229 148 2098 2099 57 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $234 m0 *1 280.56,15.12
X$234 2099 99 58 2098 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $238 m0 *1 292.88,15.12
X$238 124 2098 2099 59 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $241 r0 *1 291.2,5.04
X$241 94 2098 2099 60 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $245 r0 *1 304.64,5.04
X$245 95 2098 2099 61 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $249 m0 *1 306.88,15.12
X$249 120 2098 2099 62 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $253 r0 *1 313.04,5.04
X$253 96 2098 2099 63 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $257 m0 *1 315.28,15.12
X$257 121 2098 2099 64 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $260 m0 *1 66.64,35.28
X$260 158 65 159 181 2099 2098 189 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $262 r0 *1 66.64,45.36
X$262 2098 65 129 2099 215 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $265 r0 *1 59.36,25.2
X$265 2098 65 156 2099 128 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $268 r0 *1 70.56,85.68
X$268 2099 305 2098 352 292 65 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $275 r0 *1 58.24,15.12
X$275 2099 67 65 72 106 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $277 m0 *1 65.52,45.36
X$277 2098 105 66 2099 194 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $279 m0 *1 64.4,65.52
X$279 66 2099 257 2098 284 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $282 r0 *1 81.76,85.68
X$282 2099 338 2098 768 339 66 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $290 m0 *1 67.76,75.6
X$290 2099 67 66 290 291 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $293 m0 *1 403.76,15.12
X$293 2099 123 67 2098 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $604 m0 *1 324.24,428.4
X$604 2099 67 1840 1760 1916 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $607 r0 *1 51.52,307.44
X$607 2099 67 1496 1003 1522 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $609 m0 *1 43.12,307.44
X$609 2099 67 1396 1003 1428 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $612 r0 *1 50.4,287.28
X$612 2099 67 1379 1003 1380 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $614 m0 *1 101.92,297.36
X$614 2099 67 1363 1003 1400 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $616 r0 *1 44.8,317.52
X$616 2099 67 1492 1003 1535 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $619 m0 *1 43.68,257.04
X$619 2099 67 1174 1003 1123 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $621 r0 *1 15.12,246.96
X$621 2099 67 1122 1003 1114 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $624 r0 *1 196,367.92
X$624 2099 67 1757 1212 1784 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $626 m0 *1 59.92,277.2
X$626 2099 67 1231 1003 1265 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $628 m0 *1 12.32,327.6
X$628 2099 67 1493 1003 1556 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $631 r0 *1 3.36,257.04
X$631 2099 67 1175 1003 1062 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $633 m0 *1 111.44,257.04
X$633 2099 67 1157 658 1179 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $635 m0 *1 74.48,226.8
X$635 2099 67 975 1003 992 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $637 r0 *1 351.68,418.32
X$637 2099 67 1849 1760 1954 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $640 m0 *1 113.68,236.88
X$640 2099 67 1065 658 1088 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $642 r0 *1 145.6,317.52
X$642 2099 67 1563 1212 1580 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $645 r0 *1 370.72,418.32
X$645 2099 67 1773 1760 1978 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $648 r0 *1 127.12,246.96
X$648 2099 67 1121 658 1151 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $650 r0 *1 39.76,277.2
X$650 2099 67 1325 1003 1263 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $652 m0 *1 319.76,105.84
X$652 2099 67 120 457 391 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $654 m0 *1 3.36,287.28
X$654 2099 67 1261 1003 1481 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $656 m0 *1 42.56,357.84
X$656 2099 67 1655 1659 1726 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $658 m0 *1 367.36,418.32
X$658 2099 67 1789 1760 1979 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $660 m0 *1 166.88,297.36
X$660 2099 67 1395 1212 1425 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $662 r0 *1 331.52,428.4
X$662 2099 67 1732 1760 2011 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $664 r0 *1 188.72,317.52
X$664 2099 67 1583 1212 1582 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $666 r0 *1 157.92,327.6
X$666 2099 67 1626 1212 1596 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $668 r0 *1 39.76,347.76
X$668 2099 67 1682 1003 1725 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $670 r0 *1 76.72,418.32
X$670 2099 67 1939 1659 2012 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $672 r0 *1 81.2,347.76
X$672 2099 67 1654 1659 1698 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $675 m0 *1 91.84,267.12
X$675 2099 67 1232 1003 1251 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $677 r0 *1 42,236.88
X$677 2099 67 1102 1003 1063 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $679 m0 *1 170.8,347.76
X$679 2099 67 1686 1212 1731 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $682 m0 *1 59.92,236.88
X$682 2099 67 1035 1003 1116 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $684 m0 *1 72.24,398.16
X$684 2099 67 1877 1659 1878 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $686 r0 *1 2.8,307.44
X$686 2099 67 1360 1003 1516 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $688 r0 *1 131.6,287.28
X$688 2099 67 1401 1003 1402 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $690 r0 *1 81.76,287.28
X$690 2099 67 1362 1003 1398 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $692 r0 *1 68.32,236.88
X$692 2099 67 1036 1003 1064 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $695 r0 *1 73.92,378
X$695 2099 67 1755 1659 1829 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $697 r0 *1 191.52,347.76
X$697 2099 67 1711 1212 1687 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $699 m0 *1 124.32,267.12
X$699 2099 67 1177 1003 1254 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $702 m0 *1 352.24,428.4
X$702 2099 67 1692 1760 2014 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $704 m0 *1 85.68,378
X$704 2099 67 1818 1659 1804 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $706 r0 *1 120.96,317.52
X$706 2099 67 1561 1212 1578 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $708 r0 *1 246.96,408.24
X$708 2099 67 1800 1214 1950 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $710 r0 *1 81.76,5.04
X$710 2099 67 69 72 70 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $712 r0 *1 194.88,105.84
X$712 2099 67 366 112 379 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $715 m0 *1 380.8,136.08
X$715 2099 67 483 457 555 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $717 r0 *1 207.2,388.08
X$717 2099 67 1712 1212 1862 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $721 r0 *1 208.32,398.16
X$721 2099 67 1831 1212 1918 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $723 r0 *1 418.88,277.2
X$723 2099 67 1305 985 1349 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $725 m0 *1 54.88,15.12
X$725 2099 67 129 72 146 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $727 m0 *1 418.32,297.36
X$727 2099 67 1376 985 1482 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $730 m0 *1 309.12,196.56
X$730 2099 67 866 808 864 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $732 m0 *1 301.84,216.72
X$732 2099 67 900 808 961 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $734 r0 *1 316.4,216.72
X$734 2099 67 962 808 979 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $737 m0 *1 232.96,398.16
X$737 2099 67 1874 1214 1879 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $739 r0 *1 162.4,65.52
X$739 2099 67 185 112 301 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $741 r0 *1 154.56,55.44
X$741 2099 67 76 72 227 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $744 r0 *1 419.44,327.6
X$744 2099 67 1604 985 1643 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $746 m0 *1 175.28,75.6
X$746 2099 67 140 112 296 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $748 r0 *1 406.56,317.52
X$748 2099 67 1416 985 1575 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $750 m0 *1 409.36,166.32
X$750 2099 67 700 457 753 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $753 m0 *1 414.4,156.24
X$753 2099 67 583 457 701 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $755 r0 *1 236.32,357.84
X$755 2099 67 1759 1214 1802 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $757 r0 *1 190.4,75.6
X$757 2099 67 79 112 316 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $759 r0 *1 363.44,126
X$759 2099 67 500 457 526 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $761 m0 *1 227.36,378
X$761 2099 67 1662 1214 1826 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $763 m0 *1 140,105.84
X$763 2099 67 150 112 407 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $765 r0 *1 252,378
X$765 2099 67 1810 1214 1834 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $767 r0 *1 378,156.24
X$767 2099 67 643 457 697 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $769 m0 *1 380.8,156.24
X$769 2099 67 671 457 670 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $771 r0 *1 387.52,136.08
X$771 2099 67 527 457 617 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $773 r0 *1 391.44,327.6
X$773 2099 67 1603 985 1641 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $775 r0 *1 416.64,146.16
X$775 2099 67 636 457 642 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $778 r0 *1 416.08,307.44
X$778 2099 67 1478 985 1517 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $780 m0 *1 416.64,307.44
X$780 2099 67 1343 985 1518 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $782 r0 *1 304.08,408.24
X$782 2099 67 1910 1760 1932 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $785 r0 *1 81.76,65.52
X$785 2099 67 130 72 273 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $787 r0 *1 22.4,95.76
X$787 2099 67 394 290 392 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $789 m0 *1 305.76,388.08
X$789 2099 67 1718 1760 1852 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $792 r0 *1 27.44,105.84
X$792 2099 67 425 290 434 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $794 m0 *1 253.12,196.56
X$794 2099 67 666 808 910 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $797 r0 *1 45.36,75.6
X$797 2099 67 289 290 303 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $799 r0 *1 367.92,277.2
X$799 2099 67 1278 808 1302 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $801 r0 *1 357.28,246.96
X$801 2099 67 1110 808 1147 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $803 r0 *1 357.28,267.12
X$803 2099 67 1276 808 1285 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $806 r0 *1 218.96,196.56
X$806 2099 67 772 112 908 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $808 m0 *1 329.28,307.44
X$808 2099 67 1439 808 1485 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $810 m0 *1 33.6,55.44
X$810 2099 67 238 72 223 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $813 m0 *1 29.68,65.52
X$813 2099 67 256 72 237 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $815 m0 *1 365.68,307.44
X$815 2099 67 1411 985 1441 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $817 r0 *1 71.68,35.28
X$817 2099 67 107 72 207 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $819 m0 *1 58.8,55.44
X$819 2099 67 105 72 246 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $821 r0 *1 360.08,317.52
X$821 2099 67 1442 985 1576 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $823 r0 *1 217.28,428.4
X$823 2099 67 1881 1214 2026 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $825 m0 *1 295.68,186.48
X$825 2099 67 782 808 821 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $827 r0 *1 2.24,105.84
X$827 2099 67 399 290 422 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $829 r0 *1 240.24,428.4
X$829 2099 67 1801 1214 2028 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $831 r0 *1 301.28,166.32
X$831 2099 67 638 808 757 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $833 r0 *1 272.16,176.4
X$833 2099 67 580 808 791 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $835 r0 *1 25.76,75.6
X$835 2099 67 287 290 288 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $837 m0 *1 254.8,428.4
X$837 2099 67 1747 1214 1994 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $839 m0 *1 306.32,337.68
X$839 2099 67 1569 1214 1638 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $841 m0 *1 164.08,15.12
X$841 2099 67 81 112 80 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $843 r0 *1 187.6,15.12
X$843 2099 67 82 112 114 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $846 m0 *1 226.24,287.28
X$846 2099 67 1331 1214 1330 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $848 m0 *1 330.4,206.64
X$848 2099 67 868 457 932 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $850 r0 *1 305.2,307.44
X$850 2099 67 1512 1214 1513 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $852 r0 *1 204.96,5.04
X$852 2099 67 84 112 83 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $854 r0 *1 207.76,307.44
X$854 2099 67 1505 1212 1531 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $856 m0 *1 283.36,347.76
X$856 2099 67 1602 1214 1667 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $858 r0 *1 273.84,347.76
X$858 2099 67 1544 1214 1715 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $860 m0 *1 344.96,186.48
X$860 2099 67 837 457 812 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $862 r0 *1 242.48,297.36
X$862 2099 67 1435 1214 1461 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $864 r0 *1 273.28,287.28
X$864 2099 67 1408 1214 1406 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $866 r0 *1 419.44,176.4
X$866 2099 67 748 457 816 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $868 m0 *1 418.88,176.4
X$868 2099 67 793 457 795 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $870 r0 *1 416.08,206.64
X$870 2099 67 842 457 943 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $872 m0 *1 254.24,317.52
X$872 2099 67 1509 1214 1585 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $874 m0 *1 418.32,206.64
X$874 2099 67 874 457 925 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $876 r0 *1 417.76,196.56
X$876 2099 67 898 457 899 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $878 m0 *1 295.68,297.36
X$878 2099 67 1410 808 1409 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $881 r0 *1 127.12,45.36
X$881 2099 67 110 72 235 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $883 m0 *1 148.4,55.44
X$883 2099 67 134 72 239 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $885 r0 *1 132.16,25.2
X$885 2099 67 137 72 192 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $887 r0 *1 334.32,156.24
X$887 2099 67 553 457 735 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $889 m0 *1 297.36,257.04
X$889 2099 67 1031 808 1197 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $891 m0 *1 311.36,367.92
X$891 2099 67 1761 1760 1788 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $893 m0 *1 291.2,378
X$893 2099 67 1717 1760 1812 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $896 m0 *1 120.96,85.68
X$896 2099 67 160 72 334 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $898 m0 *1 220.08,357.84
X$898 2099 67 1745 1214 1744 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $900 m0 *1 210.56,337.68
X$900 2099 67 1587 1212 1618 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $902 m0 *1 229.6,337.68
X$902 2099 67 1633 1214 1631 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $904 r0 *1 302.96,236.88
X$904 2099 67 1045 808 1117 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $906 r0 *1 334.88,146.16
X$906 2099 67 611 457 631 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $908 m0 *1 329.28,126
X$908 2099 67 479 457 530 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $910 r0 *1 129.92,55.44
X$910 2099 67 75 72 262 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $913 m0 *1 110.32,65.52
X$913 2099 67 133 72 260 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $915 r0 *1 110.88,55.44
X$915 2099 67 73 72 261 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $918 m0 *1 280,236.88
X$918 2099 67 1044 808 1011 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $921 m0 *1 231.84,277.2
X$921 2099 67 1268 1212 1355 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $924 r0 *1 229.04,257.04
X$924 2099 67 1213 1212 1185 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $927 r0 *1 272.72,367.92
X$927 2099 67 1787 1214 1811 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $929 m0 *1 333.2,176.4
X$929 2099 67 699 457 776 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $931 r0 *1 178.64,45.36
X$931 2099 67 113 112 254 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $934 r0 *1 197.68,45.36
X$934 2099 67 116 112 252 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $937 r0 *1 252.56,246.96
X$937 2099 67 1133 808 1132 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $939 r0 *1 252.56,257.04
X$939 2099 67 1216 1214 1215 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $942 m0 *1 134.4,15.12
X$942 2099 67 78 72 77 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $944 m0 *1 103.04,15.12
X$944 2099 67 74 72 109 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $946 m0 *1 253.68,236.88
X$946 2099 67 1072 808 1094 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $948 m0 *1 103.6,35.28
X$948 2099 67 184 72 210 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $950 r0 *1 122.08,15.12
X$950 2099 67 111 72 179 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $952 m0 *1 228.48,226.8
X$952 2099 67 895 808 1030 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $954 r0 *1 221.2,85.68
X$954 2099 67 171 89 345 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $956 m0 *1 97.44,388.08
X$956 2099 67 1854 1659 1855 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $958 r0 *1 131.04,176.4
X$958 2099 67 789 658 798 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $960 m0 *1 342.16,367.92
X$960 2099 67 1719 1760 1823 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $962 r0 *1 319.2,357.84
X$962 2099 67 1762 1760 1775 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $964 m0 *1 217.84,105.84
X$964 2099 67 126 112 412 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $967 m0 *1 103.6,196.56
X$967 2099 67 824 658 902 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $970 r0 *1 104.72,196.56
X$970 2099 67 602 658 924 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $972 r0 *1 250.32,45.36
X$972 2099 67 141 89 232 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $974 m0 *1 109.2,216.72
X$974 2099 67 787 658 956 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $976 r0 *1 147.28,378
X$976 2099 67 1859 1659 1848 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $978 r0 *1 135.52,398.16
X$978 2099 67 1921 1659 1858 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $980 r0 *1 235.2,65.52
X$980 2099 67 173 89 279 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $982 m0 *1 108.64,176.4
X$982 2099 67 71 658 770 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $984 m0 *1 120.4,156.24
X$984 2099 67 567 658 707 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $987 r0 *1 273.28,65.52
X$987 2099 67 94 89 283 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $989 r0 *1 134.4,126
X$989 2099 67 68 112 519 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $991 r0 *1 157.36,146.16
X$991 2099 67 136 112 629 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $993 m0 *1 158.48,166.32
X$993 2099 67 98 658 722 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $995 m0 *1 276.64,85.68
X$995 2099 67 124 89 329 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $997 m0 *1 104.72,136.08
X$997 2099 67 135 658 536 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $999 m0 *1 96.88,428.4
X$999 2099 67 1941 1659 1995 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1002 r0 *1 109.2,428.4
X$1002 2099 67 1970 1659 1996 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1004 r0 *1 148.96,418.32
X$1004 2099 67 1972 1659 1998 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1007 r0 *1 124.32,418.32
X$1007 2099 67 1944 1659 1997 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1010 m0 *1 303.52,65.52
X$1010 2099 67 121 89 268 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1012 m0 *1 147.84,357.84
X$1012 2099 67 1707 1212 1738 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1014 m0 *1 246.96,15.12
X$1014 2099 67 90 89 125 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1017 m0 *1 266,45.36
X$1017 2099 67 92 89 220 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1020 r0 *1 257.6,15.12
X$1020 2099 67 93 89 118 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1022 m0 *1 227.92,15.12
X$1022 2099 67 88 89 86 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1025 r0 *1 201.6,206.64
X$1025 2099 67 840 658 938 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1027 r0 *1 117.6,337.68
X$1027 2099 67 1660 1659 1676 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1029 m0 *1 181.44,226.8
X$1029 2099 67 101 658 977 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1031 m0 *1 261.52,25.2
X$1031 2099 67 148 89 143 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1033 r0 *1 191.52,257.04
X$1033 2099 67 1161 1212 1182 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1035 r0 *1 135.52,236.88
X$1035 2099 67 1098 658 1067 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1037 m0 *1 168.56,267.12
X$1037 2099 67 1043 658 1210 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1039 r0 *1 160.72,226.8
X$1039 2099 67 862 658 1055 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1042 r0 *1 158.48,246.96
X$1042 2099 67 1061 658 1153 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1044 r0 *1 161.28,267.12
X$1044 2099 67 1130 658 1266 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1047 r0 *1 187.6,166.32
X$1047 2099 67 163 112 742 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1050 r0 *1 194.88,176.4
X$1050 2099 67 97 112 820 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1053 r0 *1 114.24,378
X$1053 2099 67 1805 1659 1847 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1056 r0 *1 216.72,45.36
X$1056 2099 67 87 112 251 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1058 m0 *1 146.16,206.64
X$1058 2099 67 823 658 913 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1060 r0 *1 144.48,216.72
X$1060 2099 67 825 658 995 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1062 r0 *1 142.8,367.92
X$1062 2099 67 1781 1212 1780 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1064 r0 *1 129.92,196.56
X$1064 2099 67 827 658 912 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1066 m0 *1 98,347.76
X$1066 2099 67 1705 1659 1658 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1068 r0 *1 184.8,196.56
X$1068 2099 67 197 658 885 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1070 m0 *1 154,216.72
X$1070 2099 67 829 658 974 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1072 m0 *1 115.92,367.92
X$1072 2099 67 1706 1659 1798 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1075 r0 *1 371.84,398.16
X$1075 2099 67 1720 1760 1913 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1077 r0 *1 2.24,136.08
X$1077 2099 67 563 290 539 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1079 m0 *1 417.76,267.12
X$1079 2099 67 1244 985 1281 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1082 m0 *1 419.44,277.2
X$1082 2099 67 1273 985 1309 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1084 r0 *1 17.36,126
X$1084 2099 67 509 290 489 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1086 m0 *1 295.68,428.4
X$1086 2099 67 1748 1760 2060 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1088 r0 *1 408.24,257.04
X$1088 2099 67 1142 985 1220 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1090 m0 *1 412.72,257.04
X$1090 2099 67 1187 985 1164 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1092 r0 *1 11.2,156.24
X$1092 2099 67 712 290 711 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1094 m0 *1 412.16,337.68
X$1094 2099 67 1608 985 1645 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1097 r0 *1 404.32,337.68
X$1097 2099 67 1605 985 1674 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1099 m0 *1 232.96,126
X$1099 2099 67 85 89 450 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1101 m0 *1 259.84,166.32
X$1101 2099 67 634 89 737 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1103 r0 *1 50.4,126
X$1103 2099 67 492 290 532 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1105 r0 *1 246.4,156.24
X$1105 2099 67 104 89 706 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1107 m0 *1 323.68,246.96
X$1107 2099 67 1138 808 1150 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1109 m0 *1 258.72,186.48
X$1109 2099 67 572 808 809 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1111 m0 *1 90.72,126
X$1111 2099 67 488 290 503 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1113 m0 *1 80.64,115.92
X$1113 2099 67 183 290 461 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1115 m0 *1 53.76,115.92
X$1115 2099 67 424 290 437 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1117 m0 *1 281.12,438.48
X$1117 2099 67 1799 1760 2038 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1119 m0 *1 369.6,246.96
X$1119 2099 67 1140 985 1145 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1121 m0 *1 43.12,166.32
X$1121 2099 67 599 290 685 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1123 r0 *1 272.16,428.4
X$1123 2099 67 1777 1214 2008 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1125 m0 *1 43.12,146.16
X$1125 2099 67 600 290 644 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1127 r0 *1 255.36,146.16
X$1127 2099 67 119 89 606 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1129 m0 *1 86.8,156.24
X$1129 2099 67 510 658 704 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1132 r0 *1 194.32,418.32
X$1132 2099 67 1965 1659 2001 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1134 m0 *1 174.72,428.4
X$1134 2099 67 1922 1659 2000 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1137 m0 *1 155.68,428.4
X$1137 2099 67 1973 1659 2016 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1140 m0 *1 279.44,126
X$1140 2099 67 453 89 485 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1142 r0 *1 193.2,408.24
X$1142 2099 67 1907 1212 1923 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1145 r0 *1 182.56,126
X$1145 2099 67 102 112 593 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1147 r0 *1 162.4,115.92
X$1147 2099 67 138 112 446 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1149 r0 *1 311.36,115.92
X$1149 2099 67 371 89 481 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1151 m0 *1 173.6,388.08
X$1151 2099 67 1861 1212 1860 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1154 m0 *1 295.68,85.68
X$1154 2099 67 96 89 331 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1156 m0 *1 295.12,105.84
X$1156 2099 67 95 89 409 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1158 r0 *1 253.12,115.92
X$1158 2099 67 91 89 506 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1160 r0 *1 29.12,176.4
X$1160 2099 67 754 658 755 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1162 m0 *1 400.96,357.84
X$1162 2099 67 1722 985 1794 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1164 m0 *1 284.48,166.32
X$1164 2099 67 529 808 736 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1166 m0 *1 303.52,146.16
X$1166 2099 67 480 457 649 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1169 m0 *1 284.48,146.16
X$1169 2099 67 498 89 576 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1171 m0 *1 409.36,226.8
X$1171 2099 67 1015 985 986 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1173 r0 *1 418.32,226.8
X$1173 2099 67 1016 985 1022 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1175 r0 *1 392,378
X$1175 2099 67 1672 1760 1844 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1177 m0 *1 417.76,236.88
X$1177 2099 67 1047 985 1051 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1179 r0 *1 393.12,367.92
X$1179 2099 67 1721 985 1870 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1181 r0 *1 395.92,357.84
X$1181 2099 67 1752 985 1768 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1183 r0 *1 393.68,347.76
X$1183 2099 67 1693 985 1727 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1186 m0 *1 10.64,176.4
X$1186 2099 67 653 290 751 2098 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1188 r0 *1 132.16,156.24
X$1188 68 2098 567 382 2099 688 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1190 r0 *1 142.24,156.24
X$1190 68 382 690 708 2099 2098 689 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1192 r0 *1 131.6,146.16
X$1192 68 2098 406 382 2099 648 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1194 m0 *1 133.84,136.08
X$1194 2098 68 546 2099 547 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1208 r0 *1 103.6,95.76
X$1208 2099 462 68 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1211 r0 *1 84.56,25.2
X$1211 158 69 159 131 2099 2098 191 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1213 r0 *1 77.28,15.12
X$1213 2098 69 182 2099 108 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $1215 m0 *1 92.4,85.68
X$1215 2099 305 2098 438 293 69 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1229 m0 *1 85.12,45.36
X$1229 74 130 69 107 2099 2098 181 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1233 r0 *1 91.84,25.2
X$1233 2098 157 108 2099 70 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1236 r0 *1 121.52,166.32
X$1236 71 2099 721 2098 785 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1238 m0 *1 131.6,166.32
X$1238 2098 71 98 2099 716 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1241 m0 *1 143.92,166.32
X$1241 718 2099 2098 71 98 719 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1243 m0 *1 139.44,156.24
X$1243 71 2098 98 567 2099 708 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1254 m0 *1 102.48,166.32
X$1254 2099 730 71 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1261 m0 *1 96.32,45.36
X$1261 2099 2098 72 2104 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1283 m0 *1 101.92,45.36
X$1283 2099 306 72 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1309 m0 *1 101.92,55.44
X$1309 73 2099 234 2098 248 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1311 m0 *1 129.92,45.36
X$1311 184 2098 73 110 2099 217 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1313 r0 *1 114.8,45.36
X$1313 184 73 168 172 2099 2098 196 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1322 r0 *1 103.04,85.68
X$1322 2099 275 2098 494 339 73 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1325 r0 *1 86.8,15.12
X$1325 2098 74 130 2099 131 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1328 m0 *1 99.12,25.2
X$1328 74 2099 132 2098 149 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1331 m0 *1 116.48,75.6
X$1331 2099 294 2098 430 293 74 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1333 m0 *1 82.32,65.52
X$1333 158 2098 74 159 2099 258 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1344 m0 *1 132.72,65.52
X$1344 75 2099 274 2098 271 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1346 m0 *1 138.88,95.76
X$1346 133 160 75 662 2099 2098 378 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1348 r0 *1 129.92,95.76
X$1348 133 160 75 150 2099 2098 382 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1359 m0 *1 123.76,115.92
X$1359 2099 443 75 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1361 m0 *1 161.28,45.36
X$1361 2099 2098 226 199 186 76 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1363 r0 *1 155.68,35.28
X$1363 198 2099 2098 134 76 199 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1365 m0 *1 154,35.28
X$1365 134 137 76 78 2099 2098 193 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1367 m0 *1 146.72,35.28
X$1367 134 137 76 186 2099 2098 187 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1369 r0 *1 166.88,75.6
X$1369 2099 275 2098 343 276 76 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1382 m0 *1 133.84,35.28
X$1382 2098 157 127 2099 77 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1385 r0 *1 165.2,35.28
X$1385 2098 137 78 2099 200 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1387 m0 *1 150.08,75.6
X$1387 2099 294 2098 308 293 78 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1390 m0 *1 153.44,15.12
X$1390 78 2099 187 2098 127 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1401 r0 *1 177.52,95.76
X$1401 2099 2098 79 363 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $1403 m0 *1 178.64,105.84
X$1403 138 185 140 79 2099 2098 416 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1406 m0 *1 188.16,105.84
X$1406 2098 140 79 2099 413 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1409 m0 *1 178.08,85.68
X$1409 337 2099 2098 79 140 336 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $1422 m0 *1 167.44,25.2
X$1422 2099 2098 80 81 144 139 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1424 r0 *1 166.32,15.12
X$1424 2099 2098 81 162 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1431 m0 *1 190.96,25.2
X$1431 82 2099 166 2098 155 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1434 r0 *1 208.88,25.2
X$1434 2098 82 116 2099 167 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1436 m0 *1 214.48,35.28
X$1436 82 116 84 87 2099 2098 170 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1438 r0 *1 204.4,65.52
X$1438 2099 275 2098 679 276 82 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1446 m0 *1 202.16,45.36
X$1446 82 2098 201 165 2099 218 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1449 r0 *1 208.32,15.12
X$1449 2098 115 153 2099 83 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1451 m0 *1 207.2,25.2
X$1451 84 2099 177 2098 153 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1454 r0 *1 217.84,35.28
X$1454 84 201 165 167 2099 2098 202 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1463 r0 *1 214.48,65.52
X$1463 2099 275 2098 277 276 84 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1469 r0 *1 229.6,105.84
X$1469 2099 171 433 85 126 477 2098 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $1472 r0 *1 218.4,95.76
X$1472 126 2098 85 384 2099 397 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1475 r0 *1 242.48,126
X$1475 2098 85 2099 522 537 497 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1487 m0 *1 217.84,126
X$1487 2099 472 85 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1489 r0 *1 235.76,126
X$1489 85 2099 497 522 2098 507 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1493 r0 *1 225.12,15.12
X$1493 2098 115 152 2099 86 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1497 m0 *1 227.36,55.44
X$1497 2098 244 87 2099 249 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1499 r0 *1 218.4,55.44
X$1499 2099 2098 243 264 87 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1508 m0 *1 214.48,75.6
X$1508 2099 275 2098 315 276 87 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1512 m0 *1 244.16,35.28
X$1512 88 173 90 141 2099 2098 174 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1514 r0 *1 230.72,35.28
X$1514 88 2098 173 170 2099 203 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1517 r0 *1 241.36,35.28
X$1517 88 173 170 204 2099 2098 205 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1519 m0 *1 228.48,45.36
X$1519 88 201 165 170 2099 2098 233 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1527 r0 *1 216.16,75.6
X$1527 2099 275 2098 571 276 88 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1530 m0 *1 218.96,25.2
X$1530 88 2099 169 2098 152 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1539 r0 *1 267.12,85.68
X$1539 2099 353 89 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1543 r0 *1 259.28,85.68
X$1543 2099 2098 89 2111 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1588 r0 *1 221.76,65.52
X$1588 2099 294 2098 278 276 90 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1590 r0 *1 230.16,15.12
X$1590 90 2099 188 2098 117 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1594 m0 *1 235.76,45.36
X$1594 90 201 165 203 2099 2098 221 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1606 r0 *1 244.72,45.36
X$1606 2098 90 141 2099 204 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1613 r0 *1 238.56,95.76
X$1613 2099 324 91 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1617 m0 *1 252,126
X$1617 91 497 477 478 2098 2099 505 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1619 m0 *1 259.84,126
X$1619 2098 91 2099 504 477 497 478 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1623 m0 *1 276.64,55.44
X$1623 2098 244 92 2099 245 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1625 m0 *1 270.48,55.44
X$1625 2099 2098 228 145 92 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1627 r0 *1 243.04,25.2
X$1627 93 92 170 174 2099 2098 190 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1637 m0 *1 250.88,75.6
X$1637 2099 294 2098 346 293 92 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1641 m0 *1 258.16,75.6
X$1641 2099 294 2098 335 293 93 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1643 m0 *1 246.96,25.2
X$1643 93 2099 151 2098 142 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1646 r0 *1 248.64,35.28
X$1646 2098 93 205 2099 206 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1658 m0 *1 268.8,75.6
X$1658 2099 2098 94 310 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1665 m0 *1 286.16,75.6
X$1665 94 2099 298 311 2098 267 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1668 r0 *1 283.92,75.6
X$1668 2098 94 2099 311 333 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1672 m0 *1 314.16,105.84
X$1672 2099 2098 95 373 432 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1674 r0 *1 304.64,85.68
X$1674 95 120 96 121 2099 2098 349 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1676 m0 *1 291.76,105.84
X$1676 2099 2098 95 408 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1678 r0 *1 302.96,95.76
X$1678 371 95 120 390 2099 2098 372 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1686 r0 *1 296.8,85.68
X$1686 2099 2098 96 347 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1689 r0 *1 308.56,75.6
X$1689 2099 2098 96 312 372 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1698 r0 *1 185.36,176.4
X$1698 97 2099 800 2098 819 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1700 m0 *1 207.2,176.4
X$1700 772 197 97 163 2099 2098 745 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1702 r0 *1 175.28,166.32
X$1702 97 723 689 773 2099 2098 739 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1715 m0 *1 105.84,156.24
X$1715 2099 659 97 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1721 r0 *1 153.44,166.32
X$1721 2099 2098 761 719 721 98 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1734 r0 *1 167.44,136.08
X$1734 2099 569 98 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1740 r0 *1 278.88,15.12
X$1740 2099 2098 99 145 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1743 m0 *1 148.4,176.4
X$1743 2098 774 100 2099 771 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1746 m0 *1 140,176.4
X$1746 2099 2098 798 789 144 100 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1752 r0 *1 207.2,226.8
X$1752 2098 1007 101 2099 1010 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1754 r0 *1 193.76,236.88
X$1754 101 1061 1098 1043 2099 2098 1095 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1756 r0 *1 187.6,216.72
X$1756 2099 2098 959 264 101 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1759 r0 *1 182.56,216.72
X$1759 2098 265 101 2099 998 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1762 m0 *1 186.48,246.96
X$1762 101 1061 1098 1107 2099 2098 1128 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1764 r0 *1 179.76,236.88
X$1764 101 2098 1061 1107 2099 1066 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1766 m0 *1 179.76,246.96
X$1766 2098 101 1107 2099 1127 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1780 r0 *1 194.32,136.08
X$1780 2099 2098 102 570 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1782 r0 *1 201.6,126
X$1782 2098 102 496 2099 389 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1796 m0 *1 184.24,15.12
X$1796 103 2098 2099 263 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $1799 r0 *1 248.08,115.92
X$1799 2099 2098 104 478 119 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1807 r0 *1 243.6,85.68
X$1807 2099 355 104 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1810 m0 *1 245.84,146.16
X$1810 104 2099 497 477 2098 621 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $1814 r0 *1 237.44,156.24
X$1814 2099 550 692 406 104 2098 690 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $1817 r0 *1 247.52,146.16
X$1817 2098 104 2099 477 665 497 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1821 m0 *1 59.36,65.52
X$1821 2098 105 224 2099 272 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1823 r0 *1 75.6,95.76
X$1823 2099 338 2098 442 339 105 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1825 m0 *1 48.72,45.36
X$1825 105 2099 212 2098 213 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1836 m0 *1 58.24,25.2
X$1836 2098 157 128 2099 106 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1840 m0 *1 78.4,95.76
X$1840 2099 305 2098 512 292 107 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1846 m0 *1 84.56,35.28
X$1846 107 2099 191 2098 208 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1856 m0 *1 109.2,25.2
X$1856 2098 157 149 2099 109 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1858 r0 *1 144.48,75.6
X$1858 2099 275 2098 444 276 110 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1861 r0 *1 118.72,35.28
X$1861 110 2099 196 2098 222 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $1871 r0 *1 178.64,25.2
X$1871 111 2098 159 164 2099 165 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1873 r0 *1 154.56,25.2
X$1873 2099 2098 111 158 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1875 r0 *1 162.4,25.2
X$1875 162 111 161 193 2099 2098 168 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1901 r0 *1 189.84,85.68
X$1901 2099 112 2101 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $1933 r0 *1 189.84,95.76
X$1933 2099 306 112 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1938 r0 *1 179.76,35.28
X$1938 2098 113 217 2099 164 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1941 r0 *1 181.44,55.44
X$1941 2098 265 113 2099 241 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1943 r0 *1 186.48,65.52
X$1943 2099 275 2098 302 276 113 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1945 r0 *1 186.48,55.44
X$1945 2099 2098 255 264 113 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1955 m0 *1 185.92,25.2
X$1955 2098 115 155 2099 114 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1961 m0 *1 256.48,25.2
X$1961 2098 115 142 2099 118 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1963 r0 *1 239.68,15.12
X$1963 2098 115 117 2099 125 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1968 r0 *1 263.2,25.2
X$1968 2098 115 175 2099 143 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1970 m0 *1 142.24,65.52
X$1970 2098 115 271 2099 262 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1972 r0 *1 185.36,75.6
X$1972 2098 115 309 2099 316 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1974 m0 *1 170.24,75.6
X$1974 2098 115 295 2099 301 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1976 r0 *1 177.52,75.6
X$1976 2098 115 323 2099 296 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1991 r0 *1 229.6,65.52
X$1991 265 2098 2099 115 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $1995 r0 *1 204.4,55.44
X$1995 2099 2098 242 264 116 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $1998 r0 *1 210,55.44
X$1998 2098 265 116 2099 250 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2000 m0 *1 207.2,75.6
X$2000 2099 275 2098 471 276 116 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2017 m0 *1 243.6,105.84
X$2017 2099 411 119 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2022 m0 *1 252,136.08
X$2022 2098 119 2099 550 573 477 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2025 r0 *1 252.56,136.08
X$2025 119 2099 477 550 2098 605 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2027 r0 *1 301.28,105.84
X$2027 2099 2098 120 458 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2039 r0 *1 311.36,95.76
X$2039 120 2099 298 373 2098 393 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2042 m0 *1 318.08,95.76
X$2042 2098 120 2099 373 374 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2044 r0 *1 301.28,85.68
X$2044 2099 2098 121 328 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2053 r0 *1 301.84,75.6
X$2053 121 2099 298 312 2098 281 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2057 m0 *1 302.96,75.6
X$2057 2098 121 2099 312 280 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $2059 r0 *1 425.04,15.12
X$2059 2099 123 122 2098 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $2066 m0 *1 273.28,85.68
X$2066 2099 2098 124 327 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2068 r0 *1 291.76,75.6
X$2068 2099 2098 124 311 330 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2082 m0 *1 217.28,95.76
X$2082 126 2099 384 2098 383 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2086 r0 *1 230.72,126
X$2086 2099 2098 126 522 433 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2103 m0 *1 225.12,126
X$2103 2099 474 126 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2111 m0 *1 68.88,25.2
X$2111 129 2099 189 2098 147 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2117 m0 *1 66.64,95.76
X$2117 2099 338 2098 468 339 129 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2122 r0 *1 84,55.44
X$2122 130 2099 258 2098 259 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2124 r0 *1 93.52,75.6
X$2124 2099 305 2098 340 293 130 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2130 r0 *1 78.4,25.2
X$2130 2099 2098 132 182 131 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2137 r0 *1 217.28,25.2
X$2137 132 201 164 170 2099 2098 169 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2140 m0 *1 57.68,35.28
X$2140 2099 2098 132 156 181 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2142 r0 *1 57.12,35.28
X$2142 2099 168 132 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2144 r0 *1 52.08,45.36
X$2144 2099 2098 132 231 214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2146 r0 *1 57.12,45.36
X$2146 132 2098 214 224 2099 212 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2148 m0 *1 206.64,35.28
X$2148 132 201 164 167 2099 2098 177 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2151 r0 *1 173.04,35.28
X$2151 2099 2098 132 209 201 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2155 m0 *1 227.36,35.28
X$2155 132 172 164 203 2099 2098 188 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2158 r0 *1 189.84,25.2
X$2158 132 2098 201 164 2099 166 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2177 r0 *1 131.6,65.52
X$2177 133 2098 160 300 2099 274 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2181 m0 *1 128.8,95.76
X$2181 2099 2098 133 356 406 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2185 r0 *1 115.36,65.52
X$2185 133 2099 300 2098 286 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2195 m0 *1 142.8,115.92
X$2195 2099 439 133 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2200 m0 *1 148.4,45.36
X$2200 134 2099 186 2098 236 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2213 m0 *1 97.44,95.76
X$2213 2099 338 2098 517 339 134 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2215 r0 *1 115.36,126
X$2215 135 183 488 510 2099 2098 496 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2217 r0 *1 127.68,126
X$2217 2099 2098 135 518 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2225 r0 *1 133.84,166.32
X$2225 717 136 771 716 2099 2098 300 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2227 r0 *1 147.28,166.32
X$2227 717 2098 136 771 2099 723 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2229 m0 *1 136.64,166.32
X$2229 717 718 136 771 2099 2098 662 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2231 r0 *1 152.88,156.24
X$2231 2098 136 720 2099 709 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2244 r0 *1 154,85.68
X$2244 2099 342 136 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2250 r0 *1 151.76,75.6
X$2250 2099 294 2098 360 293 137 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2258 m0 *1 144.48,25.2
X$2258 2098 137 180 2099 154 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2261 m0 *1 172.48,105.84
X$2261 138 2098 185 337 2099 447 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2264 m0 *1 169.12,126
X$2264 492 2098 138 185 2099 470 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2266 r0 *1 171.92,105.84
X$2266 2099 2098 138 431 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2280 r0 *1 173.6,25.2
X$2280 2098 211 139 2099 161 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2285 r0 *1 183.12,115.92
X$2285 2099 2098 140 561 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2290 r0 *1 180.88,85.68
X$2290 2099 2098 323 336 344 140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2302 m0 *1 243.6,75.6
X$2302 2099 294 2098 359 293 141 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2304 m0 *1 254.8,55.44
X$2304 2099 2098 219 145 141 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2306 m0 *1 260.4,55.44
X$2306 2098 244 141 2099 247 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2323 r0 *1 301.28,65.52
X$2323 2099 144 2098 268 281 280 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2326 m0 *1 281.12,65.52
X$2326 2099 144 2098 283 267 333 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2328 m0 *1 280.56,25.2
X$2328 2099 145 144 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $2331 r0 *1 318.08,95.76
X$2331 2099 144 2098 391 393 374 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2352 m0 *1 192.08,95.76
X$2352 2099 2098 379 366 144 263 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2354 r0 *1 316.96,398.16
X$2354 2099 2098 1932 1910 144 1911 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2356 r0 *1 335.44,297.36
X$2356 2099 2098 1485 1439 144 1440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2360 m0 *1 147.84,367.92
X$2360 2099 2098 1780 1781 144 1756 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2362 r0 *1 91.28,216.72
X$2362 2099 2098 992 975 144 1004 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2366 m0 *1 266.56,65.52
X$2366 2099 145 386 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2368 r0 *1 262.08,55.44
X$2368 2099 145 264 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2375 m0 *1 248.64,65.52
X$2375 2099 2098 285 145 173 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2379 m0 *1 249.2,55.44
X$2379 2099 2098 145 244 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $2384 m0 *1 63.28,25.2
X$2384 2098 157 147 2099 146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2391 r0 *1 253.68,25.2
X$2391 148 2099 176 2098 175 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2394 r0 *1 254.24,65.52
X$2394 2099 294 2098 297 293 148 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2403 r0 *1 139.44,95.76
X$2403 150 2099 378 2098 418 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2413 r0 *1 112,95.76
X$2413 2099 395 150 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2420 m0 *1 236.88,35.28
X$2420 168 172 164 205 2099 2098 151 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2428 m0 *1 140,35.28
X$2428 2098 157 154 2099 192 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2445 m0 *1 88.48,65.52
X$2445 2098 157 259 2099 273 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2447 r0 *1 110.32,65.52
X$2447 2098 157 286 2099 260 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2462 r0 *1 90.72,35.28
X$2462 2098 157 208 2099 207 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2464 r0 *1 124.32,25.2
X$2464 2098 157 178 2099 179 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2466 m0 *1 131.6,75.6
X$2466 307 2098 2099 157 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $2470 m0 *1 169.68,45.36
X$2470 2098 158 159 2099 216 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2472 r0 *1 104.72,25.2
X$2472 158 2099 159 2098 178 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2474 r0 *1 102.48,45.36
X$2474 158 184 159 172 2099 2098 234 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2477 r0 *1 59.36,65.52
X$2477 158 159 214 272 2099 2098 257 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2481 r0 *1 118.16,75.6
X$2481 2099 294 2098 321 293 158 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2483 r0 *1 49.84,55.44
X$2483 158 238 159 214 2099 2098 270 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2485 m0 *1 50.4,75.6
X$2485 158 159 214 313 2099 2098 304 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2523 m0 *1 161.84,35.28
X$2523 2099 161 162 198 159 200 2098 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $2529 r0 *1 119.84,85.68
X$2529 2098 160 356 2099 354 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2538 r0 *1 121.52,95.76
X$2538 2099 414 160 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2542 m0 *1 175.28,35.28
X$2542 2098 162 161 2099 186 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2558 m0 *1 177.52,166.32
X$2558 163 2099 739 2098 741 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2568 r0 *1 171.36,126
X$2568 2099 559 163 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2572 r0 *1 235.76,25.2
X$2572 168 172 164 190 2099 2098 176 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2590 m0 *1 243.6,45.36
X$2590 201 2098 165 206 2099 230 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2613 m0 *1 52.08,65.52
X$2613 238 256 168 214 2099 2098 282 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2635 r0 *1 232.96,95.76
X$2635 2098 265 171 2099 396 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2637 m0 *1 226.8,95.76
X$2637 2099 2098 367 264 171 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $2645 m0 *1 236.88,95.76
X$2645 2099 358 171 2098 357 341 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2648 m0 *1 70.56,45.36
X$2648 181 215 224 194 2099 2098 172 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2651 r0 *1 194.32,35.28
X$2651 2099 172 201 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2667 m0 *1 221.76,75.6
X$2667 2099 294 2098 385 276 173 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2669 r0 *1 242.48,55.44
X$2669 2098 244 173 2099 266 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2708 r0 *1 150.64,35.28
X$2708 2099 2098 198 180 186 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2711 m0 *1 60.48,45.36
X$2711 2098 181 215 2099 214 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2726 r0 *1 108.08,126
X$2726 183 2098 488 510 2099 469 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2728 r0 *1 97.44,126
X$2728 2099 2098 183 515 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2737 m0 *1 103.04,85.68
X$2737 2099 275 2098 428 339 184 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2741 r0 *1 106.4,35.28
X$2741 2098 184 209 2099 195 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $2755 m0 *1 184.24,115.92
X$2755 2098 185 448 2099 463 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2758 m0 *1 168.56,85.68
X$2758 2099 2098 185 322 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2809 r0 *1 109.76,45.36
X$2809 2098 225 195 2099 210 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2814 m0 *1 181.44,196.56
X$2814 197 2099 884 2098 886 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $2816 m0 *1 178.64,176.4
X$2816 772 2098 197 743 2099 773 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2830 m0 *1 113.12,156.24
X$2830 2099 678 197 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $2848 m0 *1 175.84,45.36
X$2848 216 2098 201 217 2099 253 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2866 m0 *1 218.96,55.44
X$2866 2099 2098 251 243 202 249 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2901 r0 *1 180.88,95.76
X$2901 263 2098 365 211 2099 344 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2904 m0 *1 176.96,115.92
X$2904 263 365 211 447 2099 2098 426 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2906 r0 *1 177.52,105.84
X$2906 263 365 211 416 2099 2098 398 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2908 m0 *1 193.2,105.84
X$2908 263 365 211 413 2099 2098 448 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2910 r0 *1 91.84,226.8
X$2910 211 2098 1004 1005 2099 1037 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $2913 m0 *1 88.48,246.96
X$2913 211 1004 1005 1104 2099 2098 1124 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2915 m0 *1 272.72,236.88
X$2915 2098 211 993 2099 1073 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2917 m0 *1 186.48,95.76
X$2917 2098 211 337 2099 364 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2919 r0 *1 257.04,226.8
X$2919 2099 774 211 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $2934 r0 *1 87.36,236.88
X$2934 2099 1005 211 1004 1105 1103 2098 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $2940 m0 *1 53.76,55.44
X$2940 2098 225 213 2099 246 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2970 m0 *1 202.16,55.44
X$2970 2099 2098 252 242 218 250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2974 m0 *1 252.56,45.36
X$2974 2099 2098 232 219 221 247 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2977 r0 *1 269.36,45.36
X$2977 2099 2098 220 228 230 245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2983 r0 *1 122.08,45.36
X$2983 2098 225 222 2099 235 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2988 r0 *1 32.48,45.36
X$2988 2098 225 229 2099 223 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2997 m0 *1 57.68,75.6
X$2997 238 256 287 289 2099 2098 224 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3000 m0 *1 115.92,85.68
X$3000 2098 225 354 2099 334 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3002 r0 *1 66.64,65.52
X$3002 2098 225 284 2099 291 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3005 r0 *1 128.24,75.6
X$3005 2099 2098 307 225 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3009 m0 *1 111.44,55.44
X$3009 2098 225 248 2099 261 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3012 m0 *1 25.76,75.6
X$3012 2098 225 299 2099 288 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3028 r0 *1 27.44,55.44
X$3028 2098 225 269 2099 237 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3030 m0 *1 45.92,85.68
X$3030 2098 225 332 2099 303 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3033 r0 *1 160.16,45.36
X$3033 2098 240 226 2099 227 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3043 r0 *1 42,45.36
X$3043 2098 238 231 2099 229 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3056 m0 *1 240.24,65.52
X$3056 2099 2098 279 285 233 266 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3072 r0 *1 149.52,55.44
X$3072 2098 240 236 2099 239 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3076 r0 *1 55.44,85.68
X$3076 2099 338 2098 765 339 238 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3082 m0 *1 44.24,75.6
X$3082 238 2098 256 287 2099 313 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3092 m0 *1 19.04,85.68
X$3092 238 2098 2099 317 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3096 m0 *1 159.04,156.24
X$3096 2098 240 709 2099 629 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3099 m0 *1 212.8,105.84
X$3099 2098 240 383 2099 412 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3102 m0 *1 254.8,166.32
X$3102 2098 240 724 2099 737 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3105 m0 *1 361.2,136.08
X$3105 2098 240 552 2099 526 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3107 m0 *1 375.76,156.24
X$3107 2098 240 696 2099 670 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3109 m0 *1 378.56,176.4
X$3109 2098 240 731 2099 697 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3111 m0 *1 383.04,146.16
X$3111 2098 240 645 2099 617 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3113 m0 *1 286.72,156.24
X$3113 2099 2098 307 240 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3128 r0 *1 382.48,136.08
X$3128 2098 240 587 2099 555 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3130 m0 *1 183.12,55.44
X$3130 2099 2098 254 255 253 241 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3140 m0 *1 280,196.56
X$3140 2099 2098 244 307 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3142 m0 *1 210.56,206.64
X$3142 2099 2098 244 935 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3151 m0 *1 226.24,206.64
X$3151 2099 2098 244 265 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3154 r0 *1 294,176.4
X$3154 2098 244 782 2099 799 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3168 r0 *1 206.64,196.56
X$3168 2098 244 840 2099 929 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3215 r0 *1 32.48,55.44
X$3215 256 2099 270 2098 269 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3225 r0 *1 62.72,85.68
X$3225 2099 338 2098 351 339 256 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3228 m0 *1 27.44,85.68
X$3228 256 2098 2099 318 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3248 r0 *1 184.8,105.84
X$3248 263 365 364 470 2099 2098 387 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3277 m0 *1 290.08,186.48
X$3277 2099 2098 822 264 782 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3279 r0 *1 262.08,236.88
X$3279 2099 2098 1094 1072 264 993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3281 r0 *1 238.56,226.8
X$3281 2099 2098 1029 264 895 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3285 r0 *1 188.72,246.96
X$3285 2099 2098 1162 264 1161 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3287 m0 *1 205.52,216.72
X$3287 2099 2098 939 264 840 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3291 m0 *1 175.28,156.24
X$3291 2099 2098 265 493 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3293 r0 *1 174.16,156.24
X$3293 2099 2098 265 380 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3295 r0 *1 194.32,246.96
X$3295 2098 265 1161 2099 1129 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3300 m0 *1 232.4,216.72
X$3300 2098 265 895 2099 960 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3304 r0 *1 231.28,236.88
X$3304 2099 2098 265 369 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3347 r0 *1 109.76,75.6
X$3347 2099 2098 305 275 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3375 m0 *1 123.76,75.6
X$3375 2099 2098 292 276 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3389 m0 *1 216.16,136.08
X$3389 2099 560 595 523 277 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3394 m0 *1 216.72,115.92
X$3394 2099 460 472 458 278 314 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3406 m0 *1 30.8,75.6
X$3406 287 2099 282 2098 299 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3436 r0 *1 61.04,95.76
X$3436 2099 338 2098 441 339 287 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3438 r0 *1 18.48,85.68
X$3438 287 2098 2099 320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3443 m0 *1 59.36,95.76
X$3443 2099 338 2098 677 339 289 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3445 m0 *1 50.96,85.68
X$3445 289 2099 304 2098 332 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $3452 r0 *1 2.8,75.6
X$3452 289 2098 2099 319 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3454 r0 *1 41.44,115.92
X$3454 2099 290 2106 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3463 m0 *1 41.44,126
X$3463 2099 306 290 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3492 m0 *1 92.96,75.6
X$3492 2099 2098 292 293 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3496 r0 *1 87.36,95.76
X$3496 2099 2098 292 404 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $3500 m0 *1 89.6,95.76
X$3500 2099 2098 292 339 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3541 r0 *1 136.08,75.6
X$3541 2099 2098 305 294 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3553 r0 *1 166.32,85.68
X$3553 2098 322 361 2099 295 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3557 r0 *1 252,75.6
X$3557 2099 368 324 310 297 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3561 m0 *1 318.64,126
X$3561 371 2099 298 482 2098 533 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3563 m0 *1 270.48,115.92
X$3563 2099 451 298 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3565 r0 *1 316.4,126
X$3565 479 2099 298 524 2098 531 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3581 r0 *1 325.92,126
X$3581 2098 479 2099 524 525 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3583 m0 *1 310.8,126
X$3583 2098 371 2099 482 499 298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3591 r0 *1 118.72,176.4
X$3591 602 787 688 300 2099 2098 818 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3604 m0 *1 112,186.48
X$3604 2099 2098 692 806 300 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3606 r0 *1 132.72,136.08
X$3606 2099 2098 382 546 300 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3612 m0 *1 172.48,146.16
X$3612 2099 604 620 570 302 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3623 m0 *1 150.08,126
X$3623 2099 305 476 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3625 m0 *1 69.44,126
X$3625 2099 305 603 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3628 m0 *1 37.52,95.76
X$3628 2099 362 305 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3633 m0 *1 104.72,95.76
X$3633 2099 305 326 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $3636 m0 *1 72.8,115.92
X$3636 2099 2098 305 338 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3650 m0 *1 117.6,398.16
X$3650 2099 306 1659 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3654 r0 *1 188.72,337.68
X$3654 2099 306 1212 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3657 r0 *1 58.8,277.2
X$3657 2099 306 1003 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3661 r0 *1 140,206.64
X$3661 2099 306 658 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3663 m0 *1 133.84,216.72
X$3663 2099 973 306 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3674 m0 *1 290.08,196.56
X$3674 307 2098 2099 675 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $3677 m0 *1 192.64,186.48
X$3677 2099 2098 307 740 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3679 m0 *1 241.36,196.56
X$3679 307 2098 2099 887 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $3681 r0 *1 222.32,186.48
X$3681 2099 2098 307 850 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3684 r0 *1 273.84,186.48
X$3684 2099 2098 307 833 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3689 r0 *1 281.68,186.48
X$3689 2099 2098 307 863 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $3691 m0 *1 278.88,186.48
X$3691 307 2098 2099 667 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $3707 r0 *1 148.96,105.84
X$3707 2099 445 439 431 308 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3711 m0 *1 176.96,95.76
X$3711 2098 363 344 2099 309 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3731 r0 *1 103.04,105.84
X$3731 2099 429 314 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $3743 m0 *1 151.76,95.76
X$3743 2099 521 342 322 360 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3747 r0 *1 118.16,105.84
X$3747 2099 417 443 381 430 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3750 m0 *1 117.6,105.84
X$3750 2099 405 414 427 321 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3754 r0 *1 251.44,95.76
X$3754 2099 725 411 327 346 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3756 m0 *1 244.16,95.76
X$3756 2099 377 358 347 359 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3758 m0 *1 250.88,85.68
X$3758 2099 325 355 328 335 314 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3760 r0 *1 217.28,115.92
X$3760 2099 449 474 408 385 314 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3763 m0 *1 217.28,146.16
X$3763 2099 623 650 578 315 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3795 r0 *1 249.2,206.64
X$3795 2098 916 2099 930 325 918 941 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3808 m0 *1 99.68,115.92
X$3808 2099 464 462 400 438 429 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3810 m0 *1 95.2,105.84
X$3810 2099 415 395 402 340 429 326 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3826 m0 *1 271.6,95.76
X$3826 2098 327 376 2099 375 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3836 m0 *1 281.12,95.76
X$3836 2098 369 375 2099 329 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3839 r0 *1 274.4,95.76
X$3839 387 388 389 330 2099 2098 376 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3845 m0 *1 305.2,95.76
X$3845 371 2098 390 349 2099 330 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3849 m0 *1 297.36,95.76
X$3849 2098 369 348 2099 331 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3869 r0 *1 175.84,85.68
X$3869 2098 337 344 2099 361 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3880 r0 *1 78.4,136.08
X$3880 2099 544 513 564 512 429 338 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3882 r0 *1 56,136.08
X$3882 2099 566 601 534 352 429 338 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3939 m0 *1 159.04,105.84
X$3939 2099 2098 404 341 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3957 m0 *1 167.44,136.08
X$3957 2099 549 569 561 343 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $3967 r0 *1 224.56,95.76
X$3967 2099 2098 345 367 397 396 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3971 m0 *1 287.84,95.76
X$3971 2098 347 370 2099 348 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $3982 m0 *1 413.28,95.76
X$3982 371 2098 2099 350 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3986 r0 *1 64.4,176.4
X$3986 2099 955 826 803 351 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4004 m0 *1 334.32,408.24
X$4004 2099 353 1760 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4006 r0 *1 407.12,297.36
X$4006 2099 353 985 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4009 m0 *1 299.6,246.96
X$4009 2099 973 353 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4012 r0 *1 301.28,226.8
X$4012 2099 353 808 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4015 m0 *1 371.84,166.32
X$4015 2099 353 457 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4018 r0 *1 255.36,357.84
X$4018 2099 353 1214 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4021 r0 *1 301.28,246.96
X$4021 2099 353 2107 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $4041 m0 *1 152.32,115.92
X$4041 2099 2098 520 357 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4083 r0 *1 101.92,156.24
X$4083 2099 687 730 363 517 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4104 m0 *1 201.6,95.76
X$4104 2099 2098 366 365 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4115 m0 *1 248.64,206.64
X$4115 2098 917 2099 890 368 918 950 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4119 r0 *1 124.32,156.24
X$4119 2098 369 661 2099 707 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4122 r0 *1 117.6,236.88
X$4122 2098 369 1089 2099 1088 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4125 m0 *1 67.2,246.96
X$4125 2098 369 1115 2099 1116 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4128 m0 *1 76.72,246.96
X$4128 2098 369 1084 2099 1064 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4131 r0 *1 294.56,146.16
X$4131 2098 369 579 2099 649 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4134 r0 *1 281.68,115.92
X$4134 2098 369 487 2099 485 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4136 r0 *1 294,105.84
X$4136 2098 369 459 2099 409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4150 r0 *1 283.36,136.08
X$4150 2098 369 591 2099 576 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4152 r0 *1 285.04,95.76
X$4152 387 388 389 372 2099 2098 370 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4157 m0 *1 301.84,136.08
X$4157 2099 2098 371 590 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4172 r0 *1 306.88,105.84
X$4172 2098 371 390 2099 432 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4196 r0 *1 247.52,216.72
X$4196 2098 1001 2099 963 377 918 1002 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4211 r0 *1 157.36,115.92
X$4211 2098 380 465 2099 446 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4213 r0 *1 46.48,105.84
X$4213 2098 380 435 2099 434 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4215 m0 *1 10.64,166.32
X$4215 2098 380 728 2099 711 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4217 m0 *1 19.04,126
X$4217 2098 380 466 2099 489 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4219 m0 *1 2.24,115.92
X$4219 2098 380 456 2099 422 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4221 r0 *1 140.56,105.84
X$4221 2098 380 418 2099 407 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4223 r0 *1 60.48,105.84
X$4223 2098 380 436 2099 437 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4225 r0 *1 19.04,166.32
X$4225 2098 380 750 2099 751 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4243 r0 *1 17.36,95.76
X$4243 2098 380 410 2099 392 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4246 m0 *1 3.92,136.08
X$4246 2098 380 557 2099 539 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4248 m0 *1 36.96,105.84
X$4248 2099 2098 425 381 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4251 m0 *1 40.32,105.84
X$4251 2098 381 403 2099 435 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4272 r0 *1 216.72,156.24
X$4272 662 688 690 433 2099 2098 384 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4280 r0 *1 239.68,115.92
X$4280 2099 386 2098 450 507 537 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4282 m0 *1 252.56,146.16
X$4282 2099 386 2098 606 605 573 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4284 m0 *1 246.96,156.24
X$4284 2099 386 2098 706 621 665 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4286 m0 *1 324.24,136.08
X$4286 2099 386 2098 530 531 525 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4288 r0 *1 306.88,126
X$4288 2099 386 2098 481 533 499 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4290 r0 *1 253.68,126
X$4290 2099 386 2098 506 505 504 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4314 m0 *1 132.72,297.36
X$4314 2099 2098 1402 386 1423 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4316 r0 *1 121.52,246.96
X$4316 2099 2098 1151 386 1149 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4318 r0 *1 329.28,246.96
X$4318 2099 2098 1150 386 1167 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4320 m0 *1 124.88,337.68
X$4320 2099 2098 1676 386 1677 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4322 r0 *1 285.04,105.84
X$4322 387 388 389 432 2099 2098 452 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4326 m0 *1 189.84,136.08
X$4326 387 2098 388 496 2099 594 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4330 m0 *1 89.6,146.16
X$4330 2098 387 388 2099 628 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4332 r0 *1 73.36,126
X$4332 488 510 387 511 2099 2098 535 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4334 m0 *1 285.04,136.08
X$4334 387 388 389 551 2099 2098 577 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4337 m0 *1 272.72,136.08
X$4337 453 387 388 389 2099 2098 575 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4350 m0 *1 110.32,126
X$4350 492 398 388 469 2099 2098 486 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4353 r0 *1 90.16,126
X$4353 510 492 398 388 2099 2098 514 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4358 r0 *1 192.64,115.92
X$4358 2099 388 389 470 448 451 2098 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $4371 r0 *1 73.36,115.92
X$4371 2099 511 388 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $4389 m0 *1 303.52,126
X$4389 479 498 453 480 2099 2098 390 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4402 m0 *1 33.6,105.84
X$4402 2099 2098 394 402 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4405 r0 *1 19.6,115.92
X$4405 399 394 425 424 2099 2098 467 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4407 m0 *1 10.64,105.84
X$4407 394 425 424 398 2099 2098 423 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4414 m0 *1 2.24,105.84
X$4414 394 2098 2099 421 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4430 m0 *1 40.32,115.92
X$4430 2098 424 398 2099 403 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4434 r0 *1 36.4,136.08
X$4434 398 565 540 541 2099 2098 586 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4436 m0 *1 35.84,156.24
X$4436 398 2098 565 540 2099 703 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4452 r0 *1 12.32,126
X$4452 2098 398 565 2099 508 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4454 r0 *1 22.4,146.16
X$4454 398 2098 565 641 2099 627 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4457 m0 *1 17.92,105.84
X$4457 2099 2098 399 400 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4461 m0 *1 16.8,115.92
X$4461 399 2098 2099 420 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4465 m0 *1 7.28,115.92
X$4465 2098 400 423 2099 456 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4471 r0 *1 21.28,105.84
X$4471 425 2098 424 426 2099 401 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4473 m0 *1 22.4,105.84
X$4473 2098 402 401 2099 410 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4483 r0 *1 159.6,136.08
X$4483 2099 2098 404 473 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4485 m0 *1 65.52,146.16
X$4485 2099 601 602 2098 520 404 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4488 r0 *1 71.68,146.16
X$4488 2099 2098 404 660 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4497 m0 *1 78.4,136.08
X$4497 2099 513 567 2098 520 404 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4500 r0 *1 123.2,297.36
X$4500 2098 1465 2099 1453 405 918 1432 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4502 r0 *1 151.2,186.48
X$4502 406 692 690 831 2099 2098 830 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4506 r0 *1 206.64,156.24
X$4506 2099 2098 662 406 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4508 m0 *1 121.52,206.64
X$4508 602 2098 406 692 2099 948 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4511 r0 *1 129.92,186.48
X$4511 406 2098 692 690 2099 858 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4513 r0 *1 178.08,176.4
X$4513 406 692 690 773 2099 2098 800 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4516 r0 *1 215.04,186.48
X$4516 406 692 690 743 2099 2098 832 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4519 r0 *1 231.28,186.48
X$4519 406 692 690 807 2099 2098 852 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4522 r0 *1 238.56,176.4
X$4522 406 692 690 790 2099 2098 802 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4540 m0 *1 287.84,115.92
X$4540 2098 408 452 2099 459 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4566 r0 *1 139.44,297.36
X$4566 2098 1467 2099 1424 415 918 1433 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4576 m0 *1 125.44,287.28
X$4576 2098 1366 2099 1368 417 918 1367 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4591 r0 *1 10.64,115.92
X$4591 425 2098 2099 419 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4604 m0 *1 69.44,105.84
X$4604 2099 2098 424 427 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4614 r0 *1 2.24,115.92
X$4614 424 2098 2099 440 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4635 m0 *1 24.08,126
X$4635 2098 426 467 2099 490 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4637 r0 *1 28.56,146.16
X$4637 563 2098 426 565 2099 682 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4640 r0 *1 35.28,146.16
X$4640 599 426 565 540 2099 2098 655 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4643 m0 *1 22.96,156.24
X$4643 653 426 565 641 2099 2098 654 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4653 r0 *1 65.52,105.84
X$4653 2098 427 426 2099 436 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4662 m0 *1 101.92,146.16
X$4662 2099 619 678 516 428 568 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4667 r0 *1 107.52,226.8
X$4667 429 2098 2099 1007 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $4669 r0 *1 103.04,146.16
X$4669 2099 429 568 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $4671 r0 *1 67.76,226.8
X$4671 2099 2098 429 1034 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $4676 m0 *1 78.4,206.64
X$4676 2099 429 714 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $4678 m0 *1 101.36,216.72
X$4678 2099 2098 429 915 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $4681 m0 *1 43.12,216.72
X$4681 2099 952 429 2098 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $4706 m0 *1 163.52,115.92
X$4706 2098 431 463 2099 465 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4721 r0 *1 221.2,166.32
X$4721 743 745 744 760 2099 2098 433 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4752 m0 *1 62.16,166.32
X$4752 2099 1158 713 684 441 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4755 m0 *1 77.84,186.48
X$4755 2099 855 848 542 442 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4759 m0 *1 145.04,136.08
X$4759 2099 548 559 518 444 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4764 r0 *1 153.44,257.04
X$4764 2098 1209 2099 1225 445 918 1200 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4780 r0 *1 197.12,226.8
X$4780 2098 1006 2099 1014 449 1009 1057 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4790 r0 *1 272.16,115.92
X$4790 2098 453 451 2099 487 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4796 m0 *1 268.24,146.16
X$4796 2099 2098 453 607 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4799 m0 *1 318.08,136.08
X$4799 2099 2098 498 524 453 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4812 m0 *1 411.04,115.92
X$4812 453 2098 2099 455 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4817 r0 *1 416.64,115.92
X$4817 479 2098 2099 454 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4846 r0 *1 378.56,166.32
X$4846 2099 2098 457 2110 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $4876 m0 *1 208.88,236.88
X$4876 2098 1069 2099 996 460 1009 1096 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4883 r0 *1 87.92,115.92
X$4883 2098 493 491 2099 461 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4894 r0 *1 108.08,307.44
X$4894 2098 1539 2099 1524 464 918 1498 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4905 m0 *1 21.84,136.08
X$4905 2098 564 490 2099 466 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4908 m0 *1 34.16,136.08
X$4908 509 467 540 541 2099 2098 511 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4911 r0 *1 24.64,136.08
X$4911 2098 509 467 2099 565 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4917 r0 *1 66.64,166.32
X$4917 2099 828 815 683 468 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4930 r0 *1 207.76,146.16
X$4930 2099 630 651 574 471 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $4935 m0 *1 210,146.16
X$4935 2099 622 634 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4937 r0 *1 210,136.08
X$4937 2099 595 572 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4939 r0 *1 200.48,146.16
X$4939 2099 663 638 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4946 m0 *1 226.8,156.24
X$4946 2099 651 666 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4948 r0 *1 230.16,146.16
X$4948 2099 650 529 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4963 r0 *1 192.64,146.16
X$4963 2099 620 580 2098 475 473 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $4968 r0 *1 161.28,126
X$4968 2099 2098 520 475 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5002 m0 *1 204.4,156.24
X$5002 2099 664 663 607 679 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5007 r0 *1 217.28,136.08
X$5007 2099 596 622 590 571 568 476 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5046 r0 *1 303.52,126
X$5046 2099 2098 479 523 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5060 m0 *1 310.8,136.08
X$5060 2099 2098 480 482 551 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5062 r0 *1 303.52,136.08
X$5062 2099 2098 480 578 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5070 m0 *1 426.16,126
X$5070 480 2098 2099 502 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5082 m0 *1 374.08,136.08
X$5082 2099 2098 483 554 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5084 r0 *1 366.8,136.08
X$5084 483 2098 610 558 2099 589 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5091 r0 *1 404.88,115.92
X$5091 483 2098 2099 484 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5100 m0 *1 118.16,126
X$5100 2098 518 486 2099 495 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5111 m0 *1 98.56,136.08
X$5111 2099 2098 488 516 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5119 m0 *1 2.24,126
X$5119 488 2098 2099 598 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5127 r0 *1 80.64,126
X$5127 2098 515 535 2099 491 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5131 m0 *1 56,136.08
X$5131 2099 2098 492 542 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5142 m0 *1 19.04,146.16
X$5142 492 2098 2099 562 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5145 r0 *1 137.76,136.08
X$5145 2098 493 547 2099 519 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5148 r0 *1 179.76,136.08
X$5148 2098 493 592 2099 593 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5151 r0 *1 122.64,126
X$5151 2098 493 495 2099 536 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5154 r0 *1 45.36,126
X$5154 2098 493 588 2099 532 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5157 r0 *1 101.92,126
X$5157 2098 493 543 2099 503 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5159 r0 *1 51.52,146.16
X$5159 2098 493 676 2099 644 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5173 r0 *1 90.16,156.24
X$5173 2098 493 729 2099 704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5175 r0 *1 44.8,166.32
X$5175 2098 493 764 2099 755 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5177 r0 *1 45.36,156.24
X$5177 2098 493 686 2099 685 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5179 r0 *1 103.04,136.08
X$5179 2099 545 659 515 494 568 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5202 r0 *1 235.2,166.32
X$5202 2099 2098 723 497 689 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5207 m0 *1 281.12,146.16
X$5207 2099 2098 498 574 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5216 m0 *1 413.28,126
X$5216 498 2098 2099 501 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5222 m0 *1 366.24,136.08
X$5222 553 611 500 527 2099 2098 558 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5224 m0 *1 361.76,146.16
X$5224 2099 2098 500 609 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5226 m0 *1 367.92,146.16
X$5226 553 611 500 610 2099 2098 618 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5235 m0 *1 407.12,136.08
X$5235 500 2098 2099 556 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5260 m0 *1 10.64,136.08
X$5260 2098 534 508 2099 557 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5264 r0 *1 30.24,136.08
X$5264 2099 2098 509 564 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5270 r0 *1 3.92,126
X$5270 509 2098 2099 538 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5278 r0 *1 97.44,156.24
X$5278 2099 2098 510 715 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5289 r0 *1 2.24,146.16
X$5289 510 2098 2099 624 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5302 m0 *1 89.04,136.08
X$5302 2098 516 514 2099 543 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5330 m0 *1 77.84,156.24
X$5330 2099 2098 520 657 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5341 r0 *1 3.36,156.24
X$5341 652 2098 2099 520 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $5346 m0 *1 156.8,287.28
X$5346 2098 1369 2099 1386 521 918 1370 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5361 m0 *1 305.2,136.08
X$5361 2099 2098 551 523 524 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5376 m0 *1 378,146.16
X$5376 2099 2098 527 612 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5379 r0 *1 365.12,146.16
X$5379 527 632 646 618 2099 2098 582 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5385 r0 *1 407.12,126
X$5385 527 2098 2099 528 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5391 m0 *1 236.88,166.32
X$5391 529 723 689 691 2099 2098 738 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5393 r0 *1 271.04,156.24
X$5393 529 2099 705 2098 693 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5402 m0 *1 426.72,136.08
X$5402 529 2098 2099 640 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5405 m0 *1 230.72,166.32
X$5405 2098 529 634 2099 760 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5430 r0 *1 21.28,136.08
X$5430 2099 2098 563 534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5448 m0 *1 28,166.32
X$5448 754 653 712 563 2099 2098 540 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5453 m0 *1 34.72,146.16
X$5453 2098 600 599 2099 541 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5458 r0 *1 43.68,136.08
X$5458 2098 542 586 2099 588 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5467 m0 *1 96.88,327.6
X$5467 2098 1591 2099 1600 544 1559 1538 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5475 r0 *1 105.84,267.12
X$5475 2099 1283 1421 1249 545 1294 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $5483 m0 *1 149.52,277.2
X$5483 2099 1315 1319 1287 548 1009 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $5487 m0 *1 169.12,277.2
X$5487 2099 1159 1404 1335 549 1009 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $5503 r0 *1 357.28,136.08
X$5503 2098 609 581 2099 552 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5505 m0 *1 356.72,156.24
X$5505 2098 553 610 2099 669 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5508 r0 *1 353.36,156.24
X$5508 2099 2098 553 695 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5517 m0 *1 415.52,136.08
X$5517 553 2098 2099 615 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5522 r0 *1 365.12,196.56
X$5522 2099 905 2098 930 872 891 873 554 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5524 r0 *1 372.96,136.08
X$5524 2098 554 582 2099 587 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5544 m0 *1 215.04,246.96
X$5544 2098 1108 2099 1028 560 1009 1131 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5554 m0 *1 19.6,166.32
X$5554 2098 712 563 2099 641 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5564 m0 *1 10.64,156.24
X$5564 563 2098 2099 680 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5589 m0 *1 66.08,327.6
X$5589 2098 1612 2099 1598 566 1559 1536 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5599 r0 *1 119.84,146.16
X$5599 567 2099 648 2098 661 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5608 m0 *1 2.24,146.16
X$5608 567 2098 2099 625 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5634 r0 *1 184.8,136.08
X$5634 2098 570 594 2099 592 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5641 m0 *1 222.88,166.32
X$5641 580 638 666 572 2099 2098 744 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5643 m0 *1 244.72,186.48
X$5643 572 2099 851 2098 853 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5652 r0 *1 414.96,136.08
X$5652 572 2098 2099 584 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5662 r0 *1 273.84,136.08
X$5662 2098 574 575 2099 591 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5671 r0 *1 288.4,136.08
X$5671 2098 578 577 2099 579 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5682 m0 *1 225.12,176.4
X$5682 580 638 743 745 2099 2098 807 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5685 r0 *1 257.04,176.4
X$5685 580 2099 802 2098 801 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5687 m0 *1 236.88,176.4
X$5687 580 723 689 790 2099 2098 759 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5699 r0 *1 406.56,136.08
X$5699 580 2098 2099 673 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5703 r0 *1 353.92,146.16
X$5703 611 632 646 669 2099 2098 581 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5708 r0 *1 390.32,216.72
X$5708 583 892 983 779 2099 2098 968 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5710 r0 *1 401.52,156.24
X$5710 583 2099 698 2098 702 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5713 r0 *1 385.84,196.56
X$5713 583 842 874 898 2099 2098 814 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5723 r0 *1 430.08,136.08
X$5723 583 2098 2099 585 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5725 r0 *1 337.68,216.72
X$5725 1027 2098 2099 583 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $5727 r0 *1 386.96,206.64
X$5727 2098 583 842 2099 921 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5745 r0 *1 361.76,166.32
X$5745 643 632 775 589 2099 2098 756 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5747 m0 *1 362.32,166.32
X$5747 694 2098 646 589 2099 732 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5776 r0 *1 212.24,226.8
X$5776 2098 1008 2099 999 596 1009 1010 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5781 m0 *1 10.64,146.16
X$5781 599 2098 2099 597 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5786 r0 *1 54.88,156.24
X$5786 2099 2098 599 684 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5798 r0 *1 56.56,146.16
X$5798 2099 2098 600 656 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5805 r0 *1 10.64,146.16
X$5805 600 2098 2099 626 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5813 r0 *1 109.2,186.48
X$5813 2098 602 806 2099 857 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5815 r0 *1 118.72,186.48
X$5815 824 787 602 2099 2098 690 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $5826 m0 *1 23.52,196.56
X$5826 602 2098 2099 879 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5832 r0 *1 64.96,156.24
X$5832 2099 767 805 656 677 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5835 m0 *1 57.12,176.4
X$5835 2099 766 804 763 765 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5840 m0 *1 81.76,176.4
X$5840 2099 769 788 715 768 714 603 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $5851 m0 *1 174.72,257.04
X$5851 2098 1180 2099 1195 604 1009 1181 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5863 m0 *1 344.4,156.24
X$5863 694 2098 646 669 2099 608 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5866 m0 *1 342.16,146.16
X$5866 2098 647 608 2099 668 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5868 r0 *1 357.84,216.72
X$5868 2099 1300 2098 996 964 982 991 609 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5872 r0 *1 351.12,186.48
X$5872 866 868 699 837 2099 2098 610 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5880 m0 *1 355.6,166.32
X$5880 632 2098 646 610 2099 733 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5884 r0 *1 361.2,146.16
X$5884 2099 2098 611 647 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5893 m0 *1 400.96,146.16
X$5893 611 2098 2099 614 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5897 r0 *1 375.76,146.16
X$5897 2098 612 633 2099 645 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5899 r0 *1 369.6,216.72
X$5899 2099 1026 2098 963 994 891 967 612 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5903 m0 *1 421.68,146.16
X$5903 643 2098 2099 613 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5909 m0 *1 391.44,146.16
X$5909 634 2098 2099 616 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5920 m0 *1 365.68,156.24
X$5920 694 2098 646 618 2099 633 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5924 m0 *1 89.6,277.2
X$5924 2099 1284 1328 1316 619 1294 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $5939 r0 *1 215.6,236.88
X$5939 2098 1119 2099 1085 623 1009 1070 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5951 r0 *1 24.08,166.32
X$5951 2098 763 627 2099 750 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5953 m0 *1 89.6,166.32
X$5953 2098 715 628 2099 729 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5958 m0 *1 213.36,257.04
X$5958 2098 1183 2099 1071 630 1009 1184 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $5964 m0 *1 338.8,156.24
X$5964 2098 667 668 2099 631 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5968 r0 *1 294,257.04
X$5968 1045 2098 1056 632 2099 1218 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5973 m0 *1 325.36,186.48
X$5973 632 2098 646 811 2099 834 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5976 r0 *1 320.88,186.48
X$5976 2098 632 646 2099 865 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5978 r0 *1 292.88,226.8
X$5978 900 1056 632 1032 2099 2098 1054 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5992 r0 *1 281.68,257.04
X$5992 1134 1073 1241 1217 2099 2098 632 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $5998 m0 *1 244.72,166.32
X$5998 634 2099 738 2098 724 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6010 r0 *1 397.6,146.16
X$6010 636 2099 635 2098 637 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6012 m0 *1 392.56,176.4
X$6012 780 781 779 814 2099 2098 635 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6015 m0 *1 392.56,196.56
X$6015 2098 636 814 2099 894 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6017 m0 *1 393.12,186.48
X$6017 636 2098 748 814 2099 817 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6020 m0 *1 385.84,186.48
X$6020 636 748 793 814 2099 2098 813 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6031 m0 *1 430.08,146.16
X$6031 636 2098 2099 674 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6035 m0 *1 364,216.72
X$6035 964 2098 2099 636 942 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6037 r0 *1 407.12,146.16
X$6037 2098 675 637 2099 642 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6040 r0 *1 272.16,166.32
X$6040 638 2099 759 2098 758 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6051 m0 *1 409.36,146.16
X$6051 638 2098 2099 639 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6071 m0 *1 370.16,176.4
X$6071 2099 2098 643 777 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6089 m0 *1 328.72,196.56
X$6089 866 2098 694 646 2099 906 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6091 m0 *1 337.68,186.48
X$6091 699 694 646 811 2099 2098 835 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6116 m0 *1 323.68,176.4
X$6116 2099 2098 775 646 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $6120 m0 *1 358.4,226.8
X$6120 2099 1301 2098 1014 965 982 972 647 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $6145 m0 *1 30.24,176.4
X$6145 2099 2098 653 763 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6155 m0 *1 2.24,156.24
X$6155 653 2098 2099 681 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6163 m0 *1 38.08,176.4
X$6163 2098 803 654 2099 764 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6168 m0 *1 52.08,156.24
X$6168 2098 656 655 2099 676 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6190 r0 *1 59.36,186.48
X$6190 2099 713 823 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6192 m0 *1 59.92,186.48
X$6192 2099 804 824 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6194 r0 *1 57.12,176.4
X$6194 2099 815 787 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6196 r0 *1 66.64,186.48
X$6196 2099 826 827 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6198 m0 *1 67.2,186.48
X$6198 2099 805 825 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6201 r0 *1 87.36,176.4
X$6201 2099 788 772 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6204 r0 *1 80.08,186.48
X$6204 2099 848 829 2098 657 660 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6296 r0 *1 230.16,156.24
X$6296 662 692 690 691 2099 2098 705 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6307 r0 *1 212.24,257.04
X$6307 2098 1227 2099 1196 664 1009 1211 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $6313 m0 *1 234.64,186.48
X$6313 666 723 689 807 2099 2098 851 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6316 r0 *1 238.56,186.48
X$6316 666 2099 852 2098 861 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6325 m0 *1 400.96,156.24
X$6325 666 2098 2099 672 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6330 m0 *1 331.52,186.48
X$6330 2098 667 810 2099 776 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6332 r0 *1 343.84,176.4
X$6332 2098 667 836 2099 812 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6334 r0 *1 305.2,216.72
X$6334 2098 667 978 2099 961 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6336 m0 *1 325.36,206.64
X$6336 2098 667 931 2099 932 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6338 m0 *1 338.8,166.32
X$6338 2098 667 734 2099 735 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6340 r0 *1 309.68,186.48
X$6340 2098 667 909 2099 864 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6342 m0 *1 316.96,226.8
X$6342 2098 667 1046 2099 979 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6344 r0 *1 281.12,226.8
X$6344 2098 667 1074 2099 1011 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6360 r0 *1 280.56,156.24
X$6360 2098 667 693 2099 736 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6374 r0 *1 394.24,166.32
X$6374 2099 2098 671 778 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6379 r0 *1 407.68,166.32
X$6379 671 2098 2099 726 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6388 r0 *1 411.6,156.24
X$6388 2098 675 702 2099 701 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6390 m0 *1 412.16,206.64
X$6390 2098 675 926 2099 925 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6392 r0 *1 408.24,216.72
X$6392 2098 675 984 2099 986 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6394 r0 *1 411.04,206.64
X$6394 2098 675 945 2099 943 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6397 r0 *1 399.28,166.32
X$6397 2098 675 746 2099 753 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6399 r0 *1 414.4,176.4
X$6399 2098 675 796 2099 795 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6401 r0 *1 412.72,196.56
X$6401 2098 675 901 2099 899 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6404 r0 *1 293.44,166.32
X$6404 2098 675 758 2099 757 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6417 m0 *1 413.28,186.48
X$6417 2098 675 847 2099 816 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6437 r0 *1 30.24,156.24
X$6437 2098 683 682 2099 728 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6442 m0 *1 24.64,166.32
X$6442 2099 2098 712 683 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6449 m0 *1 42,156.24
X$6449 2098 684 703 2099 686 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6459 m0 *1 109.2,277.2
X$6459 2099 1178 1364 1290 687 1294 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $6464 r0 *1 206.64,166.32
X$6464 2099 688 692 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $6470 r0 *1 145.04,186.48
X$6470 827 2098 723 689 2099 859 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6472 m0 *1 158.48,196.56
X$6472 825 723 689 831 2099 2098 883 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6475 m0 *1 175.28,196.56
X$6475 723 2098 689 860 2099 884 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6522 r0 *1 228.48,166.32
X$6522 743 2098 745 744 2099 691 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6552 r0 *1 286.16,236.88
X$6552 1056 2098 694 1075 2099 1092 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6554 r0 *1 294,236.88
X$6554 1056 2098 694 1032 2099 1033 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6573 m0 *1 281.68,257.04
X$6573 1134 1199 1073 1217 2099 2098 694 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6575 r0 *1 285.6,246.96
X$6575 2098 1056 694 2099 1152 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6577 r0 *1 346.08,216.72
X$6577 2099 1274 2098 999 997 982 970 695 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $6579 m0 *1 346.08,166.32
X$6579 2098 695 733 2099 734 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6585 r0 *1 369.04,166.32
X$6585 2098 778 756 2099 696 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6591 r0 *1 386.96,176.4
X$6591 2099 792 700 2098 698 813 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6594 r0 *1 380.8,176.4
X$6594 780 2098 781 779 2099 698 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6598 r0 *1 337.12,186.48
X$6598 2099 2098 699 867 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6605 r0 *1 417.76,156.24
X$6605 699 2098 2099 845 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6608 r0 *1 394.24,176.4
X$6608 700 2099 839 2098 746 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6611 r0 *1 363.44,186.48
X$6611 871 2098 2099 700 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6616 r0 *1 430.08,156.24
X$6616 700 2098 2099 727 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6654 m0 *1 2.24,166.32
X$6654 712 2098 2099 710 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6674 m0 *1 106.4,257.04
X$6674 2098 1035 714 2099 1178 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6696 m0 *1 67.76,317.52
X$6696 2098 714 1492 2099 1536 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6718 m0 *1 136.64,176.4
X$6718 2099 2098 789 717 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6720 r0 *1 141.68,166.32
X$6720 2098 717 771 2099 721 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6726 m0 *1 153.44,166.32
X$6726 2099 2098 718 720 721 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6744 r0 *1 162.4,166.32
X$6744 2098 740 761 2099 722 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6767 r0 *1 249.2,196.56
X$6767 2098 934 2099 888 725 918 933 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $6790 r0 *1 368.48,156.24
X$6790 2098 777 732 2099 731 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $6822 r0 *1 410.48,327.6
X$6822 2098 740 1613 2099 1643 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6826 r0 *1 398.72,317.52
X$6826 2098 740 1547 2099 1575 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6829 r0 *1 182.56,166.32
X$6829 2098 740 741 2099 742 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6834 r0 *1 376.32,246.96
X$6834 2098 740 1163 2099 1145 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6837 m0 *1 407.12,337.68
X$6837 2098 740 1646 2099 1645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6840 m0 *1 390.32,337.68
X$6840 2098 740 1640 2099 1641 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6842 m0 *1 406,257.04
X$6842 2098 740 1165 2099 1164 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6844 r0 *1 355.04,317.52
X$6844 2098 740 1577 2099 1576 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6860 r0 *1 399.28,337.68
X$6860 2098 740 1673 2099 1674 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6866 r0 *1 174.72,186.48
X$6866 2098 772 743 2099 860 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6880 r0 *1 228.48,176.4
X$6880 2098 743 745 2099 790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6882 r0 *1 158.48,186.48
X$6882 827 823 825 829 2099 2098 743 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6902 r0 *1 416.08,166.32
X$6902 752 2098 2099 747 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6906 m0 *1 402.08,186.48
X$6906 748 2099 849 2098 847 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $6908 r0 *1 369.6,206.64
X$6908 994 2098 2099 748 942 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6922 m0 *1 428.4,166.32
X$6922 748 2098 2099 794 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6926 r0 *1 424.48,166.32
X$6926 782 2098 2099 749 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6936 m0 *1 375.76,196.56
X$6936 2099 966 2098 890 903 891 752 778 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $6946 r0 *1 48.16,176.4
X$6946 2099 2098 754 803 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6954 r0 *1 12.32,176.4
X$6954 754 2098 2099 786 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6985 m0 *1 2.24,176.4
X$6985 772 2098 2099 762 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6999 m0 *1 71.12,307.44
X$6999 2098 1497 2099 1471 766 1294 1464 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7006 m0 *1 72.8,297.36
X$7006 2098 1431 2099 1451 767 1294 1449 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7011 m0 *1 81.2,287.28
X$7011 2099 1327 1623 1352 769 1294 2098 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $7017 r0 *1 109.2,176.4
X$7017 2098 856 785 2099 770 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7033 m0 *1 217.28,196.56
X$7033 772 2099 832 2098 907 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7054 m0 *1 332.08,398.16
X$7054 2098 774 1911 2099 1866 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7057 m0 *1 351.12,398.16
X$7057 2099 2098 1930 774 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7060 r0 *1 153.44,357.84
X$7060 2098 774 1756 2099 1700 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7062 r0 *1 350,297.36
X$7062 2098 774 1440 2099 1413 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7077 r0 *1 288.4,267.12
X$7077 1269 1288 1075 1271 2099 2098 775 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7088 m0 *1 364,196.56
X$7088 2099 920 2098 888 871 891 784 777 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $7098 m0 *1 392.56,206.64
X$7098 893 781 779 928 2099 2098 927 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7101 r0 *1 393.12,196.56
X$7101 893 781 779 894 2099 2098 849 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7103 r0 *1 392,206.64
X$7103 780 781 779 921 2099 2098 947 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7106 m0 *1 385.28,176.4
X$7106 780 781 779 817 2099 2098 797 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7108 r0 *1 389.2,186.48
X$7108 892 781 779 813 2099 2098 839 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7118 m0 *1 388.64,246.96
X$7118 1111 1113 1141 1112 2099 2098 779 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7124 m0 *1 353.36,246.96
X$7124 1110 2099 780 2098 1146 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7126 m0 *1 351.68,257.04
X$7126 2099 1168 1110 2098 1140 780 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7130 m0 *1 392.56,236.88
X$7130 1016 780 781 1048 2099 2098 1053 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7145 r0 *1 369.04,287.28
X$7145 1412 2098 1413 1415 2099 780 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7153 r0 *1 393.68,226.8
X$7153 893 781 1048 1024 2099 2098 1025 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $7155 m0 *1 390.32,226.8
X$7155 983 2098 2099 781 gf180mcu_fd_sc_mcu9t5v0__buf_2
* cell instance $7158 r0 *1 392.56,236.88
X$7158 893 2098 781 1048 2099 1078 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7178 m0 *1 356.16,196.56
X$7178 903 2098 2099 782 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7181 m0 *1 410.48,176.4
X$7181 793 2098 2099 783 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7186 m0 *1 401.52,176.4
X$7186 784 2098 2099 846 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7196 r0 *1 122.64,206.64
X$7196 787 2099 948 2098 946 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7207 m0 *1 19.04,216.72
X$7207 787 2098 2099 953 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7224 r0 *1 267.12,176.4
X$7224 2098 833 801 2099 791 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7229 r0 *1 301.28,176.4
X$7229 2099 2098 821 799 792 822 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7231 r0 *1 403.76,176.4
X$7231 793 2099 797 2098 796 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7235 r0 *1 371.28,186.48
X$7235 872 2098 2099 793 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7308 m0 *1 299.04,236.88
X$7308 2099 2098 808 2108 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7346 r0 *1 256.48,186.48
X$7346 2098 863 853 2099 809 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7350 r0 *1 326.48,186.48
X$7350 2098 867 834 2099 810 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7356 m0 *1 339.36,196.56
X$7356 2098 866 868 2099 811 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7385 m0 *1 118.72,186.48
X$7385 824 2099 818 2098 881 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7390 m0 *1 201.6,186.48
X$7390 2098 850 819 2099 820 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7408 m0 *1 147.28,196.56
X$7408 823 2099 859 2098 904 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7411 m0 *1 165.2,206.64
X$7411 2098 827 823 2099 831 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7421 r0 *1 2.24,196.56
X$7421 823 2098 2099 878 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7435 m0 *1 31.92,196.56
X$7435 824 2098 2099 880 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7447 r0 *1 153.44,196.56
X$7447 825 2099 830 2098 949 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7453 r0 *1 11.76,206.64
X$7453 825 2098 2099 954 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7459 m0 *1 126.56,196.56
X$7459 827 2099 858 2098 882 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7471 m0 *1 2.24,196.56
X$7471 827 2098 2099 854 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7477 r0 *1 70,317.52
X$7477 2098 1557 2099 1555 828 1294 1552 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7489 r0 *1 164.64,196.56
X$7489 829 2099 883 2098 936 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7493 m0 *1 27.44,216.72
X$7493 829 2098 2099 951 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7506 r0 *1 405.44,307.44
X$7506 2098 833 1515 2099 1517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7509 m0 *1 411.6,307.44
X$7509 2098 833 1479 2099 1482 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7513 m0 *1 411.04,267.12
X$7513 2098 833 1246 2099 1220 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7515 m0 *1 412.72,236.88
X$7515 2098 833 1082 2099 1051 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7517 m0 *1 414.4,277.2
X$7517 2098 833 1310 2099 1309 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7526 m0 *1 408.24,287.28
X$7526 2098 833 1350 2099 1349 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7528 r0 *1 410.48,307.44
X$7528 2098 833 1519 2099 1518 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7531 r0 *1 413.28,267.12
X$7531 2098 833 1282 2099 1281 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7533 r0 *1 413.28,226.8
X$7533 2098 833 1081 2099 1022 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7538 r0 *1 341.6,186.48
X$7538 2098 869 835 2099 836 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7543 r0 *1 358.4,186.48
X$7543 2099 2098 837 869 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7549 m0 *1 420,186.48
X$7549 837 2098 2099 844 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7552 r0 *1 348.88,327.6
X$7552 1614 2098 2099 1608 838 1374 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7555 m0 *1 339.36,267.12
X$7555 1138 2098 870 1238 2099 838 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $7557 r0 *1 352.24,257.04
X$7557 1222 2098 2099 1140 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7559 r0 *1 344.4,257.04
X$7559 1170 2098 2099 1110 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7563 r0 *1 347.2,317.52
X$7563 2099 2098 1339 838 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7575 m0 *1 353.36,327.6
X$7575 1568 2098 2099 1604 838 1374 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7578 m0 *1 348.32,307.44
X$7578 1523 2098 2099 1187 838 1374 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7580 r0 *1 342.72,287.28
X$7580 1381 2098 2099 1411 838 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7587 r0 *1 244.16,206.64
X$7587 2098 915 840 2099 941 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7601 r0 *1 413.28,186.48
X$7601 840 2098 2099 897 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7603 r0 *1 201.6,236.88
X$7603 840 2098 1107 1095 2099 1059 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7608 r0 *1 396.48,186.48
X$7608 873 2098 2099 841 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7614 r0 *1 399.28,206.64
X$7614 842 2099 968 2098 945 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7623 m0 *1 430.08,186.48
X$7623 842 2098 2099 843 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7627 m0 *1 346.64,226.8
X$7627 1086 2098 2099 842 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7647 r0 *1 385.84,347.76
X$7647 2098 850 1729 2099 1727 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7650 m0 *1 389.2,388.08
X$7650 2098 850 1871 2099 1870 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7652 r0 *1 350,267.12
X$7652 2098 850 1275 2099 1285 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7655 m0 *1 366.8,277.2
X$7655 2098 850 1314 2099 1302 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7657 m0 *1 391.44,367.92
X$7657 2098 850 1795 2099 1794 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7670 r0 *1 366.24,297.36
X$7670 2098 850 1484 2099 1441 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7672 r0 *1 352.24,246.96
X$7672 2098 850 1146 2099 1147 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7674 m0 *1 388.08,378
X$7674 2098 850 1817 2099 1844 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7676 r0 *1 390.32,357.84
X$7676 2098 850 1766 2099 1768 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7690 r0 *1 83.44,317.52
X$7690 2098 1558 2099 1554 855 1294 1429 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7693 m0 *1 44.8,317.52
X$7693 2098 856 1550 2099 1535 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7695 r0 *1 11.76,317.52
X$7695 2098 856 1548 2099 1556 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7697 r0 *1 101.92,287.28
X$7697 2098 856 1419 2099 1400 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7699 m0 *1 82.88,297.36
X$7699 2098 856 1397 2099 1398 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7703 r0 *1 42,297.36
X$7703 2098 856 1447 2099 1428 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7705 r0 *1 45.36,287.28
X$7705 2098 856 1361 2099 1380 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7707 m0 *1 16.8,317.52
X$7707 2098 856 1520 2099 1516 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7709 m0 *1 19.04,307.44
X$7709 2098 856 1324 2099 1481 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7724 r0 *1 45.36,307.44
X$7724 2098 856 1521 2099 1522 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7726 r0 *1 105.28,206.64
X$7726 2099 2098 935 856 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $7729 m0 *1 112.56,206.64
X$7729 2098 935 857 2099 924 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7740 m0 *1 247.52,196.56
X$7740 2098 887 861 2099 910 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7743 m0 *1 202.72,236.88
X$7743 862 2098 1041 1059 2099 1058 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7745 m0 *1 159.04,236.88
X$7745 862 2099 1040 2098 1093 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7747 m0 *1 243.6,206.64
X$7747 2098 915 862 2099 933 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7755 m0 *1 400.96,196.56
X$7755 862 2098 2099 922 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7758 r0 *1 283.92,337.68
X$7758 2098 863 1668 2099 1667 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7760 r0 *1 294,287.28
X$7760 2098 863 1422 2099 1409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7762 m0 *1 306.32,307.44
X$7762 2098 863 1477 2099 1513 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7766 r0 *1 306.32,327.6
X$7766 2098 863 1617 2099 1638 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7768 r0 *1 301.28,257.04
X$7768 2098 863 1248 2099 1197 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7771 m0 *1 274.96,347.76
X$7771 2098 863 1664 2099 1715 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7773 m0 *1 294.56,246.96
X$7773 2098 863 1109 2099 1117 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7796 m0 *1 271.6,297.36
X$7796 2098 863 1491 2099 1406 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7798 r0 *1 258.16,317.52
X$7798 2098 863 1567 2099 1585 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7804 r0 *1 316.4,196.56
X$7804 2098 889 865 2099 909 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $7807 m0 *1 334.88,196.56
X$7807 2099 2098 866 889 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7820 r0 *1 421.68,186.48
X$7820 866 2098 2099 877 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7827 m0 *1 334.88,226.8
X$7827 2099 980 2098 1028 1027 982 990 867 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $7832 r0 *1 340.48,196.56
X$7832 2099 2098 868 919 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7839 r0 *1 404.88,186.48
X$7839 868 2098 2099 875 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7846 m0 *1 351.12,236.88
X$7846 2099 1139 2098 1085 1086 982 1077 869 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $7868 m0 *1 343.84,287.28
X$7868 2099 2098 1374 870 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7870 r0 *1 361.76,206.64
X$7870 965 2098 2099 898 942 870 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7882 m0 *1 387.52,206.64
X$7882 2098 874 921 2099 928 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7886 m0 *1 402.64,206.64
X$7886 874 2099 947 2098 926 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $7893 m0 *1 347.76,216.72
X$7893 997 2098 2099 874 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $7895 r0 *1 430.08,186.48
X$7895 874 2098 2099 876 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7910 r0 *1 123.76,196.56
X$7910 2098 911 881 2099 902 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7913 m0 *1 131.04,206.64
X$7913 2098 911 882 2099 912 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7921 m0 *1 188.72,206.64
X$7921 2098 937 886 2099 885 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7925 r0 *1 226.24,277.2
X$7925 2098 887 1354 2099 1330 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7928 r0 *1 234.64,297.36
X$7928 2098 887 1459 2099 1461 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7930 r0 *1 226.8,327.6
X$7930 2098 887 1649 2099 1631 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7932 m0 *1 215.04,327.6
X$7932 2098 887 1584 2099 1618 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7934 m0 *1 213.36,307.44
X$7934 2098 887 1490 2099 1531 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7936 m0 *1 254.24,257.04
X$7936 2098 887 1171 2099 1132 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7938 m0 *1 252.56,267.12
X$7938 2098 887 1252 2099 1215 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7952 r0 *1 247.52,277.2
X$7952 2098 887 1356 2099 1355 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7954 m0 *1 225.68,267.12
X$7954 2098 887 1255 2099 1185 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7961 m0 *1 319.76,257.04
X$7961 2099 1194 1196 889 1224 1169 982 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $7972 r0 *1 212.8,287.28
X$7972 2099 1372 1368 1329 1733 1238 891 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $7975 m0 *1 344.96,317.52
X$7975 2099 1374 891 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $7977 r0 *1 223.44,267.12
X$7977 2099 1506 1225 1236 1267 1170 891 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $7992 m0 *1 220.08,327.6
X$7992 2099 1704 2098 1524 1568 891 1586 1565 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $7994 m0 *1 234.08,307.44
X$7994 2099 1507 2098 1453 1222 891 1530 1473 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $7997 m0 *1 218.96,307.44
X$7997 2099 1648 2098 1424 1523 891 1532 1472 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $8000 r0 *1 261.52,287.28
X$8000 2099 1388 2098 1386 1381 891 1387 1332 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $8006 m0 *1 379.12,327.6
X$8006 1605 892 1303 1606 2099 2098 1607 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8008 m0 *1 383.04,317.52
X$8008 1442 892 1303 1113 2099 2098 1551 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8012 m0 *1 382.48,216.72
X$8012 2099 2098 892 893 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8015 m0 *1 352.8,297.36
X$8015 1412 1411 1375 1413 2099 2098 892 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8024 m0 *1 392.56,287.28
X$8024 893 1111 1342 1345 2099 2098 1377 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8026 m0 *1 379.12,257.04
X$8026 2099 2098 1110 1193 893 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8031 m0 *1 387.52,277.2
X$8031 893 1111 1342 1304 2099 2098 1311 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8033 m0 *1 385.28,257.04
X$8033 2099 2098 893 1186 1111 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8045 r0 *1 393.68,287.28
X$8045 893 2098 1111 1342 2099 1446 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8047 r0 *1 388.08,317.52
X$8047 1604 2098 893 1303 2099 1572 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8053 r0 *1 239.12,206.64
X$8053 2098 915 895 2099 950 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8063 m0 *1 409.36,196.56
X$8063 895 2098 2099 896 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8072 r0 *1 403.2,196.56
X$8072 898 2099 927 2098 901 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $8080 m0 *1 430.08,196.56
X$8080 898 2098 2099 923 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8086 m0 *1 318.08,236.88
X$8086 1045 1031 900 962 2099 2098 1075 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8088 m0 *1 314.16,246.96
X$8088 2099 2098 900 1012 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8098 m0 *1 417.76,196.56
X$8098 900 2098 2099 944 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8112 m0 *1 148.4,216.72
X$8112 2098 957 904 2099 913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8117 r0 *1 365.12,347.76
X$8117 2099 1671 2098 905 1722 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8126 r0 *1 330.96,196.56
X$8126 2098 919 906 2099 931 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8129 m0 *1 226.8,196.56
X$8129 2098 940 907 2099 908 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8146 r0 *1 156.24,267.12
X$8146 2098 911 1235 2099 1266 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8148 m0 *1 162.4,246.96
X$8148 2098 911 1118 2099 1153 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8152 m0 *1 135.52,236.88
X$8152 2098 911 1090 2099 1067 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8154 m0 *1 132.16,327.6
X$8154 2098 911 1579 2099 1578 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8157 m0 *1 159.04,327.6
X$8157 2098 911 1628 2099 1596 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8174 r0 *1 140.56,317.52
X$8174 2098 911 1581 2099 1580 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8176 m0 *1 168.56,236.88
X$8176 2098 911 1093 2099 1055 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8178 r0 *1 169.68,257.04
X$8178 2098 911 1226 2099 1210 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8180 m0 *1 128.24,216.72
X$8180 935 2098 2099 911 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $8187 m0 *1 201.6,246.96
X$8187 2099 914 1043 2098 1041 1128 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8191 m0 *1 202.16,206.64
X$8191 2099 2098 938 929 914 939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8193 m0 *1 147.84,257.04
X$8193 2098 915 1121 2099 1200 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8195 m0 *1 120.4,287.28
X$8195 2098 915 1363 2099 1367 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8198 m0 *1 138.88,287.28
X$8198 2098 915 1065 2099 1370 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8201 m0 *1 99.12,317.52
X$8201 2098 915 1396 2099 1538 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8203 r0 *1 103.04,307.44
X$8203 2098 915 1493 2099 1498 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8209 m0 *1 142.24,307.44
X$8209 2098 915 1401 2099 1433 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8223 r0 *1 118.16,297.36
X$8223 2098 915 1362 2099 1432 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8232 r0 *1 186.48,297.36
X$8232 2099 1365 2098 916 1434 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8236 r0 *1 190.4,287.28
X$8236 2099 1365 2098 917 1405 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8265 m0 *1 154,307.44
X$8265 2099 1454 918 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8272 r0 *1 334.88,236.88
X$8272 2099 1076 2098 1071 1087 982 1083 919 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $8276 m0 *1 366.24,347.76
X$8276 2099 1671 2098 920 1752 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8330 r0 *1 193.76,297.36
X$8330 2099 1365 2098 934 1489 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8335 m0 *1 218.4,206.64
X$8335 2099 2098 935 940 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8340 m0 *1 143.36,226.8
X$8340 2099 2098 935 957 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8343 r0 *1 131.04,226.8
X$8343 2099 2098 935 1023 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8345 m0 *1 173.6,236.88
X$8345 2099 2098 935 1160 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8349 r0 *1 185.92,206.64
X$8349 2099 2098 935 937 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8352 m0 *1 179.2,216.72
X$8352 2099 2098 935 958 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8354 r0 *1 108.08,216.72
X$8354 935 2098 2099 976 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $8368 m0 *1 173.04,216.72
X$8368 2098 958 936 2099 974 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8371 r0 *1 336,367.92
X$8371 2098 937 1822 2099 1823 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8373 m0 *1 357.84,418.32
X$8373 2098 937 1981 2099 2014 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8376 r0 *1 378,408.24
X$8376 2098 937 1955 2099 1979 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8378 r0 *1 372.96,408.24
X$8378 2098 937 1957 2099 1978 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8380 r0 *1 367.92,408.24
X$8380 2098 937 1980 2099 1954 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8382 m0 *1 374.08,398.16
X$8382 2098 937 1900 2099 1913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8384 m0 *1 312.48,398.16
X$8384 2098 937 1902 2099 1916 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8386 r0 *1 291.76,378
X$8386 2098 937 1839 2099 1812 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8406 r0 *1 334.32,418.32
X$8406 2098 937 2017 2099 2011 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8417 m0 *1 244.72,408.24
X$8417 2098 940 1934 2099 1950 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8419 m0 *1 239.68,428.4
X$8419 2098 940 2027 2099 2028 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8422 m0 *1 250.32,378
X$8422 2098 940 1828 2099 1834 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8424 m0 *1 220.64,428.4
X$8424 2098 940 2034 2099 2026 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8427 r0 *1 266,408.24
X$8427 2098 940 1993 2099 1994 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8429 m0 *1 271.04,378
X$8429 2098 940 1827 2099 1811 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8431 r0 *1 295.12,418.32
X$8431 2098 940 1989 2099 2008 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8434 m0 *1 276.08,438.48
X$8434 2098 940 2031 2099 2038 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8452 r0 *1 309.68,428.4
X$8452 2098 940 2009 2099 2060 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8461 r0 *1 345.52,277.2
X$8461 2099 2098 1339 942 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8464 m0 *1 345.52,246.96
X$8464 1137 2098 2099 1016 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8466 m0 *1 349.44,277.2
X$8466 1299 2098 2099 1276 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8479 r0 *1 346.64,236.88
X$8479 1087 2098 2099 1015 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8481 r0 *1 344.4,246.96
X$8481 1169 2098 2099 1047 942 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8491 r0 *1 118.72,216.72
X$8491 2098 976 946 2099 956 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8506 m0 *1 151.2,226.8
X$8506 2098 1023 949 2099 995 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8521 m0 *1 72.8,317.52
X$8521 2098 1537 2099 1644 955 1294 1430 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $8528 m0 *1 75.04,378
X$8528 2098 957 1816 2099 1829 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8532 r0 *1 148.4,357.84
X$8532 2098 957 1753 2099 1738 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8534 r0 *1 58.8,347.76
X$8534 2098 957 1697 2099 1726 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8537 r0 *1 64.96,347.76
X$8537 2098 957 1728 2099 1725 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8540 m0 *1 110.88,367.92
X$8540 2098 957 1772 2099 1798 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8542 m0 *1 118.72,378
X$8542 2098 957 1820 2099 1847 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8544 r0 *1 83.44,367.92
X$8544 2098 957 1803 2099 1804 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8547 r0 *1 102.48,337.68
X$8547 2098 957 1730 2099 1658 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8549 m0 *1 89.6,347.76
X$8549 2098 957 1751 2099 1698 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8567 m0 *1 211.12,398.16
X$8567 2098 958 1904 2099 1918 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8569 r0 *1 233.52,388.08
X$8569 2098 958 1880 2099 1879 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8574 r0 *1 229.6,367.92
X$8574 2098 958 1809 2099 1826 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8576 r0 *1 221.2,357.84
X$8576 2098 958 1758 2099 1744 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8578 r0 *1 312.48,367.92
X$8578 2098 958 1825 2099 1788 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8580 r0 *1 314.16,357.84
X$8580 2098 958 1776 2099 1775 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8582 m0 *1 241.92,367.92
X$8582 2098 958 1786 2099 1802 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8585 m0 *1 208.88,388.08
X$8585 2098 958 1873 2099 1862 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8600 r0 *1 310.24,378
X$8600 2098 958 1890 2099 1852 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8603 r0 *1 184.8,226.8
X$8603 2099 2098 977 959 1042 998 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8605 r0 *1 230.16,226.8
X$8605 2099 2098 1030 1029 1058 960 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8611 r0 *1 329.28,226.8
X$8611 2099 2098 962 1013 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8619 m0 *1 426.16,216.72
X$8619 962 2098 2099 989 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8629 m0 *1 373.52,347.76
X$8629 2099 1671 2098 966 1693 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8633 r0 *1 397.6,216.72
X$8633 967 2098 2099 971 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8640 m0 *1 402.08,226.8
X$8640 969 2098 2099 993 gf180mcu_fd_sc_mcu9t5v0__dlya_2
* cell instance $8645 r0 *1 423.36,216.72
X$8645 970 2098 2099 1018 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8651 m0 *1 409.36,216.72
X$8651 972 2098 2099 987 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8657 r0 *1 224,216.72
X$8657 2099 1000 973 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8667 m0 *1 93.52,226.8
X$8667 2099 2098 975 1005 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8673 m0 *1 42.56,236.88
X$8673 2098 976 1080 2099 1063 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8675 m0 *1 26.88,246.96
X$8675 2098 976 1100 2099 1114 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8678 r0 *1 20.16,236.88
X$8678 2098 976 1205 2099 1062 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8680 r0 *1 44.24,246.96
X$8680 2098 976 1166 2099 1123 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8682 m0 *1 119.28,267.12
X$8682 2098 976 1253 2099 1254 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8686 m0 *1 112.56,267.12
X$8686 2098 976 1223 2099 1179 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8689 m0 *1 86.8,267.12
X$8689 2098 976 1233 2099 1251 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8692 r0 *1 42.56,267.12
X$8692 2098 976 1262 2099 1263 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8705 r0 *1 58.24,267.12
X$8705 2098 976 1264 2099 1265 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8711 m0 *1 302.4,226.8
X$8711 2098 1012 1033 2099 978 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8715 r0 *1 337.12,347.76
X$8715 2099 1691 2098 980 1719 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8724 r0 *1 327.04,267.12
X$8724 1318 2098 2099 1273 1272 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8726 r0 *1 334.88,267.12
X$8726 1286 2098 2099 1244 1272 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8728 m0 *1 337.68,277.2
X$8728 1317 2098 2099 1142 1272 981 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8730 m0 *1 336,287.28
X$8730 2099 2098 1374 981 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8746 r0 *1 320.88,287.28
X$8746 2099 1374 982 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $8749 r0 *1 311.36,277.2
X$8749 2099 1336 1335 1357 1383 1299 982 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $8751 m0 *1 315.28,277.2
X$8751 2099 1313 1287 1013 1690 1317 982 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $8753 r0 *1 320.88,257.04
X$8753 2099 1219 1195 1135 1514 1137 982 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $8774 r0 *1 395.36,267.12
X$8774 1344 1113 1277 983 2099 2098 1243 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8779 r0 *1 390.32,267.12
X$8779 2098 1244 1304 2099 983 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8783 r0 *1 400.96,226.8
X$8783 1015 2099 1025 2098 984 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $8837 r0 *1 413.28,216.72
X$8837 991 2098 2099 988 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8844 m0 *1 428.4,226.8
X$8844 990 2098 2099 1020 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8885 m0 *1 193.2,297.36
X$8885 2099 1365 2098 1001 1504 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8893 m0 *1 218.96,236.88
X$8893 2098 1007 1043 2099 1002 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8902 m0 *1 58.8,287.28
X$8902 2099 2098 1003 2100 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $8956 r0 *1 28,236.88
X$8956 1099 2098 2099 1004 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $8965 m0 *1 188.16,307.44
X$8965 2099 1365 2098 1006 1488 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8973 r0 *1 208.32,236.88
X$8973 2098 1007 1098 2099 1096 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8976 m0 *1 194.32,236.88
X$8976 2098 1007 1061 2099 1057 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8978 m0 *1 204.4,257.04
X$8978 2098 1007 1157 2099 1184 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8980 r0 *1 217.28,246.96
X$8980 2098 1007 1161 2099 1131 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8982 m0 *1 211.68,267.12
X$8982 2098 1007 1177 2099 1211 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8985 r0 *1 175.84,257.04
X$8985 2098 1007 1232 2099 1181 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8987 m0 *1 130.48,257.04
X$8987 2098 1007 1036 2099 1159 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9004 r0 *1 207.2,246.96
X$9004 2098 1007 1130 2099 1070 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9006 r0 *1 189.84,307.44
X$9006 2099 1502 2098 1008 1503 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9015 m0 *1 152.32,297.36
X$9015 2099 1454 1009 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $9046 r0 *1 301.28,267.12
X$9046 2099 1298 1249 1012 1420 1286 1297 2098 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $9054 m0 *1 308.56,236.88
X$9054 2098 1013 1054 2099 1046 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9065 r0 *1 384.16,236.88
X$9065 1142 1016 1047 1015 2099 2098 1112 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9075 r0 *1 430.08,236.88
X$9075 1015 2098 2099 1019 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9078 r0 *1 388.64,226.8
X$9078 2098 1016 1047 2099 1024 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9081 r0 *1 400.4,236.88
X$9081 1016 2099 1078 2098 1081 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9093 r0 *1 430.08,246.96
X$9093 1016 2098 2099 1050 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9098 m0 *1 430.08,246.96
X$9098 1047 2098 2099 1017 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9107 r0 *1 419.44,236.88
X$9107 1077 2098 2099 1021 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9115 m0 *1 85.12,418.32
X$9115 2098 1023 1938 2099 2012 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9117 m0 *1 127.12,418.32
X$9117 2098 1023 1971 2099 1997 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9120 r0 *1 95.76,418.32
X$9120 2098 1023 2013 2099 1995 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9123 r0 *1 114.24,418.32
X$9123 2098 1023 1969 2099 1996 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9126 m0 *1 148.96,418.32
X$9126 2098 1023 1984 2099 1998 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9130 m0 *1 150.64,378
X$9130 2098 1023 1821 2099 1848 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9133 r0 *1 85.68,388.08
X$9133 2098 1023 1888 2099 1878 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9136 m0 *1 135.52,388.08
X$9136 2098 1023 1857 2099 1858 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9138 r0 *1 101.92,388.08
X$9138 2098 1023 1889 2099 1855 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9160 r0 *1 363.44,337.68
X$9160 2099 1671 2098 1026 1672 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9177 m0 *1 309.12,267.12
X$9177 2099 2098 1031 1242 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9180 m0 *1 311.92,226.8
X$9180 2098 1045 1031 2099 1032 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9192 m0 *1 326.48,438.48
X$9192 1031 2098 2099 2090 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9203 m0 *1 62.16,307.44
X$9203 2098 1034 1360 2099 1464 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9205 r0 *1 70.56,307.44
X$9205 2098 1034 1496 2099 1552 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9207 m0 *1 67.76,297.36
X$9207 2098 1034 1379 2099 1430 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9209 m0 *1 74.48,287.28
X$9209 2098 1034 1122 2099 1327 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9212 m0 *1 62.72,297.36
X$9212 2098 1034 1325 2099 1449 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9214 r0 *1 76.72,267.12
X$9214 2098 1034 1175 2099 1284 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9216 m0 *1 78.96,277.2
X$9216 2098 1034 1231 2099 1315 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9230 r0 *1 62.16,297.36
X$9230 2098 1034 1261 2099 1448 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9232 r0 *1 67.2,297.36
X$9232 2098 1034 1102 2099 1429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9235 r0 *1 71.68,267.12
X$9235 2098 1034 1174 2099 1283 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9237 m0 *1 90.16,236.88
X$9237 1038 2099 2098 1035 1036 1052 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $9239 m0 *1 57.68,246.96
X$9239 1035 2099 1037 2098 1115 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9241 r0 *1 85.12,246.96
X$9241 1035 1036 1065 1121 2099 2098 1103 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9253 m0 *1 6.16,267.12
X$9253 1035 2098 2099 1172 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9256 m0 *1 95.76,246.96
X$9256 2099 1148 1065 1036 1035 2098 1037 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $9268 m0 *1 79.52,236.88
X$9268 2099 2098 1084 1052 1037 1036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9271 r0 *1 2.24,246.96
X$9271 1036 2098 2099 1120 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9275 m0 *1 104.16,236.88
X$9275 2099 2098 1038 1039 1037 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9286 r0 *1 101.92,236.88
X$9286 1065 2098 1121 1038 2099 1104 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9294 r0 *1 108.08,236.88
X$9294 2098 1065 1039 2099 1089 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9296 r0 *1 155.12,236.88
X$9296 1091 1125 1068 1059 2099 2098 1040 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9300 r0 *1 199.36,246.96
X$9300 1177 2098 1157 1041 2099 1154 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9303 m0 *1 187.04,236.88
X$9303 2098 1041 1107 2099 1042 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9306 r0 *1 113.12,257.04
X$9306 1177 2099 1041 2098 1253 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9316 r0 *1 84.56,257.04
X$9316 1105 2098 1207 1068 2099 1041 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9323 m0 *1 163.52,257.04
X$9323 1043 2099 1201 2098 1226 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9341 r0 *1 218.4,408.24
X$9341 1043 2098 2099 2056 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9343 m0 *1 288.4,317.52
X$9343 1509 1408 1544 1044 2099 2098 1271 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9346 m0 *1 291.2,246.96
X$9346 2099 2098 1044 1135 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9352 m0 *1 299.04,418.32
X$9352 1044 2098 2099 2022 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9355 m0 *1 294,257.04
X$9355 2099 2098 1045 1136 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9366 m0 *1 351.12,438.48
X$9366 1045 2098 2099 2091 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9378 m0 *1 400.96,236.88
X$9378 1047 2099 1053 2098 1082 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9391 r0 *1 388.64,246.96
X$9391 1142 1111 1113 1141 2099 2098 1048 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9395 r0 *1 409.92,236.88
X$9395 1083 2098 2099 1049 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9417 m0 *1 299.04,317.52
X$9417 1512 1239 1056 1545 2099 2098 1570 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9433 r0 *1 280.56,307.44
X$9433 1509 1269 1288 1511 2099 2098 1056 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9454 m0 *1 18.48,236.88
X$9454 1061 2098 2099 1060 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9458 m0 *1 152.32,246.96
X$9458 1061 2099 1126 2098 1118 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9495 r0 *1 10.64,287.28
X$9495 1065 2098 2099 1322 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9497 m0 *1 123.2,246.96
X$9497 1105 1125 1068 1066 2099 2098 1106 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9504 r0 *1 146.16,257.04
X$9504 1091 1125 1068 1208 2099 2098 1234 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9506 r0 *1 151.2,246.96
X$9506 1091 1125 1068 1127 2099 2098 1126 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9508 m0 *1 155.12,257.04
X$9508 1091 1125 1068 1128 2099 2098 1201 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9511 r0 *1 93.52,257.04
X$9511 1177 1124 1125 1068 2099 2098 1221 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9522 r0 *1 76.72,257.04
X$9522 1231 2098 1232 1176 2099 1068 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9525 r0 *1 199.92,287.28
X$9525 2099 1365 2098 1069 1564 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9540 m0 *1 268.8,246.96
X$9540 2099 2098 1072 1134 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9547 m0 *1 273.28,267.12
X$9547 2098 1134 1073 2099 1237 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9552 m0 *1 278.32,267.12
X$9552 1134 2098 1073 1241 2099 1239 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9558 r0 *1 278.32,267.12
X$9558 1134 2098 1199 1073 2099 1240 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9561 r0 *1 271.04,267.12
X$9561 1134 1199 1073 1269 2099 2098 1270 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9564 r0 *1 276.64,236.88
X$9564 2098 1135 1092 2099 1074 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9574 m0 *1 335.44,347.76
X$9574 2099 1691 2098 1076 1692 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9584 m0 *1 421.68,246.96
X$9584 1142 2098 2099 1079 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9588 r0 *1 32.48,236.88
X$9588 2098 1102 1101 2099 1080 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9629 r0 *1 126,236.88
X$9629 1098 2099 1106 2098 1090 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9633 m0 *1 34.16,307.44
X$9633 1492 1091 1260 1494 2099 2098 1495 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9638 r0 *1 33.04,267.12
X$9638 1261 1091 1260 1229 2099 2098 1312 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9640 r0 *1 82.32,297.36
X$9640 1362 2099 1091 2098 1397 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9644 r0 *1 35.84,297.36
X$9644 1493 2098 1091 1260 2099 1427 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9646 r0 *1 55.44,246.96
X$9646 2099 2098 1124 1091 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9648 r0 *1 27.44,287.28
X$9648 1360 1091 1260 1326 2099 2098 1378 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9664 r0 *1 114.8,287.28
X$9664 2099 1452 1362 2098 1363 1091 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $9686 m0 *1 14.56,246.96
X$9686 2099 1099 1097 2098 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $9697 m0 *1 11.76,257.04
X$9697 1098 2098 2099 1156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9704 m0 *1 21.28,257.04
X$9704 1122 2099 1191 2098 1100 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9706 m0 *1 34.16,246.96
X$9706 2099 2098 1105 1101 1125 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9713 m0 *1 33.04,267.12
X$9713 1102 1124 1229 1230 2099 2098 1191 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9717 r0 *1 64.4,257.04
X$9717 1102 1122 1175 1174 2099 2098 1176 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9725 r0 *1 26.32,257.04
X$9725 2098 1102 1122 2099 1206 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9727 r0 *1 27.44,297.36
X$9727 1102 2098 2099 1358 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9740 r0 *1 16.8,317.52
X$9740 2099 2098 1105 1574 1260 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9742 r0 *1 95.76,297.36
X$9742 2099 2098 1362 1399 1105 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9744 m0 *1 29.12,317.52
X$9744 1105 2098 1260 1494 2099 1534 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9747 m0 *1 25.2,267.12
X$9747 1105 1229 1230 1206 2099 2098 1245 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9752 m0 *1 61.6,267.12
X$9752 1105 2098 1125 1176 2099 1247 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9756 r0 *1 24.08,317.52
X$9756 1105 2098 1260 1326 2099 1549 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9776 r0 *1 23.52,277.2
X$9776 1105 2098 1260 1229 2099 1348 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9785 r0 *1 182.56,257.04
X$9785 1177 1157 1161 1130 2099 2098 1107 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9792 m0 *1 179.2,307.44
X$9792 2099 1502 2098 1108 1470 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9797 r0 *1 290.64,246.96
X$9797 2098 1136 1152 2099 1109 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9802 r0 *1 374.08,257.04
X$9802 1110 1140 1138 1187 2099 2098 1303 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9804 r0 *1 386.4,257.04
X$9804 1110 2098 1140 1138 2099 1111 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $9817 m0 *1 412.72,246.96
X$9817 1110 2098 2099 1143 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9830 m0 *1 372.4,317.52
X$9830 2099 2098 1344 1553 1113 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9832 m0 *1 391.44,307.44
X$9832 1442 1416 1344 1113 2099 2098 1483 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9834 m0 *1 391.44,297.36
X$9834 1376 1344 1113 1277 2099 2098 1443 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9836 r0 *1 389.76,277.2
X$9836 2098 1113 1141 2099 1342 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9838 r0 *1 395.36,277.2
X$9838 1344 1113 1277 1306 2099 2098 1351 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9854 m0 *1 371.84,327.6
X$9854 1604 1608 1605 1603 2099 2098 1113 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9877 m0 *1 184.24,317.52
X$9877 2099 1502 2098 1119 1540 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $9885 r0 *1 106.4,246.96
X$9885 1121 2099 1148 2098 1149 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9894 m0 *1 6.16,246.96
X$9894 1121 2098 2099 1155 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9914 m0 *1 10.64,277.2
X$9914 1122 2098 2099 1228 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9918 r0 *1 33.6,257.04
X$9918 1175 1124 1125 1206 2099 2098 1192 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9923 m0 *1 70,267.12
X$9923 1231 1124 1125 1176 2099 2098 1250 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9941 r0 *1 56,257.04
X$9941 2099 2098 1207 1125 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $9979 m0 *1 192.08,257.04
X$9979 2099 2098 1182 1162 1154 1129 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9982 m0 *1 148.96,267.12
X$9982 1130 2099 1234 2098 1235 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9991 r0 *1 5.04,277.2
X$9991 1130 2098 2099 1258 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10003 r0 *1 271.6,257.04
X$10003 1199 2099 2098 1216 1133 1198 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $10005 r0 *1 308,277.2
X$10005 2099 2098 1133 1357 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10007 m0 *1 284.48,267.12
X$10007 2098 1216 1133 2099 1241 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10009 m0 *1 265.44,257.04
X$10009 2099 2098 1171 1198 1237 1133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10022 r0 *1 314.72,428.4
X$10022 1133 2098 2099 2058 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10043 m0 *1 290.08,287.28
X$10043 2099 1373 1352 1136 1384 1382 1297 2098
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $10055 m0 *1 342.16,257.04
X$10055 1138 2099 1168 2098 1167 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10068 r0 *1 421.68,267.12
X$10068 1138 2098 2099 1189 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10071 m0 *1 351.68,347.76
X$10071 2099 1691 2098 1139 1773 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10074 m0 *1 369.6,257.04
X$10074 2098 1140 1193 2099 1163 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10089 r0 *1 404.88,246.96
X$10089 1140 2098 2099 1144 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10092 r0 *1 384.16,297.36
X$10092 1187 1442 1416 1478 2099 2098 1141 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10099 r0 *1 398.72,257.04
X$10099 1142 2099 1243 2098 1246 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10161 r0 *1 145.04,267.12
X$10161 1177 2098 1157 1161 2099 1208 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10166 r0 *1 102.48,257.04
X$10166 1157 2099 1221 2098 1223 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10178 m0 *1 19.04,277.2
X$10178 1157 2098 2099 1256 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10180 r0 *1 72.24,297.36
X$10180 2098 1463 2099 1450 1158 1294 1448 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $10187 r0 *1 196,398.16
X$10187 2098 1160 1897 2099 1923 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10189 r0 *1 174.16,347.76
X$10189 2098 1160 1680 2099 1731 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10191 r0 *1 174.16,378
X$10191 2098 1160 1851 2099 1860 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10194 r0 *1 190.96,367.92
X$10194 2098 1160 1783 2099 1784 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10196 m0 *1 193.2,347.76
X$10196 2098 1160 1630 2099 1687 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10198 r0 *1 172.48,287.28
X$10198 2098 1160 1389 2099 1425 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10200 m0 *1 191.52,317.52
X$10200 2098 1160 1541 2099 1582 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10203 m0 *1 190.4,418.32
X$10203 2098 1160 1947 2099 2001 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10205 r0 *1 178.08,418.32
X$10205 2098 1160 1946 2099 2000 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10208 r0 *1 171.36,418.32
X$10208 2098 1160 1999 2099 2016 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10241 r0 *1 19.04,267.12
X$10241 1161 2098 2099 1173 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10258 m0 *1 390.32,257.04
X$10258 2098 1187 1186 2099 1165 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10264 m0 *1 34.16,257.04
X$10264 1174 2099 1192 2098 1166 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10301 r0 *1 10.64,267.12
X$10301 1174 2098 2099 1202 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10303 m0 *1 15.12,267.12
X$10303 1175 2099 1245 2098 1205 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10316 r0 *1 2.24,267.12
X$10316 1175 2098 2099 1204 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10348 m0 *1 2.24,277.2
X$10348 1177 2098 2099 1203 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10355 m0 *1 168.56,307.44
X$10355 2099 1502 2098 1180 1469 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10362 m0 *1 176.96,317.52
X$10362 2099 1502 2098 1183 1740 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10390 r0 *1 427.28,257.04
X$10390 1187 2098 2099 1188 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10398 r0 *1 430.08,267.12
X$10398 1244 2098 2099 1190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10413 r0 *1 350.56,428.4
X$10413 1194 2098 2099 2094 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10468 r0 *1 31.36,277.2
X$10468 1260 1326 1293 1259 2099 2098 1207 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10478 r0 *1 150.64,287.28
X$10478 2099 1365 2098 1209 1385 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10500 r0 *1 188.72,327.6
X$10500 2099 1212 2102 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $10531 m0 *1 246.96,297.36
X$10531 1268 2098 1213 1240 2099 1460 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10533 r0 *1 248.64,307.44
X$10533 1268 2098 1213 1435 2099 1269 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10535 m0 *1 245.28,267.12
X$10535 2099 2098 1213 1236 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10541 r0 *1 259.28,428.4
X$10541 1213 2098 2099 2059 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10555 m0 *1 255.36,357.84
X$10555 2099 2098 1214 2109 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $10600 m0 *1 270.48,277.2
X$10600 2099 2098 1216 1295 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10611 m0 *1 286.16,408.24
X$10611 1216 2098 2099 1967 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10620 m0 *1 291.2,327.6
X$10620 1602 1410 1512 1569 2099 2098 1217 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10623 m0 *1 296.24,267.12
X$10623 2098 1242 1218 2099 1248 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10629 r0 *1 342.72,408.24
X$10629 1219 2098 2099 1982 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10645 r0 *1 326.48,347.76
X$10645 2099 1691 2098 1224 1849 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10656 r0 *1 170.24,307.44
X$10656 2099 1502 2098 1227 1527 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10670 m0 *1 30.8,277.2
X$10670 2098 1326 1293 2099 1229 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10677 r0 *1 27.44,267.12
X$10677 2098 1260 1259 2099 1230 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10679 m0 *1 49.84,267.12
X$10679 1231 2099 1247 2098 1264 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10691 m0 *1 34.72,287.28
X$10691 1231 2098 2099 1291 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10697 m0 *1 77.28,267.12
X$10697 1232 2099 1250 2098 1233 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10706 r0 *1 2.24,287.28
X$10706 1232 2098 2099 1292 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10715 m0 *1 233.52,267.12
X$10715 2098 1236 1289 2099 1255 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10726 m0 *1 261.52,267.12
X$10726 2098 1295 1237 2099 1252 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10735 m0 *1 223.44,317.52
X$10735 1331 1505 1239 1269 2099 2098 1542 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10738 m0 *1 243.6,317.52
X$10738 1239 2098 1269 1288 2099 1543 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10741 r0 *1 267.12,297.36
X$10741 1239 2098 1269 1437 2099 1436 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10744 r0 *1 278.88,297.36
X$10744 1239 2098 1437 1475 2099 1407 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10746 r0 *1 245.84,267.12
X$10746 2098 1268 1239 2099 1289 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10748 m0 *1 226.8,277.2
X$10748 2098 1239 1269 2099 1353 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10761 r0 *1 285.04,297.36
X$10761 1410 1240 1437 1475 2099 2098 1456 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10768 r0 *1 252.56,277.2
X$10768 2098 1332 1240 2099 1356 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $10777 m0 *1 292.88,277.2
X$10777 2099 1334 1316 1242 1296 1318 1297 2098
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $10786 m0 *1 400.96,267.12
X$10786 1244 2099 1311 2098 1282 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10842 m0 *1 19.04,297.36
X$10842 1325 2098 2099 1257 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10849 m0 *1 22.4,287.28
X$10849 2098 1261 1325 2099 1259 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10876 r0 *1 22.96,307.44
X$10876 1362 2098 1363 1401 2099 1260 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10881 r0 *1 13.44,277.2
X$10881 1261 2099 1348 2098 1324 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10892 r0 *1 2.24,297.36
X$10892 1261 2098 2099 1392 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10894 m0 *1 37.52,277.2
X$10894 1325 2099 1312 2098 1262 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $10905 r0 *1 221.76,347.76
X$10905 2099 1671 2098 1267 1712 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $10912 m0 *1 250.88,287.28
X$10912 2099 2098 1268 1332 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $10918 m0 *1 252,398.16
X$10918 1268 2098 2099 1909 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10930 m0 *1 283.36,317.52
X$10930 2098 1269 1511 2099 1475 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10947 r0 *1 229.6,297.36
X$10947 2098 1331 1270 2099 1458 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10949 r0 *1 276.64,327.6
X$10949 1509 2098 1270 1288 2099 1650 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10951 m0 *1 235.2,327.6
X$10951 1331 1505 1587 1270 2099 2098 1632 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10954 m0 *1 270.48,327.6
X$10954 1408 2098 1270 1437 2099 1601 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $10965 r0 *1 327.6,307.44
X$10965 1486 2098 2099 1442 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10967 m0 *1 321.44,307.44
X$10967 1525 2098 2099 1478 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10969 r0 *1 325.36,327.6
X$10969 1678 2098 2099 1603 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10971 r0 *1 336,307.44
X$10971 2099 2098 1339 1272 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10985 r0 *1 333.2,317.52
X$10985 1615 2098 2099 1343 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10987 m0 *1 328.16,287.28
X$10987 1382 2098 2099 1305 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10989 m0 *1 327.04,327.6
X$10989 1616 2098 2099 1416 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10992 r0 *1 323.68,297.36
X$10992 1487 2098 2099 1376 1272 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $10996 m0 *1 385.28,287.28
X$10996 1376 1343 1305 1273 2099 2098 1304 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $10998 m0 *1 404.32,277.2
X$10998 1273 2099 1351 2098 1310 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11007 m0 *1 430.08,287.28
X$11007 1273 2098 2099 1280 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11011 r0 *1 347.2,347.76
X$11011 2099 1691 2098 1274 1720 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11016 r0 *1 355.6,277.2
X$11016 2099 2098 1275 1341 1340 1276 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11019 m0 *1 353.36,287.28
X$11019 1375 2099 2098 1278 1276 1341 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $11021 r0 *1 362.88,287.28
X$11021 1278 2098 1276 1411 2099 1415 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11031 r0 *1 405.44,287.28
X$11031 1276 2098 2099 1279 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11039 r0 *1 391.44,297.36
X$11039 1442 2098 1416 1478 2099 1277 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11044 r0 *1 333.76,277.2
X$11044 1338 2098 2099 1339 1278 1337 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $11047 m0 *1 357.28,277.2
X$11047 1278 2099 1340 2098 1314 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11056 r0 *1 402.64,267.12
X$11056 1278 2098 2099 1346 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11097 r0 *1 236.32,337.68
X$11097 1331 1505 1587 1633 2099 2098 1288 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11105 m0 *1 280,327.6
X$11105 1509 2098 1602 1288 2099 1437 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $11115 r0 *1 263.76,277.2
X$11115 2099 1333 1290 1295 1703 1338 1297 2098
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $11122 m0 *1 28.56,287.28
X$11122 2098 1360 1379 2099 1293 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11147 m0 *1 105.28,317.52
X$11147 2099 1454 1294 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11155 r0 *1 292.88,347.76
X$11155 2099 1702 2098 1296 1748 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11176 m0 *1 268.24,337.68
X$11176 2099 1714 2098 1555 1678 1297 1666 1636
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11178 m0 *1 274.96,307.44
X$11178 2099 1508 2098 1450 1525 1297 1510 1457
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11180 m0 *1 294.56,307.44
X$11180 2099 1476 2098 1451 1487 1297 1526 1438
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11182 r0 *1 264.88,327.6
X$11182 2099 1713 2098 1644 1616 1297 1635 1663
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11184 m0 *1 298.48,327.6
X$11184 2099 1679 2098 1554 1615 1297 1637 1571
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11186 r0 *1 262.64,307.44
X$11186 2099 1746 2098 1471 1486 1297 1529 1474
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11189 m0 *1 313.6,287.28
X$11189 2099 1374 1297 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11194 r0 *1 323.12,428.4
X$11194 1298 2098 2099 2057 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11200 r0 *1 357.84,347.76
X$11200 2099 1691 2098 1300 1721 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11203 m0 *1 358.96,347.76
X$11203 2099 1691 2098 1301 1789 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11213 m0 *1 366.24,297.36
X$11213 1412 1413 1415 1303 2099 2098 1344 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11226 r0 *1 404.88,277.2
X$11226 1305 2099 1377 2098 1350 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11229 m0 *1 394.8,277.2
X$11229 2098 1305 1345 2099 1306 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11237 m0 *1 421.68,287.28
X$11237 1305 2098 2099 1308 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11244 m0 *1 413.28,287.28
X$11244 1376 2098 2099 1307 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11265 r0 *1 375.76,428.4
X$11265 1313 2098 2099 2092 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11290 r0 *1 147.28,307.44
X$11290 2099 1502 2098 1319 1627 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11295 m0 *1 27.44,297.36
X$11295 1379 2098 2099 1320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11298 m0 *1 2.24,297.36
X$11298 1363 2098 2099 1321 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11305 r0 *1 19.04,287.28
X$11305 1362 2098 2099 1323 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11323 m0 *1 21.84,317.52
X$11323 1493 1396 1492 1496 2099 2098 1326 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11336 m0 *1 106.96,327.6
X$11336 2099 1502 2098 1328 1592 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11339 m0 *1 221.2,287.28
X$11339 2099 2098 1331 1329 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11343 r0 *1 216.72,277.2
X$11343 2098 1329 1353 2099 1354 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11362 m0 *1 253.12,438.48
X$11362 1331 2098 2099 2085 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11375 r0 *1 271.04,408.24
X$11375 1333 2098 2099 1990 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11380 m0 *1 307.44,418.32
X$11380 1334 2098 2099 2021 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11387 r0 *1 323.12,408.24
X$11387 1336 2098 2099 1986 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11390 m0 *1 319.2,327.6
X$11390 2099 2098 1374 1337 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11412 m0 *1 245.28,327.6
X$11412 2099 1689 2098 1598 1546 1337 1599 1566
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11415 r0 *1 250.32,327.6
X$11415 2099 1734 2098 1600 1614 1337 1974 1634
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $11427 m0 *1 340.48,327.6
X$11427 1546 2098 2099 1605 1339 1374 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $11431 m0 *1 348.88,327.6
X$11431 2099 2098 1639 1339 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $11437 r0 *1 356.72,287.28
X$11437 2099 2098 1375 1414 1340 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11444 r0 *1 351.68,287.28
X$11444 2098 1412 1413 2099 1340 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11458 r0 *1 397.6,297.36
X$11458 1343 2099 1443 2098 1519 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11460 m0 *1 400.96,287.28
X$11460 2098 1376 1343 2099 1345 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11472 r0 *1 421.68,287.28
X$11472 1343 2098 2099 1347 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11481 m0 *1 400.96,327.6
X$11481 1604 2099 1344 2098 1613 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11485 m0 *1 380.8,337.68
X$11485 2099 2098 1344 1675 1606 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11550 m0 *1 10.64,297.36
X$11550 1395 2098 2099 1359 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11552 m0 *1 24.08,307.44
X$11552 1360 2099 1549 2098 1520 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11564 m0 *1 10.64,307.44
X$11564 1360 2098 2099 1426 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11569 r0 *1 34.72,287.28
X$11569 1379 2099 1378 2098 1361 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11589 m0 *1 92.4,297.36
X$11589 2098 1363 1399 2099 1419 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11603 m0 *1 114.8,327.6
X$11603 2099 1593 2098 1364 1454 1594 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11607 r0 *1 152.88,297.36
X$11607 2099 1365 2098 1369 1455 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11610 m0 *1 124.32,307.44
X$11610 2099 1365 2098 1465 1500 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11616 r0 *1 165.2,297.36
X$11616 2099 2098 1466 1365 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11620 r0 *1 124.32,287.28
X$11620 2099 1365 2098 1366 1499 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11650 m0 *1 144.48,297.36
X$11650 2099 2098 1454 1371 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11655 m0 *1 131.6,307.44
X$11655 2099 1466 2098 1467 1501 1371 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11679 r0 *1 214.48,418.32
X$11679 1372 2098 2099 2035 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11683 m0 *1 359.52,438.48
X$11683 1373 2098 2099 2051 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11708 m0 *1 348.88,337.68
X$11708 2099 1669 1374 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $11717 m0 *1 408.8,297.36
X$11717 1376 2099 1446 2098 1479 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11768 r0 *1 319.2,347.76
X$11768 2099 1691 2098 1383 1718 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11771 r0 *1 290.08,357.84
X$11771 2099 1702 2098 1384 1777 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11779 r0 *1 154.56,347.76
X$11779 2099 2098 1707 1385 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11782 r0 *1 145.04,347.76
X$11782 2098 1385 1708 2099 1753 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11792 r0 *1 265.44,418.32
X$11792 1387 2098 2099 2007 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11799 m0 *1 311.92,347.76
X$11799 2099 1671 2098 1388 1762 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11803 r0 *1 177.52,287.28
X$11803 2098 1405 1403 2099 1389 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11807 m0 *1 2.24,327.6
X$11807 1493 2098 2099 1390 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11810 m0 *1 2.24,307.44
X$11810 1492 2098 2099 1391 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11815 r0 *1 19.04,297.36
X$11815 1401 2098 2099 1393 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11818 r0 *1 10.64,297.36
X$11818 1396 2098 2099 1394 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11820 r0 *1 187.04,287.28
X$11820 2099 2098 1395 1405 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11827 r0 *1 29.12,307.44
X$11827 2098 1493 1396 2099 1494 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11838 m0 *1 35.84,297.36
X$11838 1396 2099 1427 2098 1447 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11852 m0 *1 123.2,297.36
X$11852 1401 2099 1452 2098 1423 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11867 m0 *1 175.28,357.84
X$11867 1708 1709 1741 1754 2099 2098 1403 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $11870 r0 *1 179.76,307.44
X$11870 2099 1502 2098 1404 1528 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $11880 m0 *1 284.48,297.36
X$11880 2098 1457 1407 2099 1422 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11885 r0 *1 273.28,297.36
X$11885 2099 2098 1408 1474 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11887 m0 *1 278.32,317.52
X$11887 2098 1408 1544 2099 1511 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11906 r0 *1 283.36,418.32
X$11906 1408 2098 2099 2030 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11910 r0 *1 301.28,327.6
X$11910 2098 1602 1410 2099 1545 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11913 m0 *1 286.72,307.44
X$11913 2099 2098 1410 1457 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11923 m0 *1 315.84,418.32
X$11923 1410 2098 2099 2018 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11927 r0 *1 356.72,297.36
X$11927 2098 1411 1414 2099 1484 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $11937 m0 *1 426.16,317.52
X$11937 1411 2098 2099 1418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11949 r0 *1 346.64,297.36
X$11949 2099 2098 1439 1412 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11970 m0 *1 390.32,317.52
X$11970 1416 2099 1551 2098 1547 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $11981 r0 *1 430.08,287.28
X$11981 1416 2098 2099 1417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $11994 r0 *1 301.28,347.76
X$11994 2099 1702 2098 1420 1840 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12004 m0 *1 130.48,317.52
X$12004 2099 1502 2098 1421 1894 1468 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12038 m0 *1 84,337.68
X$12038 2099 1593 2098 1431 1622 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12049 m0 *1 201.6,347.76
X$12049 2099 2098 1686 1434 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12051 r0 *1 178.08,337.68
X$12051 2098 1434 1661 2099 1680 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12057 m0 *1 245.84,307.44
X$12057 2099 2098 1435 1473 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12065 m0 *1 267.12,418.32
X$12065 1435 2098 2099 1992 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12069 m0 *1 265.44,307.44
X$12069 2098 1474 1436 2099 1491 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12084 r0 *1 301.84,307.44
X$12084 2099 2098 1512 1438 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12086 r0 *1 301.28,297.36
X$12086 2098 1438 1456 2099 1477 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12098 m0 *1 417.76,317.52
X$12098 1480 2098 2099 1440 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12103 m0 *1 359.52,317.52
X$12103 2098 1442 1553 2099 1577 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12117 m0 *1 430.08,327.6
X$12117 1442 2098 2099 1444 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12125 r0 *1 430.08,317.52
X$12125 1478 2098 2099 1445 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12157 m0 *1 58.8,327.6
X$12157 2099 1466 2098 1612 1656 1454 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12165 m0 *1 89.04,327.6
X$12165 2099 2098 1454 1559 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12168 r0 *1 154.56,307.44
X$12168 2099 2098 1454 1468 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12172 r0 *1 105.28,317.52
X$12172 2099 1466 2098 1539 1560 1454 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12174 m0 *1 2.24,317.52
X$12174 2099 1533 1454 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12184 r0 *1 92.96,327.6
X$12184 2099 1466 2098 1591 1657 1454 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12188 m0 *1 154.56,337.68
X$12188 2098 1455 1647 2099 1628 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12190 r0 *1 151.76,327.6
X$12190 2099 2098 1626 1455 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12209 r0 *1 220.08,297.36
X$12209 2098 1472 1458 2099 1490 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12214 m0 *1 237.44,297.36
X$12214 2098 1473 1460 2099 1459 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12226 r0 *1 10.64,327.6
X$12226 1496 2098 2099 1462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12228 m0 *1 73.36,337.68
X$12228 2099 1593 2098 1463 1621 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12241 m0 *1 302.96,347.76
X$12241 2099 2098 1466 1716 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12244 r0 *1 313.6,337.68
X$12244 2099 2098 1466 1670 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12247 m0 *1 169.12,317.52
X$12247 2099 2098 1466 1502 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12251 m0 *1 201.6,327.6
X$12251 2099 2098 1466 1593 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12253 m0 *1 220.64,347.76
X$12253 2099 2098 1466 1688 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12255 r0 *1 2.24,337.68
X$12255 2099 1653 1466 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $12302 m0 *1 158.48,378
X$12302 2098 1469 1807 2099 1821 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12307 m0 *1 162.4,388.08
X$12307 2099 2098 1859 1469 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12309 m0 *1 170.8,378
X$12309 2098 1470 1830 2099 1851 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12315 m0 *1 180.88,378
X$12315 2099 2098 1861 1470 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12325 r0 *1 226.8,307.44
X$12325 2099 2098 1505 1472 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12348 m0 *1 291.76,367.92
X$12348 2099 1702 2098 1476 1799 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12354 m0 *1 400.96,307.44
X$12354 1478 2099 1483 2098 1515 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12402 r0 *1 189.84,408.24
X$12402 2099 2098 1965 1488 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12404 m0 *1 182.56,408.24
X$12404 2098 1488 1964 2099 1947 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12414 m0 *1 188.72,337.68
X$12414 2098 1489 1629 2099 1630 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12419 m0 *1 189.84,347.76
X$12419 2099 2098 1711 1489 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12430 m0 *1 35.28,317.52
X$12430 1492 2099 1534 2098 1550 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12446 r0 *1 2.24,317.52
X$12446 2098 1493 1574 2099 1548 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12463 r0 *1 35.84,307.44
X$12463 1496 2099 1495 2098 1521 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12477 r0 *1 63.84,327.6
X$12477 2099 1593 2098 1497 1619 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12487 m0 *1 130.48,337.68
X$12487 2099 2098 1660 1499 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12490 m0 *1 123.76,347.76
X$12490 2098 1499 1685 2099 1677 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12493 r0 *1 120.4,357.84
X$12493 2098 1500 1770 2099 1772 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12497 m0 *1 127.68,357.84
X$12497 2099 2098 1706 1500 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12500 m0 *1 123.76,378
X$12500 2098 1501 1806 2099 1820 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12502 r0 *1 124.32,367.92
X$12502 2099 2098 1805 1501 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12531 m0 *1 190.4,398.16
X$12531 2098 1503 1903 2099 1897 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12533 r0 *1 192.64,398.16
X$12533 2099 2098 1907 1503 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12536 m0 *1 189.84,367.92
X$12536 2098 1504 1782 2099 1783 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12541 r0 *1 197.68,357.84
X$12541 2099 2098 1757 1504 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12553 m0 *1 233.52,418.32
X$12553 1505 2098 2099 2003 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12559 m0 *1 236.32,438.48
X$12559 1506 2098 2099 2083 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12562 m0 *1 235.76,347.76
X$12562 2099 1671 2098 1507 1745 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12565 m0 *1 279.44,367.92
X$12565 2099 1702 2098 1508 1800 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12571 r0 *1 269.36,317.52
X$12571 2099 2098 1509 1566 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12583 r0 *1 301.28,428.4
X$12583 1509 2098 2099 2062 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12587 m0 *1 277.76,408.24
X$12587 1510 2098 2099 1975 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12606 m0 *1 376.32,438.48
X$12606 1512 2098 2099 2093 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12611 m0 *1 319.2,347.76
X$12611 2099 1691 2098 1514 1732 1670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12660 m0 *1 300.16,398.16
X$12660 1526 2098 2099 1987 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12663 r0 *1 156.24,408.24
X$12663 2098 1527 1961 2099 1984 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12670 m0 *1 162.4,418.32
X$12670 2099 2098 1972 1527 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12675 r0 *1 177.52,317.52
X$12675 2099 2098 1563 1528 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12680 m0 *1 269.36,408.24
X$12680 1529 2098 2099 1991 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12686 m0 *1 261.52,438.48
X$12686 1530 2098 2099 2061 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12697 r0 *1 223.44,418.32
X$12697 1532 2098 2099 2036 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12708 r0 *1 74.48,327.6
X$12708 2099 1593 2098 1537 1590 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12716 r0 *1 183.12,398.16
X$12716 2099 2098 1922 1540 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12719 r0 *1 169.68,398.16
X$12719 2098 1540 1917 2099 1946 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12724 m0 *1 185.36,327.6
X$12724 2098 1564 1597 2099 1541 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12729 r0 *1 217.84,317.52
X$12729 2098 1565 1542 2099 1584 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12732 r0 *1 248.64,317.52
X$12732 2098 1566 1543 2099 1567 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12735 r0 *1 278.88,337.68
X$12735 2099 2098 1544 1663 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12748 r0 *1 291.2,428.4
X$12748 1544 2098 2099 2064 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12790 m0 *1 66.08,337.68
X$12790 2099 1593 2098 1557 1620 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12793 m0 *1 81.76,327.6
X$12793 2099 1593 2098 1558 1796 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12797 m0 *1 93.52,337.68
X$12797 2099 1593 2098 1623 1779 1559 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12819 r0 *1 101.92,347.76
X$12819 2098 1560 1683 2099 1730 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12824 r0 *1 111.44,347.76
X$12824 2099 2098 1705 1560 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12826 m0 *1 137.2,337.68
X$12826 1561 2098 1563 1626 2099 1624 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12829 r0 *1 138.88,327.6
X$12829 1625 2099 2098 1561 1563 1595 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $12831 r0 *1 122.08,327.6
X$12831 2099 2098 1561 1594 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12836 m0 *1 31.36,327.6
X$12836 1561 2098 2099 1588 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12839 m0 *1 149.52,337.68
X$12839 2098 1625 1562 2099 1647 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12845 m0 *1 145.6,327.6
X$12845 2099 2098 1581 1595 1562 1563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12847 m0 *1 122.08,327.6
X$12847 2098 1594 1562 2099 1579 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12849 m0 *1 141.12,347.76
X$12849 2098 1699 1700 2099 1562 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12863 r0 *1 19.04,327.6
X$12863 1563 2098 2099 1589 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12868 m0 *1 194.88,327.6
X$12868 2099 2098 1583 1564 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12877 r0 *1 227.36,317.52
X$12877 2099 2098 1587 1565 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12892 m0 *1 310.24,327.6
X$12892 2099 2098 1569 1571 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $12901 r0 *1 384.16,428.4
X$12901 1569 2098 2099 2042 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12906 r0 *1 301.84,317.52
X$12906 2098 1571 1570 2099 1617 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $12914 m0 *1 390.32,327.6
X$12914 1608 2099 1572 2098 1646 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $12917 m0 *1 421.68,327.6
X$12917 1604 2098 2099 1573 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12956 r0 *1 185.92,357.84
X$12956 1583 2098 1757 1710 2099 1774 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $12958 r0 *1 192.08,357.84
X$12958 2098 1583 1757 2099 1743 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12960 m0 *1 185.36,378
X$12960 2098 1583 1710 2099 1808 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12976 m0 *1 202.72,438.48
X$12976 1583 2098 2099 2079 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $12991 m0 *1 219.52,438.48
X$12991 1586 2098 2099 2081 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13005 r0 *1 232.96,408.24
X$13005 1587 2098 2099 2020 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13012 m0 *1 78.4,367.92
X$13012 2098 1590 1778 2099 1803 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13015 r0 *1 78.4,367.92
X$13015 2099 2098 1818 1590 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13019 r0 *1 118.72,408.24
X$13019 2099 2098 1970 1592 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13024 r0 *1 109.2,408.24
X$13024 2098 1592 1942 2099 1969 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13029 m0 *1 244.72,347.76
X$13029 2099 1665 2098 1689 1881 1593 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13033 m0 *1 262.08,347.76
X$13033 2099 1702 2098 1703 1593 1761 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13058 r0 *1 182,347.76
X$13058 1708 1709 1741 1710 2099 2098 1597 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13065 r0 *1 248.64,398.16
X$13065 1599 2098 2099 1924 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13073 r0 *1 269.36,337.68
X$13073 2098 1663 1601 2099 1664 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13077 r0 *1 282.8,327.6
X$13077 2099 2098 1602 1636 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13089 m0 *1 290.64,398.16
X$13089 1602 2098 2099 1927 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13093 r0 *1 381.92,327.6
X$13093 1603 2099 1607 2098 1640 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13103 r0 *1 428.4,337.68
X$13103 1603 2098 2099 1610 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13105 r0 *1 376.32,327.6
X$13105 2098 1604 1608 2099 1606 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13122 r0 *1 389.76,337.68
X$13122 2098 1605 1675 2099 1673 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13131 m0 *1 413.28,327.6
X$13131 1605 2098 2099 1611 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13149 m0 *1 430.08,347.76
X$13149 1608 2098 2099 1609 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13185 m0 *1 68.88,367.92
X$13185 2098 1619 1793 2099 1816 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13188 r0 *1 71.68,357.84
X$13188 2099 2098 1755 1619 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13190 r0 *1 70.56,347.76
X$13190 2098 1620 1737 2099 1728 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13196 m0 *1 67.76,347.76
X$13196 2099 2098 1682 1620 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13199 r0 *1 76.16,388.08
X$13199 2098 1621 1876 2099 1888 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13201 m0 *1 80.64,388.08
X$13201 2099 2098 1877 1621 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13204 r0 *1 91.28,388.08
X$13204 2098 1622 1901 2099 1889 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13208 m0 *1 87.36,388.08
X$13208 2099 2098 1854 1622 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13212 m0 *1 139.44,357.84
X$13212 1699 1700 1624 1736 2099 2098 1683 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13214 r0 *1 138.88,347.76
X$13214 1699 2098 1700 1624 2099 1708 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13221 m0 *1 146.16,347.76
X$13221 1699 1626 1625 1700 2099 2098 1701 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13231 m0 *1 152.32,438.48
X$13231 1626 2098 2099 2075 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13235 r0 *1 145.04,388.08
X$13235 2099 2098 1921 1627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13238 r0 *1 134.4,388.08
X$13238 2098 1627 1914 2099 1857 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13246 m0 *1 182.56,357.84
X$13246 1739 1709 1741 1742 2099 2098 1629 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13255 r0 *1 236.32,327.6
X$13255 2098 1634 1632 2099 1649 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13257 r0 *1 246.96,327.6
X$13257 2099 2098 1633 1634 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13263 r0 *1 246.4,418.32
X$13263 1633 2098 2099 2005 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13274 r0 *1 273.84,418.32
X$13274 1635 2098 2099 2063 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13277 m0 *1 280,337.68
X$13277 2098 1636 1650 2099 1668 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13284 r0 *1 301.28,398.16
X$13284 1637 2098 2099 1988 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13291 r0 *1 348.32,337.68
X$13291 2099 1639 1669 2098 1665 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13294 m0 *1 408.24,347.76
X$13294 1642 2098 2099 1639 gf180mcu_fd_sc_mcu9t5v0__dlya_2
* cell instance $13325 r0 *1 229.04,347.76
X$13325 2099 1671 2098 1648 1874 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13333 m0 *1 27.44,347.76
X$13333 1654 2098 2099 1651 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13336 r0 *1 25.2,337.68
X$13336 1655 2098 2099 1652 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13341 m0 *1 61.6,357.84
X$13341 1705 1654 1655 1682 2099 2098 1767 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13343 m0 *1 76.16,347.76
X$13343 2098 1705 1654 2099 1684 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13346 m0 *1 94.64,347.76
X$13346 2099 2098 1654 1657 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13357 r0 *1 62.16,337.68
X$13357 2099 2098 1655 1656 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13360 m0 *1 68.88,357.84
X$13360 1655 1701 1736 1684 2099 2098 1737 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13371 m0 *1 58.24,347.76
X$13371 2098 1656 1696 2099 1697 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13375 m0 *1 92.96,357.84
X$13375 2098 1657 1769 2099 1751 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13423 r0 *1 117.6,398.16
X$13423 2099 2098 1659 2105 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $13432 r0 *1 128.24,388.08
X$13432 1707 2098 1706 1660 2099 1856 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13440 r0 *1 128.24,428.4
X$13440 1660 2098 2099 2044 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13444 r0 *1 127.68,367.92
X$13444 1707 1706 1660 1805 2099 2098 1736 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13446 r0 *1 177.52,357.84
X$13446 1708 1709 1741 1774 2099 2098 1661 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13451 r0 *1 241.36,408.24
X$13451 2098 1662 1759 2099 1948 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13453 r0 *1 244.72,388.08
X$13453 1662 1759 1881 1801 2099 2098 1835 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13456 r0 *1 225.68,378
X$13456 2098 1662 1853 2099 1809 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $13458 r0 *1 235.2,378
X$13458 1662 2098 1819 1833 2099 1832 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13460 m0 *1 228.48,347.76
X$13460 2099 1671 2098 1704 1662 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13470 m0 *1 241.92,418.32
X$13470 1662 2098 2099 2004 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13479 m0 *1 327.04,347.76
X$13479 2099 2098 1665 1671 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13482 m0 *1 342.72,347.76
X$13482 2099 2098 1665 1691 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13484 r0 *1 258.72,347.76
X$13484 2099 2098 1665 1702 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13492 r0 *1 251.44,347.76
X$13492 2099 1665 2098 1734 1759 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13503 m0 *1 318.08,438.48
X$13503 1666 2098 2099 2088 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13514 m0 *1 362.88,418.32
X$13514 2015 2098 2099 1669 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $13551 r0 *1 214.48,347.76
X$13551 2099 1671 2098 1733 1831 1688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13566 m0 *1 364,357.84
X$13566 2098 1721 1672 2099 1764 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13569 m0 *1 377.44,378
X$13569 1672 2099 1845 2098 1817 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13572 r0 *1 362.32,367.92
X$13572 1721 2098 1672 1763 2099 1790 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13579 m0 *1 429.52,357.84
X$13579 1672 2098 2099 1724 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13604 m0 *1 298.48,357.84
X$13604 2099 1702 2098 1679 1787 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13614 r0 *1 10.08,347.76
X$13614 1682 2098 2099 1681 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13624 r0 *1 128.24,398.16
X$13624 1683 1767 1905 1906 2099 2098 1914 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13626 r0 *1 77.28,398.16
X$13626 1755 1818 1683 1767 2099 2098 1876 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13628 m0 *1 71.12,347.76
X$13628 2098 1683 1684 2099 1696 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13630 m0 *1 86.24,408.24
X$13630 1854 1683 1767 1905 2099 2098 1956 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13632 m0 *1 107.52,408.24
X$13632 1683 1767 1905 1958 2099 2098 1942 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13645 r0 *1 68.32,367.92
X$13645 2098 1683 1767 2099 1793 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13654 r0 *1 126,347.76
X$13654 2099 1685 1707 2098 1706 1708 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $13657 m0 *1 189.84,357.84
X$13657 1686 1711 1710 1743 2099 2098 1754 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13666 m0 *1 183.68,367.92
X$13666 1686 2098 1710 1743 2099 1742 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13670 m0 *1 182.56,438.48
X$13670 1686 2098 2099 2077 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13698 r0 *1 311.92,347.76
X$13698 2099 1691 2098 1690 1717 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13723 m0 *1 337.12,388.08
X$13723 1840 1732 1849 1692 2099 2098 1884 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13732 r0 *1 361.2,428.4
X$13732 1692 2098 2099 2050 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13734 m0 *1 338.8,418.32
X$13734 1692 2099 1983 2098 1981 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13738 r0 *1 376.32,347.76
X$13738 1693 2099 1771 2098 1729 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13741 m0 *1 417.2,347.76
X$13741 1693 2098 2099 1695 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13745 r0 *1 412.72,347.76
X$13745 1721 2098 2099 1694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13770 r0 *1 145.04,357.84
X$13770 2099 2098 1781 1699 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $13783 r0 *1 161.84,398.16
X$13783 1861 1701 1906 1741 2099 2098 1917 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13788 r0 *1 77.84,357.84
X$13788 1755 1701 1736 1767 2099 2098 1778 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13791 r0 *1 114.8,367.92
X$13791 2099 2098 1701 1739 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $13802 m0 *1 99.12,408.24
X$13802 1854 1939 1701 1893 2099 2098 1940 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13809 m0 *1 263.76,357.84
X$13809 2099 1702 2098 1746 1747 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13812 m0 *1 272.16,367.92
X$13812 2099 1702 2098 1714 1801 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13814 m0 *1 264.88,367.92
X$13814 2099 1702 2098 1713 1810 1716 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $13839 m0 *1 102.48,357.84
X$13839 1705 2098 1739 1736 2099 1769 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13847 m0 *1 2.24,357.84
X$13847 1705 2098 2099 1735 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13855 m0 *1 124.88,428.4
X$13855 1706 2098 2099 2045 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13865 r0 *1 129.92,357.84
X$13865 2098 1707 1739 2099 1770 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13874 m0 *1 127.12,438.48
X$13874 1707 2098 2099 2071 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13877 r0 *1 154.56,398.16
X$13877 1859 1708 1906 1895 2099 2098 1961 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13885 r0 *1 168,378
X$13885 1708 2098 1709 1741 2099 1830 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13887 m0 *1 183.12,398.16
X$13887 1708 1709 1741 1896 2099 2098 1903 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13899 m0 *1 157.36,398.16
X$13899 1739 2098 1709 1895 2099 1807 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13902 m0 *1 161.84,408.24
X$13902 1739 1709 1895 1963 2099 2098 1945 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13909 r0 *1 183.12,367.92
X$13909 1739 1709 1741 1808 2099 2098 1782 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13913 m0 *1 163.52,398.16
X$13913 2099 2098 1906 1709 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $13916 m0 *1 175.28,408.24
X$13916 1739 1709 1741 1935 2099 2098 1964 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13938 m0 *1 192.08,408.24
X$13938 1861 1922 1907 1965 2099 2098 1710 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $13946 r0 *1 192.08,428.4
X$13946 1711 2098 2099 2049 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13948 m0 *1 224.56,408.24
X$13948 1712 2098 1745 1831 2099 1908 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13951 m0 *1 217.84,388.08
X$13951 1712 2099 1813 2098 1873 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $13954 r0 *1 219.52,367.92
X$13954 2099 2098 1712 1785 1819 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13961 r0 *1 208.88,428.4
X$13961 1712 2098 2099 2054 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13963 m0 *1 212.24,408.24
X$13963 1712 2098 1745 1813 2099 1898 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13997 r0 *1 282.24,378
X$13997 1717 2099 1838 2098 1839 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14004 m0 *1 282.8,398.16
X$14004 2098 1874 1717 2099 1919 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14007 m0 *1 302.96,408.24
X$14007 1717 2098 2099 1951 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14010 r0 *1 315.84,388.08
X$14010 2099 2098 1890 1864 1841 1718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14012 m0 *1 324.8,388.08
X$14012 2098 1761 1718 2099 1865 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14016 m0 *1 325.92,408.24
X$14016 1718 2098 2099 1962 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14020 r0 *1 317.52,378
X$14020 2099 1842 1864 1761 1718 2098 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $14022 r0 *1 341.04,367.92
X$14022 1719 2099 1824 2098 1822 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14025 r0 *1 351.12,408.24
X$14025 1719 1899 1912 1791 2099 2098 1959 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14028 m0 *1 361.2,367.92
X$14028 1719 1773 1720 1789 2099 2098 1763 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14036 m0 *1 342.72,438.48
X$14036 1719 2098 2099 2096 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14040 r0 *1 364.56,388.08
X$14040 2098 1719 1773 2099 1887 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14045 m0 *1 364.56,398.16
X$14045 1720 2099 1886 2098 1900 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14049 m0 *1 375.2,408.24
X$14049 2098 1720 1887 2099 1929 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14059 r0 *1 392.56,428.4
X$14059 1720 2098 2099 2039 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14063 m0 *1 364,378
X$14063 2098 1721 1763 2099 1843 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14075 r0 *1 378.56,378
X$14075 1721 2099 1846 2098 1871 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14079 m0 *1 369.04,357.84
X$14079 1722 2098 1763 1764 2099 1749 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14082 m0 *1 380.8,367.92
X$14082 1722 2099 1792 2098 1795 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14084 r0 *1 369.04,357.84
X$14084 1722 1752 1763 1764 2099 2098 1765 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14092 r0 *1 426.16,347.76
X$14092 1722 2098 2099 1723 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14127 m0 *1 345.52,398.16
X$14127 2098 1732 1865 2099 1885 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14130 r0 *1 324.8,418.32
X$14130 1732 2099 1928 2098 2017 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14133 m0 *1 317.52,398.16
X$14133 1732 2098 1849 1842 2099 1869 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14148 m0 *1 367.92,438.48
X$14148 1732 2098 2099 2095 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14179 m0 *1 101.36,398.16
X$14179 2098 1739 1893 2099 1901 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14182 m0 *1 123.2,388.08
X$14182 2098 1739 1856 2099 1806 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14197 m0 *1 121.52,408.24
X$14197 1739 2098 1893 1933 2099 1943 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14201 m0 *1 165.76,418.32
X$14201 2098 1740 1945 2099 1999 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14203 m0 *1 175.84,418.32
X$14203 2099 2098 1973 1740 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14225 m0 *1 152.32,408.24
X$14225 1856 1767 1892 1985 2099 2098 1741 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14240 m0 *1 216.16,367.92
X$14240 2098 1745 1785 2099 1758 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14252 m0 *1 244.72,438.48
X$14252 1745 2098 2099 2084 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14258 r0 *1 265.44,398.16
X$14258 2098 1747 1810 2099 1920 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14261 m0 *1 254.8,388.08
X$14261 1747 1819 1833 1835 2099 2098 1863 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14264 r0 *1 254.8,418.32
X$14264 1747 2099 2006 2098 1993 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14277 m0 *1 275.52,398.16
X$14277 1747 2098 1810 1800 2099 1882 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14279 m0 *1 275.52,418.32
X$14279 1747 2098 2099 2024 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14282 r0 *1 301.28,388.08
X$14282 1799 1787 1777 1748 2099 2098 1872 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14289 r0 *1 306.88,418.32
X$14289 1748 2099 1925 2098 2009 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14291 m0 *1 294.56,408.24
X$14291 1748 2098 2099 1966 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14294 r0 *1 368.48,367.92
X$14294 1819 1815 1791 1749 2099 2098 1797 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14298 r0 *1 421.68,357.84
X$14298 1752 2098 2099 1750 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14304 r0 *1 379.12,357.84
X$14304 1752 2099 1797 2098 1766 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14328 m0 *1 94.08,398.16
X$14328 1805 1755 1818 1877 2099 2098 1892 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14330 r0 *1 94.64,398.16
X$14330 1755 2098 1818 1877 2099 1905 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14341 m0 *1 85.68,428.4
X$14341 1755 2098 2099 2033 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14344 r0 *1 150.08,428.4
X$14344 2046 2098 2099 1756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14355 m0 *1 211.12,438.48
X$14355 1757 2098 2099 2080 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14362 r0 *1 236.32,367.92
X$14362 1759 2099 1832 2098 1786 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14378 m0 *1 250.32,418.32
X$14378 1759 2098 2099 2023 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14389 r0 *1 334.32,398.16
X$14389 2099 1760 2103 2098 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $14427 r0 *1 317.52,367.92
X$14427 1761 2099 1841 2098 1825 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14440 r0 *1 334.32,408.24
X$14440 1761 2098 2099 1960 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14443 r0 *1 332.08,388.08
X$14443 1883 1762 1866 1865 2099 2098 1814 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14445 m0 *1 330.96,388.08
X$14445 1883 2098 1762 1866 2099 1867 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14447 r0 *1 324.24,388.08
X$14447 1883 1762 1842 1866 2099 2098 1899 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14456 m0 *1 323.68,398.16
X$14456 1762 2098 2099 1915 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14458 m0 *1 314.16,378
X$14458 2098 1762 1850 2099 1776 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14463 r0 *1 367.92,378
X$14463 1814 1815 1791 1763 2099 2098 1846 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14480 m0 *1 369.04,367.92
X$14480 1814 1815 1791 1765 2099 2098 1771 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14487 r0 *1 120.4,388.08
X$14487 1856 2098 1767 1892 2099 1893 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14491 m0 *1 148.4,398.16
X$14491 1921 1856 1767 1892 2099 2098 1895 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14532 r0 *1 358.4,408.24
X$14532 1773 2099 1959 2098 1957 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14540 m0 *1 385.28,428.4
X$14540 1773 2098 2099 2032 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14558 r0 *1 290.64,408.24
X$14558 1777 2099 1931 2098 1989 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14560 r0 *1 285.6,388.08
X$14560 1799 1787 1777 1882 2099 2098 1891 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14571 r0 *1 316.4,418.32
X$14571 1777 2098 2099 2010 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14575 m0 *1 98,418.32
X$14575 2098 1779 1940 2099 2013 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14578 r0 *1 97.44,408.24
X$14578 2099 2098 1941 1779 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14607 r0 *1 309.68,398.16
X$14607 1799 1787 1899 1926 2099 2098 1931 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14610 m0 *1 277.76,378
X$14610 1787 2099 1836 2098 1827 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14622 m0 *1 384.72,438.48
X$14622 1787 2098 2099 2040 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14630 m0 *1 365.68,408.24
X$14630 1789 2099 1953 2098 1955 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14637 m0 *1 376.88,428.4
X$14637 1789 2098 2099 2043 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14640 m0 *1 369.04,378
X$14640 1814 1815 1791 1790 2099 2098 1792 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14646 r0 *1 360.64,378
X$14646 1819 1815 1791 1843 2099 2098 1845 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14654 r0 *1 363.44,398.16
X$14654 1819 1815 1791 1929 2099 2098 1953 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14657 r0 *1 357.28,388.08
X$14657 1814 1815 1791 1887 2099 2098 1886 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14665 m0 *1 342.16,378
X$14665 1813 2098 1815 1791 2099 1824 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14667 r0 *1 339.92,388.08
X$14667 2098 1872 1884 2099 1791 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14686 r0 *1 79.52,408.24
X$14686 2098 1796 1956 2099 1938 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14688 m0 *1 93.52,408.24
X$14688 2099 2098 1939 1796 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $14703 m0 *1 285.04,428.4
X$14703 2098 1799 1976 2099 2031 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $14706 m0 *1 279.44,388.08
X$14706 2098 1799 1882 2099 1837 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $14725 m0 *1 309.68,438.48
X$14725 1799 2098 2099 2089 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14737 m0 *1 259.28,408.24
X$14737 1800 2099 1936 2098 1934 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14741 r0 *1 279.44,408.24
X$14741 1800 2098 2099 1968 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14744 r0 *1 231.84,418.32
X$14744 1801 2099 2002 2098 2027 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14762 m0 *1 301.28,438.48
X$14762 1801 2098 2099 2087 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14781 m0 *1 110.32,438.48
X$14781 1805 2098 2099 2069 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14793 m0 *1 257.6,378
X$14793 1810 2099 1863 2098 1828 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14804 m0 *1 275.52,428.4
X$14804 1810 2098 2099 2029 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14810 r0 *1 338.24,378
X$14810 2099 2098 1814 1813 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $14815 r0 *1 257.04,398.16
X$14815 1813 1833 1835 1920 2099 2098 1936 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14817 m0 *1 252,408.24
X$14817 1813 2098 1833 1835 2099 2006 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14819 m0 *1 227.36,388.08
X$14819 2099 2098 1813 1853 1833 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14822 r0 *1 274.96,378
X$14822 1813 1833 1835 1837 2099 2098 1836 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14824 m0 *1 286.16,388.08
X$14824 1813 1833 1835 1875 2099 2098 1838 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14826 r0 *1 290.08,398.16
X$14826 1813 1833 1835 1891 2099 2098 1925 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14841 r0 *1 226.8,408.24
X$14841 1813 2098 1833 1948 2099 1949 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14860 r0 *1 344.96,388.08
X$14860 1867 1868 1815 1885 2099 2098 1977 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14871 r0 *1 355.6,398.16
X$14871 2099 2098 1912 1815 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $14874 m0 *1 344.4,388.08
X$14874 1867 1868 1815 1869 2099 2098 1983 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14897 m0 *1 84,438.48
X$14897 1818 2098 2099 2066 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $14900 m0 *1 230.72,408.24
X$14900 2099 2098 1819 1937 1908 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14902 m0 *1 226.24,418.32
X$14902 1881 1819 1833 1948 2099 2098 2002 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $14905 m0 *1 337.68,398.16
X$14905 2099 2098 1899 1819 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $14912 m0 *1 292.32,418.32
X$14912 2099 2098 1819 1976 1926 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14916 m0 *1 311.36,408.24
X$14916 1819 2098 1926 1872 2099 2019 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $14973 m0 *1 216.16,398.16
X$14973 1831 2099 1898 2098 1904 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $14981 m0 *1 227.92,438.48
X$14981 1831 2098 2099 2082 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15009 r0 *1 242.48,398.16
X$15009 2098 1874 1908 2099 1833 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15019 r0 *1 282.8,398.16
X$15019 1908 1835 1882 1919 2099 2098 1912 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15022 r0 *1 275.52,398.16
X$15022 1874 1908 1835 1882 2099 2098 1926 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15051 r0 *1 332.08,378
X$15051 2098 1840 1872 2099 1868 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15055 m0 *1 324.8,418.32
X$15055 1840 2099 2019 2098 1902 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15058 m0 *1 293.44,388.08
X$15058 1840 2098 1882 1872 2099 1875 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15072 r0 *1 339.92,418.32
X$15072 1840 2098 2099 2055 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15075 m0 *1 323.68,378
X$15075 2099 2098 1842 1850 1841 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $15081 r0 *1 310.8,388.08
X$15081 2098 1883 1866 2099 1841 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15089 r0 *1 327.04,398.16
X$15089 1842 1867 1868 1912 2099 2098 1928 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15124 m0 *1 348.32,418.32
X$15124 1849 2099 1977 2098 1980 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15137 m0 *1 400.96,438.48
X$15137 1849 2098 2099 2097 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15155 m0 *1 112,418.32
X$15155 1854 1939 1941 1970 2099 2098 1933 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15159 r0 *1 103.04,408.24
X$15159 1854 2098 1939 1941 2099 1958 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $15171 r0 *1 105.84,418.32
X$15171 1854 2098 2099 2025 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15193 m0 *1 155.12,418.32
X$15193 1921 1859 1972 1973 2099 2098 1985 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $15196 r0 *1 165.76,408.24
X$15196 2098 1859 1972 2099 1963 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15203 r0 *1 158.48,428.4
X$15203 1859 2098 2099 2074 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15211 r0 *1 183.68,408.24
X$15211 2098 1861 1922 2099 1896 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15222 m0 *1 190.96,438.48
X$15222 1861 2098 2099 2078 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15290 r0 *1 229.04,398.16
X$15290 2098 1874 1937 2099 1880 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15305 m0 *1 283.92,418.32
X$15305 1874 2098 2099 2065 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15319 r0 *1 84,428.4
X$15319 1877 2098 2099 2041 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15342 m0 *1 244.72,428.4
X$15342 1881 2098 2099 2037 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15344 m0 *1 227.92,428.4
X$15344 1881 2099 1949 2098 2034 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $15365 m0 *1 309.12,398.16
X$15365 2099 2098 1910 1883 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15410 m0 *1 134.4,408.24
X$15410 2099 2098 1944 1894 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15413 r0 *1 123.76,408.24
X$15413 2098 1894 1943 2099 1971 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $15426 r0 *1 186.48,398.16
X$15426 2098 1907 1896 2099 1935 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15472 m0 *1 129.36,408.24
X$15472 2098 1944 1933 2099 1906 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15486 m0 *1 202.16,428.4
X$15486 1907 2098 2099 2053 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15513 m0 *1 317.52,408.24
X$15513 1952 2098 2099 1911 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15564 m0 *1 143.92,438.48
X$15564 1921 2098 2099 2073 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15575 r0 *1 183.68,428.4
X$15575 1922 2098 2099 2048 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15650 m0 *1 92.4,438.48
X$15650 1939 2098 2099 2067 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15664 m0 *1 101.92,438.48
X$15664 1941 2098 2099 2068 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15678 m0 *1 135.52,438.48
X$15678 1944 2098 2099 2072 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15750 r0 *1 200.48,428.4
X$15750 1965 2098 2099 2052 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15772 m0 *1 118.72,438.48
X$15772 1970 2098 2099 2070 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15785 m0 *1 160.72,438.48
X$15785 1972 2098 2099 2076 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15795 r0 *1 175.28,428.4
X$15795 1973 2098 2099 2047 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15797 m0 *1 258.72,418.32
X$15797 1974 2098 2099 2086 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS performance_counter

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.3 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.8906P AD=0.8906P PS=6.09U PD=6.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A4
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_4 1 3 4 5 6 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A3
* net 4 A4
* net 5 A2
* net 6 A1
* net 16 ZN
* net 17 NWELL,VDD
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 16 3 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.5616P AD=1.3312P PS=8.84U PD=7.2U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 17 4 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $9 r0 *1 9.03,4.055 pmos_5p0
M$9 16 5 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.5616P PS=7.2U PD=8.84U
* device instance $10 r0 *1 10.05,4.055 pmos_5p0
M$10 17 6 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 7 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 1 4 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $24 r0 *1 8.01,1.005 nmos_5p0
M$24 11 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $25 r0 *1 9.03,1.005 nmos_5p0
M$25 14 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $26 r0 *1 10,1.005 nmos_5p0
M$26 16 6 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 11.12,1.005 nmos_5p0
M$27 15 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.04,1.005 nmos_5p0
M$28 2 5 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.16,1.005 nmos_5p0
M$29 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.08,1.005 nmos_5p0
M$30 16 6 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.2,1.005 nmos_5p0
M$31 13 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.12,1.005 nmos_5p0
M$32 2 5 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__and4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A1
* pin A2
* pin Z
* pin A4
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_4 1 2 3 5 6 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 A1
* net 5 A2
* net 6 Z
* net 13 A4
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.885,3.505 pmos_5p0
M$1 4 13 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.8908P PS=5.24U PD=4.33U
* device instance $2 r0 *1 1.905,3.505 pmos_5p0
M$2 14 2 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.925,3.505 pmos_5p0
M$3 4 5 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.945,3.505 pmos_5p0
M$4 14 3 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 9.225,3.78 pmos_5p0
M$9 6 4 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9854P AD=2.2326P PS=9.58U PD=11.59U
* device instance $13 r0 *1 0.935,1.005 nmos_5p0
M$13 7 13 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.855,1.005 nmos_5p0
M$14 8 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $15 r0 *1 2.875,1.005 nmos_5p0
M$15 10 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $16 r0 *1 3.895,1.005 nmos_5p0
M$16 4 3 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.015,1.005 nmos_5p0
M$17 9 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.935,1.005 nmos_5p0
M$18 12 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $19 r0 *1 6.955,1.005 nmos_5p0
M$19 11 2 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $20 r0 *1 7.975,1.005 nmos_5p0
M$20 1 13 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 9.095,1.005 nmos_5p0
M$21 6 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_4 1 2 3 5 6 7 9
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 B
* net 5 ZN
* net 6 A2
* net 7 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 14.93,3.872 pmos_5p0
M$1 5 3 9 9 pmos_5p0 L=0.5U W=6.58U AS=2.212525P AD=2.212525P PS=10.915U
+ PD=10.915U
* device instance $5 r0 *1 0.97,3.78 pmos_5p0
M$5 9 2 8 9 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $8 r0 *1 4.28,3.78 pmos_5p0
M$8 11 2 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 5.4,3.78 pmos_5p0
M$9 10 6 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 6.52,3.78 pmos_5p0
M$10 5 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 7.64,3.78 pmos_5p0
M$11 13 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $12 r0 *1 8.81,3.78 pmos_5p0
M$12 8 6 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $13 r0 *1 9.88,3.78 pmos_5p0
M$13 12 6 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $14 r0 *1 11,3.78 pmos_5p0
M$14 5 7 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 12.12,3.78 pmos_5p0
M$15 14 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 13.19,3.78 pmos_5p0
M$16 8 6 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $21 r0 *1 5.4,1.005 nmos_5p0
M$21 5 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $22 r0 *1 6.52,1.005 nmos_5p0
M$22 4 7 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 14.88,1.005 nmos_5p0
M$29 1 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 10 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 10 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 11 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 11 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 3.735,3.655 pmos_5p0
M$1 6 5 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.4299P AD=0.1584P PS=2.585U PD=1.6U
* device instance $2 r0 *1 4.99,3.785 pmos_5p0
M$2 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=0.9972P AD=1.3725P PS=5.035U PD=6.99U
* device instance $4 r0 *1 0.87,3.655 pmos_5p0
M$4 2 1 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $5 r0 *1 1.99,3.655 pmos_5p0
M$5 5 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $6 r0 *1 3.685,0.795 nmos_5p0
M$6 6 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.3279P AD=0.1584P PS=2.075U PD=1.6U
* device instance $7 r0 *1 5.04,1.005 nmos_5p0
M$7 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6711P AD=0.9504P PS=3.915U PD=5.4U
* device instance $9 r0 *1 0.92,1.475 nmos_5p0
M$9 3 1 4 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $10 r0 *1 2.04,1.475 nmos_5p0
M$10 5 4 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1346P AD=1.3725P PS=4.9U PD=6.99U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $5 r0 *1 2.04,1.005 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 9 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 9 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 10 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 9 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 10 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 10 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4
