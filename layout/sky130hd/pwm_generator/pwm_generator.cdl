* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pwm_generator clk duty_cycle[0] duty_cycle[1] duty_cycle[2]
+ duty_cycle[3] duty_cycle[4] duty_cycle[5] duty_cycle[6] duty_cycle[7]
+ enable period[0] period[1] period[2] period[3] period[4] period[5]
+ period[6] period[7] pwm_out rst_n
X_123_ counter\[1\] VSS VSS VDD VDD _079_ sky130_fd_sc_hd__inv_1
X_124_ counter\[3\] VSS VSS VDD VDD _082_ sky130_fd_sc_hd__inv_1
X_125_ counter\[2\] VSS VSS VDD VDD _085_ sky130_fd_sc_hd__inv_1
X_126_ counter\[7\] VSS VSS VDD VDD _088_ sky130_fd_sc_hd__inv_1
X_127_ counter\[6\] VSS VSS VDD VDD _091_ sky130_fd_sc_hd__inv_1
X_128_ counter\[5\] VSS VSS VDD VDD _094_ sky130_fd_sc_hd__inv_1
X_129_ counter\[4\] VSS VSS VDD VDD _097_ sky130_fd_sc_hd__inv_1
X_130_ period_reg\[0\] VSS VSS VDD VDD _076_ sky130_fd_sc_hd__inv_1
X_131_ duty_reg\[7\] VSS VSS VDD VDD _102_ sky130_fd_sc_hd__inv_1
X_132_ duty_reg\[6\] VSS VSS VDD VDD _105_ sky130_fd_sc_hd__inv_1
X_133_ duty_reg\[5\] VSS VSS VDD VDD _108_ sky130_fd_sc_hd__inv_1
X_134_ duty_reg\[4\] VSS VSS VDD VDD _111_ sky130_fd_sc_hd__inv_1
X_135_ duty_reg\[3\] VSS VSS VDD VDD _114_ sky130_fd_sc_hd__inv_1
X_136_ duty_reg\[2\] VSS VSS VDD VDD _117_ sky130_fd_sc_hd__inv_1
X_137_ duty_reg\[1\] VSS VSS VDD VDD _120_ sky130_fd_sc_hd__inv_1
X_138_ counter\[0\] VSS VSS VDD VDD _025_ sky130_fd_sc_hd__inv_1
X_139_ net10 VSS VSS VDD VDD _026_ sky130_fd_sc_hd__buf_2
X_140_ _090_ _093_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nand2_1
X_141_ _096_ _098_ _095_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a21oi_1
X_142_ _090_ _092_ _089_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__a21oi_1
X_143_ _027_ _028_ _029_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__o21ai_1
X_144_ _077_ _081_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nor2b_1
X_145_ _080_ _031_ _084_ _087_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__o211ai_1
X_146_ _084_ _086_ _083_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_147_ _090_ _099_ _096_ _093_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand4_1
X_148_ _032_ _033_ _034_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__a21oi_1
X_149_ _081_ _084_ _078_ _087_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nand4_1
X_150_ _034_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2_2
X_151_ _037_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__inv_1
X_152_ _030_ _035_ _025_ net10 _038_ VSS VSS VDD VDD _039_
+ sky130_fd_sc_hd__o2111ai_1
X_153_ _025_ _026_ _039_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o21ai_0
X_154_ _030_ _035_ _038_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__o21ai_2
X_155_ _101_ _026_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nand2_1
X_156_ _079_ _026_ _040_ _041_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o22ai_1
X_157_ _100_ _085_ net10 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__and3_1
X_158_ _100_ _085_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nor2_1
X_159_ _030_ _035_ _042_ _043_ _038_ VSS VSS VDD VDD _044_
+ sky130_fd_sc_hd__o221ai_1
X_160_ _085_ _026_ _044_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__o21ai_0
X_161_ counter\[0\] counter\[2\] counter\[1\] VSS VSS VDD
+ VDD _045_ sky130_fd_sc_hd__nand3_1
X_162_ _045_ counter\[3\] net10 VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nor3b_1
X_163_ counter\[3\] _045_ _046_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__a21oi_1
X_164_ _082_ _026_ _040_ _047_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o22ai_1
X_165_ _100_ counter\[2\] counter\[3\] net10 VSS VSS VDD VDD
+ _048_ sky130_fd_sc_hd__nand4_1
X_166_ _097_ _048_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__xnor2_1
X_167_ _026_ _040_ _049_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__a21oi_1
X_168_ counter\[3\] counter\[4\] net10 VSS VSS VDD VDD _050_
+ sky130_fd_sc_hd__nand3_1
X_169_ _045_ _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nor2_1
X_170_ counter\[5\] _051_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__xnor2_1
X_171_ _026_ _040_ _052_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a21oi_1
X_172_ _097_ _094_ _048_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor3_1
X_173_ counter\[6\] _053_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__xnor2_1
X_174_ _026_ _040_ _054_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a21oi_1
X_175_ counter\[5\] counter\[6\] _051_ VSS VSS VDD VDD _055_
+ sky130_fd_sc_hd__nand3_1
X_176_ _088_ _055_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__xnor2_1
X_177_ _026_ _040_ _056_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__a21oi_1
X_178_ _037_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__buf_6
X_179_ duty_reg\[0\] net2 _057_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__mux2_1
X_180_ _037_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__buf_2
X_181_ net3 _058_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nand2_1
X_182_ _120_ _058_ _059_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__o21ai_0
X_183_ net4 _058_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand2_1
X_184_ _117_ _058_ _060_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__o21ai_0
X_185_ net5 _057_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nand2_1
X_186_ _114_ _058_ _061_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__o21ai_0
X_187_ net6 _057_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand2_1
X_188_ _111_ _058_ _062_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o21ai_0
X_189_ net7 _057_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nand2_1
X_190_ _108_ _058_ _063_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o21ai_0
X_191_ net8 _057_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__nand2_1
X_192_ _105_ _058_ _064_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__o21ai_0
X_193_ net9 _057_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nand2_1
X_194_ _102_ _058_ _065_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__o21ai_0
X_195_ net11 _057_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand2_1
X_196_ _076_ _058_ _066_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__o21ai_0
X_197_ period_reg\[1\] net12 _057_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__mux2_1
X_198_ period_reg\[2\] net13 _057_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__mux2_1
X_199_ period_reg\[3\] net14 _057_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__mux2_1
X_200_ period_reg\[4\] net15 _037_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__mux2_1
X_201_ period_reg\[5\] net16 _037_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__mux2_1
X_202_ period_reg\[6\] net17 _037_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__mux2_1
X_203_ period_reg\[7\] net18 _037_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__mux2_1
X_204_ _112_ _113_ _110_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__o21a_1
X_205_ counter\[0\] duty_reg\[0\] VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nand2b_1
X_206_ _122_ _068_ _121_ _118_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__a211oi_1
X_207_ _119_ _118_ _116_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__o21ai_0
X_208_ _112_ _110_ _109_ _115_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__a211oi_1
X_209_ _069_ _070_ _071_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__o21ai_0
X_210_ _109_ _067_ _072_ _107_ _104_ VSS VSS VDD VDD _073_
+ sky130_fd_sc_hd__o2111ai_1
X_211_ _104_ _106_ _103_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__a21oi_1
X_212_ net10 net20 VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nor2b_1
X_213_ _026_ _073_ _074_ _075_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a31o_1
X_214_ counter\[0\] _076_ VSS VSS VDD VDD _077_ _078_ sky130_fd_sc_hd__ha_1
X_215_ _079_ period_reg\[1\] VSS VSS VDD VDD _080_ _081_ sky130_fd_sc_hd__ha_1
X_216_ _082_ period_reg\[3\] VSS VSS VDD VDD _083_ _084_ sky130_fd_sc_hd__ha_1
X_217_ _085_ period_reg\[2\] VSS VSS VDD VDD _086_ _087_ sky130_fd_sc_hd__ha_1
X_218_ _088_ period_reg\[7\] VSS VSS VDD VDD _089_ _090_ sky130_fd_sc_hd__ha_1
X_219_ _091_ period_reg\[6\] VSS VSS VDD VDD _092_ _093_ sky130_fd_sc_hd__ha_1
X_220_ _094_ period_reg\[5\] VSS VSS VDD VDD _095_ _096_ sky130_fd_sc_hd__ha_1
X_221_ _097_ period_reg\[4\] VSS VSS VDD VDD _098_ _099_ sky130_fd_sc_hd__ha_1
X_222_ counter\[0\] counter\[1\] VSS VSS VDD VDD _100_ _101_
+ sky130_fd_sc_hd__ha_1
X_223_ counter\[7\] _102_ VSS VSS VDD VDD _103_ _104_ sky130_fd_sc_hd__ha_1
X_224_ counter\[6\] _105_ VSS VSS VDD VDD _106_ _107_ sky130_fd_sc_hd__ha_1
X_225_ counter\[5\] _108_ VSS VSS VDD VDD _109_ _110_ sky130_fd_sc_hd__ha_1
X_226_ counter\[4\] _111_ VSS VSS VDD VDD _112_ _113_ sky130_fd_sc_hd__ha_1
X_227_ counter\[3\] _114_ VSS VSS VDD VDD _115_ _116_ sky130_fd_sc_hd__ha_1
X_228_ counter\[2\] _117_ VSS VSS VDD VDD _118_ _119_ sky130_fd_sc_hd__ha_1
X_229_ counter\[1\] _120_ VSS VSS VDD VDD _121_ _122_ sky130_fd_sc_hd__ha_1
Xcounter\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _000_ net1
+ VSS VSS VDD VDD counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _001_ net1
+ VSS VSS VDD VDD counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _002_ net1
+ VSS VSS VDD VDD counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _003_ net1
+ VSS VSS VDD VDD counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _004_ net1
+ VSS VSS VDD VDD counter\[4\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _005_ net1
+ VSS VSS VDD VDD counter\[5\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_ net1
+ VSS VSS VDD VDD counter\[6\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _007_ net1
+ VSS VSS VDD VDD counter\[7\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _008_ net1
+ VSS VSS VDD VDD duty_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _009_ net1
+ VSS VSS VDD VDD duty_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _010_ net1
+ VSS VSS VDD VDD duty_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _011_ net1
+ VSS VSS VDD VDD duty_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _012_ net1
+ VSS VSS VDD VDD duty_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _013_ net1
+ VSS VSS VDD VDD duty_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _014_ net1
+ VSS VSS VDD VDD duty_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xduty_reg\[7\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _015_ net19
+ VSS VSS VDD VDD duty_reg\[7\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[0\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _016_ net19
+ VSS VSS VDD VDD period_reg\[0\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[1\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _017_ net19
+ VSS VSS VDD VDD period_reg\[1\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[2\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _018_ net19
+ VSS VSS VDD VDD period_reg\[2\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[3\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _019_ net19
+ VSS VSS VDD VDD period_reg\[3\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[4\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _020_ net19
+ VSS VSS VDD VDD period_reg\[4\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[5\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _021_ net19
+ VSS VSS VDD VDD period_reg\[5\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[6\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _022_ net19
+ VSS VSS VDD VDD period_reg\[6\] sky130_fd_sc_hd__dfstp_1
Xperiod_reg\[7\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _023_ net19
+ VSS VSS VDD VDD period_reg\[7\] sky130_fd_sc_hd__dfstp_1
Xpwm_out$_DFFE_PN0P_ clknet_1_1__leaf_clk _024_ net1 VSS VSS
+ VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xhold1 net19 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 duty_cycle[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 duty_cycle[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 duty_cycle[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 duty_cycle[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 duty_cycle[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 duty_cycle[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 duty_cycle[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 duty_cycle[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 enable VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_2
Xinput10 period[0] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 period[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 period[2] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 period[3] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 period[4] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 period[5] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 period[6] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 period[7] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 net21 VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_4
Xoutput19 net20 VSS VSS VDD VDD pwm_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_4
Xhold2 rst_n VSS VSS VDD VDD net21 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS pwm_generator
