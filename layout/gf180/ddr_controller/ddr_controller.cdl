* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT ddr_controller clk cmd_addr[0] cmd_addr[10] cmd_addr[11]
+ cmd_addr[12] cmd_addr[13] cmd_addr[14] cmd_addr[15] cmd_addr[16]
+ cmd_addr[17] cmd_addr[18] cmd_addr[19] cmd_addr[1] cmd_addr[20]
+ cmd_addr[21] cmd_addr[22] cmd_addr[23] cmd_addr[24] cmd_addr[25]
+ cmd_addr[26] cmd_addr[27] cmd_addr[2] cmd_addr[3] cmd_addr[4]
+ cmd_addr[5] cmd_addr[6] cmd_addr[7] cmd_addr[8] cmd_addr[9]
+ cmd_burst_len[0] cmd_burst_len[1] cmd_burst_len[2] cmd_burst_len[3]
+ cmd_ready cmd_valid cmd_write init_done phy_addr[0] phy_addr[10]
+ phy_addr[11] phy_addr[12] phy_addr[13] phy_addr[1] phy_addr[2]
+ phy_addr[3] phy_addr[4] phy_addr[5] phy_addr[6] phy_addr[7]
+ phy_addr[8] phy_addr[9] phy_bank[0] phy_bank[1] phy_bank[2]
+ phy_bank_group[0] phy_bank_group[1] phy_cas_n phy_cke phy_clk
+ phy_cs_n phy_dm[0] phy_dm[1] phy_dm[2] phy_dm[3] phy_dm[4]
+ phy_dm[5] phy_dm[6] phy_dm[7] phy_dq[0] phy_dq[10] phy_dq[11]
+ phy_dq[12] phy_dq[13] phy_dq[14] phy_dq[15] phy_dq[16] phy_dq[17]
+ phy_dq[18] phy_dq[19] phy_dq[1] phy_dq[20] phy_dq[21] phy_dq[22]
+ phy_dq[23] phy_dq[24] phy_dq[25] phy_dq[26] phy_dq[27] phy_dq[28]
+ phy_dq[29] phy_dq[2] phy_dq[30] phy_dq[31] phy_dq[32] phy_dq[33]
+ phy_dq[34] phy_dq[35] phy_dq[36] phy_dq[37] phy_dq[38] phy_dq[39]
+ phy_dq[3] phy_dq[40] phy_dq[41] phy_dq[42] phy_dq[43] phy_dq[44]
+ phy_dq[45] phy_dq[46] phy_dq[47] phy_dq[48] phy_dq[49] phy_dq[4]
+ phy_dq[50] phy_dq[51] phy_dq[52] phy_dq[53] phy_dq[54] phy_dq[55]
+ phy_dq[56] phy_dq[57] phy_dq[58] phy_dq[59] phy_dq[5] phy_dq[60]
+ phy_dq[61] phy_dq[62] phy_dq[63] phy_dq[6] phy_dq[7] phy_dq[8]
+ phy_dq[9] phy_dqs_n[0] phy_dqs_n[1] phy_dqs_n[2] phy_dqs_n[3]
+ phy_dqs_n[4] phy_dqs_n[5] phy_dqs_n[6] phy_dqs_n[7] phy_dqs_p[0]
+ phy_dqs_p[1] phy_dqs_p[2] phy_dqs_p[3] phy_dqs_p[4] phy_dqs_p[5]
+ phy_dqs_p[6] phy_dqs_p[7] phy_odt phy_ras_n phy_reset_n phy_we_n
+ rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[32] rd_data[33] rd_data[34] rd_data[35] rd_data[36]
+ rd_data[37] rd_data[38] rd_data[39] rd_data[3] rd_data[40]
+ rd_data[41] rd_data[42] rd_data[43] rd_data[44] rd_data[45]
+ rd_data[46] rd_data[47] rd_data[48] rd_data[49] rd_data[4]
+ rd_data[50] rd_data[51] rd_data[52] rd_data[53] rd_data[54]
+ rd_data[55] rd_data[56] rd_data[57] rd_data[58] rd_data[59]
+ rd_data[5] rd_data[60] rd_data[61] rd_data[62] rd_data[63]
+ rd_data[6] rd_data[7] rd_data[8] rd_data[9] rd_ready rd_valid
+ rst_n state[0] state[1] wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[32] wr_data[33] wr_data[34]
+ wr_data[35] wr_data[36] wr_data[37] wr_data[38] wr_data[39]
+ wr_data[3] wr_data[40] wr_data[41] wr_data[42] wr_data[43]
+ wr_data[44] wr_data[45] wr_data[46] wr_data[47] wr_data[48]
+ wr_data[49] wr_data[4] wr_data[50] wr_data[51] wr_data[52]
+ wr_data[53] wr_data[54] wr_data[55] wr_data[56] wr_data[57]
+ wr_data[58] wr_data[59] wr_data[5] wr_data[60] wr_data[61]
+ wr_data[62] wr_data[63] wr_data[6] wr_data[7] wr_data[8] wr_data[9]
+ wr_mask[0] wr_mask[1] wr_mask[2] wr_mask[3] wr_mask[4] wr_mask[5]
+ wr_mask[6] wr_mask[7] wr_ready wr_valid VSS VDD
X_0888_ _0546_ _0776_ _0802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput89 wr_data[38] net88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0890_ _0521_ _0804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_0891_ net232 _0804_ _0805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0892_ net232 net231 _0805_ _0806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0893_ _0793_ _0806_ _0807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput88 wr_data[37] net87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput87 wr_data[36] net86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0896_ net233 _0788_ net234 _0810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0897_ _0801_ _0802_ _0807_ _0810_ _0841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_0898_ net52 _0811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0899_ _0811_ _0519_ _0520_ _0812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_0900_ _0812_ _0776_ _0813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0901_ _0545_ _0813_ _0814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0902_ _0795_ _0798_ _0814_ _0842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_0903_ _0793_ net231 _0815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0904_ init_state\[7\] _0514_ _0816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0905_ _0815_ _0816_ _0801_ _0817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput86 wr_data[35] net85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0907_ refresh_counter\[0\] _0023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0908_ _0023_ _0543_ _0819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0909_ _0817_ _0819_ _0843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0910_ _0025_ _0820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0911_ refresh_counter\[1\] _0820_ _0543_ _0821_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0912_ _0817_ _0821_ _0850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0913_ _0026_ _0543_ _0822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0914_ refresh_counter\[2\] _0822_ _0823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0915_ _0817_ _0823_ _0851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0916_ refresh_counter\[2\] refresh_counter\[1\] refresh_counter\[0\]
+ _0543_ _0824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_0917_ refresh_counter\[3\] _0824_ _0825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_0918_ _0817_ _0825_ _0852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0919_ refresh_counter\[2\] _0026_ _0543_ _0826_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0920_ refresh_counter\[3\] _0826_ _0827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0921_ refresh_counter\[4\] _0827_ _0828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0922_ _0817_ _0828_ _0853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0923_ refresh_counter\[4\] refresh_counter\[3\] _0824_ _0829_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0924_ refresh_counter\[5\] _0829_ _0830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_0925_ _0817_ _0830_ _0854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0926_ refresh_counter\[5\] refresh_counter\[4\] refresh_counter\[3\]
+ _0826_ _0831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_0927_ refresh_counter\[6\] _0831_ _0832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_0928_ _0817_ _0832_ _0855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0929_ refresh_counter\[6\] refresh_counter\[5\] refresh_counter\[4\]
+ refresh_counter\[3\] _0833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_0930_ _0824_ _0833_ _0834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0931_ _0536_ _0834_ _0835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0932_ _0817_ _0835_ _0856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0933_ refresh_counter\[2\] _0026_ _0543_ _0836_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0934_ refresh_counter\[7\] _0833_ _0837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0935_ _0836_ _0837_ _0838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0936_ refresh_counter\[8\] _0838_ _0251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0937_ _0817_ _0251_ _0857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0938_ refresh_counter\[8\] _0837_ _0252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0939_ _0824_ _0252_ _0253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0940_ refresh_counter\[9\] _0253_ _0254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_0941_ _0817_ _0254_ _0858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0942_ refresh_counter\[9\] _0836_ _0252_ _0255_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0943_ refresh_counter\[10\] _0255_ _0256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0944_ _0817_ _0256_ _0844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0945_ refresh_counter\[11\] _0817_ _0845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0946_ refresh_counter\[12\] _0817_ _0846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0947_ refresh_counter\[13\] _0817_ _0847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0948_ refresh_counter\[14\] _0817_ _0848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0949_ refresh_counter\[15\] _0817_ _0849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0950_ _0033_ _0509_ _0257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0951_ _0035_ _0509_ _0258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0952_ _0511_ _0520_ _0259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_0953_ net153 _0530_ _0259_ _0260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_0954_ _0257_ _0258_ _0260_ _0261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0955_ net218 net55 _0262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0956_ net121 _0262_ net153 _0263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0957_ _0530_ _0263_ _0264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0958_ _0030_ _0791_ _0264_ _0265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0959_ _0261_ _0265_ _0266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0960_ _0510_ _0258_ _0267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0961_ timer\[0\] _0260_ _0267_ _0268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_0962_ _0266_ _0268_ _0269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput85 wr_data[34] net84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0964_ net234 _0804_ _0271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0965_ net234 _0528_ _0272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0966_ _0804_ _0272_ _0273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0967_ _0030_ _0274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0968_ init_state\[2\] _0787_ _0275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0969_ init_state\[4\] init_state\[3\] init_state\[0\] _0275_
+ _0276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_0970_ _0274_ _0029_ _0276_ _0277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0971_ _0794_ _0796_ _0278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0972_ _0795_ _0031_ _0278_ _0279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0973_ net233 _0277_ _0279_ _0280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0974_ _0269_ _0271_ _0273_ _0030_ _0280_ _0281_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_0975_ _0546_ _0281_ _0278_ _0282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0976_ _0545_ _0813_ _0281_ _0283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0977_ _0030_ _0282_ _0283_ _0859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0978_ timer\[1\] _0032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0979_ _0801_ _0778_ _0284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_0980_ net52 _0278_ timer\[1\] _0285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0981_ _0034_ _0285_ _0521_ _0286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_0982_ init_state\[4\] init_state\[3\] init_state\[0\] _0287_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_0983_ timer\[1\] _0287_ _0288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0984_ _0804_ _0275_ _0288_ net233 _0289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_0985_ _0278_ _0800_ _0289_ _0290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0986_ net153 _0530_ _0259_ _0291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_0987_ _0035_ _0509_ _0292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_0988_ net153 _0510_ _0530_ _0259_ _0293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_0989_ _0291_ _0292_ _0264_ _0293_ _0294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_0990_ _0294_ _0295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_0991_ _0290_ _0295_ _0034_ _0296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_0992_ _0513_ _0528_ _0297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_0993_ timer\[1\] _0297_ net234 _0298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0994_ _0290_ _0298_ _0299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput84 wr_data[33] net83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_0996_ timer\[1\] _0804_ _0278_ _0300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_0997_ _0521_ _0296_ _0299_ _0300_ _0301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_0998_ _0284_ _0286_ _0301_ _0866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_0999_ init_state\[0\] _0804_ net233 _0302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1000_ net234 _0294_ _0303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1001_ net231 _0797_ _0303_ _0804_ _0304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1002_ _0800_ _0302_ _0304_ _0305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1003_ timer\[2\] _0033_ _0306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1004_ _0305_ _0306_ _0307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1005_ net231 _0784_ _0308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1006_ net231 _0776_ _0309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1007_ net53 _0812_ _0309_ _0310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1008_ _0307_ _0308_ _0310_ _0867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1009_ init_state\[4\] init_state\[3\] _0275_ net233 _0311_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1010_ _0795_ net53 _0528_ _0523_ _0311_ _0312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_1011_ net233 _0303_ _0804_ _0313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1012_ timer\[2\] timer\[0\] timer\[1\] timer\[3\] _0314_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1013_ timer\[0\] _0027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1014_ _0027_ _0032_ _0509_ _0315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1015_ _0314_ _0315_ _0316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1016_ _0800_ _0313_ _0316_ _0317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1017_ _0521_ _0312_ _0317_ _0797_ _0318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1018_ net52 _0312_ _0278_ _0319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1019_ _0316_ _0319_ _0521_ _0320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1020_ _0284_ _0318_ _0320_ _0868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1021_ _0528_ _0294_ _0804_ _0321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1022_ net234 _0321_ _0322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1023_ _0793_ _0276_ _0278_ _0323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1024_ net233 _0804_ _0323_ _0324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1025_ _0795_ _0780_ _0322_ _0324_ _0325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_1026_ timer\[4\] _0259_ _0326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1027_ timer\[4\] _0326_ _0257_ _0327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1028_ _0325_ _0327_ _0328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1029_ _0308_ _0328_ _0869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1030_ _0792_ _0294_ net232 _0545_ _0329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1031_ _0278_ _0302_ _0329_ _0330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1032_ timer\[4\] _0315_ timer\[5\] _0331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1033_ _0511_ _0315_ _0332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1034_ _0804_ _0331_ _0332_ _0333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1035_ _0521_ _0302_ _0330_ _0333_ _0870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1036_ _0545_ _0812_ _0323_ net232 _0334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1037_ _0523_ _0261_ _0264_ _0334_ _0335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1038_ _0804_ _0275_ _0336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1039_ _0287_ _0336_ _0337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1040_ _0804_ _0335_ _0337_ net233 _0338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1041_ timer\[6\] _0519_ _0339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_1042_ _0338_ _0339_ _0871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1043_ timer\[6\] _0332_ _0340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1044_ timer\[7\] _0340_ _0341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1045_ init_state\[0\] _0275_ _0342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1046_ _0804_ _0342_ _0343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1047_ init_state\[4\] init_state\[3\] _0343_ _0344_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1048_ _0523_ _0295_ _0334_ _0345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1049_ net233 _0344_ _0345_ _0804_ _0346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1050_ _0804_ _0341_ _0346_ _0872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1051_ net233 _0345_ _0347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1052_ _0804_ _0347_ _0348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1053_ timer\[7\] timer\[6\] _0519_ _0349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_1054_ timer\[8\] _0349_ _0350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_1055_ _0348_ _0350_ _0873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1056_ timer\[7\] timer\[6\] timer\[8\] _0332_ _0351_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1057_ timer\[9\] _0351_ _0352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1058_ _0348_ _0352_ _0874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1059_ _0519_ _0507_ _0353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1060_ timer\[10\] _0353_ _0354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_1061_ _0348_ _0354_ _0860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1062_ _0507_ _0332_ _0355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1063_ timer\[10\] _0355_ _0356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1064_ timer\[11\] _0356_ _0357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1065_ _0348_ _0357_ _0861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1066_ _0324_ _0329_ _0358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1067_ timer\[15\] timer\[14\] _0508_ _0359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_1068_ timer\[12\] _0359_ _0360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1069_ timer\[10\] timer\[11\] _0519_ _0507_ _0361_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1070_ _0360_ timer\[12\] _0361_ _0362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1071_ _0358_ _0362_ _0862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1072_ timer\[10\] timer\[11\] timer\[12\] _0355_ _0363_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1073_ timer\[13\] _0363_ _0364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1074_ _0804_ _0347_ _0364_ _0863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1075_ _0519_ _0507_ _0508_ _0365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1076_ timer\[14\] _0365_ _0366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1077_ _0348_ _0366_ _0864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1078_ timer\[14\] _0508_ _0355_ _0367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1079_ timer\[15\] _0367_ _0368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1080_ _0348_ _0368_ _0865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1081_ net234 net153 _0530_ _0369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
Xinput83 wr_data[32] net82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput82 wr_data[31] net81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1084_ _0033_ net55 _0528_ _0372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1085_ _0259_ _0267_ _0369_ _0372_ _0000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1086_ net138 _0009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1087_ net219 _0036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1088_ net139 _0010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1089_ burst_counter\[1\] _0020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1090_ net220 _0037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1091_ net56 net232 _0513_ _0373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1092_ _0016_ _0373_ _0374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput81 wr_data[30] net80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1094_ active_row\[0\]\[0\] net124 _0374_ _0043_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1095_ active_row\[0\]\[10\] net125 _0374_ _0044_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1096_ active_row\[0\]\[11\] net126 _0374_ _0045_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1097_ active_row\[0\]\[12\] net127 _0374_ _0046_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1098_ active_row\[0\]\[13\] net128 _0374_ _0047_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1099_ active_row\[0\]\[1\] net129 _0374_ _0048_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1100_ active_row\[0\]\[2\] net130 _0374_ _0049_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1101_ active_row\[0\]\[3\] net131 _0374_ _0050_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1102_ active_row\[0\]\[4\] net132 _0374_ _0051_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1103_ active_row\[0\]\[5\] net133 _0374_ _0052_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1104_ active_row\[0\]\[6\] net134 _0374_ _0053_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1105_ active_row\[0\]\[7\] net135 _0374_ _0054_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1106_ active_row\[0\]\[8\] net136 _0374_ _0055_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1107_ active_row\[0\]\[9\] net137 _0374_ _0056_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1108_ _0015_ _0373_ _0376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1109_ _0013_ _0376_ _0377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput80 wr_data[2] net79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1111_ active_row\[1\]\[0\] net124 _0377_ _0057_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1112_ active_row\[1\]\[10\] net125 _0377_ _0058_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1113_ active_row\[1\]\[11\] net126 _0377_ _0059_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1114_ active_row\[1\]\[12\] net127 _0377_ _0060_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1115_ active_row\[1\]\[13\] net128 _0377_ _0061_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1116_ active_row\[1\]\[1\] net129 _0377_ _0062_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1117_ active_row\[1\]\[2\] net130 _0377_ _0063_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1118_ active_row\[1\]\[3\] net131 _0377_ _0064_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1119_ active_row\[1\]\[4\] net132 _0377_ _0065_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1120_ active_row\[1\]\[5\] net133 _0377_ _0066_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1121_ active_row\[1\]\[6\] net134 _0377_ _0067_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1122_ active_row\[1\]\[7\] net135 _0377_ _0068_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1123_ active_row\[1\]\[8\] net136 _0377_ _0069_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1124_ active_row\[1\]\[9\] net137 _0377_ _0070_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1125_ _0012_ _0376_ _0379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput79 wr_data[29] net78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1127_ active_row\[2\]\[0\] net124 _0379_ _0071_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1128_ active_row\[2\]\[10\] net125 _0379_ _0072_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1129_ active_row\[2\]\[11\] net126 _0379_ _0073_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1130_ active_row\[2\]\[12\] net127 _0379_ _0074_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1131_ active_row\[2\]\[13\] net128 _0379_ _0075_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1132_ active_row\[2\]\[1\] net129 _0379_ _0076_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1133_ active_row\[2\]\[2\] net130 _0379_ _0077_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1134_ active_row\[2\]\[3\] net131 _0379_ _0078_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1135_ active_row\[2\]\[4\] net132 _0379_ _0079_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1136_ active_row\[2\]\[5\] net133 _0379_ _0080_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1137_ active_row\[2\]\[6\] net134 _0379_ _0081_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1138_ active_row\[2\]\[7\] net135 _0379_ _0082_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1139_ active_row\[2\]\[8\] net136 _0379_ _0083_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1140_ active_row\[2\]\[9\] net137 _0379_ _0084_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1141_ _0014_ _0376_ _0381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput78 wr_data[28] net77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1143_ active_row\[3\]\[0\] net124 _0381_ _0085_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1144_ active_row\[3\]\[10\] net125 _0381_ _0086_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1145_ active_row\[3\]\[11\] net126 _0381_ _0087_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1146_ active_row\[3\]\[12\] net127 _0381_ _0088_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1147_ active_row\[3\]\[13\] net128 _0381_ _0089_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1148_ active_row\[3\]\[1\] net129 _0381_ _0090_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1149_ active_row\[3\]\[2\] net130 _0381_ _0091_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1150_ active_row\[3\]\[3\] net131 _0381_ _0092_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1151_ active_row\[3\]\[4\] net132 _0381_ _0093_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1152_ active_row\[3\]\[5\] net133 _0381_ _0094_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1153_ active_row\[3\]\[6\] net134 _0381_ _0095_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1154_ active_row\[3\]\[7\] net135 _0381_ _0096_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1155_ active_row\[3\]\[8\] net136 _0381_ _0097_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1156_ active_row\[3\]\[9\] net137 _0381_ _0098_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1157_ _0018_ _0373_ _0383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput77 wr_data[27] net76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1159_ active_row\[4\]\[0\] net124 _0383_ _0099_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1160_ active_row\[4\]\[10\] net125 _0383_ _0100_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1161_ active_row\[4\]\[11\] net126 _0383_ _0101_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1162_ active_row\[4\]\[12\] net127 _0383_ _0102_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1163_ active_row\[4\]\[13\] net128 _0383_ _0103_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1164_ active_row\[4\]\[1\] net129 _0383_ _0104_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1165_ active_row\[4\]\[2\] net130 _0383_ _0105_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1166_ active_row\[4\]\[3\] net131 _0383_ _0106_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1167_ active_row\[4\]\[4\] net132 _0383_ _0107_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1168_ active_row\[4\]\[5\] net133 _0383_ _0108_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1169_ active_row\[4\]\[6\] net134 _0383_ _0109_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1170_ active_row\[4\]\[7\] net135 _0383_ _0110_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1171_ active_row\[4\]\[8\] net136 _0383_ _0111_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1172_ active_row\[4\]\[9\] net137 _0383_ _0112_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1173_ net140 _0013_ _0373_ _0385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput76 wr_data[26] net75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1175_ active_row\[5\]\[0\] net124 _0385_ _0113_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1176_ active_row\[5\]\[10\] net125 _0385_ _0114_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1177_ active_row\[5\]\[11\] net126 _0385_ _0115_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1178_ active_row\[5\]\[12\] net127 _0385_ _0116_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1179_ active_row\[5\]\[13\] net128 _0385_ _0117_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1180_ active_row\[5\]\[1\] net129 _0385_ _0118_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1181_ active_row\[5\]\[2\] net130 _0385_ _0119_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1182_ active_row\[5\]\[3\] net131 _0385_ _0120_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1183_ active_row\[5\]\[4\] net132 _0385_ _0121_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1184_ active_row\[5\]\[5\] net133 _0385_ _0122_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1185_ active_row\[5\]\[6\] net134 _0385_ _0123_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1186_ active_row\[5\]\[7\] net135 _0385_ _0124_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1187_ active_row\[5\]\[8\] net136 _0385_ _0125_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1188_ active_row\[5\]\[9\] net137 _0385_ _0126_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1189_ net140 _0012_ _0373_ _0387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput75 wr_data[25] net74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1191_ active_row\[6\]\[0\] net124 _0387_ _0127_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1192_ active_row\[6\]\[10\] net125 _0387_ _0128_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1193_ active_row\[6\]\[11\] net126 _0387_ _0129_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1194_ active_row\[6\]\[12\] net127 _0387_ _0130_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1195_ active_row\[6\]\[13\] net128 _0387_ _0131_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1196_ active_row\[6\]\[1\] net129 _0387_ _0132_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1197_ active_row\[6\]\[2\] net130 _0387_ _0133_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1198_ active_row\[6\]\[3\] net131 _0387_ _0134_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1199_ active_row\[6\]\[4\] net132 _0387_ _0135_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1200_ active_row\[6\]\[5\] net133 _0387_ _0136_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1201_ active_row\[6\]\[6\] net134 _0387_ _0137_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1202_ active_row\[6\]\[7\] net135 _0387_ _0138_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1203_ active_row\[6\]\[8\] net136 _0387_ _0139_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1204_ active_row\[6\]\[9\] net137 _0387_ _0140_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1205_ net140 _0014_ _0373_ _0389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput74 wr_data[24] net73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1207_ active_row\[7\]\[0\] net124 _0389_ _0141_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1208_ active_row\[7\]\[10\] net125 _0389_ _0142_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1209_ active_row\[7\]\[11\] net126 _0389_ _0143_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1210_ active_row\[7\]\[12\] net127 _0389_ _0144_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1211_ active_row\[7\]\[13\] net128 _0389_ _0145_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1212_ active_row\[7\]\[1\] net129 _0389_ _0146_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1213_ active_row\[7\]\[2\] net130 _0389_ _0147_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1214_ active_row\[7\]\[3\] net131 _0389_ _0148_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1215_ active_row\[7\]\[4\] net132 _0389_ _0149_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1216_ active_row\[7\]\[5\] net133 _0389_ _0150_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1217_ active_row\[7\]\[6\] net134 _0389_ _0151_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1218_ active_row\[7\]\[7\] net135 _0389_ _0152_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1219_ active_row\[7\]\[8\] net136 _0389_ _0153_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1220_ active_row\[7\]\[9\] net137 _0389_ _0154_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1221_ net231 _0812_ _0391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1222_ _0278_ _0273_ _0308_ _0391_ _0392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_1223_ _0788_ _0393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1224_ _0804_ _0796_ net233 _0394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1225_ _0393_ _0394_ _0395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1226_ _0392_ _0395_ _0396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1227_ init_state\[5\] init_state\[1\] _0397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1228_ _0393_ _0394_ _0392_ _0398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1229_ _0793_ _0397_ _0398_ _0399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1230_ net124 _0396_ _0399_ _0400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1231_ net25 net21 _0776_ _0401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput73 wr_data[23] net72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1233_ _0793_ _0805_ _0403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1234_ _0397_ _0403_ _0398_ net234 _0404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1235_ _0404_ _0405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1236_ net232 net21 _0401_ net231 _0405_ _0406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1237_ _0400_ _0406_ _0155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1238_ _0392_ _0394_ _0407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1239_ _0780_ _0776_ _0408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
Xinput72 wr_data[22] net71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1241_ _0392_ _0394_ _0410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1242_ net125 _0398_ _0410_ net234 _0411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1243_ _0767_ _0407_ _0408_ _0411_ _0156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1244_ _0793_ _0523_ _0412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1245_ _0412_ _0805_ _0392_ _0413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1246_ _0709_ _0408_ _0414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1247_ init_state\[5\] _0415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1248_ net233 _0415_ init_state\[1\] _0396_ _0416_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1249_ net126 _0396_ _0417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1250_ _0413_ _0414_ _0416_ _0417_ _0157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1251_ net127 _0398_ _0410_ net234 _0418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1252_ _0640_ _0407_ _0408_ _0418_ _0158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1253_ net128 _0398_ _0410_ net234 _0419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1254_ _0757_ _0407_ _0408_ _0419_ _0159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1255_ net129 _0396_ _0399_ _0420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1256_ net26 net31 _0776_ _0421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1257_ net232 net31 _0421_ net231 _0405_ _0422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1258_ _0420_ _0422_ _0160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1259_ net27 net40 _0776_ _0423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1260_ net232 net40 _0424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1261_ _0412_ _0424_ _0425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1262_ net231 _0423_ _0425_ _0426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1263_ init_state\[1\] _0521_ _0392_ _0427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1264_ _0410_ _0427_ _0428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1265_ net130 _0398_ _0429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1266_ _0426_ _0428_ _0429_ _0161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1267_ net28 net41 _0776_ _0430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1268_ net232 net41 _0430_ net231 net234 _0431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1269_ net131 _0398_ _0432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1270_ _0407_ _0431_ _0432_ _0162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1271_ net29 net42 _0776_ _0433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1272_ net232 net42 _0433_ net231 net234 _0434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1273_ net233 init_state\[5\] _0396_ _0435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1274_ net132 _0398_ _0435_ _0436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1275_ _0407_ _0434_ _0436_ _0163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1276_ net133 _0396_ _0399_ _0437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1277_ net30 net43 _0776_ _0438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1278_ net232 net43 _0438_ net231 _0405_ _0439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1279_ _0437_ _0439_ _0164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1280_ net32 net44 _0776_ _0440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1281_ net232 net44 _0440_ net231 net234 _0441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1282_ net134 _0398_ _0435_ _0442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1283_ _0407_ _0441_ _0442_ _0165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1284_ net33 net45 _0776_ _0443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1285_ net232 net45 _0443_ net231 net234 _0444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1286_ net135 _0398_ _0445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1287_ _0407_ _0444_ _0445_ _0166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1288_ net136 _0446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1289_ net34 net46 _0776_ _0447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1290_ _0413_ _0448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1291_ net232 net46 _0447_ net231 _0448_ _0449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1292_ _0446_ _0398_ _0416_ _0449_ _0167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1293_ net35 net47 _0776_ _0450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1294_ net232 net47 _0450_ net231 net234 _0451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1295_ net137 _0398_ _0435_ _0452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1296_ _0407_ _0451_ _0452_ _0168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1297_ _0521_ _0272_ _0453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1298_ _0796_ _0453_ _0794_ _0454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1299_ net234 _0454_ _0455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1300_ _0017_ _0456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1301_ _0456_ _0454_ _0457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1302_ _0011_ _0458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1303_ _0015_ _0010_ _0009_ _0458_ _0459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1304_ _0457_ _0459_ bank_active\[0\] _0460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1305_ _0455_ _0460_ _0169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1306_ _0017_ _0454_ _0461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1307_ _0013_ _0461_ bank_active\[1\] _0462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1308_ _0455_ _0462_ _0170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1309_ _0015_ _0010_ _0463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1310_ _0009_ _0011_ _0463_ _0464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1311_ _0461_ _0464_ bank_active\[2\] _0465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1312_ _0455_ _0465_ _0171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1313_ _0014_ _0461_ bank_active\[3\] _0466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1314_ _0455_ _0466_ _0172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1315_ _0009_ _0458_ _0463_ _0461_ _0467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1316_ bank_active\[4\] _0467_ _0468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1317_ _0455_ _0468_ _0173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1318_ _0013_ _0457_ bank_active\[5\] _0469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1319_ _0455_ _0469_ _0174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1320_ _0457_ _0464_ bank_active\[6\] _0470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1321_ _0455_ _0470_ _0175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1322_ _0014_ _0457_ bank_active\[7\] _0471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1323_ _0455_ _0471_ _0176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1324_ init_state\[1\] net239 net231 _0472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1325_ net231 _0811_ _0473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1326_ _0793_ _0787_ _0474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1327_ _0521_ _0794_ _0473_ _0474_ _0475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1328_ _0308_ _0475_ _0476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1329_ net138 _0472_ _0476_ _0177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1330_ net23 _0397_ _0780_ _0477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1331_ net139 _0477_ _0476_ _0178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1332_ net238 _0545_ _0475_ _0478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1333_ _0015_ _0476_ _0478_ _0179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1334_ net48 _0019_ net234 _0479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1335_ _0812_ _0708_ _0743_ _0775_ _0480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1336_ _0523_ _0805_ _0481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1337_ net231 _0784_ _0297_ _0481_ net233 _0482_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_1338_ _0482_ _0483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_1339_ _0545_ _0480_ _0483_ _0484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_1340_ burst_counter\[0\] _0479_ _0484_ _0180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1341_ _0022_ _0485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1342_ net49 _0485_ net234 _0486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1343_ burst_counter\[1\] _0486_ _0484_ _0181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_1344_ net234 _0790_ _0021_ _0484_ _0487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1345_ net234 burst_counter\[2\] _0527_ _0488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1346_ _0523_ net50 _0489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1347_ burst_counter\[2\] _0489_ _0484_ _0490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1348_ _0487_ _0488_ _0490_ _0182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1349_ _0801_ _0802_ _0482_ _0491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1350_ _0523_ net51 _0492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1351_ burst_counter\[2\] burst_counter\[1\] burst_counter\[0\]
+ _0493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1352_ net234 burst_counter\[3\] _0493_ _0494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1353_ _0523_ burst_counter\[3\] _0493_ _0495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1354_ _0789_ _0495_ _0484_ _0496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1355_ _0491_ _0492_ _0494_ _0496_ _0183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1356_ _0795_ _0039_ _0309_ _0497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1357_ init_state\[7\] _0521_ _0498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1358_ _0498_ _0394_ _0499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1359_ _0392_ _0499_ _0500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1360_ net219 _0497_ _0500_ _0184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1361_ net220 _0039_ _0500_ _0185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1362_ net123 _0816_ _0186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1363_ net154 net57 _0369_ _0187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1364_ net155 net58 _0369_ _0188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1365_ net156 net59 _0369_ _0189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1366_ net157 net60 _0369_ _0190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1367_ net158 net61 _0369_ _0191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1368_ net159 net62 _0369_ _0192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1369_ net160 net63 _0369_ _0193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1370_ net161 net64 _0369_ _0194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1371_ net162 net65 _0369_ _0195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput71 wr_data[21] net70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1373_ net163 net66 _0369_ _0196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1374_ net164 net67 net230 _0197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1375_ net165 net68 net230 _0198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1376_ net166 net69 _0369_ _0199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1377_ net167 net70 _0369_ _0200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1378_ net168 net71 _0369_ _0201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1379_ net169 net72 net230 _0202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1380_ net170 net73 net230 _0203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1381_ net171 net74 net230 _0204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1382_ net172 net75 _0369_ _0205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput70 wr_data[20] net69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1384_ net173 net76 net230 _0206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1385_ net174 net77 net230 _0207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1386_ net175 net78 net230 _0208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1387_ net176 net79 net230 _0209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1388_ net177 net80 net230 _0210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1389_ net178 net81 net230 _0211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1390_ net179 net82 net230 _0212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1391_ net180 net83 net230 _0213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1392_ net181 net84 net230 _0214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1393_ net182 net85 net230 _0215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput69 wr_data[1] net68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1395_ net183 net86 _0369_ _0216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1396_ net184 net87 _0369_ _0217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1397_ net185 net88 net230 _0218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1398_ net186 net89 _0369_ _0219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1399_ net187 net90 _0369_ _0220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1400_ net188 net91 net230 _0221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1401_ net189 net92 _0369_ _0222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1402_ net190 net93 _0369_ _0223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1403_ net191 net94 net230 _0224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1404_ net192 net95 net230 _0225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput68 wr_data[19] net67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1406_ net193 net96 net230 _0226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1407_ net194 net97 net230 _0227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1408_ net195 net98 net230 _0228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1409_ net196 net99 net230 _0229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1410_ net197 net100 net230 _0230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1411_ net198 net101 net230 _0231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1412_ net199 net102 net230 _0232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1413_ net200 net103 net230 _0233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1414_ net201 net104 net230 _0234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1415_ net202 net105 net230 _0235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput67 wr_data[18] net66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1417_ net203 net106 net230 _0236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1418_ net204 net107 net230 _0237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1419_ net205 net108 net230 _0238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1420_ net206 net109 net230 _0239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1421_ net207 net110 _0369_ _0240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1422_ net208 net111 net230 _0241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1423_ net209 net112 _0369_ _0242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1424_ net210 net113 net230 _0243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1425_ net211 net114 net230 _0244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1426_ net212 net115 _0369_ _0245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1427_ net213 net116 _0369_ _0246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1428_ net214 net117 _0369_ _0247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1429_ net215 net118 net230 _0248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1430_ net216 net119 _0369_ _0249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1431_ net217 net120 net230 _0250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1432_ net231 _0521_ _0543_ net122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1433_ cmd_reg_valid net142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1434_ init_state\[7\] init_state\[3\] _0275_ _0506_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1435_ net236 _0506_ net152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1436_ timer\[7\] timer\[6\] timer\[9\] timer\[8\] _0507_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1437_ timer\[10\] timer\[11\] timer\[13\] timer\[12\] _0508_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1438_ timer\[3\] timer\[2\] _0509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1439_ _0033_ _0509_ _0510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1440_ timer\[5\] timer\[4\] _0511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1441_ timer\[15\] timer\[14\] _0510_ _0511_ _0512_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1442_ _0507_ _0508_ _0512_ _0513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_1443_ net233 _0513_ _0514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1444_ init_state\[2\] init_state\[4\] _0514_ _0003_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1445_ init_state\[3\] init_state\[5\] _0514_ _0004_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1446_ init_state\[4\] init_state\[0\] _0514_ _0005_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1447_ init_state\[5\] init_state\[1\] _0514_ _0006_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1448_ net140 _0015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1449_ _0514_ _0515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1450_ init_state\[0\] _0515_ _0001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1451_ init_state\[1\] init_state\[6\] _0514_ _0002_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1452_ init_state\[6\] init_state\[2\] _0514_ _0007_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1453_ init_state\[3\] _0514_ _0516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1454_ init_state\[7\] _0516_ _0008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1455_ burst_counter\[0\] _0019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput66 wr_data[17] net65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1457_ _0033_ _0518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1458_ timer\[3\] timer\[2\] _0518_ _0511_ _0519_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1459_ timer\[15\] timer\[14\] _0507_ _0508_ _0520_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or4_4
X_1460_ _0519_ _0520_ _0521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xinput65 wr_data[16] net64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1462_ _0042_ _0523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput64 wr_data[15] net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1464_ net232 _0523_ net53 _0525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1465_ net153 _0526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1466_ _0021_ _0527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1467_ burst_counter\[3\] burst_counter\[2\] _0527_ _0528_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1468_ net141 _0529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1469_ net151 _0529_ _0530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1470_ net234 _0526_ _0528_ _0530_ _0531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1471_ _0525_ _0531_ _0532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput63 wr_data[14] net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1473_ refresh_counter\[14\] refresh_counter\[13\] refresh_counter\[12\]
+ refresh_counter\[11\] _0534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1474_ refresh_counter\[15\] _0534_ _0535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1475_ refresh_counter\[7\] _0536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1476_ refresh_counter\[6\] refresh_counter\[5\] _0537_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1477_ _0536_ _0537_ _0538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1478_ refresh_counter\[7\] refresh_counter\[4\] refresh_counter\[3\]
+ refresh_counter\[2\] _0539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1479_ refresh_counter\[1\] _0539_ _0540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1480_ refresh_counter\[10\] refresh_counter\[9\] refresh_counter\[8\]
+ _0541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1481_ _0538_ _0540_ _0541_ _0542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1482_ _0535_ _0542_ _0543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1483_ _0024_ _0541_ _0537_ _0539_ _0544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_1484_ net231 _0543_ _0544_ _0545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1485_ net52 _0521_ _0546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1486_ net238 _0547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xinput62 wr_data[13] net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput61 wr_data[12] net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput60 wr_data[11] net59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput59 wr_data[10] net58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput58 wr_data[0] net57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1492_ _0547_ net239 net23 active_row\[3\]\[13\] _0553_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput57 net240 net56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput56 rd_ready net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1495_ net23 _0556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xinput55 phy_clk net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1497_ net238 net239 net235 active_row\[5\]\[13\] _0558_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1498_ _0553_ _0558_ _0559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1499_ _0547_ net239 net235 active_row\[1\]\[13\] _0560_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1500_ net239 _0561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xinput54 cmd_write net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1502_ net238 _0561_ net235 active_row\[4\]\[13\] _0563_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1503_ _0560_ _0563_ _0564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput53 cmd_valid net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1505_ active_row\[6\]\[13\] active_row\[7\]\[13\] net239
+ _0566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1506_ net238 net23 _0567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput52 cmd_burst_len[3] net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1508_ _0566_ _0567_ _0569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput51 cmd_burst_len[2] net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput50 cmd_burst_len[1] net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput49 cmd_burst_len[0] net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1512_ net235 active_row\[2\]\[13\] _0547_ _0561_ _0573_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1513_ _0569_ _0573_ _0574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1514_ active_row\[0\]\[13\] _0575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1515_ net238 net23 _0576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_1516_ _0561_ _0576_ _0577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput48 cmd_addr[9] net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1518_ _0575_ _0577_ net39 _0579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1519_ _0559_ _0564_ _0574_ _0579_ _0580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
Xinput47 cmd_addr[8] net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput46 cmd_addr[7] net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput45 cmd_addr[6] net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1523_ _0547_ net239 net235 active_row\[1\]\[9\] _0584_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput44 cmd_addr[5] net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1525_ net238 _0561_ net235 active_row\[4\]\[9\] _0586_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1526_ _0584_ _0586_ _0587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1527_ _0547_ net239 net23 active_row\[3\]\[9\] _0588_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1528_ net238 net239 net235 active_row\[5\]\[9\] _0589_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1529_ _0588_ _0589_ _0590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1530_ active_row\[6\]\[9\] active_row\[7\]\[9\] net239 _0591_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1531_ _0567_ _0591_ _0592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput43 cmd_addr[4] net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1533_ net235 active_row\[2\]\[9\] _0547_ _0561_ _0594_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1534_ _0592_ _0594_ _0595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1535_ active_row\[0\]\[9\] _0596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1536_ _0596_ _0577_ net35 _0597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1537_ _0587_ _0590_ _0595_ _0597_ _0598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1538_ _0547_ net239 net23 active_row\[3\]\[7\] _0599_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1539_ net238 net239 net235 active_row\[5\]\[7\] _0600_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1540_ _0599_ _0600_ _0601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1541_ _0547_ net239 net235 active_row\[1\]\[7\] _0602_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1542_ net238 _0561_ net235 active_row\[4\]\[7\] _0603_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1543_ _0602_ _0603_ _0604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1544_ active_row\[6\]\[7\] active_row\[7\]\[7\] net239 _0605_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1545_ _0567_ _0605_ _0606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1546_ net235 active_row\[2\]\[7\] _0547_ _0561_ _0607_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1547_ _0606_ _0607_ _0608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1548_ active_row\[0\]\[7\] _0609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1549_ _0609_ _0577_ net33 _0610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1550_ _0601_ _0604_ _0608_ _0610_ _0611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1551_ net33 _0612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1552_ _0612_ _0601_ _0604_ _0608_ _0613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1553_ _0580_ _0598_ _0611_ _0613_ _0614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1554_ net25 _0615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1555_ _0547_ net239 net23 active_row\[3\]\[0\] _0616_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1556_ net238 net239 net235 active_row\[5\]\[0\] _0617_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1557_ _0616_ _0617_ _0618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1558_ _0547_ net239 net235 active_row\[1\]\[0\] _0619_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1559_ net238 _0561_ net235 active_row\[4\]\[0\] _0620_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1560_ _0619_ _0620_ _0621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1561_ active_row\[6\]\[0\] active_row\[7\]\[0\] net239 _0622_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1562_ _0567_ _0622_ _0623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1563_ net235 active_row\[2\]\[0\] _0547_ _0561_ _0624_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1564_ _0623_ _0624_ _0625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1565_ _0615_ _0618_ _0621_ _0625_ _0626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1566_ _0547_ net239 net235 active_row\[1\]\[5\] _0627_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1567_ net238 _0561_ net235 active_row\[4\]\[5\] _0628_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1568_ _0627_ _0628_ _0629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1569_ _0547_ net239 net23 active_row\[3\]\[5\] _0630_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1570_ net238 net239 net235 active_row\[5\]\[5\] _0631_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1571_ _0630_ _0631_ _0632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1572_ active_row\[6\]\[5\] active_row\[7\]\[5\] net239 _0633_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1573_ _0567_ _0633_ _0634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1574_ net235 active_row\[2\]\[5\] _0547_ _0561_ _0635_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1575_ _0634_ _0635_ _0636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1576_ active_row\[0\]\[5\] _0637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1577_ _0637_ _0577_ net30 _0638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1578_ _0629_ _0632_ _0636_ _0638_ _0639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1579_ net38 _0640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1580_ net238 active_row\[5\]\[12\] _0641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1581_ active_row\[4\]\[12\] _0641_ net239 _0642_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1582_ net235 _0642_ _0643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1583_ net235 active_row\[2\]\[12\] _0561_ _0644_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1584_ net235 active_row\[1\]\[12\] _0645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1585_ _0644_ _0645_ net238 _0646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1586_ active_row\[6\]\[12\] active_row\[7\]\[12\] net239
+ _0647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1587_ net239 active_row\[3\]\[12\] _0648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1588_ _0647_ _0648_ _0547_ _0649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1589_ net23 _0649_ _0650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1590_ _0640_ _0643_ _0646_ _0650_ _0651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1591_ active_row\[0\]\[12\] _0652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1592_ _0652_ _0577_ net38 _0653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1593_ _0643_ _0646_ _0650_ _0653_ _0654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1594_ _0626_ _0639_ _0651_ _0654_ _0655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1595_ net26 _0656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1596_ _0547_ net239 net23 active_row\[3\]\[1\] _0657_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1597_ net238 net239 net235 active_row\[5\]\[1\] _0658_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1598_ _0657_ _0658_ _0659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1599_ _0547_ net239 net235 active_row\[1\]\[1\] _0660_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1600_ net238 _0561_ net235 active_row\[4\]\[1\] _0661_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1601_ _0660_ _0661_ _0662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1602_ active_row\[6\]\[1\] active_row\[7\]\[1\] net239 _0663_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1603_ _0567_ _0663_ _0664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1604_ net235 active_row\[2\]\[1\] _0547_ _0561_ _0665_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1605_ _0664_ _0665_ _0666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1606_ _0656_ _0659_ _0662_ _0666_ _0667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1607_ active_row\[0\]\[0\] _0668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1608_ _0668_ _0577_ net25 _0669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1609_ _0618_ _0621_ _0625_ _0669_ _0670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1610_ net35 _0671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1611_ _0671_ _0587_ _0590_ _0595_ _0672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1612_ net34 _0673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1613_ _0547_ net239 net23 active_row\[3\]\[8\] _0674_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1614_ net238 net239 net235 active_row\[5\]\[8\] _0675_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1615_ _0674_ _0675_ _0676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1616_ _0547_ net239 net235 active_row\[1\]\[8\] _0677_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1617_ net238 _0561_ net235 active_row\[4\]\[8\] _0678_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1618_ _0677_ _0678_ _0679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1619_ active_row\[6\]\[8\] active_row\[7\]\[8\] net239 _0680_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1620_ _0567_ _0680_ _0681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1621_ net235 active_row\[2\]\[8\] _0547_ _0561_ _0682_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1622_ _0681_ _0682_ _0683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1623_ _0673_ _0676_ _0679_ _0683_ _0684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1624_ _0667_ _0670_ _0672_ _0684_ _0685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1625_ net30 _0686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1626_ _0686_ _0629_ _0632_ _0636_ _0687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1627_ active_row\[0\]\[8\] _0688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1628_ _0688_ _0577_ net34 _0689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1629_ _0676_ _0679_ _0683_ _0689_ _0690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1630_ active_row\[0\]\[1\] _0691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1631_ _0691_ _0577_ net26 _0692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1632_ _0659_ _0662_ _0666_ _0692_ _0693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1633_ _0547_ net239 net23 active_row\[3\]\[11\] _0694_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1634_ net238 net239 net235 active_row\[5\]\[11\] _0695_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1635_ _0694_ _0695_ _0696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1636_ _0547_ net239 net235 active_row\[1\]\[11\] _0697_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1637_ net238 _0561_ net235 active_row\[4\]\[11\] _0698_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1638_ _0697_ _0698_ _0699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1639_ active_row\[6\]\[11\] active_row\[7\]\[11\] net239
+ _0700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1640_ _0567_ _0700_ _0701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1641_ net235 active_row\[2\]\[11\] _0547_ _0561_ _0702_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1642_ _0701_ _0702_ _0703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1643_ active_row\[0\]\[11\] _0704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1644_ _0704_ _0577_ net37 _0705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1645_ _0696_ _0699_ _0703_ _0705_ _0706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1646_ _0687_ _0690_ _0693_ _0706_ _0707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1647_ _0614_ _0655_ _0685_ _0707_ _0708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_1648_ net37 _0709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1649_ _0709_ _0696_ _0699_ _0703_ _0710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_1650_ active_row\[0\]\[3\] _0711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1651_ _0711_ _0577_ net28 _0712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1652_ net235 active_row\[5\]\[3\] _0713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1653_ active_row\[1\]\[3\] active_row\[3\]\[3\] net23 _0714_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1654_ _0713_ _0714_ _0547_ _0715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1655_ net235 active_row\[4\]\[3\] _0716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1656_ net235 active_row\[2\]\[3\] _0547_ _0717_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1657_ _0716_ _0717_ net239 _0718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1658_ active_row\[6\]\[3\] active_row\[7\]\[3\] net239 _0719_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1659_ _0567_ _0719_ _0720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1660_ net239 _0715_ _0718_ _0720_ _0721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1661_ _0712_ net28 _0721_ _0722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1662_ active_row\[0\]\[10\] _0723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1663_ _0723_ _0577_ net36 _0724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1664_ _0547_ net23 active_row\[3\]\[10\] _0725_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1665_ net238 net235 active_row\[5\]\[10\] _0726_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1666_ _0561_ _0725_ _0726_ _0727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1667_ net235 active_row\[2\]\[10\] _0547_ _0728_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1668_ net235 active_row\[4\]\[10\] _0729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1669_ _0561_ _0728_ _0729_ _0730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1670_ active_row\[6\]\[10\] active_row\[7\]\[10\] net239
+ _0731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1671_ net239 active_row\[1\]\[10\] _0576_ _0732_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1672_ _0727_ _0730_ _0731_ _0567_ _0732_ _0733_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_1673_ _0724_ net36 _0733_ _0734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1674_ _0561_ _0576_ _0735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1675_ active_row\[1\]\[4\] active_row\[3\]\[4\] net23 _0736_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1676_ net235 active_row\[2\]\[4\] _0737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1677_ _0736_ _0737_ _0561_ _0738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1678_ active_row\[4\]\[4\] active_row\[5\]\[4\] active_row\[6\]\[4\]
+ active_row\[7\]\[4\] net239 net23 _0739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_1679_ _0547_ _0739_ _0740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_1680_ active_row\[0\]\[4\] _0735_ _0738_ net238 _0740_ _0741_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_1681_ net29 _0741_ _0742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1682_ _0710_ _0722_ _0734_ _0742_ _0743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_1683_ net32 _0744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1684_ active_row\[0\]\[6\] _0735_ _0744_ _0745_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1685_ net235 active_row\[4\]\[6\] _0746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1686_ _0547_ active_row\[2\]\[6\] _0747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1687_ _0576_ _0746_ _0747_ _0748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1688_ active_row\[1\]\[6\] active_row\[3\]\[6\] net23 _0749_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1689_ _0547_ _0749_ _0750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1690_ net238 net235 active_row\[5\]\[6\] _0751_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_1691_ _0750_ _0751_ _0561_ _0752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1692_ active_row\[6\]\[6\] active_row\[7\]\[6\] net239 _0753_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1693_ _0567_ _0753_ _0754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1694_ _0561_ _0748_ _0752_ _0754_ _0755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1695_ _0745_ _0744_ _0755_ _0756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1696_ net39 _0757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1697_ _0757_ _0559_ _0564_ _0574_ _0758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_1698_ active_row\[2\]\[2\] active_row\[3\]\[2\] active_row\[6\]\[2\]
+ active_row\[7\]\[2\] net239 net238 _0759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_1699_ active_row\[0\]\[2\] active_row\[1\]\[2\] active_row\[4\]\[2\]
+ active_row\[5\]\[2\] net239 net238 _0760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_1700_ _0759_ _0760_ net235 _0761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1701_ net27 _0761_ _0762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_1702_ _0609_ net33 _0596_ net35 _0763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1703_ active_row\[0\]\[6\] _0744_ active_row\[0\]\[13\]
+ _0757_ _0763_ _0764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_1704_ _0691_ net26 _0652_ net38 _0765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1705_ active_row\[0\]\[5\] _0686_ active_row\[0\]\[11\]
+ _0709_ _0765_ _0766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_1706_ net36 _0767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1707_ _0711_ net28 _0688_ net34 _0768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1708_ active_row\[0\]\[0\] _0615_ active_row\[0\]\[10\]
+ _0767_ _0768_ _0769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_1709_ _0764_ _0766_ _0769_ _0577_ _0770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_1710_ bank_active\[4\] bank_active\[5\] bank_active\[6\]
+ bank_active\[7\] net239 net23 _0771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_1711_ bank_active\[0\] bank_active\[1\] bank_active\[2\]
+ bank_active\[3\] net239 net23 _0772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_1712_ _0771_ _0772_ _0547_ _0773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1713_ _0758_ _0762_ _0770_ _0773_ _0774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_1714_ _0756_ _0774_ _0775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1715_ _0708_ _0743_ _0775_ _0776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
Xinput42 cmd_addr[3] net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1717_ net53 _0546_ _0776_ _0778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1718_ _0521_ _0532_ _0545_ _0778_ _0779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1719_ net233 _0779_ _0839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1720_ net231 _0780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1721_ _0541_ _0539_ _0781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1722_ _0024_ _0537_ refresh_counter\[1\] _0782_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1723_ refresh_counter\[6\] refresh_counter\[5\] _0541_ refresh_counter\[7\]
+ _0783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1724_ _0781_ _0782_ _0783_ _0535_ _0784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1725_ _0784_ _0785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1726_ _0778_ _0785_ _0786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1727_ init_state\[5\] init_state\[1\] init_state\[6\] _0787_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_1728_ _0521_ _0787_ _0788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1729_ burst_counter\[3\] _0789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1730_ burst_counter\[2\] _0790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1731_ _0789_ _0790_ _0021_ _0791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_1732_ _0521_ _0791_ _0523_ _0792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1733_ net233 _0793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1734_ _0793_ _0780_ _0794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1735_ net232 _0795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1736_ _0795_ _0523_ _0796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1737_ _0794_ _0796_ _0797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_1738_ net233 _0788_ _0792_ _0797_ _0798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_1739_ net53 _0521_ _0799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1740_ net232 _0799_ _0800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_1741_ _0780_ _0786_ _0798_ _0800_ _0840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1742_ _0545_ _0801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1743_ _0009_ _0010_ _0875_ _0011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1744_ _0009_ net139 _0012_ _0876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1745_ net138 _0010_ _0013_ _0877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1746_ net138 net139 _0014_ _0878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1747_ _0015_ _0875_ _0016_ _0017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1748_ net140 _0875_ _0018_ _0879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1749_ _0019_ _0020_ _0021_ _0022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1750_ _0023_ refresh_counter\[1\] _0024_ _0025_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1751_ refresh_counter\[0\] refresh_counter\[1\] _0026_ _0880_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1752_ _0027_ _0804_ _0029_ _0030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1753_ timer\[0\] _0804_ _0031_ _0881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1754_ _0027_ _0032_ _0033_ _0034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1755_ timer\[0\] _0032_ _0035_ _0882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1756_ _0036_ _0037_ _0038_ _0039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1757_ _0036_ net220 _0040_ _0883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1758_ net219 _0037_ _0041_ _0884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_1759_ net219 net220 _0042_ _0885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
X_1764__11 phy_cke VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
Xinput41 cmd_addr[2] net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput40 cmd_addr[27] net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput39 cmd_addr[26] net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1765_ wr_mask[0] net143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1766_ wr_mask[1] net144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1767_ wr_mask[2] net145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1768_ wr_mask[3] net146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1769_ wr_mask[4] net147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1770_ wr_mask[5] net148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1771_ wr_mask[6] net149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1772_ wr_mask[7] net150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1773_ net57 phy_dq[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1774_ net68 phy_dq[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1775_ net79 phy_dq[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1776_ net90 phy_dq[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1777_ net101 phy_dq[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1778_ net112 phy_dq[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1779_ net117 phy_dq[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1780_ net118 phy_dq[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1781_ net119 phy_dq[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1782_ net120 phy_dq[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1783_ net58 phy_dq[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1784_ net59 phy_dq[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1785_ net60 phy_dq[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1786_ net61 phy_dq[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1787_ net62 phy_dq[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1788_ net63 phy_dq[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1789_ net64 phy_dq[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1790_ net65 phy_dq[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1791_ net66 phy_dq[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1792_ net67 phy_dq[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1793_ net69 phy_dq[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1794_ net70 phy_dq[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1795_ net71 phy_dq[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1796_ net72 phy_dq[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1797_ net73 phy_dq[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1798_ net74 phy_dq[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1799_ net75 phy_dq[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1800_ net76 phy_dq[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1801_ net77 phy_dq[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1802_ net78 phy_dq[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1803_ net80 phy_dq[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1804_ net81 phy_dq[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1805_ net82 phy_dq[32] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1806_ net83 phy_dq[33] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1807_ net84 phy_dq[34] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1808_ net85 phy_dq[35] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1809_ net86 phy_dq[36] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1810_ net87 phy_dq[37] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1811_ net88 phy_dq[38] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1812_ net89 phy_dq[39] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1813_ net91 phy_dq[40] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1814_ net92 phy_dq[41] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1815_ net93 phy_dq[42] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1816_ net94 phy_dq[43] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1817_ net95 phy_dq[44] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1818_ net96 phy_dq[45] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1819_ net97 phy_dq[46] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1820_ net98 phy_dq[47] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1821_ net99 phy_dq[48] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1822_ net100 phy_dq[49] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1823_ net102 phy_dq[50] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1824_ net103 phy_dq[51] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1825_ net104 phy_dq[52] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1826_ net105 phy_dq[53] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1827_ net106 phy_dq[54] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1828_ net107 phy_dq[55] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1829_ net108 phy_dq[56] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1830_ net109 phy_dq[57] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1831_ net110 phy_dq[58] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1832_ net111 phy_dq[59] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1833_ net113 phy_dq[60] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1834_ net114 phy_dq[61] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1835_ net115 phy_dq[62] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
X_1836_ net116 phy_dq[63] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_4
Xinput38 cmd_addr[25] net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput37 cmd_addr[24] net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput36 cmd_addr[23] net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput35 cmd_addr[22] net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput34 cmd_addr[21] net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput33 cmd_addr[20] net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput32 cmd_addr[1] net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput31 cmd_addr[19] net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput30 cmd_addr[18] net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput29 cmd_addr[17] net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput28 cmd_addr[16] net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput27 cmd_addr[15] net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput26 cmd_addr[14] net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput25 cmd_addr[13] net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput24 cmd_addr[12] net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput23 cmd_addr[11] net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput22 cmd_addr[0] net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xactive_row\[0\]\[0\]$_DFFE_PP_ _0043_ clknet_4_8_0_clk active_row\[0\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[10\]$_DFFE_PP_ _0044_ clknet_4_2_0_clk active_row\[0\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[11\]$_DFFE_PP_ _0045_ clknet_4_9_0_clk active_row\[0\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[12\]$_DFFE_PP_ _0046_ clknet_4_8_0_clk active_row\[0\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[13\]$_DFFE_PP_ _0047_ clknet_4_9_0_clk active_row\[0\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[1\]$_DFFE_PP_ _0048_ clknet_4_8_0_clk active_row\[0\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[2\]$_DFFE_PP_ _0049_ clknet_4_3_0_clk active_row\[0\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[3\]$_DFFE_PP_ _0050_ clknet_4_2_0_clk active_row\[0\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[4\]$_DFFE_PP_ _0051_ clknet_4_3_0_clk active_row\[0\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[5\]$_DFFE_PP_ _0052_ clknet_4_9_0_clk active_row\[0\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[6\]$_DFFE_PP_ _0053_ clknet_4_14_0_clk active_row\[0\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[7\]$_DFFE_PP_ _0054_ clknet_4_14_0_clk active_row\[0\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[8\]$_DFFE_PP_ _0055_ clknet_4_9_0_clk active_row\[0\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[0\]\[9\]$_DFFE_PP_ _0056_ clknet_4_14_0_clk active_row\[0\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[0\]$_DFFE_PP_ _0057_ clknet_4_8_0_clk active_row\[1\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[10\]$_DFFE_PP_ _0058_ clknet_4_2_0_clk active_row\[1\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[11\]$_DFFE_PP_ _0059_ clknet_4_3_0_clk active_row\[1\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[12\]$_DFFE_PP_ _0060_ clknet_4_8_0_clk active_row\[1\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[13\]$_DFFE_PP_ _0061_ clknet_4_11_0_clk
+ active_row\[1\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[1\]$_DFFE_PP_ _0062_ clknet_4_10_0_clk active_row\[1\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[2\]$_DFFE_PP_ _0063_ clknet_4_3_0_clk active_row\[1\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[3\]$_DFFE_PP_ _0064_ clknet_4_2_0_clk active_row\[1\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[4\]$_DFFE_PP_ _0065_ clknet_4_3_0_clk active_row\[1\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[5\]$_DFFE_PP_ _0066_ clknet_4_10_0_clk active_row\[1\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[6\]$_DFFE_PP_ _0067_ clknet_4_15_0_clk active_row\[1\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[7\]$_DFFE_PP_ _0068_ clknet_4_10_0_clk active_row\[1\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[8\]$_DFFE_PP_ _0069_ clknet_4_10_0_clk active_row\[1\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[1\]\[9\]$_DFFE_PP_ _0070_ clknet_4_14_0_clk active_row\[1\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[0\]$_DFFE_PP_ _0071_ clknet_4_8_0_clk active_row\[2\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[10\]$_DFFE_PP_ _0072_ clknet_4_2_0_clk active_row\[2\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[11\]$_DFFE_PP_ _0073_ clknet_4_2_0_clk active_row\[2\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[12\]$_DFFE_PP_ _0074_ clknet_4_8_0_clk active_row\[2\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[13\]$_DFFE_PP_ _0075_ clknet_4_11_0_clk
+ active_row\[2\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[1\]$_DFFE_PP_ _0076_ clknet_4_10_0_clk active_row\[2\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[2\]$_DFFE_PP_ _0077_ clknet_4_3_0_clk active_row\[2\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[3\]$_DFFE_PP_ _0078_ clknet_4_0_0_clk active_row\[2\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[4\]$_DFFE_PP_ _0079_ clknet_4_3_0_clk active_row\[2\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[5\]$_DFFE_PP_ _0080_ clknet_4_11_0_clk active_row\[2\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[6\]$_DFFE_PP_ _0081_ clknet_4_15_0_clk active_row\[2\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[7\]$_DFFE_PP_ _0082_ clknet_4_11_0_clk active_row\[2\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[8\]$_DFFE_PP_ _0083_ clknet_4_11_0_clk active_row\[2\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[2\]\[9\]$_DFFE_PP_ _0084_ clknet_4_14_0_clk active_row\[2\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[0\]$_DFFE_PP_ _0085_ clknet_4_8_0_clk active_row\[3\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[10\]$_DFFE_PP_ _0086_ clknet_4_2_0_clk active_row\[3\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[11\]$_DFFE_PP_ _0087_ clknet_4_2_0_clk active_row\[3\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[12\]$_DFFE_PP_ _0088_ clknet_4_0_0_clk active_row\[3\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[13\]$_DFFE_PP_ _0089_ clknet_4_10_0_clk
+ active_row\[3\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[1\]$_DFFE_PP_ _0090_ clknet_4_8_0_clk active_row\[3\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[2\]$_DFFE_PP_ _0091_ clknet_4_3_0_clk active_row\[3\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[3\]$_DFFE_PP_ _0092_ clknet_4_0_0_clk active_row\[3\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[4\]$_DFFE_PP_ _0093_ clknet_4_6_0_clk active_row\[3\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[5\]$_DFFE_PP_ _0094_ clknet_4_10_0_clk active_row\[3\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[6\]$_DFFE_PP_ _0095_ clknet_4_15_0_clk active_row\[3\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[7\]$_DFFE_PP_ _0096_ clknet_4_11_0_clk active_row\[3\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[8\]$_DFFE_PP_ _0097_ clknet_4_11_0_clk active_row\[3\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[3\]\[9\]$_DFFE_PP_ _0098_ clknet_4_14_0_clk active_row\[3\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[0\]$_DFFE_PP_ _0099_ clknet_4_8_0_clk active_row\[4\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[10\]$_DFFE_PP_ _0100_ clknet_4_2_0_clk active_row\[4\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[11\]$_DFFE_PP_ _0101_ clknet_4_2_0_clk active_row\[4\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[12\]$_DFFE_PP_ _0102_ clknet_4_0_0_clk active_row\[4\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[13\]$_DFFE_PP_ _0103_ clknet_4_11_0_clk
+ active_row\[4\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[1\]$_DFFE_PP_ _0104_ clknet_4_10_0_clk active_row\[4\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[2\]$_DFFE_PP_ _0105_ clknet_4_1_0_clk active_row\[4\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[3\]$_DFFE_PP_ _0106_ clknet_4_0_0_clk active_row\[4\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[4\]$_DFFE_PP_ _0107_ clknet_4_1_0_clk active_row\[4\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[5\]$_DFFE_PP_ _0108_ clknet_4_11_0_clk active_row\[4\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[6\]$_DFFE_PP_ _0109_ clknet_4_14_0_clk active_row\[4\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[7\]$_DFFE_PP_ _0110_ clknet_4_11_0_clk active_row\[4\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[8\]$_DFFE_PP_ _0111_ clknet_4_11_0_clk active_row\[4\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[4\]\[9\]$_DFFE_PP_ _0112_ clknet_4_14_0_clk active_row\[4\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[0\]$_DFFE_PP_ _0113_ clknet_4_8_0_clk active_row\[5\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[10\]$_DFFE_PP_ _0114_ clknet_4_2_0_clk active_row\[5\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[11\]$_DFFE_PP_ _0115_ clknet_4_0_0_clk active_row\[5\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[12\]$_DFFE_PP_ _0116_ clknet_4_0_0_clk active_row\[5\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[13\]$_DFFE_PP_ _0117_ clknet_4_11_0_clk
+ active_row\[5\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[1\]$_DFFE_PP_ _0118_ clknet_4_9_0_clk active_row\[5\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[2\]$_DFFE_PP_ _0119_ clknet_4_1_0_clk active_row\[5\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[3\]$_DFFE_PP_ _0120_ clknet_4_0_0_clk active_row\[5\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[4\]$_DFFE_PP_ _0121_ clknet_4_6_0_clk active_row\[5\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[5\]$_DFFE_PP_ _0122_ clknet_4_10_0_clk active_row\[5\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[6\]$_DFFE_PP_ _0123_ clknet_4_14_0_clk active_row\[5\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[7\]$_DFFE_PP_ _0124_ clknet_4_11_0_clk active_row\[5\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[8\]$_DFFE_PP_ _0125_ clknet_4_10_0_clk active_row\[5\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[5\]\[9\]$_DFFE_PP_ _0126_ clknet_4_14_0_clk active_row\[5\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[0\]$_DFFE_PP_ _0127_ clknet_4_8_0_clk active_row\[6\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[10\]$_DFFE_PP_ _0128_ clknet_4_2_0_clk active_row\[6\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[11\]$_DFFE_PP_ _0129_ clknet_4_0_0_clk active_row\[6\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[12\]$_DFFE_PP_ _0130_ clknet_4_0_0_clk active_row\[6\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[13\]$_DFFE_PP_ _0131_ clknet_4_11_0_clk
+ active_row\[6\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[1\]$_DFFE_PP_ _0132_ clknet_4_10_0_clk active_row\[6\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[2\]$_DFFE_PP_ _0133_ clknet_4_1_0_clk active_row\[6\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[3\]$_DFFE_PP_ _0134_ clknet_4_0_0_clk active_row\[6\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[4\]$_DFFE_PP_ _0135_ clknet_4_1_0_clk active_row\[6\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[5\]$_DFFE_PP_ _0136_ clknet_4_11_0_clk active_row\[6\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[6\]$_DFFE_PP_ _0137_ clknet_4_14_0_clk active_row\[6\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[7\]$_DFFE_PP_ _0138_ clknet_4_11_0_clk active_row\[6\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[8\]$_DFFE_PP_ _0139_ clknet_4_10_0_clk active_row\[6\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[6\]\[9\]$_DFFE_PP_ _0140_ clknet_4_11_0_clk active_row\[6\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[0\]$_DFFE_PP_ _0141_ clknet_4_8_0_clk active_row\[7\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[10\]$_DFFE_PP_ _0142_ clknet_4_2_0_clk active_row\[7\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[11\]$_DFFE_PP_ _0143_ clknet_4_0_0_clk active_row\[7\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[12\]$_DFFE_PP_ _0144_ clknet_4_0_0_clk active_row\[7\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[13\]$_DFFE_PP_ _0145_ clknet_4_11_0_clk
+ active_row\[7\]\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[1\]$_DFFE_PP_ _0146_ clknet_4_8_0_clk active_row\[7\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[2\]$_DFFE_PP_ _0147_ clknet_4_1_0_clk active_row\[7\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[3\]$_DFFE_PP_ _0148_ clknet_4_0_0_clk active_row\[7\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[4\]$_DFFE_PP_ _0149_ clknet_4_1_0_clk active_row\[7\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[5\]$_DFFE_PP_ _0150_ clknet_4_10_0_clk active_row\[7\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[6\]$_DFFE_PP_ _0151_ clknet_4_14_0_clk active_row\[7\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[7\]$_DFFE_PP_ _0152_ clknet_4_11_0_clk active_row\[7\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[8\]$_DFFE_PP_ _0153_ clknet_4_10_0_clk active_row\[7\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xactive_row\[7\]\[9\]$_DFFE_PP_ _0154_ clknet_4_11_0_clk active_row\[7\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xaddr_reg\[0\]$_DFFE_PN0P_ _0155_ net56 clknet_4_9_0_clk net124
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[10\]$_DFFE_PN0P_ _0156_ net56 clknet_4_9_0_clk
+ net125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[11\]$_DFFE_PN0P_ _0157_ net56 clknet_4_12_0_clk
+ net126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[12\]$_DFFE_PN0P_ _0158_ net56 clknet_4_9_0_clk
+ net127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[13\]$_DFFE_PN0P_ _0159_ net56 clknet_4_9_0_clk
+ net128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[1\]$_DFFE_PN0P_ _0160_ net56 clknet_4_12_0_clk
+ net129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[2\]$_DFFE_PN0P_ _0161_ net56 clknet_4_6_0_clk net130
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[3\]$_DFFE_PN0P_ _0162_ net56 clknet_4_2_0_clk net131
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[4\]$_DFFE_PN0P_ _0163_ net56 clknet_4_3_0_clk net132
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[5\]$_DFFE_PN0P_ _0164_ net56 clknet_4_12_0_clk
+ net133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[6\]$_DFFE_PN0P_ _0165_ net56 clknet_4_12_0_clk
+ net134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[7\]$_DFFE_PN0P_ _0166_ net56 clknet_4_12_0_clk
+ net135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[8\]$_DFFE_PN0P_ _0167_ net56 clknet_4_9_0_clk net136
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xaddr_reg\[9\]$_DFFE_PN0P_ _0168_ net56 clknet_4_12_0_clk
+ net137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[0\]$_DFFE_PN0P_ _0169_ net56 clknet_4_15_0_clk
+ bank_active\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[1\]$_DFFE_PN0P_ _0170_ net56 clknet_4_15_0_clk
+ bank_active\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[2\]$_DFFE_PN0P_ _0171_ net56 clknet_4_13_0_clk
+ bank_active\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[3\]$_DFFE_PN0P_ _0172_ net56 clknet_4_12_0_clk
+ bank_active\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[4\]$_DFFE_PN0P_ _0173_ net56 clknet_4_15_0_clk
+ bank_active\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[5\]$_DFFE_PN0P_ _0174_ net56 clknet_4_15_0_clk
+ bank_active\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[6\]$_DFFE_PN0P_ _0175_ net56 clknet_4_13_0_clk
+ bank_active\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_active\[7\]$_DFFE_PN0P_ _0176_ net56 clknet_4_13_0_clk
+ bank_active\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_reg\[0\]$_DFFE_PN0P_ _0177_ net56 clknet_4_13_0_clk
+ net138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_reg\[1\]$_DFFE_PN0P_ _0178_ net56 clknet_4_13_0_clk
+ net139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbank_reg\[2\]$_DFFE_PN0P_ _0179_ net56 clknet_4_12_0_clk
+ net140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xburst_counter\[0\]$_DFFE_PN0P_ _0180_ net236 clknet_4_5_0_clk
+ burst_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xburst_counter\[1\]$_DFFE_PN0P_ _0181_ net236 clknet_4_4_0_clk
+ burst_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xburst_counter\[2\]$_DFFE_PN0P_ _0182_ net236 clknet_4_4_0_clk
+ burst_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xburst_counter\[3\]$_DFFE_PN0P_ _0183_ net236 clknet_4_5_0_clk
+ burst_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcmd_reg\[0\]$_DFF_PN1_ _0840_ net56 clknet_4_13_0_clk net153
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcmd_reg\[1\]$_DFF_PN1_ _0841_ net236 clknet_4_7_0_clk net141
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcmd_reg\[2\]$_DFF_PN1_ _0842_ net236 clknet_4_7_0_clk net151
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcmd_reg_valid$_DFF_PN0_ net20 net236 clknet_4_1_0_clk cmd_reg_valid
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcurr_state\[0\]$_DFFE_PN0P_ _0184_ net56 clknet_4_13_0_clk
+ net219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcurr_state\[1\]$_DFFE_PN0P_ _0185_ net56 clknet_4_13_0_clk
+ net220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_done_reg$_DFFE_PN0P_ _0186_ net236 clknet_4_5_0_clk
+ net123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[0\]$_DFF_PN1_ _0001_ net236 clknet_4_5_0_clk
+ init_state\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xinit_state\[1\]$_DFF_PN0_ _0002_ net236 clknet_4_6_0_clk
+ init_state\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[2\]$_DFF_PN0_ _0003_ net236 clknet_4_5_0_clk
+ init_state\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[3\]$_DFF_PN0_ _0004_ net236 clknet_4_4_0_clk
+ init_state\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[4\]$_DFF_PN0_ _0005_ net236 clknet_4_5_0_clk
+ init_state\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[5\]$_DFF_PN0_ _0006_ net236 clknet_4_4_0_clk
+ init_state\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[6\]$_DFF_PN0_ _0007_ net236 clknet_4_4_0_clk
+ init_state\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xinit_state\[7\]$_DFF_PN0_ _0008_ net236 clknet_4_5_0_clk
+ init_state\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrd_data_reg\[0\]$_DFFE_PP_ _0187_ net237 net154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[10\]$_DFFE_PP_ _0188_ net237 net155 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[11\]$_DFFE_PP_ _0189_ net237 net156 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[12\]$_DFFE_PP_ _0190_ net237 net157 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[13\]$_DFFE_PP_ _0191_ net237 net158 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[14\]$_DFFE_PP_ _0192_ net237 net159 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[15\]$_DFFE_PP_ _0193_ net237 net160 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[16\]$_DFFE_PP_ _0194_ net237 net161 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[17\]$_DFFE_PP_ _0195_ net237 net162 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[18\]$_DFFE_PP_ _0196_ net237 net163 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[19\]$_DFFE_PP_ _0197_ net237 net164 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[1\]$_DFFE_PP_ _0198_ net237 net165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[20\]$_DFFE_PP_ _0199_ net237 net166 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[21\]$_DFFE_PP_ _0200_ net237 net167 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[22\]$_DFFE_PP_ _0201_ net237 net168 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[23\]$_DFFE_PP_ _0202_ net237 net169 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[24\]$_DFFE_PP_ _0203_ net237 net170 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[25\]$_DFFE_PP_ _0204_ net237 net171 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[26\]$_DFFE_PP_ _0205_ net237 net172 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[27\]$_DFFE_PP_ _0206_ net237 net173 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[28\]$_DFFE_PP_ _0207_ net237 net174 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[29\]$_DFFE_PP_ _0208_ net237 net175 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[2\]$_DFFE_PP_ _0209_ net237 net176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[30\]$_DFFE_PP_ _0210_ net237 net177 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[31\]$_DFFE_PP_ _0211_ net237 net178 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[32\]$_DFFE_PP_ _0212_ net237 net179 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[33\]$_DFFE_PP_ _0213_ net237 net180 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[34\]$_DFFE_PP_ _0214_ net237 net181 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[35\]$_DFFE_PP_ _0215_ net237 net182 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[36\]$_DFFE_PP_ _0216_ net237 net183 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[37\]$_DFFE_PP_ _0217_ net237 net184 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[38\]$_DFFE_PP_ _0218_ net237 net185 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[39\]$_DFFE_PP_ _0219_ net237 net186 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[3\]$_DFFE_PP_ _0220_ net237 net187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[40\]$_DFFE_PP_ _0221_ net237 net188 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[41\]$_DFFE_PP_ _0222_ net237 net189 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[42\]$_DFFE_PP_ _0223_ net237 net190 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[43\]$_DFFE_PP_ _0224_ net237 net191 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[44\]$_DFFE_PP_ _0225_ net237 net192 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[45\]$_DFFE_PP_ _0226_ net237 net193 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[46\]$_DFFE_PP_ _0227_ net237 net194 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[47\]$_DFFE_PP_ _0228_ net237 net195 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[48\]$_DFFE_PP_ _0229_ net237 net196 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[49\]$_DFFE_PP_ _0230_ net237 net197 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[4\]$_DFFE_PP_ _0231_ net237 net198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[50\]$_DFFE_PP_ _0232_ net237 net199 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[51\]$_DFFE_PP_ _0233_ net237 net200 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[52\]$_DFFE_PP_ _0234_ net237 net201 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[53\]$_DFFE_PP_ _0235_ net237 net202 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[54\]$_DFFE_PP_ _0236_ net237 net203 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[55\]$_DFFE_PP_ _0237_ net237 net204 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[56\]$_DFFE_PP_ _0238_ net237 net205 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[57\]$_DFFE_PP_ _0239_ net237 net206 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[58\]$_DFFE_PP_ _0240_ net237 net207 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[59\]$_DFFE_PP_ _0241_ net237 net208 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[5\]$_DFFE_PP_ _0242_ net237 net209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[60\]$_DFFE_PP_ _0243_ net237 net210 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[61\]$_DFFE_PP_ _0244_ net237 net211 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[62\]$_DFFE_PP_ _0245_ net237 net212 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[63\]$_DFFE_PP_ _0246_ net237 net213 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[6\]$_DFFE_PP_ _0247_ net237 net214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[7\]$_DFFE_PP_ _0248_ net237 net215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[8\]$_DFFE_PP_ _0249_ net237 net216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_data_reg\[9\]$_DFFE_PP_ _0250_ net237 net217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xrd_valid_reg$_DFF_PN0_ _0000_ net236 clknet_4_13_0_clk net218
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[0\]$_DFF_PN0_ _0843_ net236 clknet_4_4_0_clk
+ refresh_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[10\]$_DFF_PN0_ _0844_ net236 clknet_4_1_0_clk
+ refresh_counter\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[11\]$_DFF_PN0_ _0845_ net236 clknet_4_1_0_clk
+ refresh_counter\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[12\]$_DFF_PN0_ _0846_ net236 clknet_4_1_0_clk
+ refresh_counter\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[13\]$_DFF_PN0_ _0847_ net236 clknet_4_0_0_clk
+ refresh_counter\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[14\]$_DFF_PN0_ _0848_ net236 clknet_4_1_0_clk
+ refresh_counter\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[15\]$_DFF_PN0_ _0849_ net236 clknet_4_1_0_clk
+ refresh_counter\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[1\]$_DFF_PN0_ _0850_ net236 clknet_4_4_0_clk
+ refresh_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[2\]$_DFF_PN0_ _0851_ net236 clknet_4_4_0_clk
+ refresh_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[3\]$_DFF_PN0_ _0852_ net236 clknet_4_1_0_clk
+ refresh_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[4\]$_DFF_PN0_ _0853_ net236 clknet_4_4_0_clk
+ refresh_counter\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[5\]$_DFF_PN0_ _0854_ net236 clknet_4_1_0_clk
+ refresh_counter\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[6\]$_DFF_PN0_ _0855_ net236 clknet_4_4_0_clk
+ refresh_counter\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[7\]$_DFF_PN0_ _0856_ net236 clknet_4_1_0_clk
+ refresh_counter\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[8\]$_DFF_PN0_ _0857_ net236 clknet_4_1_0_clk
+ refresh_counter\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrefresh_counter\[9\]$_DFF_PN0_ _0858_ net236 clknet_4_1_0_clk
+ refresh_counter\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[0\]$_DFF_PN0_ _0859_ net56 clknet_4_6_0_clk timer\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[10\]$_DFF_PN0_ _0860_ net236 clknet_4_5_0_clk timer\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[11\]$_DFF_PN0_ _0861_ net236 clknet_4_5_0_clk timer\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[12\]$_DFF_PN0_ _0862_ net236 clknet_4_7_0_clk timer\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[13\]$_DFF_PN0_ _0863_ net236 clknet_4_5_0_clk timer\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[14\]$_DFF_PN0_ _0864_ net236 clknet_4_7_0_clk timer\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[15\]$_DFF_PN0_ _0865_ net236 clknet_4_7_0_clk timer\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[1\]$_DFF_PN0_ _0866_ net236 clknet_4_7_0_clk timer\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[2\]$_DFF_PN0_ _0867_ net236 clknet_4_6_0_clk timer\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[3\]$_DFF_PN0_ _0868_ net236 clknet_4_7_0_clk timer\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[4\]$_DFF_PN0_ _0869_ net236 clknet_4_7_0_clk timer\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[5\]$_DFF_PN0_ _0870_ net236 clknet_4_7_0_clk timer\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[6\]$_DFF_PN0_ _0871_ net236 clknet_4_5_0_clk timer\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[7\]$_DFF_PN0_ _0872_ net236 clknet_4_5_0_clk timer\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[8\]$_DFF_PN0_ _0873_ net236 clknet_4_5_0_clk timer\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtimer\[9\]$_DFF_PN0_ _0874_ net236 clknet_4_5_0_clk timer\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ready_reg$_DFF_PN0_ _0839_ net56 clknet_4_13_0_clk net221
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_1762__1 phy_bank_group[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1763__2 phy_bank_group[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1837__3 phy_dqs_n[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1838__4 phy_dqs_n[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1839__5 phy_dqs_n[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1840__6 phy_dqs_n[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1841__7 phy_dqs_n[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1842__8 phy_dqs_n[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1843__9 phy_dqs_n[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1844__10 phy_dqs_n[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_1845__12 phy_dqs_p[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1846__13 phy_dqs_p[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1847__14 phy_dqs_p[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1848__15 phy_dqs_p[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1849__16 phy_dqs_p[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1850__17 phy_dqs_p[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1851__18 phy_dqs_p[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1852__19 phy_dqs_p[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
X_1853__20 phy_odt VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
Xcmd_reg_valid$_DFF_PN0__21 net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__tieh
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput90 wr_data[39] net89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput91 wr_data[3] net90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput92 wr_data[40] net91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput93 wr_data[41] net92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput94 wr_data[42] net93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput95 wr_data[43] net94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput96 wr_data[44] net95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput97 wr_data[45] net96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput98 wr_data[46] net97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput99 wr_data[47] net98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput100 wr_data[48] net99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput101 wr_data[49] net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput102 wr_data[4] net101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput103 wr_data[50] net102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput104 wr_data[51] net103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput105 wr_data[52] net104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput106 wr_data[53] net105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput107 wr_data[54] net106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput108 wr_data[55] net107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput109 wr_data[56] net108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput110 wr_data[57] net109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput111 wr_data[58] net110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput112 wr_data[59] net111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput113 wr_data[5] net112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput114 wr_data[60] net113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput115 wr_data[61] net114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput116 wr_data[62] net115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput117 wr_data[63] net116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput118 wr_data[6] net117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput119 wr_data[7] net118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput120 wr_data[8] net119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput121 wr_data[9] net120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput122 wr_valid net121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput123 net122 cmd_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput124 net123 init_done VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput125 net124 phy_addr[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput126 net125 phy_addr[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput127 net126 phy_addr[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput128 net127 phy_addr[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput129 net128 phy_addr[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput130 net129 phy_addr[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput131 net130 phy_addr[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput132 net131 phy_addr[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput133 net132 phy_addr[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput134 net133 phy_addr[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput135 net134 phy_addr[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput136 net135 phy_addr[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput137 net136 phy_addr[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput138 net137 phy_addr[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput139 net138 phy_bank[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput140 net139 phy_bank[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput141 net140 phy_bank[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput142 net141 phy_cas_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput143 net142 phy_cs_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput144 net143 phy_dm[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput145 net144 phy_dm[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput146 net145 phy_dm[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput147 net146 phy_dm[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput148 net147 phy_dm[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput149 net148 phy_dm[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput150 net149 phy_dm[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput151 net150 phy_dm[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput152 net151 phy_ras_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput153 net152 phy_reset_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput154 net153 phy_we_n VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput155 net154 rd_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput156 net155 rd_data[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput157 net156 rd_data[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput158 net157 rd_data[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput159 net158 rd_data[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput160 net159 rd_data[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput161 net160 rd_data[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput162 net161 rd_data[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput163 net162 rd_data[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput164 net163 rd_data[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput165 net164 rd_data[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput166 net165 rd_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput167 net166 rd_data[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput168 net167 rd_data[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput169 net168 rd_data[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput170 net169 rd_data[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput171 net170 rd_data[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput172 net171 rd_data[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput173 net172 rd_data[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput174 net173 rd_data[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput175 net174 rd_data[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput176 net175 rd_data[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput177 net176 rd_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput178 net177 rd_data[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput179 net178 rd_data[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput180 net179 rd_data[32] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput181 net180 rd_data[33] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput182 net181 rd_data[34] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput183 net182 rd_data[35] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput184 net183 rd_data[36] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput185 net184 rd_data[37] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput186 net185 rd_data[38] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput187 net186 rd_data[39] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput188 net187 rd_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput189 net188 rd_data[40] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput190 net189 rd_data[41] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput191 net190 rd_data[42] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput192 net191 rd_data[43] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput193 net192 rd_data[44] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput194 net193 rd_data[45] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput195 net194 rd_data[46] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput196 net195 rd_data[47] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput197 net196 rd_data[48] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput198 net197 rd_data[49] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput199 net198 rd_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput200 net199 rd_data[50] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput201 net200 rd_data[51] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput202 net201 rd_data[52] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput203 net202 rd_data[53] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput204 net203 rd_data[54] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput205 net204 rd_data[55] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput206 net205 rd_data[56] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput207 net206 rd_data[57] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput208 net207 rd_data[58] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput209 net208 rd_data[59] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput210 net209 rd_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput211 net210 rd_data[60] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput212 net211 rd_data[61] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput213 net212 rd_data[62] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput214 net213 rd_data[63] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput215 net214 rd_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput216 net215 rd_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput217 net216 rd_data[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput218 net217 rd_data[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput219 net218 rd_valid VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput220 net219 state[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput221 net220 state[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput222 net221 wr_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace232 _0041_ net231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace233 _0040_ net232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace234 _0038_ net233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace235 _0042_ net234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace236 _0556_ net235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace238 net54 net237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace231 _0369_ net230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace237 net56 net236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace239 net24 net238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace240 net22 net239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkbuf_4_0_0_clk clknet_0_clk clknet_4_0_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk clknet_4_1_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk clknet_4_2_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk clknet_4_3_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk clknet_4_4_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk clknet_4_5_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk clknet_4_6_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk clknet_4_7_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk clknet_4_8_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk clknet_4_9_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk clknet_4_10_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk clknet_4_11_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk clknet_4_12_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk clknet_4_13_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk clknet_4_14_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk clknet_4_15_0_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload0 clknet_4_0_0_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload1 clknet_4_1_0_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload2 clknet_4_2_0_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload3 clknet_4_3_0_clk _unconnected_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload4 clknet_4_4_0_clk _unconnected_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload5 clknet_4_5_0_clk _unconnected_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload6 clknet_4_6_0_clk _unconnected_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload7 clknet_4_7_0_clk _unconnected_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload8 clknet_4_8_0_clk _unconnected_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload9 clknet_4_9_0_clk _unconnected_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload10 clknet_4_10_0_clk _unconnected_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload11 clknet_4_12_0_clk _unconnected_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload12 clknet_4_13_0_clk _unconnected_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload13 clknet_4_14_0_clk _unconnected_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xclkload14 clknet_4_15_0_clk _unconnected_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xhold241 rst_n net240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS ddr_controller
