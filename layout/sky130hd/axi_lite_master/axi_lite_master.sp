* cell axi_lite_master
* pin write_data[0]
* pin write_data[13]
* pin wdata[0]
* pin wdata[13]
* pin write_strb[1]
* pin wstrb[1]
* pin write_strb[0]
* pin write_strb[2]
* pin write_data[7]
* pin wstrb[0]
* pin wstrb[2]
* pin wdata[7]
* pin write_addr[16]
* pin awaddr[16]
* pin write_addr[17]
* pin write_addr[12]
* pin awaddr[12]
* pin awaddr[17]
* pin write_addr[14]
* pin write_addr[10]
* pin write_addr[0]
* pin awaddr[10]
* pin awaddr[14]
* pin awaddr[0]
* pin bready
* pin wvalid
* pin awaddr[11]
* pin wready
* pin awready
* pin awvalid
* pin read_addr[3]
* pin read_addr[4]
* pin araddr[4]
* pin read_addr[6]
* pin read_addr[2]
* pin araddr[6]
* pin read_addr[7]
* pin read_addr[29]
* pin araddr[7]
* pin araddr[29]
* pin araddr[31]
* pin read_addr[31]
* pin read_addr[30]
* pin read_addr[5]
* pin read_addr[28]
* pin araddr[30]
* pin araddr[5]
* pin araddr[28]
* pin read_addr[21]
* pin read_addr[26]
* pin araddr[26]
* pin write_addr[11]
* pin araddr[3]
* pin araddr[2]
* pin read_addr[27]
* pin araddr[21]
* pin VSS
* pin araddr[0]
* pin VDD
* pin read_addr[22]
* pin awaddr[7]
* pin awaddr[13]
* pin read_addr[0]
* pin araddr[10]
* pin awaddr[2]
* pin write_addr[7]
* pin araddr[22]
* pin araddr[11]
* pin write_strb[3]
* pin wstrb[3]
* pin araddr[23]
* pin wdata[10]
* pin write_addr[2]
* pin read_addr[24]
* pin read_addr[23]
* pin write_data[10]
* pin wdata[14]
* pin araddr[24]
* pin araddr[19]
* pin wdata[12]
* pin awaddr[8]
* pin write_addr[8]
* pin araddr[27]
* pin araddr[20]
* pin araddr[25]
* pin wdata[5]
* pin read_addr[20]
* pin write_addr[3]
* pin write_data[12]
* pin araddr[1]
* pin read_addr[25]
* pin wdata[6]
* pin wdata[11]
* pin read_addr[19]
* pin read_addr[1]
* pin write_data[11]
* pin read_addr[11]
* pin araddr[8]
* pin write_data[15]
* pin write_data[9]
* pin wdata[9]
* pin read_addr[9]
* pin read_addr[8]
* pin wdata[15]
* pin write_data[5]
* pin araddr[9]
* pin araddr[17]
* pin read_addr[10]
* pin write_addr[9]
* pin write_data[14]
* pin read_addr[16]
* pin awaddr[9]
* pin read_addr[17]
* pin write_data[6]
* pin araddr[16]
* pin write_data[8]
* pin wdata[8]
* pin araddr[14]
* pin arvalid
* pin write_addr[15]
* pin awaddr[15]
* pin read_addr[14]
* pin read_req
* pin write_addr[13]
* pin write_req
* pin write_addr[30]
* pin arready
* pin awaddr[30]
* pin awaddr[3]
* pin araddr[13]
* pin read_addr[15]
* pin write_addr[4]
* pin write_addr[31]
* pin read_addr[13]
* pin bvalid
* pin read_addr[12]
* pin awaddr[4]
* pin awaddr[31]
* pin araddr[15]
* pin clk
* pin write_addr[19]
* pin araddr[18]
* pin awaddr[19]
* pin rvalid
* pin read_addr[18]
* pin write_addr[21]
* pin rready
* pin araddr[12]
* pin write_addr[20]
* pin write_addr[5]
* pin awaddr[29]
* pin rdata[22]
* pin read_done
* pin awaddr[6]
* pin write_addr[6]
* pin read_data[22]
* pin rdata[23]
* pin awaddr[21]
* pin awaddr[27]
* pin rdata[27]
* pin awaddr[20]
* pin awaddr[1]
* pin write_addr[23]
* pin rdata[20]
* pin read_data[27]
* pin awaddr[28]
* pin write_addr[29]
* pin read_data[23]
* pin read_data[20]
* pin awaddr[26]
* pin write_addr[26]
* pin read_data[19]
* pin read_data[8]
* pin write_addr[27]
* pin wdata[23]
* pin write_data[23]
* pin rdata[24]
* pin write_data[27]
* pin rdata[8]
* pin read_data[6]
* pin read_data[29]
* pin wdata[31]
* pin rdata[25]
* pin read_data[26]
* pin write_addr[28]
* pin write_data[31]
* pin write_addr[22]
* pin awaddr[25]
* pin wdata[2]
* pin read_data[9]
* pin read_data[24]
* pin write_data[2]
* pin wdata[27]
* pin rdata[21]
* pin read_data[21]
* pin awaddr[23]
* pin read_data[25]
* pin wdata[26]
* pin rdata[19]
* pin rdata[9]
* pin read_data[7]
* pin write_data[25]
* pin write_data[26]
* pin rdata[1]
* pin rdata[7]
* pin awaddr[22]
* pin wdata[1]
* pin write_data[1]
* pin wdata[25]
* pin read_data[10]
* pin write_data[30]
* pin wdata[16]
* pin read_data[3]
* pin rdata[3]
* pin wdata[3]
* pin write_data[16]
* pin read_data[13]
* pin read_data[17]
* pin read_data[11]
* pin read_data[4]
* pin rdata[4]
* pin wdata[4]
* pin write_data[29]
* pin rdata[17]
* pin rdata[11]
* pin write_data[19]
* pin write_addr[24]
* pin write_data[4]
* pin write_data[28]
* pin write_data[3]
* pin rdata[26]
* pin wdata[30]
* pin wdata[17]
* pin wdata[19]
* pin read_data[12]
* pin read_data[30]
* pin wdata[29]
* pin awaddr[5]
* pin rdata[12]
* pin read_data[1]
* pin rdata[10]
* pin rdata[13]
* pin write_data[17]
* pin rdata[30]
* pin read_data[16]
* pin rdata[6]
* pin read_data[14]
* pin rst_n
* pin wdata[22]
* pin read_data[18]
* pin read_data[31]
* pin wdata[28]
* pin wdata[24]
* pin rdata[16]
* pin wdata[21]
* pin wdata[18]
* pin write_addr[1]
* pin read_data[0]
* pin awaddr[18]
* pin read_data[5]
* pin read_data[15]
* pin read_data[2]
* pin write_data[20]
* pin rdata[5]
* pin wdata[20]
* pin write_data[22]
* pin write_data[24]
* pin rdata[14]
* pin rdata[0]
* pin write_data[21]
* pin write_data[18]
* pin rdata[18]
* pin rdata[15]
* pin read_data[28]
* pin rdata[28]
* pin write_addr[18]
* pin rdata[2]
* pin rdata[31]
* pin write_addr[25]
* pin awaddr[24]
* pin rdata[29]
* pin write_done
.SUBCKT axi_lite_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 53 54 55 56 57 60 66 67 68 70 87 92 93 106 107 112 113 127 128
+ 131 142 143 144 145 153 154 158 159 166 167 168 170 171 172 187 190 198 199
+ 204 205 213 214 218 219 227 233 234 237 247 248 250 251 259 260 262 263 266
+ 270 271 272 279 281 284 286 290 291 294 295 300 319 321 322 332 336 339 343
+ 353 354 362 363 369 370 375 383 388 393 394 398 403 405 408 414 418 419 425
+ 427 428 432 433 447 449 454 458 459 463 464 465 471 473 474 481 482 483 484
+ 488 489 493 497 502 503 506 507 510 514 517 518 521 524 525 527 529 531 532
+ 533 537 538 539 542 544 545 555 556 560 561 563 569 573 578 583 585 588 589
+ 593 602 603 604 605 606 609 611 617 618 621 625 627 629 634 635 637 638 640
+ 641 646 647 651 653 654 655 656 657 662 663 665 667 670 672 673 674 676 677
+ 678 679 683 685 700 702 703 707 708 712 722 723 726 727 728 729 730 731 733
+ 734 736 738 739 741 743 744 747 749 750 751 753 755 757 759 760 762 765 766
+ 767 768 769
* net 1 write_data[0]
* net 2 write_data[13]
* net 3 wdata[0]
* net 4 wdata[13]
* net 5 write_strb[1]
* net 6 wstrb[1]
* net 7 write_strb[0]
* net 8 write_strb[2]
* net 9 write_data[7]
* net 10 wstrb[0]
* net 11 wstrb[2]
* net 12 wdata[7]
* net 13 write_addr[16]
* net 14 awaddr[16]
* net 15 write_addr[17]
* net 16 write_addr[12]
* net 17 awaddr[12]
* net 18 awaddr[17]
* net 19 write_addr[14]
* net 20 write_addr[10]
* net 21 write_addr[0]
* net 22 awaddr[10]
* net 23 awaddr[14]
* net 24 awaddr[0]
* net 25 bready
* net 26 wvalid
* net 27 awaddr[11]
* net 28 wready
* net 29 awready
* net 30 awvalid
* net 31 read_addr[3]
* net 32 read_addr[4]
* net 33 araddr[4]
* net 34 read_addr[6]
* net 35 read_addr[2]
* net 36 araddr[6]
* net 37 read_addr[7]
* net 38 read_addr[29]
* net 39 araddr[7]
* net 40 araddr[29]
* net 41 araddr[31]
* net 42 read_addr[31]
* net 43 read_addr[30]
* net 44 read_addr[5]
* net 45 read_addr[28]
* net 46 araddr[30]
* net 47 araddr[5]
* net 48 araddr[28]
* net 49 read_addr[21]
* net 50 read_addr[26]
* net 51 araddr[26]
* net 53 write_addr[11]
* net 54 araddr[3]
* net 55 araddr[2]
* net 56 read_addr[27]
* net 57 araddr[21]
* net 60 VSS
* net 66 araddr[0]
* net 67 VDD
* net 68 read_addr[22]
* net 70 awaddr[7]
* net 87 awaddr[13]
* net 92 read_addr[0]
* net 93 araddr[10]
* net 106 awaddr[2]
* net 107 write_addr[7]
* net 112 araddr[22]
* net 113 araddr[11]
* net 127 write_strb[3]
* net 128 wstrb[3]
* net 131 araddr[23]
* net 142 wdata[10]
* net 143 write_addr[2]
* net 144 read_addr[24]
* net 145 read_addr[23]
* net 153 write_data[10]
* net 154 wdata[14]
* net 158 araddr[24]
* net 159 araddr[19]
* net 166 wdata[12]
* net 167 awaddr[8]
* net 168 write_addr[8]
* net 170 araddr[27]
* net 171 araddr[20]
* net 172 araddr[25]
* net 187 wdata[5]
* net 190 read_addr[20]
* net 198 write_addr[3]
* net 199 write_data[12]
* net 204 araddr[1]
* net 205 read_addr[25]
* net 213 wdata[6]
* net 214 wdata[11]
* net 218 read_addr[19]
* net 219 read_addr[1]
* net 227 write_data[11]
* net 233 read_addr[11]
* net 234 araddr[8]
* net 237 write_data[15]
* net 247 write_data[9]
* net 248 wdata[9]
* net 250 read_addr[9]
* net 251 read_addr[8]
* net 259 wdata[15]
* net 260 write_data[5]
* net 262 araddr[9]
* net 263 araddr[17]
* net 266 read_addr[10]
* net 270 write_addr[9]
* net 271 write_data[14]
* net 272 read_addr[16]
* net 279 awaddr[9]
* net 281 read_addr[17]
* net 284 write_data[6]
* net 286 araddr[16]
* net 290 write_data[8]
* net 291 wdata[8]
* net 294 araddr[14]
* net 295 arvalid
* net 300 write_addr[15]
* net 319 awaddr[15]
* net 321 read_addr[14]
* net 322 read_req
* net 332 write_addr[13]
* net 336 write_req
* net 339 write_addr[30]
* net 343 arready
* net 353 awaddr[30]
* net 354 awaddr[3]
* net 362 araddr[13]
* net 363 read_addr[15]
* net 369 write_addr[4]
* net 370 write_addr[31]
* net 375 read_addr[13]
* net 383 bvalid
* net 388 read_addr[12]
* net 393 awaddr[4]
* net 394 awaddr[31]
* net 398 araddr[15]
* net 403 clk
* net 405 write_addr[19]
* net 408 araddr[18]
* net 414 awaddr[19]
* net 418 rvalid
* net 419 read_addr[18]
* net 425 write_addr[21]
* net 427 rready
* net 428 araddr[12]
* net 432 write_addr[20]
* net 433 write_addr[5]
* net 447 awaddr[29]
* net 449 rdata[22]
* net 454 read_done
* net 458 awaddr[6]
* net 459 write_addr[6]
* net 463 read_data[22]
* net 464 rdata[23]
* net 465 awaddr[21]
* net 471 awaddr[27]
* net 473 rdata[27]
* net 474 awaddr[20]
* net 481 awaddr[1]
* net 482 write_addr[23]
* net 483 rdata[20]
* net 484 read_data[27]
* net 488 awaddr[28]
* net 489 write_addr[29]
* net 493 read_data[23]
* net 497 read_data[20]
* net 502 awaddr[26]
* net 503 write_addr[26]
* net 506 read_data[19]
* net 507 read_data[8]
* net 510 write_addr[27]
* net 514 wdata[23]
* net 517 write_data[23]
* net 518 rdata[24]
* net 521 write_data[27]
* net 524 rdata[8]
* net 525 read_data[6]
* net 527 read_data[29]
* net 529 wdata[31]
* net 531 rdata[25]
* net 532 read_data[26]
* net 533 write_addr[28]
* net 537 write_data[31]
* net 538 write_addr[22]
* net 539 awaddr[25]
* net 542 wdata[2]
* net 544 read_data[9]
* net 545 read_data[24]
* net 555 write_data[2]
* net 556 wdata[27]
* net 560 rdata[21]
* net 561 read_data[21]
* net 563 awaddr[23]
* net 569 read_data[25]
* net 573 wdata[26]
* net 578 rdata[19]
* net 583 rdata[9]
* net 585 read_data[7]
* net 588 write_data[25]
* net 589 write_data[26]
* net 593 rdata[1]
* net 602 rdata[7]
* net 603 awaddr[22]
* net 604 wdata[1]
* net 605 write_data[1]
* net 606 wdata[25]
* net 609 read_data[10]
* net 611 write_data[30]
* net 617 wdata[16]
* net 618 read_data[3]
* net 621 rdata[3]
* net 625 wdata[3]
* net 627 write_data[16]
* net 629 read_data[13]
* net 634 read_data[17]
* net 635 read_data[11]
* net 637 read_data[4]
* net 638 rdata[4]
* net 640 wdata[4]
* net 641 write_data[29]
* net 646 rdata[17]
* net 647 rdata[11]
* net 651 write_data[19]
* net 653 write_addr[24]
* net 654 write_data[4]
* net 655 write_data[28]
* net 656 write_data[3]
* net 657 rdata[26]
* net 662 wdata[30]
* net 663 wdata[17]
* net 665 wdata[19]
* net 667 read_data[12]
* net 670 read_data[30]
* net 672 wdata[29]
* net 673 awaddr[5]
* net 674 rdata[12]
* net 676 read_data[1]
* net 677 rdata[10]
* net 678 rdata[13]
* net 679 write_data[17]
* net 683 rdata[30]
* net 685 read_data[16]
* net 700 rdata[6]
* net 702 read_data[14]
* net 703 rst_n
* net 707 wdata[22]
* net 708 read_data[18]
* net 712 read_data[31]
* net 722 wdata[28]
* net 723 wdata[24]
* net 726 rdata[16]
* net 727 wdata[21]
* net 728 wdata[18]
* net 729 write_addr[1]
* net 730 read_data[0]
* net 731 awaddr[18]
* net 733 read_data[5]
* net 734 read_data[15]
* net 736 read_data[2]
* net 738 write_data[20]
* net 739 rdata[5]
* net 741 wdata[20]
* net 743 write_data[22]
* net 744 write_data[24]
* net 747 rdata[14]
* net 749 rdata[0]
* net 750 write_data[21]
* net 751 write_data[18]
* net 753 rdata[18]
* net 755 rdata[15]
* net 757 read_data[28]
* net 759 rdata[28]
* net 760 write_addr[18]
* net 762 rdata[2]
* net 765 rdata[31]
* net 766 write_addr[25]
* net 767 awaddr[24]
* net 768 rdata[29]
* net 769 write_done
* cell instance $3 r0 *1 17.48,13.6
X$3 67 1 60 67 134 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $6 r0 *1 22.54,2.72
X$6 67 2 60 67 74 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $8 r0 *1 18.86,2.72
X$8 67 72 60 67 3 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $12 m0 *1 23,8.16
X$12 67 90 60 67 4 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $15 m0 *1 30.36,13.6
X$15 67 5 60 67 120 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $18 r0 *1 31.74,2.72
X$18 67 62 60 67 6 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $21 r0 *1 31.28,13.6
X$21 67 7 60 67 135 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $24 m0 *1 31.28,24.48
X$24 67 8 60 67 195 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $29 m0 *1 42.32,29.92
X$29 67 9 60 67 222 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $32 r0 *1 39.1,13.6
X$32 67 130 60 67 10 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $37 m0 *1 40.02,24.48
X$37 67 209 60 67 11 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $42 r0 *1 43.7,24.48
X$42 67 215 60 67 12 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $45 r0 *1 39.1,8.16
X$45 67 13 60 67 104 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $48 m0 *1 43.24,8.16
X$48 67 91 60 67 14 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $51 r0 *1 39.1,2.72
X$51 67 15 60 67 78 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $54 r0 *1 44.16,2.72
X$54 67 16 60 67 79 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $57 m0 *1 48.76,8.16
X$57 67 105 60 67 17 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $60 r0 *1 47.84,2.72
X$60 67 80 60 67 18 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $63 r0 *1 49.68,19.04
X$63 67 19 60 67 182 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $66 r0 *1 55.2,13.6
X$66 67 20 60 67 151 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $69 m0 *1 51.52,40.8
X$69 67 21 60 67 269 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $72 r0 *1 53.82,19.04
X$72 67 183 60 67 22 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $75 m0 *1 51.06,19.04
X$75 67 165 60 67 23 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $80 r0 *1 53.36,29.92
X$80 67 241 60 67 24 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $87 m0 *1 52.9,46.24
X$87 67 285 60 67 25 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $89 r0 *1 56.12,40.8
X$89 67 283 60 67 26 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $93 r0 *1 57.04,2.72
X$93 67 85 60 67 27 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $96 r0 *1 57.5,35.36
X$96 67 28 60 67 293 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $99 r0 *1 61.18,35.36
X$99 67 29 60 67 310 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $102 m0 *1 61.18,40.8
X$102 67 277 60 67 30 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $105 r0 *1 63.02,2.72
X$105 67 31 60 67 103 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $108 m0 *1 67.62,8.16
X$108 67 32 60 67 101 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $111 m0 *1 59.8,8.16
X$111 67 126 60 67 33 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $114 r0 *1 66.7,2.72
X$114 67 34 60 67 83 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $117 r0 *1 65.32,19.04
X$117 67 35 60 67 185 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $120 r0 *1 71.3,2.72
X$120 67 82 60 67 36 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $125 r0 *1 70.84,24.48
X$125 67 37 60 67 212 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $128 r0 *1 70.84,29.92
X$128 67 38 60 67 236 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $131 m0 *1 70.38,29.92
X$131 67 226 60 67 39 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $135 m0 *1 74.52,35.36
X$135 67 242 60 67 40 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $139 m0 *1 73.14,8.16
X$139 67 99 60 67 41 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $142 r0 *1 78.66,2.72
X$142 67 42 60 67 77 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $145 r0 *1 84.64,2.72
X$145 67 43 60 67 76 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $148 m0 *1 84.64,19.04
X$148 67 44 60 67 139 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $151 r0 *1 88.32,2.72
X$151 67 45 60 67 189 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $156 r0 *1 83.72,8.16
X$156 67 125 60 67 46 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $159 r0 *1 82.8,13.6
X$159 67 140 60 67 47 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $162 r0 *1 82.8,24.48
X$162 67 188 60 67 48 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $165 r0 *1 92,2.72
X$165 67 49 60 67 75 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $168 m0 *1 97.98,8.16
X$168 67 50 60 67 94 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $171 m0 *1 95.68,19.04
X$171 67 121 60 67 51 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $174 m0 *1 4.6,8.16
X$174 60 88 52 89 69 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $177 r0 *1 10.12,2.72
X$177 67 52 60 67 70 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $179 r0 *1 5.98,2.72
X$179 60 69 52 61 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $182 r0 *1 52.9,2.72
X$182 67 53 60 67 84 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $185 r0 *1 74.98,2.72
X$185 67 64 60 67 54 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $188 m0 *1 68.54,24.48
X$188 67 169 60 67 55 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $191 r0 *1 92,13.6
X$191 67 56 60 67 163 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $194 r0 *1 98.44,2.72
X$194 67 73 60 67 57 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $198 r0 *1 107.18,2.72
X$198 60 71 65 58 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $200 r0 *1 109.48,8.16
X$200 67 92 60 67 58 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $234 m0 *1 106.26,40.8
X$234 60 243 217 253 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $237 m0 *1 101.66,13.6
X$237 60 137 111 136 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $239 m0 *1 75.44,46.24
X$239 67 305 67 60 59 60 sky130_fd_sc_hd__buf_4
* cell instance $241 m0 *1 105.8,13.6
X$241 60 119 117 133 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $244 r0 *1 70.84,35.36
X$244 60 246 242 236 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $246 m0 *1 99.36,51.68
X$246 60 334 326 325 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $248 r0 *1 93.84,57.12
X$248 60 402 401 420 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $250 r0 *1 86.94,29.92
X$250 60 231 225 224 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $252 m0 *1 89.7,13.6
X$252 60 98 73 75 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $254 r0 *1 93.84,40.8
X$254 60 275 258 268 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $256 r0 *1 89.7,35.36
X$256 60 244 235 194 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $259 m0 *1 93.84,13.6
X$259 60 122 121 94 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $261 m0 *1 105.34,46.24
X$261 60 288 298 296 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $264 r0 *1 107.64,40.8
X$264 60 267 232 265 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $266 r0 *1 106.26,46.24
X$266 60 302 316 273 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $268 m0 *1 106.72,51.68
X$268 60 348 337 347 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $270 m0 *1 105.8,57.12
X$270 60 374 335 391 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $272 m0 *1 67.62,13.6
X$272 60 110 126 101 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $274 m0 *1 63.48,8.16
X$274 60 86 64 103 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $276 m0 *1 64.4,24.48
X$276 60 197 169 185 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $278 m0 *1 66.24,29.92
X$278 60 223 226 212 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $280 m0 *1 76.82,8.16
X$280 60 81 77 99 59 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $282 r0 *1 66.24,13.6
X$282 60 152 82 83 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $284 m0 *1 72.22,13.6
X$284 60 141 125 76 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $287 m0 *1 76.36,13.6
X$287 60 186 140 139 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $289 r0 *1 107.18,19.04
X$289 60 179 157 162 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $291 m0 *1 91.54,19.04
X$291 60 184 164 163 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $294 r0 *1 98.44,24.48
X$294 60 210 181 192 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $296 r0 *1 78.66,24.48
X$296 60 211 188 189 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $299 r0 *1 102.12,19.04
X$299 60 180 147 148 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $303 r0 *1 106.26,24.48
X$303 60 208 178 191 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $305 m0 *1 107.64,62.56
X$305 60 410 400 421 59 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $322 r0 *1 2.3,2.72
X$322 67 116 60 67 106 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $356 r0 *1 103.5,2.72
X$356 67 68 60 67 133 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $373 m0 *1 13.8,8.16
X$373 60 88 72 89 97 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $378 m0 *1 29.9,8.16
X$378 60 88 62 124 100 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $379 m0 *1 39.1,8.16
X$379 60 102 104 91 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $393 m0 *1 87.4,8.16
X$393 60 96 73 95 98 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $396 m0 *1 101.66,8.16
X$396 60 96 65 95 71 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $399 m0 *1 112.24,8.16
X$399 67 117 60 67 112 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $405 r0 *1 4.6,8.16
X$405 60 88 116 89 114 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $413 r0 *1 18.86,8.16
X$413 60 88 90 89 118 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $417 r0 *1 31.28,8.16
X$417 60 100 62 120 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $421 r0 *1 43.24,8.16
X$421 60 96 105 124 123 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $424 r0 *1 53.82,8.16
X$424 60 138 84 85 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $426 r0 *1 59.8,8.16
X$426 60 96 64 109 86 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $433 r0 *1 73.14,8.16
X$433 60 96 99 95 81 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $436 r0 *1 87.4,8.16
X$436 60 96 121 95 122 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $442 r0 *1 100.28,8.16
X$442 60 96 117 95 119 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $443 r0 *1 113.16,8.16
X$443 67 111 60 67 131 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $453 m0 *1 1.38,13.6
X$453 67 127 60 67 129 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $455 m0 *1 5.52,13.6
X$455 60 114 116 132 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $458 m0 *1 11.04,13.6
X$458 60 115 146 129 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $462 m0 *1 18.4,13.6
X$462 60 97 72 134 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $463 m0 *1 22.54,13.6
X$463 60 118 90 74 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $468 m0 *1 34.04,13.6
X$468 60 96 91 124 102 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $471 m0 *1 47.38,13.6
X$471 60 96 85 124 138 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $475 m0 *1 58.42,13.6
X$475 60 96 126 109 110 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $482 m0 *1 97.98,13.6
X$482 67 145 60 67 136 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $489 r0 *1 1.84,13.6
X$489 67 143 60 67 132 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $490 r0 *1 5.52,13.6
X$490 60 88 146 89 115 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $495 r0 *1 21.16,13.6
X$495 67 89 67 60 60 sky130_fd_sc_hd__clkinv_2
* cell instance $499 r0 *1 34.96,13.6
X$499 60 149 130 135 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $502 r0 *1 43.24,13.6
X$502 60 150 78 80 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $503 r0 *1 47.38,13.6
X$503 60 123 79 105 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $511 r0 *1 73.6,13.6
X$511 60 96 125 109 141 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $519 r0 *1 99.36,13.6
X$519 60 96 111 95 137 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $520 r0 *1 108.56,13.6
X$520 67 144 60 67 148 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $523 r0 *1 113.62,13.6
X$523 67 147 60 67 158 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $532 m0 *1 1.38,19.04
X$532 67 168 60 67 160 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $533 m0 *1 5.06,19.04
X$533 67 107 60 67 61 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $535 m0 *1 9.66,19.04
X$535 67 146 60 67 128 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $537 m0 *1 13.8,19.04
X$537 67 153 60 67 161 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $538 m0 *1 17.48,19.04
X$538 60 88 155 89 175 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $545 m0 *1 32.66,19.04
X$545 60 96 130 124 149 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $546 m0 *1 41.86,19.04
X$546 60 96 80 124 150 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $551 m0 *1 64.4,19.04
X$551 60 96 82 109 152 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $553 m0 *1 74.52,19.04
X$553 60 156 109 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $560 m0 *1 100.28,19.04
X$560 60 96 147 95 180 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $564 m0 *1 112.24,19.04
X$564 67 65 60 67 66 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $568 r0 *1 2.3,19.04
X$568 67 173 60 67 167 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $569 r0 *1 5.98,19.04
X$569 60 174 173 160 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $572 r0 *1 11.5,19.04
X$572 67 155 60 67 142 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $577 r0 *1 17.02,19.04
X$577 60 175 155 161 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $578 r0 *1 21.16,19.04
X$578 60 156 89 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $582 r0 *1 33.58,19.04
X$582 60 156 124 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $597 r0 *1 74.52,19.04
X$597 60 109 67 67 60 sky130_fd_sc_hd__bufinv_16
* cell instance $599 r0 *1 86.02,19.04
X$599 67 95 67 60 60 sky130_fd_sc_hd__clkinv_2
* cell instance $600 r0 *1 87.86,19.04
X$600 60 156 95 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $604 r0 *1 98.44,19.04
X$604 67 164 60 67 170 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $606 r0 *1 111.32,19.04
X$606 67 157 60 67 159 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $619 m0 *1 4.14,24.48
X$619 60 88 173 89 174 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $622 m0 *1 16.1,24.48
X$622 67 199 60 67 193 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $623 m0 *1 19.78,24.48
X$623 60 177 176 193 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $629 m0 *1 34.96,24.48
X$629 60 124 67 67 60 sky130_fd_sc_hd__clkbuf_8
* cell instance $633 m0 *1 51.52,24.48
X$633 60 196 182 165 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $640 m0 *1 74.98,24.48
X$640 60 96 140 109 186 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $644 m0 *1 87.4,24.48
X$644 60 96 164 95 184 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $647 m0 *1 99.36,24.48
X$647 67 251 60 67 194 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $648 m0 *1 103.04,24.48
X$648 67 181 60 67 171 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $651 m0 *1 108.1,24.48
X$651 67 178 60 67 172 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $653 m0 *1 112.24,24.48
X$653 67 218 60 67 162 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $658 r0 *1 3.68,24.48
X$658 67 206 60 67 154 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $661 r0 *1 11.5,24.48
X$661 67 176 60 67 166 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $666 r0 *1 18.4,24.48
X$666 60 88 176 89 177 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $670 r0 *1 35.88,24.48
X$670 60 207 209 195 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $676 r0 *1 47.38,24.48
X$676 60 216 183 124 202 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $677 r0 *1 56.58,24.48
X$677 60 202 151 183 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $678 r0 *1 60.72,24.48
X$678 60 216 169 109 197 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $690 r0 *1 102.58,24.48
X$690 67 190 60 67 192 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $691 r0 *1 110.4,24.48
X$691 67 205 60 67 191 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $705 m0 *1 2.76,29.92
X$705 67 227 60 67 200 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $706 m0 *1 6.44,29.92
X$706 60 220 201 200 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $707 m0 *1 10.58,29.92
X$707 67 201 60 67 214 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $710 m0 *1 18.86,29.92
X$710 67 221 60 67 187 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $716 m0 *1 33.12,29.92
X$716 60 96 209 124 207 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $719 m0 *1 47.38,29.92
X$719 60 216 165 124 196 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $725 m0 *1 74.52,29.92
X$725 60 96 188 109 211 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $730 m0 *1 88.78,29.92
X$730 67 225 60 67 204 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $731 m0 *1 92.46,29.92
X$731 60 96 181 203 210 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $733 m0 *1 102.58,29.92
X$733 60 96 178 203 208 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $735 m0 *1 112.24,29.92
X$735 67 217 60 67 113 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $741 r0 *1 4.6,29.92
X$741 60 88 201 228 220 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $748 r0 *1 20.24,29.92
X$748 60 88 221 228 245 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $751 r0 *1 33.58,29.92
X$751 60 96 215 257 229 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $754 r0 *1 43.24,29.92
X$754 60 229 215 222 63 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $760 r0 *1 61.18,29.92
X$760 60 216 226 230 223 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $766 r0 *1 77.74,29.92
X$766 60 216 225 230 231 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $768 r0 *1 91.54,29.92
X$768 67 219 60 67 224 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $773 r0 *1 98.44,29.92
X$773 67 235 60 67 234 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $774 r0 *1 102.12,29.92
X$774 60 96 157 203 179 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $777 r0 *1 113.62,29.92
X$777 67 232 60 67 93 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $780 m0 *1 4.14,35.36
X$780 60 88 206 228 264 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $784 m0 *1 15.18,35.36
X$784 67 247 60 67 238 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $785 m0 *1 18.86,35.36
X$785 60 254 249 238 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $786 m0 *1 23,35.36
X$786 60 245 221 255 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $792 m0 *1 32.66,35.36
X$792 67 237 60 67 256 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $793 m0 *1 36.34,35.36
X$793 60 278 239 256 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $797 m0 *1 42.32,35.36
X$797 60 216 241 257 240 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $798 m0 *1 51.52,35.36
X$798 60 240 269 241 63 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $804 m0 *1 65.32,35.36
X$804 60 216 242 230 246 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $813 m0 *1 86.02,35.36
X$813 60 216 235 230 244 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $818 m0 *1 97.52,35.36
X$818 67 258 60 67 262 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $819 m0 *1 101.2,35.36
X$819 60 96 217 203 243 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $823 m0 *1 112.24,35.36
X$823 67 233 60 67 253 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $827 r0 *1 1.84,35.36
X$827 67 271 60 67 252 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $828 r0 *1 5.52,35.36
X$828 60 264 206 252 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $831 r0 *1 11.04,35.36
X$831 67 249 60 67 248 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $836 r0 *1 17.48,35.36
X$836 60 88 249 228 254 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $839 r0 *1 34.04,35.36
X$839 60 257 67 67 60 sky130_fd_sc_hd__clkbuf_8
* cell instance $854 r0 *1 78.66,35.36
X$854 60 156 230 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $856 r0 *1 93.84,35.36
X$856 67 250 60 67 268 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $862 r0 *1 101.2,35.36
X$862 60 96 232 203 267 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $866 r0 *1 113.62,35.36
X$866 67 266 60 67 265 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $870 m0 *1 4.6,40.8
X$870 60 88 280 228 274 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $872 m0 *1 14.26,40.8
X$872 67 260 60 67 255 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $877 m0 *1 20.24,40.8
X$877 67 228 60 67 60 sky130_fd_sc_hd__clkbuf_1
* cell instance $878 m0 *1 21.62,40.8
X$878 67 261 60 67 213 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $879 m0 *1 25.3,40.8
X$879 67 284 60 67 276 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $883 m0 *1 30.82,40.8
X$883 60 303 261 276 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $885 m0 *1 35.42,40.8
X$885 60 88 239 257 278 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $904 m0 *1 78.66,40.8
X$904 67 230 67 60 60 sky130_fd_sc_hd__clkinv_2
* cell instance $909 m0 *1 87.4,40.8
X$909 60 96 258 230 275 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $912 m0 *1 96.6,40.8
X$912 60 156 203 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $919 m0 *1 113.62,40.8
X$919 67 272 60 67 273 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $920 r0 *1 1.38,40.8
X$920 67 270 60 67 282 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $921 r0 *1 5.06,40.8
X$921 60 274 280 282 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $924 r0 *1 11.5,40.8
X$924 67 280 60 67 279 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $928 r0 *1 16.56,40.8
X$928 67 198 60 67 287 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $929 r0 *1 20.24,40.8
X$929 60 156 228 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $932 r0 *1 33.58,40.8
X$932 60 156 257 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $955 r0 *1 98.44,40.8
X$955 60 96 298 203 288 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $956 r0 *1 111.78,40.8
X$956 67 281 60 67 296 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $959 m0 *1 2.3,46.24
X$959 67 290 60 67 292 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $960 m0 *1 5.98,46.24
X$960 60 297 317 292 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $966 m0 *1 15.18,46.24
X$966 67 300 60 67 301 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $967 m0 *1 18.86,46.24
X$967 60 299 301 323 108 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $969 m0 *1 23.92,46.24
X$969 60 318 324 287 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $972 m0 *1 29.44,46.24
X$972 60 88 261 257 303 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $973 m0 *1 38.64,46.24
X$973 67 239 60 67 259 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $976 m0 *1 42.32,46.24
X$976 67 304 60 67 87 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $982 m0 *1 57.04,46.24
X$982 67 293 283 306 285 60 67 289 60 sky130_fd_sc_hd__a31oi_1
* cell instance $983 m0 *1 59.34,46.24
X$983 67 293 67 60 307 60 sky130_fd_sc_hd__inv_1
* cell instance $986 m0 *1 66.24,46.24
X$986 60 88 277 230 308 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $999 m0 *1 96.14,46.24
X$999 60 96 316 203 302 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1003 m0 *1 112.24,46.24
X$1003 67 298 60 67 263 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1008 r0 *1 4.14,46.24
X$1008 60 88 317 228 297 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1014 r0 *1 18.4,46.24
X$1014 67 323 60 67 319 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1016 r0 *1 22.54,46.24
X$1016 60 88 324 228 318 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1018 r0 *1 32.66,46.24
X$1018 60 88 304 257 327 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1024 r0 *1 48.76,46.24
X$1024 60 88 283 257 328 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1025 r0 *1 57.96,46.24
X$1025 67 309 307 283 311 320 67 60 60 sky130_fd_sc_hd__o211ai_1
* cell instance $1026 r0 *1 60.72,46.24
X$1026 60 331 277 309 283 310 311 67 67 60 sky130_fd_sc_hd__a41oi_1
* cell instance $1028 r0 *1 64.86,46.24
X$1028 67 312 313 314 277 67 367 60 60 sky130_fd_sc_hd__a22oi_1
* cell instance $1029 r0 *1 67.62,46.24
X$1029 67 314 309 312 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1035 r0 *1 71.3,46.24
X$1035 67 315 330 329 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1037 r0 *1 74.52,46.24
X$1037 60 216 315 230 366 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1041 r0 *1 90.16,46.24
X$1041 67 315 60 67 295 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1046 r0 *1 98.44,46.24
X$1046 67 321 60 67 325 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1048 r0 *1 102.58,46.24
X$1048 67 326 60 67 294 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1049 r0 *1 110.4,46.24
X$1049 67 316 60 67 286 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1063 m0 *1 5.52,51.68
X$1063 60 346 344 345 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1064 m0 *1 9.66,51.68
X$1064 67 317 60 67 291 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1066 m0 *1 17.02,51.68
X$1066 60 88 323 228 299 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1071 m0 *1 31.28,51.68
X$1071 67 332 60 67 338 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1072 m0 *1 34.96,51.68
X$1072 60 327 338 304 108 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $1076 m0 *1 47.38,51.68
X$1076 67 63 67 60 108 60 sky130_fd_sc_hd__buf_4
* cell instance $1080 m0 *1 55.2,51.68
X$1080 67 285 67 60 350 60 sky130_fd_sc_hd__inv_1
* cell instance $1082 m0 *1 57.04,51.68
X$1082 67 306 331 320 67 328 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1083 m0 *1 58.88,51.68
X$1083 60 63 314 306 309 313 67 67 60 sky130_fd_sc_hd__nor4b_4
* cell instance $1084 m0 *1 67.62,51.68
X$1084 67 311 277 341 352 67 60 60 sky130_fd_sc_hd__nand3_1
* cell instance $1085 m0 *1 69.46,51.68
X$1085 67 306 333 330 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1087 m0 *1 71.3,51.68
X$1087 67 313 333 351 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1088 m0 *1 72.68,51.68
X$1088 60 314 305 306 333 67 67 60 sky130_fd_sc_hd__nor3_4
* cell instance $1089 m0 *1 78.66,51.68
X$1089 67 315 67 60 349 60 sky130_fd_sc_hd__inv_1
* cell instance $1091 m0 *1 80.5,51.68
X$1091 67 336 60 67 313 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1095 m0 *1 90.16,51.68
X$1095 60 96 326 203 334 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1101 m0 *1 112.24,51.68
X$1101 67 335 60 67 362 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1106 r0 *1 4.14,51.68
X$1106 60 88 344 228 346 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1111 r0 *1 16.56,51.68
X$1111 60 88 377 228 376 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1112 r0 *1 25.76,51.68
X$1112 67 324 60 67 354 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1114 r0 *1 30.36,51.68
X$1114 60 88 364 257 378 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1122 r0 *1 44.62,51.68
X$1122 60 88 285 257 356 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1126 r0 *1 57.04,51.68
X$1126 67 283 293 309 60 67 365 60 sky130_fd_sc_hd__a21o_1
* cell instance $1127 r0 *1 59.8,51.68
X$1127 67 289 306 358 60 67 356 60 sky130_fd_sc_hd__a21oi_1
* cell instance $1128 r0 *1 61.64,51.68
X$1128 67 350 359 309 67 340 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1129 r0 *1 63.48,51.68
X$1129 67 311 340 358 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1131 r0 *1 65.32,51.68
X$1131 67 306 367 352 67 308 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1132 r0 *1 67.16,51.68
X$1132 67 314 309 385 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1133 r0 *1 68.54,51.68
X$1133 67 310 371 341 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1137 r0 *1 70.84,51.68
X$1137 67 277 310 368 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1138 r0 *1 72.22,51.68
X$1138 67 314 67 60 311 60 sky130_fd_sc_hd__inv_1
* cell instance $1139 r0 *1 73.6,51.68
X$1139 60 329 366 314 360 349 306 67 67 60 sky130_fd_sc_hd__o32ai_1
* cell instance $1140 r0 *1 76.82,51.68
X$1140 67 309 361 360 60 67 60 sky130_fd_sc_hd__nor2b_1
* cell instance $1141 r0 *1 79.12,51.68
X$1141 67 342 309 333 60 67 60 sky130_fd_sc_hd__nand2b_1
* cell instance $1145 r0 *1 90.62,51.68
X$1145 67 322 60 67 342 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1146 r0 *1 94.3,51.68
X$1146 67 343 60 67 361 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1150 r0 *1 100.28,51.68
X$1150 60 96 337 203 348 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1152 r0 *1 110.4,51.68
X$1152 67 337 60 67 398 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1166 m0 *1 2.76,57.12
X$1166 67 339 60 67 345 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1167 m0 *1 6.44,57.12
X$1167 67 344 60 67 353 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1169 m0 *1 10.58,57.12
X$1169 67 370 60 67 390 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1170 m0 *1 14.26,57.12
X$1170 60 376 377 390 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1172 m0 *1 20.24,57.12
X$1172 67 369 60 67 355 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1180 m0 *1 32.66,57.12
X$1180 60 378 364 355 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1188 m0 *1 54.74,57.12
X$1188 67 306 379 381 67 380 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1190 m0 *1 57.04,57.12
X$1190 60 381 357 306 63 365 311 67 67 60 sky130_fd_sc_hd__a41oi_1
* cell instance $1191 m0 *1 60.26,57.12
X$1191 67 309 285 359 357 67 60 60 sky130_fd_sc_hd__nand3_1
* cell instance $1192 m0 *1 62.1,57.12
X$1192 67 306 357 371 310 277 384 60 67 60 sky130_fd_sc_hd__a32oi_1
* cell instance $1193 m0 *1 65.32,57.12
X$1193 67 383 60 67 359 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1194 m0 *1 69,57.12
X$1194 67 368 309 382 311 372 67 379 60 60 sky130_fd_sc_hd__a311oi_1
* cell instance $1196 m0 *1 72.68,57.12
X$1196 67 351 314 412 60 67 373 60 sky130_fd_sc_hd__a21oi_1
* cell instance $1197 m0 *1 74.52,57.12
X$1197 67 311 386 306 411 67 392 60 60 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $1198 m0 *1 77.74,57.12
X$1198 60 315 372 314 360 67 67 60 sky130_fd_sc_hd__and3_1
* cell instance $1206 m0 *1 96.6,57.12
X$1206 60 96 335 203 374 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1209 m0 *1 112.24,57.12
X$1209 67 375 60 67 391 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1214 r0 *1 2.76,57.12
X$1214 67 405 60 67 389 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1215 r0 *1 6.44,57.12
X$1215 60 399 395 389 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1217 r0 *1 11.5,57.12
X$1217 67 377 60 67 394 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1224 r0 *1 27.6,57.12
X$1224 67 364 60 67 393 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1235 r0 *1 53.36,57.12
X$1235 60 403 156 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1236 r0 *1 62.56,57.12
X$1236 67 314 357 397 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1237 r0 *1 63.94,57.12
X$1237 67 309 306 371 60 67 60 sky130_fd_sc_hd__and2b_1
* cell instance $1238 r0 *1 66.7,57.12
X$1238 67 314 384 444 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1240 r0 *1 68.54,57.12
X$1240 67 385 386 387 60 67 382 60 sky130_fd_sc_hd__a21oi_1
* cell instance $1244 r0 *1 71.76,57.12
X$1244 67 386 309 387 60 67 404 60 sky130_fd_sc_hd__a21boi_0
* cell instance $1245 r0 *1 74.52,57.12
X$1245 60 216 386 230 392 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1254 r0 *1 101.2,57.12
X$1254 60 96 400 203 410 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1255 r0 *1 110.4,57.12
X$1255 67 363 60 67 347 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1259 m0 *1 1.38,62.56
X$1259 67 395 60 67 414 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1260 m0 *1 5.06,62.56
X$1260 60 88 395 409 399 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1265 m0 *1 19.78,62.56
X$1265 60 88 415 409 422 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1279 m0 *1 57.04,62.56
X$1279 67 406 396 424 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1280 m0 *1 58.42,62.56
X$1280 67 314 309 407 67 396 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1281 m0 *1 60.26,62.56
X$1281 67 407 397 306 67 406 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1282 m0 *1 62.1,62.56
X$1282 60 216 314 416 413 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1285 m0 *1 71.3,62.56
X$1285 67 306 373 413 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1286 m0 *1 72.68,62.56
X$1286 60 387 417 386 371 67 67 60 sky130_fd_sc_hd__and3_1
* cell instance $1287 m0 *1 74.98,62.56
X$1287 67 309 386 387 412 67 60 60 sky130_fd_sc_hd__nand3_1
* cell instance $1289 m0 *1 77.28,62.56
X$1289 67 372 404 411 60 67 60 sky130_fd_sc_hd__nor2_1
* cell instance $1293 m0 *1 84.64,62.56
X$1293 67 418 60 67 387 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1294 m0 *1 88.32,62.56
X$1294 60 96 401 429 402 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1297 m0 *1 97.52,62.56
X$1297 67 401 60 67 408 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1302 m0 *1 112.24,62.56
X$1302 67 388 60 67 421 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1307 r0 *1 4.14,62.56
X$1307 60 216 434 409 437 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1312 r0 *1 17.48,62.56
X$1312 67 425 60 67 423 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1313 r0 *1 21.16,62.56
X$1313 60 422 415 423 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1314 r0 *1 25.3,62.56
X$1314 60 88 435 430 442 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1317 r0 *1 35.88,62.56
X$1317 60 446 431 445 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1324 r0 *1 50.6,62.56
X$1324 60 88 309 257 380 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1326 r0 *1 60.26,62.56
X$1326 60 88 306 416 444 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1331 r0 *1 72.68,62.56
X$1331 67 426 417 314 67 456 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1332 r0 *1 74.52,62.56
X$1332 67 306 309 426 67 440 60 60 sky130_fd_sc_hd__o21ai_0
* cell instance $1334 r0 *1 76.82,62.56
X$1334 60 60 417 443 314 67 67 sky130_fd_sc_hd__nand2_2
* cell instance $1337 r0 *1 83.26,62.56
X$1337 67 386 60 67 427 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1340 r0 *1 94.3,62.56
X$1340 67 419 60 67 420 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1344 r0 *1 102.12,62.56
X$1344 60 96 436 429 438 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1345 r0 *1 111.32,62.56
X$1345 67 400 60 67 428 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1356 m0 *1 1.38,68
X$1356 67 433 60 67 450 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1357 m0 *1 5.06,68
X$1357 60 437 434 450 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1358 m0 *1 9.2,68
X$1358 60 216 439 409 453 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1361 m0 *1 21.16,68
X$1361 67 435 60 67 447 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1362 m0 *1 24.84,68
X$1362 60 442 435 455 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1366 m0 *1 30.82,68
X$1366 67 459 60 67 445 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1367 m0 *1 34.5,68
X$1367 60 88 431 430 446 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1369 m0 *1 47.38,68
X$1369 60 88 457 430 466 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1371 m0 *1 57.04,68
X$1371 60 88 407 416 424 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1374 m0 *1 73.6,68
X$1374 67 440 456 441 67 60 60 sky130_fd_sc_hd__nand2_1
* cell instance $1375 m0 *1 74.98,68
X$1375 60 216 426 416 441 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1379 m0 *1 89.24,68
X$1379 60 216 448 429 468 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1383 m0 *1 107.64,68
X$1383 60 438 436 452 443 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $1385 m0 *1 112.24,68
X$1385 67 449 60 67 452 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1391 r0 *1 4.6,68
X$1391 67 432 60 67 451 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1394 r0 *1 9.66,68
X$1394 60 453 439 451 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1402 r0 *1 21.62,68
X$1402 67 415 60 67 465 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1404 r0 *1 26.22,68
X$1404 67 431 60 67 458 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1413 r0 *1 50.6,68
X$1413 60 466 457 467 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1417 r0 *1 63.02,68
X$1417 67 407 60 67 769 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1428 r0 *1 88.78,68
X$1428 60 468 469 448 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1429 r0 *1 92.92,68
X$1429 67 426 60 67 454 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1437 r0 *1 104.42,68
X$1437 67 448 60 67 484 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1440 r0 *1 110.4,68
X$1440 67 436 60 67 463 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1444 m0 *1 1.38,73.44
X$1444 67 439 60 67 474 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1447 m0 *1 6.44,73.44
X$1447 67 434 60 67 673 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1449 m0 *1 11.96,73.44
X$1449 60 88 472 409 496 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1453 m0 *1 21.62,73.44
X$1453 67 489 60 67 455 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1454 m0 *1 25.3,73.44
X$1454 67 503 60 67 487 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1457 m0 *1 29.9,73.44
X$1457 67 460 60 67 502 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1458 m0 *1 33.58,73.44
X$1458 60 88 460 430 479 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1464 m0 *1 49.22,73.44
X$1464 67 729 60 67 467 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1465 m0 *1 52.9,73.44
X$1465 67 457 60 67 481 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1469 m0 *1 61.64,73.44
X$1469 67 216 67 60 88 60 sky130_fd_sc_hd__buf_4
* cell instance $1471 m0 *1 64.86,73.44
X$1471 67 216 67 60 96 60 sky130_fd_sc_hd__buf_4
* cell instance $1477 m0 *1 70.84,73.44
X$1477 60 470 461 480 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1478 m0 *1 74.98,73.44
X$1478 60 216 505 416 478 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1482 m0 *1 88.78,73.44
X$1482 60 96 477 429 499 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1485 m0 *1 97.98,73.44
X$1485 60 96 476 429 462 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1486 m0 *1 107.18,73.44
X$1486 60 462 476 475 443 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $1489 m0 *1 112.24,73.44
X$1489 67 464 60 67 475 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1494 r0 *1 2.76,73.44
X$1494 67 482 60 67 485 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1495 r0 *1 6.44,73.44
X$1495 60 494 495 485 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1497 r0 *1 11.5,73.44
X$1497 67 472 60 67 471 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1501 r0 *1 16.1,73.44
X$1501 60 496 472 486 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1502 r0 *1 20.24,73.44
X$1502 60 156 409 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1503 r0 *1 29.44,73.44
X$1503 60 479 460 487 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1504 r0 *1 33.58,73.44
X$1504 60 156 430 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1508 r0 *1 45.08,73.44
X$1508 60 88 490 430 498 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1513 r0 *1 61.18,73.44
X$1513 60 88 501 416 500 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1517 r0 *1 71.76,73.44
X$1517 67 416 60 67 60 sky130_fd_sc_hd__clkbuf_1
* cell instance $1518 r0 *1 73.14,73.44
X$1518 60 156 416 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1521 r0 *1 86.48,73.44
X$1521 60 156 429 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1526 r0 *1 98.44,73.44
X$1526 60 499 491 477 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1527 r0 *1 102.58,73.44
X$1527 67 483 60 67 491 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1528 r0 *1 106.26,73.44
X$1528 67 477 60 67 497 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1530 r0 *1 110.4,73.44
X$1530 67 476 60 67 493 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1542 m0 *1 1.38,78.88
X$1542 67 508 60 67 488 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1543 m0 *1 5.06,78.88
X$1543 60 216 495 409 494 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1544 m0 *1 14.26,78.88
X$1544 67 510 60 67 486 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1545 m0 *1 17.94,78.88
X$1545 60 409 67 67 60 sky130_fd_sc_hd__bufinv_16
* cell instance $1549 m0 *1 34.04,78.88
X$1549 60 430 67 67 60 sky130_fd_sc_hd__bufinv_16
* cell instance $1551 m0 *1 45.54,78.88
X$1551 60 498 490 513 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1554 m0 *1 51.98,78.88
X$1554 67 490 60 67 514 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1560 m0 *1 63.02,78.88
X$1560 60 500 515 501 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1562 m0 *1 68.08,78.88
X$1562 60 88 480 416 470 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1565 m0 *1 78.66,78.88
X$1565 60 478 512 505 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1570 m0 *1 86.48,78.88
X$1570 60 429 67 67 60 sky130_fd_sc_hd__clkbuf_8
* cell instance $1573 m0 *1 94.3,78.88
X$1573 67 473 60 67 469 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1577 m0 *1 101.2,78.88
X$1577 60 96 492 429 509 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1581 m0 *1 112.24,78.88
X$1581 67 492 60 67 506 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1587 r0 *1 4.6,78.88
X$1587 60 216 508 409 534 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1595 r0 *1 21.62,78.88
X$1595 67 521 60 67 511 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1598 r0 *1 27.6,78.88
X$1598 60 516 504 511 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1599 r0 *1 31.74,78.88
X$1599 60 88 504 430 516 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1604 r0 *1 43.7,78.88
X$1604 67 517 60 67 513 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1605 r0 *1 47.38,78.88
X$1605 60 88 528 416 526 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1608 r0 *1 60.72,78.88
X$1608 67 768 60 67 515 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1609 r0 *1 64.4,78.88
X$1609 67 501 60 67 527 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1615 r0 *1 74.52,78.88
X$1615 67 480 60 67 525 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1617 r0 *1 78.66,78.88
X$1617 67 524 60 67 512 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1621 r0 *1 87.4,78.88
X$1621 60 96 523 429 540 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1627 r0 *1 100.28,78.88
X$1627 60 96 520 429 522 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1628 r0 *1 109.48,78.88
X$1628 60 509 562 492 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1629 r0 *1 113.62,78.88
X$1629 67 518 60 67 519 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1639 m0 *1 2.3,84.32
X$1639 67 533 60 67 546 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1640 m0 *1 5.98,84.32
X$1640 60 534 508 546 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1641 m0 *1 10.12,84.32
X$1641 67 535 60 67 529 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1643 m0 *1 14.72,84.32
X$1643 67 537 60 67 548 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1644 m0 *1 18.4,84.32
X$1644 60 216 535 430 549 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1652 m0 *1 38.18,84.32
X$1652 67 538 60 67 551 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1655 m0 *1 46,84.32
X$1655 67 528 60 67 539 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1656 m0 *1 49.68,84.32
X$1656 60 526 528 554 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1666 m0 *1 73.14,84.32
X$1666 67 700 60 67 461 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1667 m0 *1 76.82,84.32
X$1667 60 541 553 543 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1673 m0 *1 88.32,84.32
X$1673 60 540 530 523 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1675 m0 *1 92.92,84.32
X$1675 67 531 60 67 530 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1676 m0 *1 96.6,84.32
X$1676 67 505 60 67 507 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1679 m0 *1 102.58,84.32
X$1679 60 96 547 429 536 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1681 m0 *1 112.24,84.32
X$1681 67 520 60 67 532 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1685 r0 *1 3.22,84.32
X$1685 67 588 60 67 564 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1686 r0 *1 6.9,84.32
X$1686 67 495 60 67 563 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1694 r0 *1 18.86,84.32
X$1694 60 216 568 565 566 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1697 r0 *1 30.36,84.32
X$1697 67 504 60 67 556 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1700 r0 *1 36.8,84.32
X$1700 60 570 557 551 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1706 r0 *1 47.38,84.32
X$1706 60 572 552 586 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1707 r0 *1 51.52,84.32
X$1707 67 766 60 67 554 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1710 r0 *1 56.58,84.32
X$1710 60 216 576 416 571 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1717 r0 *1 73.14,84.32
X$1717 60 216 543 416 541 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1721 r0 *1 88.32,84.32
X$1721 67 543 60 67 544 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1724 r0 *1 94.3,84.32
X$1724 67 523 60 67 569 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1727 r0 *1 98.44,84.32
X$1727 67 550 60 67 561 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1729 r0 *1 103.04,84.32
X$1729 60 522 567 520 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1730 r0 *1 107.18,84.32
X$1730 60 536 547 519 443 67 67 60 sky130_fd_sc_hd__mux2_1
* cell instance $1731 r0 *1 111.32,84.32
X$1731 67 547 60 67 545 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1736 m0 *1 4.14,89.76
X$1736 60 216 580 565 579 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1741 m0 *1 16.1,89.76
X$1741 60 549 535 548 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1742 m0 *1 20.24,89.76
X$1742 60 566 568 581 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1743 m0 *1 24.38,89.76
X$1743 67 568 60 67 542 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1748 m0 *1 34.04,89.76
X$1748 60 216 557 575 570 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1752 m0 *1 45.08,89.76
X$1752 60 216 552 575 572 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1757 m0 *1 57.96,89.76
X$1757 60 571 587 576 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1758 m0 *1 62.1,89.76
X$1758 67 576 60 67 585 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1760 m0 *1 67.62,89.76
X$1760 60 216 577 607 584 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1763 m0 *1 76.82,89.76
X$1763 67 583 60 67 553 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1768 m0 *1 88.78,89.76
X$1768 60 96 550 582 558 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1771 m0 *1 97.98,89.76
X$1771 60 558 559 550 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1774 m0 *1 103.5,89.76
X$1774 67 560 60 67 559 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1776 m0 *1 108.1,89.76
X$1776 67 657 60 67 567 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1778 m0 *1 112.24,89.76
X$1778 67 578 60 67 562 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1782 r0 *1 3.22,89.76
X$1782 60 216 596 565 594 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1787 r0 *1 15.64,89.76
X$1787 67 555 60 67 581 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1788 r0 *1 19.32,89.76
X$1788 60 599 626 612 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1789 r0 *1 23.46,89.76
X$1789 60 216 574 565 590 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1790 r0 *1 32.66,89.76
X$1790 60 590 574 600 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1793 r0 *1 39.1,89.76
X$1793 67 557 60 67 603 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1797 r0 *1 45.08,89.76
X$1797 67 605 60 67 586 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1798 r0 *1 48.76,89.76
X$1798 67 552 60 67 604 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1802 r0 *1 58.42,89.76
X$1802 67 602 60 67 587 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1803 r0 *1 62.1,89.76
X$1803 60 601 639 591 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1808 r0 *1 70.84,89.76
X$1808 60 584 619 577 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1811 r0 *1 80.5,89.76
X$1811 60 216 597 582 598 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1818 r0 *1 100.28,89.76
X$1818 60 96 592 582 595 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1820 r0 *1 110.4,89.76
X$1820 67 592 60 67 635 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1833 m0 *1 2.3,95.2
X$1833 67 589 60 67 610 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1834 m0 *1 5.98,95.2
X$1834 60 594 596 610 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1835 m0 *1 10.12,95.2
X$1835 67 596 60 67 573 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1837 m0 *1 14.72,95.2
X$1837 67 611 60 67 612 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1838 m0 *1 18.4,95.2
X$1838 60 156 565 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1843 m0 *1 29.9,95.2
X$1843 67 575 67 60 60 sky130_fd_sc_hd__clkinv_2
* cell instance $1844 m0 *1 31.74,95.2
X$1844 60 613 614 615 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1845 m0 *1 35.88,95.2
X$1845 67 574 60 67 617 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1848 m0 *1 40.94,95.2
X$1848 60 216 622 575 620 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1851 m0 *1 52.44,95.2
X$1851 60 623 628 624 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1854 m0 *1 58.88,95.2
X$1854 60 216 591 607 601 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1858 m0 *1 71.3,95.2
X$1858 67 621 60 67 619 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1859 m0 *1 74.98,95.2
X$1859 67 577 60 67 618 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1863 m0 *1 84.64,95.2
X$1863 60 598 616 597 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1867 m0 *1 97.06,95.2
X$1867 60 96 608 582 666 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1869 m0 *1 106.72,95.2
X$1869 60 595 631 592 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1872 m0 *1 112.24,95.2
X$1872 67 608 60 67 609 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1876 r0 *1 1.84,95.2
X$1876 67 580 60 67 606 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1877 r0 *1 5.52,95.2
X$1877 60 579 580 564 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1887 r0 *1 18.86,95.2
X$1887 60 216 626 565 599 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1888 r0 *1 28.06,95.2
X$1888 67 627 60 67 600 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1889 r0 *1 31.74,95.2
X$1889 60 156 575 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1896 r0 *1 43.7,95.2
X$1896 60 620 622 636 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1899 r0 *1 50.6,95.2
X$1899 60 216 628 607 623 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1902 r0 *1 61.18,95.2
X$1902 67 638 60 67 639 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1903 r0 *1 64.86,95.2
X$1903 67 591 60 67 637 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1912 r0 *1 74.06,95.2
X$1912 60 156 607 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1913 r0 *1 83.26,95.2
X$1913 60 216 650 582 668 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1914 r0 *1 92.46,95.2
X$1914 67 597 60 67 629 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1920 r0 *1 98.44,95.2
X$1920 60 96 632 582 630 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1921 r0 *1 107.64,95.2
X$1921 60 630 633 632 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1922 r0 *1 111.78,95.2
X$1922 67 593 60 67 633 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1925 m0 *1 1.84,100.64
X$1925 67 641 60 67 659 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1926 m0 *1 5.52,100.64
X$1926 67 648 60 67 640 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1927 m0 *1 9.2,100.64
X$1927 60 642 643 661 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1928 m0 *1 13.34,100.64
X$1928 60 216 643 565 642 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1933 m0 *1 29.44,100.64
X$1933 60 216 614 575 613 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1937 m0 *1 45.08,100.64
X$1937 67 651 60 67 636 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1940 m0 *1 52.9,100.64
X$1940 67 653 60 67 624 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1947 m0 *1 69.46,100.64
X$1947 60 216 671 607 652 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1953 m0 *1 87.4,100.64
X$1953 60 156 582 67 67 60 sky130_fd_sc_hd__clkbuf_16
* cell instance $1956 m0 *1 97.98,100.64
X$1956 60 96 645 582 644 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $1957 m0 *1 107.18,100.64
X$1957 60 644 649 645 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1960 m0 *1 112.24,100.64
X$1960 67 647 60 67 631 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1964 r0 *1 1.84,100.64
X$1964 67 654 60 67 660 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1965 r0 *1 5.52,100.64
X$1965 60 658 648 660 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $1966 r0 *1 9.66,100.64
X$1966 67 656 60 67 661 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1970 r0 *1 15.64,100.64
X$1970 67 643 60 67 625 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1973 r0 *1 21.62,100.64
X$1973 67 626 60 67 662 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1978 r0 *1 34.04,100.64
X$1978 67 614 60 67 663 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1985 r0 *1 45.08,100.64
X$1985 67 622 60 67 665 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1989 r0 *1 54.74,100.64
X$1989 67 628 60 67 767 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $1999 r0 *1 74.06,100.64
X$1999 60 607 67 67 60 sky130_fd_sc_hd__clkbuf_8
* cell instance $2000 r0 *1 79.12,100.64
X$2000 67 671 60 67 670 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2003 r0 *1 85.56,100.64
X$2003 60 668 669 650 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2004 r0 *1 89.7,100.64
X$2004 67 650 60 67 667 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2011 r0 *1 103.96,100.64
X$2011 60 666 664 608 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2014 r0 *1 110.4,100.64
X$2014 67 645 60 67 634 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2020 m0 *1 3.68,106.08
X$2020 60 216 648 565 658 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2032 m0 *1 32.2,106.08
X$2032 67 679 60 67 615 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2038 m0 *1 42.32,106.08
X$2038 60 216 682 575 681 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2046 m0 *1 64.86,106.08
X$2046 60 216 691 607 680 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2049 m0 *1 74.06,106.08
X$2049 60 652 689 671 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2054 m0 *1 84.64,106.08
X$2054 67 674 60 67 669 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2055 m0 *1 88.32,106.08
X$2055 67 678 60 67 616 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2057 m0 *1 92.46,106.08
X$2057 60 216 701 582 675 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2062 m0 *1 104.42,106.08
X$2062 67 677 60 67 664 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2063 m0 *1 108.1,106.08
X$2063 67 646 60 67 649 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2065 m0 *1 112.24,106.08
X$2065 67 632 60 67 676 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2070 r0 *1 4.14,106.08
X$2070 60 704 686 659 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2079 r0 *1 18.4,106.08
X$2079 60 216 697 565 688 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2080 r0 *1 27.6,106.08
X$2080 60 216 692 575 690 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2082 r0 *1 38.64,106.08
X$2082 60 710 694 695 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2088 r0 *1 46.46,106.08
X$2088 60 216 698 575 713 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2089 r0 *1 55.66,106.08
X$2089 60 216 716 607 699 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2092 r0 *1 66.24,106.08
X$2092 60 680 693 691 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2098 r0 *1 74.06,106.08
X$2098 67 683 60 67 689 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2100 r0 *1 78.2,106.08
X$2100 60 216 711 607 684 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2103 r0 *1 92,106.08
X$2103 67 687 60 67 708 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2111 r0 *1 104.88,106.08
X$2111 60 216 718 582 725 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2125 m0 *1 2.76,111.52
X$2125 60 216 686 565 704 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2126 m0 *1 11.96,111.52
X$2126 60 719 696 721 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2127 m0 *1 16.1,111.52
X$2127 60 216 714 565 720 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2128 m0 *1 25.3,111.52
X$2128 67 697 60 67 707 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2131 m0 *1 29.9,111.52
X$2131 60 690 692 742 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2133 m0 *1 34.96,111.52
X$2133 60 216 694 575 710 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2135 m0 *1 45.08,111.52
X$2135 60 681 682 756 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2137 m0 *1 50.14,111.52
X$2137 60 713 698 761 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2141 m0 *1 57.04,111.52
X$2141 60 216 717 607 732 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2142 m0 *1 66.24,111.52
X$2142 67 717 60 67 712 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2145 m0 *1 72.22,111.52
X$2145 60 216 735 607 737 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2152 m0 *1 87.86,111.52
X$2152 60 216 687 582 709 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2153 m0 *1 97.06,111.52
X$2153 60 675 748 701 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2156 m0 *1 102.58,111.52
X$2156 60 216 706 582 746 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2158 m0 *1 112.24,111.52
X$2158 60 705 216 67 67 60 sky130_fd_sc_hd__buf_6
* cell instance $2161 r0 *1 2.3,111.52
X$2161 67 686 60 67 672 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2162 r0 *1 5.98,111.52
X$2162 60 216 696 565 719 67 67 60 sky130_fd_sc_hd__dfrtp_1
* cell instance $2165 r0 *1 15.64,111.52
X$2165 67 696 60 67 722 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2166 r0 *1 19.32,111.52
X$2166 60 720 714 740 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2169 r0 *1 26.22,111.52
X$2169 60 688 697 715 108 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2171 r0 *1 32.2,111.52
X$2171 67 692 60 67 723 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2175 r0 *1 39.1,111.52
X$2175 67 694 60 67 727 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2179 r0 *1 43.7,111.52
X$2179 67 682 60 67 728 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2183 r0 *1 53.36,111.52
X$2183 67 698 60 67 731 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2184 r0 *1 57.04,111.52
X$2184 60 699 764 716 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2185 r0 *1 61.18,111.52
X$2185 67 716 60 67 733 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2186 r0 *1 64.86,111.52
X$2186 60 732 763 717 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2191 r0 *1 70.84,111.52
X$2191 67 691 60 67 736 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2193 r0 *1 74.98,111.52
X$2193 60 737 758 735 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2197 r0 *1 82.34,111.52
X$2197 60 684 754 711 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2198 r0 *1 86.48,111.52
X$2198 67 711 60 67 734 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2200 r0 *1 91.08,111.52
X$2200 60 709 752 687 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2205 r0 *1 98.44,111.52
X$2205 67 701 60 67 730 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2206 r0 *1 102.12,111.52
X$2206 67 726 60 67 724 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2207 r0 *1 105.8,111.52
X$2207 60 725 724 718 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2208 r0 *1 109.94,111.52
X$2208 67 706 60 67 702 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2209 r0 *1 113.62,111.52
X$2209 67 703 67 705 60 60 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2220 m0 *1 6.9,116.96
X$2220 67 655 60 67 721 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2226 m0 *1 17.02,116.96
X$2226 67 738 60 67 740 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2228 m0 *1 21.62,116.96
X$2228 67 714 60 67 741 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2229 m0 *1 25.3,116.96
X$2229 67 743 60 67 715 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2232 m0 *1 30.36,116.96
X$2232 67 744 60 67 742 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2236 m0 *1 39.1,116.96
X$2236 67 750 60 67 695 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2240 m0 *1 44.62,116.96
X$2240 67 751 60 67 756 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2243 m0 *1 52.9,116.96
X$2243 67 760 60 67 761 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2247 m0 *1 61.18,116.96
X$2247 67 739 60 67 764 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2248 m0 *1 64.86,116.96
X$2248 67 765 60 67 763 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2251 m0 *1 70.84,116.96
X$2251 67 762 60 67 693 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2253 m0 *1 74.98,116.96
X$2253 67 759 60 67 758 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2254 m0 *1 78.66,116.96
X$2254 67 735 60 67 757 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2258 m0 *1 85.56,116.96
X$2258 67 755 60 67 754 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2260 m0 *1 91.08,116.96
X$2260 67 753 60 67 752 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2265 m0 *1 98.44,116.96
X$2265 67 749 60 67 748 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2266 m0 *1 102.12,116.96
X$2266 67 747 60 67 745 60 sky130_fd_sc_hd__clkdlybuf4s50_1
* cell instance $2267 m0 *1 105.8,116.96
X$2267 60 746 745 706 443 67 67 60 sky130_fd_sc_hd__mux2_2
* cell instance $2272 m0 *1 113.62,116.96
X$2272 67 718 60 67 685 60 sky130_fd_sc_hd__clkdlybuf4s50_1
.ENDS axi_lite_master

* cell sky130_fd_sc_hd__a32oi_1
* pin VPB
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a32oi_1 1 2 3 4 5 6 8 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A3
* net 5 A2
* net 6 A1
* net 8 Y
* net 9 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=215000000000P PS=1270000U PD=1430000U
* device instance $3 r0 *1 1.47,1.985 pfet_01v8_hvt
M$3 10 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=215000000000P
+ AD=135000000000P PS=1430000U PD=1270000U
* device instance $4 r0 *1 1.89,1.985 pfet_01v8_hvt
M$4 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=140000000000P PS=1270000U PD=1280000U
* device instance $5 r0 *1 2.32,1.985 pfet_01v8_hvt
M$5 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=260000000000P PS=1280000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $7 r0 *1 0.85,0.56 nfet_01v8
M$7 8 3 14 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=152750000000P
+ PS=880000U PD=1120000U
* device instance $8 r0 *1 1.47,0.56 nfet_01v8
M$8 12 6 8 11 nfet_01v8 L=150000U W=650000U AS=152750000000P AD=71500000000P
+ PS=1120000U PD=870000U
* device instance $9 r0 *1 1.84,0.56 nfet_01v8
M$9 13 5 12 11 nfet_01v8 L=150000U W=650000U AS=71500000000P AD=107250000000P
+ PS=870000U PD=980000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 9 4 13 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__a32oi_1

* cell sky130_fd_sc_hd__a311oi_1
* pin VPB
* pin A3
* pin A2
* pin B1
* pin A1
* pin C1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a311oi_1 1 2 3 4 5 6 7 9 10 11
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 B1
* net 5 A1
* net 6 C1
* net 7 VPWR
* net 9 Y
* net 10 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 0.895,1.985 pfet_01v8_hvt
M$2 7 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 1.325,1.985 pfet_01v8_hvt
M$3 8 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=165000000000P PS=1280000U PD=1330000U
* device instance $4 r0 *1 1.805,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=172500000000P PS=1330000U PD=1345000U
* device instance $5 r0 *1 2.3,1.985 pfet_01v8_hvt
M$5 9 6 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 14 2 10 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=89375000000P
+ PS=1820000U PD=925000U
* device instance $7 r0 *1 0.895,0.56 nfet_01v8
M$7 13 3 14 11 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 1.325,0.56 nfet_01v8
M$8 9 5 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=115375000000P
+ PS=930000U PD=1005000U
* device instance $9 r0 *1 1.83,0.56 nfet_01v8
M$9 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=112125000000P
+ PS=1005000U PD=995000U
* device instance $10 r0 *1 2.325,0.56 nfet_01v8
M$10 9 6 10 11 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311oi_1

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__o32ai_1
* pin VGND
* pin B1
* pin Y
* pin B2
* pin A3
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32ai_1 1 2 4 5 6 7 8 9 10 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 B2
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 4 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=305000000000P PS=1210000U PD=1610000U
* device instance $3 r0 *1 1.59,1.985 pfet_01v8_hvt
M$3 13 6 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=245000000000P PS=1610000U PD=1490000U
* device instance $4 r0 *1 2.23,1.985 pfet_01v8_hvt
M$4 14 7 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=245000000000P
+ AD=135000000000P PS=1490000U PD=1270000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 9 8 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=280000000000P PS=1270000U PD=2560000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 4 2 3 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1820000U PD=975000U
* device instance $7 r0 *1 0.945,0.56 nfet_01v8
M$7 3 5 4 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=100750000000P
+ PS=975000U PD=960000U
* device instance $8 r0 *1 1.405,0.56 nfet_01v8
M$8 1 6 3 12 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=219375000000P
+ PS=960000U PD=1325000U
* device instance $9 r0 *1 2.23,0.56 nfet_01v8
M$9 3 7 1 12 nfet_01v8 L=150000U W=650000U AS=219375000000P AD=87750000000P
+ PS=1325000U PD=920000U
* device instance $10 r0 *1 2.65,0.56 nfet_01v8
M$10 1 8 3 12 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=234000000000P
+ PS=920000U PD=2020000U
.ENDS sky130_fd_sc_hd__o32ai_1

* cell sky130_fd_sc_hd__nor3_4
* pin VGND
* pin A
* pin Y
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3_4 1 2 3 4 5 7 9 10
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 B
* net 5 C
* net 7 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 7 2 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $5 r0 *1 2.17,1.985 pfet_01v8_hvt
M$5 8 4 6 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $8 r0 *1 3.43,1.985 pfet_01v8_hvt
M$8 3 5 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 3 2 1 10 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $17 r0 *1 2.17,0.56 nfet_01v8
M$17 3 4 1 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $20 r0 *1 3.43,0.56 nfet_01v8
M$20 1 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__nor3_4

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__clkdlybuf4s50_1
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 1 2 4 7 8 9
* net 1 VPB
* net 2 A
* net 4 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 2.465,2.075 pfet_01v8_hvt
M$1 6 5 7 1 pfet_01v8_hvt L=500000U W=820000U AS=155750000000P AD=217300000000P
+ PS=1325000U PD=2170000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=155750000000P
+ AD=355000000000P PS=1325000U PD=2710000U
* device instance $3 r0 *1 0.48,1.985 pfet_01v8_hvt
M$3 7 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=270000000000P
+ AD=170100000000P PS=2540000U PD=1360000U
* device instance $4 r0 *1 1.165,2.075 pfet_01v8_hvt
M$4 5 3 7 1 pfet_01v8_hvt L=500000U W=820000U AS=170100000000P AD=217300000000P
+ PS=1360000U PD=2170000U
* device instance $5 r0 *1 3.115,0.445 nfet_01v8
M$5 8 6 4 9 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=149100000000P
+ PS=975000U PD=1550000U
* device instance $6 r0 *1 2.465,0.56 nfet_01v8
M$6 4 5 6 9 nfet_01v8 L=500000U W=650000U AS=172250000000P AD=97000000000P
+ PS=1830000U PD=975000U
* device instance $7 r0 *1 0.48,0.445 nfet_01v8
M$7 4 2 3 9 nfet_01v8 L=150000U W=420000U AS=113400000000P AD=104350000000P
+ PS=1380000U PD=1010000U
* device instance $8 r0 *1 1.165,0.56 nfet_01v8
M$8 5 3 4 9 nfet_01v8 L=500000U W=650000U AS=104350000000P AD=169000000000P
+ PS=1010000U PD=1820000U
.ENDS sky130_fd_sc_hd__clkdlybuf4s50_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__a41oi_1
* pin VGND
* pin Y
* pin A3
* pin A2
* pin B1
* pin A4
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_1 1 2 3 4 8 9 10 11 12 14
* net 1 VGND
* net 2 Y
* net 3 A3
* net 4 A2
* net 8 B1
* net 9 A4
* net 10 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 13 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=212500000000P PS=2520000U PD=1425000U
* device instance $2 r0 *1 1.045,1.985 pfet_01v8_hvt
M$2 11 9 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=205000000000P PS=1425000U PD=1410000U
* device instance $3 r0 *1 1.605,1.985 pfet_01v8_hvt
M$3 13 3 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=155000000000P PS=1410000U PD=1310000U
* device instance $4 r0 *1 2.065,1.985 pfet_01v8_hvt
M$4 11 4 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=212500000000P PS=1310000U PD=1425000U
* device instance $5 r0 *1 2.64,1.985 pfet_01v8_hvt
M$5 13 10 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=370000000000P PS=1425000U PD=2740000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 2 8 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=169000000000P
+ PS=1175000U PD=1820000U
* device instance $7 r0 *1 1.105,0.56 nfet_01v8
M$7 5 9 1 14 nfet_01v8 L=150000U W=650000U AS=163425000000P AD=113750000000P
+ PS=1175000U PD=1000000U
* device instance $8 r0 *1 1.605,0.56 nfet_01v8
M$8 7 3 5 14 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $9 r0 *1 2.065,0.56 nfet_01v8
M$9 6 4 7 14 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=138125000000P
+ PS=960000U PD=1075000U
* device instance $10 r0 *1 2.64,0.56 nfet_01v8
M$10 2 10 6 14 nfet_01v8 L=150000U W=650000U AS=138125000000P AD=240500000000P
+ PS=1075000U PD=2040000U
.ENDS sky130_fd_sc_hd__a41oi_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__and2b_1
* pin VPB
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and2b_1 1 3 5 6 7 8 9
* net 1 VPB
* net 3 B
* net 5 A_N
* net 6 X
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 8 5 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=71400000000P
+ PS=1360000U PD=760000U
* device instance $2 r0 *1 0.96,2.275 pfet_01v8_hvt
M$2 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=71400000000P AD=60900000000P
+ PS=760000U PD=710000U
* device instance $3 r0 *1 1.4,2.275 pfet_01v8_hvt
M$3 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=227900000000P AD=60900000000P
+ PS=1740000U PD=710000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=227900000000P
+ AD=260000000000P PS=1740000U PD=2520000U
* device instance $5 r0 *1 1.41,0.445 nfet_01v8
M$5 10 4 2 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=50400000000P
+ PS=1360000U PD=660000U
* device instance $6 r0 *1 1.8,0.445 nfet_01v8
M$6 7 3 10 9 nfet_01v8 L=150000U W=420000U AS=50400000000P AD=101300000000P
+ PS=660000U PD=990000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=101300000000P AD=169000000000P
+ PS=990000U PD=1820000U
* device instance $8 r0 *1 0.47,0.445 nfet_01v8
M$8 4 5 7 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and2b_1

* cell sky130_fd_sc_hd__nor4b_4
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_4 1 3 4 6 7 8 9 12 13
* net 1 VGND
* net 3 Y
* net 4 A
* net 6 B
* net 7 C
* net 8 D_N
* net 9 VPWR
* net 12 VPB
* device instance $1 r0 *1 8.23,1.985 pfet_01v8_hvt
M$1 9 8 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=280000000000P PS=2520000U PD=2560000U
* device instance $2 r0 *1 4.35,1.985 pfet_01v8_hvt
M$2 10 7 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $6 r0 *1 6.03,1.985 pfet_01v8_hvt
M$6 3 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $10 r0 *1 0.47,1.985 pfet_01v8_hvt
M$10 9 4 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $14 r0 *1 2.15,1.985 pfet_01v8_hvt
M$14 10 6 5 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $18 r0 *1 8.23,0.56 nfet_01v8
M$18 1 8 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=182000000000P
+ PS=1820000U PD=1860000U
* device instance $19 r0 *1 0.47,0.56 nfet_01v8
M$19 3 4 1 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $23 r0 *1 2.15,0.56 nfet_01v8
M$23 3 6 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=520000000000P
+ PS=3680000U PD=4200000U
* device instance $27 r0 *1 4.35,0.56 nfet_01v8
M$27 3 7 1 13 nfet_01v8 L=150000U W=2600000U AS=520000000000P AD=351000000000P
+ PS=4200000U PD=3680000U
* device instance $31 r0 *1 6.03,0.56 nfet_01v8
M$31 3 2 1 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nor4b_4

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__mux2_2
* pin VGND
* pin X
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_2 1 2 4 5 6 10 11 14
* net 1 VGND
* net 2 X
* net 4 A0
* net 5 A1
* net 6 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=312800000000P PS=3790000U PD=2685000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 12 9 10 11 pfet_01v8_hvt L=150000U W=640000U AS=177800000000P
+ AD=228800000000P PS=1415000U PD=1355000U
* device instance $4 r0 *1 2.32,2.165 pfet_01v8_hvt
M$4 3 5 12 11 pfet_01v8_hvt L=150000U W=640000U AS=228800000000P
+ AD=131200000000P PS=1355000U PD=1050000U
* device instance $5 r0 *1 2.88,2.165 pfet_01v8_hvt
M$5 13 4 3 11 pfet_01v8_hvt L=150000U W=640000U AS=131200000000P
+ AD=67200000000P PS=1050000U PD=850000U
* device instance $6 r0 *1 3.24,2.165 pfet_01v8_hvt
M$6 10 6 13 11 pfet_01v8_hvt L=150000U W=640000U AS=67200000000P
+ AD=86400000000P PS=850000U PD=910000U
* device instance $7 r0 *1 3.66,2.165 pfet_01v8_hvt
M$7 9 6 10 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=172800000000P PS=910000U PD=1820000U
* device instance $8 r0 *1 1.365,0.445 nfet_01v8
M$8 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=97000000000P AD=68250000000P
+ PS=975000U PD=745000U
* device instance $9 r0 *1 1.84,0.445 nfet_01v8
M$9 3 4 7 14 nfet_01v8 L=150000U W=420000U AS=68250000000P AD=173250000000P
+ PS=745000U PD=1245000U
* device instance $10 r0 *1 2.815,0.445 nfet_01v8
M$10 8 5 3 14 nfet_01v8 L=150000U W=420000U AS=173250000000P AD=57750000000P
+ PS=1245000U PD=695000U
* device instance $11 r0 *1 3.24,0.445 nfet_01v8
M$11 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=57750000000P AD=56700000000P
+ PS=695000U PD=690000U
* device instance $12 r0 *1 3.66,0.445 nfet_01v8
M$12 9 6 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=113400000000P
+ PS=690000U PD=1380000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 2 3 1 14 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=184750000000P
+ PS=2740000U PD=1895000U
.ENDS sky130_fd_sc_hd__mux2_2
