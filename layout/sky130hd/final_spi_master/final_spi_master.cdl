* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT final_spi_master clk rst_n rx_data[0] rx_data[1] rx_data[2]
+ rx_data[3] rx_data[4] rx_data[5] rx_data[6] rx_data[7] rx_valid
+ spi_clk spi_cs_n spi_miso spi_mosi tx_data[0] tx_data[1] tx_data[2]
+ tx_data[3] tx_data[4] tx_data[5] tx_data[6] tx_data[7] tx_ready
+ tx_valid
X_141_ bit_counter\[3\] VSS VSS VDD VDD _122_ sky130_fd_sc_hd__clkinvlp_4
X_142_ bit_counter\[2\] VSS VSS VDD VDD _118_ sky130_fd_sc_hd__buf_2
X_143_ _136_ VSS VSS VDD VDD _119_ sky130_fd_sc_hd__clkbuf_2
X_144_ _122_ _118_ _119_ VSS VSS VDD VDD _123_ sky130_fd_sc_hd__nand3_2
X_145_ _123_ VSS VSS VDD VDD _130_ sky130_fd_sc_hd__inv_1
X_146_ state\[0\] VSS VSS VDD VDD _120_ sky130_fd_sc_hd__buf_2
X_147_ state\[1\] VSS VSS VDD VDD _121_ sky130_fd_sc_hd__buf_2
X_148_ _120_ _121_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand2b_1
X_149_ _034_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__clkbuf_4
X_150_ _035_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__inv_1
X_151_ _118_ bit_counter\[1\] bit_counter\[0\] VSS VSS VDD
+ VDD _138_ sky130_fd_sc_hd__nand3_1
X_152_ _138_ _122_ VSS VSS VDD VDD _133_ sky130_fd_sc_hd__nand2b_1
X_153_ state\[1\] net22 bit_counter\[3\] state\[0\] VSS VSS
+ VDD VDD _036_ sky130_fd_sc_hd__or4b_2
X_154_ net22 bit_counter\[3\] state\[0\] VSS VSS VDD VDD _037_
+ sky130_fd_sc_hd__o21ai_0
X_155_ _121_ _037_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2b_1
X_156_ _038_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__clkbuf_2
X_157_ bit_counter\[0\] _039_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nand2_1
X_158_ bit_counter\[0\] _036_ _040_ VSS VSS VDD VDD _001_
+ sky130_fd_sc_hd__o21ai_0
X_159_ state\[1\] net22 bit_counter\[3\] state\[0\] VSS VSS
+ VDD VDD _041_ sky130_fd_sc_hd__nor4b_4
X_160_ _137_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__buf_2
X_161_ bit_counter\[1\] _039_ _041_ _042_ VSS VSS VDD VDD
+ _002_ sky130_fd_sc_hd__a22o_1
X_162_ _119_ _041_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand2_1
X_163_ _119_ _036_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nor2_1
X_164_ _039_ _044_ _118_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__o21ai_0
X_165_ _118_ _043_ _045_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o21ai_0
X_166_ _121_ _120_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nor2_1
X_167_ _140_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__clkbuf_2
X_168_ _121_ net22 VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nor2_1
X_169_ _047_ _048_ bit_counter\[3\] VSS VSS VDD VDD _049_
+ sky130_fd_sc_hd__a21oi_1
X_170_ _046_ _049_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nor2_1
X_171_ _125_ _135_ _134_ _139_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__and4bb_1
X_172_ _134_ _139_ _125_ _135_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nor4bb_1
X_173_ _118_ _119_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__xnor2_1
X_174_ _042_ _047_ _125_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__and3b_1
X_175_ _131_ _128_ bit_counter\[0\] VSS VSS VDD VDD _054_
+ sky130_fd_sc_hd__nor3b_1
X_176_ _050_ _051_ _052_ _053_ _054_ VSS VSS VDD VDD _055_
+ sky130_fd_sc_hd__o2111ai_1
X_177_ net3 _041_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nand2_1
X_178_ _041_ _055_ _039_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__a21oi_1
X_179_ miso_capture\[0\] VSS VSS VDD VDD _058_ sky130_fd_sc_hd__inv_1
X_180_ _055_ _056_ _057_ _058_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__o22ai_1
X_181_ _047_ _052_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nor2_1
X_182_ bit_counter\[0\] _131_ _128_ VSS VSS VDD VDD _060_
+ sky130_fd_sc_hd__nor3_1
X_183_ _050_ _060_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__nand2_1
X_184_ _056_ _061_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nor2_1
X_185_ _120_ net22 bit_counter\[3\] bit_counter\[0\] _121_
+ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__a2111oi_2
X_186_ _121_ _120_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__or2_0
X_187_ _064_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__clkbuf_2
X_188_ miso_capture\[1\] _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand2_1
X_189_ _042_ _063_ _059_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__a31oi_1
X_190_ _042_ _059_ _062_ _067_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a31o_1
X_191_ _042_ _054_ _050_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nand3_1
X_192_ _047_ _039_ _052_ _068_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nor4_1
X_193_ miso_capture\[2\] _065_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nand2_1
X_194_ _042_ _054_ _050_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__and3_1
X_195_ net3 _041_ _059_ _071_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__nand4_1
X_196_ _069_ _070_ _072_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_197_ _118_ _119_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__xor2_2
X_198_ _042_ _047_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nor2_1
X_199_ bit_counter\[3\] bit_counter\[0\] VSS VSS VDD VDD _075_
+ sky130_fd_sc_hd__nor2_1
X_200_ _073_ _075_ _074_ _036_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__a31oi_1
X_201_ _039_ _076_ miso_capture\[3\] VSS VSS VDD VDD _077_
+ sky130_fd_sc_hd__o21a_1
X_202_ _073_ _062_ _074_ _077_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__a31o_1
X_203_ _073_ _054_ _050_ _074_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__nand4_1
X_204_ _041_ _078_ _039_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__a21oi_1
X_205_ miso_capture\[4\] VSS VSS VDD VDD _080_ sky130_fd_sc_hd__inv_1
X_206_ _056_ _078_ _079_ _080_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__o22ai_1
X_207_ _047_ _073_ VSS VSS VDD VDD _081_ sky130_fd_sc_hd__nor2_1
X_208_ miso_capture\[5\] _065_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__nand2_1
X_209_ _042_ _063_ _081_ _082_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__a31oi_1
X_210_ _042_ _062_ _081_ _083_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__a31o_1
X_211_ _047_ _039_ _073_ _068_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nor4_1
X_212_ miso_capture\[6\] _065_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__nand2_1
X_213_ net3 _041_ _071_ _081_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nand4_1
X_214_ _084_ _085_ _086_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__o21ai_0
X_215_ _042_ _047_ _073_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__nor3_1
X_216_ _063_ _087_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nand2_1
X_217_ miso_capture\[7\] _065_ _088_ _087_ _062_ VSS VSS VDD
+ VDD _012_ sky130_fd_sc_hd__a32o_1
X_218_ net13 _035_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__nand2_1
X_219_ _058_ _035_ _089_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o21ai_0
X_220_ miso_capture\[1\] net14 _035_ VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__mux2_1
X_221_ miso_capture\[2\] net15 _035_ VSS VSS VDD VDD _015_
+ sky130_fd_sc_hd__mux2_1
X_222_ miso_capture\[3\] net16 _035_ VSS VSS VDD VDD _016_
+ sky130_fd_sc_hd__mux2_1
X_223_ net17 _035_ VSS VSS VDD VDD _090_ sky130_fd_sc_hd__nand2_1
X_224_ _080_ _035_ _090_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__o21ai_0
X_225_ miso_capture\[5\] net18 _035_ VSS VSS VDD VDD _018_
+ sky130_fd_sc_hd__mux2_1
X_226_ miso_capture\[6\] net19 _035_ VSS VSS VDD VDD _019_
+ sky130_fd_sc_hd__mux2_1
X_227_ miso_capture\[7\] net20 _034_ VSS VSS VDD VDD _020_
+ sky130_fd_sc_hd__mux2_1
X_228_ _121_ net22 VSS VSS VDD VDD _091_ sky130_fd_sc_hd__and2_0
X_229_ _048_ _091_ _120_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__o21a_1
X_230_ net23 _120_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__nor2b_1
X_231_ net12 _046_ _092_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_232_ _120_ net12 VSS VSS VDD VDD _093_ sky130_fd_sc_hd__nand2b_1
X_233_ _120_ net22 _126_ VSS VSS VDD VDD _094_ sky130_fd_sc_hd__nand3_1
X_234_ _093_ _094_ _121_ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__a21oi_2
X_235_ _095_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__buf_2
X_236_ _121_ _120_ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nor2b_1
X_237_ _097_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__clkbuf_4
X_238_ net11 tx_shift\[6\] _098_ VSS VSS VDD VDD _099_ sky130_fd_sc_hd__mux2i_1
X_239_ net24 _096_ VSS VSS VDD VDD _100_ sky130_fd_sc_hd__nor2_1
X_240_ _096_ _099_ _100_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__a21oi_1
X_241_ net22 _123_ _120_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__o21ai_0
X_242_ _093_ _101_ _121_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a21oi_1
X_243_ _118_ _119_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nand2_1
X_244_ _102_ _036_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor2_1
X_245_ net25 _065_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__nand2_1
X_246_ net12 _065_ _103_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__o21ai_0
X_247_ tx_shift\[0\] VSS VSS VDD VDD _104_ sky130_fd_sc_hd__inv_1
X_248_ net12 net4 _046_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__nand3_1
X_249_ _104_ _096_ _105_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__o21ai_0
X_250_ net5 tx_shift\[0\] _098_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__mux2i_1
X_251_ tx_shift\[1\] _096_ VSS VSS VDD VDD _107_ sky130_fd_sc_hd__nor2_1
X_252_ _096_ _106_ _107_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a21oi_1
X_253_ net6 tx_shift\[1\] _098_ VSS VSS VDD VDD _108_ sky130_fd_sc_hd__mux2i_1
X_254_ tx_shift\[2\] _095_ VSS VSS VDD VDD _109_ sky130_fd_sc_hd__nor2_1
X_255_ _096_ _108_ _109_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__a21oi_1
X_256_ net7 tx_shift\[2\] _098_ VSS VSS VDD VDD _110_ sky130_fd_sc_hd__mux2i_1
X_257_ tx_shift\[3\] _095_ VSS VSS VDD VDD _111_ sky130_fd_sc_hd__nor2_1
X_258_ _096_ _110_ _111_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__a21oi_1
X_259_ net8 tx_shift\[3\] _098_ VSS VSS VDD VDD _112_ sky130_fd_sc_hd__mux2i_1
X_260_ tx_shift\[4\] _095_ VSS VSS VDD VDD _113_ sky130_fd_sc_hd__nor2_1
X_261_ _096_ _112_ _113_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__a21oi_1
X_262_ net9 tx_shift\[4\] _098_ VSS VSS VDD VDD _114_ sky130_fd_sc_hd__mux2i_1
X_263_ tx_shift\[5\] _095_ VSS VSS VDD VDD _115_ sky130_fd_sc_hd__nor2_1
X_264_ _096_ _114_ _115_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__a21oi_1
X_265_ net10 tx_shift\[5\] _098_ VSS VSS VDD VDD _116_ sky130_fd_sc_hd__mux2i_1
X_266_ tx_shift\[6\] _095_ VSS VSS VDD VDD _117_ sky130_fd_sc_hd__nor2_1
X_267_ _096_ _116_ _117_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_268_ _122_ _123_ VSS VSS VDD VDD _124_ _125_ sky130_fd_sc_hd__ha_1
X_269_ _122_ _123_ VSS VSS VDD VDD _126_ _127_ sky130_fd_sc_hd__ha_1
X_270_ bit_counter\[3\] _123_ VSS VSS VDD VDD _128_ _129_
+ sky130_fd_sc_hd__ha_1
X_271_ bit_counter\[3\] _130_ VSS VSS VDD VDD _131_ _132_
+ sky130_fd_sc_hd__ha_1
X_272_ _122_ _133_ VSS VSS VDD VDD _134_ _135_ sky130_fd_sc_hd__ha_1
X_273_ bit_counter\[0\] bit_counter\[1\] VSS VSS VDD VDD _136_
+ _137_ sky130_fd_sc_hd__ha_1
X_274_ _122_ _138_ VSS VSS VDD VDD _139_ _140_ sky130_fd_sc_hd__ha_1
Xbit_counter\[0\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _001_ net1
+ VSS VSS VDD VDD bit_counter\[0\] sky130_fd_sc_hd__dfrtp_2
Xbit_counter\[1\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _002_ net1
+ VSS VSS VDD VDD bit_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xbit_counter\[2\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _003_ net1
+ VSS VSS VDD VDD bit_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xbit_counter\[3\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _004_ net1
+ VSS VSS VDD VDD bit_counter\[3\] sky130_fd_sc_hd__dfrtp_4
Xmiso_capture\[0\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _005_
+ net1 VSS VSS VDD VDD miso_capture\[0\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[1\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _006_
+ net1 VSS VSS VDD VDD miso_capture\[1\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[2\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _007_
+ net1 VSS VSS VDD VDD miso_capture\[2\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _008_
+ net1 VSS VSS VDD VDD miso_capture\[3\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[4\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _009_
+ net1 VSS VSS VDD VDD miso_capture\[4\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[5\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _010_
+ net1 VSS VSS VDD VDD miso_capture\[5\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[6\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _011_
+ net1 VSS VSS VDD VDD miso_capture\[6\] sky130_fd_sc_hd__dfrtp_1
Xmiso_capture\[7\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _012_
+ net1 VSS VSS VDD VDD miso_capture\[7\] sky130_fd_sc_hd__dfrtp_1
Xrx_data\[0\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _013_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[1\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _014_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[2\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _015_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _016_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[4\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _017_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[5\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _018_ net1
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[6\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _019_ net1
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xrx_data\[7\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _020_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xrx_valid$_DFF_PN0_ clknet_2_2__leaf_clk _000_ net1 VSS VSS
+ VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xspi_clk$_DFFE_PN0P_ clknet_2_1__leaf_clk _021_ net1 VSS VSS
+ VDD VDD net22 sky130_fd_sc_hd__dfrtp_4
Xspi_cs_n$_DFFE_PN1P_ clknet_2_0__leaf_clk _022_ net2 VSS
+ VSS VDD VDD net23 sky130_fd_sc_hd__dfstp_1
Xspi_mosi$_DFFE_PN0P_ clknet_2_2__leaf_clk _023_ net1 VSS
+ VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xstate\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _024_ net1 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfrtp_1
Xstate\[1\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _025_ net1 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_1
Xtx_ready$_DFFE_PN1P_ clknet_2_0__leaf_clk _026_ net2 VSS
+ VSS VDD VDD net25 sky130_fd_sc_hd__dfstp_1
Xtx_shift\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _027_ net1
+ VSS VSS VDD VDD tx_shift\[0\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[1\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _028_ net1
+ VSS VSS VDD VDD tx_shift\[1\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _029_ net1
+ VSS VSS VDD VDD tx_shift\[2\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[3\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _030_ net1
+ VSS VSS VDD VDD tx_shift\[3\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[4\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _031_ net1
+ VSS VSS VDD VDD tx_shift\[4\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[5\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _032_ net1
+ VSS VSS VDD VDD tx_shift\[5\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift\[6\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _033_ net1
+ VSS VSS VDD VDD tx_shift\[6\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net2 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net26 VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 spi_miso VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 tx_data[0] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 tx_data[1] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 tx_data[2] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 tx_data[3] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 tx_data[4] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 tx_data[5] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 tx_data[6] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 tx_data[7] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 tx_valid VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD rx_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD rx_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD rx_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD rx_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD rx_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD rx_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD rx_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD rx_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD rx_valid sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD spi_clk sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD spi_cs_n sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD spi_mosi sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD tx_ready sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xclkload1 clknet_2_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__bufinv_16
Xclkload2 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net26 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS final_spi_master
