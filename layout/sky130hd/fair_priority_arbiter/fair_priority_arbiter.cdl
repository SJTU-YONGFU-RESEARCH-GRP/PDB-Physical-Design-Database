* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT fair_priority_arbiter clk grant[0] grant[1] grant[2]
+ grant[3] grant_idx[0] grant_idx[1] priorities[0] priorities[1]
+ priorities[2] priorities[3] priorities[4] priorities[5] priorities[6]
+ priorities[7] request[0] request[1] request[2] request[3]
+ rst_n valid
X_132_ net8 _108_ _120_ net6 _116_ net10 VSS VSS VDD VDD _053_
+ sky130_fd_sc_hd__a222oi_1
X_133_ net4 VSS VSS VDD VDD _054_ sky130_fd_sc_hd__inv_1
X_134_ _053_ _054_ _114_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__mux2i_4
X_135_ _055_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__inv_1
X_136_ request[1] VSS VSS VDD VDD _056_ sky130_fd_sc_hd__buf_2
X_137_ request[3] VSS VSS VDD VDD _057_ sky130_fd_sc_hd__buf_2
Xsplit1 net23 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
X_139_ _056_ _057_ _109_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__mux2i_1
X_140_ net12 net13 _109_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__mux2i_1
X_141_ _122_ net21 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__or2_4
X_143_ _059_ _060_ _061_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__mux2_4
X_144_ _112_ net11 net9 _116_ net7 _108_ VSS VSS VDD VDD _064_
+ sky130_fd_sc_hd__a222oi_1
X_145_ net36 net5 VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nand2_1
X_146_ net36 _064_ _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__o21ai_1
X_147_ _063_ _066_ VSS VSS VDD VDD _099_ sky130_fd_sc_hd__nand2b_4
X_148_ net11 _110_ _112_ net7 _120_ net9 VSS VSS VDD VDD _067_
+ sky130_fd_sc_hd__a222oi_1
X_149_ net5 VSS VSS VDD VDD _068_ sky130_fd_sc_hd__inv_1
X_150_ _067_ _068_ _118_ VSS VSS VDD VDD _124_ sky130_fd_sc_hd__mux2_1
X_151_ _110_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__inv_1
X_152_ net9 _112_ _116_ net7 _120_ net11 VSS VSS VDD VDD _070_
+ sky130_fd_sc_hd__a222oi_1
X_153_ _069_ _070_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__nand2_1
X_154_ net5 _069_ _071_ VSS VSS VDD VDD _128_ sky130_fd_sc_hd__o21ai_0
X_155_ _109_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__buf_2
X_156_ net12 net13 _057_ _056_ _072_ _061_ VSS VSS VDD VDD
+ _073_ sky130_fd_sc_hd__mux4_1
X_157_ _057_ _109_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nand2b_1
X_158_ net2 net1 _072_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__o21bai_1
X_159_ _061_ _074_ _075_ net13 VSS VSS VDD VDD _076_ sky130_fd_sc_hd__o22ai_1
X_160_ net12 _056_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__nor2_1
X_161_ _056_ net2 net1 _109_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__or4_1
X_162_ net2 net1 _072_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__o21ai_1
X_163_ net12 net13 _057_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__or3_1
X_164_ net13 _057_ _078_ _079_ _080_ VSS VSS VDD VDD _081_
+ sky130_fd_sc_hd__o32ai_2
X_165_ _076_ _077_ _081_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__a21oi_1
X_166_ _073_ _082_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nor2_1
X_167_ _083_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__inv_1
X_168_ net2 net22 VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nor2_2
X_169_ _056_ net13 _057_ net12 _084_ _109_ VSS VSS VDD VDD
+ _085_ sky130_fd_sc_hd__mux4_2
X_170_ _104_ _101_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nor2b_4
X_171_ _086_ _100_ net34 _105_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__a2bb2oi_2
X_172_ net10 _112_ _116_ net8 net6 _108_ VSS VSS VDD VDD _088_
+ sky130_fd_sc_hd__a222oi_1
X_173_ net36 _088_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__and2b_2
X_174_ net4 net36 VSS VSS VDD VDD _090_ sky130_fd_sc_hd__nor2b_1
X_175_ _085_ net31 _063_ _089_ _090_ VSS VSS VDD VDD _091_
+ sky130_fd_sc_hd__a2111oi_2
X_176_ _087_ _063_ _085_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__o21a_2
X_177_ _063_ _089_ _090_ VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nor3_4
X_178_ _055_ _091_ _092_ net75 VSS VSS VDD VDD _093_ sky130_fd_sc_hd__o22ai_4
X_179_ net13 VSS VSS VDD VDD _094_ sky130_fd_sc_hd__inv_1
X_180_ _057_ _079_ _078_ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__o21ai_1
X_181_ _061_ _074_ _075_ _056_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__o22ai_2
X_182_ net12 VSS VSS VDD VDD _097_ sky130_fd_sc_hd__inv_1
X_183_ _126_ _127_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__nor2_4
X_184_ _094_ _095_ _096_ _097_ _007_ VSS VSS VDD VDD _008_
+ sky130_fd_sc_hd__a221oi_4
X_185_ net13 _057_ net12 _056_ _084_ _072_ VSS VSS VDD VDD
+ _009_ sky130_fd_sc_hd__mux4_1
X_186_ _009_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__inv_1
X_187_ _131_ _130_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nor2_1
X_188_ _076_ _077_ _081_ _011_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__a211oi_2
X_189_ _008_ _010_ _012_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o21ai_1
X_190_ net10 _110_ _112_ net6 _120_ net8 VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__a222oi_1
X_191_ _014_ _054_ _118_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__mux2i_2
X_192_ net8 _112_ _116_ net6 _120_ net10 VSS VSS VDD VDD _016_
+ sky130_fd_sc_hd__a222oi_1
X_193_ net4 _110_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nor2b_1
X_194_ _069_ _016_ _017_ _130_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__a211o_1
X_195_ _015_ _009_ _018_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__a21o_1
X_196_ _126_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__inv_1
X_197_ _069_ _016_ _017_ _130_ _020_ VSS VSS VDD VDD _021_
+ sky130_fd_sc_hd__a2111o_1
X_198_ _094_ _095_ _096_ _097_ _021_ VSS VSS VDD VDD _022_
+ sky130_fd_sc_hd__a221o_1
X_199_ _012_ _022_ _019_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nand3_2
X_200_ _013_ _093_ _073_ _023_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__o211ai_2
X_201_ _020_ _015_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__and2_0
X_202_ _093_ _025_ _008_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__a21boi_0
X_203_ _072_ _084_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_204_ net30 _057_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__nor2b_1
X_205_ _097_ _061_ _028_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__nor3_1
X_206_ _063_ net30 _085_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__o21ai_1
X_207_ _056_ _027_ _029_ _072_ _030_ VSS VSS VDD VDD _031_
+ sky130_fd_sc_hd__a221oi_1
X_208_ _026_ _010_ _031_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__o21ai_1
X_209_ _010_ _008_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nor2_1
X_210_ _020_ _093_ _015_ _009_ _033_ VSS VSS VDD VDD _034_
+ sky130_fd_sc_hd__a41o_1
X_211_ _057_ _084_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand2_1
X_212_ _094_ _084_ _035_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__o21ai_0
X_213_ _072_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nand2_1
X_214_ _072_ _036_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2b_1
X_215_ _034_ _029_ _037_ _038_ _026_ VSS VSS VDD VDD _039_
+ sky130_fd_sc_hd__o32a_1
X_216_ _056_ _072_ net35 VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nand3_1
X_217_ _097_ _072_ net35 _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o31ai_2
X_218_ _019_ _022_ _033_ _093_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__o2bb2ai_1
X_219_ _012_ _042_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand2_1
X_220_ net37 _032_ _039_ _041_ _043_ VSS VSS VDD VDD _044_
+ sky130_fd_sc_hd__a32oi_4
X_221_ _059_ _092_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nor2_1
X_222_ _034_ _045_ _024_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__o21a_1
X_223_ _030_ _034_ _024_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__o21ai_1
X_224_ _046_ _047_ net35 VSS VSS VDD VDD _048_ sky130_fd_sc_hd__mux2_4
X_225_ _083_ _048_ _044_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__nor3_2
X_226_ _046_ _047_ net35 VSS VSS VDD VDD _049_ sky130_fd_sc_hd__mux2i_2
X_227_ _049_ _044_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor2_1
X_228_ _049_ _044_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__and2_4
X_229_ _048_ _044_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__and2_4
X_230_ net9 _108_ _120_ net7 _116_ net11 VSS VSS VDD VDD _050_
+ sky130_fd_sc_hd__a222oi_1
X_231_ _050_ _068_ _114_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__mux2i_2
X_232_ net18 VSS VSS VDD VDD _106_ sky130_fd_sc_hd__inv_4
X_233_ net19 VSS VSS VDD VDD _107_ sky130_fd_sc_hd__inv_2
X_234_ _092_ _098_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand2_2
X_235_ _092_ _099_ _051_ VSS VSS VDD VDD _125_ sky130_fd_sc_hd__o21ai_4
X_236_ _034_ _125_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor2_1
X_237_ _124_ _034_ _052_ VSS VSS VDD VDD _129_ sky130_fd_sc_hd__a21oi_1
X_238_ _106_ _004_ _049_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__o21ai_1
X_239_ net25 _083_ _044_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a21o_1
X_240_ _099_ _098_ VSS VSS VDD VDD _100_ _101_ sky130_fd_sc_hd__ha_4
X_241_ _102_ _103_ VSS VSS VDD VDD _104_ _105_ sky130_fd_sc_hd__ha_2
X_242_ _106_ _107_ VSS VSS VDD VDD _108_ _109_ sky130_fd_sc_hd__ha_4
X_243_ _106_ _107_ VSS VSS VDD VDD _110_ _111_ sky130_fd_sc_hd__ha_1
X_244_ _106_ net26 VSS VSS VDD VDD _112_ _113_ sky130_fd_sc_hd__ha_4
X_245_ _106_ net27 VSS VSS VDD VDD _114_ _115_ sky130_fd_sc_hd__ha_2
X_246_ net24 _107_ VSS VSS VDD VDD _116_ _117_ sky130_fd_sc_hd__ha_2
X_247_ net1 _107_ VSS VSS VDD VDD _118_ _119_ sky130_fd_sc_hd__ha_1
X_248_ net33 net26 VSS VSS VDD VDD _120_ _121_ sky130_fd_sc_hd__ha_2
X_249_ net19 net18 VSS VSS VDD VDD _122_ _123_ sky130_fd_sc_hd__ha_4
X_250_ _125_ _124_ VSS VSS VDD VDD _126_ _127_ sky130_fd_sc_hd__ha_4
X_251_ _128_ _129_ VSS VSS VDD VDD _130_ _131_ sky130_fd_sc_hd__ha_2
Xgrant\[0\]$_DFF_PN0_ clknet_1_0__leaf_clk _000_ net3 VSS
+ VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xgrant\[1\]$_DFF_PN0_ clknet_1_0__leaf_clk _001_ net3 VSS
+ VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xgrant\[2\]$_DFF_PN0_ clknet_1_1__leaf_clk _002_ net3 VSS
+ VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xgrant\[3\]$_DFF_PN0_ clknet_1_0__leaf_clk _003_ net3 VSS
+ VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xlast_grant_idx\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _005_
+ net3 VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_4
Xlast_grant_idx\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_
+ net3 VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_4
Xvalid$_DFF_PN0_ clknet_1_1__leaf_clk _004_ net3 VSS VSS VDD
+ VDD net20 sky130_fd_sc_hd__dfrtp_1
Xsplit2 _122_ VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xhold3 net76 VSS VSS VDD VDD net3 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 priorities[0] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput2 priorities[1] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput3 priorities[2] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput4 priorities[3] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput5 priorities[4] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput6 priorities[5] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput7 priorities[6] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput8 priorities[7] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput9 request[0] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xinput10 request[2] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xoutput11 net14 VSS VSS VDD VDD grant[0] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net15 VSS VSS VDD VDD grant[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net16 VSS VSS VDD VDD grant[2] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net17 VSS VSS VDD VDD grant[3] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net32 VSS VSS VDD VDD grant_idx[0] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net28 VSS VSS VDD VDD grant_idx[1] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net20 VSS VSS VDD VDD valid sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xrebuffer1 net18 VSS VSS VDD VDD net21 sky130_fd_sc_hd__buf_6
Xrebuffer2 net21 VSS VSS VDD VDD net22 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer3 net22 VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer4 net21 VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_1
Xrebuffer5 net19 VSS VSS VDD VDD net25 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer6 net19 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_2
Xrebuffer7 net26 VSS VSS VDD VDD net27 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 net19 VSS VSS VDD VDD net28 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 _087_ VSS VSS VDD VDD net30 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer11 _087_ VSS VSS VDD VDD net31 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer12 net57 VSS VSS VDD VDD net32 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer13 net18 VSS VSS VDD VDD net33 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer14 _101_ VSS VSS VDD VDD net34 sky130_fd_sc_hd__dlymetal6s2s_1
Xclone15 _061_ VSS VSS VDD VDD net35 sky130_fd_sc_hd__buf_2
Xrebuffer16 _122_ VSS VSS VDD VDD net36 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer37 net58 VSS VSS VDD VDD net57 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer38 net59 VSS VSS VDD VDD net58 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer39 net60 VSS VSS VDD VDD net59 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 net61 VSS VSS VDD VDD net60 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer41 net62 VSS VSS VDD VDD net61 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer42 net63 VSS VSS VDD VDD net62 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer43 net64 VSS VSS VDD VDD net63 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer44 net65 VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer45 net66 VSS VSS VDD VDD net65 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer46 net67 VSS VSS VDD VDD net66 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer47 net68 VSS VSS VDD VDD net67 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer48 net69 VSS VSS VDD VDD net68 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer49 net70 VSS VSS VDD VDD net69 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer50 net74 VSS VSS VDD VDD net70 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer54 net38 VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkbuf_2
Xrebuffer55 _102_ VSS VSS VDD VDD net75 sky130_fd_sc_hd__dlygate4sd1_1
Xhold56 rst_n VSS VSS VDD VDD net76 sky130_fd_sc_hd__dlygate4sd3_1
Xrebuffer15 _024_ VSS VSS VDD VDD net37 sky130_fd_sc_hd__buf_2
Xrebuffer17 net18 VSS VSS VDD VDD net38 sky130_fd_sc_hd__buf_6
.ENDS fair_priority_arbiter
