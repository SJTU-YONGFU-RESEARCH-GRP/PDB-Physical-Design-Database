* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT universal_shift_register clk direction[0] direction[1]
+ enable load parallel_in[0] parallel_in[1] parallel_in[2] parallel_in[3]
+ parallel_in[4] parallel_in[5] parallel_in[6] parallel_in[7]
+ parallel_out[0] parallel_out[1] parallel_out[2] parallel_out[3]
+ parallel_out[4] parallel_out[5] parallel_out[6] parallel_out[7]
+ rst_n serial_in_left serial_in_right
X_082_ shift_right_count\[0\] VSS VSS VDD VDD _073_ sky130_fd_sc_hd__inv_1
X_083_ net2 VSS VSS VDD VDD _064_ sky130_fd_sc_hd__inv_1
X_084_ net3 VSS VSS VDD VDD _067_ sky130_fd_sc_hd__inv_1
X_085_ shift_right_count\[1\] VSS VSS VDD VDD _074_ sky130_fd_sc_hd__inv_1
X_086_ _065_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__buf_6
X_087_ shift_right_count\[2\] VSS VSS VDD VDD _024_ sky130_fd_sc_hd__buf_6
X_088_ shift_right_count\[0\] _024_ VSS VSS VDD VDD _025_
+ sky130_fd_sc_hd__nor2b_1
X_089_ _024_ _079_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nor2b_1
X_090_ net14 _023_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nand2b_1
X_091_ net5 VSS VSS VDD VDD _028_ sky130_fd_sc_hd__clkinvlp_4
X_092_ _023_ _025_ _026_ _027_ _028_ VSS VSS VDD VDD _029_
+ sky130_fd_sc_hd__o311ai_1
X_093_ net5 _066_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nand2b_1
X_094_ _030_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__buf_2
X_095_ net4 _031_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__and2_1
X_096_ net5 VSS VSS VDD VDD _033_ sky130_fd_sc_hd__clkbuf_4
X_097_ _033_ net6 VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand2_1
X_098_ net4 VSS VSS VDD VDD _035_ sky130_fd_sc_hd__buf_2
X_099_ _035_ _031_ net15 VSS VSS VDD VDD _036_ sky130_fd_sc_hd__a21oi_1
X_100_ _029_ _032_ _034_ _036_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__a31oi_1
X_101_ net4 _031_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nand2_1
X_102_ shift_right_count\[2\] _076_ VSS VSS VDD VDD _038_
+ sky130_fd_sc_hd__nor2b_1
X_103_ _079_ _024_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nor2b_1
X_104_ _023_ net15 _033_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__a21oi_1
X_105_ _023_ _038_ _039_ _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o31a_1
X_106_ _028_ net7 _031_ _035_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__o211ai_1
X_107_ net16 _037_ _041_ _042_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o2bb2ai_1
X_108_ _024_ _077_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nor2_1
X_109_ _024_ _076_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__and2_0
X_110_ _023_ net16 _033_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__a21oi_1
X_111_ _023_ _043_ _044_ _045_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__o31a_1
X_112_ _028_ net8 _031_ _035_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__o211ai_1
X_113_ net17 _037_ _046_ _047_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__o2bb2ai_1
X_114_ shift_right_count\[0\] shift_right_count\[1\] shift_right_count\[2\]
+ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__mux2_1
X_115_ net17 _023_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nand2b_1
X_116_ _023_ _048_ _049_ _028_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__o211ai_1
X_117_ _033_ net9 VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand2_1
X_118_ _035_ _031_ net18 VSS VSS VDD VDD _052_ sky130_fd_sc_hd__a21oi_1
X_119_ _032_ _050_ _051_ _052_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__a31oi_1
X_120_ _023_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__inv_2
X_121_ shift_right_count\[0\] _075_ _024_ VSS VSS VDD VDD
+ _054_ sky130_fd_sc_hd__mux2i_1
X_122_ _023_ net18 net5 VSS VSS VDD VDD _055_ sky130_fd_sc_hd__a21o_1
X_123_ _053_ _054_ _055_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__a21oi_1
X_124_ _028_ net10 _031_ _035_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__o211ai_1
X_125_ net19 _037_ _056_ _057_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__o2bb2ai_1
X_126_ _079_ _024_ _065_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__or3_1
X_127_ _053_ net19 _058_ _028_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__o211ai_1
X_128_ _033_ net11 VSS VSS VDD VDD _060_ sky130_fd_sc_hd__nand2_1
X_129_ _035_ _031_ net20 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__a21oi_1
X_130_ _032_ _059_ _060_ _061_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a31oi_1
X_131_ net20 _065_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nor2b_1
X_132_ _053_ _038_ _062_ net5 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__a211o_1
X_133_ _033_ net12 VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nand2_1
X_134_ _035_ _031_ net21 VSS VSS VDD VDD _012_ sky130_fd_sc_hd__a21oi_1
X_135_ _032_ _063_ _011_ _012_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a31oi_1
X_136_ _024_ _065_ shift_right_count\[1\] VSS VSS VDD VDD
+ _013_ sky130_fd_sc_hd__or3_1
X_137_ _053_ net21 _013_ _028_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__o211ai_1
X_138_ _033_ net13 VSS VSS VDD VDD _015_ sky130_fd_sc_hd__nand2_1
X_139_ net4 _031_ net22 VSS VSS VDD VDD _016_ sky130_fd_sc_hd__a21oi_1
X_140_ _032_ _014_ _015_ _016_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__a31oi_1
X_141_ _071_ _068_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nand2b_1
X_142_ _071_ _068_ net4 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__and3b_1
X_143_ _017_ _018_ _073_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__mux2i_1
X_144_ _035_ _073_ _019_ _033_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o22ai_1
X_145_ shift_right_count\[1\] _017_ _018_ _076_ VSS VSS VDD
+ VDD _020_ sky130_fd_sc_hd__a22oi_1
X_146_ _035_ _074_ _020_ _033_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__o22ai_1
X_147_ _024_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__inv_1
X_148_ _024_ _017_ _018_ _072_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a22oi_1
X_149_ _035_ _021_ _022_ _033_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__o22ai_1
X_150_ _064_ net3 VSS VSS VDD VDD _065_ _066_ sky130_fd_sc_hd__ha_1
X_151_ net2 _067_ VSS VSS VDD VDD _068_ _069_ sky130_fd_sc_hd__ha_1
X_152_ shift_right_count\[2\] _070_ VSS VSS VDD VDD _071_
+ _072_ sky130_fd_sc_hd__ha_1
X_153_ _073_ _074_ VSS VSS VDD VDD _075_ _076_ sky130_fd_sc_hd__ha_1
X_154_ _073_ shift_right_count\[1\] VSS VSS VDD VDD _077_
+ _078_ sky130_fd_sc_hd__ha_1
X_155_ shift_right_count\[0\] _074_ VSS VSS VDD VDD _079_
+ _080_ sky130_fd_sc_hd__ha_1
X_156_ shift_right_count\[0\] shift_right_count\[1\] VSS VSS
+ VDD VDD _070_ _081_ sky130_fd_sc_hd__ha_1
Xparallel_out\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _000_
+ net1 VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _001_
+ net1 VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _002_
+ net1 VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _003_
+ net1 VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _004_
+ net1 VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _005_
+ net1 VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_
+ net1 VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _007_
+ net1 VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xshift_right_count\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _008_
+ net1 VSS VSS VDD VDD shift_right_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xshift_right_count\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _009_
+ net1 VSS VSS VDD VDD shift_right_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xshift_right_count\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _010_
+ net1 VSS VSS VDD VDD shift_right_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net23 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 direction[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 direction[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 enable VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 load VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xinput5 parallel_in[0] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 parallel_in[1] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 parallel_in[2] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 parallel_in[3] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 parallel_in[4] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 parallel_in[5] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 parallel_in[6] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 parallel_in[7] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 serial_in_right VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS universal_shift_register
