* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pulse_width_detector clk pulse_detected rst signal_in
+ threshold[0] threshold[1] threshold[2] threshold[3] threshold[4]
+ threshold[5] threshold[6] threshold[7]
X_082_ net1 VSS VSS VDD VDD _000_ sky130_fd_sc_hd__clkinv_4
X_083_ counter\[7\] VSS VSS VDD VDD _056_ sky130_fd_sc_hd__inv_1
X_084_ counter\[6\] VSS VSS VDD VDD _059_ sky130_fd_sc_hd__inv_1
X_085_ counter\[5\] VSS VSS VDD VDD _062_ sky130_fd_sc_hd__inv_1
X_086_ counter\[4\] VSS VSS VDD VDD _065_ sky130_fd_sc_hd__inv_1
X_087_ counter\[3\] VSS VSS VDD VDD _068_ sky130_fd_sc_hd__inv_1
X_088_ counter\[2\] VSS VSS VDD VDD _071_ sky130_fd_sc_hd__inv_1
X_089_ counter\[1\] VSS VSS VDD VDD _074_ sky130_fd_sc_hd__inv_1
X_090_ net3 VSS VSS VDD VDD _077_ sky130_fd_sc_hd__inv_1
X_091_ counter\[3\] counter\[2\] _080_ VSS VSS VDD VDD _023_
+ sky130_fd_sc_hd__and3_1
X_092_ _023_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__clkbuf_2
X_093_ counter\[5\] counter\[4\] counter\[6\] counter\[7\]
+ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__and4_1
X_094_ _024_ _025_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__and2_0
X_095_ _026_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__clkbuf_2
X_096_ counter\[0\] _027_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__xor2_1
X_097_ net2 signal_prev VSS VSS VDD VDD _029_ sky130_fd_sc_hd__nand2_2
X_098_ net2 signal_prev VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nor2_2
X_099_ counter\[0\] _030_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nand2_1
X_100_ _028_ _029_ _031_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o21ai_0
X_101_ _081_ counter\[1\] _027_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__mux2i_1
X_102_ counter\[1\] _030_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nand2_1
X_103_ _029_ _032_ _033_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__o21ai_0
X_104_ net2 signal_prev VSS VSS VDD VDD _034_ sky130_fd_sc_hd__xor2_1
X_105_ net2 counter\[2\] _080_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand3_1
X_106_ _027_ _035_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor2_1
X_107_ net2 _080_ counter\[2\] VSS VSS VDD VDD _037_ sky130_fd_sc_hd__a21oi_1
X_108_ _034_ _036_ _037_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__nor3_1
X_109_ counter\[2\] counter\[0\] counter\[1\] VSS VSS VDD
+ VDD _038_ sky130_fd_sc_hd__nand3_2
X_110_ net2 counter\[3\] VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand2_1
X_111_ _027_ _038_ _039_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor3_1
X_112_ _068_ _038_ _029_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__a21oi_1
X_113_ counter\[3\] _030_ _041_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__a21oi_1
X_114_ _040_ _042_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__nor2_1
X_115_ _025_ _024_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nor2b_1
X_116_ counter\[4\] _024_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nor2_1
X_117_ counter\[4\] _043_ _044_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__a21oi_1
X_118_ net2 signal_prev VSS VSS VDD VDD _046_ sky130_fd_sc_hd__and2_0
X_119_ counter\[4\] _030_ _045_ _046_ VSS VSS VDD VDD _005_
+ sky130_fd_sc_hd__a22o_1
X_120_ _024_ _025_ _038_ _039_ _065_ VSS VSS VDD VDD _047_
+ sky130_fd_sc_hd__a2111o_1
X_121_ _062_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__xnor2_1
X_122_ _034_ _048_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__nor2_1
X_123_ counter\[6\] _056_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nand2_1
X_124_ counter\[5\] counter\[4\] _024_ VSS VSS VDD VDD _050_
+ sky130_fd_sc_hd__nand3_1
X_125_ _049_ counter\[6\] _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__mux2i_1
X_126_ counter\[6\] _030_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nand2_1
X_127_ _029_ _051_ _052_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_128_ counter\[5\] counter\[4\] counter\[6\] VSS VSS VDD
+ VDD _053_ sky130_fd_sc_hd__nand3_1
X_129_ _024_ _053_ _038_ _039_ counter\[7\] VSS VSS VDD VDD
+ _054_ sky130_fd_sc_hd__o41ai_1
X_130_ counter\[7\] _053_ _038_ _039_ VSS VSS VDD VDD _055_
+ sky130_fd_sc_hd__or4_1
X_131_ _054_ _055_ _034_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__a21oi_1
X_132_ _066_ _061_ _064_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nand3_1
X_133_ _061_ _063_ _060_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__a21oi_1
X_134_ _010_ _011_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__nand2_1
X_135_ _058_ _012_ _029_ _057_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__a211o_1
X_136_ _078_ _076_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nor2b_1
X_137_ _075_ _014_ _070_ _073_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__o211ai_1
X_138_ _070_ _072_ _069_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__a21oi_1
X_139_ _058_ _061_ _064_ _067_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nand4_1
X_140_ _015_ _016_ _017_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__a21oi_1
X_141_ _070_ _073_ _076_ _079_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nand4_1
X_142_ _017_ _019_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nor2_1
X_143_ net11 _020_ _046_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__o21ai_0
X_144_ net11 _030_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nand2_1
X_145_ _013_ _018_ _021_ _022_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__o211ai_1
X_146_ _056_ net10 VSS VSS VDD VDD _057_ _058_ sky130_fd_sc_hd__ha_1
X_147_ _059_ net9 VSS VSS VDD VDD _060_ _061_ sky130_fd_sc_hd__ha_1
X_148_ _062_ net8 VSS VSS VDD VDD _063_ _064_ sky130_fd_sc_hd__ha_1
X_149_ _065_ net7 VSS VSS VDD VDD _066_ _067_ sky130_fd_sc_hd__ha_1
X_150_ _068_ net6 VSS VSS VDD VDD _069_ _070_ sky130_fd_sc_hd__ha_1
X_151_ _071_ net5 VSS VSS VDD VDD _072_ _073_ sky130_fd_sc_hd__ha_1
X_152_ _074_ net4 VSS VSS VDD VDD _075_ _076_ sky130_fd_sc_hd__ha_1
X_153_ counter\[0\] _077_ VSS VSS VDD VDD _078_ _079_ sky130_fd_sc_hd__ha_1
X_154_ counter\[0\] counter\[1\] VSS VSS VDD VDD _080_ _081_
+ sky130_fd_sc_hd__ha_1
Xcounter\[0\]$_DFFE_PP0P_ clknet_1_0__leaf_clk _001_ _000_
+ VSS VSS VDD VDD counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[1\]$_DFFE_PP0P_ clknet_1_0__leaf_clk _002_ _000_
+ VSS VSS VDD VDD counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[2\]$_DFFE_PP0P_ clknet_1_1__leaf_clk _003_ _000_
+ VSS VSS VDD VDD counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[3\]$_DFFE_PP0P_ clknet_1_0__leaf_clk _004_ _000_
+ VSS VSS VDD VDD counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[4\]$_DFFE_PP0P_ clknet_1_1__leaf_clk _005_ _000_
+ VSS VSS VDD VDD counter\[4\] sky130_fd_sc_hd__dfrtp_2
Xcounter\[5\]$_DFFE_PP0P_ clknet_1_1__leaf_clk _006_ _000_
+ VSS VSS VDD VDD counter\[5\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[6\]$_DFFE_PP0P_ clknet_1_1__leaf_clk _007_ _000_
+ VSS VSS VDD VDD counter\[6\] sky130_fd_sc_hd__dfrtp_1
Xcounter\[7\]$_DFFE_PP0P_ clknet_1_1__leaf_clk _008_ _000_
+ VSS VSS VDD VDD counter\[7\] sky130_fd_sc_hd__dfrtp_1
Xpulse_detected$_DFFE_PP0P_ clknet_1_0__leaf_clk _009_ _000_
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xsignal_prev$_DFF_PP0_ clknet_1_0__leaf_clk net2 _000_ VSS
+ VSS VDD VDD signal_prev sky130_fd_sc_hd__dfrtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net12 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 signal_in VSS VSS VDD VDD net2 sky130_fd_sc_hd__buf_2
Xinput3 threshold[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 threshold[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 threshold[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 threshold[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 threshold[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 threshold[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 threshold[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput10 threshold[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD pulse_detected sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold1 rst VSS VSS VDD VDD net12 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS pulse_width_detector
