* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT multi_ported_fifo almost_empty almost_full clk data_count[0]
+ data_count[1] data_count[2] data_count[3] data_count[4] empty
+ full rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[32] rd_data[33] rd_data[34] rd_data[35] rd_data[36]
+ rd_data[37] rd_data[38] rd_data[39] rd_data[3] rd_data[40]
+ rd_data[41] rd_data[42] rd_data[43] rd_data[44] rd_data[45]
+ rd_data[46] rd_data[47] rd_data[48] rd_data[49] rd_data[4]
+ rd_data[50] rd_data[51] rd_data[52] rd_data[53] rd_data[54]
+ rd_data[55] rd_data[56] rd_data[57] rd_data[58] rd_data[59]
+ rd_data[5] rd_data[60] rd_data[61] rd_data[62] rd_data[63]
+ rd_data[6] rd_data[7] rd_data[8] rd_data[9] rd_en[0] rd_en[1]
+ rd_valid[0] rd_valid[1] rst_n wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[32] wr_data[33] wr_data[34]
+ wr_data[35] wr_data[36] wr_data[37] wr_data[38] wr_data[39]
+ wr_data[3] wr_data[40] wr_data[41] wr_data[42] wr_data[43]
+ wr_data[44] wr_data[45] wr_data[46] wr_data[47] wr_data[48]
+ wr_data[49] wr_data[4] wr_data[50] wr_data[51] wr_data[52]
+ wr_data[53] wr_data[54] wr_data[55] wr_data[56] wr_data[57]
+ wr_data[58] wr_data[59] wr_data[5] wr_data[60] wr_data[61]
+ wr_data[62] wr_data[63] wr_data[6] wr_data[7] wr_data[8] wr_data[9]
+ wr_en[0] wr_en[1] wr_ready[0] wr_ready[1]
X_2568_ _2512_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__inv_1
X_2569_ net71 VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__buf_6
X_2570_ _0607_ VSS VSS VDD VDD _2514_ sky130_fd_sc_hd__inv_1
X_2571_ net67 _2512_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__nand2_2
X_2572_ net72 VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__clkbuf_4
X_2573_ _0609_ _0607_ net73 _2548_ VSS VSS VDD VDD _0610_
+ sky130_fd_sc_hd__nor4_1
X_2574_ net75 VSS VSS VDD VDD _2510_ sky130_fd_sc_hd__clkinv_4
X_2575_ _2561_ _0610_ _2510_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__a21oi_2
X_2576_ _0608_ _0611_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__nor2_1
X_2577_ _0612_ VSS VSS VDD VDD _2526_ sky130_fd_sc_hd__inv_2
X_2578_ wr_ptr\[1\] VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__buf_2
X_2579_ _0613_ VSS VSS VDD VDD _2501_ sky130_fd_sc_hd__inv_1
X_2580_ net67 _2512_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__and2_0
X_2581_ _0614_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__clkbuf_2
X_2582_ net168 _2552_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__nand2b_1
X_2583_ net73 _2565_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__nand2_1
X_2584_ _0609_ _0607_ VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__nand2_1
X_2585_ _0616_ _0617_ _0618_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__a21oi_2
X_2586_ _2510_ net68 _2512_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__nand3_1
X_2587_ _0615_ _0619_ _0620_ VSS VSS VDD VDD _2519_ sky130_fd_sc_hd__a21oi_1
X_2588_ _2519_ VSS VSS VDD VDD _2525_ sky130_fd_sc_hd__inv_1
X_2589_ wr_ptr\[3\] VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__clkbuf_4
X_2590_ wr_ptr\[2\] VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__clkbuf_4
X_2591_ _0621_ _0622_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__or2_4
X_2592_ _0612_ VSS VSS VDD VDD _2520_ sky130_fd_sc_hd__clkbuf_8
X_2593_ _2504_ _2520_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__nand2_4
X_2594_ _2510_ net68 _2512_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__and3_1
X_2595_ _0625_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__clkbuf_2
X_2596_ _0621_ wr_ptr\[0\] _0615_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__nor3_1
X_2597_ wr_ptr\[2\] _0613_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__nand2_1
X_2598_ _0621_ wr_ptr\[0\] VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__nand2_1
X_2599_ _0608_ _0619_ _0628_ _0629_ VSS VSS VDD VDD _0630_
+ sky130_fd_sc_hd__nor4_1
X_2600_ wr_ptr\[3\] wr_ptr\[0\] VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__nor2b_1
X_2601_ _0628_ _0631_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__nand2_1
X_2602_ _0608_ _0619_ _0632_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__nor3_1
X_2603_ _0627_ _0630_ _0633_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__or3_1
X_2604_ wr_ptr\[2\] _2508_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nand2b_1
X_2605_ _2508_ wr_ptr\[2\] VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__nand2b_1
X_2606_ _2503_ _0635_ _0636_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__nand3_1
X_2607_ _0622_ _0613_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__nand2b_1
X_2608_ _0637_ _0638_ _2526_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__mux2i_1
X_2609_ _0626_ _0634_ _0639_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__and3_1
X_2610_ _0640_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__buf_4
X_2611_ _0641_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__buf_6
X_2612_ _0623_ _0624_ _0642_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__o21bai_4
X_2613_ wr_ptr\[0\] _0608_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nand2_1
X_2614_ wr_ptr\[0\] VSS VSS VDD VDD _2500_ sky130_fd_sc_hd__inv_1
X_2615_ _0616_ _0617_ _0618_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__a21o_1
X_2616_ _2500_ _0615_ _0644_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__nand3_2
X_2617_ _0643_ _0645_ _0621_ _0620_ VSS VSS VDD VDD _0646_
+ sky130_fd_sc_hd__a211o_4
X_2618_ wr_ptr\[2\] _2508_ VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__nor2_1
X_2619_ wr_ptr\[2\] _2508_ VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__and2_0
X_2620_ _2503_ VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__inv_1
X_2621_ _2561_ _0610_ _2510_ VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__a21o_1
X_2622_ _0647_ _0648_ _0649_ _0615_ _0650_ VSS VSS VDD VDD
+ _0651_ sky130_fd_sc_hd__o2111ai_2
X_2623_ _0622_ _0613_ _2520_ _0651_ VSS VSS VDD VDD _0652_
+ sky130_fd_sc_hd__o31a_2
X_2624_ _2506_ _2520_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__nand2_4
X_2625_ _0646_ _0652_ _0653_ _0623_ VSS VSS VDD VDD _0008_
+ sky130_fd_sc_hd__o22ai_4
X_2626_ _2508_ _2520_ VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__nand2_4
X_2627_ _0621_ _0622_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__nand2_4
X_2628_ _0621_ _0626_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__nand2_1
X_2629_ _0643_ _0645_ _0656_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__a21oi_4
X_2630_ _0649_ _0635_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__nor2_1
X_2631_ _0649_ _0636_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__nor2_1
X_2632_ _0658_ _0659_ _0615_ _0650_ VSS VSS VDD VDD _0660_
+ sky130_fd_sc_hd__o211ai_2
X_2633_ _2520_ _0628_ _0660_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__o21ai_4
X_2634_ _0657_ _0661_ VSS VSS VDD VDD _0662_ sky130_fd_sc_hd__nand2_8
X_2635_ _0662_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__buf_6
X_2636_ _0654_ _0655_ _0663_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__o21ai_4
X_2637_ _0621_ _2500_ _0608_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__nand3_1
X_2638_ wr_ptr\[2\] wr_ptr\[1\] VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__and2_0
X_2639_ _0615_ _0644_ _0665_ _0631_ VSS VSS VDD VDD _0666_
+ sky130_fd_sc_hd__nand4_1
X_2640_ _0608_ _0619_ _0665_ _0629_ VSS VSS VDD VDD _0667_
+ sky130_fd_sc_hd__or4_1
X_2641_ _0664_ _0666_ _0667_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__nand3_1
X_2642_ _0626_ _0661_ _0668_ VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__and3_1
X_2643_ _0669_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__buf_6
X_2644_ _0670_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__buf_6
X_2645_ _0624_ _0655_ _0671_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__o21bai_4
X_2646_ _0622_ _2501_ VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__nand2_1
X_2647_ _0635_ _0636_ _2503_ _0608_ _0611_ VSS VSS VDD VDD
+ _0673_ sky130_fd_sc_hd__a2111o_1
X_2648_ _2520_ _0672_ _0673_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__o21ai_1
X_2649_ _0657_ _0674_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__and2_0
X_2650_ _0675_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__buf_6
X_2651_ _0676_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__buf_6
X_2652_ _0653_ _0655_ _0677_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__o21bai_4
X_2653_ _2502_ _2520_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__nand2_4
X_2654_ _0626_ _0668_ _0674_ VSS VSS VDD VDD _0679_ sky130_fd_sc_hd__and3_1
X_2655_ _0679_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__buf_6
X_2656_ _0680_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__buf_6
X_2657_ _0655_ _0678_ _0681_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__o21bai_4
X_2658_ _0622_ _0621_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__nand2b_4
X_2659_ _0626_ _0639_ _0668_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__and3_1
X_2660_ _0683_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__buf_6
X_2661_ _0684_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__buf_6
X_2662_ _0624_ _0682_ _0685_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__o21bai_4
X_2663_ _0621_ _0622_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__nand2b_4
X_2664_ _0646_ _0661_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__nor2b_1
X_2665_ _0687_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__buf_4
X_2666_ _0688_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__buf_6
X_2667_ _0654_ _0686_ _0689_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__o21bai_4
X_2668_ _0639_ _0657_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__and2_0
X_2669_ _0690_ VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__buf_6
X_2670_ _0691_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__buf_6
X_2671_ _0654_ _0682_ _0692_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__o21bai_4
X_2672_ _0622_ _0613_ _2520_ _0651_ VSS VSS VDD VDD _0693_
+ sky130_fd_sc_hd__o31ai_1
X_2673_ _0626_ _0634_ _0693_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__and3_1
X_2674_ _0694_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__buf_4
X_2675_ _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__buf_6
X_2676_ _0623_ _0678_ _0696_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__o21bai_4
X_2677_ _0626_ _0634_ _0661_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__and3_1
X_2678_ _0697_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__buf_4
X_2679_ _0698_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__buf_6
X_2680_ _0624_ _0686_ _0699_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__o21bai_4
X_2681_ _2520_ _0672_ _0673_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__o21a_1
X_2682_ _0646_ _0700_ _0686_ _0653_ VSS VSS VDD VDD _0004_
+ sky130_fd_sc_hd__o22ai_4
X_2683_ _0626_ _0634_ _0674_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__and3_1
X_2684_ _0701_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__buf_4
X_2685_ _0702_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__buf_6
X_2686_ _0678_ _0686_ _0703_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__o21bai_4
X_2687_ _0637_ _0638_ _2526_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__mux2_2
X_2688_ _0704_ _0646_ _0654_ _0623_ VSS VSS VDD VDD _0006_
+ sky130_fd_sc_hd__o22ai_4
X_2689_ _0626_ _0693_ _0668_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__and3_1
X_2690_ _0705_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__buf_4
X_2691_ _0706_ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__buf_6
X_2692_ _0678_ _0682_ _0707_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__o21bai_4
X_2693_ _0693_ _0657_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__and2_0
X_2694_ _0708_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__buf_6
X_2695_ _0709_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__buf_6
X_2696_ _0653_ _0682_ _0710_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__o21bai_4
X_2697_ rd_en[0] VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__clkbuf_4
X_2698_ net72 _0607_ net73 _2557_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__or4b_4
Xrebuffer4 net219 VSS VSS VDD VDD net166 sky130_fd_sc_hd__dlygate4sd1_1
X_2700_ _0711_ _0712_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__nand2_8
X_2701_ _0714_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__inv_2
XANTENNA_1 _0997_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
X_2703_ _0715_ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__clkbuf_16
X_2704_ _2559_ VSS VSS VDD VDD _0717_ sky130_fd_sc_hd__inv_1
X_2705_ net72 net73 _2559_ _2515_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__or4bb_1
X_2706_ net72 net168 _2516_ _2548_ VSS VSS VDD VDD _0719_
+ sky130_fd_sc_hd__or4bb_4
X_2707_ _0717_ _2557_ _0718_ net2 _0719_ VSS VSS VDD VDD _0720_
+ sky130_fd_sc_hd__o2111ai_4
X_2708_ _0720_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__inv_4
X_2709_ _0721_ VSS VSS VDD VDD _2537_ sky130_fd_sc_hd__buf_6
X_2710_ rd_ptr\[1\] VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__buf_6
X_2711_ _0722_ VSS VSS VDD VDD _2492_ sky130_fd_sc_hd__inv_1
X_2712_ net3 VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__clkbuf_2
X_2713_ net28 VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__buf_2
X_2714_ _0723_ _0724_ _0696_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__mux2_1
X_2715_ net14 VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__buf_2
X_2716_ net29 VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__buf_2
X_2717_ _0725_ _0726_ _0696_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__mux2_1
X_2718_ net25 VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__buf_2
X_2719_ net30 VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__buf_2
X_2720_ _0727_ _0728_ _0696_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__mux2_1
X_2721_ net36 VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__clkbuf_2
X_2722_ net31 VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__buf_2
X_2723_ _0729_ _0730_ _0696_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__mux2_1
X_2724_ net47 VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__buf_2
X_2725_ net32 VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__buf_2
X_2726_ _0731_ _0732_ _0696_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__mux2_1
X_2727_ net58 VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__buf_2
X_2728_ net33 VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__buf_2
X_2729_ _0733_ _0734_ _0696_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__mux2_1
X_2730_ net63 VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__clkbuf_2
X_2731_ net34 VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__buf_2
X_2732_ _0735_ _0736_ _0696_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__mux2_1
X_2733_ net64 VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__clkbuf_2
X_2734_ net35 VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__clkbuf_2
X_2735_ _0737_ _0738_ _0696_ VSS VSS VDD VDD _0045_ sky130_fd_sc_hd__mux2_1
X_2736_ net65 VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__clkbuf_2
X_2737_ net37 VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__buf_2
X_2738_ _0739_ _0740_ _0696_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__mux2_1
X_2739_ net66 VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__buf_2
X_2740_ net38 VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__buf_2
X_2741_ _0695_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__buf_6
X_2742_ _0741_ _0742_ _0743_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__mux2_1
X_2743_ net4 VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__clkbuf_2
X_2744_ net39 VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__buf_2
X_2745_ _0744_ _0745_ _0743_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__mux2_1
X_2746_ net5 VSS VSS VDD VDD _0746_ sky130_fd_sc_hd__buf_2
X_2747_ net40 VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__buf_2
X_2748_ _0746_ _0747_ _0743_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__mux2_1
X_2749_ net6 VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__buf_2
X_2750_ net41 VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__buf_2
X_2751_ _0748_ _0749_ _0743_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__mux2_1
X_2752_ net7 VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__buf_2
X_2753_ net42 VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__buf_2
X_2754_ _0750_ _0751_ _0743_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__mux2_1
X_2755_ net8 VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__buf_2
X_2756_ net43 VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__buf_2
X_2757_ _0752_ _0753_ _0743_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__mux2_1
X_2758_ net9 VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__buf_2
X_2759_ net44 VSS VSS VDD VDD _0755_ sky130_fd_sc_hd__buf_2
X_2760_ _0754_ _0755_ _0743_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__mux2_1
X_2761_ net10 VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__buf_2
X_2762_ net45 VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__buf_2
X_2763_ _0756_ _0757_ _0743_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__mux2_1
X_2764_ net11 VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__buf_2
X_2765_ net46 VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__buf_2
X_2766_ _0758_ _0759_ _0743_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__mux2_1
X_2767_ net12 VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__clkbuf_2
X_2768_ net48 VSS VSS VDD VDD _0761_ sky130_fd_sc_hd__buf_2
X_2769_ _0760_ _0761_ _0743_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__mux2_1
X_2770_ net13 VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__buf_2
X_2771_ net49 VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__buf_2
X_2772_ _0695_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__buf_4
X_2773_ _0762_ _0763_ _0764_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__mux2_1
X_2774_ net15 VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__buf_2
X_2775_ net50 VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__buf_2
X_2776_ _0765_ _0766_ _0764_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__mux2_1
X_2777_ net16 VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__buf_2
X_2778_ net51 VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__buf_2
X_2779_ _0767_ _0768_ _0764_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__mux2_1
X_2780_ net17 VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__buf_2
X_2781_ net52 VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__buf_2
X_2782_ _0769_ _0770_ _0764_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__mux2_1
X_2783_ net18 VSS VSS VDD VDD _0771_ sky130_fd_sc_hd__buf_2
X_2784_ net53 VSS VSS VDD VDD _0772_ sky130_fd_sc_hd__buf_2
X_2785_ _0771_ _0772_ _0764_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__mux2_1
X_2786_ net19 VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__clkbuf_2
X_2787_ net54 VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__clkbuf_2
X_2788_ _0773_ _0774_ _0764_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__mux2_1
X_2789_ net20 VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__buf_2
X_2790_ net55 VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__clkbuf_4
X_2791_ _0775_ _0776_ _0764_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__mux2_1
X_2792_ net21 VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__buf_2
X_2793_ net56 VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__buf_2
X_2794_ _0777_ _0778_ _0764_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__mux2_1
X_2795_ net22 VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__buf_2
X_2796_ net57 VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__buf_2
X_2797_ _0779_ _0780_ _0764_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__mux2_1
X_2798_ net23 VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__buf_2
X_2799_ net59 VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__buf_2
X_2800_ _0781_ _0782_ _0764_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__mux2_1
X_2801_ net24 VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__buf_2
X_2802_ net60 VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__buf_2
X_2803_ _0783_ _0784_ _0695_ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__mux2_1
X_2804_ net26 VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__buf_2
X_2805_ net61 VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__buf_2
X_2806_ _0785_ _0786_ _0695_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__mux2_1
X_2807_ net27 VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__buf_2
X_2808_ net62 VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__buf_2
X_2809_ _0787_ _0788_ _0695_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__mux2_1
X_2810_ _0646_ _0652_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__nor2_4
X_2811_ _0789_ VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__buf_6
X_2812_ _0723_ _0724_ _0790_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__mux2_1
X_2813_ _0725_ _0726_ _0790_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__mux2_1
X_2814_ _0727_ _0728_ _0790_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__mux2_1
X_2815_ _0729_ _0730_ _0790_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__mux2_1
X_2816_ _0731_ _0732_ _0790_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__mux2_1
X_2817_ _0733_ _0734_ _0790_ VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__mux2_1
X_2818_ _0735_ _0736_ _0790_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__mux2_1
X_2819_ _0737_ _0738_ _0790_ VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__mux2_1
X_2820_ _0739_ _0740_ _0790_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__mux2_1
X_2821_ _0741_ _0742_ _0790_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__mux2_1
X_2822_ _0789_ VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__buf_6
X_2823_ _0744_ _0745_ _0791_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__mux2_1
X_2824_ _0746_ _0747_ _0791_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__mux2_1
X_2825_ _0748_ _0749_ _0791_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__mux2_1
X_2826_ _0750_ _0751_ _0791_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__mux2_1
X_2827_ _0752_ _0753_ _0791_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__mux2_1
X_2828_ _0754_ _0755_ _0791_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__mux2_1
X_2829_ _0756_ _0757_ _0791_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__mux2_1
X_2830_ _0758_ _0759_ _0791_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__mux2_1
X_2831_ _0760_ _0761_ _0791_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__mux2_1
X_2832_ _0762_ _0763_ _0791_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__mux2_1
X_2833_ _0789_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__buf_6
X_2834_ _0765_ _0766_ _0792_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__mux2_1
X_2835_ _0767_ _0768_ _0792_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__mux2_1
X_2836_ _0769_ _0770_ _0792_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__mux2_1
X_2837_ _0771_ _0772_ _0792_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__mux2_1
X_2838_ _0773_ _0774_ _0792_ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__mux2_1
X_2839_ _0775_ _0776_ _0792_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__mux2_1
X_2840_ _0777_ _0778_ _0792_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__mux2_1
X_2841_ _0779_ _0780_ _0792_ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__mux2_1
X_2842_ _0781_ _0782_ _0792_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__mux2_1
X_2843_ _0783_ _0784_ _0792_ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__mux2_1
X_2844_ _0785_ _0786_ _0789_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__mux2_1
X_2845_ _0787_ _0788_ _0789_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__mux2_1
X_2846_ _0723_ _0724_ _0642_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__mux2_1
X_2847_ _0725_ _0726_ _0642_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__mux2_1
X_2848_ _0727_ _0728_ _0642_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__mux2_1
X_2849_ _0729_ _0730_ _0642_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__mux2_1
X_2850_ _0731_ _0732_ _0642_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__mux2_1
X_2851_ _0733_ _0734_ _0642_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__mux2_1
X_2852_ _0735_ _0736_ _0642_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__mux2_1
X_2853_ _0737_ _0738_ _0642_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__mux2_1
X_2854_ _0739_ _0740_ _0642_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__mux2_1
X_2855_ _0641_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__buf_6
X_2856_ _0741_ _0742_ _0793_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__mux2_1
X_2857_ _0744_ _0745_ _0793_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__mux2_1
X_2858_ _0746_ _0747_ _0793_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__mux2_1
X_2859_ _0748_ _0749_ _0793_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__mux2_1
X_2860_ _0750_ _0751_ _0793_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__mux2_1
X_2861_ _0752_ _0753_ _0793_ VSS VSS VDD VDD _0277_ sky130_fd_sc_hd__mux2_1
X_2862_ _0754_ _0755_ _0793_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__mux2_1
X_2863_ _0756_ _0757_ _0793_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__mux2_1
X_2864_ _0758_ _0759_ _0793_ VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__mux2_1
X_2865_ _0760_ _0761_ _0793_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__mux2_1
X_2866_ _0641_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__buf_4
X_2867_ _0762_ _0763_ _0794_ VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__mux2_1
X_2868_ _0765_ _0766_ _0794_ VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__mux2_1
X_2869_ _0767_ _0768_ _0794_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__mux2_1
X_2870_ _0769_ _0770_ _0794_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__mux2_1
X_2871_ _0771_ _0772_ _0794_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__mux2_1
X_2872_ _0773_ _0774_ _0794_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__mux2_1
X_2873_ _0775_ _0776_ _0794_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__mux2_1
X_2874_ _0777_ _0778_ _0794_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__mux2_1
X_2875_ _0779_ _0780_ _0794_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__mux2_1
X_2876_ _0781_ _0782_ _0794_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__mux2_1
X_2877_ _0783_ _0784_ _0641_ VSS VSS VDD VDD _0293_ sky130_fd_sc_hd__mux2_1
X_2878_ _0785_ _0786_ _0641_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__mux2_1
X_2879_ _0787_ _0788_ _0641_ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__mux2_1
X_2880_ _0704_ _0646_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__nor2_4
X_2881_ _0795_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__buf_6
X_2882_ _0723_ _0724_ _0796_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__mux2_1
X_2883_ _0725_ _0726_ _0796_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__mux2_1
X_2884_ _0727_ _0728_ _0796_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__mux2_1
X_2885_ _0729_ _0730_ _0796_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__mux2_1
X_2886_ _0731_ _0732_ _0796_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__mux2_1
X_2887_ _0733_ _0734_ _0796_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__mux2_1
X_2888_ _0735_ _0736_ _0796_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__mux2_1
X_2889_ _0737_ _0738_ _0796_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__mux2_1
X_2890_ _0739_ _0740_ _0796_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__mux2_1
X_2891_ _0741_ _0742_ _0796_ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__mux2_1
X_2892_ _0795_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__buf_6
X_2893_ _0744_ _0745_ _0797_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__mux2_1
X_2894_ _0746_ _0747_ _0797_ VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__mux2_1
X_2895_ _0748_ _0749_ _0797_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__mux2_1
X_2896_ _0750_ _0751_ _0797_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__mux2_1
X_2897_ _0752_ _0753_ _0797_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__mux2_1
X_2898_ _0754_ _0755_ _0797_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__mux2_1
X_2899_ _0756_ _0757_ _0797_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__mux2_1
X_2900_ _0758_ _0759_ _0797_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__mux2_1
X_2901_ _0760_ _0761_ _0797_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__mux2_1
X_2902_ _0762_ _0763_ _0797_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__mux2_1
X_2903_ _0795_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__clkbuf_8
X_2904_ _0765_ _0766_ _0798_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__mux2_1
X_2905_ _0767_ _0768_ _0798_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__mux2_1
X_2906_ _0769_ _0770_ _0798_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__mux2_1
X_2907_ _0771_ _0772_ _0798_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__mux2_1
X_2908_ _0773_ _0774_ _0798_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__mux2_1
X_2909_ _0775_ _0776_ _0798_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__mux2_1
X_2910_ _0777_ _0778_ _0798_ VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__mux2_1
X_2911_ _0779_ _0780_ _0798_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__mux2_1
X_2912_ _0781_ _0782_ _0798_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__mux2_1
X_2913_ _0783_ _0784_ _0798_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__mux2_1
X_2914_ _0785_ _0786_ _0795_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__mux2_1
X_2915_ _0787_ _0788_ _0795_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__mux2_1
X_2916_ _0723_ _0724_ _0703_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__mux2_1
X_2917_ _0725_ _0726_ _0703_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__mux2_1
X_2918_ _0727_ _0728_ _0703_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__mux2_1
X_2919_ _0729_ _0730_ _0703_ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__mux2_1
X_2920_ _0731_ _0732_ _0703_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__mux2_1
X_2921_ _0733_ _0734_ _0703_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__mux2_1
X_2922_ _0735_ _0736_ _0703_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__mux2_1
X_2923_ _0737_ _0738_ _0703_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__mux2_1
X_2924_ _0739_ _0740_ _0703_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__mux2_1
X_2925_ _0702_ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__buf_6
X_2926_ _0741_ _0742_ _0799_ VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__mux2_1
X_2927_ _0744_ _0745_ _0799_ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__mux2_1
X_2928_ _0746_ _0747_ _0799_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__mux2_1
X_2929_ _0748_ _0749_ _0799_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__mux2_1
X_2930_ _0750_ _0751_ _0799_ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__mux2_1
X_2931_ _0752_ _0753_ _0799_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__mux2_1
X_2932_ _0754_ _0755_ _0799_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__mux2_1
X_2933_ _0756_ _0757_ _0799_ VSS VSS VDD VDD _0343_ sky130_fd_sc_hd__mux2_1
X_2934_ _0758_ _0759_ _0799_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__mux2_1
X_2935_ _0760_ _0761_ _0799_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__mux2_1
X_2936_ _0702_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__clkbuf_8
X_2937_ _0762_ _0763_ _0800_ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__mux2_1
X_2938_ _0765_ _0766_ _0800_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__mux2_1
X_2939_ _0767_ _0768_ _0800_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__mux2_1
X_2940_ _0769_ _0770_ _0800_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__mux2_1
X_2941_ _0771_ _0772_ _0800_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__mux2_1
X_2942_ _0773_ _0774_ _0800_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__mux2_1
X_2943_ _0775_ _0776_ _0800_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__mux2_1
X_2944_ _0777_ _0778_ _0800_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__mux2_1
X_2945_ _0779_ _0780_ _0800_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__mux2_1
X_2946_ _0781_ _0782_ _0800_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__mux2_1
X_2947_ _0783_ _0784_ _0702_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__mux2_1
X_2948_ _0785_ _0786_ _0702_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__mux2_1
X_2949_ _0787_ _0788_ _0702_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__mux2_1
X_2950_ _0646_ _0700_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__nor2_4
X_2951_ _0801_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__buf_6
X_2952_ _0723_ _0724_ _0802_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__mux2_1
X_2953_ _0725_ _0726_ _0802_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__mux2_1
X_2954_ _0727_ _0728_ _0802_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__mux2_1
X_2955_ _0729_ _0730_ _0802_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__mux2_1
X_2956_ _0731_ _0732_ _0802_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__mux2_1
X_2957_ _0733_ _0734_ _0802_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__mux2_1
X_2958_ _0735_ _0736_ _0802_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__mux2_1
X_2959_ _0737_ _0738_ _0802_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__mux2_1
X_2960_ _0739_ _0740_ _0802_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__mux2_1
X_2961_ _0741_ _0742_ _0802_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__mux2_1
X_2962_ _0801_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__buf_6
X_2963_ _0744_ _0745_ _0803_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__mux2_1
X_2964_ _0746_ _0747_ _0803_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__mux2_1
X_2965_ _0748_ _0749_ _0803_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__mux2_1
X_2966_ _0750_ _0751_ _0803_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__mux2_1
X_2967_ _0752_ _0753_ _0803_ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__mux2_1
X_2968_ _0754_ _0755_ _0803_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__mux2_1
X_2969_ _0756_ _0757_ _0803_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__mux2_1
X_2970_ _0758_ _0759_ _0803_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__mux2_1
X_2971_ _0760_ _0761_ _0803_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__mux2_1
X_2972_ _0762_ _0763_ _0803_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__mux2_1
X_2973_ _0801_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__buf_6
X_2974_ _0765_ _0766_ _0804_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__mux2_1
X_2975_ _0767_ _0768_ _0804_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__mux2_1
X_2976_ _0769_ _0770_ _0804_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__mux2_1
X_2977_ _0771_ _0772_ _0804_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__mux2_1
X_2978_ _0773_ _0774_ _0804_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__mux2_1
X_2979_ _0775_ _0776_ _0804_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__mux2_1
X_2980_ _0777_ _0778_ _0804_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__mux2_1
X_2981_ _0779_ _0780_ _0804_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__mux2_1
X_2982_ _0781_ _0782_ _0804_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__mux2_1
X_2983_ _0783_ _0784_ _0804_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__mux2_1
X_2984_ _0785_ _0786_ _0801_ VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__mux2_1
X_2985_ _0787_ _0788_ _0801_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__mux2_1
X_2986_ _0723_ _0724_ _0699_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__mux2_1
X_2987_ _0725_ _0726_ _0699_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__mux2_1
X_2988_ _0727_ _0728_ _0699_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__mux2_1
X_2989_ _0729_ _0730_ _0699_ VSS VSS VDD VDD _0425_ sky130_fd_sc_hd__mux2_1
X_2990_ _0731_ _0732_ _0699_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__mux2_1
X_2991_ _0733_ _0734_ _0699_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__mux2_1
X_2992_ _0735_ _0736_ _0699_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__mux2_1
X_2993_ _0737_ _0738_ _0699_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__mux2_1
X_2994_ _0739_ _0740_ _0699_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__mux2_1
X_2995_ _0698_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__buf_6
X_2996_ _0741_ _0742_ _0805_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__mux2_1
X_2997_ _0744_ _0745_ _0805_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__mux2_1
X_2998_ _0746_ _0747_ _0805_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__mux2_1
X_2999_ _0748_ _0749_ _0805_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__mux2_1
X_3000_ _0750_ _0751_ _0805_ VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__mux2_1
X_3001_ _0752_ _0753_ _0805_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__mux2_1
X_3002_ _0754_ _0755_ _0805_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__mux2_1
X_3003_ _0756_ _0757_ _0805_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__mux2_1
X_3004_ _0758_ _0759_ _0805_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__mux2_1
X_3005_ _0760_ _0761_ _0805_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__mux2_1
X_3006_ _0698_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__clkbuf_8
X_3007_ _0762_ _0763_ _0806_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__mux2_1
X_3008_ _0765_ _0766_ _0806_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__mux2_1
X_3009_ _0767_ _0768_ _0806_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__mux2_1
X_3010_ _0769_ _0770_ _0806_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__mux2_1
X_3011_ _0771_ _0772_ _0806_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__mux2_1
X_3012_ _0773_ _0774_ _0806_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__mux2_1
X_3013_ _0775_ _0776_ _0806_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__mux2_1
X_3014_ _0777_ _0778_ _0806_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__mux2_1
X_3015_ _0779_ _0780_ _0806_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__mux2_1
X_3016_ _0781_ _0782_ _0806_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__mux2_1
X_3017_ _0783_ _0784_ _0698_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__mux2_1
X_3018_ _0785_ _0786_ _0698_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__mux2_1
X_3019_ _0787_ _0788_ _0698_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__mux2_1
X_3020_ _0723_ _0724_ _0689_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__mux2_1
X_3021_ _0725_ _0726_ _0689_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__mux2_1
X_3022_ _0727_ _0728_ _0689_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__mux2_1
X_3023_ _0729_ _0730_ _0689_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__mux2_1
X_3024_ _0731_ _0732_ _0689_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__mux2_1
X_3025_ _0733_ _0734_ _0689_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__mux2_1
X_3026_ _0735_ _0736_ _0689_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__mux2_1
X_3027_ _0737_ _0738_ _0689_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__mux2_1
X_3028_ _0739_ _0740_ _0689_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__mux2_1
X_3029_ _0688_ VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__buf_6
X_3030_ _0741_ _0742_ _0807_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__mux2_1
X_3031_ _0744_ _0745_ _0807_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__mux2_1
X_3032_ _0746_ _0747_ _0807_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__mux2_1
X_3033_ _0748_ _0749_ _0807_ VSS VSS VDD VDD _0435_ sky130_fd_sc_hd__mux2_1
X_3034_ _0750_ _0751_ _0807_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__mux2_1
X_3035_ _0752_ _0753_ _0807_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__mux2_1
X_3036_ _0754_ _0755_ _0807_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__mux2_1
X_3037_ _0756_ _0757_ _0807_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__mux2_1
X_3038_ _0758_ _0759_ _0807_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__mux2_1
X_3039_ _0760_ _0761_ _0807_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__mux2_1
X_3040_ _0688_ VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__clkbuf_8
X_3041_ _0762_ _0763_ _0808_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__mux2_1
X_3042_ _0765_ _0766_ _0808_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__mux2_1
X_3043_ _0767_ _0768_ _0808_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__mux2_1
X_3044_ _0769_ _0770_ _0808_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__mux2_1
X_3045_ _0771_ _0772_ _0808_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__mux2_1
X_3046_ _0773_ _0774_ _0808_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__mux2_1
X_3047_ _0775_ _0776_ _0808_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__mux2_1
X_3048_ _0777_ _0778_ _0808_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__mux2_1
X_3049_ _0779_ _0780_ _0808_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__mux2_1
X_3050_ _0781_ _0782_ _0808_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__mux2_1
X_3051_ _0783_ _0784_ _0688_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__mux2_1
X_3052_ _0785_ _0786_ _0688_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__mux2_1
X_3053_ _0787_ _0788_ _0688_ VSS VSS VDD VDD _0456_ sky130_fd_sc_hd__mux2_1
X_3054_ _0723_ _0724_ _0707_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__mux2_1
X_3055_ _0725_ _0726_ _0707_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__mux2_1
X_3056_ _0727_ _0728_ _0707_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__mux2_1
X_3057_ _0729_ _0730_ _0707_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__mux2_1
X_3058_ _0731_ _0732_ _0707_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__mux2_1
X_3059_ _0733_ _0734_ _0707_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__mux2_1
X_3060_ _0735_ _0736_ _0707_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__mux2_1
X_3061_ _0737_ _0738_ _0707_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__mux2_1
X_3062_ _0739_ _0740_ _0707_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__mux2_1
X_3063_ _0706_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__buf_6
X_3064_ _0741_ _0742_ _0809_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__mux2_1
X_3065_ _0744_ _0745_ _0809_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__mux2_1
X_3066_ _0746_ _0747_ _0809_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__mux2_1
X_3067_ _0748_ _0749_ _0809_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__mux2_1
X_3068_ _0750_ _0751_ _0809_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__mux2_1
X_3069_ _0752_ _0753_ _0809_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__mux2_1
X_3070_ _0754_ _0755_ _0809_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__mux2_1
X_3071_ _0756_ _0757_ _0809_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__mux2_1
X_3072_ _0758_ _0759_ _0809_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__mux2_1
X_3073_ _0760_ _0761_ _0809_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__mux2_1
X_3074_ _0706_ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__buf_6
X_3075_ _0762_ _0763_ _0810_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__mux2_1
X_3076_ _0765_ _0766_ _0810_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__mux2_1
X_3077_ _0767_ _0768_ _0810_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__mux2_1
X_3078_ _0769_ _0770_ _0810_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__mux2_1
X_3079_ _0771_ _0772_ _0810_ VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__mux2_1
X_3080_ _0773_ _0774_ _0810_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__mux2_1
X_3081_ _0775_ _0776_ _0810_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__mux2_1
X_3082_ _0777_ _0778_ _0810_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__mux2_1
X_3083_ _0779_ _0780_ _0810_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__mux2_1
X_3084_ _0781_ _0782_ _0810_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__mux2_1
X_3085_ _0783_ _0784_ _0706_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__mux2_1
X_3086_ _0785_ _0786_ _0706_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__mux2_1
X_3087_ _0787_ _0788_ _0706_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__mux2_1
X_3088_ _0723_ net28 _0710_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__mux2_1
X_3089_ _0725_ net29 _0710_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__mux2_1
X_3090_ _0727_ net30 _0710_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__mux2_1
X_3091_ _0729_ net31 _0710_ VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__mux2_1
X_3092_ _0731_ net32 _0710_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__mux2_1
X_3093_ _0733_ net33 _0710_ VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__mux2_1
X_3094_ _0735_ net34 _0710_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__mux2_1
X_3095_ _0737_ net35 _0710_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__mux2_1
X_3096_ _0739_ net37 _0710_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__mux2_1
X_3097_ _0709_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__buf_6
X_3098_ _0741_ net38 _0811_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__mux2_1
X_3099_ _0744_ net39 _0811_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__mux2_1
X_3100_ _0746_ net40 _0811_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__mux2_1
X_3101_ _0748_ net41 _0811_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__mux2_1
X_3102_ _0750_ net42 _0811_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__mux2_1
X_3103_ _0752_ net43 _0811_ VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__mux2_1
X_3104_ _0754_ net44 _0811_ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__mux2_1
X_3105_ _0756_ net45 _0811_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__mux2_1
X_3106_ _0758_ net46 _0811_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__mux2_1
X_3107_ _0760_ net48 _0811_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__mux2_1
X_3108_ _0709_ VSS VSS VDD VDD _0812_ sky130_fd_sc_hd__buf_8
X_3109_ _0762_ net49 _0812_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__mux2_1
X_3110_ _0765_ net50 _0812_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__mux2_1
X_3111_ _0767_ net51 _0812_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__mux2_1
X_3112_ _0769_ net52 _0812_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__mux2_1
X_3113_ _0771_ net53 _0812_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__mux2_1
X_3114_ _0773_ net54 _0812_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__mux2_1
X_3115_ _0775_ net55 _0812_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__mux2_1
X_3116_ _0777_ net56 _0812_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__mux2_1
X_3117_ _0779_ net57 _0812_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__mux2_1
X_3118_ _0781_ net59 _0812_ VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__mux2_1
X_3119_ _0783_ net60 _0709_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__mux2_1
X_3120_ _0785_ net61 _0709_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__mux2_1
X_3121_ _0787_ net62 _0709_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__mux2_1
X_3122_ net3 net28 _0685_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__mux2_1
X_3123_ net14 net29 _0685_ VSS VSS VDD VDD _0059_ sky130_fd_sc_hd__mux2_1
X_3124_ net25 net30 _0685_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__mux2_1
X_3125_ net36 net31 _0685_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__mux2_1
X_3126_ net47 net32 _0685_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__mux2_1
X_3127_ net58 net33 _0685_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__mux2_1
X_3128_ net63 net34 _0685_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__mux2_1
X_3129_ net64 net35 _0685_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__mux2_1
X_3130_ net65 net37 _0685_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__mux2_1
X_3131_ _0684_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__buf_8
X_3132_ net66 net38 _0813_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__mux2_1
X_3133_ net4 net39 _0813_ VSS VSS VDD VDD _0049_ sky130_fd_sc_hd__mux2_1
X_3134_ net5 net40 _0813_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__mux2_1
X_3135_ net6 net41 _0813_ VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__mux2_1
X_3136_ net7 net42 _0813_ VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__mux2_1
X_3137_ net8 net43 _0813_ VSS VSS VDD VDD _0053_ sky130_fd_sc_hd__mux2_1
X_3138_ net9 net44 _0813_ VSS VSS VDD VDD _0054_ sky130_fd_sc_hd__mux2_1
X_3139_ net10 net45 _0813_ VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__mux2_1
X_3140_ net11 net46 _0813_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__mux2_1
X_3141_ net12 net48 _0813_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__mux2_1
X_3142_ _0684_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__buf_6
X_3143_ net13 net49 _0814_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__mux2_1
X_3144_ net15 net50 _0814_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__mux2_1
X_3145_ net16 net51 _0814_ VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__mux2_1
X_3146_ net17 net52 _0814_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__mux2_1
X_3147_ net18 net53 _0814_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__mux2_1
X_3148_ net19 net54 _0814_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__mux2_1
X_3149_ net20 net55 _0814_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__mux2_1
X_3150_ net21 net56 _0814_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__mux2_1
X_3151_ net22 net57 _0814_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__mux2_1
X_3152_ net23 net59 _0814_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__mux2_1
X_3153_ net24 net60 _0684_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__mux2_1
X_3154_ net26 net61 _0684_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__mux2_1
X_3155_ net27 net62 _0684_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__mux2_1
X_3156_ net3 net28 _0692_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__mux2_1
X_3157_ net14 net29 _0692_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__mux2_1
X_3158_ net25 net30 _0692_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__mux2_1
X_3159_ net36 net31 _0692_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__mux2_1
X_3160_ net47 net32 _0692_ VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__mux2_1
X_3161_ net58 net33 _0692_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__mux2_1
X_3162_ net63 net34 _0692_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__mux2_1
X_3163_ net64 net35 _0692_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__mux2_1
X_3164_ net65 net37 _0692_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__mux2_1
X_3165_ _0691_ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__buf_6
X_3166_ net66 net38 _0815_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__mux2_1
X_3167_ net4 net39 _0815_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__mux2_1
X_3168_ net5 net40 _0815_ VSS VSS VDD VDD _0082_ sky130_fd_sc_hd__mux2_1
X_3169_ net6 net41 _0815_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__mux2_1
X_3170_ net7 net42 _0815_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__mux2_1
X_3171_ net8 net43 _0815_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__mux2_1
X_3172_ net9 net44 _0815_ VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__mux2_1
X_3173_ net10 net45 _0815_ VSS VSS VDD VDD _0087_ sky130_fd_sc_hd__mux2_1
X_3174_ net11 net46 _0815_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__mux2_1
X_3175_ net12 net48 _0815_ VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__mux2_1
X_3176_ _0691_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__buf_6
X_3177_ net13 net49 _0816_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__mux2_1
X_3178_ net15 net50 _0816_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__mux2_1
X_3179_ net16 net51 _0816_ VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__mux2_1
X_3180_ net17 net52 _0816_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__mux2_1
X_3181_ net18 net53 _0816_ VSS VSS VDD VDD _0095_ sky130_fd_sc_hd__mux2_1
X_3182_ net19 net54 _0816_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__mux2_1
X_3183_ net20 net55 _0816_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__mux2_1
X_3184_ net21 net56 _0816_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__mux2_1
X_3185_ net22 net57 _0816_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__mux2_1
X_3186_ net23 net59 _0816_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__mux2_1
X_3187_ net24 net60 _0691_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__mux2_1
X_3188_ net26 net61 _0691_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__mux2_1
X_3189_ net27 net62 _0691_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__mux2_1
X_3190_ net3 net28 _0681_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__mux2_1
X_3191_ net14 net29 _0681_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__mux2_1
X_3192_ net25 net30 _0681_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__mux2_1
X_3193_ net36 net31 _0681_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__mux2_1
X_3194_ net47 net32 _0681_ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__mux2_1
X_3195_ net58 net33 _0681_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__mux2_1
X_3196_ net63 net34 _0681_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__mux2_1
X_3197_ net64 net35 _0681_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__mux2_1
X_3198_ net65 net37 _0681_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__mux2_1
X_3199_ _0680_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__buf_6
X_3200_ net66 net38 _0817_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__mux2_1
X_3201_ net4 net39 _0817_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__mux2_1
X_3202_ net5 net40 _0817_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__mux2_1
X_3203_ net6 net41 _0817_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__mux2_1
X_3204_ net7 net42 _0817_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__mux2_1
X_3205_ net8 net43 _0817_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__mux2_1
X_3206_ net9 net44 _0817_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__mux2_1
X_3207_ net10 net45 _0817_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__mux2_1
X_3208_ net11 net46 _0817_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__mux2_1
X_3209_ net12 net48 _0817_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__mux2_1
X_3210_ _0680_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__buf_8
X_3211_ net13 net49 _0818_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__mux2_1
X_3212_ net15 net50 _0818_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__mux2_1
X_3213_ net16 net51 _0818_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__mux2_1
X_3214_ net17 net52 _0818_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__mux2_1
X_3215_ net18 net53 _0818_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__mux2_1
X_3216_ net19 net54 _0818_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__mux2_1
X_3217_ net20 net55 _0818_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__mux2_1
X_3218_ net21 net56 _0818_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__mux2_1
X_3219_ net22 net57 _0818_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__mux2_1
X_3220_ net23 net59 _0818_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__mux2_1
X_3221_ net24 net60 _0680_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__mux2_1
X_3222_ net26 net61 _0680_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__mux2_1
X_3223_ net27 net62 _0680_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__mux2_1
X_3224_ net3 net28 _0677_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__mux2_1
X_3225_ net14 net29 _0677_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__mux2_1
X_3226_ net25 net30 _0677_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__mux2_1
X_3227_ net36 net31 _0677_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__mux2_1
X_3228_ net47 net32 _0677_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__mux2_1
X_3229_ net58 net33 _0677_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__mux2_1
X_3230_ net63 net34 _0677_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__mux2_1
X_3231_ net64 net35 _0677_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__mux2_1
X_3232_ net65 net37 _0677_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__mux2_1
X_3233_ _0676_ VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__buf_8
X_3234_ net66 net38 _0819_ VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__mux2_1
X_3235_ net4 net39 _0819_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__mux2_1
X_3236_ net5 net40 _0819_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__mux2_1
X_3237_ net6 net41 _0819_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__mux2_1
X_3238_ net7 net42 _0819_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__mux2_1
X_3239_ net8 net43 _0819_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__mux2_1
X_3240_ net9 net44 _0819_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__mux2_1
X_3241_ net10 net45 _0819_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__mux2_1
X_3242_ net11 net46 _0819_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__mux2_1
X_3243_ net12 net48 _0819_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__mux2_1
X_3244_ _0676_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__buf_8
X_3245_ net13 net49 _0820_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__mux2_1
X_3246_ net15 net50 _0820_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__mux2_1
X_3247_ net16 net51 _0820_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__mux2_1
X_3248_ net17 net52 _0820_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__mux2_1
X_3249_ net18 net53 _0820_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__mux2_1
X_3250_ net19 net54 _0820_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__mux2_1
X_3251_ net20 net55 _0820_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__mux2_1
X_3252_ net21 net56 _0820_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__mux2_1
X_3253_ net22 net57 _0820_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__mux2_1
X_3254_ net23 net59 _0820_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__mux2_1
X_3255_ net24 net60 _0676_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__mux2_1
X_3256_ net26 net61 _0676_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__mux2_1
X_3257_ net27 net62 _0676_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__mux2_1
X_3258_ net3 net28 _0671_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__mux2_1
X_3259_ net14 net29 _0671_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__mux2_1
X_3260_ net25 net30 _0671_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__mux2_1
X_3261_ net36 net31 _0671_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__mux2_1
X_3262_ net47 net32 _0671_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__mux2_1
X_3263_ net58 net33 _0671_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__mux2_1
X_3264_ net63 net34 _0671_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__mux2_1
X_3265_ net64 net35 _0671_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__mux2_1
X_3266_ net65 net37 _0671_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__mux2_1
X_3267_ _0670_ VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__buf_6
X_3268_ net66 net38 _0821_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__mux2_1
X_3269_ net4 net39 _0821_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__mux2_1
X_3270_ net5 net40 _0821_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__mux2_1
X_3271_ net6 net41 _0821_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__mux2_1
X_3272_ net7 net42 _0821_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__mux2_1
X_3273_ net8 net43 _0821_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__mux2_1
X_3274_ net9 net44 _0821_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__mux2_1
X_3275_ net10 net45 _0821_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__mux2_1
X_3276_ net11 net46 _0821_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__mux2_1
X_3277_ net12 net48 _0821_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__mux2_1
X_3278_ _0670_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__buf_8
X_3279_ net13 net49 _0822_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__mux2_1
X_3280_ net15 net50 _0822_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__mux2_1
X_3281_ net16 net51 _0822_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__mux2_1
X_3282_ net17 net52 _0822_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__mux2_1
X_3283_ net18 net53 _0822_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__mux2_1
X_3284_ net19 net54 _0822_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__mux2_1
X_3285_ net20 net55 _0822_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__mux2_1
X_3286_ net21 net56 _0822_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__mux2_1
X_3287_ net22 net57 _0822_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__mux2_1
X_3288_ net23 net59 _0822_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__mux2_1
X_3289_ net24 net60 _0670_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__mux2_1
X_3290_ net26 net61 _0670_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__mux2_1
X_3291_ net27 net62 _0670_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__mux2_1
X_3292_ _0724_ net3 _0663_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__mux2_1
X_3293_ _0726_ net14 _0663_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__mux2_1
X_3294_ _0728_ net25 _0663_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__mux2_1
X_3295_ _0730_ net36 _0663_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__mux2_1
X_3296_ _0732_ net47 _0663_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__mux2_1
X_3297_ _0734_ net58 _0663_ VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__mux2_1
X_3298_ _0736_ net63 _0663_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__mux2_1
X_3299_ _0738_ net64 _0663_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__mux2_1
X_3300_ _0740_ net65 _0663_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__mux2_1
X_3301_ _0662_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__buf_6
X_3302_ _0742_ net66 _0823_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__mux2_1
X_3303_ _0745_ net4 _0823_ VSS VSS VDD VDD _0209_ sky130_fd_sc_hd__mux2_1
X_3304_ _0747_ net5 _0823_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__mux2_1
X_3305_ _0749_ net6 _0823_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__mux2_1
X_3306_ _0751_ net7 _0823_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__mux2_1
X_3307_ _0753_ net8 _0823_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__mux2_1
X_3308_ _0755_ net9 _0823_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__mux2_1
X_3309_ _0757_ net10 _0823_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__mux2_1
X_3310_ _0759_ net11 _0823_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__mux2_1
X_3311_ _0761_ net12 _0823_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__mux2_1
X_3312_ _0662_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__buf_6
X_3313_ _0763_ net13 _0824_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__mux2_1
X_3314_ _0766_ net15 _0824_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__mux2_1
X_3315_ _0768_ net16 _0824_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__mux2_1
X_3316_ _0770_ net17 _0824_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__mux2_1
X_3317_ _0772_ net18 _0824_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__mux2_1
X_3318_ _0774_ net19 _0824_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__mux2_1
X_3319_ _0776_ net20 _0824_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__mux2_1
X_3320_ _0778_ net21 _0824_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__mux2_1
X_3321_ _0780_ net22 _0824_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__mux2_1
X_3322_ _0782_ net23 _0824_ VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__mux2_1
X_3323_ _0784_ net24 _0662_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__mux2_1
X_3324_ _0786_ net26 _0662_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__mux2_1
X_3325_ _0788_ net27 _0662_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__mux2_1
X_3326_ _2539_ VSS VSS VDD VDD _2493_ sky130_fd_sc_hd__inv_1
X_3327_ _0720_ VSS VSS VDD VDD _2534_ sky130_fd_sc_hd__buf_8
X_3328_ _0609_ _2523_ VSS VSS VDD VDD _2540_ sky130_fd_sc_hd__xor2_1
X_3329_ _2544_ VSS VSS VDD VDD _2497_ sky130_fd_sc_hd__inv_1
X_3330_ net73 VSS VSS VDD VDD _2546_ sky130_fd_sc_hd__inv_1
X_3331_ net74 VSS VSS VDD VDD _2547_ sky130_fd_sc_hd__inv_2
X_3332_ _2545_ VSS VSS VDD VDD _2567_ sky130_fd_sc_hd__inv_1
X_3333_ _0609_ _0607_ _2552_ VSS VSS VDD VDD _2511_ sky130_fd_sc_hd__nand3_1
X_3334_ _0613_ _2523_ VSS VSS VDD VDD _2529_ sky130_fd_sc_hd__xor2_1
X_3335_ _0714_ VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__buf_4
X_3336_ _0825_ VSS VSS VDD VDD _2535_ sky130_fd_sc_hd__buf_6
X_3337_ _2531_ VSS VSS VDD VDD _2494_ sky130_fd_sc_hd__inv_2
X_3338_ _0609_ _2521_ _2541_ VSS VSS VDD VDD _2554_ sky130_fd_sc_hd__a21o_1
X_3339_ rd_ptr\[2\] VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__buf_2
X_3340_ _0826_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__buf_6
X_3341_ _0827_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__buf_4
X_3342_ _0828_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__buf_6
X_3343_ _0722_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__buf_8
X_3344_ _0830_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__buf_8
X_3345_ mem\[5\]\[0\] mem\[7\]\[0\] _0831_ VSS VSS VDD VDD
+ _0832_ sky130_fd_sc_hd__mux2i_1
X_3346_ _0722_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__buf_8
X_3347_ mem\[4\]\[0\] mem\[6\]\[0\] _0833_ VSS VSS VDD VDD
+ _0834_ sky130_fd_sc_hd__mux2i_1
X_3348_ _0722_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__buf_6
X_3349_ mem\[13\]\[0\] mem\[15\]\[0\] _0835_ VSS VSS VDD VDD
+ _0836_ sky130_fd_sc_hd__mux2i_2
X_3350_ _0830_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__buf_16
X_3351_ mem\[12\]\[0\] mem\[14\]\[0\] _0837_ VSS VSS VDD VDD
+ _0838_ sky130_fd_sc_hd__mux2i_2
X_3352_ rd_ptr\[0\] VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__buf_6
X_3353_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__inv_4
X_3354_ rd_ptr\[3\] VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__clkbuf_4
X_3355_ _0841_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__buf_6
X_3356_ _0832_ _0834_ _0836_ _0838_ _0840_ _0842_ VSS VSS
+ VDD VDD _0843_ sky130_fd_sc_hd__mux4_1
X_3357_ _0841_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__buf_8
X_3358_ _0840_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__buf_6
X_3359_ _0833_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__buf_6
X_3360_ mem\[8\]\[0\] mem\[10\]\[0\] _0846_ VSS VSS VDD VDD
+ _0847_ sky130_fd_sc_hd__mux2i_1
X_3361_ _0845_ _0847_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__nand2_1
X_3362_ _0839_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__buf_6
X_3363_ _0849_ VSS VSS VDD VDD _0850_ sky130_fd_sc_hd__clkbuf_8
X_3364_ _0837_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__buf_8
X_3365_ mem\[9\]\[0\] mem\[11\]\[0\] _0851_ VSS VSS VDD VDD
+ _0852_ sky130_fd_sc_hd__mux2i_1
X_3366_ _0850_ _0852_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__nand2_1
X_3367_ _0839_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__clkbuf_8
X_3368_ _0835_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__buf_6
X_3369_ mem\[1\]\[0\] mem\[3\]\[0\] _0855_ VSS VSS VDD VDD
+ _0856_ sky130_fd_sc_hd__mux2i_2
X_3370_ mem\[0\]\[0\] mem\[2\]\[0\] _0835_ VSS VSS VDD VDD
+ _0857_ sky130_fd_sc_hd__mux2_1
X_3371_ _0849_ _0857_ VSS VSS VDD VDD _0858_ sky130_fd_sc_hd__nor2_1
X_3372_ _0854_ _0856_ _0858_ _0842_ VSS VSS VDD VDD _0859_
+ sky130_fd_sc_hd__a211oi_1
X_3373_ _0826_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__buf_4
X_3374_ _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__buf_8
X_3375_ _0844_ _0848_ _0853_ _0859_ _0861_ VSS VSS VDD VDD
+ _0862_ sky130_fd_sc_hd__a311oi_1
X_3376_ _0829_ _0843_ _0862_ _0825_ VSS VSS VDD VDD _0863_
+ sky130_fd_sc_hd__a211oi_2
X_3377_ net78 _0825_ _0863_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__a21o_1
X_3378_ _0825_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__buf_6
X_3379_ _0860_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__buf_6
X_3380_ _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__clkbuf_8
X_3381_ _0844_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__buf_6
X_3382_ _0854_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__buf_6
X_3383_ _0833_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__buf_6
X_3384_ mem\[4\]\[10\] mem\[6\]\[10\] _0869_ VSS VSS VDD VDD
+ _0870_ sky130_fd_sc_hd__mux2_1
X_3385_ _0849_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__buf_6
X_3386_ _0831_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__buf_8
X_3387_ mem\[5\]\[10\] mem\[7\]\[10\] _0872_ VSS VSS VDD VDD
+ _0873_ sky130_fd_sc_hd__mux2i_1
X_3388_ _0871_ _0873_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__nand2_1
X_3389_ _0868_ _0870_ _0874_ VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__o21ai_0
X_3390_ _0854_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__buf_4
X_3391_ mem\[12\]\[10\] mem\[14\]\[10\] _0831_ VSS VSS VDD
+ VDD _0877_ sky130_fd_sc_hd__mux2_1
X_3392_ _0854_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__clkbuf_8
X_3393_ _0855_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__buf_8
X_3394_ mem\[13\]\[10\] mem\[15\]\[10\] _0879_ VSS VSS VDD
+ VDD _0880_ sky130_fd_sc_hd__mux2i_1
X_3395_ _0878_ _0880_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__nand2_1
X_3396_ _0842_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__clkbuf_8
X_3397_ _0876_ _0877_ _0881_ _0882_ VSS VSS VDD VDD _0883_
+ sky130_fd_sc_hd__o211ai_1
X_3398_ _0867_ _0875_ _0883_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__o21ai_0
X_3399_ _0830_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__buf_8
X_3400_ mem\[0\]\[10\] mem\[2\]\[10\] _0885_ VSS VSS VDD VDD
+ _0886_ sky130_fd_sc_hd__mux2i_2
X_3401_ _0835_ VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__buf_6
X_3402_ mem\[1\]\[10\] mem\[3\]\[10\] _0887_ VSS VSS VDD VDD
+ _0888_ sky130_fd_sc_hd__mux2i_1
X_3403_ mem\[8\]\[10\] mem\[10\]\[10\] _0837_ VSS VSS VDD
+ VDD _0889_ sky130_fd_sc_hd__mux2i_1
X_3404_ _0835_ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__buf_8
X_3405_ mem\[9\]\[10\] mem\[11\]\[10\] _0890_ VSS VSS VDD
+ VDD _0891_ sky130_fd_sc_hd__mux2i_1
X_3406_ _0886_ _0888_ _0889_ _0891_ _0849_ _0844_ VSS VSS
+ VDD VDD _0892_ sky130_fd_sc_hd__mux4_1
X_3407_ _0829_ _0892_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__nor2_1
X_3408_ _0866_ _0884_ _0893_ VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__a21oi_1
X_3409_ net79 _2535_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__nand2_1
X_3410_ _0864_ _0894_ _0895_ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__o21ai_0
X_3411_ _0826_ VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__inv_4
X_3412_ _0896_ VSS VSS VDD VDD _0897_ sky130_fd_sc_hd__buf_4
X_3413_ _0897_ VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__buf_4
X_3414_ mem\[0\]\[11\] mem\[2\]\[11\] _0722_ VSS VSS VDD VDD
+ _0899_ sky130_fd_sc_hd__mux2_1
X_3415_ mem\[1\]\[11\] mem\[3\]\[11\] _0872_ VSS VSS VDD VDD
+ _0900_ sky130_fd_sc_hd__mux2i_2
X_3416_ _0871_ _0900_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__nand2_1
X_3417_ _0868_ _0899_ _0901_ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__o21ai_0
X_3418_ _0845_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__buf_4
X_3419_ mem\[8\]\[11\] mem\[10\]\[11\] _0851_ VSS VSS VDD
+ VDD _0904_ sky130_fd_sc_hd__mux2i_1
X_3420_ _0903_ _0904_ VSS VSS VDD VDD _0905_ sky130_fd_sc_hd__nand2_1
X_3421_ _0854_ VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__buf_6
X_3422_ _0855_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__buf_6
X_3423_ mem\[9\]\[11\] mem\[11\]\[11\] _0907_ VSS VSS VDD
+ VDD _0908_ sky130_fd_sc_hd__mux2i_1
X_3424_ _0906_ _0908_ VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__nand2_1
X_3425_ _0882_ _0905_ _0909_ VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__nand3_1
X_3426_ _0867_ _0902_ _0910_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__o21ai_0
X_3427_ mem\[5\]\[11\] mem\[7\]\[11\] _0890_ VSS VSS VDD VDD
+ _0912_ sky130_fd_sc_hd__mux2i_1
X_3428_ mem\[4\]\[11\] mem\[6\]\[11\] _0831_ VSS VSS VDD VDD
+ _0913_ sky130_fd_sc_hd__mux2i_2
X_3429_ _0830_ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__buf_16
X_3430_ mem\[13\]\[11\] mem\[15\]\[11\] _0914_ VSS VSS VDD
+ VDD _0915_ sky130_fd_sc_hd__mux2i_1
X_3431_ _0835_ VSS VSS VDD VDD _0916_ sky130_fd_sc_hd__buf_8
X_3432_ mem\[12\]\[11\] mem\[14\]\[11\] _0916_ VSS VSS VDD
+ VDD _0917_ sky130_fd_sc_hd__mux2i_1
X_3433_ _0912_ _0913_ _0915_ _0917_ _0845_ _0844_ VSS VSS
+ VDD VDD _0918_ sky130_fd_sc_hd__mux4_1
X_3434_ _0898_ _0918_ VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__nor2_1
X_3435_ _0898_ _0911_ _0919_ VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__a21oi_1
X_3436_ net80 _2535_ VSS VSS VDD VDD _0921_ sky130_fd_sc_hd__nand2_1
X_3437_ _0864_ _0920_ _0921_ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__o21ai_0
X_3438_ mem\[4\]\[12\] mem\[6\]\[12\] _0869_ VSS VSS VDD VDD
+ _0922_ sky130_fd_sc_hd__mux2_1
X_3439_ mem\[5\]\[12\] mem\[7\]\[12\] _0872_ VSS VSS VDD VDD
+ _0923_ sky130_fd_sc_hd__mux2i_1
X_3440_ _0871_ _0923_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__nand2_1
X_3441_ _0868_ _0922_ _0924_ VSS VSS VDD VDD _0925_ sky130_fd_sc_hd__o21ai_0
X_3442_ _0722_ VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__buf_6
X_3443_ mem\[12\]\[12\] mem\[14\]\[12\] _0926_ VSS VSS VDD
+ VDD _0927_ sky130_fd_sc_hd__mux2_1
X_3444_ mem\[13\]\[12\] mem\[15\]\[12\] _0879_ VSS VSS VDD
+ VDD _0928_ sky130_fd_sc_hd__mux2i_1
X_3445_ _0878_ _0928_ VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__nand2_1
X_3446_ _0842_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__clkbuf_8
X_3447_ _0876_ _0927_ _0929_ _0930_ VSS VSS VDD VDD _0931_
+ sky130_fd_sc_hd__o211ai_1
X_3448_ _0867_ _0925_ _0931_ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__o21ai_0
X_3449_ mem\[0\]\[12\] mem\[2\]\[12\] _0885_ VSS VSS VDD VDD
+ _0933_ sky130_fd_sc_hd__mux2i_2
X_3450_ mem\[1\]\[12\] mem\[3\]\[12\] _0887_ VSS VSS VDD VDD
+ _0934_ sky130_fd_sc_hd__mux2i_1
X_3451_ mem\[8\]\[12\] mem\[10\]\[12\] _0837_ VSS VSS VDD
+ VDD _0935_ sky130_fd_sc_hd__mux2i_1
X_3452_ mem\[9\]\[12\] mem\[11\]\[12\] _0890_ VSS VSS VDD
+ VDD _0936_ sky130_fd_sc_hd__mux2i_1
X_3453_ _0933_ _0934_ _0935_ _0936_ _0849_ _0844_ VSS VSS
+ VDD VDD _0937_ sky130_fd_sc_hd__mux4_1
X_3454_ _0829_ _0937_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__nor2_1
X_3455_ _0866_ _0932_ _0938_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__a21oi_1
X_3456_ net81 _2535_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__nand2_1
X_3457_ _0864_ _0939_ _0940_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__o21ai_0
X_3458_ mem\[4\]\[13\] mem\[6\]\[13\] _0869_ VSS VSS VDD VDD
+ _0941_ sky130_fd_sc_hd__mux2_1
X_3459_ mem\[5\]\[13\] mem\[7\]\[13\] _0872_ VSS VSS VDD VDD
+ _0942_ sky130_fd_sc_hd__mux2i_1
X_3460_ _0871_ _0942_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__nand2_1
X_3461_ _0868_ _0941_ _0943_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__o21ai_0
X_3462_ mem\[12\]\[13\] mem\[14\]\[13\] _0926_ VSS VSS VDD
+ VDD _0945_ sky130_fd_sc_hd__mux2_1
X_3463_ mem\[13\]\[13\] mem\[15\]\[13\] _0879_ VSS VSS VDD
+ VDD _0946_ sky130_fd_sc_hd__mux2i_1
X_3464_ _0878_ _0946_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__nand2_1
X_3465_ _0876_ _0945_ _0947_ _0930_ VSS VSS VDD VDD _0948_
+ sky130_fd_sc_hd__o211ai_1
X_3466_ _0867_ _0944_ _0948_ VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__o21ai_0
X_3467_ mem\[0\]\[13\] mem\[2\]\[13\] _0885_ VSS VSS VDD VDD
+ _0950_ sky130_fd_sc_hd__mux2i_2
X_3468_ mem\[1\]\[13\] mem\[3\]\[13\] _0887_ VSS VSS VDD VDD
+ _0951_ sky130_fd_sc_hd__mux2i_1
X_3469_ _0830_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__clkbuf_16
X_3470_ mem\[8\]\[13\] mem\[10\]\[13\] _0952_ VSS VSS VDD
+ VDD _0953_ sky130_fd_sc_hd__mux2i_1
X_3471_ _0830_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__clkbuf_16
X_3472_ mem\[9\]\[13\] mem\[11\]\[13\] _0954_ VSS VSS VDD
+ VDD _0955_ sky130_fd_sc_hd__mux2i_1
X_3473_ _0950_ _0951_ _0953_ _0955_ _0849_ _0844_ VSS VSS
+ VDD VDD _0956_ sky130_fd_sc_hd__mux4_1
X_3474_ _0829_ _0956_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__nor2_1
X_3475_ _0866_ _0949_ _0957_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__a21oi_1
X_3476_ net82 _2535_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__nand2_1
X_3477_ _0864_ _0958_ _0959_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__o21ai_0
X_3478_ mem\[4\]\[14\] mem\[6\]\[14\] _0869_ VSS VSS VDD VDD
+ _0960_ sky130_fd_sc_hd__mux2_1
X_3479_ mem\[5\]\[14\] mem\[7\]\[14\] _0872_ VSS VSS VDD VDD
+ _0961_ sky130_fd_sc_hd__mux2i_1
X_3480_ _0871_ _0961_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__nand2_1
X_3481_ _0868_ _0960_ _0962_ VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__o21ai_0
X_3482_ mem\[12\]\[14\] mem\[14\]\[14\] _0926_ VSS VSS VDD
+ VDD _0964_ sky130_fd_sc_hd__mux2_1
X_3483_ mem\[13\]\[14\] mem\[15\]\[14\] _0879_ VSS VSS VDD
+ VDD _0965_ sky130_fd_sc_hd__mux2i_1
X_3484_ _0878_ _0965_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__nand2_1
X_3485_ _0876_ _0964_ _0966_ _0930_ VSS VSS VDD VDD _0967_
+ sky130_fd_sc_hd__o211ai_1
X_3486_ _0867_ _0963_ _0967_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__o21ai_0
X_3487_ mem\[0\]\[14\] mem\[2\]\[14\] _0885_ VSS VSS VDD VDD
+ _0969_ sky130_fd_sc_hd__mux2i_2
X_3488_ mem\[1\]\[14\] mem\[3\]\[14\] _0887_ VSS VSS VDD VDD
+ _0970_ sky130_fd_sc_hd__mux2i_1
X_3489_ mem\[8\]\[14\] mem\[10\]\[14\] _0952_ VSS VSS VDD
+ VDD _0971_ sky130_fd_sc_hd__mux2i_2
X_3490_ mem\[9\]\[14\] mem\[11\]\[14\] _0954_ VSS VSS VDD
+ VDD _0972_ sky130_fd_sc_hd__mux2i_2
X_3491_ _0969_ _0970_ _0971_ _0972_ _0849_ _0844_ VSS VSS
+ VDD VDD _0973_ sky130_fd_sc_hd__mux4_1
X_3492_ _0829_ _0973_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__nor2_1
X_3493_ _0866_ _0968_ _0974_ VSS VSS VDD VDD _0975_ sky130_fd_sc_hd__a21oi_1
X_3494_ net83 _2535_ VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__nand2_1
X_3495_ _0864_ _0975_ _0976_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__o21ai_0
X_3496_ mem\[0\]\[15\] mem\[2\]\[15\] _0833_ VSS VSS VDD VDD
+ _0977_ sky130_fd_sc_hd__mux2_1
X_3497_ _0849_ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__clkbuf_8
X_3498_ mem\[1\]\[15\] mem\[3\]\[15\] _0846_ VSS VSS VDD VDD
+ _0979_ sky130_fd_sc_hd__mux2i_1
X_3499_ _0978_ _0979_ VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__nand2_1
X_3500_ _0868_ _0977_ _0980_ VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__o21ai_1
X_3501_ mem\[8\]\[15\] mem\[10\]\[15\] _0907_ VSS VSS VDD
+ VDD _0982_ sky130_fd_sc_hd__mux2i_1
X_3502_ _0903_ _0982_ VSS VSS VDD VDD _0983_ sky130_fd_sc_hd__nand2_1
X_3503_ mem\[9\]\[15\] mem\[11\]\[15\] _0907_ VSS VSS VDD
+ VDD _0984_ sky130_fd_sc_hd__mux2i_1
X_3504_ _0876_ _0984_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__nand2_1
X_3505_ _0882_ _0983_ _0985_ VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__nand3_1
X_3506_ _0867_ _0981_ _0986_ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__o21ai_0
X_3507_ mem\[5\]\[15\] mem\[7\]\[15\] _0890_ VSS VSS VDD VDD
+ _0988_ sky130_fd_sc_hd__mux2i_1
X_3508_ mem\[4\]\[15\] mem\[6\]\[15\] _0914_ VSS VSS VDD VDD
+ _0989_ sky130_fd_sc_hd__mux2i_1
X_3509_ mem\[13\]\[15\] mem\[15\]\[15\] _0952_ VSS VSS VDD
+ VDD _0990_ sky130_fd_sc_hd__mux2i_1
X_3510_ mem\[12\]\[15\] mem\[14\]\[15\] _0916_ VSS VSS VDD
+ VDD _0991_ sky130_fd_sc_hd__mux2i_1
X_3511_ _0841_ VSS VSS VDD VDD _0992_ sky130_fd_sc_hd__buf_8
X_3512_ _0988_ _0989_ _0990_ _0991_ _0845_ _0992_ VSS VSS
+ VDD VDD _0993_ sky130_fd_sc_hd__mux4_1
X_3513_ _0898_ _0993_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__nor2_1
X_3514_ _0898_ _0987_ _0994_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__a21oi_1
X_3515_ net84 _2535_ VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__nand2_1
X_3516_ _0864_ _0995_ _0996_ VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__o21ai_0
X_3517_ _0839_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__buf_6
X_3518_ mem\[4\]\[16\] mem\[6\]\[16\] _0869_ VSS VSS VDD VDD
+ _0998_ sky130_fd_sc_hd__mux2_1
X_3519_ mem\[5\]\[16\] mem\[7\]\[16\] _0872_ VSS VSS VDD VDD
+ _0999_ sky130_fd_sc_hd__mux2i_1
X_3520_ _0978_ _0999_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__nand2_1
X_3521_ _0997_ _0998_ _1000_ VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__o21ai_0
X_3522_ _0854_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__buf_4
X_3523_ mem\[12\]\[16\] mem\[14\]\[16\] _0926_ VSS VSS VDD
+ VDD _1003_ sky130_fd_sc_hd__mux2_1
X_3524_ mem\[13\]\[16\] mem\[15\]\[16\] _0879_ VSS VSS VDD
+ VDD _1004_ sky130_fd_sc_hd__mux2i_1
X_3525_ _0878_ _1004_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__nand2_1
X_3526_ _1002_ _1003_ _1005_ _0930_ VSS VSS VDD VDD _1006_
+ sky130_fd_sc_hd__o211ai_1
X_3527_ _0867_ _1001_ _1006_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__o21ai_0
X_3528_ mem\[0\]\[16\] mem\[2\]\[16\] _0885_ VSS VSS VDD VDD
+ _1008_ sky130_fd_sc_hd__mux2i_1
X_3529_ mem\[1\]\[16\] mem\[3\]\[16\] _0887_ VSS VSS VDD VDD
+ _1009_ sky130_fd_sc_hd__mux2i_1
X_3530_ mem\[8\]\[16\] mem\[10\]\[16\] _0952_ VSS VSS VDD
+ VDD _1010_ sky130_fd_sc_hd__mux2i_2
X_3531_ mem\[9\]\[16\] mem\[11\]\[16\] _0954_ VSS VSS VDD
+ VDD _1011_ sky130_fd_sc_hd__mux2i_4
X_3532_ _0839_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__buf_6
X_3533_ _1008_ _1009_ _1010_ _1011_ _1012_ _0992_ VSS VSS
+ VDD VDD _1013_ sky130_fd_sc_hd__mux4_1
X_3534_ _0829_ _1013_ VSS VSS VDD VDD _1014_ sky130_fd_sc_hd__nor2_1
X_3535_ _0866_ _1007_ _1014_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__a21oi_1
X_3536_ net85 _2535_ VSS VSS VDD VDD _1016_ sky130_fd_sc_hd__nand2_1
X_3537_ _0864_ _1015_ _1016_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__o21ai_0
X_3538_ mem\[4\]\[17\] mem\[6\]\[17\] _0869_ VSS VSS VDD VDD
+ _1017_ sky130_fd_sc_hd__mux2_1
X_3539_ mem\[5\]\[17\] mem\[7\]\[17\] _0872_ VSS VSS VDD VDD
+ _1018_ sky130_fd_sc_hd__mux2i_1
X_3540_ _0978_ _1018_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__nand2_1
X_3541_ _0997_ _1017_ _1019_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__o21ai_0
X_3542_ mem\[12\]\[17\] mem\[14\]\[17\] _0926_ VSS VSS VDD
+ VDD _1021_ sky130_fd_sc_hd__mux2_1
X_3543_ mem\[13\]\[17\] mem\[15\]\[17\] _0879_ VSS VSS VDD
+ VDD _1022_ sky130_fd_sc_hd__mux2i_1
X_3544_ _0878_ _1022_ VSS VSS VDD VDD _1023_ sky130_fd_sc_hd__nand2_1
X_3545_ _1002_ _1021_ _1023_ _0930_ VSS VSS VDD VDD _1024_
+ sky130_fd_sc_hd__o211ai_1
X_3546_ _0867_ _1020_ _1024_ VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__o21ai_0
X_3547_ _0828_ VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__buf_4
X_3548_ mem\[0\]\[17\] mem\[2\]\[17\] _0885_ VSS VSS VDD VDD
+ _1027_ sky130_fd_sc_hd__mux2i_2
X_3549_ mem\[1\]\[17\] mem\[3\]\[17\] _0887_ VSS VSS VDD VDD
+ _1028_ sky130_fd_sc_hd__mux2i_1
X_3550_ mem\[8\]\[17\] mem\[10\]\[17\] _0952_ VSS VSS VDD
+ VDD _1029_ sky130_fd_sc_hd__mux2i_2
X_3551_ mem\[9\]\[17\] mem\[11\]\[17\] _0954_ VSS VSS VDD
+ VDD _1030_ sky130_fd_sc_hd__mux2i_2
X_3552_ _1027_ _1028_ _1029_ _1030_ _1012_ _0992_ VSS VSS
+ VDD VDD _1031_ sky130_fd_sc_hd__mux4_1
X_3553_ _1026_ _1031_ VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__nor2_1
X_3554_ _0866_ _1025_ _1032_ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__a21oi_1
X_3555_ net86 _2535_ VSS VSS VDD VDD _1034_ sky130_fd_sc_hd__nand2_1
X_3556_ _0864_ _1033_ _1034_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__o21ai_0
X_3557_ net221 VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__buf_6
X_3558_ mem\[4\]\[18\] mem\[6\]\[18\] _0869_ VSS VSS VDD VDD
+ _1036_ sky130_fd_sc_hd__mux2_1
X_3559_ mem\[5\]\[18\] mem\[7\]\[18\] _0872_ VSS VSS VDD VDD
+ _1037_ sky130_fd_sc_hd__mux2i_1
X_3560_ _0978_ _1037_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__nand2_1
X_3561_ _0997_ _1036_ _1038_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__o21ai_0
X_3562_ mem\[12\]\[18\] mem\[14\]\[18\] _0926_ VSS VSS VDD
+ VDD _1040_ sky130_fd_sc_hd__mux2_1
X_3563_ _0855_ VSS VSS VDD VDD _1041_ sky130_fd_sc_hd__buf_8
X_3564_ mem\[13\]\[18\] mem\[15\]\[18\] _1041_ VSS VSS VDD
+ VDD _1042_ sky130_fd_sc_hd__mux2i_1
X_3565_ _0878_ _1042_ VSS VSS VDD VDD _1043_ sky130_fd_sc_hd__nand2_1
X_3566_ _1002_ _1040_ _1043_ _0930_ VSS VSS VDD VDD _1044_
+ sky130_fd_sc_hd__o211ai_1
X_3567_ _0867_ _1039_ _1044_ VSS VSS VDD VDD _1045_ sky130_fd_sc_hd__o21ai_0
X_3568_ mem\[0\]\[18\] mem\[2\]\[18\] _0885_ VSS VSS VDD VDD
+ _1046_ sky130_fd_sc_hd__mux2i_2
X_3569_ mem\[1\]\[18\] mem\[3\]\[18\] _0887_ VSS VSS VDD VDD
+ _1047_ sky130_fd_sc_hd__mux2i_1
X_3570_ mem\[8\]\[18\] mem\[10\]\[18\] _0952_ VSS VSS VDD
+ VDD _1048_ sky130_fd_sc_hd__mux2i_1
X_3571_ mem\[9\]\[18\] mem\[11\]\[18\] _0954_ VSS VSS VDD
+ VDD _1049_ sky130_fd_sc_hd__mux2i_2
X_3572_ _1046_ _1047_ _1048_ _1049_ _1012_ _0992_ VSS VSS
+ VDD VDD _1050_ sky130_fd_sc_hd__mux4_1
X_3573_ _1026_ _1050_ VSS VSS VDD VDD _1051_ sky130_fd_sc_hd__nor2_1
X_3574_ _0866_ _1045_ _1051_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__a21oi_1
X_3575_ net87 _2535_ VSS VSS VDD VDD _1053_ sky130_fd_sc_hd__nand2_1
X_3576_ _1035_ _1052_ _1053_ VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__o21ai_0
X_3577_ _0841_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__buf_6
X_3578_ mem\[4\]\[19\] mem\[6\]\[19\] _0869_ VSS VSS VDD VDD
+ _1055_ sky130_fd_sc_hd__mux2_1
X_3579_ mem\[5\]\[19\] mem\[7\]\[19\] _0872_ VSS VSS VDD VDD
+ _1056_ sky130_fd_sc_hd__mux2i_1
X_3580_ _0978_ _1056_ VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__nand2_1
X_3581_ _0997_ _1055_ _1057_ VSS VSS VDD VDD _1058_ sky130_fd_sc_hd__o21ai_0
X_3582_ mem\[12\]\[19\] mem\[14\]\[19\] _0926_ VSS VSS VDD
+ VDD _1059_ sky130_fd_sc_hd__mux2_1
X_3583_ mem\[13\]\[19\] mem\[15\]\[19\] _1041_ VSS VSS VDD
+ VDD _1060_ sky130_fd_sc_hd__mux2i_1
X_3584_ _0878_ _1060_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__nand2_1
X_3585_ _1002_ _1059_ _1061_ _0930_ VSS VSS VDD VDD _1062_
+ sky130_fd_sc_hd__o211ai_1
X_3586_ _1054_ _1058_ _1062_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__o21ai_0
X_3587_ mem\[0\]\[19\] mem\[2\]\[19\] _0885_ VSS VSS VDD VDD
+ _1064_ sky130_fd_sc_hd__mux2i_2
X_3588_ mem\[1\]\[19\] mem\[3\]\[19\] _0887_ VSS VSS VDD VDD
+ _1065_ sky130_fd_sc_hd__mux2i_1
X_3589_ mem\[8\]\[19\] mem\[10\]\[19\] _0952_ VSS VSS VDD
+ VDD _1066_ sky130_fd_sc_hd__mux2i_1
X_3590_ mem\[9\]\[19\] mem\[11\]\[19\] _0954_ VSS VSS VDD
+ VDD _1067_ sky130_fd_sc_hd__mux2i_2
X_3591_ _1064_ _1065_ _1066_ _1067_ _1012_ _0992_ VSS VSS
+ VDD VDD _1068_ sky130_fd_sc_hd__mux4_1
X_3592_ _1026_ _1068_ VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__nor2_1
X_3593_ _0866_ _1063_ _1069_ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__a21oi_1
X_3594_ _0825_ VSS VSS VDD VDD _1071_ sky130_fd_sc_hd__buf_8
X_3595_ net88 _1071_ VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__nand2_1
X_3596_ _1035_ _1070_ _1072_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__o21ai_0
X_3597_ mem\[0\]\[1\] mem\[2\]\[1\] _0833_ VSS VSS VDD VDD
+ _1073_ sky130_fd_sc_hd__mux2_1
X_3598_ mem\[1\]\[1\] mem\[3\]\[1\] _0846_ VSS VSS VDD VDD
+ _1074_ sky130_fd_sc_hd__mux2i_1
X_3599_ _0978_ _1074_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__nand2_1
X_3600_ _0997_ _1073_ _1075_ VSS VSS VDD VDD _1076_ sky130_fd_sc_hd__o21ai_0
X_3601_ mem\[8\]\[1\] mem\[10\]\[1\] _0907_ VSS VSS VDD VDD
+ _1077_ sky130_fd_sc_hd__mux2i_1
X_3602_ _0903_ _1077_ VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__nand2_1
X_3603_ mem\[9\]\[1\] mem\[11\]\[1\] _0907_ VSS VSS VDD VDD
+ _1079_ sky130_fd_sc_hd__mux2i_1
X_3604_ _0876_ _1079_ VSS VSS VDD VDD _1080_ sky130_fd_sc_hd__nand2_1
X_3605_ _0882_ _1078_ _1080_ VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__nand3_1
X_3606_ _1054_ _1076_ _1081_ VSS VSS VDD VDD _1082_ sky130_fd_sc_hd__o21ai_0
X_3607_ mem\[5\]\[1\] mem\[7\]\[1\] _0890_ VSS VSS VDD VDD
+ _1083_ sky130_fd_sc_hd__mux2i_1
X_3608_ mem\[4\]\[1\] mem\[6\]\[1\] _0831_ VSS VSS VDD VDD
+ _1084_ sky130_fd_sc_hd__mux2i_2
X_3609_ mem\[13\]\[1\] mem\[15\]\[1\] _0952_ VSS VSS VDD VDD
+ _1085_ sky130_fd_sc_hd__mux2i_1
X_3610_ mem\[12\]\[1\] mem\[14\]\[1\] _0916_ VSS VSS VDD VDD
+ _1086_ sky130_fd_sc_hd__mux2i_1
X_3611_ _1083_ _1084_ _1085_ _1086_ _0845_ _0992_ VSS VSS
+ VDD VDD _1087_ sky130_fd_sc_hd__mux4_1
X_3612_ _0897_ _1087_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__nor2_1
X_3613_ _0898_ _1082_ _1088_ VSS VSS VDD VDD _1089_ sky130_fd_sc_hd__a21oi_2
X_3614_ net89 _1071_ VSS VSS VDD VDD _1090_ sky130_fd_sc_hd__nand2_1
X_3615_ _1035_ _1089_ _1090_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__o21ai_0
X_3616_ _0835_ VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__buf_4
X_3617_ mem\[4\]\[20\] mem\[6\]\[20\] _1091_ VSS VSS VDD VDD
+ _1092_ sky130_fd_sc_hd__mux2_1
X_3618_ mem\[5\]\[20\] mem\[7\]\[20\] _0872_ VSS VSS VDD VDD
+ _1093_ sky130_fd_sc_hd__mux2i_1
X_3619_ _0978_ _1093_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__nand2_1
X_3620_ _0997_ _1092_ _1094_ VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__o21ai_0
X_3621_ mem\[12\]\[20\] mem\[14\]\[20\] _0926_ VSS VSS VDD
+ VDD _1096_ sky130_fd_sc_hd__mux2_1
X_3622_ mem\[13\]\[20\] mem\[15\]\[20\] _1041_ VSS VSS VDD
+ VDD _1097_ sky130_fd_sc_hd__mux2i_1
X_3623_ _0878_ _1097_ VSS VSS VDD VDD _1098_ sky130_fd_sc_hd__nand2_1
X_3624_ _1002_ _1096_ _1098_ _0930_ VSS VSS VDD VDD _1099_
+ sky130_fd_sc_hd__o211ai_1
X_3625_ _1054_ _1095_ _1099_ VSS VSS VDD VDD _1100_ sky130_fd_sc_hd__o21ai_0
X_3626_ _0830_ VSS VSS VDD VDD _1101_ sky130_fd_sc_hd__buf_8
X_3627_ mem\[0\]\[20\] mem\[2\]\[20\] _1101_ VSS VSS VDD VDD
+ _1102_ sky130_fd_sc_hd__mux2i_2
X_3628_ mem\[1\]\[20\] mem\[3\]\[20\] _0887_ VSS VSS VDD VDD
+ _1103_ sky130_fd_sc_hd__mux2i_2
X_3629_ mem\[8\]\[20\] mem\[10\]\[20\] _0952_ VSS VSS VDD
+ VDD _1104_ sky130_fd_sc_hd__mux2i_1
X_3630_ mem\[9\]\[20\] mem\[11\]\[20\] _0954_ VSS VSS VDD
+ VDD _1105_ sky130_fd_sc_hd__mux2i_2
X_3631_ _1102_ _1103_ _1104_ _1105_ _1012_ _0992_ VSS VSS
+ VDD VDD _1106_ sky130_fd_sc_hd__mux4_1
X_3632_ _1026_ _1106_ VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__nor2_1
X_3633_ _0866_ _1100_ _1107_ VSS VSS VDD VDD _1108_ sky130_fd_sc_hd__a21oi_1
X_3634_ net90 _1071_ VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__nand2_1
X_3635_ _1035_ _1108_ _1109_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__o21ai_0
X_3636_ mem\[4\]\[21\] mem\[6\]\[21\] _1091_ VSS VSS VDD VDD
+ _1110_ sky130_fd_sc_hd__mux2_1
X_3637_ _0831_ VSS VSS VDD VDD _1111_ sky130_fd_sc_hd__buf_6
X_3638_ mem\[5\]\[21\] mem\[7\]\[21\] _1111_ VSS VSS VDD VDD
+ _1112_ sky130_fd_sc_hd__mux2i_1
X_3639_ _0978_ _1112_ VSS VSS VDD VDD _1113_ sky130_fd_sc_hd__nand2_1
X_3640_ _0997_ _1110_ _1113_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__o21ai_0
X_3641_ mem\[12\]\[21\] mem\[14\]\[21\] _0926_ VSS VSS VDD
+ VDD _1115_ sky130_fd_sc_hd__mux2_1
X_3642_ mem\[13\]\[21\] mem\[15\]\[21\] _1041_ VSS VSS VDD
+ VDD _1116_ sky130_fd_sc_hd__mux2i_1
X_3643_ _0878_ _1116_ VSS VSS VDD VDD _1117_ sky130_fd_sc_hd__nand2_1
X_3644_ _1002_ _1115_ _1117_ _0930_ VSS VSS VDD VDD _1118_
+ sky130_fd_sc_hd__o211ai_1
X_3645_ _1054_ _1114_ _1118_ VSS VSS VDD VDD _1119_ sky130_fd_sc_hd__o21ai_0
X_3646_ mem\[0\]\[21\] mem\[2\]\[21\] _1101_ VSS VSS VDD VDD
+ _1120_ sky130_fd_sc_hd__mux2i_2
X_3647_ mem\[1\]\[21\] mem\[3\]\[21\] _0887_ VSS VSS VDD VDD
+ _1121_ sky130_fd_sc_hd__mux2i_1
X_3648_ mem\[8\]\[21\] mem\[10\]\[21\] _0952_ VSS VSS VDD
+ VDD _1122_ sky130_fd_sc_hd__mux2i_1
X_3649_ mem\[9\]\[21\] mem\[11\]\[21\] _0954_ VSS VSS VDD
+ VDD _1123_ sky130_fd_sc_hd__mux2i_2
X_3650_ _1120_ _1121_ _1122_ _1123_ _1012_ _0992_ VSS VSS
+ VDD VDD _1124_ sky130_fd_sc_hd__mux4_1
X_3651_ _1026_ _1124_ VSS VSS VDD VDD _1125_ sky130_fd_sc_hd__nor2_1
X_3652_ _0866_ _1119_ _1125_ VSS VSS VDD VDD _1126_ sky130_fd_sc_hd__a21oi_2
X_3653_ net91 _1071_ VSS VSS VDD VDD _1127_ sky130_fd_sc_hd__nand2_1
X_3654_ _1035_ _1126_ _1127_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__o21ai_0
X_3655_ _0861_ VSS VSS VDD VDD _1128_ sky130_fd_sc_hd__buf_4
X_3656_ mem\[4\]\[22\] mem\[6\]\[22\] _1091_ VSS VSS VDD VDD
+ _1129_ sky130_fd_sc_hd__mux2_1
X_3657_ mem\[5\]\[22\] mem\[7\]\[22\] _1111_ VSS VSS VDD VDD
+ _1130_ sky130_fd_sc_hd__mux2i_1
X_3658_ _0978_ _1130_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__nand2_1
X_3659_ _0997_ _1129_ _1131_ VSS VSS VDD VDD _1132_ sky130_fd_sc_hd__o21ai_0
X_3660_ mem\[12\]\[22\] mem\[14\]\[22\] _0926_ VSS VSS VDD
+ VDD _1133_ sky130_fd_sc_hd__mux2_1
X_3661_ _0854_ VSS VSS VDD VDD _1134_ sky130_fd_sc_hd__buf_4
X_3662_ mem\[13\]\[22\] mem\[15\]\[22\] _1041_ VSS VSS VDD
+ VDD _1135_ sky130_fd_sc_hd__mux2i_1
X_3663_ _1134_ _1135_ VSS VSS VDD VDD _1136_ sky130_fd_sc_hd__nand2_1
X_3664_ _1002_ _1133_ _1136_ _0930_ VSS VSS VDD VDD _1137_
+ sky130_fd_sc_hd__o211ai_1
X_3665_ _1054_ _1132_ _1137_ VSS VSS VDD VDD _1138_ sky130_fd_sc_hd__o21ai_0
X_3666_ mem\[0\]\[22\] mem\[2\]\[22\] _1101_ VSS VSS VDD VDD
+ _1139_ sky130_fd_sc_hd__mux2i_2
X_3667_ _0835_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__buf_6
X_3668_ mem\[1\]\[22\] mem\[3\]\[22\] _1140_ VSS VSS VDD VDD
+ _1141_ sky130_fd_sc_hd__mux2i_1
X_3669_ _0830_ VSS VSS VDD VDD _1142_ sky130_fd_sc_hd__buf_8
X_3670_ mem\[8\]\[22\] mem\[10\]\[22\] _1142_ VSS VSS VDD
+ VDD _1143_ sky130_fd_sc_hd__mux2i_2
X_3671_ mem\[9\]\[22\] mem\[11\]\[22\] _0954_ VSS VSS VDD
+ VDD _1144_ sky130_fd_sc_hd__mux2i_2
X_3672_ _1139_ _1141_ _1143_ _1144_ _1012_ _0992_ VSS VSS
+ VDD VDD _1145_ sky130_fd_sc_hd__mux4_1
X_3673_ _1026_ _1145_ VSS VSS VDD VDD _1146_ sky130_fd_sc_hd__nor2_1
X_3674_ _1128_ _1138_ _1146_ VSS VSS VDD VDD _1147_ sky130_fd_sc_hd__a21oi_2
X_3675_ net92 _1071_ VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__nand2_1
X_3676_ _1035_ _1147_ _1148_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__o21ai_0
X_3677_ mem\[4\]\[23\] mem\[6\]\[23\] _1091_ VSS VSS VDD VDD
+ _1149_ sky130_fd_sc_hd__mux2_1
X_3678_ mem\[5\]\[23\] mem\[7\]\[23\] _1111_ VSS VSS VDD VDD
+ _1150_ sky130_fd_sc_hd__mux2i_1
X_3679_ _0978_ _1150_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__nand2_1
X_3680_ _0997_ _1149_ _1151_ VSS VSS VDD VDD _1152_ sky130_fd_sc_hd__o21ai_1
X_3681_ _0722_ VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__buf_6
X_3682_ mem\[12\]\[23\] mem\[14\]\[23\] _1153_ VSS VSS VDD
+ VDD _1154_ sky130_fd_sc_hd__mux2_1
X_3683_ mem\[13\]\[23\] mem\[15\]\[23\] _1041_ VSS VSS VDD
+ VDD _1155_ sky130_fd_sc_hd__mux2i_1
X_3684_ _1134_ _1155_ VSS VSS VDD VDD _1156_ sky130_fd_sc_hd__nand2_1
X_3685_ _0841_ VSS VSS VDD VDD _1157_ sky130_fd_sc_hd__buf_4
X_3686_ _1002_ _1154_ _1156_ _1157_ VSS VSS VDD VDD _1158_
+ sky130_fd_sc_hd__o211ai_1
X_3687_ _1054_ _1152_ _1158_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__o21ai_0
X_3688_ mem\[0\]\[23\] mem\[2\]\[23\] _1101_ VSS VSS VDD VDD
+ _1160_ sky130_fd_sc_hd__mux2i_2
X_3689_ mem\[1\]\[23\] mem\[3\]\[23\] _1140_ VSS VSS VDD VDD
+ _1161_ sky130_fd_sc_hd__mux2i_1
X_3690_ mem\[8\]\[23\] mem\[10\]\[23\] _1142_ VSS VSS VDD
+ VDD _1162_ sky130_fd_sc_hd__mux2i_2
X_3691_ mem\[9\]\[23\] mem\[11\]\[23\] _0954_ VSS VSS VDD
+ VDD _1163_ sky130_fd_sc_hd__mux2i_2
X_3692_ _1160_ _1161_ _1162_ _1163_ _1012_ _0992_ VSS VSS
+ VDD VDD _1164_ sky130_fd_sc_hd__mux4_1
X_3693_ _1026_ _1164_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__nor2_1
X_3694_ _1128_ _1159_ _1165_ VSS VSS VDD VDD _1166_ sky130_fd_sc_hd__a21oi_1
X_3695_ net93 _1071_ VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__nand2_1
X_3696_ _1035_ _1166_ _1167_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__o21ai_0
X_3697_ mem\[0\]\[24\] mem\[2\]\[24\] _0833_ VSS VSS VDD VDD
+ _1168_ sky130_fd_sc_hd__mux2_1
X_3698_ _0849_ VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__buf_6
X_3699_ mem\[1\]\[24\] mem\[3\]\[24\] _0846_ VSS VSS VDD VDD
+ _1170_ sky130_fd_sc_hd__mux2i_1
X_3700_ _1169_ _1170_ VSS VSS VDD VDD _1171_ sky130_fd_sc_hd__nand2_1
X_3701_ _0997_ _1168_ _1171_ VSS VSS VDD VDD _1172_ sky130_fd_sc_hd__o21ai_0
X_3702_ mem\[8\]\[24\] mem\[10\]\[24\] _0879_ VSS VSS VDD
+ VDD _1173_ sky130_fd_sc_hd__mux2i_2
X_3703_ _0903_ _1173_ VSS VSS VDD VDD _1174_ sky130_fd_sc_hd__nand2_1
X_3704_ mem\[9\]\[24\] mem\[11\]\[24\] _0907_ VSS VSS VDD
+ VDD _1175_ sky130_fd_sc_hd__mux2i_1
X_3705_ _0876_ _1175_ VSS VSS VDD VDD _1176_ sky130_fd_sc_hd__nand2_1
X_3706_ _0882_ _1174_ _1176_ VSS VSS VDD VDD _1177_ sky130_fd_sc_hd__nand3_1
X_3707_ _1054_ _1172_ _1177_ VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__o21ai_0
X_3708_ mem\[5\]\[24\] mem\[7\]\[24\] _0890_ VSS VSS VDD VDD
+ _1179_ sky130_fd_sc_hd__mux2i_2
X_3709_ mem\[4\]\[24\] mem\[6\]\[24\] _0831_ VSS VSS VDD VDD
+ _1180_ sky130_fd_sc_hd__mux2i_2
X_3710_ mem\[13\]\[24\] mem\[15\]\[24\] _1142_ VSS VSS VDD
+ VDD _1181_ sky130_fd_sc_hd__mux2i_1
X_3711_ mem\[12\]\[24\] mem\[14\]\[24\] _0916_ VSS VSS VDD
+ VDD _1182_ sky130_fd_sc_hd__mux2i_1
X_3712_ _0841_ VSS VSS VDD VDD _1183_ sky130_fd_sc_hd__clkbuf_8
X_3713_ _1179_ _1180_ _1181_ _1182_ _0845_ _1183_ VSS VSS
+ VDD VDD _1184_ sky130_fd_sc_hd__mux4_1
X_3714_ _0897_ _1184_ VSS VSS VDD VDD _1185_ sky130_fd_sc_hd__nor2_1
X_3715_ _0898_ _1178_ _1185_ VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__a21oi_2
X_3716_ net94 _1071_ VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__nand2_1
X_3717_ _1035_ _1186_ _1187_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__o21ai_0
X_3718_ _0839_ VSS VSS VDD VDD _1188_ sky130_fd_sc_hd__buf_6
X_3719_ mem\[4\]\[25\] mem\[6\]\[25\] _1091_ VSS VSS VDD VDD
+ _1189_ sky130_fd_sc_hd__mux2_1
X_3720_ mem\[5\]\[25\] mem\[7\]\[25\] _1111_ VSS VSS VDD VDD
+ _1190_ sky130_fd_sc_hd__mux2i_2
X_3721_ _1169_ _1190_ VSS VSS VDD VDD _1191_ sky130_fd_sc_hd__nand2_1
X_3722_ _1188_ _1189_ _1191_ VSS VSS VDD VDD _1192_ sky130_fd_sc_hd__o21ai_1
X_3723_ mem\[12\]\[25\] mem\[14\]\[25\] _1153_ VSS VSS VDD
+ VDD _1193_ sky130_fd_sc_hd__mux2_1
X_3724_ mem\[13\]\[25\] mem\[15\]\[25\] _1041_ VSS VSS VDD
+ VDD _1194_ sky130_fd_sc_hd__mux2i_1
X_3725_ _1134_ _1194_ VSS VSS VDD VDD _1195_ sky130_fd_sc_hd__nand2_1
X_3726_ _1002_ _1193_ _1195_ _1157_ VSS VSS VDD VDD _1196_
+ sky130_fd_sc_hd__o211ai_1
X_3727_ _1054_ _1192_ _1196_ VSS VSS VDD VDD _1197_ sky130_fd_sc_hd__o21ai_0
X_3728_ mem\[0\]\[25\] mem\[2\]\[25\] _1101_ VSS VSS VDD VDD
+ _1198_ sky130_fd_sc_hd__mux2i_2
X_3729_ mem\[1\]\[25\] mem\[3\]\[25\] _1140_ VSS VSS VDD VDD
+ _1199_ sky130_fd_sc_hd__mux2i_1
X_3730_ mem\[8\]\[25\] mem\[10\]\[25\] _1142_ VSS VSS VDD
+ VDD _1200_ sky130_fd_sc_hd__mux2i_2
X_3731_ _0830_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__buf_8
X_3732_ mem\[9\]\[25\] mem\[11\]\[25\] _1201_ VSS VSS VDD
+ VDD _1202_ sky130_fd_sc_hd__mux2i_2
X_3733_ _1198_ _1199_ _1200_ _1202_ _1012_ _1183_ VSS VSS
+ VDD VDD _1203_ sky130_fd_sc_hd__mux4_1
X_3734_ _1026_ _1203_ VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__nor2_1
X_3735_ _1128_ _1197_ _1204_ VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__a21oi_1
X_3736_ net95 _1071_ VSS VSS VDD VDD _1206_ sky130_fd_sc_hd__nand2_1
X_3737_ _1035_ _1205_ _1206_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__o21ai_0
X_3738_ mem\[4\]\[26\] mem\[6\]\[26\] _1091_ VSS VSS VDD VDD
+ _1207_ sky130_fd_sc_hd__mux2_1
X_3739_ mem\[5\]\[26\] mem\[7\]\[26\] _1111_ VSS VSS VDD VDD
+ _1208_ sky130_fd_sc_hd__mux2i_1
X_3740_ _1169_ _1208_ VSS VSS VDD VDD _1209_ sky130_fd_sc_hd__nand2_1
X_3741_ _1188_ _1207_ _1209_ VSS VSS VDD VDD _1210_ sky130_fd_sc_hd__o21ai_1
X_3742_ mem\[12\]\[26\] mem\[14\]\[26\] _1153_ VSS VSS VDD
+ VDD _1211_ sky130_fd_sc_hd__mux2_1
X_3743_ mem\[13\]\[26\] mem\[15\]\[26\] _1041_ VSS VSS VDD
+ VDD _1212_ sky130_fd_sc_hd__mux2i_1
X_3744_ _1134_ _1212_ VSS VSS VDD VDD _1213_ sky130_fd_sc_hd__nand2_1
X_3745_ _1002_ _1211_ _1213_ _1157_ VSS VSS VDD VDD _1214_
+ sky130_fd_sc_hd__o211ai_1
X_3746_ _1054_ _1210_ _1214_ VSS VSS VDD VDD _1215_ sky130_fd_sc_hd__o21ai_0
X_3747_ mem\[0\]\[26\] mem\[2\]\[26\] _1101_ VSS VSS VDD VDD
+ _1216_ sky130_fd_sc_hd__mux2i_2
X_3748_ mem\[1\]\[26\] mem\[3\]\[26\] _1140_ VSS VSS VDD VDD
+ _1217_ sky130_fd_sc_hd__mux2i_1
X_3749_ mem\[8\]\[26\] mem\[10\]\[26\] _1142_ VSS VSS VDD
+ VDD _1218_ sky130_fd_sc_hd__mux2i_1
X_3750_ mem\[9\]\[26\] mem\[11\]\[26\] _1201_ VSS VSS VDD
+ VDD _1219_ sky130_fd_sc_hd__mux2i_2
X_3751_ _1216_ _1217_ _1218_ _1219_ _1012_ _1183_ VSS VSS
+ VDD VDD _1220_ sky130_fd_sc_hd__mux4_1
X_3752_ _1026_ _1220_ VSS VSS VDD VDD _1221_ sky130_fd_sc_hd__nor2_1
X_3753_ _1128_ _1215_ _1221_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__a21oi_1
X_3754_ net96 _1071_ VSS VSS VDD VDD _1223_ sky130_fd_sc_hd__nand2_1
X_3755_ _1035_ _1222_ _1223_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__o21ai_0
X_3756_ _0714_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__clkbuf_8
X_3757_ mem\[4\]\[27\] mem\[6\]\[27\] _1091_ VSS VSS VDD VDD
+ _1225_ sky130_fd_sc_hd__mux2_1
X_3758_ mem\[5\]\[27\] mem\[7\]\[27\] _1111_ VSS VSS VDD VDD
+ _1226_ sky130_fd_sc_hd__mux2i_1
X_3759_ _1169_ _1226_ VSS VSS VDD VDD _1227_ sky130_fd_sc_hd__nand2_1
X_3760_ _1188_ _1225_ _1227_ VSS VSS VDD VDD _1228_ sky130_fd_sc_hd__o21ai_1
X_3761_ _0854_ VSS VSS VDD VDD _1229_ sky130_fd_sc_hd__buf_6
X_3762_ mem\[12\]\[27\] mem\[14\]\[27\] _1153_ VSS VSS VDD
+ VDD _1230_ sky130_fd_sc_hd__mux2_1
X_3763_ mem\[13\]\[27\] mem\[15\]\[27\] _1041_ VSS VSS VDD
+ VDD _1231_ sky130_fd_sc_hd__mux2i_1
X_3764_ _1134_ _1231_ VSS VSS VDD VDD _1232_ sky130_fd_sc_hd__nand2_1
X_3765_ _1229_ _1230_ _1232_ _1157_ VSS VSS VDD VDD _1233_
+ sky130_fd_sc_hd__o211ai_1
X_3766_ _1054_ _1228_ _1233_ VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__o21ai_0
X_3767_ mem\[0\]\[27\] mem\[2\]\[27\] _1101_ VSS VSS VDD VDD
+ _1235_ sky130_fd_sc_hd__mux2i_2
X_3768_ mem\[1\]\[27\] mem\[3\]\[27\] _1140_ VSS VSS VDD VDD
+ _1236_ sky130_fd_sc_hd__mux2i_1
X_3769_ mem\[8\]\[27\] mem\[10\]\[27\] _1142_ VSS VSS VDD
+ VDD _1237_ sky130_fd_sc_hd__mux2i_1
X_3770_ mem\[9\]\[27\] mem\[11\]\[27\] _1201_ VSS VSS VDD
+ VDD _1238_ sky130_fd_sc_hd__mux2i_2
X_3771_ _0839_ VSS VSS VDD VDD _1239_ sky130_fd_sc_hd__buf_8
X_3772_ _1235_ _1236_ _1237_ _1238_ _1239_ _1183_ VSS VSS
+ VDD VDD _1240_ sky130_fd_sc_hd__mux4_1
X_3773_ _1026_ _1240_ VSS VSS VDD VDD _1241_ sky130_fd_sc_hd__nor2_1
X_3774_ _1128_ _1234_ _1241_ VSS VSS VDD VDD _1242_ sky130_fd_sc_hd__a21oi_1
X_3775_ net97 _1071_ VSS VSS VDD VDD _1243_ sky130_fd_sc_hd__nand2_1
X_3776_ _1224_ _1242_ _1243_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__o21ai_0
X_3777_ _0841_ VSS VSS VDD VDD _1244_ sky130_fd_sc_hd__clkbuf_8
X_3778_ mem\[4\]\[28\] mem\[6\]\[28\] _1091_ VSS VSS VDD VDD
+ _1245_ sky130_fd_sc_hd__mux2_1
X_3779_ mem\[5\]\[28\] mem\[7\]\[28\] _1111_ VSS VSS VDD VDD
+ _1246_ sky130_fd_sc_hd__mux2i_1
X_3780_ _1169_ _1246_ VSS VSS VDD VDD _1247_ sky130_fd_sc_hd__nand2_1
X_3781_ _1188_ _1245_ _1247_ VSS VSS VDD VDD _1248_ sky130_fd_sc_hd__o21ai_1
X_3782_ mem\[12\]\[28\] mem\[14\]\[28\] _1153_ VSS VSS VDD
+ VDD _1249_ sky130_fd_sc_hd__mux2_1
X_3783_ mem\[13\]\[28\] mem\[15\]\[28\] _1041_ VSS VSS VDD
+ VDD _1250_ sky130_fd_sc_hd__mux2i_1
X_3784_ _1134_ _1250_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__nand2_1
X_3785_ _1229_ _1249_ _1251_ _1157_ VSS VSS VDD VDD _1252_
+ sky130_fd_sc_hd__o211ai_1
X_3786_ _1244_ _1248_ _1252_ VSS VSS VDD VDD _1253_ sky130_fd_sc_hd__o21ai_0
X_3787_ mem\[0\]\[28\] mem\[2\]\[28\] _1101_ VSS VSS VDD VDD
+ _1254_ sky130_fd_sc_hd__mux2i_2
X_3788_ mem\[1\]\[28\] mem\[3\]\[28\] _1140_ VSS VSS VDD VDD
+ _1255_ sky130_fd_sc_hd__mux2i_1
X_3789_ mem\[8\]\[28\] mem\[10\]\[28\] _1142_ VSS VSS VDD
+ VDD _1256_ sky130_fd_sc_hd__mux2i_1
X_3790_ mem\[9\]\[28\] mem\[11\]\[28\] _1201_ VSS VSS VDD
+ VDD _1257_ sky130_fd_sc_hd__mux2i_1
X_3791_ _1254_ _1255_ _1256_ _1257_ _1239_ _1183_ VSS VSS
+ VDD VDD _1258_ sky130_fd_sc_hd__mux4_1
X_3792_ _0865_ _1258_ VSS VSS VDD VDD _1259_ sky130_fd_sc_hd__nor2_1
X_3793_ _1128_ _1253_ _1259_ VSS VSS VDD VDD _1260_ sky130_fd_sc_hd__a21oi_1
X_3794_ _0825_ VSS VSS VDD VDD _1261_ sky130_fd_sc_hd__buf_4
X_3795_ net98 _1261_ VSS VSS VDD VDD _1262_ sky130_fd_sc_hd__nand2_1
X_3796_ _1224_ _1260_ _1262_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__o21ai_0
X_3797_ mem\[0\]\[29\] mem\[2\]\[29\] _0833_ VSS VSS VDD VDD
+ _1263_ sky130_fd_sc_hd__mux2_1
X_3798_ mem\[1\]\[29\] mem\[3\]\[29\] _0846_ VSS VSS VDD VDD
+ _1264_ sky130_fd_sc_hd__mux2i_1
X_3799_ _1169_ _1264_ VSS VSS VDD VDD _1265_ sky130_fd_sc_hd__nand2_1
X_3800_ _1188_ _1263_ _1265_ VSS VSS VDD VDD _1266_ sky130_fd_sc_hd__o21ai_0
X_3801_ mem\[8\]\[29\] mem\[10\]\[29\] _0879_ VSS VSS VDD
+ VDD _1267_ sky130_fd_sc_hd__mux2i_1
X_3802_ _0903_ _1267_ VSS VSS VDD VDD _1268_ sky130_fd_sc_hd__nand2_1
X_3803_ mem\[9\]\[29\] mem\[11\]\[29\] _0907_ VSS VSS VDD
+ VDD _1269_ sky130_fd_sc_hd__mux2i_1
X_3804_ _0876_ _1269_ VSS VSS VDD VDD _1270_ sky130_fd_sc_hd__nand2_1
X_3805_ _0882_ _1268_ _1270_ VSS VSS VDD VDD _1271_ sky130_fd_sc_hd__nand3_1
X_3806_ _1244_ _1266_ _1271_ VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__o21ai_0
X_3807_ mem\[5\]\[29\] mem\[7\]\[29\] _0890_ VSS VSS VDD VDD
+ _1273_ sky130_fd_sc_hd__mux2i_2
X_3808_ mem\[4\]\[29\] mem\[6\]\[29\] _0831_ VSS VSS VDD VDD
+ _1274_ sky130_fd_sc_hd__mux2i_1
X_3809_ mem\[13\]\[29\] mem\[15\]\[29\] _1142_ VSS VSS VDD
+ VDD _1275_ sky130_fd_sc_hd__mux2i_2
X_3810_ mem\[12\]\[29\] mem\[14\]\[29\] _0916_ VSS VSS VDD
+ VDD _1276_ sky130_fd_sc_hd__mux2i_2
X_3811_ _1273_ _1274_ _1275_ _1276_ _0840_ _1183_ VSS VSS
+ VDD VDD _1277_ sky130_fd_sc_hd__mux4_1
X_3812_ _0897_ _1277_ VSS VSS VDD VDD _1278_ sky130_fd_sc_hd__nor2_1
X_3813_ _0898_ _1272_ _1278_ VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__a21oi_2
X_3814_ net99 _1261_ VSS VSS VDD VDD _1280_ sky130_fd_sc_hd__nand2_1
X_3815_ _1224_ _1279_ _1280_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__o21ai_0
X_3816_ mem\[4\]\[2\] mem\[6\]\[2\] _1091_ VSS VSS VDD VDD
+ _1281_ sky130_fd_sc_hd__mux2_1
X_3817_ mem\[5\]\[2\] mem\[7\]\[2\] _1111_ VSS VSS VDD VDD
+ _1282_ sky130_fd_sc_hd__mux2i_1
X_3818_ _1169_ _1282_ VSS VSS VDD VDD _1283_ sky130_fd_sc_hd__nand2_1
X_3819_ _1188_ _1281_ _1283_ VSS VSS VDD VDD _1284_ sky130_fd_sc_hd__o21ai_1
X_3820_ mem\[12\]\[2\] mem\[14\]\[2\] _1153_ VSS VSS VDD VDD
+ _1285_ sky130_fd_sc_hd__mux2_1
X_3821_ mem\[13\]\[2\] mem\[15\]\[2\] _0851_ VSS VSS VDD VDD
+ _1286_ sky130_fd_sc_hd__mux2i_1
X_3822_ _1134_ _1286_ VSS VSS VDD VDD _1287_ sky130_fd_sc_hd__nand2_1
X_3823_ _1229_ _1285_ _1287_ _1157_ VSS VSS VDD VDD _1288_
+ sky130_fd_sc_hd__o211ai_1
X_3824_ _1244_ _1284_ _1288_ VSS VSS VDD VDD _1289_ sky130_fd_sc_hd__o21ai_0
X_3825_ mem\[0\]\[2\] mem\[2\]\[2\] _1101_ VSS VSS VDD VDD
+ _1290_ sky130_fd_sc_hd__mux2i_4
X_3826_ mem\[1\]\[2\] mem\[3\]\[2\] _1140_ VSS VSS VDD VDD
+ _1291_ sky130_fd_sc_hd__mux2i_2
X_3827_ mem\[8\]\[2\] mem\[10\]\[2\] _1142_ VSS VSS VDD VDD
+ _1292_ sky130_fd_sc_hd__mux2i_1
X_3828_ mem\[9\]\[2\] mem\[11\]\[2\] _1201_ VSS VSS VDD VDD
+ _1293_ sky130_fd_sc_hd__mux2i_1
X_3829_ _1290_ _1291_ _1292_ _1293_ _1239_ _1183_ VSS VSS
+ VDD VDD _1294_ sky130_fd_sc_hd__mux4_1
X_3830_ _0865_ _1294_ VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__nor2_1
X_3831_ _1128_ _1289_ _1295_ VSS VSS VDD VDD _1296_ sky130_fd_sc_hd__a21oi_1
X_3832_ net100 _1261_ VSS VSS VDD VDD _1297_ sky130_fd_sc_hd__nand2_1
X_3833_ _1224_ _1296_ _1297_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__o21ai_0
X_3834_ mem\[4\]\[30\] mem\[6\]\[30\] _1091_ VSS VSS VDD VDD
+ _1298_ sky130_fd_sc_hd__mux2_1
X_3835_ mem\[5\]\[30\] mem\[7\]\[30\] _1111_ VSS VSS VDD VDD
+ _1299_ sky130_fd_sc_hd__mux2i_1
X_3836_ _1169_ _1299_ VSS VSS VDD VDD _1300_ sky130_fd_sc_hd__nand2_1
X_3837_ _1188_ _1298_ _1300_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__o21ai_1
X_3838_ mem\[12\]\[30\] mem\[14\]\[30\] _1153_ VSS VSS VDD
+ VDD _1302_ sky130_fd_sc_hd__mux2_1
X_3839_ mem\[13\]\[30\] mem\[15\]\[30\] _0851_ VSS VSS VDD
+ VDD _1303_ sky130_fd_sc_hd__mux2i_1
X_3840_ _1134_ _1303_ VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__nand2_1
X_3841_ _1229_ _1302_ _1304_ _1157_ VSS VSS VDD VDD _1305_
+ sky130_fd_sc_hd__o211ai_1
X_3842_ _1244_ _1301_ _1305_ VSS VSS VDD VDD _1306_ sky130_fd_sc_hd__o21ai_0
X_3843_ mem\[0\]\[30\] mem\[2\]\[30\] _1101_ VSS VSS VDD VDD
+ _1307_ sky130_fd_sc_hd__mux2i_2
X_3844_ mem\[1\]\[30\] mem\[3\]\[30\] _1140_ VSS VSS VDD VDD
+ _1308_ sky130_fd_sc_hd__mux2i_1
X_3845_ mem\[8\]\[30\] mem\[10\]\[30\] _1142_ VSS VSS VDD
+ VDD _1309_ sky130_fd_sc_hd__mux2i_1
X_3846_ mem\[9\]\[30\] mem\[11\]\[30\] _1201_ VSS VSS VDD
+ VDD _1310_ sky130_fd_sc_hd__mux2i_1
X_3847_ _1307_ _1308_ _1309_ _1310_ _1239_ _1183_ VSS VSS
+ VDD VDD _1311_ sky130_fd_sc_hd__mux4_1
X_3848_ _0865_ _1311_ VSS VSS VDD VDD _1312_ sky130_fd_sc_hd__nor2_1
X_3849_ _1128_ _1306_ _1312_ VSS VSS VDD VDD _1313_ sky130_fd_sc_hd__a21oi_1
X_3850_ net101 _1261_ VSS VSS VDD VDD _1314_ sky130_fd_sc_hd__nand2_1
X_3851_ _1224_ _1313_ _1314_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__o21ai_0
X_3852_ mem\[4\]\[31\] mem\[6\]\[31\] _0855_ VSS VSS VDD VDD
+ _1315_ sky130_fd_sc_hd__mux2_1
X_3853_ mem\[5\]\[31\] mem\[7\]\[31\] _1111_ VSS VSS VDD VDD
+ _1316_ sky130_fd_sc_hd__mux2i_1
X_3854_ _1169_ _1316_ VSS VSS VDD VDD _1317_ sky130_fd_sc_hd__nand2_1
X_3855_ _1188_ _1315_ _1317_ VSS VSS VDD VDD _1318_ sky130_fd_sc_hd__o21ai_1
X_3856_ mem\[12\]\[31\] mem\[14\]\[31\] _1153_ VSS VSS VDD
+ VDD _1319_ sky130_fd_sc_hd__mux2_1
X_3857_ mem\[13\]\[31\] mem\[15\]\[31\] _0851_ VSS VSS VDD
+ VDD _1320_ sky130_fd_sc_hd__mux2i_1
X_3858_ _1134_ _1320_ VSS VSS VDD VDD _1321_ sky130_fd_sc_hd__nand2_1
X_3859_ _1229_ _1319_ _1321_ _1157_ VSS VSS VDD VDD _1322_
+ sky130_fd_sc_hd__o211ai_1
X_3860_ _1244_ _1318_ _1322_ VSS VSS VDD VDD _1323_ sky130_fd_sc_hd__o21ai_0
X_3861_ mem\[0\]\[31\] mem\[2\]\[31\] _0837_ VSS VSS VDD VDD
+ _1324_ sky130_fd_sc_hd__mux2i_2
X_3862_ mem\[1\]\[31\] mem\[3\]\[31\] _1140_ VSS VSS VDD VDD
+ _1325_ sky130_fd_sc_hd__mux2i_1
X_3863_ mem\[8\]\[31\] mem\[10\]\[31\] _0914_ VSS VSS VDD
+ VDD _1326_ sky130_fd_sc_hd__mux2i_1
X_3864_ mem\[9\]\[31\] mem\[11\]\[31\] _1201_ VSS VSS VDD
+ VDD _1327_ sky130_fd_sc_hd__mux2i_2
X_3865_ _1324_ _1325_ _1326_ _1327_ _1239_ _1183_ VSS VSS
+ VDD VDD _1328_ sky130_fd_sc_hd__mux4_1
X_3866_ _0865_ _1328_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__nor2_1
X_3867_ _1128_ _1323_ _1329_ VSS VSS VDD VDD _1330_ sky130_fd_sc_hd__a21oi_1
X_3868_ net102 _1261_ VSS VSS VDD VDD _1331_ sky130_fd_sc_hd__nand2_1
X_3869_ _1224_ _1330_ _1331_ VSS VSS VDD VDD _0559_ sky130_fd_sc_hd__o21ai_0
X_3870_ mem\[4\]\[3\] mem\[6\]\[3\] _0855_ VSS VSS VDD VDD
+ _1332_ sky130_fd_sc_hd__mux2_1
X_3871_ mem\[5\]\[3\] mem\[7\]\[3\] _0846_ VSS VSS VDD VDD
+ _1333_ sky130_fd_sc_hd__mux2i_1
X_3872_ _1169_ _1333_ VSS VSS VDD VDD _1334_ sky130_fd_sc_hd__nand2_1
X_3873_ _1188_ _1332_ _1334_ VSS VSS VDD VDD _1335_ sky130_fd_sc_hd__o21ai_0
X_3874_ mem\[12\]\[3\] mem\[14\]\[3\] _1153_ VSS VSS VDD VDD
+ _1336_ sky130_fd_sc_hd__mux2_1
X_3875_ mem\[13\]\[3\] mem\[15\]\[3\] _0851_ VSS VSS VDD VDD
+ _1337_ sky130_fd_sc_hd__mux2i_1
X_3876_ _1134_ _1337_ VSS VSS VDD VDD _1338_ sky130_fd_sc_hd__nand2_1
X_3877_ _1229_ _1336_ _1338_ _1157_ VSS VSS VDD VDD _1339_
+ sky130_fd_sc_hd__o211ai_1
X_3878_ _1244_ _1335_ _1339_ VSS VSS VDD VDD _1340_ sky130_fd_sc_hd__o21ai_0
X_3879_ mem\[0\]\[3\] mem\[2\]\[3\] _0837_ VSS VSS VDD VDD
+ _1341_ sky130_fd_sc_hd__mux2i_2
X_3880_ mem\[1\]\[3\] mem\[3\]\[3\] _1140_ VSS VSS VDD VDD
+ _1342_ sky130_fd_sc_hd__mux2i_1
X_3881_ mem\[8\]\[3\] mem\[10\]\[3\] _0914_ VSS VSS VDD VDD
+ _1343_ sky130_fd_sc_hd__mux2i_2
X_3882_ mem\[9\]\[3\] mem\[11\]\[3\] _1201_ VSS VSS VDD VDD
+ _1344_ sky130_fd_sc_hd__mux2i_1
X_3883_ _1341_ _1342_ _1343_ _1344_ _1239_ _1183_ VSS VSS
+ VDD VDD _1345_ sky130_fd_sc_hd__mux4_1
X_3884_ _0865_ _1345_ VSS VSS VDD VDD _1346_ sky130_fd_sc_hd__nor2_1
X_3885_ _1128_ _1340_ _1346_ VSS VSS VDD VDD _1347_ sky130_fd_sc_hd__a21oi_2
X_3886_ net111 _1261_ VSS VSS VDD VDD _1348_ sky130_fd_sc_hd__nand2_1
X_3887_ _1224_ _1347_ _1348_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__o21ai_0
X_3888_ mem\[0\]\[4\] mem\[2\]\[4\] _0835_ VSS VSS VDD VDD
+ _1349_ sky130_fd_sc_hd__mux2_1
X_3889_ mem\[1\]\[4\] mem\[3\]\[4\] _0869_ VSS VSS VDD VDD
+ _1350_ sky130_fd_sc_hd__mux2i_1
X_3890_ _0850_ _1350_ VSS VSS VDD VDD _1351_ sky130_fd_sc_hd__nand2_1
X_3891_ _1188_ _1349_ _1351_ VSS VSS VDD VDD _1352_ sky130_fd_sc_hd__o21ai_0
X_3892_ mem\[8\]\[4\] mem\[10\]\[4\] _0879_ VSS VSS VDD VDD
+ _1353_ sky130_fd_sc_hd__mux2i_1
X_3893_ _0845_ _1353_ VSS VSS VDD VDD _1354_ sky130_fd_sc_hd__nand2_1
X_3894_ mem\[9\]\[4\] mem\[11\]\[4\] _0907_ VSS VSS VDD VDD
+ _1355_ sky130_fd_sc_hd__mux2i_1
X_3895_ _0876_ _1355_ VSS VSS VDD VDD _1356_ sky130_fd_sc_hd__nand2_1
X_3896_ _0882_ _1354_ _1356_ VSS VSS VDD VDD _1357_ sky130_fd_sc_hd__nand3_1
X_3897_ _1244_ _1352_ _1357_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__o21ai_0
X_3898_ mem\[5\]\[4\] mem\[7\]\[4\] _0890_ VSS VSS VDD VDD
+ _1359_ sky130_fd_sc_hd__mux2i_1
X_3899_ mem\[4\]\[4\] mem\[6\]\[4\] _0831_ VSS VSS VDD VDD
+ _1360_ sky130_fd_sc_hd__mux2i_2
X_3900_ mem\[13\]\[4\] mem\[15\]\[4\] _0914_ VSS VSS VDD VDD
+ _1361_ sky130_fd_sc_hd__mux2i_1
X_3901_ mem\[12\]\[4\] mem\[14\]\[4\] _0916_ VSS VSS VDD VDD
+ _1362_ sky130_fd_sc_hd__mux2i_1
X_3902_ _1359_ _1360_ _1361_ _1362_ _0840_ _0842_ VSS VSS
+ VDD VDD _1363_ sky130_fd_sc_hd__mux4_1
X_3903_ _0897_ _1363_ VSS VSS VDD VDD _1364_ sky130_fd_sc_hd__nor2_1
X_3904_ _0898_ _1358_ _1364_ VSS VSS VDD VDD _1365_ sky130_fd_sc_hd__a21oi_2
X_3905_ net122 _1261_ VSS VSS VDD VDD _1366_ sky130_fd_sc_hd__nand2_1
X_3906_ _1224_ _1365_ _1366_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__o21ai_0
X_3907_ mem\[4\]\[5\] mem\[6\]\[5\] _0855_ VSS VSS VDD VDD
+ _1367_ sky130_fd_sc_hd__mux2_1
X_3908_ mem\[5\]\[5\] mem\[7\]\[5\] _0846_ VSS VSS VDD VDD
+ _1368_ sky130_fd_sc_hd__mux2i_1
X_3909_ _0850_ _1368_ VSS VSS VDD VDD _1369_ sky130_fd_sc_hd__nand2_1
X_3910_ _0871_ _1367_ _1369_ VSS VSS VDD VDD _1370_ sky130_fd_sc_hd__o21ai_0
X_3911_ mem\[12\]\[5\] mem\[14\]\[5\] _1153_ VSS VSS VDD VDD
+ _1371_ sky130_fd_sc_hd__mux2_1
X_3912_ mem\[13\]\[5\] mem\[15\]\[5\] _0851_ VSS VSS VDD VDD
+ _1372_ sky130_fd_sc_hd__mux2i_1
X_3913_ _0868_ _1372_ VSS VSS VDD VDD _1373_ sky130_fd_sc_hd__nand2_1
X_3914_ _1229_ _1371_ _1373_ _1157_ VSS VSS VDD VDD _1374_
+ sky130_fd_sc_hd__o211ai_1
X_3915_ _1244_ _1370_ _1374_ VSS VSS VDD VDD _1375_ sky130_fd_sc_hd__o21ai_0
X_3916_ mem\[0\]\[5\] mem\[2\]\[5\] _0837_ VSS VSS VDD VDD
+ _1376_ sky130_fd_sc_hd__mux2i_2
X_3917_ mem\[1\]\[5\] mem\[3\]\[5\] _0916_ VSS VSS VDD VDD
+ _1377_ sky130_fd_sc_hd__mux2i_2
X_3918_ mem\[8\]\[5\] mem\[10\]\[5\] _0914_ VSS VSS VDD VDD
+ _1378_ sky130_fd_sc_hd__mux2i_2
X_3919_ mem\[9\]\[5\] mem\[11\]\[5\] _1201_ VSS VSS VDD VDD
+ _1379_ sky130_fd_sc_hd__mux2i_2
X_3920_ _1376_ _1377_ _1378_ _1379_ _1239_ _0842_ VSS VSS
+ VDD VDD _1380_ sky130_fd_sc_hd__mux4_1
X_3921_ _0865_ _1380_ VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__nor2_1
X_3922_ _0829_ _1375_ _1381_ VSS VSS VDD VDD _1382_ sky130_fd_sc_hd__a21oi_1
X_3923_ net133 _1261_ VSS VSS VDD VDD _1383_ sky130_fd_sc_hd__nand2_1
X_3924_ _1224_ _1382_ _1383_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__o21ai_0
X_3925_ mem\[4\]\[6\] mem\[6\]\[6\] _0855_ VSS VSS VDD VDD
+ _1384_ sky130_fd_sc_hd__mux2_1
X_3926_ mem\[5\]\[6\] mem\[7\]\[6\] _0846_ VSS VSS VDD VDD
+ _1385_ sky130_fd_sc_hd__mux2i_1
X_3927_ _0850_ _1385_ VSS VSS VDD VDD _1386_ sky130_fd_sc_hd__nand2_1
X_3928_ _0871_ _1384_ _1386_ VSS VSS VDD VDD _1387_ sky130_fd_sc_hd__o21ai_0
X_3929_ mem\[12\]\[6\] mem\[14\]\[6\] _0833_ VSS VSS VDD VDD
+ _1388_ sky130_fd_sc_hd__mux2_1
X_3930_ mem\[13\]\[6\] mem\[15\]\[6\] _0851_ VSS VSS VDD VDD
+ _1389_ sky130_fd_sc_hd__mux2i_1
X_3931_ _0868_ _1389_ VSS VSS VDD VDD _1390_ sky130_fd_sc_hd__nand2_1
X_3932_ _1229_ _1388_ _1390_ _0844_ VSS VSS VDD VDD _1391_
+ sky130_fd_sc_hd__o211ai_1
X_3933_ _1244_ _1387_ _1391_ VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__o21ai_0
X_3934_ mem\[0\]\[6\] mem\[2\]\[6\] _0837_ VSS VSS VDD VDD
+ _1393_ sky130_fd_sc_hd__mux2i_2
X_3935_ mem\[1\]\[6\] mem\[3\]\[6\] _0916_ VSS VSS VDD VDD
+ _1394_ sky130_fd_sc_hd__mux2i_1
X_3936_ mem\[8\]\[6\] mem\[10\]\[6\] _0914_ VSS VSS VDD VDD
+ _1395_ sky130_fd_sc_hd__mux2i_1
X_3937_ mem\[9\]\[6\] mem\[11\]\[6\] _1201_ VSS VSS VDD VDD
+ _1396_ sky130_fd_sc_hd__mux2i_1
X_3938_ _1393_ _1394_ _1395_ _1396_ _1239_ _0842_ VSS VSS
+ VDD VDD _1397_ sky130_fd_sc_hd__mux4_1
X_3939_ _0865_ _1397_ VSS VSS VDD VDD _1398_ sky130_fd_sc_hd__nor2_1
X_3940_ _0829_ _1392_ _1398_ VSS VSS VDD VDD _1399_ sky130_fd_sc_hd__a21oi_1
X_3941_ net138 _1261_ VSS VSS VDD VDD _1400_ sky130_fd_sc_hd__nand2_1
X_3942_ _1224_ _1399_ _1400_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__o21ai_0
X_3943_ mem\[4\]\[7\] mem\[6\]\[7\] _0855_ VSS VSS VDD VDD
+ _1401_ sky130_fd_sc_hd__mux2_1
X_3944_ mem\[5\]\[7\] mem\[7\]\[7\] _0846_ VSS VSS VDD VDD
+ _1402_ sky130_fd_sc_hd__mux2i_1
X_3945_ _0850_ _1402_ VSS VSS VDD VDD _1403_ sky130_fd_sc_hd__nand2_1
X_3946_ _0871_ _1401_ _1403_ VSS VSS VDD VDD _1404_ sky130_fd_sc_hd__o21ai_0
X_3947_ mem\[12\]\[7\] mem\[14\]\[7\] _0833_ VSS VSS VDD VDD
+ _1405_ sky130_fd_sc_hd__mux2_1
X_3948_ mem\[13\]\[7\] mem\[15\]\[7\] _0851_ VSS VSS VDD VDD
+ _1406_ sky130_fd_sc_hd__mux2i_1
X_3949_ _0868_ _1406_ VSS VSS VDD VDD _1407_ sky130_fd_sc_hd__nand2_1
X_3950_ _1229_ _1405_ _1407_ _0844_ VSS VSS VDD VDD _1408_
+ sky130_fd_sc_hd__o211ai_1
X_3951_ _1244_ _1404_ _1408_ VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__o21ai_0
X_3952_ mem\[0\]\[7\] mem\[2\]\[7\] _0837_ VSS VSS VDD VDD
+ _1410_ sky130_fd_sc_hd__mux2i_2
X_3953_ mem\[1\]\[7\] mem\[3\]\[7\] _0916_ VSS VSS VDD VDD
+ _1411_ sky130_fd_sc_hd__mux2i_1
X_3954_ mem\[8\]\[7\] mem\[10\]\[7\] _0914_ VSS VSS VDD VDD
+ _1412_ sky130_fd_sc_hd__mux2i_1
X_3955_ mem\[9\]\[7\] mem\[11\]\[7\] _0885_ VSS VSS VDD VDD
+ _1413_ sky130_fd_sc_hd__mux2i_1
X_3956_ _1410_ _1411_ _1412_ _1413_ _1239_ _0842_ VSS VSS
+ VDD VDD _1414_ sky130_fd_sc_hd__mux4_1
X_3957_ _0865_ _1414_ VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__nor2_1
X_3958_ _0829_ _1409_ _1415_ VSS VSS VDD VDD _1416_ sky130_fd_sc_hd__a21oi_1
X_3959_ net139 _1261_ VSS VSS VDD VDD _1417_ sky130_fd_sc_hd__nand2_1
X_3960_ _0825_ _1416_ _1417_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__o21ai_0
X_3961_ mem\[4\]\[8\] mem\[6\]\[8\] _0855_ VSS VSS VDD VDD
+ _1418_ sky130_fd_sc_hd__mux2_1
X_3962_ mem\[5\]\[8\] mem\[7\]\[8\] _0846_ VSS VSS VDD VDD
+ _1419_ sky130_fd_sc_hd__mux2i_1
X_3963_ _0850_ _1419_ VSS VSS VDD VDD _1420_ sky130_fd_sc_hd__nand2_1
X_3964_ _0871_ _1418_ _1420_ VSS VSS VDD VDD _1421_ sky130_fd_sc_hd__o21ai_0
X_3965_ mem\[12\]\[8\] mem\[14\]\[8\] _0833_ VSS VSS VDD VDD
+ _1422_ sky130_fd_sc_hd__mux2_1
X_3966_ mem\[13\]\[8\] mem\[15\]\[8\] _0851_ VSS VSS VDD VDD
+ _1423_ sky130_fd_sc_hd__mux2i_1
X_3967_ _0868_ _1423_ VSS VSS VDD VDD _1424_ sky130_fd_sc_hd__nand2_1
X_3968_ _1229_ _1422_ _1424_ _0844_ VSS VSS VDD VDD _1425_
+ sky130_fd_sc_hd__o211ai_1
X_3969_ _0882_ _1421_ _1425_ VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__o21ai_0
X_3970_ mem\[0\]\[8\] mem\[2\]\[8\] _0837_ VSS VSS VDD VDD
+ _1427_ sky130_fd_sc_hd__mux2i_2
X_3971_ mem\[1\]\[8\] mem\[3\]\[8\] _0916_ VSS VSS VDD VDD
+ _1428_ sky130_fd_sc_hd__mux2i_1
X_3972_ mem\[8\]\[8\] mem\[10\]\[8\] _0914_ VSS VSS VDD VDD
+ _1429_ sky130_fd_sc_hd__mux2i_1
X_3973_ mem\[9\]\[8\] mem\[11\]\[8\] _0885_ VSS VSS VDD VDD
+ _1430_ sky130_fd_sc_hd__mux2i_1
X_3974_ _1427_ _1428_ _1429_ _1430_ _1239_ _0842_ VSS VSS
+ VDD VDD _1431_ sky130_fd_sc_hd__mux4_1
X_3975_ _0865_ _1431_ VSS VSS VDD VDD _1432_ sky130_fd_sc_hd__nor2_1
X_3976_ _0829_ _1426_ _1432_ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__a21oi_1
X_3977_ net140 _0864_ VSS VSS VDD VDD _1434_ sky130_fd_sc_hd__nand2_1
X_3978_ _0825_ _1433_ _1434_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__o21ai_0
X_3979_ mem\[0\]\[9\] mem\[2\]\[9\] _0835_ VSS VSS VDD VDD
+ _1435_ sky130_fd_sc_hd__mux2_1
X_3980_ mem\[1\]\[9\] mem\[3\]\[9\] _0869_ VSS VSS VDD VDD
+ _1436_ sky130_fd_sc_hd__mux2i_1
X_3981_ _0850_ _1436_ VSS VSS VDD VDD _1437_ sky130_fd_sc_hd__nand2_1
X_3982_ _0871_ _1435_ _1437_ VSS VSS VDD VDD _1438_ sky130_fd_sc_hd__o21ai_0
X_3983_ mem\[8\]\[9\] mem\[10\]\[9\] _0879_ VSS VSS VDD VDD
+ _1439_ sky130_fd_sc_hd__mux2i_1
X_3984_ _0845_ _1439_ VSS VSS VDD VDD _1440_ sky130_fd_sc_hd__nand2_1
X_3985_ mem\[9\]\[9\] mem\[11\]\[9\] _0907_ VSS VSS VDD VDD
+ _1441_ sky130_fd_sc_hd__mux2i_1
X_3986_ _0876_ _1441_ VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__nand2_1
X_3987_ _0882_ _1440_ _1442_ VSS VSS VDD VDD _1443_ sky130_fd_sc_hd__nand3_1
X_3988_ _0882_ _1438_ _1443_ VSS VSS VDD VDD _1444_ sky130_fd_sc_hd__o21ai_0
X_3989_ mem\[5\]\[9\] mem\[7\]\[9\] _0890_ VSS VSS VDD VDD
+ _1445_ sky130_fd_sc_hd__mux2i_1
X_3990_ mem\[4\]\[9\] mem\[6\]\[9\] _0831_ VSS VSS VDD VDD
+ _1446_ sky130_fd_sc_hd__mux2i_1
X_3991_ mem\[13\]\[9\] mem\[15\]\[9\] _0914_ VSS VSS VDD VDD
+ _1447_ sky130_fd_sc_hd__mux2i_1
X_3992_ mem\[12\]\[9\] mem\[14\]\[9\] _0890_ VSS VSS VDD VDD
+ _1448_ sky130_fd_sc_hd__mux2i_2
X_3993_ _1445_ _1446_ _1447_ _1448_ _0840_ _0842_ VSS VSS
+ VDD VDD _1449_ sky130_fd_sc_hd__mux4_1
X_3994_ _0897_ _1449_ VSS VSS VDD VDD _1450_ sky130_fd_sc_hd__nor2_1
X_3995_ _0898_ _1444_ _1450_ VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__a21oi_2
X_3996_ net141 _0864_ VSS VSS VDD VDD _1452_ sky130_fd_sc_hd__nand2_1
X_3997_ _0825_ _1451_ _1452_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__o21ai_0
X_3998_ _0711_ VSS VSS VDD VDD _1453_ sky130_fd_sc_hd__inv_2
X_3999_ _0609_ _0607_ net73 _2557_ VSS VSS VDD VDD _1454_
+ sky130_fd_sc_hd__nor4b_4
X_4000_ _1453_ _1454_ _2492_ VSS VSS VDD VDD _1455_ sky130_fd_sc_hd__o21ai_4
X_4001_ _1455_ VSS VSS VDD VDD _1456_ sky130_fd_sc_hd__buf_6
X_4002_ _2518_ VSS VSS VDD VDD _1457_ sky130_fd_sc_hd__buf_6
X_4003_ _1453_ _1457_ _1454_ VSS VSS VDD VDD _1458_ sky130_fd_sc_hd__or3_1
X_4004_ _1458_ VSS VSS VDD VDD _1459_ sky130_fd_sc_hd__clkbuf_2
X_4005_ _1459_ VSS VSS VDD VDD _1460_ sky130_fd_sc_hd__buf_6
X_4006_ mem\[9\]\[0\] _1456_ _1460_ mem\[8\]\[0\] VSS VSS
+ VDD VDD _1461_ sky130_fd_sc_hd__o22ai_1
X_4007_ _0711_ _1457_ net219 VSS VSS VDD VDD _1462_ sky130_fd_sc_hd__nand3_4
X_4008_ _1462_ VSS VSS VDD VDD _1463_ sky130_fd_sc_hd__buf_6
X_4009_ _1453_ _1454_ _0830_ VSS VSS VDD VDD _1464_ sky130_fd_sc_hd__o21ai_4
X_4010_ _1464_ VSS VSS VDD VDD _1465_ sky130_fd_sc_hd__buf_6
X_4011_ mem\[10\]\[0\] _1463_ _1465_ mem\[11\]\[0\] VSS VSS
+ VDD VDD _1466_ sky130_fd_sc_hd__o22ai_1
X_4012_ _2517_ VSS VSS VDD VDD _1467_ sky130_fd_sc_hd__buf_4
X_4013_ _1467_ VSS VSS VDD VDD _1468_ sky130_fd_sc_hd__inv_2
X_4014_ _0826_ _1468_ VSS VSS VDD VDD _1469_ sky130_fd_sc_hd__nor2_2
X_4015_ _0711_ _1467_ net166 _0896_ VSS VSS VDD VDD _1470_
+ sky130_fd_sc_hd__a31oi_2
X_4016_ _0715_ _1469_ _1470_ _0840_ VSS VSS VDD VDD _1471_
+ sky130_fd_sc_hd__a211o_4
X_4017_ _1471_ VSS VSS VDD VDD _1472_ sky130_fd_sc_hd__clkbuf_8
X_4018_ _1461_ _1466_ _1472_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__nor3_1
X_4019_ _0840_ rd_ptr\[3\] _0721_ VSS VSS VDD VDD _1474_ sky130_fd_sc_hd__and3_1
X_4020_ _1474_ VSS VSS VDD VDD _1475_ sky130_fd_sc_hd__buf_4
X_4021_ _1475_ VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__buf_6
X_4022_ _0826_ _1467_ VSS VSS VDD VDD _1477_ sky130_fd_sc_hd__xnor2_1
X_4023_ _1477_ VSS VSS VDD VDD _1478_ sky130_fd_sc_hd__buf_4
X_4024_ _1478_ VSS VSS VDD VDD _1479_ sky130_fd_sc_hd__buf_4
X_4025_ _1457_ VSS VSS VDD VDD _1480_ sky130_fd_sc_hd__buf_8
X_4026_ _1480_ VSS VSS VDD VDD _1481_ sky130_fd_sc_hd__buf_8
X_4027_ mem\[13\]\[0\] mem\[15\]\[0\] _1481_ VSS VSS VDD VDD
+ _1482_ sky130_fd_sc_hd__mux2i_1
X_4028_ _1457_ VSS VSS VDD VDD _1483_ sky130_fd_sc_hd__buf_6
X_4029_ mem\[9\]\[0\] mem\[11\]\[0\] _1483_ VSS VSS VDD VDD
+ _1484_ sky130_fd_sc_hd__mux2_1
X_4030_ _0897_ _1468_ _1484_ VSS VSS VDD VDD _1485_ sky130_fd_sc_hd__nand3_1
X_4031_ _1479_ _1482_ _1485_ VSS VSS VDD VDD _1486_ sky130_fd_sc_hd__o21ai_0
X_4032_ net222 _1486_ VSS VSS VDD VDD _1487_ sky130_fd_sc_hd__nand2_1
X_4033_ _0827_ VSS VSS VDD VDD _1488_ sky130_fd_sc_hd__buf_6
X_4034_ _0715_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__clkbuf_4
X_4035_ _0711_ VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__buf_6
X_4036_ net220 VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__buf_6
X_4037_ _1490_ _1467_ _1491_ _1484_ VSS VSS VDD VDD _1492_
+ sky130_fd_sc_hd__nand4_1
X_4038_ _1489_ _0838_ _1492_ VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__o21ai_0
X_4039_ _1453_ _1454_ _0896_ VSS VSS VDD VDD _1494_ sky130_fd_sc_hd__o21ai_4
X_4040_ _1494_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__buf_6
X_4041_ _0847_ _1495_ VSS VSS VDD VDD _1496_ sky130_fd_sc_hd__nor2_1
X_4042_ _1488_ _1493_ _1496_ VSS VSS VDD VDD _1497_ sky130_fd_sc_hd__a21oi_1
X_4043_ _0711_ _0839_ _0826_ _0722_ VSS VSS VDD VDD _1498_
+ sky130_fd_sc_hd__nand4_1
X_4044_ _1454_ _1498_ _0841_ VSS VSS VDD VDD _1499_ sky130_fd_sc_hd__o21ai_2
X_4045_ _0841_ _1454_ _1498_ VSS VSS VDD VDD _1500_ sky130_fd_sc_hd__or3_2
X_4046_ _1499_ _1500_ _0840_ net164 VSS VSS VDD VDD _1501_
+ sky130_fd_sc_hd__a211oi_4
X_4047_ _0896_ _1467_ VSS VSS VDD VDD _1502_ sky130_fd_sc_hd__nor2_1
X_4048_ mem\[12\]\[0\] mem\[14\]\[0\] _1480_ VSS VSS VDD VDD
+ _1503_ sky130_fd_sc_hd__mux2_1
X_4049_ _1502_ _1469_ _1503_ _1489_ VSS VSS VDD VDD _1504_
+ sky130_fd_sc_hd__o211ai_1
X_4050_ _0896_ _0715_ _0836_ VSS VSS VDD VDD _1505_ sky130_fd_sc_hd__or3_1
X_4051_ _1501_ _1504_ _1505_ VSS VSS VDD VDD _1506_ sky130_fd_sc_hd__and3_1
X_4052_ _1476_ _1487_ _1497_ _1506_ VSS VSS VDD VDD _1507_
+ sky130_fd_sc_hd__a31oi_1
X_4053_ _1499_ _1500_ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__nand2_2
X_4054_ _0845_ _2534_ _1508_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__nor3_4
X_4055_ _1483_ VSS VSS VDD VDD _1510_ sky130_fd_sc_hd__buf_8
X_4056_ mem\[4\]\[0\] mem\[6\]\[0\] mem\[0\]\[0\] mem\[2\]\[0\]
+ _1510_ _1478_ VSS VSS VDD VDD _1511_ sky130_fd_sc_hd__mux4_1
X_4057_ _0529_ _1511_ VSS VSS VDD VDD _1512_ sky130_fd_sc_hd__nand2_1
X_4058_ _0897_ _0856_ VSS VSS VDD VDD _1513_ sky130_fd_sc_hd__nand2_1
X_4059_ _0827_ VSS VSS VDD VDD _1514_ sky130_fd_sc_hd__buf_8
X_4060_ _1514_ _0832_ VSS VSS VDD VDD _1515_ sky130_fd_sc_hd__nand2_1
X_4061_ _0825_ _1513_ _1515_ VSS VSS VDD VDD _1516_ sky130_fd_sc_hd__nand3_1
X_4062_ mem\[5\]\[0\] mem\[7\]\[0\] mem\[1\]\[0\] mem\[3\]\[0\]
+ _1480_ _1478_ VSS VSS VDD VDD _1517_ sky130_fd_sc_hd__mux4_1
X_4063_ _0827_ _0857_ VSS VSS VDD VDD _1518_ sky130_fd_sc_hd__nor2_1
X_4064_ _0715_ VSS VSS VDD VDD _1519_ sky130_fd_sc_hd__buf_4
X_4065_ _0828_ _0834_ _1518_ _1519_ VSS VSS VDD VDD _1520_
+ sky130_fd_sc_hd__a211oi_1
X_4066_ _0839_ _0841_ net164 VSS VSS VDD VDD _1521_ sky130_fd_sc_hd__or3_1
X_4067_ _1521_ VSS VSS VDD VDD _1522_ sky130_fd_sc_hd__clkbuf_4
X_4068_ _0529_ _1517_ _1520_ _1522_ VSS VSS VDD VDD _1523_
+ sky130_fd_sc_hd__a211oi_1
X_4069_ _1509_ _1512_ _1516_ _1523_ VSS VSS VDD VDD _1524_
+ sky130_fd_sc_hd__a31oi_1
X_4070_ net103 _2537_ _1473_ _1507_ _1524_ VSS VSS VDD VDD
+ _0567_ sky130_fd_sc_hd__o221a_1
X_4071_ _0850_ VSS VSS VDD VDD _1525_ sky130_fd_sc_hd__buf_6
X_4072_ _0896_ _0715_ VSS VSS VDD VDD _1526_ sky130_fd_sc_hd__nor2_4
X_4073_ _1526_ VSS VSS VDD VDD _1527_ sky130_fd_sc_hd__buf_4
X_4074_ _1453_ _1454_ _1477_ VSS VSS VDD VDD _1528_ sky130_fd_sc_hd__or3_1
X_4075_ _1528_ VSS VSS VDD VDD _1529_ sky130_fd_sc_hd__clkbuf_4
X_4076_ _1529_ VSS VSS VDD VDD _1530_ sky130_fd_sc_hd__buf_4
X_4077_ _1530_ VSS VSS VDD VDD _1531_ sky130_fd_sc_hd__buf_6
X_4078_ _1483_ VSS VSS VDD VDD _1532_ sky130_fd_sc_hd__buf_6
X_4079_ _1532_ VSS VSS VDD VDD _1533_ sky130_fd_sc_hd__buf_6
X_4080_ mem\[5\]\[10\] mem\[7\]\[10\] _1533_ VSS VSS VDD VDD
+ _1534_ sky130_fd_sc_hd__mux2i_1
X_4081_ _1531_ _1534_ VSS VSS VDD VDD _1535_ sky130_fd_sc_hd__nor2_1
X_4082_ _0870_ _1527_ _1535_ VSS VSS VDD VDD _1536_ sky130_fd_sc_hd__a21oi_1
X_4083_ _0849_ VSS VSS VDD VDD _1537_ sky130_fd_sc_hd__buf_4
X_4084_ _0827_ VSS VSS VDD VDD _1538_ sky130_fd_sc_hd__buf_6
X_4085_ _0715_ VSS VSS VDD VDD _1539_ sky130_fd_sc_hd__buf_6
X_4086_ _0711_ VSS VSS VDD VDD _1540_ sky130_fd_sc_hd__buf_4
X_4087_ _1540_ VSS VSS VDD VDD _1541_ sky130_fd_sc_hd__buf_4
X_4088_ net220 VSS VSS VDD VDD _1542_ sky130_fd_sc_hd__buf_4
X_4089_ _1542_ VSS VSS VDD VDD _1543_ sky130_fd_sc_hd__buf_4
X_4090_ mem\[1\]\[10\] mem\[3\]\[10\] _1510_ VSS VSS VDD VDD
+ _1544_ sky130_fd_sc_hd__mux2_1
X_4091_ _1541_ _1543_ _1479_ _1544_ VSS VSS VDD VDD _1545_
+ sky130_fd_sc_hd__nand4_1
X_4092_ _1538_ _1539_ _0886_ _1545_ VSS VSS VDD VDD _1546_
+ sky130_fd_sc_hd__o31ai_1
X_4093_ _1453_ _1454_ _0826_ VSS VSS VDD VDD _1547_ sky130_fd_sc_hd__o21ai_1
X_4094_ _1547_ VSS VSS VDD VDD _1548_ sky130_fd_sc_hd__buf_6
X_4095_ _1529_ VSS VSS VDD VDD _1549_ sky130_fd_sc_hd__buf_4
X_4096_ _1510_ VSS VSS VDD VDD _1550_ sky130_fd_sc_hd__buf_16
X_4097_ mem\[4\]\[10\] mem\[6\]\[10\] _1550_ VSS VSS VDD VDD
+ _1551_ sky130_fd_sc_hd__mux2i_1
X_4098_ _0854_ VSS VSS VDD VDD _1552_ sky130_fd_sc_hd__buf_6
X_4099_ _0873_ _1548_ _1549_ _1551_ _1552_ VSS VSS VDD VDD
+ _1553_ sky130_fd_sc_hd__o221ai_1
X_4100_ _1537_ _1546_ _1553_ VSS VSS VDD VDD _1554_ sky130_fd_sc_hd__o21ai_0
X_4101_ _1455_ VSS VSS VDD VDD _1555_ sky130_fd_sc_hd__buf_6
X_4102_ _1459_ VSS VSS VDD VDD _1556_ sky130_fd_sc_hd__buf_6
X_4103_ mem\[1\]\[10\] _1555_ _1556_ mem\[0\]\[10\] VSS VSS
+ VDD VDD _1557_ sky130_fd_sc_hd__o22ai_1
X_4104_ mem\[2\]\[10\] _1463_ _1465_ mem\[3\]\[10\] VSS VSS
+ VDD VDD _1558_ sky130_fd_sc_hd__o22ai_1
X_4105_ _1472_ _1557_ _1558_ VSS VSS VDD VDD _1559_ sky130_fd_sc_hd__or3_1
X_4106_ _2534_ _1508_ VSS VSS VDD VDD _1560_ sky130_fd_sc_hd__nor2_4
X_4107_ _1560_ VSS VSS VDD VDD _1561_ sky130_fd_sc_hd__buf_4
X_4108_ _1525_ _1536_ _1554_ _1559_ _1561_ VSS VSS VDD VDD
+ _1562_ sky130_fd_sc_hd__o2111ai_1
X_4109_ _1530_ VSS VSS VDD VDD _1563_ sky130_fd_sc_hd__buf_6
X_4110_ _1563_ VSS VSS VDD VDD _1564_ sky130_fd_sc_hd__buf_4
X_4111_ _1550_ VSS VSS VDD VDD _1565_ sky130_fd_sc_hd__clkbuf_16
X_4112_ mem\[12\]\[10\] mem\[14\]\[10\] _1565_ VSS VSS VDD
+ VDD _1566_ sky130_fd_sc_hd__mux2i_1
X_4113_ _0715_ VSS VSS VDD VDD _1567_ sky130_fd_sc_hd__buf_4
X_4114_ _1540_ VSS VSS VDD VDD _1568_ sky130_fd_sc_hd__buf_6
X_4115_ _1542_ VSS VSS VDD VDD _1569_ sky130_fd_sc_hd__buf_6
X_4116_ mem\[8\]\[10\] mem\[10\]\[10\] _1480_ VSS VSS VDD
+ VDD _1570_ sky130_fd_sc_hd__mux2_1
X_4117_ _1568_ _1569_ _1570_ VSS VSS VDD VDD _1571_ sky130_fd_sc_hd__nand3_1
X_4118_ _1467_ VSS VSS VDD VDD _1572_ sky130_fd_sc_hd__buf_6
X_4119_ _1567_ _0891_ _1571_ _1572_ VSS VSS VDD VDD _1573_
+ sky130_fd_sc_hd__o22ai_1
X_4120_ _1468_ VSS VSS VDD VDD _1574_ sky130_fd_sc_hd__buf_6
X_4121_ _1574_ _1571_ VSS VSS VDD VDD _1575_ sky130_fd_sc_hd__nor2_1
X_4122_ net222 _0880_ _1488_ VSS VSS VDD VDD _1576_ sky130_fd_sc_hd__o21ai_0
X_4123_ _0861_ _1573_ _1575_ _1576_ VSS VSS VDD VDD _1577_
+ sky130_fd_sc_hd__o22ai_1
X_4124_ _1501_ VSS VSS VDD VDD _1578_ sky130_fd_sc_hd__buf_6
X_4125_ _1564_ _1566_ _1577_ _1578_ VSS VSS VDD VDD _1579_
+ sky130_fd_sc_hd__o211ai_1
X_4126_ _1529_ VSS VSS VDD VDD _1580_ sky130_fd_sc_hd__buf_6
X_4127_ _1510_ VSS VSS VDD VDD _1581_ sky130_fd_sc_hd__buf_8
X_4128_ mem\[13\]\[10\] mem\[15\]\[10\] _1581_ VSS VSS VDD
+ VDD _1582_ sky130_fd_sc_hd__mux2i_1
X_4129_ net221 VSS VSS VDD VDD _1583_ sky130_fd_sc_hd__clkbuf_8
X_4130_ _0828_ _1583_ _0877_ VSS VSS VDD VDD _1584_ sky130_fd_sc_hd__nand3_1
X_4131_ _0889_ _1495_ _1580_ _1582_ _1584_ VSS VSS VDD VDD
+ _1585_ sky130_fd_sc_hd__o221ai_1
X_4132_ mem\[9\]\[10\] mem\[11\]\[10\] _1581_ VSS VSS VDD
+ VDD _1586_ sky130_fd_sc_hd__mux2i_1
X_4133_ _0711_ net166 _1478_ VSS VSS VDD VDD _1587_ sky130_fd_sc_hd__nand3_1
X_4134_ _1587_ VSS VSS VDD VDD _1588_ sky130_fd_sc_hd__buf_6
X_4135_ _1588_ VSS VSS VDD VDD _1589_ sky130_fd_sc_hd__clkbuf_8
X_4136_ _1586_ _1589_ _1476_ VSS VSS VDD VDD _1590_ sky130_fd_sc_hd__o21ai_0
X_4137_ net114 _2537_ _1585_ _1590_ VSS VSS VDD VDD _1591_
+ sky130_fd_sc_hd__o22a_1
X_4138_ _1562_ _1579_ _1591_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__and3_1
X_4139_ _1499_ _1500_ VSS VSS VDD VDD _1592_ sky130_fd_sc_hd__and2_0
X_4140_ _1592_ VSS VSS VDD VDD _1593_ sky130_fd_sc_hd__clkbuf_4
X_4141_ net163 _1593_ VSS VSS VDD VDD _1594_ sky130_fd_sc_hd__nor2_1
X_4142_ _0845_ VSS VSS VDD VDD _1595_ sky130_fd_sc_hd__buf_4
X_4143_ _1547_ VSS VSS VDD VDD _1596_ sky130_fd_sc_hd__buf_4
X_4144_ _1596_ VSS VSS VDD VDD _1597_ sky130_fd_sc_hd__buf_4
X_4145_ _1530_ VSS VSS VDD VDD _1598_ sky130_fd_sc_hd__buf_4
X_4146_ _1532_ VSS VSS VDD VDD _1599_ sky130_fd_sc_hd__buf_6
X_4147_ mem\[13\]\[11\] mem\[15\]\[11\] _1599_ VSS VSS VDD
+ VDD _1600_ sky130_fd_sc_hd__mux2i_1
X_4148_ _0917_ _1597_ _1598_ _1600_ VSS VSS VDD VDD _1601_
+ sky130_fd_sc_hd__o22ai_1
X_4149_ _1595_ _1601_ VSS VSS VDD VDD _1602_ sky130_fd_sc_hd__nand2_1
X_4150_ mem\[9\]\[11\] _1555_ _1556_ mem\[8\]\[11\] VSS VSS
+ VDD VDD _1603_ sky130_fd_sc_hd__o22ai_1
X_4151_ mem\[10\]\[11\] _1463_ _1465_ mem\[11\]\[11\] VSS
+ VSS VDD VDD _1604_ sky130_fd_sc_hd__o22ai_1
X_4152_ _1472_ _1603_ _1604_ VSS VSS VDD VDD _1605_ sky130_fd_sc_hd__or3_1
X_4153_ mem\[12\]\[11\] mem\[14\]\[11\] _1533_ VSS VSS VDD
+ VDD _1606_ sky130_fd_sc_hd__mux2i_1
X_4154_ _0915_ _1548_ _1563_ _1606_ VSS VSS VDD VDD _1607_
+ sky130_fd_sc_hd__o22ai_1
X_4155_ _1532_ VSS VSS VDD VDD _1608_ sky130_fd_sc_hd__buf_8
X_4156_ mem\[9\]\[11\] mem\[11\]\[11\] _1608_ VSS VSS VDD
+ VDD _1609_ sky130_fd_sc_hd__mux2i_1
X_4157_ _0904_ _1495_ _1589_ _1609_ _0903_ VSS VSS VDD VDD
+ _1610_ sky130_fd_sc_hd__o221ai_1
X_4158_ _0903_ _1607_ _1610_ VSS VSS VDD VDD _1611_ sky130_fd_sc_hd__o21ai_0
X_4159_ _1594_ _1602_ _1605_ _1611_ VSS VSS VDD VDD _1612_
+ sky130_fd_sc_hd__nand4_1
X_4160_ mem\[4\]\[11\] mem\[6\]\[11\] _1565_ VSS VSS VDD VDD
+ _1613_ sky130_fd_sc_hd__mux2i_1
X_4161_ mem\[0\]\[11\] mem\[2\]\[11\] _1480_ VSS VSS VDD VDD
+ _1614_ sky130_fd_sc_hd__mux2_1
X_4162_ _1568_ _1569_ _1614_ VSS VSS VDD VDD _1615_ sky130_fd_sc_hd__nand3_1
X_4163_ _1567_ _0900_ _1615_ _1572_ VSS VSS VDD VDD _1616_
+ sky130_fd_sc_hd__o22ai_1
X_4164_ _1574_ _1615_ VSS VSS VDD VDD _1617_ sky130_fd_sc_hd__nor2_1
X_4165_ net222 _0912_ _1488_ VSS VSS VDD VDD _1618_ sky130_fd_sc_hd__o21ai_0
X_4166_ _0861_ _1616_ _1617_ _1618_ VSS VSS VDD VDD _1619_
+ sky130_fd_sc_hd__o22ai_1
X_4167_ _1564_ _1613_ _1619_ _1509_ VSS VSS VDD VDD _1620_
+ sky130_fd_sc_hd__o211ai_1
X_4168_ mem\[1\]\[11\] mem\[3\]\[11\] _1481_ VSS VSS VDD VDD
+ _1621_ sky130_fd_sc_hd__mux2i_1
X_4169_ _1588_ _1621_ VSS VSS VDD VDD _1622_ sky130_fd_sc_hd__nor2_1
X_4170_ mem\[5\]\[11\] mem\[7\]\[11\] _1480_ VSS VSS VDD VDD
+ _1623_ sky130_fd_sc_hd__mux2_1
X_4171_ _1502_ _1469_ _1623_ _1489_ VSS VSS VDD VDD _1624_
+ sky130_fd_sc_hd__o211ai_1
X_4172_ _0896_ _0899_ VSS VSS VDD VDD _1625_ sky130_fd_sc_hd__and2_0
X_4173_ _0896_ _0913_ VSS VSS VDD VDD _1626_ sky130_fd_sc_hd__nor2_1
X_4174_ net221 VSS VSS VDD VDD _1627_ sky130_fd_sc_hd__clkbuf_8
X_4175_ _1625_ _1626_ _1627_ VSS VSS VDD VDD _1628_ sky130_fd_sc_hd__o21ai_0
X_4176_ _1624_ _1628_ VSS VSS VDD VDD _1629_ sky130_fd_sc_hd__nand2_1
X_4177_ _1522_ _1622_ _1629_ _2537_ net115 VSS VSS VDD VDD
+ _1630_ sky130_fd_sc_hd__o32a_1
X_4178_ _1612_ _1620_ _1630_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__and3_1
X_4179_ mem\[5\]\[12\] mem\[7\]\[12\] _1533_ VSS VSS VDD VDD
+ _1631_ sky130_fd_sc_hd__mux2i_1
X_4180_ _1531_ _1631_ VSS VSS VDD VDD _1632_ sky130_fd_sc_hd__nor2_1
X_4181_ _0922_ _1527_ _1632_ VSS VSS VDD VDD _1633_ sky130_fd_sc_hd__a21oi_1
X_4182_ mem\[1\]\[12\] mem\[3\]\[12\] _1510_ VSS VSS VDD VDD
+ _1634_ sky130_fd_sc_hd__mux2_1
X_4183_ _1541_ _1543_ _1479_ _1634_ VSS VSS VDD VDD _1635_
+ sky130_fd_sc_hd__nand4_1
X_4184_ _1538_ _1539_ _0933_ _1635_ VSS VSS VDD VDD _1636_
+ sky130_fd_sc_hd__o31ai_1
X_4185_ mem\[4\]\[12\] mem\[6\]\[12\] _1550_ VSS VSS VDD VDD
+ _1637_ sky130_fd_sc_hd__mux2i_1
X_4186_ _0923_ _1548_ _1549_ _1637_ _1552_ VSS VSS VDD VDD
+ _1638_ sky130_fd_sc_hd__o221ai_1
X_4187_ _1537_ _1636_ _1638_ VSS VSS VDD VDD _1639_ sky130_fd_sc_hd__o21ai_0
X_4188_ mem\[1\]\[12\] _1555_ _1556_ mem\[0\]\[12\] VSS VSS
+ VDD VDD _1640_ sky130_fd_sc_hd__o22ai_1
X_4189_ mem\[2\]\[12\] _1463_ _1465_ mem\[3\]\[12\] VSS VSS
+ VDD VDD _1641_ sky130_fd_sc_hd__o22ai_1
X_4190_ _1472_ _1640_ _1641_ VSS VSS VDD VDD _1642_ sky130_fd_sc_hd__or3_1
X_4191_ _1525_ _1633_ _1639_ _1642_ _1561_ VSS VSS VDD VDD
+ _1643_ sky130_fd_sc_hd__o2111ai_1
X_4192_ mem\[12\]\[12\] mem\[14\]\[12\] _1565_ VSS VSS VDD
+ VDD _1644_ sky130_fd_sc_hd__mux2i_1
X_4193_ mem\[8\]\[12\] mem\[10\]\[12\] _1480_ VSS VSS VDD
+ VDD _1645_ sky130_fd_sc_hd__mux2_1
X_4194_ _1568_ _1569_ _1645_ VSS VSS VDD VDD _1646_ sky130_fd_sc_hd__nand3_1
X_4195_ _1567_ _0936_ _1646_ _1572_ VSS VSS VDD VDD _1647_
+ sky130_fd_sc_hd__o22ai_1
X_4196_ _1574_ _1646_ VSS VSS VDD VDD _1648_ sky130_fd_sc_hd__nor2_1
X_4197_ net222 _0928_ _1488_ VSS VSS VDD VDD _1649_ sky130_fd_sc_hd__o21ai_0
X_4198_ _0861_ _1647_ _1648_ _1649_ VSS VSS VDD VDD _1650_
+ sky130_fd_sc_hd__o22ai_1
X_4199_ _1564_ _1644_ _1650_ _1578_ VSS VSS VDD VDD _1651_
+ sky130_fd_sc_hd__o211ai_1
X_4200_ _0721_ VSS VSS VDD VDD _1652_ sky130_fd_sc_hd__buf_6
X_4201_ mem\[13\]\[12\] mem\[15\]\[12\] _1581_ VSS VSS VDD
+ VDD _1653_ sky130_fd_sc_hd__mux2i_1
X_4202_ _0827_ VSS VSS VDD VDD _1654_ sky130_fd_sc_hd__buf_4
X_4203_ _1654_ _1583_ _0927_ VSS VSS VDD VDD _1655_ sky130_fd_sc_hd__nand3_1
X_4204_ _0935_ _1495_ _1580_ _1653_ _1655_ VSS VSS VDD VDD
+ _1656_ sky130_fd_sc_hd__o221ai_1
X_4205_ mem\[9\]\[12\] mem\[11\]\[12\] _1608_ VSS VSS VDD
+ VDD _1657_ sky130_fd_sc_hd__mux2i_1
X_4206_ _1589_ _1657_ _1476_ VSS VSS VDD VDD _1658_ sky130_fd_sc_hd__o21ai_0
X_4207_ net116 _1652_ _1656_ _1658_ VSS VSS VDD VDD _1659_
+ sky130_fd_sc_hd__o22a_1
X_4208_ _1643_ _1651_ _1659_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__and3_1
X_4209_ mem\[5\]\[13\] mem\[7\]\[13\] _1533_ VSS VSS VDD VDD
+ _1660_ sky130_fd_sc_hd__mux2i_1
X_4210_ _1531_ _1660_ VSS VSS VDD VDD _1661_ sky130_fd_sc_hd__nor2_1
X_4211_ _0941_ _1527_ _1661_ VSS VSS VDD VDD _1662_ sky130_fd_sc_hd__a21oi_1
X_4212_ _1457_ VSS VSS VDD VDD _1663_ sky130_fd_sc_hd__buf_4
X_4213_ mem\[1\]\[13\] mem\[3\]\[13\] _1663_ VSS VSS VDD VDD
+ _1664_ sky130_fd_sc_hd__mux2_1
X_4214_ _1541_ _1543_ _1479_ _1664_ VSS VSS VDD VDD _1665_
+ sky130_fd_sc_hd__nand4_1
X_4215_ _1538_ _1539_ _0950_ _1665_ VSS VSS VDD VDD _1666_
+ sky130_fd_sc_hd__o31ai_1
X_4216_ mem\[4\]\[13\] mem\[6\]\[13\] _1550_ VSS VSS VDD VDD
+ _1667_ sky130_fd_sc_hd__mux2i_1
X_4217_ _0942_ _1548_ _1549_ _1667_ _1552_ VSS VSS VDD VDD
+ _1668_ sky130_fd_sc_hd__o221ai_1
X_4218_ _1537_ _1666_ _1668_ VSS VSS VDD VDD _1669_ sky130_fd_sc_hd__o21ai_0
X_4219_ _1471_ VSS VSS VDD VDD _1670_ sky130_fd_sc_hd__clkbuf_4
X_4220_ mem\[1\]\[13\] _1555_ _1556_ mem\[0\]\[13\] VSS VSS
+ VDD VDD _1671_ sky130_fd_sc_hd__o22ai_1
X_4221_ _1462_ VSS VSS VDD VDD _1672_ sky130_fd_sc_hd__buf_4
X_4222_ _1464_ VSS VSS VDD VDD _1673_ sky130_fd_sc_hd__buf_4
X_4223_ mem\[2\]\[13\] _1672_ _1673_ mem\[3\]\[13\] VSS VSS
+ VDD VDD _1674_ sky130_fd_sc_hd__o22ai_1
X_4224_ _1670_ _1671_ _1674_ VSS VSS VDD VDD _1675_ sky130_fd_sc_hd__or3_1
X_4225_ _1525_ _1662_ _1669_ _1675_ _1561_ VSS VSS VDD VDD
+ _1676_ sky130_fd_sc_hd__o2111ai_2
X_4226_ mem\[12\]\[13\] mem\[14\]\[13\] _1565_ VSS VSS VDD
+ VDD _1677_ sky130_fd_sc_hd__mux2i_1
X_4227_ mem\[8\]\[13\] mem\[10\]\[13\] _1480_ VSS VSS VDD
+ VDD _1678_ sky130_fd_sc_hd__mux2_1
X_4228_ _1568_ _1569_ _1678_ VSS VSS VDD VDD _1679_ sky130_fd_sc_hd__nand3_1
X_4229_ _1567_ _0955_ _1679_ _1572_ VSS VSS VDD VDD _1680_
+ sky130_fd_sc_hd__o22ai_1
X_4230_ _1574_ _1679_ VSS VSS VDD VDD _1681_ sky130_fd_sc_hd__nor2_1
X_4231_ net222 _0946_ _1488_ VSS VSS VDD VDD _1682_ sky130_fd_sc_hd__o21ai_0
X_4232_ _0861_ _1680_ _1681_ _1682_ VSS VSS VDD VDD _1683_
+ sky130_fd_sc_hd__o22ai_1
X_4233_ _1564_ _1677_ _1683_ _1578_ VSS VSS VDD VDD _1684_
+ sky130_fd_sc_hd__o211ai_1
X_4234_ _1494_ VSS VSS VDD VDD _1685_ sky130_fd_sc_hd__buf_4
X_4235_ mem\[13\]\[13\] mem\[15\]\[13\] _1581_ VSS VSS VDD
+ VDD _1686_ sky130_fd_sc_hd__mux2i_1
X_4236_ _1654_ _1583_ _0945_ VSS VSS VDD VDD _1687_ sky130_fd_sc_hd__nand3_1
X_4237_ _0953_ _1685_ _1580_ _1686_ _1687_ VSS VSS VDD VDD
+ _1688_ sky130_fd_sc_hd__o221ai_1
X_4238_ mem\[9\]\[13\] mem\[11\]\[13\] _1608_ VSS VSS VDD
+ VDD _1689_ sky130_fd_sc_hd__mux2i_1
X_4239_ _1589_ _1689_ _1476_ VSS VSS VDD VDD _1690_ sky130_fd_sc_hd__o21ai_0
X_4240_ net117 _1652_ _1688_ _1690_ VSS VSS VDD VDD _1691_
+ sky130_fd_sc_hd__o22a_1
X_4241_ _1676_ _1684_ _1691_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__and3_1
X_4242_ _1532_ VSS VSS VDD VDD _1692_ sky130_fd_sc_hd__buf_6
X_4243_ mem\[5\]\[14\] mem\[7\]\[14\] _1692_ VSS VSS VDD VDD
+ _1693_ sky130_fd_sc_hd__mux2i_1
X_4244_ _1531_ _1693_ VSS VSS VDD VDD _1694_ sky130_fd_sc_hd__nor2_1
X_4245_ _0960_ _1527_ _1694_ VSS VSS VDD VDD _1695_ sky130_fd_sc_hd__a21oi_1
X_4246_ mem\[1\]\[14\] mem\[3\]\[14\] _1663_ VSS VSS VDD VDD
+ _1696_ sky130_fd_sc_hd__mux2_1
X_4247_ _1541_ _1543_ _1479_ _1696_ VSS VSS VDD VDD _1697_
+ sky130_fd_sc_hd__nand4_1
X_4248_ _1538_ _1539_ _0969_ _1697_ VSS VSS VDD VDD _1698_
+ sky130_fd_sc_hd__o31ai_1
X_4249_ _1510_ VSS VSS VDD VDD _1699_ sky130_fd_sc_hd__buf_6
X_4250_ mem\[4\]\[14\] mem\[6\]\[14\] _1699_ VSS VSS VDD VDD
+ _1700_ sky130_fd_sc_hd__mux2i_1
X_4251_ _0961_ _1548_ _1549_ _1700_ _1552_ VSS VSS VDD VDD
+ _1701_ sky130_fd_sc_hd__o221ai_1
X_4252_ _1537_ _1698_ _1701_ VSS VSS VDD VDD _1702_ sky130_fd_sc_hd__o21ai_0
X_4253_ mem\[1\]\[14\] _1555_ _1556_ mem\[0\]\[14\] VSS VSS
+ VDD VDD _1703_ sky130_fd_sc_hd__o22ai_1
X_4254_ mem\[2\]\[14\] _1672_ _1673_ mem\[3\]\[14\] VSS VSS
+ VDD VDD _1704_ sky130_fd_sc_hd__o22ai_1
X_4255_ _1670_ _1703_ _1704_ VSS VSS VDD VDD _1705_ sky130_fd_sc_hd__or3_1
X_4256_ _1525_ _1695_ _1702_ _1705_ _1561_ VSS VSS VDD VDD
+ _1706_ sky130_fd_sc_hd__o2111ai_2
X_4257_ mem\[12\]\[14\] mem\[14\]\[14\] _1565_ VSS VSS VDD
+ VDD _1707_ sky130_fd_sc_hd__mux2i_1
X_4258_ _0715_ VSS VSS VDD VDD _1708_ sky130_fd_sc_hd__buf_6
X_4259_ _1457_ VSS VSS VDD VDD _1709_ sky130_fd_sc_hd__clkbuf_8
X_4260_ mem\[8\]\[14\] mem\[10\]\[14\] _1709_ VSS VSS VDD
+ VDD _1710_ sky130_fd_sc_hd__mux2_1
X_4261_ _1568_ _1569_ _1710_ VSS VSS VDD VDD _1711_ sky130_fd_sc_hd__nand3_1
X_4262_ _1708_ _0972_ _1711_ _1572_ VSS VSS VDD VDD _1712_
+ sky130_fd_sc_hd__o22ai_1
X_4263_ _1574_ _1711_ VSS VSS VDD VDD _1713_ sky130_fd_sc_hd__nor2_1
X_4264_ net222 _0965_ _1488_ VSS VSS VDD VDD _1714_ sky130_fd_sc_hd__o21ai_0
X_4265_ _0861_ _1712_ _1713_ _1714_ VSS VSS VDD VDD _1715_
+ sky130_fd_sc_hd__o22ai_1
X_4266_ _1564_ _1707_ _1715_ _1578_ VSS VSS VDD VDD _1716_
+ sky130_fd_sc_hd__o211ai_1
X_4267_ mem\[13\]\[14\] mem\[15\]\[14\] _1581_ VSS VSS VDD
+ VDD _1717_ sky130_fd_sc_hd__mux2i_1
X_4268_ _1654_ _1583_ _0964_ VSS VSS VDD VDD _1718_ sky130_fd_sc_hd__nand3_1
X_4269_ _0971_ _1685_ _1580_ _1717_ _1718_ VSS VSS VDD VDD
+ _1719_ sky130_fd_sc_hd__o221ai_1
X_4270_ mem\[9\]\[14\] mem\[11\]\[14\] _1608_ VSS VSS VDD
+ VDD _1720_ sky130_fd_sc_hd__mux2i_1
X_4271_ _1589_ _1720_ _1476_ VSS VSS VDD VDD _1721_ sky130_fd_sc_hd__o21ai_0
X_4272_ net118 _1652_ _1719_ _1721_ VSS VSS VDD VDD _1722_
+ sky130_fd_sc_hd__o22a_1
X_4273_ _1706_ _1716_ _1722_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__and3_1
X_4274_ mem\[13\]\[15\] mem\[15\]\[15\] _1599_ VSS VSS VDD
+ VDD _1723_ sky130_fd_sc_hd__mux2i_1
X_4275_ _0991_ _1597_ _1598_ _1723_ VSS VSS VDD VDD _1724_
+ sky130_fd_sc_hd__o22ai_1
X_4276_ _1595_ _1724_ _1593_ _2534_ VSS VSS VDD VDD _1725_
+ sky130_fd_sc_hd__a211oi_1
X_4277_ _1588_ VSS VSS VDD VDD _1726_ sky130_fd_sc_hd__buf_4
X_4278_ _1481_ VSS VSS VDD VDD _1727_ sky130_fd_sc_hd__buf_6
X_4279_ mem\[9\]\[15\] mem\[11\]\[15\] _1727_ VSS VSS VDD
+ VDD _1728_ sky130_fd_sc_hd__mux2i_1
X_4280_ _0982_ _1495_ _1726_ _1728_ _1595_ VSS VSS VDD VDD
+ _1729_ sky130_fd_sc_hd__o221ai_1
X_4281_ mem\[12\]\[15\] mem\[14\]\[15\] _1533_ VSS VSS VDD
+ VDD _1730_ sky130_fd_sc_hd__mux2i_1
X_4282_ _0850_ VSS VSS VDD VDD _1731_ sky130_fd_sc_hd__buf_6
X_4283_ _0990_ _1597_ _1598_ _1730_ _1731_ VSS VSS VDD VDD
+ _1732_ sky130_fd_sc_hd__o221ai_1
X_4284_ mem\[10\]\[15\] _1463_ _1465_ mem\[11\]\[15\] VSS
+ VSS VDD VDD _1733_ sky130_fd_sc_hd__o22ai_1
X_4285_ mem\[9\]\[15\] _1456_ _1460_ mem\[8\]\[15\] VSS VSS
+ VDD VDD _1734_ sky130_fd_sc_hd__o22ai_1
X_4286_ _1472_ _1733_ _1734_ VSS VSS VDD VDD _1735_ sky130_fd_sc_hd__nor3_1
X_4287_ _1729_ _1732_ _1735_ VSS VSS VDD VDD _1736_ sky130_fd_sc_hd__a21oi_1
X_4288_ _1580_ VSS VSS VDD VDD _1737_ sky130_fd_sc_hd__buf_6
X_4289_ _1581_ VSS VSS VDD VDD _1738_ sky130_fd_sc_hd__clkbuf_16
X_4290_ mem\[4\]\[15\] mem\[6\]\[15\] _1738_ VSS VSS VDD VDD
+ _1739_ sky130_fd_sc_hd__mux2i_1
X_4291_ _0715_ VSS VSS VDD VDD _1740_ sky130_fd_sc_hd__buf_4
X_4292_ mem\[0\]\[15\] mem\[2\]\[15\] _1483_ VSS VSS VDD VDD
+ _1741_ sky130_fd_sc_hd__mux2_1
X_4293_ _1540_ _1542_ _1741_ VSS VSS VDD VDD _1742_ sky130_fd_sc_hd__nand3_1
X_4294_ _1467_ VSS VSS VDD VDD _1743_ sky130_fd_sc_hd__buf_6
X_4295_ _1740_ _0979_ _1742_ _1743_ VSS VSS VDD VDD _1744_
+ sky130_fd_sc_hd__o22ai_1
X_4296_ _1468_ VSS VSS VDD VDD _1745_ sky130_fd_sc_hd__buf_6
X_4297_ _1745_ _1742_ VSS VSS VDD VDD _1746_ sky130_fd_sc_hd__nor2_1
X_4298_ _1567_ _0988_ _0828_ VSS VSS VDD VDD _1747_ sky130_fd_sc_hd__o21ai_0
X_4299_ _1514_ _1744_ _1746_ _1747_ VSS VSS VDD VDD _1748_
+ sky130_fd_sc_hd__o22ai_1
X_4300_ _1737_ _1739_ _1748_ _1509_ VSS VSS VDD VDD _1749_
+ sky130_fd_sc_hd__o211a_1
X_4301_ mem\[5\]\[15\] mem\[7\]\[15\] _1532_ VSS VSS VDD VDD
+ _1750_ sky130_fd_sc_hd__mux2i_1
X_4302_ _1530_ _1750_ VSS VSS VDD VDD _1751_ sky130_fd_sc_hd__nor2_1
X_4303_ _0896_ VSS VSS VDD VDD _1752_ sky130_fd_sc_hd__clkbuf_4
X_4304_ _1752_ _1489_ _0989_ VSS VSS VDD VDD _1753_ sky130_fd_sc_hd__nor3_1
X_4305_ _0897_ _1627_ _0977_ _1751_ _1753_ VSS VSS VDD VDD
+ _1754_ sky130_fd_sc_hd__a311o_1
X_4306_ mem\[1\]\[15\] mem\[3\]\[15\] _1727_ VSS VSS VDD VDD
+ _1755_ sky130_fd_sc_hd__mux2i_1
X_4307_ _1726_ _1755_ VSS VSS VDD VDD _1756_ sky130_fd_sc_hd__nor2_1
X_4308_ _1522_ _1754_ _1756_ _2537_ net119 VSS VSS VDD VDD
+ _1757_ sky130_fd_sc_hd__o32ai_1
X_4309_ _1725_ _1736_ _1749_ _1757_ VSS VSS VDD VDD _0573_
+ sky130_fd_sc_hd__a211oi_1
X_4310_ mem\[5\]\[16\] mem\[7\]\[16\] _1692_ VSS VSS VDD VDD
+ _1758_ sky130_fd_sc_hd__mux2i_1
X_4311_ _1531_ _1758_ VSS VSS VDD VDD _1759_ sky130_fd_sc_hd__nor2_1
X_4312_ _0998_ _1527_ _1759_ VSS VSS VDD VDD _1760_ sky130_fd_sc_hd__a21oi_1
X_4313_ mem\[1\]\[16\] mem\[3\]\[16\] _1663_ VSS VSS VDD VDD
+ _1761_ sky130_fd_sc_hd__mux2_1
X_4314_ _1541_ _1543_ _1479_ _1761_ VSS VSS VDD VDD _1762_
+ sky130_fd_sc_hd__nand4_1
X_4315_ _1538_ _1539_ _1008_ _1762_ VSS VSS VDD VDD _1763_
+ sky130_fd_sc_hd__o31ai_1
X_4316_ mem\[4\]\[16\] mem\[6\]\[16\] _1699_ VSS VSS VDD VDD
+ _1764_ sky130_fd_sc_hd__mux2i_1
X_4317_ _0999_ _1548_ _1549_ _1764_ _1552_ VSS VSS VDD VDD
+ _1765_ sky130_fd_sc_hd__o221ai_1
X_4318_ _1537_ _1763_ _1765_ VSS VSS VDD VDD _1766_ sky130_fd_sc_hd__o21ai_0
X_4319_ _1462_ VSS VSS VDD VDD _1767_ sky130_fd_sc_hd__buf_6
X_4320_ _1464_ VSS VSS VDD VDD _1768_ sky130_fd_sc_hd__buf_6
X_4321_ mem\[2\]\[16\] _1767_ _1768_ mem\[3\]\[16\] VSS VSS
+ VDD VDD _1769_ sky130_fd_sc_hd__o22ai_1
X_4322_ mem\[1\]\[16\] _1456_ _1460_ mem\[0\]\[16\] VSS VSS
+ VDD VDD _1770_ sky130_fd_sc_hd__o22ai_1
X_4323_ _1670_ _1769_ _1770_ VSS VSS VDD VDD _1771_ sky130_fd_sc_hd__or3_1
X_4324_ _1525_ _1760_ _1766_ _1771_ _1561_ VSS VSS VDD VDD
+ _1772_ sky130_fd_sc_hd__o2111ai_1
X_4325_ mem\[12\]\[16\] mem\[14\]\[16\] _1565_ VSS VSS VDD
+ VDD _1773_ sky130_fd_sc_hd__mux2i_1
X_4326_ mem\[8\]\[16\] mem\[10\]\[16\] _1709_ VSS VSS VDD
+ VDD _1774_ sky130_fd_sc_hd__mux2_1
X_4327_ _1568_ _1569_ _1774_ VSS VSS VDD VDD _1775_ sky130_fd_sc_hd__nand3_1
X_4328_ _1708_ _1011_ _1775_ _1572_ VSS VSS VDD VDD _1776_
+ sky130_fd_sc_hd__o22ai_1
X_4329_ _1574_ _1775_ VSS VSS VDD VDD _1777_ sky130_fd_sc_hd__nor2_1
X_4330_ _0827_ VSS VSS VDD VDD _1778_ sky130_fd_sc_hd__buf_4
X_4331_ net222 _1004_ _1778_ VSS VSS VDD VDD _1779_ sky130_fd_sc_hd__o21ai_0
X_4332_ _0861_ _1776_ _1777_ _1779_ VSS VSS VDD VDD _1780_
+ sky130_fd_sc_hd__o22ai_1
X_4333_ _1564_ _1773_ _1780_ _1578_ VSS VSS VDD VDD _1781_
+ sky130_fd_sc_hd__o211ai_1
X_4334_ _1529_ VSS VSS VDD VDD _1782_ sky130_fd_sc_hd__clkbuf_8
X_4335_ mem\[13\]\[16\] mem\[15\]\[16\] _1581_ VSS VSS VDD
+ VDD _1783_ sky130_fd_sc_hd__mux2i_1
X_4336_ _1654_ _1583_ _1003_ VSS VSS VDD VDD _1784_ sky130_fd_sc_hd__nand3_1
X_4337_ _1010_ _1685_ _1782_ _1783_ _1784_ VSS VSS VDD VDD
+ _1785_ sky130_fd_sc_hd__o221ai_1
X_4338_ mem\[9\]\[16\] mem\[11\]\[16\] _1608_ VSS VSS VDD
+ VDD _1786_ sky130_fd_sc_hd__mux2i_1
X_4339_ _1589_ _1786_ _1476_ VSS VSS VDD VDD _1787_ sky130_fd_sc_hd__o21ai_0
X_4340_ net120 _1652_ _1785_ _1787_ VSS VSS VDD VDD _1788_
+ sky130_fd_sc_hd__o22a_1
X_4341_ _1772_ _1781_ _1788_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__and3_1
X_4342_ mem\[5\]\[17\] mem\[7\]\[17\] _1692_ VSS VSS VDD VDD
+ _1789_ sky130_fd_sc_hd__mux2i_1
X_4343_ _1531_ _1789_ VSS VSS VDD VDD _1790_ sky130_fd_sc_hd__nor2_1
X_4344_ _1017_ _1527_ _1790_ VSS VSS VDD VDD _1791_ sky130_fd_sc_hd__a21oi_1
X_4345_ mem\[1\]\[17\] mem\[3\]\[17\] _1663_ VSS VSS VDD VDD
+ _1792_ sky130_fd_sc_hd__mux2_1
X_4346_ _1541_ _1543_ _1479_ _1792_ VSS VSS VDD VDD _1793_
+ sky130_fd_sc_hd__nand4_1
X_4347_ _1538_ _1539_ _1027_ _1793_ VSS VSS VDD VDD _1794_
+ sky130_fd_sc_hd__o31ai_1
X_4348_ mem\[4\]\[17\] mem\[6\]\[17\] _1699_ VSS VSS VDD VDD
+ _1795_ sky130_fd_sc_hd__mux2i_1
X_4349_ _0854_ VSS VSS VDD VDD _1796_ sky130_fd_sc_hd__buf_4
X_4350_ _1018_ _1548_ _1549_ _1795_ _1796_ VSS VSS VDD VDD
+ _1797_ sky130_fd_sc_hd__o221ai_1
X_4351_ _1537_ _1794_ _1797_ VSS VSS VDD VDD _1798_ sky130_fd_sc_hd__o21ai_0
X_4352_ mem\[1\]\[17\] _1555_ _1556_ mem\[0\]\[17\] VSS VSS
+ VDD VDD _1799_ sky130_fd_sc_hd__o22ai_1
X_4353_ mem\[2\]\[17\] _1672_ _1673_ mem\[3\]\[17\] VSS VSS
+ VDD VDD _1800_ sky130_fd_sc_hd__o22ai_1
X_4354_ _1670_ _1799_ _1800_ VSS VSS VDD VDD _1801_ sky130_fd_sc_hd__or3_1
X_4355_ _1525_ _1791_ _1798_ _1801_ _1561_ VSS VSS VDD VDD
+ _1802_ sky130_fd_sc_hd__o2111ai_1
X_4356_ mem\[12\]\[17\] mem\[14\]\[17\] _1565_ VSS VSS VDD
+ VDD _1803_ sky130_fd_sc_hd__mux2i_1
X_4357_ _1540_ VSS VSS VDD VDD _1804_ sky130_fd_sc_hd__buf_4
X_4358_ _1542_ VSS VSS VDD VDD _1805_ sky130_fd_sc_hd__clkbuf_8
X_4359_ mem\[8\]\[17\] mem\[10\]\[17\] _1709_ VSS VSS VDD
+ VDD _1806_ sky130_fd_sc_hd__mux2_1
X_4360_ _1804_ _1805_ _1806_ VSS VSS VDD VDD _1807_ sky130_fd_sc_hd__nand3_1
X_4361_ _1708_ _1030_ _1807_ _1572_ VSS VSS VDD VDD _1808_
+ sky130_fd_sc_hd__o22ai_1
X_4362_ _1574_ _1807_ VSS VSS VDD VDD _1809_ sky130_fd_sc_hd__nor2_1
X_4363_ _0715_ VSS VSS VDD VDD _1810_ sky130_fd_sc_hd__buf_6
X_4364_ _1810_ _1022_ _1778_ VSS VSS VDD VDD _1811_ sky130_fd_sc_hd__o21ai_0
X_4365_ _0861_ _1808_ _1809_ _1811_ VSS VSS VDD VDD _1812_
+ sky130_fd_sc_hd__o22ai_1
X_4366_ _1564_ _1803_ _1812_ _1578_ VSS VSS VDD VDD _1813_
+ sky130_fd_sc_hd__o211ai_1
X_4367_ mem\[13\]\[17\] mem\[15\]\[17\] _1581_ VSS VSS VDD
+ VDD _1814_ sky130_fd_sc_hd__mux2i_1
X_4368_ _1654_ _1583_ _1021_ VSS VSS VDD VDD _1815_ sky130_fd_sc_hd__nand3_1
X_4369_ _1029_ _1685_ _1782_ _1814_ _1815_ VSS VSS VDD VDD
+ _1816_ sky130_fd_sc_hd__o221ai_1
X_4370_ mem\[9\]\[17\] mem\[11\]\[17\] _1608_ VSS VSS VDD
+ VDD _1817_ sky130_fd_sc_hd__mux2i_1
X_4371_ _1589_ _1817_ _1476_ VSS VSS VDD VDD _1818_ sky130_fd_sc_hd__o21ai_0
X_4372_ net121 _1652_ _1816_ _1818_ VSS VSS VDD VDD _1819_
+ sky130_fd_sc_hd__o22a_1
X_4373_ _1802_ _1813_ _1819_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__and3_1
X_4374_ _1530_ VSS VSS VDD VDD _1820_ sky130_fd_sc_hd__buf_4
X_4375_ mem\[5\]\[18\] mem\[7\]\[18\] _1692_ VSS VSS VDD VDD
+ _1821_ sky130_fd_sc_hd__mux2i_1
X_4376_ _1820_ _1821_ VSS VSS VDD VDD _1822_ sky130_fd_sc_hd__nor2_1
X_4377_ _1036_ _1527_ _1822_ VSS VSS VDD VDD _1823_ sky130_fd_sc_hd__a21oi_1
X_4378_ mem\[1\]\[18\] mem\[3\]\[18\] _1663_ VSS VSS VDD VDD
+ _1824_ sky130_fd_sc_hd__mux2_1
X_4379_ _1541_ _1543_ _1479_ _1824_ VSS VSS VDD VDD _1825_
+ sky130_fd_sc_hd__nand4_1
X_4380_ _1538_ _1539_ _1046_ _1825_ VSS VSS VDD VDD _1826_
+ sky130_fd_sc_hd__o31ai_1
X_4381_ _1596_ VSS VSS VDD VDD _1827_ sky130_fd_sc_hd__buf_4
X_4382_ mem\[4\]\[18\] mem\[6\]\[18\] _1699_ VSS VSS VDD VDD
+ _1828_ sky130_fd_sc_hd__mux2i_1
X_4383_ _1037_ _1827_ _1549_ _1828_ _1796_ VSS VSS VDD VDD
+ _1829_ sky130_fd_sc_hd__o221ai_1
X_4384_ _1537_ _1826_ _1829_ VSS VSS VDD VDD _1830_ sky130_fd_sc_hd__o21ai_0
X_4385_ mem\[1\]\[18\] _1555_ _1556_ mem\[0\]\[18\] VSS VSS
+ VDD VDD _1831_ sky130_fd_sc_hd__o22ai_1
X_4386_ mem\[2\]\[18\] _1672_ _1673_ mem\[3\]\[18\] VSS VSS
+ VDD VDD _1832_ sky130_fd_sc_hd__o22ai_1
X_4387_ _1670_ _1831_ _1832_ VSS VSS VDD VDD _1833_ sky130_fd_sc_hd__or3_1
X_4388_ _1525_ _1823_ _1830_ _1833_ _1561_ VSS VSS VDD VDD
+ _1834_ sky130_fd_sc_hd__o2111ai_1
X_4389_ mem\[12\]\[18\] mem\[14\]\[18\] _1565_ VSS VSS VDD
+ VDD _1835_ sky130_fd_sc_hd__mux2i_1
X_4390_ mem\[8\]\[18\] mem\[10\]\[18\] _1709_ VSS VSS VDD
+ VDD _1836_ sky130_fd_sc_hd__mux2_1
X_4391_ _1804_ _1805_ _1836_ VSS VSS VDD VDD _1837_ sky130_fd_sc_hd__nand3_1
X_4392_ _1708_ _1049_ _1837_ _1572_ VSS VSS VDD VDD _1838_
+ sky130_fd_sc_hd__o22ai_1
X_4393_ _1574_ _1837_ VSS VSS VDD VDD _1839_ sky130_fd_sc_hd__nor2_1
X_4394_ _1810_ _1042_ _1778_ VSS VSS VDD VDD _1840_ sky130_fd_sc_hd__o21ai_0
X_4395_ _0861_ _1838_ _1839_ _1840_ VSS VSS VDD VDD _1841_
+ sky130_fd_sc_hd__o22ai_1
X_4396_ _1564_ _1835_ _1841_ _1578_ VSS VSS VDD VDD _1842_
+ sky130_fd_sc_hd__o211ai_1
X_4397_ mem\[13\]\[18\] mem\[15\]\[18\] _1581_ VSS VSS VDD
+ VDD _1843_ sky130_fd_sc_hd__mux2i_1
X_4398_ _1654_ _1583_ _1040_ VSS VSS VDD VDD _1844_ sky130_fd_sc_hd__nand3_1
X_4399_ _1048_ _1685_ _1782_ _1843_ _1844_ VSS VSS VDD VDD
+ _1845_ sky130_fd_sc_hd__o221ai_1
X_4400_ mem\[9\]\[18\] mem\[11\]\[18\] _1608_ VSS VSS VDD
+ VDD _1846_ sky130_fd_sc_hd__mux2i_1
X_4401_ _1589_ _1846_ _1476_ VSS VSS VDD VDD _1847_ sky130_fd_sc_hd__o21ai_0
X_4402_ net123 _1652_ _1845_ _1847_ VSS VSS VDD VDD _1848_
+ sky130_fd_sc_hd__o22a_1
X_4403_ _1834_ _1842_ _1848_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__and3_1
X_4404_ mem\[5\]\[19\] mem\[7\]\[19\] _1692_ VSS VSS VDD VDD
+ _1849_ sky130_fd_sc_hd__mux2i_1
X_4405_ _1820_ _1849_ VSS VSS VDD VDD _1850_ sky130_fd_sc_hd__nor2_1
X_4406_ _1055_ _1527_ _1850_ VSS VSS VDD VDD _1851_ sky130_fd_sc_hd__a21oi_1
X_4407_ _0827_ VSS VSS VDD VDD _1852_ sky130_fd_sc_hd__buf_4
X_4408_ mem\[1\]\[19\] mem\[3\]\[19\] _1663_ VSS VSS VDD VDD
+ _1853_ sky130_fd_sc_hd__mux2_1
X_4409_ _1541_ _1543_ _1479_ _1853_ VSS VSS VDD VDD _1854_
+ sky130_fd_sc_hd__nand4_1
X_4410_ _1852_ _1539_ _1064_ _1854_ VSS VSS VDD VDD _1855_
+ sky130_fd_sc_hd__o31ai_1
X_4411_ mem\[4\]\[19\] mem\[6\]\[19\] _1699_ VSS VSS VDD VDD
+ _1856_ sky130_fd_sc_hd__mux2i_1
X_4412_ _1056_ _1827_ _1549_ _1856_ _1796_ VSS VSS VDD VDD
+ _1857_ sky130_fd_sc_hd__o221ai_1
X_4413_ _1537_ _1855_ _1857_ VSS VSS VDD VDD _1858_ sky130_fd_sc_hd__o21ai_0
X_4414_ mem\[1\]\[19\] _1555_ _1556_ mem\[0\]\[19\] VSS VSS
+ VDD VDD _1859_ sky130_fd_sc_hd__o22ai_1
X_4415_ mem\[2\]\[19\] _1672_ _1673_ mem\[3\]\[19\] VSS VSS
+ VDD VDD _1860_ sky130_fd_sc_hd__o22ai_1
X_4416_ _1670_ _1859_ _1860_ VSS VSS VDD VDD _1861_ sky130_fd_sc_hd__or3_1
X_4417_ _1525_ _1851_ _1858_ _1861_ _1561_ VSS VSS VDD VDD
+ _1862_ sky130_fd_sc_hd__o2111ai_1
X_4418_ mem\[12\]\[19\] mem\[14\]\[19\] _1565_ VSS VSS VDD
+ VDD _1863_ sky130_fd_sc_hd__mux2i_1
X_4419_ _0860_ VSS VSS VDD VDD _1864_ sky130_fd_sc_hd__buf_6
X_4420_ mem\[8\]\[19\] mem\[10\]\[19\] _1709_ VSS VSS VDD
+ VDD _1865_ sky130_fd_sc_hd__mux2_1
X_4421_ _1804_ _1805_ _1865_ VSS VSS VDD VDD _1866_ sky130_fd_sc_hd__nand3_1
X_4422_ _1708_ _1067_ _1866_ _1572_ VSS VSS VDD VDD _1867_
+ sky130_fd_sc_hd__o22ai_1
X_4423_ _1574_ _1866_ VSS VSS VDD VDD _1868_ sky130_fd_sc_hd__nor2_1
X_4424_ _1810_ _1060_ _1778_ VSS VSS VDD VDD _1869_ sky130_fd_sc_hd__o21ai_0
X_4425_ _1864_ _1867_ _1868_ _1869_ VSS VSS VDD VDD _1870_
+ sky130_fd_sc_hd__o22ai_1
X_4426_ _1564_ _1863_ _1870_ _1578_ VSS VSS VDD VDD _1871_
+ sky130_fd_sc_hd__o211ai_1
X_4427_ _1510_ VSS VSS VDD VDD _1872_ sky130_fd_sc_hd__buf_8
X_4428_ mem\[13\]\[19\] mem\[15\]\[19\] _1872_ VSS VSS VDD
+ VDD _1873_ sky130_fd_sc_hd__mux2i_1
X_4429_ _1654_ _1583_ _1059_ VSS VSS VDD VDD _1874_ sky130_fd_sc_hd__nand3_1
X_4430_ _1066_ _1685_ _1782_ _1873_ _1874_ VSS VSS VDD VDD
+ _1875_ sky130_fd_sc_hd__o221ai_1
X_4431_ _1587_ VSS VSS VDD VDD _1876_ sky130_fd_sc_hd__buf_6
X_4432_ mem\[9\]\[19\] mem\[11\]\[19\] _1608_ VSS VSS VDD
+ VDD _1877_ sky130_fd_sc_hd__mux2i_1
X_4433_ _1876_ _1877_ _1476_ VSS VSS VDD VDD _1878_ sky130_fd_sc_hd__o21ai_0
X_4434_ net124 _1652_ _1875_ _1878_ VSS VSS VDD VDD _1879_
+ sky130_fd_sc_hd__o22a_1
X_4435_ _1862_ _1871_ _1879_ VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__and3_1
X_4436_ mem\[13\]\[1\] mem\[15\]\[1\] _1599_ VSS VSS VDD VDD
+ _1880_ sky130_fd_sc_hd__mux2i_1
X_4437_ _1086_ _1597_ _1598_ _1880_ VSS VSS VDD VDD _1881_
+ sky130_fd_sc_hd__o22ai_1
X_4438_ _1595_ _1881_ _1593_ net163 VSS VSS VDD VDD _1882_
+ sky130_fd_sc_hd__a211oi_1
X_4439_ mem\[9\]\[1\] mem\[11\]\[1\] _1727_ VSS VSS VDD VDD
+ _1883_ sky130_fd_sc_hd__mux2i_1
X_4440_ _1077_ _1495_ _1726_ _1883_ _1595_ VSS VSS VDD VDD
+ _1884_ sky130_fd_sc_hd__o221ai_1
X_4441_ mem\[12\]\[1\] mem\[14\]\[1\] _1533_ VSS VSS VDD VDD
+ _1885_ sky130_fd_sc_hd__mux2i_1
X_4442_ _1085_ _1597_ _1598_ _1885_ _1731_ VSS VSS VDD VDD
+ _1886_ sky130_fd_sc_hd__o221ai_1
X_4443_ mem\[10\]\[1\] _1463_ _1465_ mem\[11\]\[1\] VSS VSS
+ VDD VDD _1887_ sky130_fd_sc_hd__o22ai_1
X_4444_ mem\[9\]\[1\] _1456_ _1460_ mem\[8\]\[1\] VSS VSS
+ VDD VDD _1888_ sky130_fd_sc_hd__o22ai_1
X_4445_ _1472_ _1887_ _1888_ VSS VSS VDD VDD _1889_ sky130_fd_sc_hd__nor3_1
X_4446_ _1884_ _1886_ _1889_ VSS VSS VDD VDD _1890_ sky130_fd_sc_hd__a21oi_1
X_4447_ mem\[4\]\[1\] mem\[6\]\[1\] _1738_ VSS VSS VDD VDD
+ _1891_ sky130_fd_sc_hd__mux2i_1
X_4448_ mem\[0\]\[1\] mem\[2\]\[1\] _1483_ VSS VSS VDD VDD
+ _1892_ sky130_fd_sc_hd__mux2_1
X_4449_ _1540_ _1542_ _1892_ VSS VSS VDD VDD _1893_ sky130_fd_sc_hd__nand3_1
X_4450_ _1740_ _1074_ _1893_ _1743_ VSS VSS VDD VDD _1894_
+ sky130_fd_sc_hd__o22ai_1
X_4451_ _1745_ _1893_ VSS VSS VDD VDD _1895_ sky130_fd_sc_hd__nor2_1
X_4452_ _1567_ _1083_ _0828_ VSS VSS VDD VDD _1896_ sky130_fd_sc_hd__o21ai_0
X_4453_ _1514_ _1894_ _1895_ _1896_ VSS VSS VDD VDD _1897_
+ sky130_fd_sc_hd__o22ai_1
X_4454_ _1737_ _1891_ _1897_ _1509_ VSS VSS VDD VDD _1898_
+ sky130_fd_sc_hd__o211a_1
X_4455_ mem\[5\]\[1\] mem\[7\]\[1\] _1532_ VSS VSS VDD VDD
+ _1899_ sky130_fd_sc_hd__mux2i_1
X_4456_ _1530_ _1899_ VSS VSS VDD VDD _1900_ sky130_fd_sc_hd__nor2_1
X_4457_ _1752_ _1489_ _1084_ VSS VSS VDD VDD _1901_ sky130_fd_sc_hd__nor3_1
X_4458_ _1752_ _1627_ _1073_ _1900_ _1901_ VSS VSS VDD VDD
+ _1902_ sky130_fd_sc_hd__a311o_1
X_4459_ mem\[1\]\[1\] mem\[3\]\[1\] _1727_ VSS VSS VDD VDD
+ _1903_ sky130_fd_sc_hd__mux2i_1
X_4460_ _1726_ _1903_ VSS VSS VDD VDD _1904_ sky130_fd_sc_hd__nor2_1
X_4461_ _1522_ _1902_ _1904_ _2537_ net104 VSS VSS VDD VDD
+ _1905_ sky130_fd_sc_hd__o32ai_1
X_4462_ _1882_ _1890_ _1898_ _1905_ VSS VSS VDD VDD _0578_
+ sky130_fd_sc_hd__a211oi_1
X_4463_ mem\[5\]\[20\] mem\[7\]\[20\] _1692_ VSS VSS VDD VDD
+ _1906_ sky130_fd_sc_hd__mux2i_1
X_4464_ _1820_ _1906_ VSS VSS VDD VDD _1907_ sky130_fd_sc_hd__nor2_1
X_4465_ _1092_ _1527_ _1907_ VSS VSS VDD VDD _1908_ sky130_fd_sc_hd__a21oi_1
X_4466_ mem\[1\]\[20\] mem\[3\]\[20\] _1663_ VSS VSS VDD VDD
+ _1909_ sky130_fd_sc_hd__mux2_1
X_4467_ _1541_ _1543_ _1479_ _1909_ VSS VSS VDD VDD _1910_
+ sky130_fd_sc_hd__nand4_1
X_4468_ _1852_ _1539_ _1102_ _1910_ VSS VSS VDD VDD _1911_
+ sky130_fd_sc_hd__o31ai_1
X_4469_ mem\[4\]\[20\] mem\[6\]\[20\] _1699_ VSS VSS VDD VDD
+ _1912_ sky130_fd_sc_hd__mux2i_1
X_4470_ _1093_ _1827_ _1549_ _1912_ _1796_ VSS VSS VDD VDD
+ _1913_ sky130_fd_sc_hd__o221ai_1
X_4471_ _1537_ _1911_ _1913_ VSS VSS VDD VDD _1914_ sky130_fd_sc_hd__o21ai_0
X_4472_ mem\[2\]\[20\] _1767_ _1768_ mem\[3\]\[20\] VSS VSS
+ VDD VDD _1915_ sky130_fd_sc_hd__o22ai_1
X_4473_ mem\[1\]\[20\] _1456_ _1460_ mem\[0\]\[20\] VSS VSS
+ VDD VDD _1916_ sky130_fd_sc_hd__o22ai_1
X_4474_ _1670_ _1915_ _1916_ VSS VSS VDD VDD _1917_ sky130_fd_sc_hd__or3_1
X_4475_ _1525_ _1908_ _1914_ _1917_ _1561_ VSS VSS VDD VDD
+ _1918_ sky130_fd_sc_hd__o2111ai_1
X_4476_ mem\[12\]\[20\] mem\[14\]\[20\] _1565_ VSS VSS VDD
+ VDD _1919_ sky130_fd_sc_hd__mux2i_1
X_4477_ mem\[8\]\[20\] mem\[10\]\[20\] _1709_ VSS VSS VDD
+ VDD _1920_ sky130_fd_sc_hd__mux2_1
X_4478_ _1804_ _1805_ _1920_ VSS VSS VDD VDD _1921_ sky130_fd_sc_hd__nand3_1
X_4479_ _1708_ _1105_ _1921_ _1572_ VSS VSS VDD VDD _1922_
+ sky130_fd_sc_hd__o22ai_1
X_4480_ _1574_ _1921_ VSS VSS VDD VDD _1923_ sky130_fd_sc_hd__nor2_1
X_4481_ _1810_ _1097_ _1778_ VSS VSS VDD VDD _1924_ sky130_fd_sc_hd__o21ai_0
X_4482_ _1864_ _1922_ _1923_ _1924_ VSS VSS VDD VDD _1925_
+ sky130_fd_sc_hd__o22ai_1
X_4483_ _1564_ _1919_ _1925_ _1578_ VSS VSS VDD VDD _1926_
+ sky130_fd_sc_hd__o211ai_1
X_4484_ mem\[13\]\[20\] mem\[15\]\[20\] _1872_ VSS VSS VDD
+ VDD _1927_ sky130_fd_sc_hd__mux2i_1
X_4485_ _1654_ _1583_ _1096_ VSS VSS VDD VDD _1928_ sky130_fd_sc_hd__nand3_1
X_4486_ _1104_ _1685_ _1782_ _1927_ _1928_ VSS VSS VDD VDD
+ _1929_ sky130_fd_sc_hd__o221ai_1
X_4487_ mem\[9\]\[20\] mem\[11\]\[20\] _1608_ VSS VSS VDD
+ VDD _1930_ sky130_fd_sc_hd__mux2i_1
X_4488_ _1876_ _1930_ _1476_ VSS VSS VDD VDD _1931_ sky130_fd_sc_hd__o21ai_0
X_4489_ net125 _1652_ _1929_ _1931_ VSS VSS VDD VDD _1932_
+ sky130_fd_sc_hd__o22a_1
X_4490_ _1918_ _1926_ _1932_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__and3_1
X_4491_ _0850_ VSS VSS VDD VDD _1933_ sky130_fd_sc_hd__buf_6
X_4492_ mem\[5\]\[21\] mem\[7\]\[21\] _1692_ VSS VSS VDD VDD
+ _1934_ sky130_fd_sc_hd__mux2i_1
X_4493_ _1820_ _1934_ VSS VSS VDD VDD _1935_ sky130_fd_sc_hd__nor2_1
X_4494_ _1110_ _1527_ _1935_ VSS VSS VDD VDD _1936_ sky130_fd_sc_hd__a21oi_1
X_4495_ _0839_ VSS VSS VDD VDD _1937_ sky130_fd_sc_hd__buf_4
X_4496_ _0715_ VSS VSS VDD VDD _1938_ sky130_fd_sc_hd__buf_4
X_4497_ _1478_ VSS VSS VDD VDD _1939_ sky130_fd_sc_hd__clkbuf_4
X_4498_ mem\[1\]\[21\] mem\[3\]\[21\] _1663_ VSS VSS VDD VDD
+ _1940_ sky130_fd_sc_hd__mux2_1
X_4499_ _1541_ _1543_ _1939_ _1940_ VSS VSS VDD VDD _1941_
+ sky130_fd_sc_hd__nand4_1
X_4500_ _1852_ _1938_ _1120_ _1941_ VSS VSS VDD VDD _1942_
+ sky130_fd_sc_hd__o31ai_1
X_4501_ _1529_ VSS VSS VDD VDD _1943_ sky130_fd_sc_hd__buf_4
X_4502_ mem\[4\]\[21\] mem\[6\]\[21\] _1699_ VSS VSS VDD VDD
+ _1944_ sky130_fd_sc_hd__mux2i_1
X_4503_ _1112_ _1827_ _1943_ _1944_ _1796_ VSS VSS VDD VDD
+ _1945_ sky130_fd_sc_hd__o221ai_1
X_4504_ _1937_ _1942_ _1945_ VSS VSS VDD VDD _1946_ sky130_fd_sc_hd__o21ai_0
X_4505_ _1455_ VSS VSS VDD VDD _1947_ sky130_fd_sc_hd__buf_4
X_4506_ _1459_ VSS VSS VDD VDD _1948_ sky130_fd_sc_hd__buf_4
X_4507_ mem\[1\]\[21\] _1947_ _1948_ mem\[0\]\[21\] VSS VSS
+ VDD VDD _1949_ sky130_fd_sc_hd__o22ai_1
X_4508_ mem\[2\]\[21\] _1672_ _1673_ mem\[3\]\[21\] VSS VSS
+ VDD VDD _1950_ sky130_fd_sc_hd__o22ai_1
X_4509_ _1670_ _1949_ _1950_ VSS VSS VDD VDD _1951_ sky130_fd_sc_hd__or3_1
X_4510_ _1933_ _1936_ _1946_ _1951_ _1561_ VSS VSS VDD VDD
+ _1952_ sky130_fd_sc_hd__o2111ai_2
X_4511_ _1549_ VSS VSS VDD VDD _1953_ sky130_fd_sc_hd__clkbuf_8
X_4512_ _1550_ VSS VSS VDD VDD _1954_ sky130_fd_sc_hd__buf_8
X_4513_ mem\[12\]\[21\] mem\[14\]\[21\] _1954_ VSS VSS VDD
+ VDD _1955_ sky130_fd_sc_hd__mux2i_1
X_4514_ mem\[8\]\[21\] mem\[10\]\[21\] _1709_ VSS VSS VDD
+ VDD _1956_ sky130_fd_sc_hd__mux2_1
X_4515_ _1804_ _1805_ _1956_ VSS VSS VDD VDD _1957_ sky130_fd_sc_hd__nand3_1
X_4516_ _1467_ VSS VSS VDD VDD _1958_ sky130_fd_sc_hd__clkbuf_8
X_4517_ _1708_ _1123_ _1957_ _1958_ VSS VSS VDD VDD _1959_
+ sky130_fd_sc_hd__o22ai_1
X_4518_ _1468_ VSS VSS VDD VDD _1960_ sky130_fd_sc_hd__clkbuf_8
X_4519_ _1960_ _1957_ VSS VSS VDD VDD _1961_ sky130_fd_sc_hd__nor2_1
X_4520_ _1810_ _1116_ _1778_ VSS VSS VDD VDD _1962_ sky130_fd_sc_hd__o21ai_0
X_4521_ _1864_ _1959_ _1961_ _1962_ VSS VSS VDD VDD _1963_
+ sky130_fd_sc_hd__o22ai_1
X_4522_ _1953_ _1955_ _1963_ _1578_ VSS VSS VDD VDD _1964_
+ sky130_fd_sc_hd__o211ai_1
X_4523_ mem\[13\]\[21\] mem\[15\]\[21\] _1872_ VSS VSS VDD
+ VDD _1965_ sky130_fd_sc_hd__mux2i_1
X_4524_ _1654_ _1583_ _1115_ VSS VSS VDD VDD _1966_ sky130_fd_sc_hd__nand3_1
X_4525_ _1122_ _1685_ _1782_ _1965_ _1966_ VSS VSS VDD VDD
+ _1967_ sky130_fd_sc_hd__o221ai_1
X_4526_ _1532_ VSS VSS VDD VDD _1968_ sky130_fd_sc_hd__buf_6
X_4527_ mem\[9\]\[21\] mem\[11\]\[21\] _1968_ VSS VSS VDD
+ VDD _1969_ sky130_fd_sc_hd__mux2i_1
X_4528_ _1475_ VSS VSS VDD VDD _1970_ sky130_fd_sc_hd__buf_4
X_4529_ _1876_ _1969_ _1970_ VSS VSS VDD VDD _1971_ sky130_fd_sc_hd__o21ai_0
X_4530_ net126 _1652_ _1967_ _1971_ VSS VSS VDD VDD _1972_
+ sky130_fd_sc_hd__o22a_1
X_4531_ _1952_ _1964_ _1972_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__and3_1
X_4532_ _1526_ VSS VSS VDD VDD _1973_ sky130_fd_sc_hd__buf_4
X_4533_ mem\[5\]\[22\] mem\[7\]\[22\] _1692_ VSS VSS VDD VDD
+ _1974_ sky130_fd_sc_hd__mux2i_1
X_4534_ _1820_ _1974_ VSS VSS VDD VDD _1975_ sky130_fd_sc_hd__nor2_1
X_4535_ _1129_ _1973_ _1975_ VSS VSS VDD VDD _1976_ sky130_fd_sc_hd__a21oi_1
X_4536_ _1540_ VSS VSS VDD VDD _1977_ sky130_fd_sc_hd__buf_4
X_4537_ _1542_ VSS VSS VDD VDD _1978_ sky130_fd_sc_hd__buf_4
X_4538_ mem\[1\]\[22\] mem\[3\]\[22\] _1663_ VSS VSS VDD VDD
+ _1979_ sky130_fd_sc_hd__mux2_1
X_4539_ _1977_ _1978_ _1939_ _1979_ VSS VSS VDD VDD _1980_
+ sky130_fd_sc_hd__nand4_1
X_4540_ _1852_ _1938_ _1139_ _1980_ VSS VSS VDD VDD _1981_
+ sky130_fd_sc_hd__o31ai_1
X_4541_ mem\[4\]\[22\] mem\[6\]\[22\] _1699_ VSS VSS VDD VDD
+ _1982_ sky130_fd_sc_hd__mux2i_1
X_4542_ _1130_ _1827_ _1943_ _1982_ _1796_ VSS VSS VDD VDD
+ _1983_ sky130_fd_sc_hd__o221ai_1
X_4543_ _1937_ _1981_ _1983_ VSS VSS VDD VDD _1984_ sky130_fd_sc_hd__o21ai_0
X_4544_ mem\[1\]\[22\] _1947_ _1948_ mem\[0\]\[22\] VSS VSS
+ VDD VDD _1985_ sky130_fd_sc_hd__o22ai_1
X_4545_ mem\[2\]\[22\] _1672_ _1673_ mem\[3\]\[22\] VSS VSS
+ VDD VDD _1986_ sky130_fd_sc_hd__o22ai_1
X_4546_ _1670_ _1985_ _1986_ VSS VSS VDD VDD _1987_ sky130_fd_sc_hd__or3_1
X_4547_ _1560_ VSS VSS VDD VDD _1988_ sky130_fd_sc_hd__buf_6
X_4548_ _1933_ _1976_ _1984_ _1987_ _1988_ VSS VSS VDD VDD
+ _1989_ sky130_fd_sc_hd__o2111ai_2
X_4549_ mem\[12\]\[22\] mem\[14\]\[22\] _1954_ VSS VSS VDD
+ VDD _1990_ sky130_fd_sc_hd__mux2i_1
X_4550_ mem\[8\]\[22\] mem\[10\]\[22\] _1709_ VSS VSS VDD
+ VDD _1991_ sky130_fd_sc_hd__mux2_1
X_4551_ _1804_ _1805_ _1991_ VSS VSS VDD VDD _1992_ sky130_fd_sc_hd__nand3_1
X_4552_ _1708_ _1144_ _1992_ _1958_ VSS VSS VDD VDD _1993_
+ sky130_fd_sc_hd__o22ai_1
X_4553_ _1960_ _1992_ VSS VSS VDD VDD _1994_ sky130_fd_sc_hd__nor2_1
X_4554_ _1810_ _1135_ _1778_ VSS VSS VDD VDD _1995_ sky130_fd_sc_hd__o21ai_0
X_4555_ _1864_ _1993_ _1994_ _1995_ VSS VSS VDD VDD _1996_
+ sky130_fd_sc_hd__o22ai_1
X_4556_ _1501_ VSS VSS VDD VDD _1997_ sky130_fd_sc_hd__buf_4
X_4557_ _1953_ _1990_ _1996_ _1997_ VSS VSS VDD VDD _1998_
+ sky130_fd_sc_hd__o211ai_1
X_4558_ mem\[13\]\[22\] mem\[15\]\[22\] _1872_ VSS VSS VDD
+ VDD _1999_ sky130_fd_sc_hd__mux2i_1
X_4559_ _0714_ VSS VSS VDD VDD _2000_ sky130_fd_sc_hd__clkbuf_8
X_4560_ _1654_ _2000_ _1133_ VSS VSS VDD VDD _2001_ sky130_fd_sc_hd__nand3_1
X_4561_ _1143_ _1685_ _1782_ _1999_ _2001_ VSS VSS VDD VDD
+ _2002_ sky130_fd_sc_hd__o221ai_1
X_4562_ mem\[9\]\[22\] mem\[11\]\[22\] _1968_ VSS VSS VDD
+ VDD _2003_ sky130_fd_sc_hd__mux2i_1
X_4563_ _1876_ _2003_ _1970_ VSS VSS VDD VDD _2004_ sky130_fd_sc_hd__o21ai_0
X_4564_ net127 _1652_ _2002_ _2004_ VSS VSS VDD VDD _2005_
+ sky130_fd_sc_hd__o22a_1
X_4565_ _1989_ _1998_ _2005_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__and3_1
X_4566_ mem\[5\]\[23\] mem\[7\]\[23\] _1692_ VSS VSS VDD VDD
+ _2006_ sky130_fd_sc_hd__mux2i_1
X_4567_ _1820_ _2006_ VSS VSS VDD VDD _2007_ sky130_fd_sc_hd__nor2_1
X_4568_ _1149_ _1973_ _2007_ VSS VSS VDD VDD _2008_ sky130_fd_sc_hd__a21oi_1
X_4569_ mem\[1\]\[23\] mem\[3\]\[23\] _1663_ VSS VSS VDD VDD
+ _2009_ sky130_fd_sc_hd__mux2_1
X_4570_ _1977_ _1978_ _1939_ _2009_ VSS VSS VDD VDD _2010_
+ sky130_fd_sc_hd__nand4_1
X_4571_ _1852_ _1938_ _1160_ _2010_ VSS VSS VDD VDD _2011_
+ sky130_fd_sc_hd__o31ai_1
X_4572_ mem\[4\]\[23\] mem\[6\]\[23\] _1699_ VSS VSS VDD VDD
+ _2012_ sky130_fd_sc_hd__mux2i_1
X_4573_ _1150_ _1827_ _1943_ _2012_ _1796_ VSS VSS VDD VDD
+ _2013_ sky130_fd_sc_hd__o221ai_1
X_4574_ _1937_ _2011_ _2013_ VSS VSS VDD VDD _2014_ sky130_fd_sc_hd__o21ai_0
X_4575_ mem\[1\]\[23\] _1947_ _1948_ mem\[0\]\[23\] VSS VSS
+ VDD VDD _2015_ sky130_fd_sc_hd__o22ai_1
X_4576_ mem\[2\]\[23\] _1672_ _1673_ mem\[3\]\[23\] VSS VSS
+ VDD VDD _2016_ sky130_fd_sc_hd__o22ai_1
X_4577_ _1670_ _2015_ _2016_ VSS VSS VDD VDD _2017_ sky130_fd_sc_hd__or3_1
X_4578_ _1933_ _2008_ _2014_ _2017_ _1988_ VSS VSS VDD VDD
+ _2018_ sky130_fd_sc_hd__o2111ai_2
X_4579_ mem\[12\]\[23\] mem\[14\]\[23\] _1954_ VSS VSS VDD
+ VDD _2019_ sky130_fd_sc_hd__mux2i_1
X_4580_ mem\[8\]\[23\] mem\[10\]\[23\] _1709_ VSS VSS VDD
+ VDD _2020_ sky130_fd_sc_hd__mux2_1
X_4581_ _1804_ _1805_ _2020_ VSS VSS VDD VDD _2021_ sky130_fd_sc_hd__nand3_1
X_4582_ _1708_ _1163_ _2021_ _1958_ VSS VSS VDD VDD _2022_
+ sky130_fd_sc_hd__o22ai_1
X_4583_ _1960_ _2021_ VSS VSS VDD VDD _2023_ sky130_fd_sc_hd__nor2_1
X_4584_ _1810_ _1155_ _1778_ VSS VSS VDD VDD _2024_ sky130_fd_sc_hd__o21ai_0
X_4585_ _1864_ _2022_ _2023_ _2024_ VSS VSS VDD VDD _2025_
+ sky130_fd_sc_hd__o22ai_1
X_4586_ _1953_ _2019_ _2025_ _1997_ VSS VSS VDD VDD _2026_
+ sky130_fd_sc_hd__o211ai_1
X_4587_ _0721_ VSS VSS VDD VDD _2027_ sky130_fd_sc_hd__buf_4
X_4588_ mem\[13\]\[23\] mem\[15\]\[23\] _1872_ VSS VSS VDD
+ VDD _2028_ sky130_fd_sc_hd__mux2i_1
X_4589_ _0827_ VSS VSS VDD VDD _2029_ sky130_fd_sc_hd__clkbuf_8
X_4590_ _2029_ _2000_ _1154_ VSS VSS VDD VDD _2030_ sky130_fd_sc_hd__nand3_1
X_4591_ _1162_ _1685_ _1782_ _2028_ _2030_ VSS VSS VDD VDD
+ _2031_ sky130_fd_sc_hd__o221ai_1
X_4592_ mem\[9\]\[23\] mem\[11\]\[23\] _1968_ VSS VSS VDD
+ VDD _2032_ sky130_fd_sc_hd__mux2i_1
X_4593_ _1876_ _2032_ _1970_ VSS VSS VDD VDD _2033_ sky130_fd_sc_hd__o21ai_0
X_4594_ net128 _2027_ _2031_ _2033_ VSS VSS VDD VDD _2034_
+ sky130_fd_sc_hd__o22a_1
X_4595_ _2018_ _2026_ _2034_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__and3_1
X_4596_ mem\[13\]\[24\] mem\[15\]\[24\] _1599_ VSS VSS VDD
+ VDD _2035_ sky130_fd_sc_hd__mux2i_1
X_4597_ _1182_ _1597_ _1598_ _2035_ VSS VSS VDD VDD _2036_
+ sky130_fd_sc_hd__o22ai_1
X_4598_ _1595_ _2036_ _1593_ net163 VSS VSS VDD VDD _2037_
+ sky130_fd_sc_hd__a211oi_1
X_4599_ mem\[9\]\[24\] mem\[11\]\[24\] _1727_ VSS VSS VDD
+ VDD _2038_ sky130_fd_sc_hd__mux2i_1
X_4600_ _1173_ _1495_ _1726_ _2038_ _1595_ VSS VSS VDD VDD
+ _2039_ sky130_fd_sc_hd__o221ai_1
X_4601_ mem\[12\]\[24\] mem\[14\]\[24\] _1533_ VSS VSS VDD
+ VDD _2040_ sky130_fd_sc_hd__mux2i_1
X_4602_ _1181_ _1597_ _1531_ _2040_ _1731_ VSS VSS VDD VDD
+ _2041_ sky130_fd_sc_hd__o221ai_1
X_4603_ mem\[10\]\[24\] _1463_ _1465_ mem\[11\]\[24\] VSS
+ VSS VDD VDD _2042_ sky130_fd_sc_hd__o22ai_1
X_4604_ mem\[9\]\[24\] _1456_ _1460_ mem\[8\]\[24\] VSS VSS
+ VDD VDD _2043_ sky130_fd_sc_hd__o22ai_1
X_4605_ _1472_ _2042_ _2043_ VSS VSS VDD VDD _2044_ sky130_fd_sc_hd__nor3_1
X_4606_ _2039_ _2041_ _2044_ VSS VSS VDD VDD _2045_ sky130_fd_sc_hd__a21oi_1
X_4607_ mem\[4\]\[24\] mem\[6\]\[24\] _1738_ VSS VSS VDD VDD
+ _2046_ sky130_fd_sc_hd__mux2i_2
X_4608_ mem\[0\]\[24\] mem\[2\]\[24\] _1483_ VSS VSS VDD VDD
+ _2047_ sky130_fd_sc_hd__mux2_1
X_4609_ _1540_ _1542_ _2047_ VSS VSS VDD VDD _2048_ sky130_fd_sc_hd__nand3_1
X_4610_ _1740_ _1170_ _2048_ _1743_ VSS VSS VDD VDD _2049_
+ sky130_fd_sc_hd__o22ai_1
X_4611_ _1745_ _2048_ VSS VSS VDD VDD _2050_ sky130_fd_sc_hd__nor2_1
X_4612_ _1567_ _1179_ _0828_ VSS VSS VDD VDD _2051_ sky130_fd_sc_hd__o21ai_0
X_4613_ _1488_ _2049_ _2050_ _2051_ VSS VSS VDD VDD _2052_
+ sky130_fd_sc_hd__o22ai_1
X_4614_ _1737_ _2046_ _2052_ _1509_ VSS VSS VDD VDD _2053_
+ sky130_fd_sc_hd__o211a_1
X_4615_ mem\[5\]\[24\] mem\[7\]\[24\] _1532_ VSS VSS VDD VDD
+ _2054_ sky130_fd_sc_hd__mux2i_1
X_4616_ _1530_ _2054_ VSS VSS VDD VDD _2055_ sky130_fd_sc_hd__nor2_1
X_4617_ _1752_ _1489_ _1180_ VSS VSS VDD VDD _2056_ sky130_fd_sc_hd__nor3_1
X_4618_ _1752_ _1627_ _1168_ _2055_ _2056_ VSS VSS VDD VDD
+ _2057_ sky130_fd_sc_hd__a311o_1
X_4619_ mem\[1\]\[24\] mem\[3\]\[24\] _1727_ VSS VSS VDD VDD
+ _2058_ sky130_fd_sc_hd__mux2i_1
X_4620_ _1726_ _2058_ VSS VSS VDD VDD _2059_ sky130_fd_sc_hd__nor2_1
X_4621_ _1522_ _2057_ _2059_ _2537_ net129 VSS VSS VDD VDD
+ _2060_ sky130_fd_sc_hd__o32ai_1
X_4622_ _2037_ _2045_ _2053_ _2060_ VSS VSS VDD VDD _0583_
+ sky130_fd_sc_hd__a211oi_1
X_4623_ mem\[5\]\[25\] mem\[7\]\[25\] _1692_ VSS VSS VDD VDD
+ _2061_ sky130_fd_sc_hd__mux2i_1
X_4624_ _1820_ _2061_ VSS VSS VDD VDD _2062_ sky130_fd_sc_hd__nor2_1
X_4625_ _1189_ _1973_ _2062_ VSS VSS VDD VDD _2063_ sky130_fd_sc_hd__a21oi_1
X_4626_ _1457_ VSS VSS VDD VDD _2064_ sky130_fd_sc_hd__buf_6
X_4627_ mem\[1\]\[25\] mem\[3\]\[25\] _2064_ VSS VSS VDD VDD
+ _2065_ sky130_fd_sc_hd__mux2_1
X_4628_ _1977_ _1978_ _1939_ _2065_ VSS VSS VDD VDD _2066_
+ sky130_fd_sc_hd__nand4_1
X_4629_ _1852_ _1938_ _1198_ _2066_ VSS VSS VDD VDD _2067_
+ sky130_fd_sc_hd__o31ai_1
X_4630_ mem\[4\]\[25\] mem\[6\]\[25\] _1699_ VSS VSS VDD VDD
+ _2068_ sky130_fd_sc_hd__mux2i_1
X_4631_ _1190_ _1827_ _1943_ _2068_ _1796_ VSS VSS VDD VDD
+ _2069_ sky130_fd_sc_hd__o221ai_1
X_4632_ _1937_ _2067_ _2069_ VSS VSS VDD VDD _2070_ sky130_fd_sc_hd__o21ai_0
X_4633_ _1471_ VSS VSS VDD VDD _2071_ sky130_fd_sc_hd__buf_4
X_4634_ mem\[2\]\[25\] _1767_ _1768_ mem\[3\]\[25\] VSS VSS
+ VDD VDD _2072_ sky130_fd_sc_hd__o22ai_1
X_4635_ mem\[1\]\[25\] _1456_ _1460_ mem\[0\]\[25\] VSS VSS
+ VDD VDD _2073_ sky130_fd_sc_hd__o22ai_1
X_4636_ _2071_ _2072_ _2073_ VSS VSS VDD VDD _2074_ sky130_fd_sc_hd__or3_1
X_4637_ _1933_ _2063_ _2070_ _2074_ _1988_ VSS VSS VDD VDD
+ _2075_ sky130_fd_sc_hd__o2111ai_2
X_4638_ mem\[12\]\[25\] mem\[14\]\[25\] _1954_ VSS VSS VDD
+ VDD _2076_ sky130_fd_sc_hd__mux2i_1
X_4639_ mem\[8\]\[25\] mem\[10\]\[25\] _1709_ VSS VSS VDD
+ VDD _2077_ sky130_fd_sc_hd__mux2_1
X_4640_ _1804_ _1805_ _2077_ VSS VSS VDD VDD _2078_ sky130_fd_sc_hd__nand3_1
X_4641_ _1708_ _1202_ _2078_ _1958_ VSS VSS VDD VDD _2079_
+ sky130_fd_sc_hd__o22ai_1
X_4642_ _1960_ _2078_ VSS VSS VDD VDD _2080_ sky130_fd_sc_hd__nor2_1
X_4643_ _1810_ _1194_ _1778_ VSS VSS VDD VDD _2081_ sky130_fd_sc_hd__o21ai_0
X_4644_ _1864_ _2079_ _2080_ _2081_ VSS VSS VDD VDD _2082_
+ sky130_fd_sc_hd__o22ai_1
X_4645_ _1953_ _2076_ _2082_ _1997_ VSS VSS VDD VDD _2083_
+ sky130_fd_sc_hd__o211ai_1
X_4646_ _1494_ VSS VSS VDD VDD _2084_ sky130_fd_sc_hd__buf_6
X_4647_ mem\[13\]\[25\] mem\[15\]\[25\] _1872_ VSS VSS VDD
+ VDD _2085_ sky130_fd_sc_hd__mux2i_1
X_4648_ _2029_ _2000_ _1193_ VSS VSS VDD VDD _2086_ sky130_fd_sc_hd__nand3_1
X_4649_ _1200_ _2084_ _1782_ _2085_ _2086_ VSS VSS VDD VDD
+ _2087_ sky130_fd_sc_hd__o221ai_1
X_4650_ mem\[9\]\[25\] mem\[11\]\[25\] _1968_ VSS VSS VDD
+ VDD _2088_ sky130_fd_sc_hd__mux2i_1
X_4651_ _1876_ _2088_ _1970_ VSS VSS VDD VDD _2089_ sky130_fd_sc_hd__o21ai_0
X_4652_ net130 _2027_ _2087_ _2089_ VSS VSS VDD VDD _2090_
+ sky130_fd_sc_hd__o22a_1
X_4653_ _2075_ _2083_ _2090_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__and3_1
X_4654_ _1532_ VSS VSS VDD VDD _2091_ sky130_fd_sc_hd__buf_6
X_4655_ mem\[5\]\[26\] mem\[7\]\[26\] _2091_ VSS VSS VDD VDD
+ _2092_ sky130_fd_sc_hd__mux2i_1
X_4656_ _1820_ _2092_ VSS VSS VDD VDD _2093_ sky130_fd_sc_hd__nor2_1
X_4657_ _1207_ _1973_ _2093_ VSS VSS VDD VDD _2094_ sky130_fd_sc_hd__a21oi_1
X_4658_ mem\[1\]\[26\] mem\[3\]\[26\] _2064_ VSS VSS VDD VDD
+ _2095_ sky130_fd_sc_hd__mux2_1
X_4659_ _1977_ _1978_ _1939_ _2095_ VSS VSS VDD VDD _2096_
+ sky130_fd_sc_hd__nand4_1
X_4660_ _1852_ _1938_ _1216_ _2096_ VSS VSS VDD VDD _2097_
+ sky130_fd_sc_hd__o31ai_1
X_4661_ _1510_ VSS VSS VDD VDD _2098_ sky130_fd_sc_hd__buf_6
X_4662_ mem\[4\]\[26\] mem\[6\]\[26\] _2098_ VSS VSS VDD VDD
+ _2099_ sky130_fd_sc_hd__mux2i_1
X_4663_ _1208_ _1827_ _1943_ _2099_ _1796_ VSS VSS VDD VDD
+ _2100_ sky130_fd_sc_hd__o221ai_1
X_4664_ _1937_ _2097_ _2100_ VSS VSS VDD VDD _2101_ sky130_fd_sc_hd__o21ai_0
X_4665_ mem\[1\]\[26\] _1947_ _1948_ mem\[0\]\[26\] VSS VSS
+ VDD VDD _2102_ sky130_fd_sc_hd__o22ai_1
X_4666_ mem\[2\]\[26\] _1672_ _1673_ mem\[3\]\[26\] VSS VSS
+ VDD VDD _2103_ sky130_fd_sc_hd__o22ai_1
X_4667_ _2071_ _2102_ _2103_ VSS VSS VDD VDD _2104_ sky130_fd_sc_hd__or3_1
X_4668_ _1933_ _2094_ _2101_ _2104_ _1988_ VSS VSS VDD VDD
+ _2105_ sky130_fd_sc_hd__o2111ai_2
X_4669_ mem\[12\]\[26\] mem\[14\]\[26\] _1954_ VSS VSS VDD
+ VDD _2106_ sky130_fd_sc_hd__mux2i_1
X_4670_ _0715_ VSS VSS VDD VDD _2107_ sky130_fd_sc_hd__buf_6
X_4671_ _1457_ VSS VSS VDD VDD _2108_ sky130_fd_sc_hd__buf_6
X_4672_ mem\[8\]\[26\] mem\[10\]\[26\] _2108_ VSS VSS VDD
+ VDD _2109_ sky130_fd_sc_hd__mux2_1
X_4673_ _1804_ _1805_ _2109_ VSS VSS VDD VDD _2110_ sky130_fd_sc_hd__nand3_1
X_4674_ _2107_ _1219_ _2110_ _1958_ VSS VSS VDD VDD _2111_
+ sky130_fd_sc_hd__o22ai_1
X_4675_ _1960_ _2110_ VSS VSS VDD VDD _2112_ sky130_fd_sc_hd__nor2_1
X_4676_ _1810_ _1212_ _1778_ VSS VSS VDD VDD _2113_ sky130_fd_sc_hd__o21ai_0
X_4677_ _1864_ _2111_ _2112_ _2113_ VSS VSS VDD VDD _2114_
+ sky130_fd_sc_hd__o22ai_1
X_4678_ _1953_ _2106_ _2114_ _1997_ VSS VSS VDD VDD _2115_
+ sky130_fd_sc_hd__o211ai_1
X_4679_ mem\[13\]\[26\] mem\[15\]\[26\] _1872_ VSS VSS VDD
+ VDD _2116_ sky130_fd_sc_hd__mux2i_1
X_4680_ _2029_ _2000_ _1211_ VSS VSS VDD VDD _2117_ sky130_fd_sc_hd__nand3_1
X_4681_ _1218_ _2084_ _1782_ _2116_ _2117_ VSS VSS VDD VDD
+ _2118_ sky130_fd_sc_hd__o221ai_1
X_4682_ mem\[9\]\[26\] mem\[11\]\[26\] _1968_ VSS VSS VDD
+ VDD _2119_ sky130_fd_sc_hd__mux2i_1
X_4683_ _1876_ _2119_ _1970_ VSS VSS VDD VDD _2120_ sky130_fd_sc_hd__o21ai_0
X_4684_ net131 _2027_ _2118_ _2120_ VSS VSS VDD VDD _2121_
+ sky130_fd_sc_hd__o22a_1
X_4685_ _2105_ _2115_ _2121_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__and3_1
X_4686_ mem\[5\]\[27\] mem\[7\]\[27\] _2091_ VSS VSS VDD VDD
+ _2122_ sky130_fd_sc_hd__mux2i_1
X_4687_ _1820_ _2122_ VSS VSS VDD VDD _2123_ sky130_fd_sc_hd__nor2_1
X_4688_ _1225_ _1973_ _2123_ VSS VSS VDD VDD _2124_ sky130_fd_sc_hd__a21oi_1
X_4689_ mem\[1\]\[27\] mem\[3\]\[27\] _2064_ VSS VSS VDD VDD
+ _2125_ sky130_fd_sc_hd__mux2_1
X_4690_ _1977_ _1978_ _1939_ _2125_ VSS VSS VDD VDD _2126_
+ sky130_fd_sc_hd__nand4_1
X_4691_ _1852_ _1938_ _1235_ _2126_ VSS VSS VDD VDD _2127_
+ sky130_fd_sc_hd__o31ai_1
X_4692_ mem\[4\]\[27\] mem\[6\]\[27\] _2098_ VSS VSS VDD VDD
+ _2128_ sky130_fd_sc_hd__mux2i_1
X_4693_ _1226_ _1827_ _1943_ _2128_ _1796_ VSS VSS VDD VDD
+ _2129_ sky130_fd_sc_hd__o221ai_1
X_4694_ _1937_ _2127_ _2129_ VSS VSS VDD VDD _2130_ sky130_fd_sc_hd__o21ai_0
X_4695_ mem\[1\]\[27\] _1947_ _1948_ mem\[0\]\[27\] VSS VSS
+ VDD VDD _2131_ sky130_fd_sc_hd__o22ai_1
X_4696_ mem\[2\]\[27\] _1672_ _1673_ mem\[3\]\[27\] VSS VSS
+ VDD VDD _2132_ sky130_fd_sc_hd__o22ai_1
X_4697_ _2071_ _2131_ _2132_ VSS VSS VDD VDD _2133_ sky130_fd_sc_hd__or3_1
X_4698_ _1933_ _2124_ _2130_ _2133_ _1988_ VSS VSS VDD VDD
+ _2134_ sky130_fd_sc_hd__o2111ai_2
X_4699_ mem\[12\]\[27\] mem\[14\]\[27\] _1954_ VSS VSS VDD
+ VDD _2135_ sky130_fd_sc_hd__mux2i_1
X_4700_ mem\[8\]\[27\] mem\[10\]\[27\] _2108_ VSS VSS VDD
+ VDD _2136_ sky130_fd_sc_hd__mux2_1
X_4701_ _1804_ _1805_ _2136_ VSS VSS VDD VDD _2137_ sky130_fd_sc_hd__nand3_1
X_4702_ _2107_ _1238_ _2137_ _1958_ VSS VSS VDD VDD _2138_
+ sky130_fd_sc_hd__o22ai_1
X_4703_ _1960_ _2137_ VSS VSS VDD VDD _2139_ sky130_fd_sc_hd__nor2_1
X_4704_ _0827_ VSS VSS VDD VDD _2140_ sky130_fd_sc_hd__buf_4
X_4705_ _1810_ _1231_ _2140_ VSS VSS VDD VDD _2141_ sky130_fd_sc_hd__o21ai_0
X_4706_ _1864_ _2138_ _2139_ _2141_ VSS VSS VDD VDD _2142_
+ sky130_fd_sc_hd__o22ai_1
X_4707_ _1953_ _2135_ _2142_ _1997_ VSS VSS VDD VDD _2143_
+ sky130_fd_sc_hd__o211ai_1
X_4708_ _1529_ VSS VSS VDD VDD _2144_ sky130_fd_sc_hd__buf_6
X_4709_ mem\[13\]\[27\] mem\[15\]\[27\] _1872_ VSS VSS VDD
+ VDD _2145_ sky130_fd_sc_hd__mux2i_1
X_4710_ _2029_ _2000_ _1230_ VSS VSS VDD VDD _2146_ sky130_fd_sc_hd__nand3_1
X_4711_ _1237_ _2084_ _2144_ _2145_ _2146_ VSS VSS VDD VDD
+ _2147_ sky130_fd_sc_hd__o221ai_1
X_4712_ mem\[9\]\[27\] mem\[11\]\[27\] _1968_ VSS VSS VDD
+ VDD _2148_ sky130_fd_sc_hd__mux2i_1
X_4713_ _1876_ _2148_ _1970_ VSS VSS VDD VDD _2149_ sky130_fd_sc_hd__o21ai_0
X_4714_ net132 _2027_ _2147_ _2149_ VSS VSS VDD VDD _2150_
+ sky130_fd_sc_hd__o22a_1
X_4715_ _2134_ _2143_ _2150_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__and3_1
X_4716_ mem\[5\]\[28\] mem\[7\]\[28\] _2091_ VSS VSS VDD VDD
+ _2151_ sky130_fd_sc_hd__mux2i_1
X_4717_ _1820_ _2151_ VSS VSS VDD VDD _2152_ sky130_fd_sc_hd__nor2_1
X_4718_ _1245_ _1973_ _2152_ VSS VSS VDD VDD _2153_ sky130_fd_sc_hd__a21oi_1
X_4719_ mem\[1\]\[28\] mem\[3\]\[28\] _2064_ VSS VSS VDD VDD
+ _2154_ sky130_fd_sc_hd__mux2_1
X_4720_ _1977_ _1978_ _1939_ _2154_ VSS VSS VDD VDD _2155_
+ sky130_fd_sc_hd__nand4_1
X_4721_ _1852_ _1938_ _1254_ _2155_ VSS VSS VDD VDD _2156_
+ sky130_fd_sc_hd__o31ai_1
X_4722_ mem\[4\]\[28\] mem\[6\]\[28\] _2098_ VSS VSS VDD VDD
+ _2157_ sky130_fd_sc_hd__mux2i_1
X_4723_ _1246_ _1827_ _1943_ _2157_ _0906_ VSS VSS VDD VDD
+ _2158_ sky130_fd_sc_hd__o221ai_1
X_4724_ _1937_ _2156_ _2158_ VSS VSS VDD VDD _2159_ sky130_fd_sc_hd__o21ai_0
X_4725_ mem\[1\]\[28\] _1947_ _1948_ mem\[0\]\[28\] VSS VSS
+ VDD VDD _2160_ sky130_fd_sc_hd__o22ai_1
X_4726_ mem\[2\]\[28\] _1767_ _1768_ mem\[3\]\[28\] VSS VSS
+ VDD VDD _2161_ sky130_fd_sc_hd__o22ai_1
X_4727_ _2071_ _2160_ _2161_ VSS VSS VDD VDD _2162_ sky130_fd_sc_hd__or3_1
X_4728_ _1933_ _2153_ _2159_ _2162_ _1988_ VSS VSS VDD VDD
+ _2163_ sky130_fd_sc_hd__o2111ai_2
X_4729_ mem\[12\]\[28\] mem\[14\]\[28\] _1954_ VSS VSS VDD
+ VDD _2164_ sky130_fd_sc_hd__mux2i_1
X_4730_ mem\[8\]\[28\] mem\[10\]\[28\] _2108_ VSS VSS VDD
+ VDD _2165_ sky130_fd_sc_hd__mux2_1
X_4731_ _1490_ _1491_ _2165_ VSS VSS VDD VDD _2166_ sky130_fd_sc_hd__nand3_1
X_4732_ _2107_ _1257_ _2166_ _1958_ VSS VSS VDD VDD _2167_
+ sky130_fd_sc_hd__o22ai_1
X_4733_ _1960_ _2166_ VSS VSS VDD VDD _2168_ sky130_fd_sc_hd__nor2_1
X_4734_ _1519_ _1250_ _2140_ VSS VSS VDD VDD _2169_ sky130_fd_sc_hd__o21ai_0
X_4735_ _1864_ _2167_ _2168_ _2169_ VSS VSS VDD VDD _2170_
+ sky130_fd_sc_hd__o22ai_1
X_4736_ _1953_ _2164_ _2170_ _1997_ VSS VSS VDD VDD _2171_
+ sky130_fd_sc_hd__o211ai_1
X_4737_ mem\[13\]\[28\] mem\[15\]\[28\] _1872_ VSS VSS VDD
+ VDD _2172_ sky130_fd_sc_hd__mux2i_1
X_4738_ _2029_ _2000_ _1249_ VSS VSS VDD VDD _2173_ sky130_fd_sc_hd__nand3_1
X_4739_ _1256_ _2084_ _2144_ _2172_ _2173_ VSS VSS VDD VDD
+ _2174_ sky130_fd_sc_hd__o221ai_1
X_4740_ mem\[9\]\[28\] mem\[11\]\[28\] _1968_ VSS VSS VDD
+ VDD _2175_ sky130_fd_sc_hd__mux2i_1
X_4741_ _1876_ _2175_ _1970_ VSS VSS VDD VDD _2176_ sky130_fd_sc_hd__o21ai_0
X_4742_ net134 _2027_ _2174_ _2176_ VSS VSS VDD VDD _2177_
+ sky130_fd_sc_hd__o22a_1
X_4743_ _2163_ _2171_ _2177_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__and3_1
X_4744_ mem\[13\]\[29\] mem\[15\]\[29\] _1599_ VSS VSS VDD
+ VDD _2178_ sky130_fd_sc_hd__mux2i_1
X_4745_ _1276_ _1597_ _1598_ _2178_ VSS VSS VDD VDD _2179_
+ sky130_fd_sc_hd__o22ai_1
X_4746_ _1595_ _2179_ _1593_ net163 VSS VSS VDD VDD _2180_
+ sky130_fd_sc_hd__a211oi_1
X_4747_ mem\[9\]\[29\] mem\[11\]\[29\] _1599_ VSS VSS VDD
+ VDD _2181_ sky130_fd_sc_hd__mux2i_1
X_4748_ _1267_ _1495_ _1726_ _2181_ _0903_ VSS VSS VDD VDD
+ _2182_ sky130_fd_sc_hd__o221ai_1
X_4749_ mem\[12\]\[29\] mem\[14\]\[29\] _1533_ VSS VSS VDD
+ VDD _2183_ sky130_fd_sc_hd__mux2i_1
X_4750_ _1275_ _1548_ _1531_ _2183_ _1731_ VSS VSS VDD VDD
+ _2184_ sky130_fd_sc_hd__o221ai_1
X_4751_ mem\[10\]\[29\] _1463_ _1465_ mem\[11\]\[29\] VSS
+ VSS VDD VDD _2185_ sky130_fd_sc_hd__o22ai_1
X_4752_ mem\[9\]\[29\] _1456_ _1460_ mem\[8\]\[29\] VSS VSS
+ VDD VDD _2186_ sky130_fd_sc_hd__o22ai_1
X_4753_ _1472_ _2185_ _2186_ VSS VSS VDD VDD _2187_ sky130_fd_sc_hd__nor3_1
X_4754_ _2182_ _2184_ _2187_ VSS VSS VDD VDD _2188_ sky130_fd_sc_hd__a21oi_1
X_4755_ mem\[4\]\[29\] mem\[6\]\[29\] _1738_ VSS VSS VDD VDD
+ _2189_ sky130_fd_sc_hd__mux2i_1
X_4756_ mem\[0\]\[29\] mem\[2\]\[29\] _1483_ VSS VSS VDD VDD
+ _2190_ sky130_fd_sc_hd__mux2_1
X_4757_ _1540_ _1542_ _2190_ VSS VSS VDD VDD _2191_ sky130_fd_sc_hd__nand3_1
X_4758_ _1740_ _1264_ _2191_ _1743_ VSS VSS VDD VDD _2192_
+ sky130_fd_sc_hd__o22ai_1
X_4759_ _1745_ _2191_ VSS VSS VDD VDD _2193_ sky130_fd_sc_hd__nor2_1
X_4760_ _1567_ _1273_ _0828_ VSS VSS VDD VDD _2194_ sky130_fd_sc_hd__o21ai_0
X_4761_ _1488_ _2192_ _2193_ _2194_ VSS VSS VDD VDD _2195_
+ sky130_fd_sc_hd__o22ai_1
X_4762_ _1737_ _2189_ _2195_ _1509_ VSS VSS VDD VDD _2196_
+ sky130_fd_sc_hd__o211a_1
X_4763_ mem\[5\]\[29\] mem\[7\]\[29\] _1532_ VSS VSS VDD VDD
+ _2197_ sky130_fd_sc_hd__mux2i_1
X_4764_ _1530_ _2197_ VSS VSS VDD VDD _2198_ sky130_fd_sc_hd__nor2_1
X_4765_ _1752_ _1489_ _1274_ VSS VSS VDD VDD _2199_ sky130_fd_sc_hd__nor3_1
X_4766_ _1752_ _1627_ _1263_ _2198_ _2199_ VSS VSS VDD VDD
+ _2200_ sky130_fd_sc_hd__a311o_1
X_4767_ mem\[1\]\[29\] mem\[3\]\[29\] _1727_ VSS VSS VDD VDD
+ _2201_ sky130_fd_sc_hd__mux2i_1
X_4768_ _1726_ _2201_ VSS VSS VDD VDD _2202_ sky130_fd_sc_hd__nor2_1
X_4769_ _1522_ _2200_ _2202_ _2537_ net135 VSS VSS VDD VDD
+ _2203_ sky130_fd_sc_hd__o32ai_1
X_4770_ _2180_ _2188_ _2196_ _2203_ VSS VSS VDD VDD _0588_
+ sky130_fd_sc_hd__a211oi_1
X_4771_ mem\[5\]\[2\] mem\[7\]\[2\] _2091_ VSS VSS VDD VDD
+ _2204_ sky130_fd_sc_hd__mux2i_1
X_4772_ _1563_ _2204_ VSS VSS VDD VDD _2205_ sky130_fd_sc_hd__nor2_1
X_4773_ _1281_ _1973_ _2205_ VSS VSS VDD VDD _2206_ sky130_fd_sc_hd__a21oi_1
X_4774_ mem\[1\]\[2\] mem\[3\]\[2\] _2064_ VSS VSS VDD VDD
+ _2207_ sky130_fd_sc_hd__mux2_1
X_4775_ _1977_ _1978_ _1939_ _2207_ VSS VSS VDD VDD _2208_
+ sky130_fd_sc_hd__nand4_1
X_4776_ _1852_ _1938_ _1290_ _2208_ VSS VSS VDD VDD _2209_
+ sky130_fd_sc_hd__o31ai_1
X_4777_ mem\[4\]\[2\] mem\[6\]\[2\] _2098_ VSS VSS VDD VDD
+ _2210_ sky130_fd_sc_hd__mux2i_1
X_4778_ _1282_ _1596_ _1943_ _2210_ _0906_ VSS VSS VDD VDD
+ _2211_ sky130_fd_sc_hd__o221ai_1
X_4779_ _1937_ _2209_ _2211_ VSS VSS VDD VDD _2212_ sky130_fd_sc_hd__o21ai_1
X_4780_ mem\[2\]\[2\] _1462_ _1464_ mem\[3\]\[2\] VSS VSS
+ VDD VDD _2213_ sky130_fd_sc_hd__o22ai_1
X_4781_ mem\[1\]\[2\] _1555_ _1556_ mem\[0\]\[2\] VSS VSS
+ VDD VDD _2214_ sky130_fd_sc_hd__o22ai_1
X_4782_ _2071_ _2213_ _2214_ VSS VSS VDD VDD _2215_ sky130_fd_sc_hd__or3_1
X_4783_ _1933_ _2206_ _2212_ _2215_ _1988_ VSS VSS VDD VDD
+ _2216_ sky130_fd_sc_hd__o2111ai_4
X_4784_ mem\[12\]\[2\] mem\[14\]\[2\] _1954_ VSS VSS VDD VDD
+ _2217_ sky130_fd_sc_hd__mux2i_1
X_4785_ mem\[8\]\[2\] mem\[10\]\[2\] _2108_ VSS VSS VDD VDD
+ _2218_ sky130_fd_sc_hd__mux2_1
X_4786_ _1490_ _1491_ _2218_ VSS VSS VDD VDD _2219_ sky130_fd_sc_hd__nand3_1
X_4787_ _2107_ _1293_ _2219_ _1958_ VSS VSS VDD VDD _2220_
+ sky130_fd_sc_hd__o22ai_1
X_4788_ _1960_ _2219_ VSS VSS VDD VDD _2221_ sky130_fd_sc_hd__nor2_1
X_4789_ _1519_ _1286_ _2140_ VSS VSS VDD VDD _2222_ sky130_fd_sc_hd__o21ai_0
X_4790_ _1864_ _2220_ _2221_ _2222_ VSS VSS VDD VDD _2223_
+ sky130_fd_sc_hd__o22ai_1
X_4791_ _1953_ _2217_ _2223_ _1997_ VSS VSS VDD VDD _2224_
+ sky130_fd_sc_hd__o211ai_1
X_4792_ mem\[13\]\[2\] mem\[15\]\[2\] _1872_ VSS VSS VDD VDD
+ _2225_ sky130_fd_sc_hd__mux2i_1
X_4793_ _2029_ _2000_ _1285_ VSS VSS VDD VDD _2226_ sky130_fd_sc_hd__nand3_1
X_4794_ _1292_ _2084_ _2144_ _2225_ _2226_ VSS VSS VDD VDD
+ _2227_ sky130_fd_sc_hd__o221ai_1
X_4795_ mem\[9\]\[2\] mem\[11\]\[2\] _1968_ VSS VSS VDD VDD
+ _2228_ sky130_fd_sc_hd__mux2i_1
X_4796_ _1876_ _2228_ _1970_ VSS VSS VDD VDD _2229_ sky130_fd_sc_hd__o21ai_0
X_4797_ net105 _2027_ _2227_ _2229_ VSS VSS VDD VDD _2230_
+ sky130_fd_sc_hd__o22a_1
X_4798_ _2216_ _2224_ _2230_ VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__and3_1
X_4799_ mem\[5\]\[30\] mem\[7\]\[30\] _2091_ VSS VSS VDD VDD
+ _2231_ sky130_fd_sc_hd__mux2i_1
X_4800_ _1563_ _2231_ VSS VSS VDD VDD _2232_ sky130_fd_sc_hd__nor2_1
X_4801_ _1298_ _1973_ _2232_ VSS VSS VDD VDD _2233_ sky130_fd_sc_hd__a21oi_1
X_4802_ mem\[1\]\[30\] mem\[3\]\[30\] _2064_ VSS VSS VDD VDD
+ _2234_ sky130_fd_sc_hd__mux2_1
X_4803_ _1977_ _1978_ _1939_ _2234_ VSS VSS VDD VDD _2235_
+ sky130_fd_sc_hd__nand4_1
X_4804_ _0860_ _1938_ _1307_ _2235_ VSS VSS VDD VDD _2236_
+ sky130_fd_sc_hd__o31ai_1
X_4805_ mem\[4\]\[30\] mem\[6\]\[30\] _2098_ VSS VSS VDD VDD
+ _2237_ sky130_fd_sc_hd__mux2i_1
X_4806_ _1299_ _1596_ _1943_ _2237_ _0906_ VSS VSS VDD VDD
+ _2238_ sky130_fd_sc_hd__o221ai_1
X_4807_ _1937_ _2236_ _2238_ VSS VSS VDD VDD _2239_ sky130_fd_sc_hd__o21ai_0
X_4808_ mem\[1\]\[30\] _1947_ _1948_ mem\[0\]\[30\] VSS VSS
+ VDD VDD _2240_ sky130_fd_sc_hd__o22ai_1
X_4809_ mem\[2\]\[30\] _1767_ _1768_ mem\[3\]\[30\] VSS VSS
+ VDD VDD _2241_ sky130_fd_sc_hd__o22ai_1
X_4810_ _2071_ _2240_ _2241_ VSS VSS VDD VDD _2242_ sky130_fd_sc_hd__or3_1
X_4811_ _1933_ _2233_ _2239_ _2242_ _1988_ VSS VSS VDD VDD
+ _2243_ sky130_fd_sc_hd__o2111ai_2
X_4812_ mem\[12\]\[30\] mem\[14\]\[30\] _1954_ VSS VSS VDD
+ VDD _2244_ sky130_fd_sc_hd__mux2i_1
X_4813_ mem\[8\]\[30\] mem\[10\]\[30\] _2108_ VSS VSS VDD
+ VDD _2245_ sky130_fd_sc_hd__mux2_1
X_4814_ _1490_ _1491_ _2245_ VSS VSS VDD VDD _2246_ sky130_fd_sc_hd__nand3_1
X_4815_ _2107_ _1310_ _2246_ _1958_ VSS VSS VDD VDD _2247_
+ sky130_fd_sc_hd__o22ai_1
X_4816_ _1960_ _2246_ VSS VSS VDD VDD _2248_ sky130_fd_sc_hd__nor2_1
X_4817_ _1519_ _1303_ _2140_ VSS VSS VDD VDD _2249_ sky130_fd_sc_hd__o21ai_0
X_4818_ _1514_ _2247_ _2248_ _2249_ VSS VSS VDD VDD _2250_
+ sky130_fd_sc_hd__o22ai_1
X_4819_ _1953_ _2244_ _2250_ _1997_ VSS VSS VDD VDD _2251_
+ sky130_fd_sc_hd__o211ai_1
X_4820_ mem\[13\]\[30\] mem\[15\]\[30\] _1481_ VSS VSS VDD
+ VDD _2252_ sky130_fd_sc_hd__mux2i_1
X_4821_ _2029_ _2000_ _1302_ VSS VSS VDD VDD _2253_ sky130_fd_sc_hd__nand3_1
X_4822_ _1309_ _2084_ _2144_ _2252_ _2253_ VSS VSS VDD VDD
+ _2254_ sky130_fd_sc_hd__o221ai_1
X_4823_ mem\[9\]\[30\] mem\[11\]\[30\] _1968_ VSS VSS VDD
+ VDD _2255_ sky130_fd_sc_hd__mux2i_1
X_4824_ _1588_ _2255_ _1970_ VSS VSS VDD VDD _2256_ sky130_fd_sc_hd__o21ai_0
X_4825_ net136 _2027_ _2254_ _2256_ VSS VSS VDD VDD _2257_
+ sky130_fd_sc_hd__o22a_1
X_4826_ _2243_ _2251_ _2257_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__and3_1
X_4827_ mem\[5\]\[31\] mem\[7\]\[31\] _2091_ VSS VSS VDD VDD
+ _2258_ sky130_fd_sc_hd__mux2i_1
X_4828_ _1563_ _2258_ VSS VSS VDD VDD _2259_ sky130_fd_sc_hd__nor2_1
X_4829_ _1315_ _1973_ _2259_ VSS VSS VDD VDD _2260_ sky130_fd_sc_hd__a21oi_1
X_4830_ mem\[1\]\[31\] mem\[3\]\[31\] _2064_ VSS VSS VDD VDD
+ _2261_ sky130_fd_sc_hd__mux2_1
X_4831_ _1977_ _1978_ _1939_ _2261_ VSS VSS VDD VDD _2262_
+ sky130_fd_sc_hd__nand4_1
X_4832_ _0860_ _1938_ _1324_ _2262_ VSS VSS VDD VDD _2263_
+ sky130_fd_sc_hd__o31ai_1
X_4833_ mem\[4\]\[31\] mem\[6\]\[31\] _2098_ VSS VSS VDD VDD
+ _2264_ sky130_fd_sc_hd__mux2i_1
X_4834_ _1316_ _1596_ _1943_ _2264_ _0906_ VSS VSS VDD VDD
+ _2265_ sky130_fd_sc_hd__o221ai_1
X_4835_ _1937_ _2263_ _2265_ VSS VSS VDD VDD _2266_ sky130_fd_sc_hd__o21ai_0
X_4836_ mem\[1\]\[31\] _1947_ _1948_ mem\[0\]\[31\] VSS VSS
+ VDD VDD _2267_ sky130_fd_sc_hd__o22ai_1
X_4837_ mem\[2\]\[31\] _1767_ _1768_ mem\[3\]\[31\] VSS VSS
+ VDD VDD _2268_ sky130_fd_sc_hd__o22ai_1
X_4838_ _2071_ _2267_ _2268_ VSS VSS VDD VDD _2269_ sky130_fd_sc_hd__or3_1
X_4839_ _1933_ _2260_ _2266_ _2269_ _1988_ VSS VSS VDD VDD
+ _2270_ sky130_fd_sc_hd__o2111ai_2
X_4840_ mem\[12\]\[31\] mem\[14\]\[31\] _1954_ VSS VSS VDD
+ VDD _2271_ sky130_fd_sc_hd__mux2i_1
X_4841_ mem\[8\]\[31\] mem\[10\]\[31\] _2108_ VSS VSS VDD
+ VDD _2272_ sky130_fd_sc_hd__mux2_1
X_4842_ _1490_ _1491_ _2272_ VSS VSS VDD VDD _2273_ sky130_fd_sc_hd__nand3_1
X_4843_ _2107_ _1327_ _2273_ _1958_ VSS VSS VDD VDD _2274_
+ sky130_fd_sc_hd__o22ai_1
X_4844_ _1960_ _2273_ VSS VSS VDD VDD _2275_ sky130_fd_sc_hd__nor2_1
X_4845_ _1519_ _1320_ _2140_ VSS VSS VDD VDD _2276_ sky130_fd_sc_hd__o21ai_0
X_4846_ _1514_ _2274_ _2275_ _2276_ VSS VSS VDD VDD _2277_
+ sky130_fd_sc_hd__o22ai_1
X_4847_ _1953_ _2271_ _2277_ _1997_ VSS VSS VDD VDD _2278_
+ sky130_fd_sc_hd__o211ai_1
X_4848_ mem\[13\]\[31\] mem\[15\]\[31\] _1481_ VSS VSS VDD
+ VDD _2279_ sky130_fd_sc_hd__mux2i_1
X_4849_ _2029_ _2000_ _1319_ VSS VSS VDD VDD _2280_ sky130_fd_sc_hd__nand3_1
X_4850_ _1326_ _2084_ _2144_ _2279_ _2280_ VSS VSS VDD VDD
+ _2281_ sky130_fd_sc_hd__o221ai_1
X_4851_ mem\[9\]\[31\] mem\[11\]\[31\] _1968_ VSS VSS VDD
+ VDD _2282_ sky130_fd_sc_hd__mux2i_1
X_4852_ _1588_ _2282_ _1970_ VSS VSS VDD VDD _2283_ sky130_fd_sc_hd__o21ai_0
X_4853_ net137 _2027_ _2281_ _2283_ VSS VSS VDD VDD _2284_
+ sky130_fd_sc_hd__o22a_1
X_4854_ _2270_ _2278_ _2284_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__and3_1
X_4855_ mem\[5\]\[3\] mem\[7\]\[3\] _2091_ VSS VSS VDD VDD
+ _2285_ sky130_fd_sc_hd__mux2i_1
X_4856_ _1563_ _2285_ VSS VSS VDD VDD _2286_ sky130_fd_sc_hd__nor2_1
X_4857_ _1332_ _1973_ _2286_ VSS VSS VDD VDD _2287_ sky130_fd_sc_hd__a21oi_1
X_4858_ mem\[1\]\[3\] mem\[3\]\[3\] _2064_ VSS VSS VDD VDD
+ _2288_ sky130_fd_sc_hd__mux2_1
X_4859_ _1977_ _1978_ _1478_ _2288_ VSS VSS VDD VDD _2289_
+ sky130_fd_sc_hd__nand4_1
X_4860_ _0860_ _1740_ _1341_ _2289_ VSS VSS VDD VDD _2290_
+ sky130_fd_sc_hd__o31ai_1
X_4861_ mem\[4\]\[3\] mem\[6\]\[3\] _2098_ VSS VSS VDD VDD
+ _2291_ sky130_fd_sc_hd__mux2i_1
X_4862_ _1333_ _1596_ _1580_ _2291_ _0906_ VSS VSS VDD VDD
+ _2292_ sky130_fd_sc_hd__o221ai_1
X_4863_ _1552_ _2290_ _2292_ VSS VSS VDD VDD _2293_ sky130_fd_sc_hd__o21ai_0
X_4864_ mem\[1\]\[3\] _1947_ _1948_ mem\[0\]\[3\] VSS VSS
+ VDD VDD _2294_ sky130_fd_sc_hd__o22ai_1
X_4865_ mem\[2\]\[3\] _1767_ _1768_ mem\[3\]\[3\] VSS VSS
+ VDD VDD _2295_ sky130_fd_sc_hd__o22ai_1
X_4866_ _2071_ _2294_ _2295_ VSS VSS VDD VDD _2296_ sky130_fd_sc_hd__or3_1
X_4867_ _1731_ _2287_ _2293_ _2296_ _1988_ VSS VSS VDD VDD
+ _2297_ sky130_fd_sc_hd__o2111ai_2
X_4868_ mem\[12\]\[3\] mem\[14\]\[3\] _1738_ VSS VSS VDD VDD
+ _2298_ sky130_fd_sc_hd__mux2i_1
X_4869_ mem\[8\]\[3\] mem\[10\]\[3\] _2108_ VSS VSS VDD VDD
+ _2299_ sky130_fd_sc_hd__mux2_1
X_4870_ _1490_ _1491_ _2299_ VSS VSS VDD VDD _2300_ sky130_fd_sc_hd__nand3_1
X_4871_ _2107_ _1344_ _2300_ _1743_ VSS VSS VDD VDD _2301_
+ sky130_fd_sc_hd__o22ai_1
X_4872_ _1745_ _2300_ VSS VSS VDD VDD _2302_ sky130_fd_sc_hd__nor2_1
X_4873_ _1519_ _1337_ _2140_ VSS VSS VDD VDD _2303_ sky130_fd_sc_hd__o21ai_0
X_4874_ _1514_ _2301_ _2302_ _2303_ VSS VSS VDD VDD _2304_
+ sky130_fd_sc_hd__o22ai_1
X_4875_ _1737_ _2298_ _2304_ _1997_ VSS VSS VDD VDD _2305_
+ sky130_fd_sc_hd__o211ai_1
X_4876_ mem\[13\]\[3\] mem\[15\]\[3\] _1481_ VSS VSS VDD VDD
+ _2306_ sky130_fd_sc_hd__mux2i_1
X_4877_ _2029_ _2000_ _1336_ VSS VSS VDD VDD _2307_ sky130_fd_sc_hd__nand3_1
X_4878_ _1343_ _2084_ _2144_ _2306_ _2307_ VSS VSS VDD VDD
+ _2308_ sky130_fd_sc_hd__o221ai_1
X_4879_ mem\[9\]\[3\] mem\[11\]\[3\] _1550_ VSS VSS VDD VDD
+ _2309_ sky130_fd_sc_hd__mux2i_1
X_4880_ _1588_ _2309_ _1475_ VSS VSS VDD VDD _2310_ sky130_fd_sc_hd__o21ai_0
X_4881_ net106 _2027_ _2308_ _2310_ VSS VSS VDD VDD _2311_
+ sky130_fd_sc_hd__o22a_1
X_4882_ _2297_ _2305_ _2311_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__and3_1
X_4883_ mem\[13\]\[4\] mem\[15\]\[4\] _1599_ VSS VSS VDD VDD
+ _2312_ sky130_fd_sc_hd__mux2i_1
X_4884_ _1362_ _1597_ _1598_ _2312_ VSS VSS VDD VDD _2313_
+ sky130_fd_sc_hd__o22ai_1
X_4885_ _1595_ _2313_ _1593_ net163 VSS VSS VDD VDD _2314_
+ sky130_fd_sc_hd__a211oi_1
X_4886_ mem\[9\]\[4\] mem\[11\]\[4\] _1599_ VSS VSS VDD VDD
+ _2315_ sky130_fd_sc_hd__mux2i_1
X_4887_ _1353_ _1495_ _1589_ _2315_ _0903_ VSS VSS VDD VDD
+ _2316_ sky130_fd_sc_hd__o221ai_1
X_4888_ mem\[12\]\[4\] mem\[14\]\[4\] _1533_ VSS VSS VDD VDD
+ _2317_ sky130_fd_sc_hd__mux2i_1
X_4889_ _1361_ _1548_ _1531_ _2317_ _1731_ VSS VSS VDD VDD
+ _2318_ sky130_fd_sc_hd__o221ai_1
X_4890_ mem\[10\]\[4\] _1463_ _1465_ mem\[11\]\[4\] VSS VSS
+ VDD VDD _2319_ sky130_fd_sc_hd__o22ai_1
X_4891_ mem\[9\]\[4\] _1456_ _1460_ mem\[8\]\[4\] VSS VSS
+ VDD VDD _2320_ sky130_fd_sc_hd__o22ai_1
X_4892_ _1472_ _2319_ _2320_ VSS VSS VDD VDD _2321_ sky130_fd_sc_hd__nor3_1
X_4893_ _2316_ _2318_ _2321_ VSS VSS VDD VDD _2322_ sky130_fd_sc_hd__a21oi_1
X_4894_ mem\[4\]\[4\] mem\[6\]\[4\] _1738_ VSS VSS VDD VDD
+ _2323_ sky130_fd_sc_hd__mux2i_1
X_4895_ mem\[0\]\[4\] mem\[2\]\[4\] _1483_ VSS VSS VDD VDD
+ _2324_ sky130_fd_sc_hd__mux2_1
X_4896_ _1540_ _1542_ _2324_ VSS VSS VDD VDD _2325_ sky130_fd_sc_hd__nand3_1
X_4897_ _1740_ _1350_ _2325_ _1743_ VSS VSS VDD VDD _2326_
+ sky130_fd_sc_hd__o22ai_1
X_4898_ _1745_ _2325_ VSS VSS VDD VDD _2327_ sky130_fd_sc_hd__nor2_1
X_4899_ _1567_ _1359_ _0828_ VSS VSS VDD VDD _2328_ sky130_fd_sc_hd__o21ai_0
X_4900_ _1488_ _2326_ _2327_ _2328_ VSS VSS VDD VDD _2329_
+ sky130_fd_sc_hd__o22ai_1
X_4901_ _1737_ _2323_ _2329_ _1509_ VSS VSS VDD VDD _2330_
+ sky130_fd_sc_hd__o211a_1
X_4902_ mem\[5\]\[4\] mem\[7\]\[4\] _1510_ VSS VSS VDD VDD
+ _2331_ sky130_fd_sc_hd__mux2i_1
X_4903_ _1530_ _2331_ VSS VSS VDD VDD _2332_ sky130_fd_sc_hd__nor2_1
X_4904_ _1752_ _1489_ _1360_ VSS VSS VDD VDD _2333_ sky130_fd_sc_hd__nor3_1
X_4905_ _1752_ _1627_ _1349_ _2332_ _2333_ VSS VSS VDD VDD
+ _2334_ sky130_fd_sc_hd__a311o_1
X_4906_ mem\[1\]\[4\] mem\[3\]\[4\] _1727_ VSS VSS VDD VDD
+ _2335_ sky130_fd_sc_hd__mux2i_1
X_4907_ _1726_ _2335_ VSS VSS VDD VDD _2336_ sky130_fd_sc_hd__nor2_1
X_4908_ _1522_ _2334_ _2336_ _2537_ net107 VSS VSS VDD VDD
+ _2337_ sky130_fd_sc_hd__o32ai_1
X_4909_ _2314_ _2322_ _2330_ _2337_ VSS VSS VDD VDD _0593_
+ sky130_fd_sc_hd__a211oi_1
X_4910_ mem\[5\]\[5\] mem\[7\]\[5\] _2091_ VSS VSS VDD VDD
+ _2338_ sky130_fd_sc_hd__mux2i_1
X_4911_ _1563_ _2338_ VSS VSS VDD VDD _2339_ sky130_fd_sc_hd__nor2_1
X_4912_ _1367_ _1526_ _2339_ VSS VSS VDD VDD _2340_ sky130_fd_sc_hd__a21oi_1
X_4913_ mem\[1\]\[5\] mem\[3\]\[5\] _2064_ VSS VSS VDD VDD
+ _2341_ sky130_fd_sc_hd__mux2_1
X_4914_ _1568_ _1569_ _1478_ _2341_ VSS VSS VDD VDD _2342_
+ sky130_fd_sc_hd__nand4_1
X_4915_ _0860_ _1740_ _1376_ _2342_ VSS VSS VDD VDD _2343_
+ sky130_fd_sc_hd__o31ai_1
X_4916_ mem\[4\]\[5\] mem\[6\]\[5\] _2098_ VSS VSS VDD VDD
+ _2344_ sky130_fd_sc_hd__mux2i_1
X_4917_ _1368_ _1596_ _1580_ _2344_ _0906_ VSS VSS VDD VDD
+ _2345_ sky130_fd_sc_hd__o221ai_1
X_4918_ _1552_ _2343_ _2345_ VSS VSS VDD VDD _2346_ sky130_fd_sc_hd__o21ai_0
X_4919_ mem\[2\]\[5\] _1462_ _1464_ mem\[3\]\[5\] VSS VSS
+ VDD VDD _2347_ sky130_fd_sc_hd__o22ai_1
X_4920_ mem\[1\]\[5\] _1555_ _1556_ mem\[0\]\[5\] VSS VSS
+ VDD VDD _2348_ sky130_fd_sc_hd__o22ai_1
X_4921_ _2071_ _2347_ _2348_ VSS VSS VDD VDD _2349_ sky130_fd_sc_hd__or3_1
X_4922_ _1731_ _2340_ _2346_ _2349_ _1560_ VSS VSS VDD VDD
+ _2350_ sky130_fd_sc_hd__o2111ai_2
X_4923_ mem\[12\]\[5\] mem\[14\]\[5\] _1738_ VSS VSS VDD VDD
+ _2351_ sky130_fd_sc_hd__mux2i_1
X_4924_ mem\[8\]\[5\] mem\[10\]\[5\] _2108_ VSS VSS VDD VDD
+ _2352_ sky130_fd_sc_hd__mux2_1
X_4925_ _1490_ _1491_ _2352_ VSS VSS VDD VDD _2353_ sky130_fd_sc_hd__nand3_1
X_4926_ _2107_ _1379_ _2353_ _1743_ VSS VSS VDD VDD _2354_
+ sky130_fd_sc_hd__o22ai_1
X_4927_ _1745_ _2353_ VSS VSS VDD VDD _2355_ sky130_fd_sc_hd__nor2_1
X_4928_ _1519_ _1372_ _2140_ VSS VSS VDD VDD _2356_ sky130_fd_sc_hd__o21ai_0
X_4929_ _1514_ _2354_ _2355_ _2356_ VSS VSS VDD VDD _2357_
+ sky130_fd_sc_hd__o22ai_1
X_4930_ _1737_ _2351_ _2357_ _1501_ VSS VSS VDD VDD _2358_
+ sky130_fd_sc_hd__o211ai_1
X_4931_ mem\[13\]\[5\] mem\[15\]\[5\] _1481_ VSS VSS VDD VDD
+ _2359_ sky130_fd_sc_hd__mux2i_1
X_4932_ _2029_ _1627_ _1371_ VSS VSS VDD VDD _2360_ sky130_fd_sc_hd__nand3_1
X_4933_ _1378_ _2084_ _2144_ _2359_ _2360_ VSS VSS VDD VDD
+ _2361_ sky130_fd_sc_hd__o221ai_1
X_4934_ mem\[9\]\[5\] mem\[11\]\[5\] _1550_ VSS VSS VDD VDD
+ _2362_ sky130_fd_sc_hd__mux2i_1
X_4935_ _1588_ _2362_ _1475_ VSS VSS VDD VDD _2363_ sky130_fd_sc_hd__o21ai_0
X_4936_ net108 _2027_ _2361_ _2363_ VSS VSS VDD VDD _2364_
+ sky130_fd_sc_hd__o22a_1
X_4937_ _2350_ _2358_ _2364_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__and3_1
X_4938_ mem\[5\]\[6\] mem\[7\]\[6\] _2091_ VSS VSS VDD VDD
+ _2365_ sky130_fd_sc_hd__mux2i_1
X_4939_ _1563_ _2365_ VSS VSS VDD VDD _2366_ sky130_fd_sc_hd__nor2_1
X_4940_ _1384_ _1526_ _2366_ VSS VSS VDD VDD _2367_ sky130_fd_sc_hd__a21oi_1
X_4941_ mem\[1\]\[6\] mem\[3\]\[6\] _2064_ VSS VSS VDD VDD
+ _2368_ sky130_fd_sc_hd__mux2_1
X_4942_ _1568_ _1569_ _1478_ _2368_ VSS VSS VDD VDD _2369_
+ sky130_fd_sc_hd__nand4_1
X_4943_ _0860_ _1740_ _1393_ _2369_ VSS VSS VDD VDD _2370_
+ sky130_fd_sc_hd__o31ai_1
X_4944_ mem\[4\]\[6\] mem\[6\]\[6\] _2098_ VSS VSS VDD VDD
+ _2371_ sky130_fd_sc_hd__mux2i_1
X_4945_ _1385_ _1596_ _1580_ _2371_ _0906_ VSS VSS VDD VDD
+ _2372_ sky130_fd_sc_hd__o221ai_1
X_4946_ _1552_ _2370_ _2372_ VSS VSS VDD VDD _2373_ sky130_fd_sc_hd__o21ai_0
X_4947_ mem\[1\]\[6\] _1947_ _1948_ mem\[0\]\[6\] VSS VSS
+ VDD VDD _2374_ sky130_fd_sc_hd__o22ai_1
X_4948_ mem\[2\]\[6\] _1767_ _1768_ mem\[3\]\[6\] VSS VSS
+ VDD VDD _2375_ sky130_fd_sc_hd__o22ai_1
X_4949_ _2071_ _2374_ _2375_ VSS VSS VDD VDD _2376_ sky130_fd_sc_hd__or3_1
X_4950_ _1731_ _2367_ _2373_ _2376_ _1560_ VSS VSS VDD VDD
+ _2377_ sky130_fd_sc_hd__o2111ai_1
X_4951_ mem\[12\]\[6\] mem\[14\]\[6\] _1738_ VSS VSS VDD VDD
+ _2378_ sky130_fd_sc_hd__mux2i_1
X_4952_ mem\[8\]\[6\] mem\[10\]\[6\] _2108_ VSS VSS VDD VDD
+ _2379_ sky130_fd_sc_hd__mux2_1
X_4953_ _1490_ _1491_ _2379_ VSS VSS VDD VDD _2380_ sky130_fd_sc_hd__nand3_1
X_4954_ _2107_ _1396_ _2380_ _1743_ VSS VSS VDD VDD _2381_
+ sky130_fd_sc_hd__o22ai_1
X_4955_ _1745_ _2380_ VSS VSS VDD VDD _2382_ sky130_fd_sc_hd__nor2_1
X_4956_ _1519_ _1389_ _2140_ VSS VSS VDD VDD _2383_ sky130_fd_sc_hd__o21ai_0
X_4957_ _1514_ _2381_ _2382_ _2383_ VSS VSS VDD VDD _2384_
+ sky130_fd_sc_hd__o22ai_1
X_4958_ _1737_ _2378_ _2384_ _1501_ VSS VSS VDD VDD _2385_
+ sky130_fd_sc_hd__o211ai_1
X_4959_ mem\[13\]\[6\] mem\[15\]\[6\] _1481_ VSS VSS VDD VDD
+ _2386_ sky130_fd_sc_hd__mux2i_1
X_4960_ _1538_ _1627_ _1388_ VSS VSS VDD VDD _2387_ sky130_fd_sc_hd__nand3_1
X_4961_ _1395_ _2084_ _2144_ _2386_ _2387_ VSS VSS VDD VDD
+ _2388_ sky130_fd_sc_hd__o221ai_1
X_4962_ mem\[9\]\[6\] mem\[11\]\[6\] _1550_ VSS VSS VDD VDD
+ _2389_ sky130_fd_sc_hd__mux2i_1
X_4963_ _1588_ _2389_ _1475_ VSS VSS VDD VDD _2390_ sky130_fd_sc_hd__o21ai_0
X_4964_ net109 _0721_ _2388_ _2390_ VSS VSS VDD VDD _2391_
+ sky130_fd_sc_hd__o22a_1
X_4965_ _2377_ _2385_ _2391_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__and3_1
X_4966_ mem\[5\]\[7\] mem\[7\]\[7\] _2091_ VSS VSS VDD VDD
+ _2392_ sky130_fd_sc_hd__mux2i_1
X_4967_ _1563_ _2392_ VSS VSS VDD VDD _2393_ sky130_fd_sc_hd__nor2_1
X_4968_ _1401_ _1526_ _2393_ VSS VSS VDD VDD _2394_ sky130_fd_sc_hd__a21oi_1
X_4969_ mem\[1\]\[7\] mem\[3\]\[7\] _1480_ VSS VSS VDD VDD
+ _2395_ sky130_fd_sc_hd__mux2_1
X_4970_ _1568_ _1569_ _1478_ _2395_ VSS VSS VDD VDD _2396_
+ sky130_fd_sc_hd__nand4_1
X_4971_ _0860_ _1740_ _1410_ _2396_ VSS VSS VDD VDD _2397_
+ sky130_fd_sc_hd__o31ai_1
X_4972_ mem\[4\]\[7\] mem\[6\]\[7\] _2098_ VSS VSS VDD VDD
+ _2398_ sky130_fd_sc_hd__mux2i_1
X_4973_ _1402_ _1596_ _1580_ _2398_ _0906_ VSS VSS VDD VDD
+ _2399_ sky130_fd_sc_hd__o221ai_1
X_4974_ _1552_ _2397_ _2399_ VSS VSS VDD VDD _2400_ sky130_fd_sc_hd__o21ai_0
X_4975_ mem\[1\]\[7\] _1455_ _1459_ mem\[0\]\[7\] VSS VSS
+ VDD VDD _2401_ sky130_fd_sc_hd__o22ai_1
X_4976_ mem\[2\]\[7\] _1767_ _1768_ mem\[3\]\[7\] VSS VSS
+ VDD VDD _2402_ sky130_fd_sc_hd__o22ai_1
X_4977_ _1471_ _2401_ _2402_ VSS VSS VDD VDD _2403_ sky130_fd_sc_hd__or3_1
X_4978_ _1731_ _2394_ _2400_ _2403_ _1560_ VSS VSS VDD VDD
+ _2404_ sky130_fd_sc_hd__o2111ai_1
X_4979_ mem\[12\]\[7\] mem\[14\]\[7\] _1738_ VSS VSS VDD VDD
+ _2405_ sky130_fd_sc_hd__mux2i_1
X_4980_ mem\[8\]\[7\] mem\[10\]\[7\] _2108_ VSS VSS VDD VDD
+ _2406_ sky130_fd_sc_hd__mux2_1
X_4981_ _1490_ _1491_ _2406_ VSS VSS VDD VDD _2407_ sky130_fd_sc_hd__nand3_1
X_4982_ _2107_ _1413_ _2407_ _1743_ VSS VSS VDD VDD _2408_
+ sky130_fd_sc_hd__o22ai_1
X_4983_ _1745_ _2407_ VSS VSS VDD VDD _2409_ sky130_fd_sc_hd__nor2_1
X_4984_ _1519_ _1406_ _2140_ VSS VSS VDD VDD _2410_ sky130_fd_sc_hd__o21ai_0
X_4985_ _1514_ _2408_ _2409_ _2410_ VSS VSS VDD VDD _2411_
+ sky130_fd_sc_hd__o22ai_1
X_4986_ _1737_ _2405_ _2411_ _1501_ VSS VSS VDD VDD _2412_
+ sky130_fd_sc_hd__o211ai_1
X_4987_ mem\[13\]\[7\] mem\[15\]\[7\] _1481_ VSS VSS VDD VDD
+ _2413_ sky130_fd_sc_hd__mux2i_1
X_4988_ _1538_ _1627_ _1405_ VSS VSS VDD VDD _2414_ sky130_fd_sc_hd__nand3_1
X_4989_ _1412_ _1494_ _2144_ _2413_ _2414_ VSS VSS VDD VDD
+ _2415_ sky130_fd_sc_hd__o221ai_1
X_4990_ mem\[9\]\[7\] mem\[11\]\[7\] _1550_ VSS VSS VDD VDD
+ _2416_ sky130_fd_sc_hd__mux2i_1
X_4991_ _1588_ _2416_ _1475_ VSS VSS VDD VDD _2417_ sky130_fd_sc_hd__o21ai_0
X_4992_ net110 _0721_ _2415_ _2417_ VSS VSS VDD VDD _2418_
+ sky130_fd_sc_hd__o22a_1
X_4993_ _2404_ _2412_ _2418_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__and3_1
X_4994_ mem\[5\]\[8\] mem\[7\]\[8\] _1608_ VSS VSS VDD VDD
+ _2419_ sky130_fd_sc_hd__mux2i_1
X_4995_ _1563_ _2419_ VSS VSS VDD VDD _2420_ sky130_fd_sc_hd__nor2_1
X_4996_ _1418_ _1526_ _2420_ VSS VSS VDD VDD _2421_ sky130_fd_sc_hd__a21oi_1
X_4997_ mem\[1\]\[8\] mem\[3\]\[8\] _1480_ VSS VSS VDD VDD
+ _2422_ sky130_fd_sc_hd__mux2_1
X_4998_ _1568_ _1569_ _1478_ _2422_ VSS VSS VDD VDD _2423_
+ sky130_fd_sc_hd__nand4_1
X_4999_ _0860_ _1740_ _1427_ _2423_ VSS VSS VDD VDD _2424_
+ sky130_fd_sc_hd__o31ai_1
X_5000_ mem\[4\]\[8\] mem\[6\]\[8\] _1581_ VSS VSS VDD VDD
+ _2425_ sky130_fd_sc_hd__mux2i_1
X_5001_ _1419_ _1596_ _1580_ _2425_ _0906_ VSS VSS VDD VDD
+ _2426_ sky130_fd_sc_hd__o221ai_1
X_5002_ _1552_ _2424_ _2426_ VSS VSS VDD VDD _2427_ sky130_fd_sc_hd__o21ai_0
X_5003_ mem\[1\]\[8\] _1455_ _1459_ mem\[0\]\[8\] VSS VSS
+ VDD VDD _2428_ sky130_fd_sc_hd__o22ai_1
X_5004_ mem\[2\]\[8\] _1767_ _1768_ mem\[3\]\[8\] VSS VSS
+ VDD VDD _2429_ sky130_fd_sc_hd__o22ai_1
X_5005_ _1471_ _2428_ _2429_ VSS VSS VDD VDD _2430_ sky130_fd_sc_hd__or3_1
X_5006_ _1731_ _2421_ _2427_ _2430_ _1560_ VSS VSS VDD VDD
+ _2431_ sky130_fd_sc_hd__o2111ai_1
X_5007_ mem\[12\]\[8\] mem\[14\]\[8\] _1738_ VSS VSS VDD VDD
+ _2432_ sky130_fd_sc_hd__mux2i_1
X_5008_ mem\[8\]\[8\] mem\[10\]\[8\] _1483_ VSS VSS VDD VDD
+ _2433_ sky130_fd_sc_hd__mux2_1
X_5009_ _1490_ _1491_ _2433_ VSS VSS VDD VDD _2434_ sky130_fd_sc_hd__nand3_1
X_5010_ _1539_ _1430_ _2434_ _1743_ VSS VSS VDD VDD _2435_
+ sky130_fd_sc_hd__o22ai_1
X_5011_ _1745_ _2434_ VSS VSS VDD VDD _2436_ sky130_fd_sc_hd__nor2_1
X_5012_ _1519_ _1423_ _2140_ VSS VSS VDD VDD _2437_ sky130_fd_sc_hd__o21ai_0
X_5013_ _1514_ _2435_ _2436_ _2437_ VSS VSS VDD VDD _2438_
+ sky130_fd_sc_hd__o22ai_1
X_5014_ _1737_ _2432_ _2438_ _1501_ VSS VSS VDD VDD _2439_
+ sky130_fd_sc_hd__o211ai_1
X_5015_ mem\[13\]\[8\] mem\[15\]\[8\] _1481_ VSS VSS VDD VDD
+ _2440_ sky130_fd_sc_hd__mux2i_1
X_5016_ _1538_ _1627_ _1422_ VSS VSS VDD VDD _2441_ sky130_fd_sc_hd__nand3_1
X_5017_ _1429_ _1494_ _2144_ _2440_ _2441_ VSS VSS VDD VDD
+ _2442_ sky130_fd_sc_hd__o221ai_1
X_5018_ mem\[9\]\[8\] mem\[11\]\[8\] _1550_ VSS VSS VDD VDD
+ _2443_ sky130_fd_sc_hd__mux2i_1
X_5019_ _1588_ _2443_ _1475_ VSS VSS VDD VDD _2444_ sky130_fd_sc_hd__o21ai_0
X_5020_ net112 _0721_ _2442_ _2444_ VSS VSS VDD VDD _2445_
+ sky130_fd_sc_hd__o22a_1
X_5021_ _2431_ _2439_ _2445_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__and3_1
X_5022_ mem\[13\]\[9\] mem\[15\]\[9\] _1599_ VSS VSS VDD VDD
+ _2446_ sky130_fd_sc_hd__mux2i_1
X_5023_ _1448_ _1597_ _1598_ _2446_ VSS VSS VDD VDD _2447_
+ sky130_fd_sc_hd__o22ai_1
X_5024_ _1595_ _2447_ _1593_ _2534_ VSS VSS VDD VDD _2448_
+ sky130_fd_sc_hd__a211oi_1
X_5025_ mem\[9\]\[9\] mem\[11\]\[9\] _1599_ VSS VSS VDD VDD
+ _2449_ sky130_fd_sc_hd__mux2i_1
X_5026_ _1439_ _1495_ _1589_ _2449_ _0903_ VSS VSS VDD VDD
+ _2450_ sky130_fd_sc_hd__o221ai_1
X_5027_ mem\[12\]\[9\] mem\[14\]\[9\] _1533_ VSS VSS VDD VDD
+ _2451_ sky130_fd_sc_hd__mux2i_1
X_5028_ _1447_ _1548_ _1531_ _2451_ _1537_ VSS VSS VDD VDD
+ _2452_ sky130_fd_sc_hd__o221ai_1
X_5029_ mem\[10\]\[9\] _1463_ _1465_ mem\[11\]\[9\] VSS VSS
+ VDD VDD _2453_ sky130_fd_sc_hd__o22ai_1
X_5030_ mem\[9\]\[9\] _1456_ _1460_ mem\[8\]\[9\] VSS VSS
+ VDD VDD _2454_ sky130_fd_sc_hd__o22ai_1
X_5031_ _1472_ _2453_ _2454_ VSS VSS VDD VDD _2455_ sky130_fd_sc_hd__nor3_1
X_5032_ _2450_ _2452_ _2455_ VSS VSS VDD VDD _2456_ sky130_fd_sc_hd__a21oi_1
X_5033_ mem\[4\]\[9\] mem\[6\]\[9\] _1727_ VSS VSS VDD VDD
+ _2457_ sky130_fd_sc_hd__mux2i_1
X_5034_ mem\[0\]\[9\] mem\[2\]\[9\] _1483_ VSS VSS VDD VDD
+ _2458_ sky130_fd_sc_hd__mux2_1
X_5035_ _1540_ _1542_ _2458_ VSS VSS VDD VDD _2459_ sky130_fd_sc_hd__nand3_1
X_5036_ _1489_ _1436_ _2459_ _1467_ VSS VSS VDD VDD _2460_
+ sky130_fd_sc_hd__o22ai_1
X_5037_ _1468_ _2459_ VSS VSS VDD VDD _2461_ sky130_fd_sc_hd__nor2_1
X_5038_ _1567_ _1445_ _0828_ VSS VSS VDD VDD _2462_ sky130_fd_sc_hd__o21ai_0
X_5039_ _1488_ _2460_ _2461_ _2462_ VSS VSS VDD VDD _2463_
+ sky130_fd_sc_hd__o22ai_1
X_5040_ _1598_ _2457_ _2463_ _1509_ VSS VSS VDD VDD _2464_
+ sky130_fd_sc_hd__o211a_1
X_5041_ mem\[5\]\[9\] mem\[7\]\[9\] _1510_ VSS VSS VDD VDD
+ _2465_ sky130_fd_sc_hd__mux2i_1
X_5042_ _1530_ _2465_ VSS VSS VDD VDD _2466_ sky130_fd_sc_hd__nor2_1
X_5043_ _0896_ _1489_ _1446_ VSS VSS VDD VDD _2467_ sky130_fd_sc_hd__nor3_1
X_5044_ _1752_ _0714_ _1435_ _2466_ _2467_ VSS VSS VDD VDD
+ _2468_ sky130_fd_sc_hd__a311o_1
X_5045_ mem\[1\]\[9\] mem\[3\]\[9\] _1727_ VSS VSS VDD VDD
+ _2469_ sky130_fd_sc_hd__mux2i_1
X_5046_ _1726_ _2469_ VSS VSS VDD VDD _2470_ sky130_fd_sc_hd__nor2_1
X_5047_ _1522_ _2468_ _2470_ _2537_ net113 VSS VSS VDD VDD
+ _2471_ sky130_fd_sc_hd__o32ai_1
X_5048_ _2448_ _2456_ _2464_ _2471_ VSS VSS VDD VDD _0598_
+ sky130_fd_sc_hd__a211oi_1
X_5049_ _0533_ _1525_ _0528_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__mux2_1
X_5050_ _0534_ _0907_ _0528_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__mux2_1
X_5051_ _2495_ _0528_ VSS VSS VDD VDD _2472_ sky130_fd_sc_hd__nor2_1
X_5052_ _0898_ _2472_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__xnor2_1
X_5053_ _2539_ _2533_ _2532_ VSS VSS VDD VDD _2473_ sky130_fd_sc_hd__a21oi_1
X_5054_ _0897_ _0528_ _2473_ VSS VSS VDD VDD _2474_ sky130_fd_sc_hd__nor3_1
X_5055_ _0867_ _2474_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__xor2_1
X_5056_ _0531_ wr_ptr\[0\] _0530_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__mux2_1
X_5057_ _0532_ _0613_ _0530_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__mux2_1
X_5058_ _0613_ _2521_ _2530_ VSS VSS VDD VDD _2475_ sky130_fd_sc_hd__a21oi_1
X_5059_ _0530_ _2475_ VSS VSS VDD VDD _2476_ sky130_fd_sc_hd__nor2_1
X_5060_ _0622_ _2476_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__xor2_1
X_5061_ _2523_ _2528_ VSS VSS VDD VDD _2477_ sky130_fd_sc_hd__nand2_1
X_5062_ _2523_ _2528_ VSS VSS VDD VDD _2478_ sky130_fd_sc_hd__nor2b_1
X_5063_ _2521_ _2478_ _0613_ VSS VSS VDD VDD _2479_ sky130_fd_sc_hd__o21ai_0
X_5064_ _0613_ _2477_ _2479_ VSS VSS VDD VDD _2480_ sky130_fd_sc_hd__o21ai_0
X_5065_ _0530_ _2480_ _0622_ VSS VSS VDD VDD _2481_ sky130_fd_sc_hd__nand3b_1
X_5066_ _0621_ _2481_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__xnor2_1
X_5067_ _0609_ _2510_ _2548_ _2557_ _2546_ VSS VSS VDD VDD
+ _2482_ sky130_fd_sc_hd__a32oi_1
X_5068_ _0609_ _0607_ _2482_ VSS VSS VDD VDD net69 sky130_fd_sc_hd__a21oi_1
X_5069_ _0607_ net73 VSS VSS VDD VDD _2483_ sky130_fd_sc_hd__nand2_1
X_5070_ _0607_ _0616_ _2483_ _2557_ VSS VSS VDD VDD _2484_
+ sky130_fd_sc_hd__o22ai_1
X_5071_ _0609_ _2484_ VSS VSS VDD VDD _2485_ sky130_fd_sc_hd__nand2_1
X_5072_ _2563_ _2557_ _2485_ VSS VSS VDD VDD net70 sky130_fd_sc_hd__o21ai_0
X_5073_ _0609_ _0607_ net223 _2548_ VSS VSS VDD VDD net76
+ sky130_fd_sc_hd__nor4b_1
X_5074_ _2556_ _2499_ VSS VSS VDD VDD next_count\[2\] sky130_fd_sc_hd__xor2_1
X_5075_ _2496_ _2543_ _2542_ VSS VSS VDD VDD _2486_ sky130_fd_sc_hd__a21o_1
X_5076_ _2556_ _2486_ _2555_ VSS VSS VDD VDD _2487_ sky130_fd_sc_hd__a21oi_1
X_5077_ _2549_ _2487_ VSS VSS VDD VDD next_count\[3\] sky130_fd_sc_hd__xor2_1
X_5078_ _2556_ _2499_ _2555_ VSS VSS VDD VDD _2488_ sky130_fd_sc_hd__a21oi_1
X_5079_ _2549_ _2488_ VSS VSS VDD VDD _2489_ sky130_fd_sc_hd__nor2_1
X_5080_ _2550_ _2489_ VSS VSS VDD VDD _2490_ sky130_fd_sc_hd__nor2_1
X_5081_ _2490_ _2558_ VSS VSS VDD VDD next_count\[4\] sky130_fd_sc_hd__xor2_1
X_5082_ net77 _0611_ VSS VSS VDD VDD net144 sky130_fd_sc_hd__nor2_1
X_5083_ _0618_ _0617_ VSS VSS VDD VDD _2491_ sky130_fd_sc_hd__nor2_1
X_5084_ _2513_ net77 _2491_ VSS VSS VDD VDD net145 sky130_fd_sc_hd__nor3_1
X_5085_ _2492_ _2493_ _2494_ VSS VSS VDD VDD _2495_ _0534_
+ sky130_fd_sc_hd__fa_1
X_5086_ _2496_ _2497_ _2498_ VSS VSS VDD VDD _2499_ next_count\[1\]
+ sky130_fd_sc_hd__fa_2
X_5087_ _2500_ _2501_ VSS VSS VDD VDD _2502_ _2503_ sky130_fd_sc_hd__ha_1
X_5088_ _2500_ wr_ptr\[1\] VSS VSS VDD VDD _2504_ _2505_ sky130_fd_sc_hd__ha_1
X_5089_ wr_ptr\[0\] _2501_ VSS VSS VDD VDD _2506_ _2507_ sky130_fd_sc_hd__ha_1
X_5090_ wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD _2508_ _2509_
+ sky130_fd_sc_hd__ha_1
X_5091_ _2510_ _2511_ VSS VSS VDD VDD _2512_ _2513_ sky130_fd_sc_hd__ha_1
X_5092_ _2514_ _0529_ VSS VSS VDD VDD _2515_ _2516_ sky130_fd_sc_hd__ha_1
X_5093_ rd_ptr\[0\] rd_ptr\[1\] VSS VSS VDD VDD _2517_ _2518_
+ sky130_fd_sc_hd__ha_1
X_5094_ _2519_ _2520_ VSS VSS VDD VDD _2521_ _2522_ sky130_fd_sc_hd__ha_1
X_5095_ _2519_ _2520_ VSS VSS VDD VDD _2523_ _2524_ sky130_fd_sc_hd__ha_1
X_5096_ _2525_ _2526_ VSS VSS VDD VDD _0530_ _2527_ sky130_fd_sc_hd__ha_1
X_5097_ _2528_ _2529_ VSS VSS VDD VDD _2530_ _0532_ sky130_fd_sc_hd__ha_1
X_5098_ wr_ptr\[0\] _2522_ VSS VSS VDD VDD _2528_ _0531_ sky130_fd_sc_hd__ha_1
X_5099_ rd_ptr\[1\] _2531_ VSS VSS VDD VDD _2532_ _2533_ sky130_fd_sc_hd__ha_1
X_5100_ _2534_ _2535_ VSS VSS VDD VDD _0528_ _2536_ sky130_fd_sc_hd__ha_4
X_5101_ _2537_ _0529_ VSS VSS VDD VDD _2531_ _2538_ sky130_fd_sc_hd__ha_1
X_5102_ rd_ptr\[0\] _2536_ VSS VSS VDD VDD _2539_ _0533_ sky130_fd_sc_hd__ha_1
X_5103_ _2540_ _2494_ VSS VSS VDD VDD _2541_ _2498_ sky130_fd_sc_hd__ha_1
X_5104_ _2497_ _2498_ VSS VSS VDD VDD _2542_ _2543_ sky130_fd_sc_hd__ha_1
X_5105_ _2514_ _2536_ VSS VSS VDD VDD _2544_ _2545_ sky130_fd_sc_hd__ha_1
X_5106_ _2546_ _2547_ VSS VSS VDD VDD _2548_ _2549_ sky130_fd_sc_hd__ha_1
X_5107_ net73 _2547_ VSS VSS VDD VDD _2550_ _2551_ sky130_fd_sc_hd__ha_1
X_5108_ net73 net169 VSS VSS VDD VDD _2552_ _2553_ sky130_fd_sc_hd__ha_1
X_5109_ _2546_ _2554_ VSS VSS VDD VDD _2555_ _2556_ sky130_fd_sc_hd__ha_1
X_5110_ _2510_ _2547_ VSS VSS VDD VDD _2557_ _2558_ sky130_fd_sc_hd__ha_4
X_5111_ net167 _2510_ VSS VSS VDD VDD _2559_ _2560_ sky130_fd_sc_hd__ha_1
X_5112_ net167 net168 VSS VSS VDD VDD _2561_ _2562_ sky130_fd_sc_hd__ha_1
X_5113_ net169 _2510_ VSS VSS VDD VDD _2563_ _2564_ sky130_fd_sc_hd__ha_1
X_5114_ net170 net168 VSS VSS VDD VDD _2565_ _2566_ sky130_fd_sc_hd__ha_1
X_5115_ _2567_ _2522_ VSS VSS VDD VDD _2496_ next_count\[0\]
+ sky130_fd_sc_hd__ha_1
Xfifo_count\[0\]$_DFF_PN0_ clknet_leaf_58_clk next_count\[0\]
+ net1 VSS VSS VDD VDD net71 sky130_fd_sc_hd__dfrtp_1
Xfifo_count\[1\]$_DFF_PN0_ clknet_leaf_58_clk next_count\[1\]
+ net1 VSS VSS VDD VDD net72 sky130_fd_sc_hd__dfrtp_1
Xfifo_count\[2\]$_DFF_PN0_ clknet_leaf_58_clk next_count\[2\]
+ net1 VSS VSS VDD VDD net73 sky130_fd_sc_hd__dfrtp_4
Xfifo_count\[3\]$_DFF_PN0_ clknet_leaf_58_clk next_count\[3\]
+ net1 VSS VSS VDD VDD net74 sky130_fd_sc_hd__dfrtp_1
Xfifo_count\[4\]$_DFF_PN0_ clknet_leaf_58_clk next_count\[4\]
+ net1 VSS VSS VDD VDD net75 sky130_fd_sc_hd__dfrtp_2
Xmem\[0\]\[0\]$_DFFE_PP_ clknet_leaf_47_clk _0016_ net217
+ VSS VSS VDD VDD mem\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[10\]$_DFFE_PP_ clknet_leaf_35_clk _0017_ net217
+ VSS VSS VDD VDD mem\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[11\]$_DFFE_PP_ clknet_leaf_37_clk _0018_ net217
+ VSS VSS VDD VDD mem\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[12\]$_DFFE_PP_ clknet_leaf_34_clk _0019_ net217
+ VSS VSS VDD VDD mem\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[13\]$_DFFE_PP_ clknet_leaf_34_clk _0020_ net217
+ VSS VSS VDD VDD mem\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[14\]$_DFFE_PP_ clknet_leaf_34_clk _0021_ net217
+ VSS VSS VDD VDD mem\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[15\]$_DFFE_PP_ clknet_leaf_37_clk _0022_ net217
+ VSS VSS VDD VDD mem\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[16\]$_DFFE_PP_ clknet_leaf_22_clk _0023_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[17\]$_DFFE_PP_ clknet_leaf_22_clk _0024_ net217
+ VSS VSS VDD VDD mem\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[18\]$_DFFE_PP_ clknet_leaf_22_clk _0025_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[19\]$_DFFE_PP_ clknet_leaf_20_clk _0026_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk _0027_ net217
+ VSS VSS VDD VDD mem\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0028_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0029_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[22\]$_DFFE_PP_ clknet_leaf_7_clk _0030_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[23\]$_DFFE_PP_ clknet_leaf_11_clk _0031_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[24\]$_DFFE_PP_ clknet_leaf_50_clk _0032_ net217
+ VSS VSS VDD VDD mem\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0033_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0034_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[27\]$_DFFE_PP_ clknet_leaf_8_clk _0035_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0036_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0037_ net217
+ VSS VSS VDD VDD mem\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0038_ net217
+ VSS VSS VDD VDD mem\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[30\]$_DFFE_PP_ clknet_leaf_3_clk _0039_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[31\]$_DFFE_PP_ clknet_leaf_3_clk _0040_ _0015_
+ VSS VSS VDD VDD mem\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[3\]$_DFFE_PP_ clknet_leaf_3_clk _0041_ _0015_ VSS
+ VSS VDD VDD mem\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[4\]$_DFFE_PP_ clknet_leaf_45_clk _0042_ net217
+ VSS VSS VDD VDD mem\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[5\]$_DFFE_PP_ clknet_leaf_51_clk _0043_ net217
+ VSS VSS VDD VDD mem\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[6\]$_DFFE_PP_ clknet_leaf_52_clk _0044_ net217
+ VSS VSS VDD VDD mem\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[7\]$_DFFE_PP_ clknet_leaf_52_clk _0045_ net217
+ VSS VSS VDD VDD mem\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[8\]$_DFFE_PP_ clknet_leaf_53_clk _0046_ net217
+ VSS VSS VDD VDD mem\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[0\]\[9\]$_DFFE_PP_ clknet_leaf_37_clk _0047_ net217
+ VSS VSS VDD VDD mem\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk net179 net152
+ VSS VSS VDD VDD mem\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[10\]$_DFFE_PP_ clknet_leaf_31_clk net183 net152
+ VSS VSS VDD VDD mem\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0050_ net152
+ VSS VSS VDD VDD mem\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0051_ net152
+ VSS VSS VDD VDD mem\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0052_ net152
+ VSS VSS VDD VDD mem\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[14\]$_DFFE_PP_ clknet_leaf_28_clk _0053_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0054_ net152
+ VSS VSS VDD VDD mem\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[16\]$_DFFE_PP_ clknet_leaf_28_clk _0055_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[17\]$_DFFE_PP_ clknet_leaf_25_clk _0056_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0057_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[19\]$_DFFE_PP_ clknet_leaf_17_clk _0058_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0059_ net152
+ VSS VSS VDD VDD mem\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0060_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0061_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[22\]$_DFFE_PP_ clknet_leaf_14_clk _0062_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0063_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0064_ net152
+ VSS VSS VDD VDD mem\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk _0065_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk _0066_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[27\]$_DFFE_PP_ clknet_leaf_10_clk _0067_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0068_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0069_ net152
+ VSS VSS VDD VDD mem\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0070_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0071_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0072_ _0014_
+ VSS VSS VDD VDD mem\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[3\]$_DFFE_PP_ clknet_leaf_57_clk net212 net152
+ VSS VSS VDD VDD mem\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[4\]$_DFFE_PP_ clknet_leaf_43_clk _0074_ net152
+ VSS VSS VDD VDD mem\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0075_ net152
+ VSS VSS VDD VDD mem\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0076_ net152
+ VSS VSS VDD VDD mem\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0077_ net152
+ VSS VSS VDD VDD mem\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0078_ net152
+ VSS VSS VDD VDD mem\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[10\]\[9\]$_DFFE_PP_ clknet_leaf_42_clk _0079_ net152
+ VSS VSS VDD VDD mem\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0080_ net150
+ VSS VSS VDD VDD mem\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0081_ net150
+ VSS VSS VDD VDD mem\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0082_ net150
+ VSS VSS VDD VDD mem\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0083_ net150
+ VSS VSS VDD VDD mem\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk net186 net150
+ VSS VSS VDD VDD mem\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[14\]$_DFFE_PP_ clknet_leaf_28_clk _0085_ net149
+ VSS VSS VDD VDD mem\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0086_ net150
+ VSS VSS VDD VDD mem\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[16\]$_DFFE_PP_ clknet_leaf_28_clk _0087_ net149
+ VSS VSS VDD VDD mem\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[17\]$_DFFE_PP_ clknet_leaf_25_clk _0088_ net149
+ VSS VSS VDD VDD mem\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0089_ net149
+ VSS VSS VDD VDD mem\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[19\]$_DFFE_PP_ clknet_leaf_17_clk _0090_ net149
+ VSS VSS VDD VDD mem\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0091_ net150
+ VSS VSS VDD VDD mem\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0092_ net149
+ VSS VSS VDD VDD mem\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk net196 net149
+ VSS VSS VDD VDD mem\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[22\]$_DFFE_PP_ clknet_leaf_14_clk _0094_ net149
+ VSS VSS VDD VDD mem\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0095_ net149
+ VSS VSS VDD VDD mem\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0096_ _0013_
+ VSS VSS VDD VDD mem\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk _0097_ net149
+ VSS VSS VDD VDD mem\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0098_ net149
+ VSS VSS VDD VDD mem\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[27\]$_DFFE_PP_ clknet_leaf_11_clk _0099_ net149
+ VSS VSS VDD VDD mem\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0100_ net149
+ VSS VSS VDD VDD mem\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[29\]$_DFFE_PP_ clknet_leaf_35_clk _0101_ _0013_
+ VSS VSS VDD VDD mem\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[2\]$_DFFE_PP_ clknet_leaf_59_clk _0102_ net149
+ VSS VSS VDD VDD mem\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0103_ net149
+ VSS VSS VDD VDD mem\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0104_ net149
+ VSS VSS VDD VDD mem\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0105_ _0013_
+ VSS VSS VDD VDD mem\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[4\]$_DFFE_PP_ clknet_leaf_43_clk _0106_ net150
+ VSS VSS VDD VDD mem\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0107_ net150
+ VSS VSS VDD VDD mem\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0108_ net150
+ VSS VSS VDD VDD mem\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0109_ net150
+ VSS VSS VDD VDD mem\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0110_ net150
+ VSS VSS VDD VDD mem\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[11\]\[9\]$_DFFE_PP_ clknet_leaf_42_clk _0111_ net150
+ VSS VSS VDD VDD mem\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0112_ net154
+ VSS VSS VDD VDD mem\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0113_ net154
+ VSS VSS VDD VDD mem\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0114_ net154
+ VSS VSS VDD VDD mem\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0115_ net154
+ VSS VSS VDD VDD mem\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0116_ net154
+ VSS VSS VDD VDD mem\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[14\]$_DFFE_PP_ clknet_leaf_28_clk _0117_ net153
+ VSS VSS VDD VDD mem\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0118_ net154
+ VSS VSS VDD VDD mem\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[16\]$_DFFE_PP_ clknet_leaf_28_clk _0119_ net153
+ VSS VSS VDD VDD mem\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[17\]$_DFFE_PP_ clknet_leaf_26_clk _0120_ net153
+ VSS VSS VDD VDD mem\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0121_ net153
+ VSS VSS VDD VDD mem\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0122_ net153
+ VSS VSS VDD VDD mem\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0123_ net154
+ VSS VSS VDD VDD mem\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0124_ net153
+ VSS VSS VDD VDD mem\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0125_ net153
+ VSS VSS VDD VDD mem\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[22\]$_DFFE_PP_ clknet_leaf_15_clk _0126_ net153
+ VSS VSS VDD VDD mem\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk _0127_ net153
+ VSS VSS VDD VDD mem\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0128_ _0012_
+ VSS VSS VDD VDD mem\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk _0129_ net153
+ VSS VSS VDD VDD mem\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk _0130_ net153
+ VSS VSS VDD VDD mem\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[27\]$_DFFE_PP_ clknet_leaf_10_clk _0131_ net153
+ VSS VSS VDD VDD mem\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0132_ net153
+ VSS VSS VDD VDD mem\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[29\]$_DFFE_PP_ clknet_leaf_35_clk _0133_ _0012_
+ VSS VSS VDD VDD mem\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0134_ net153
+ VSS VSS VDD VDD mem\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk net202 net153
+ VSS VSS VDD VDD mem\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0136_ net153
+ VSS VSS VDD VDD mem\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0137_ net153
+ VSS VSS VDD VDD mem\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0138_ net154
+ VSS VSS VDD VDD mem\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0139_ net154
+ VSS VSS VDD VDD mem\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0140_ net154
+ VSS VSS VDD VDD mem\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0141_ net154
+ VSS VSS VDD VDD mem\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0142_ net154
+ VSS VSS VDD VDD mem\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[12\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0143_ net154
+ VSS VSS VDD VDD mem\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0144_ net155
+ VSS VSS VDD VDD mem\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0145_ net155
+ VSS VSS VDD VDD mem\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk _0146_ net155
+ VSS VSS VDD VDD mem\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0147_ net155
+ VSS VSS VDD VDD mem\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0148_ net155
+ VSS VSS VDD VDD mem\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[14\]$_DFFE_PP_ clknet_leaf_29_clk _0149_ net155
+ VSS VSS VDD VDD mem\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0150_ net155
+ VSS VSS VDD VDD mem\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[16\]$_DFFE_PP_ clknet_leaf_26_clk _0151_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[17\]$_DFFE_PP_ clknet_leaf_26_clk _0152_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0153_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0154_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0155_ net155
+ VSS VSS VDD VDD mem\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0156_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0157_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[22\]$_DFFE_PP_ clknet_leaf_14_clk _0158_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0159_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0160_ net155
+ VSS VSS VDD VDD mem\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk net206 _0011_
+ VSS VSS VDD VDD mem\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk net175 _0011_
+ VSS VSS VDD VDD mem\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[27\]$_DFFE_PP_ clknet_leaf_9_clk _0163_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0164_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0165_ net155
+ VSS VSS VDD VDD mem\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0166_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[30\]$_DFFE_PP_ clknet_leaf_1_clk _0167_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0168_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0169_ _0011_
+ VSS VSS VDD VDD mem\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0170_ net155
+ VSS VSS VDD VDD mem\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0171_ net155
+ VSS VSS VDD VDD mem\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0172_ net155
+ VSS VSS VDD VDD mem\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0173_ net155
+ VSS VSS VDD VDD mem\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0174_ net155
+ VSS VSS VDD VDD mem\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[13\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0175_ net155
+ VSS VSS VDD VDD mem\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0176_ net157
+ VSS VSS VDD VDD mem\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0177_ net157
+ VSS VSS VDD VDD mem\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0178_ net157
+ VSS VSS VDD VDD mem\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0179_ net157
+ VSS VSS VDD VDD mem\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0180_ net157
+ VSS VSS VDD VDD mem\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[14\]$_DFFE_PP_ clknet_leaf_28_clk _0181_ net156
+ VSS VSS VDD VDD mem\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0182_ net157
+ VSS VSS VDD VDD mem\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[16\]$_DFFE_PP_ clknet_leaf_28_clk _0183_ net156
+ VSS VSS VDD VDD mem\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[17\]$_DFFE_PP_ clknet_leaf_26_clk _0184_ net156
+ VSS VSS VDD VDD mem\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0185_ net156
+ VSS VSS VDD VDD mem\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0186_ net156
+ VSS VSS VDD VDD mem\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0187_ net157
+ VSS VSS VDD VDD mem\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0188_ net156
+ VSS VSS VDD VDD mem\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0189_ net156
+ VSS VSS VDD VDD mem\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[22\]$_DFFE_PP_ clknet_leaf_14_clk _0190_ net156
+ VSS VSS VDD VDD mem\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[23\]$_DFFE_PP_ clknet_leaf_13_clk _0191_ net156
+ VSS VSS VDD VDD mem\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0192_ _0010_
+ VSS VSS VDD VDD mem\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[25\]$_DFFE_PP_ clknet_leaf_13_clk _0193_ net156
+ VSS VSS VDD VDD mem\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk _0194_ net156
+ VSS VSS VDD VDD mem\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[27\]$_DFFE_PP_ clknet_leaf_10_clk _0195_ net156
+ VSS VSS VDD VDD mem\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0196_ net156
+ VSS VSS VDD VDD mem\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[29\]$_DFFE_PP_ clknet_leaf_35_clk _0197_ _0010_
+ VSS VSS VDD VDD mem\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0198_ net156
+ VSS VSS VDD VDD mem\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0199_ net156
+ VSS VSS VDD VDD mem\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[31\]$_DFFE_PP_ clknet_leaf_0_clk _0200_ net156
+ VSS VSS VDD VDD mem\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0201_ net156
+ VSS VSS VDD VDD mem\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk net190 net157
+ VSS VSS VDD VDD mem\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0203_ net157
+ VSS VSS VDD VDD mem\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0204_ net157
+ VSS VSS VDD VDD mem\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0205_ net157
+ VSS VSS VDD VDD mem\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0206_ net157
+ VSS VSS VDD VDD mem\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[14\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0207_ net157
+ VSS VSS VDD VDD mem\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[0\]$_DFFE_PP_ clknet_leaf_47_clk _0208_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[10\]$_DFFE_PP_ clknet_leaf_31_clk _0209_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[11\]$_DFFE_PP_ clknet_leaf_40_clk _0210_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0211_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0212_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[14\]$_DFFE_PP_ clknet_leaf_27_clk _0213_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0214_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[16\]$_DFFE_PP_ clknet_leaf_26_clk _0215_ net158
+ VSS VSS VDD VDD mem\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[17\]$_DFFE_PP_ clknet_leaf_26_clk _0216_ net158
+ VSS VSS VDD VDD mem\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[18\]$_DFFE_PP_ clknet_leaf_24_clk _0217_ net158
+ VSS VSS VDD VDD mem\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0218_ net158
+ VSS VSS VDD VDD mem\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0219_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0220_ net158
+ VSS VSS VDD VDD mem\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0221_ net158
+ VSS VSS VDD VDD mem\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[22\]$_DFFE_PP_ clknet_leaf_15_clk _0222_ net158
+ VSS VSS VDD VDD mem\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0223_ net158
+ VSS VSS VDD VDD mem\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0224_ net158
+ VSS VSS VDD VDD mem\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk _0225_ net158
+ VSS VSS VDD VDD mem\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[26\]$_DFFE_PP_ clknet_leaf_10_clk _0226_ net158
+ VSS VSS VDD VDD mem\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[27\]$_DFFE_PP_ clknet_leaf_9_clk _0227_ net158
+ VSS VSS VDD VDD mem\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0228_ net158
+ VSS VSS VDD VDD mem\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0229_ net158
+ VSS VSS VDD VDD mem\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0230_ net158
+ VSS VSS VDD VDD mem\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0231_ net158
+ VSS VSS VDD VDD mem\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0232_ net158
+ VSS VSS VDD VDD mem\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0233_ net158
+ VSS VSS VDD VDD mem\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0234_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0235_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0236_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[7\]$_DFFE_PP_ clknet_leaf_54_clk _0237_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0238_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[15\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0239_ _0009_
+ VSS VSS VDD VDD mem\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[0\]$_DFFE_PP_ clknet_leaf_48_clk _0240_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[10\]$_DFFE_PP_ clknet_leaf_35_clk _0241_ net162
+ VSS VSS VDD VDD mem\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[11\]$_DFFE_PP_ clknet_leaf_36_clk _0242_ net162
+ VSS VSS VDD VDD mem\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[12\]$_DFFE_PP_ clknet_leaf_35_clk _0243_ net162
+ VSS VSS VDD VDD mem\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[13\]$_DFFE_PP_ clknet_leaf_34_clk _0244_ net162
+ VSS VSS VDD VDD mem\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[14\]$_DFFE_PP_ clknet_leaf_23_clk _0245_ net162
+ VSS VSS VDD VDD mem\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[15\]$_DFFE_PP_ clknet_leaf_37_clk _0246_ net162
+ VSS VSS VDD VDD mem\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[16\]$_DFFE_PP_ clknet_leaf_22_clk _0247_ net162
+ VSS VSS VDD VDD mem\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[17\]$_DFFE_PP_ clknet_leaf_22_clk _0248_ net162
+ VSS VSS VDD VDD mem\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[18\]$_DFFE_PP_ clknet_leaf_22_clk _0249_ net162
+ VSS VSS VDD VDD mem\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[19\]$_DFFE_PP_ clknet_leaf_20_clk _0250_ net162
+ VSS VSS VDD VDD mem\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk _0251_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0252_ net162
+ VSS VSS VDD VDD mem\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0253_ net162
+ VSS VSS VDD VDD mem\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[22\]$_DFFE_PP_ clknet_leaf_19_clk _0254_ net162
+ VSS VSS VDD VDD mem\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk _0255_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[24\]$_DFFE_PP_ clknet_leaf_5_clk _0256_ net162
+ VSS VSS VDD VDD mem\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk _0257_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0258_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[27\]$_DFFE_PP_ clknet_leaf_8_clk _0259_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0260_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0261_ net162
+ VSS VSS VDD VDD mem\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0262_ net162
+ VSS VSS VDD VDD mem\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[30\]$_DFFE_PP_ clknet_leaf_3_clk _0263_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[31\]$_DFFE_PP_ clknet_leaf_3_clk _0264_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[3\]$_DFFE_PP_ clknet_leaf_4_clk _0265_ _0008_ VSS
+ VSS VDD VDD mem\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[4\]$_DFFE_PP_ clknet_leaf_45_clk _0266_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[5\]$_DFFE_PP_ clknet_leaf_52_clk _0267_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[6\]$_DFFE_PP_ clknet_leaf_52_clk _0268_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[7\]$_DFFE_PP_ clknet_leaf_52_clk _0269_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[8\]$_DFFE_PP_ clknet_leaf_53_clk _0270_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[1\]\[9\]$_DFFE_PP_ clknet_leaf_49_clk _0271_ _0008_
+ VSS VSS VDD VDD mem\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[0\]$_DFFE_PP_ clknet_leaf_47_clk _0272_ net218
+ VSS VSS VDD VDD mem\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[10\]$_DFFE_PP_ clknet_leaf_35_clk _0273_ net218
+ VSS VSS VDD VDD mem\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[11\]$_DFFE_PP_ clknet_leaf_37_clk _0274_ net218
+ VSS VSS VDD VDD mem\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[12\]$_DFFE_PP_ clknet_leaf_35_clk _0275_ net218
+ VSS VSS VDD VDD mem\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[13\]$_DFFE_PP_ clknet_leaf_34_clk _0276_ net218
+ VSS VSS VDD VDD mem\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[14\]$_DFFE_PP_ clknet_leaf_34_clk _0277_ net218
+ VSS VSS VDD VDD mem\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[15\]$_DFFE_PP_ clknet_leaf_37_clk _0278_ net218
+ VSS VSS VDD VDD mem\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[16\]$_DFFE_PP_ clknet_leaf_22_clk _0279_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[17\]$_DFFE_PP_ clknet_leaf_34_clk _0280_ net218
+ VSS VSS VDD VDD mem\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[18\]$_DFFE_PP_ clknet_leaf_22_clk _0281_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[19\]$_DFFE_PP_ clknet_leaf_20_clk _0282_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk _0283_ net218
+ VSS VSS VDD VDD mem\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0284_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0285_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[22\]$_DFFE_PP_ clknet_leaf_19_clk _0286_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[23\]$_DFFE_PP_ clknet_leaf_11_clk _0287_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[24\]$_DFFE_PP_ clknet_leaf_50_clk _0288_ net218
+ VSS VSS VDD VDD mem\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[25\]$_DFFE_PP_ clknet_leaf_7_clk _0289_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0290_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[27\]$_DFFE_PP_ clknet_leaf_8_clk _0291_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0292_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0293_ net218
+ VSS VSS VDD VDD mem\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0294_ net218
+ VSS VSS VDD VDD mem\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[30\]$_DFFE_PP_ clknet_leaf_4_clk _0295_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[31\]$_DFFE_PP_ clknet_leaf_4_clk _0296_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[3\]$_DFFE_PP_ clknet_leaf_3_clk _0297_ _0007_ VSS
+ VSS VDD VDD mem\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[4\]$_DFFE_PP_ clknet_leaf_45_clk _0298_ net218
+ VSS VSS VDD VDD mem\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[5\]$_DFFE_PP_ clknet_leaf_51_clk _0299_ net218
+ VSS VSS VDD VDD mem\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0300_ _0007_
+ VSS VSS VDD VDD mem\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[7\]$_DFFE_PP_ clknet_leaf_52_clk _0301_ net218
+ VSS VSS VDD VDD mem\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0302_ net218
+ VSS VSS VDD VDD mem\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[2\]\[9\]$_DFFE_PP_ clknet_leaf_37_clk _0303_ net218
+ VSS VSS VDD VDD mem\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[0\]$_DFFE_PP_ clknet_leaf_48_clk _0304_ net160
+ VSS VSS VDD VDD mem\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[10\]$_DFFE_PP_ clknet_leaf_35_clk _0305_ net160
+ VSS VSS VDD VDD mem\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[11\]$_DFFE_PP_ clknet_leaf_36_clk _0306_ net160
+ VSS VSS VDD VDD mem\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[12\]$_DFFE_PP_ clknet_leaf_34_clk _0307_ net160
+ VSS VSS VDD VDD mem\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[13\]$_DFFE_PP_ clknet_leaf_34_clk _0308_ net159
+ VSS VSS VDD VDD mem\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[14\]$_DFFE_PP_ clknet_leaf_23_clk _0309_ net159
+ VSS VSS VDD VDD mem\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[15\]$_DFFE_PP_ clknet_leaf_37_clk _0310_ net160
+ VSS VSS VDD VDD mem\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[16\]$_DFFE_PP_ clknet_leaf_22_clk _0311_ net159
+ VSS VSS VDD VDD mem\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[17\]$_DFFE_PP_ clknet_leaf_22_clk _0312_ net159
+ VSS VSS VDD VDD mem\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[18\]$_DFFE_PP_ clknet_leaf_22_clk _0313_ net159
+ VSS VSS VDD VDD mem\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[19\]$_DFFE_PP_ clknet_leaf_20_clk _0314_ net159
+ VSS VSS VDD VDD mem\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[1\]$_DFFE_PP_ clknet_leaf_45_clk _0315_ net160
+ VSS VSS VDD VDD mem\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0316_ net159
+ VSS VSS VDD VDD mem\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0317_ net159
+ VSS VSS VDD VDD mem\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[22\]$_DFFE_PP_ clknet_leaf_19_clk _0318_ net159
+ VSS VSS VDD VDD mem\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[23\]$_DFFE_PP_ clknet_leaf_11_clk _0319_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[24\]$_DFFE_PP_ clknet_leaf_50_clk _0320_ net159
+ VSS VSS VDD VDD mem\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[25\]$_DFFE_PP_ clknet_leaf_11_clk _0321_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0322_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[27\]$_DFFE_PP_ clknet_leaf_8_clk _0323_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[28\]$_DFFE_PP_ clknet_leaf_8_clk _0324_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0325_ net159
+ VSS VSS VDD VDD mem\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0326_ net159
+ VSS VSS VDD VDD mem\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[30\]$_DFFE_PP_ clknet_leaf_3_clk _0327_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[31\]$_DFFE_PP_ clknet_leaf_3_clk _0328_ _0006_
+ VSS VSS VDD VDD mem\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[3\]$_DFFE_PP_ clknet_leaf_4_clk _0329_ _0006_ VSS
+ VSS VDD VDD mem\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[4\]$_DFFE_PP_ clknet_leaf_45_clk _0330_ net160
+ VSS VSS VDD VDD mem\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[5\]$_DFFE_PP_ clknet_leaf_51_clk _0331_ net159
+ VSS VSS VDD VDD mem\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0332_ net160
+ VSS VSS VDD VDD mem\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[7\]$_DFFE_PP_ clknet_leaf_52_clk _0333_ net160
+ VSS VSS VDD VDD mem\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[8\]$_DFFE_PP_ clknet_leaf_53_clk _0334_ net160
+ VSS VSS VDD VDD mem\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[3\]\[9\]$_DFFE_PP_ clknet_leaf_49_clk _0335_ net160
+ VSS VSS VDD VDD mem\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0336_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[10\]$_DFFE_PP_ clknet_leaf_33_clk _0337_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0338_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[12\]$_DFFE_PP_ clknet_leaf_33_clk _0339_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[13\]$_DFFE_PP_ clknet_leaf_30_clk _0340_ net148
+ VSS VSS VDD VDD mem\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[14\]$_DFFE_PP_ clknet_leaf_30_clk _0341_ net148
+ VSS VSS VDD VDD mem\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[15\]$_DFFE_PP_ clknet_leaf_38_clk _0342_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[16\]$_DFFE_PP_ clknet_leaf_27_clk _0343_ net148
+ VSS VSS VDD VDD mem\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[17\]$_DFFE_PP_ clknet_leaf_23_clk _0344_ net148
+ VSS VSS VDD VDD mem\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[18\]$_DFFE_PP_ clknet_leaf_23_clk _0345_ net148
+ VSS VSS VDD VDD mem\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[19\]$_DFFE_PP_ clknet_leaf_20_clk _0346_ net148
+ VSS VSS VDD VDD mem\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0347_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk _0348_ net148
+ VSS VSS VDD VDD mem\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0349_ net148
+ VSS VSS VDD VDD mem\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[22\]$_DFFE_PP_ clknet_leaf_19_clk _0350_ net148
+ VSS VSS VDD VDD mem\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[23\]$_DFFE_PP_ clknet_leaf_12_clk _0351_ net148
+ VSS VSS VDD VDD mem\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[24\]$_DFFE_PP_ clknet_leaf_5_clk _0352_ net148
+ VSS VSS VDD VDD mem\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk _0353_ net148
+ VSS VSS VDD VDD mem\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0354_ net148
+ VSS VSS VDD VDD mem\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[27\]$_DFFE_PP_ clknet_leaf_6_clk _0355_ net148
+ VSS VSS VDD VDD mem\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[28\]$_DFFE_PP_ clknet_leaf_6_clk _0356_ net148
+ VSS VSS VDD VDD mem\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0357_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0358_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[30\]$_DFFE_PP_ clknet_leaf_6_clk _0359_ net148
+ VSS VSS VDD VDD mem\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[31\]$_DFFE_PP_ clknet_leaf_4_clk _0360_ net148
+ VSS VSS VDD VDD mem\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[3\]$_DFFE_PP_ clknet_leaf_52_clk _0361_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0362_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[5\]$_DFFE_PP_ clknet_leaf_56_clk _0363_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0364_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[7\]$_DFFE_PP_ clknet_leaf_53_clk _0365_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0366_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[4\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0367_ _0005_
+ VSS VSS VDD VDD mem\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk _0368_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[10\]$_DFFE_PP_ clknet_leaf_33_clk _0369_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[11\]$_DFFE_PP_ clknet_leaf_37_clk _0370_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[12\]$_DFFE_PP_ clknet_leaf_33_clk _0371_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[13\]$_DFFE_PP_ clknet_leaf_34_clk _0372_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[14\]$_DFFE_PP_ clknet_leaf_27_clk _0373_ net161
+ VSS VSS VDD VDD mem\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[15\]$_DFFE_PP_ clknet_leaf_38_clk _0374_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[16\]$_DFFE_PP_ clknet_leaf_27_clk _0375_ net161
+ VSS VSS VDD VDD mem\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[17\]$_DFFE_PP_ clknet_leaf_23_clk _0376_ net161
+ VSS VSS VDD VDD mem\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[18\]$_DFFE_PP_ clknet_leaf_24_clk _0377_ net161
+ VSS VSS VDD VDD mem\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[19\]$_DFFE_PP_ clknet_leaf_18_clk _0378_ net161
+ VSS VSS VDD VDD mem\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0379_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0380_ net161
+ VSS VSS VDD VDD mem\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[21\]$_DFFE_PP_ clknet_leaf_18_clk _0381_ net161
+ VSS VSS VDD VDD mem\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[22\]$_DFFE_PP_ clknet_leaf_16_clk _0382_ net161
+ VSS VSS VDD VDD mem\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[23\]$_DFFE_PP_ clknet_leaf_15_clk _0383_ net161
+ VSS VSS VDD VDD mem\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0384_ net161
+ VSS VSS VDD VDD mem\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk _0385_ net161
+ VSS VSS VDD VDD mem\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk _0386_ net161
+ VSS VSS VDD VDD mem\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[27\]$_DFFE_PP_ clknet_leaf_6_clk _0387_ net161
+ VSS VSS VDD VDD mem\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[28\]$_DFFE_PP_ clknet_leaf_6_clk _0388_ net161
+ VSS VSS VDD VDD mem\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0389_ net161
+ VSS VSS VDD VDD mem\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[2\]$_DFFE_PP_ clknet_leaf_5_clk _0390_ net161 VSS
+ VSS VDD VDD mem\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[30\]$_DFFE_PP_ clknet_leaf_5_clk _0391_ net161
+ VSS VSS VDD VDD mem\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[31\]$_DFFE_PP_ clknet_leaf_4_clk _0392_ net161
+ VSS VSS VDD VDD mem\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[3\]$_DFFE_PP_ clknet_leaf_4_clk _0393_ net161 VSS
+ VSS VDD VDD mem\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0394_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[5\]$_DFFE_PP_ clknet_leaf_56_clk _0395_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0396_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[7\]$_DFFE_PP_ clknet_leaf_53_clk _0397_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0398_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[5\]\[9\]$_DFFE_PP_ clknet_leaf_38_clk _0399_ _0004_
+ VSS VSS VDD VDD mem\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[0\]$_DFFE_PP_ clknet_leaf_45_clk _0400_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[10\]$_DFFE_PP_ clknet_leaf_33_clk _0401_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0402_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[12\]$_DFFE_PP_ clknet_leaf_33_clk _0403_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[13\]$_DFFE_PP_ clknet_leaf_30_clk _0404_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[14\]$_DFFE_PP_ clknet_leaf_30_clk _0405_ net216
+ VSS VSS VDD VDD mem\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[15\]$_DFFE_PP_ clknet_leaf_38_clk _0406_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[16\]$_DFFE_PP_ clknet_leaf_27_clk _0407_ net216
+ VSS VSS VDD VDD mem\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[17\]$_DFFE_PP_ clknet_leaf_23_clk _0408_ net216
+ VSS VSS VDD VDD mem\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[18\]$_DFFE_PP_ clknet_leaf_23_clk _0409_ net216
+ VSS VSS VDD VDD mem\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[19\]$_DFFE_PP_ clknet_leaf_24_clk _0410_ net216
+ VSS VSS VDD VDD mem\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0411_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk _0412_ net216
+ VSS VSS VDD VDD mem\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[21\]$_DFFE_PP_ clknet_leaf_19_clk _0413_ net216
+ VSS VSS VDD VDD mem\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[22\]$_DFFE_PP_ clknet_leaf_19_clk _0414_ net216
+ VSS VSS VDD VDD mem\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[23\]$_DFFE_PP_ clknet_leaf_15_clk _0415_ net216
+ VSS VSS VDD VDD mem\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[24\]$_DFFE_PP_ clknet_leaf_5_clk _0416_ net216
+ VSS VSS VDD VDD mem\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk _0417_ net216
+ VSS VSS VDD VDD mem\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[26\]$_DFFE_PP_ clknet_leaf_7_clk _0418_ net216
+ VSS VSS VDD VDD mem\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[27\]$_DFFE_PP_ clknet_leaf_6_clk _0419_ net216
+ VSS VSS VDD VDD mem\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[28\]$_DFFE_PP_ clknet_leaf_6_clk _0420_ net216
+ VSS VSS VDD VDD mem\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0421_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[2\]$_DFFE_PP_ clknet_leaf_51_clk _0422_ net216
+ VSS VSS VDD VDD mem\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[30\]$_DFFE_PP_ clknet_leaf_5_clk _0423_ net216
+ VSS VSS VDD VDD mem\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[31\]$_DFFE_PP_ clknet_leaf_4_clk _0424_ net216
+ VSS VSS VDD VDD mem\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[3\]$_DFFE_PP_ clknet_leaf_51_clk _0425_ net216
+ VSS VSS VDD VDD mem\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[4\]$_DFFE_PP_ clknet_leaf_44_clk _0426_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[5\]$_DFFE_PP_ clknet_leaf_56_clk _0427_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0428_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[7\]$_DFFE_PP_ clknet_leaf_53_clk _0429_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0430_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[6\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0431_ _0003_
+ VSS VSS VDD VDD mem\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[0\]$_DFFE_PP_ clknet_leaf_48_clk _0432_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[10\]$_DFFE_PP_ clknet_leaf_33_clk _0433_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[11\]$_DFFE_PP_ clknet_leaf_38_clk _0434_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[12\]$_DFFE_PP_ clknet_leaf_33_clk _0435_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[13\]$_DFFE_PP_ clknet_leaf_33_clk _0436_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[14\]$_DFFE_PP_ clknet_leaf_27_clk _0437_ net151
+ VSS VSS VDD VDD mem\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[15\]$_DFFE_PP_ clknet_leaf_38_clk _0438_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[16\]$_DFFE_PP_ clknet_leaf_26_clk _0439_ net151
+ VSS VSS VDD VDD mem\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[17\]$_DFFE_PP_ clknet_leaf_23_clk _0440_ net151
+ VSS VSS VDD VDD mem\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[18\]$_DFFE_PP_ clknet_leaf_23_clk _0441_ net151
+ VSS VSS VDD VDD mem\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[19\]$_DFFE_PP_ clknet_leaf_18_clk _0442_ net151
+ VSS VSS VDD VDD mem\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[1\]$_DFFE_PP_ clknet_leaf_44_clk _0443_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[20\]$_DFFE_PP_ clknet_leaf_20_clk _0444_ net151
+ VSS VSS VDD VDD mem\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[21\]$_DFFE_PP_ clknet_leaf_18_clk _0445_ net151
+ VSS VSS VDD VDD mem\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[22\]$_DFFE_PP_ clknet_leaf_16_clk _0446_ net151
+ VSS VSS VDD VDD mem\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[23\]$_DFFE_PP_ clknet_leaf_15_clk _0447_ net151
+ VSS VSS VDD VDD mem\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0448_ net151
+ VSS VSS VDD VDD mem\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[25\]$_DFFE_PP_ clknet_leaf_15_clk _0449_ net151
+ VSS VSS VDD VDD mem\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[26\]$_DFFE_PP_ clknet_leaf_6_clk _0450_ net151
+ VSS VSS VDD VDD mem\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[27\]$_DFFE_PP_ clknet_leaf_6_clk _0451_ net151
+ VSS VSS VDD VDD mem\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[28\]$_DFFE_PP_ clknet_leaf_6_clk _0452_ net151
+ VSS VSS VDD VDD mem\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[29\]$_DFFE_PP_ clknet_leaf_50_clk _0453_ net151
+ VSS VSS VDD VDD mem\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[2\]$_DFFE_PP_ clknet_leaf_5_clk _0454_ net151 VSS
+ VSS VDD VDD mem\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[30\]$_DFFE_PP_ clknet_leaf_5_clk _0455_ net151
+ VSS VSS VDD VDD mem\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[31\]$_DFFE_PP_ clknet_leaf_4_clk _0456_ net151
+ VSS VSS VDD VDD mem\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[3\]$_DFFE_PP_ clknet_leaf_3_clk _0457_ net151 VSS
+ VSS VDD VDD mem\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[4\]$_DFFE_PP_ clknet_leaf_45_clk _0458_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[5\]$_DFFE_PP_ clknet_leaf_56_clk _0459_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0460_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[7\]$_DFFE_PP_ clknet_leaf_52_clk _0461_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0462_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[7\]\[9\]$_DFFE_PP_ clknet_leaf_38_clk _0463_ _0002_
+ VSS VSS VDD VDD mem\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0464_ net147
+ VSS VSS VDD VDD mem\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0465_ net147
+ VSS VSS VDD VDD mem\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0466_ net147
+ VSS VSS VDD VDD mem\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[12\]$_DFFE_PP_ clknet_leaf_33_clk _0467_ net147
+ VSS VSS VDD VDD mem\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[13\]$_DFFE_PP_ clknet_leaf_30_clk _0468_ net147
+ VSS VSS VDD VDD mem\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[14\]$_DFFE_PP_ clknet_leaf_27_clk _0469_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[15\]$_DFFE_PP_ clknet_leaf_41_clk _0470_ net147
+ VSS VSS VDD VDD mem\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[16\]$_DFFE_PP_ clknet_leaf_26_clk _0471_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[17\]$_DFFE_PP_ clknet_leaf_25_clk _0472_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[18\]$_DFFE_PP_ clknet_leaf_24_clk _0473_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[19\]$_DFFE_PP_ clknet_leaf_18_clk _0474_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[1\]$_DFFE_PP_ clknet_leaf_42_clk _0475_ net147
+ VSS VSS VDD VDD mem\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[20\]$_DFFE_PP_ clknet_leaf_18_clk _0476_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0477_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[22\]$_DFFE_PP_ clknet_leaf_15_clk _0478_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0479_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0480_ net147
+ VSS VSS VDD VDD mem\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk _0481_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[26\]$_DFFE_PP_ clknet_leaf_11_clk _0482_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[27\]$_DFFE_PP_ clknet_leaf_10_clk _0483_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0484_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0485_ net147
+ VSS VSS VDD VDD mem\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0486_ _0001_ VSS
+ VSS VDD VDD mem\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0487_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[31\]$_DFFE_PP_ clknet_leaf_2_clk _0488_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0489_ _0001_
+ VSS VSS VDD VDD mem\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[4\]$_DFFE_PP_ clknet_leaf_42_clk _0490_ net147
+ VSS VSS VDD VDD mem\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0491_ net147
+ VSS VSS VDD VDD mem\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[6\]$_DFFE_PP_ clknet_leaf_56_clk _0492_ net147
+ VSS VSS VDD VDD mem\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[7\]$_DFFE_PP_ clknet_leaf_55_clk _0493_ net147
+ VSS VSS VDD VDD mem\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[8\]$_DFFE_PP_ clknet_leaf_48_clk _0494_ net147
+ VSS VSS VDD VDD mem\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[8\]\[9\]$_DFFE_PP_ clknet_leaf_41_clk _0495_ net147
+ VSS VSS VDD VDD mem\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[0\]$_DFFE_PP_ clknet_leaf_46_clk _0496_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[10\]$_DFFE_PP_ clknet_leaf_32_clk _0497_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[11\]$_DFFE_PP_ clknet_leaf_39_clk _0498_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[12\]$_DFFE_PP_ clknet_leaf_31_clk _0499_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[13\]$_DFFE_PP_ clknet_leaf_29_clk _0500_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[14\]$_DFFE_PP_ clknet_leaf_28_clk _0501_ net146
+ VSS VSS VDD VDD mem\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[15\]$_DFFE_PP_ clknet_leaf_40_clk _0502_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[16\]$_DFFE_PP_ clknet_leaf_27_clk _0503_ net146
+ VSS VSS VDD VDD mem\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[17\]$_DFFE_PP_ clknet_leaf_25_clk _0504_ net146
+ VSS VSS VDD VDD mem\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[18\]$_DFFE_PP_ clknet_leaf_25_clk _0505_ net146
+ VSS VSS VDD VDD mem\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[19\]$_DFFE_PP_ clknet_leaf_17_clk _0506_ net146
+ VSS VSS VDD VDD mem\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[1\]$_DFFE_PP_ clknet_leaf_43_clk _0507_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[20\]$_DFFE_PP_ clknet_leaf_17_clk _0508_ net146
+ VSS VSS VDD VDD mem\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[21\]$_DFFE_PP_ clknet_leaf_16_clk _0509_ net146
+ VSS VSS VDD VDD mem\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[22\]$_DFFE_PP_ clknet_leaf_15_clk _0510_ net146
+ VSS VSS VDD VDD mem\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[23\]$_DFFE_PP_ clknet_leaf_14_clk _0511_ net146
+ VSS VSS VDD VDD mem\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[24\]$_DFFE_PP_ clknet_leaf_21_clk _0512_ net146
+ VSS VSS VDD VDD mem\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[25\]$_DFFE_PP_ clknet_leaf_12_clk _0513_ net146
+ VSS VSS VDD VDD mem\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[26\]$_DFFE_PP_ clknet_leaf_12_clk _0514_ net146
+ VSS VSS VDD VDD mem\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[27\]$_DFFE_PP_ clknet_leaf_10_clk _0515_ net146
+ VSS VSS VDD VDD mem\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[28\]$_DFFE_PP_ clknet_leaf_9_clk _0516_ net146
+ VSS VSS VDD VDD mem\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[29\]$_DFFE_PP_ clknet_leaf_36_clk _0517_ net146
+ VSS VSS VDD VDD mem\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[2\]$_DFFE_PP_ clknet_leaf_0_clk _0518_ net146 VSS
+ VSS VDD VDD mem\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[30\]$_DFFE_PP_ clknet_leaf_2_clk _0519_ net146
+ VSS VSS VDD VDD mem\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[31\]$_DFFE_PP_ clknet_leaf_1_clk _0520_ net146
+ VSS VSS VDD VDD mem\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[3\]$_DFFE_PP_ clknet_leaf_59_clk _0521_ net146
+ VSS VSS VDD VDD mem\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[4\]$_DFFE_PP_ clknet_leaf_43_clk _0522_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[5\]$_DFFE_PP_ clknet_leaf_57_clk _0523_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[6\]$_DFFE_PP_ clknet_leaf_55_clk _0524_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[7\]$_DFFE_PP_ clknet_leaf_53_clk _0525_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[8\]$_DFFE_PP_ clknet_leaf_47_clk _0526_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xmem\[9\]\[9\]$_DFFE_PP_ clknet_leaf_42_clk _0527_ _0000_
+ VSS VSS VDD VDD mem\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xrd_data_regs\[0\]\[0\]$_DFFE_PN0P_ clknet_leaf_46_clk _0535_
+ net1 VSS VSS VDD VDD net78 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[10\]$_DFFE_PN0P_ clknet_leaf_32_clk _0536_
+ net1 VSS VSS VDD VDD net79 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[11\]$_DFFE_PN0P_ clknet_leaf_39_clk _0537_
+ net1 VSS VSS VDD VDD net80 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[12\]$_DFFE_PN0P_ clknet_leaf_31_clk _0538_
+ net1 VSS VSS VDD VDD net81 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[13\]$_DFFE_PN0P_ clknet_leaf_30_clk _0539_
+ net1 VSS VSS VDD VDD net82 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[14\]$_DFFE_PN0P_ clknet_leaf_31_clk _0540_
+ net1 VSS VSS VDD VDD net83 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[15\]$_DFFE_PN0P_ clknet_leaf_40_clk _0541_
+ net1 VSS VSS VDD VDD net84 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[16\]$_DFFE_PN0P_ clknet_leaf_29_clk _0542_
+ net1 VSS VSS VDD VDD net85 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[17\]$_DFFE_PN0P_ clknet_leaf_26_clk _0543_
+ net1 VSS VSS VDD VDD net86 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[18\]$_DFFE_PN0P_ clknet_leaf_23_clk _0544_
+ net1 VSS VSS VDD VDD net87 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[19\]$_DFFE_PN0P_ clknet_leaf_24_clk _0545_
+ net1 VSS VSS VDD VDD net88 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[1\]$_DFFE_PN0P_ clknet_leaf_39_clk _0546_
+ net1 VSS VSS VDD VDD net89 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[20\]$_DFFE_PN0P_ clknet_leaf_18_clk _0547_
+ net1 VSS VSS VDD VDD net90 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[21\]$_DFFE_PN0P_ clknet_leaf_13_clk _0548_
+ net1 VSS VSS VDD VDD net91 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[22\]$_DFFE_PN0P_ clknet_leaf_12_clk _0549_
+ net1 VSS VSS VDD VDD net92 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[23\]$_DFFE_PN0P_ clknet_leaf_13_clk _0550_
+ net1 VSS VSS VDD VDD net93 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[24\]$_DFFE_PN0P_ clknet_leaf_39_clk _0551_
+ net1 VSS VSS VDD VDD net94 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[25\]$_DFFE_PN0P_ clknet_leaf_13_clk _0552_
+ net1 VSS VSS VDD VDD net95 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[26\]$_DFFE_PN0P_ clknet_leaf_10_clk _0553_
+ net1 VSS VSS VDD VDD net96 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[27\]$_DFFE_PN0P_ clknet_leaf_9_clk _0554_
+ net1 VSS VSS VDD VDD net97 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[28\]$_DFFE_PN0P_ clknet_leaf_2_clk _0555_
+ net1 VSS VSS VDD VDD net98 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[29\]$_DFFE_PN0P_ clknet_leaf_54_clk _0556_
+ net1 VSS VSS VDD VDD net99 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[2\]$_DFFE_PN0P_ clknet_leaf_1_clk _0557_
+ net1 VSS VSS VDD VDD net100 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[30\]$_DFFE_PN0P_ clknet_leaf_1_clk _0558_
+ net1 VSS VSS VDD VDD net101 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[31\]$_DFFE_PN0P_ clknet_leaf_1_clk _0559_
+ net1 VSS VSS VDD VDD net102 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[3\]$_DFFE_PN0P_ clknet_leaf_55_clk _0560_
+ net1 VSS VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[4\]$_DFFE_PN0P_ clknet_leaf_54_clk _0561_
+ net1 VSS VSS VDD VDD net122 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[5\]$_DFFE_PN0P_ clknet_leaf_55_clk _0562_
+ net1 VSS VSS VDD VDD net133 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[6\]$_DFFE_PN0P_ clknet_leaf_55_clk _0563_
+ net1 VSS VSS VDD VDD net138 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[7\]$_DFFE_PN0P_ clknet_leaf_54_clk _0564_
+ net1 VSS VSS VDD VDD net139 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[8\]$_DFFE_PN0P_ clknet_leaf_46_clk _0565_
+ net1 VSS VSS VDD VDD net140 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[0\]\[9\]$_DFFE_PN0P_ clknet_leaf_44_clk _0566_
+ net1 VSS VSS VDD VDD net141 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[0\]$_DFFE_PN0P_ clknet_leaf_49_clk _0567_
+ net1 VSS VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[10\]$_DFFE_PN0P_ clknet_leaf_32_clk _0568_
+ net1 VSS VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[11\]$_DFFE_PN0P_ clknet_leaf_38_clk _0569_
+ net1 VSS VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[12\]$_DFFE_PN0P_ clknet_leaf_30_clk _0570_
+ net1 VSS VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[13\]$_DFFE_PN0P_ clknet_leaf_30_clk _0571_
+ net1 VSS VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[14\]$_DFFE_PN0P_ clknet_leaf_29_clk _0572_
+ net1 VSS VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[15\]$_DFFE_PN0P_ clknet_leaf_38_clk _0573_
+ net1 VSS VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[16\]$_DFFE_PN0P_ clknet_leaf_27_clk _0574_
+ net1 VSS VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[17\]$_DFFE_PN0P_ clknet_leaf_26_clk _0575_
+ net1 VSS VSS VDD VDD net121 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[18\]$_DFFE_PN0P_ clknet_leaf_25_clk _0576_
+ net1 VSS VSS VDD VDD net123 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[19\]$_DFFE_PN0P_ clknet_leaf_24_clk _0577_
+ net1 VSS VSS VDD VDD net124 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[1\]$_DFFE_PN0P_ clknet_leaf_42_clk _0578_
+ net1 VSS VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[20\]$_DFFE_PN0P_ clknet_leaf_18_clk _0579_
+ net1 VSS VSS VDD VDD net125 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[21\]$_DFFE_PN0P_ clknet_leaf_17_clk _0580_
+ net1 VSS VSS VDD VDD net126 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[22\]$_DFFE_PN0P_ clknet_leaf_16_clk _0581_
+ net1 VSS VSS VDD VDD net127 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[23\]$_DFFE_PN0P_ clknet_leaf_12_clk _0582_
+ net1 VSS VSS VDD VDD net128 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[24\]$_DFFE_PN0P_ clknet_leaf_36_clk _0583_
+ net1 VSS VSS VDD VDD net129 sky130_fd_sc_hd__dfrtp_2
Xrd_data_regs\[1\]\[25\]$_DFFE_PN0P_ clknet_leaf_12_clk _0584_
+ net1 VSS VSS VDD VDD net130 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[26\]$_DFFE_PN0P_ clknet_leaf_11_clk _0585_
+ net1 VSS VSS VDD VDD net131 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[27\]$_DFFE_PN0P_ clknet_leaf_9_clk _0586_
+ net1 VSS VSS VDD VDD net132 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[28\]$_DFFE_PN0P_ clknet_leaf_8_clk _0587_
+ net1 VSS VSS VDD VDD net134 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[29\]$_DFFE_PN0P_ clknet_leaf_37_clk _0588_
+ net1 VSS VSS VDD VDD net135 sky130_fd_sc_hd__dfrtp_2
Xrd_data_regs\[1\]\[2\]$_DFFE_PN0P_ clknet_leaf_0_clk _0589_
+ net1 VSS VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[30\]$_DFFE_PN0P_ clknet_leaf_3_clk _0590_
+ net1 VSS VSS VDD VDD net136 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[31\]$_DFFE_PN0P_ clknet_leaf_3_clk _0591_
+ net1 VSS VSS VDD VDD net137 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[3\]$_DFFE_PN0P_ clknet_leaf_4_clk _0592_
+ net1 VSS VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[4\]$_DFFE_PN0P_ clknet_leaf_42_clk _0593_
+ net1 VSS VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[5\]$_DFFE_PN0P_ clknet_leaf_57_clk _0594_
+ net1 VSS VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[6\]$_DFFE_PN0P_ clknet_leaf_54_clk _0595_
+ net1 VSS VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[7\]$_DFFE_PN0P_ clknet_leaf_53_clk _0596_
+ net1 VSS VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[8\]$_DFFE_PN0P_ clknet_leaf_47_clk _0597_
+ net1 VSS VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_1
Xrd_data_regs\[1\]\[9\]$_DFFE_PN0P_ clknet_leaf_41_clk _0598_
+ net1 VSS VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[0\]$_DFFE_PN0N_ clknet_leaf_49_clk _0599_ net1 VSS
+ VSS VDD VDD rd_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[1\]$_DFFE_PN0N_ clknet_leaf_49_clk _0600_ net1 VSS
+ VSS VDD VDD rd_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[2\]$_DFFE_PN0N_ clknet_leaf_49_clk _0601_ net1 VSS
+ VSS VDD VDD rd_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[3\]$_DFFE_PN0N_ clknet_leaf_49_clk _0602_ net1 VSS
+ VSS VDD VDD rd_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_valid_regs\[0\]$_DFF_PN0_ clknet_leaf_43_clk _0529_ net1
+ VSS VSS VDD VDD net142 sky130_fd_sc_hd__dfrtp_1
Xrd_valid_regs\[1\]$_DFF_PN0_ clknet_leaf_42_clk _2537_ net1
+ VSS VSS VDD VDD net143 sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[0\]$_DFFE_PN0N_ clknet_leaf_58_clk _0603_ net1 VSS
+ VSS VDD VDD wr_ptr\[0\] sky130_fd_sc_hd__dfrtp_4
Xwr_ptr\[1\]$_DFFE_PN0N_ clknet_leaf_58_clk _0604_ net1 VSS
+ VSS VDD VDD wr_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[2\]$_DFFE_PN0N_ clknet_leaf_58_clk _0605_ net1 VSS
+ VSS VDD VDD wr_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[3\]$_DFFE_PN0N_ clknet_leaf_58_clk _0606_ net1 VSS
+ VSS VDD VDD wr_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net171 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 rd_en[1] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 net178 VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 net182 VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 wr_data[11] VSS VSS VDD VDD net5 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput5 wr_data[12] VSS VSS VDD VDD net6 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput6 net185 VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
Xinput7 net184 VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_2
Xinput8 wr_data[15] VSS VSS VDD VDD net9 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput9 wr_data[16] VSS VSS VDD VDD net10 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput10 wr_data[17] VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput11 net172 VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xinput12 wr_data[19] VSS VSS VDD VDD net13 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput13 wr_data[1] VSS VSS VDD VDD net14 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput14 wr_data[20] VSS VSS VDD VDD net15 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput15 net195 VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_2
Xinput16 wr_data[22] VSS VSS VDD VDD net17 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput17 wr_data[23] VSS VSS VDD VDD net18 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput18 net210 VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_2
Xinput19 net205 VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_2
Xinput20 net176 VSS VSS VDD VDD net21 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput21 wr_data[27] VSS VSS VDD VDD net22 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput22 wr_data[28] VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 net215 VSS VSS VDD VDD net24 sky130_fd_sc_hd__buf_2
Xinput24 wr_data[2] VSS VSS VDD VDD net25 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput25 net208 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_2
Xinput26 wr_data[31] VSS VSS VDD VDD net27 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput27 net181 VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_2
Xinput28 net204 VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_2
Xinput29 net209 VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_2
Xinput30 net211 VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_2
Xinput31 net192 VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_2
Xinput32 wr_data[37] VSS VSS VDD VDD net33 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput33 wr_data[38] VSS VSS VDD VDD net34 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput34 net177 VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_2
Xinput35 net214 VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_2
Xinput36 wr_data[40] VSS VSS VDD VDD net37 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput37 wr_data[41] VSS VSS VDD VDD net38 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput38 net187 VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_2
Xinput39 net203 VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_2
Xinput40 net193 VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_2
Xinput41 net191 VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_2
Xinput42 net188 VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_2
Xinput43 net199 VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_2
Xinput44 net180 VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_2
Xinput45 wr_data[49] VSS VSS VDD VDD net46 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput46 net189 VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_2
Xinput47 net173 VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_2
Xinput48 wr_data[51] VSS VSS VDD VDD net49 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput49 wr_data[52] VSS VSS VDD VDD net50 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput50 net197 VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_2
Xinput51 wr_data[54] VSS VSS VDD VDD net52 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput52 net200 VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_2
Xinput53 net213 VSS VSS VDD VDD net54 sky130_fd_sc_hd__buf_2
Xinput54 net207 VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_2
Xinput55 net174 VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_2
Xinput56 wr_data[59] VSS VSS VDD VDD net57 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput57 wr_data[5] VSS VSS VDD VDD net58 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput58 net198 VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_2
Xinput59 wr_data[61] VSS VSS VDD VDD net60 sky130_fd_sc_hd__buf_2
Xinput60 net201 VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_2
Xinput61 net194 VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_2
Xinput62 wr_data[6] VSS VSS VDD VDD net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput63 wr_data[7] VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput64 wr_data[8] VSS VSS VDD VDD net65 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput65 wr_data[9] VSS VSS VDD VDD net66 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput66 wr_en[0] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_1
Xinput67 wr_en[1] VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkbuf_1
Xoutput68 net69 VSS VSS VDD VDD almost_empty sky130_fd_sc_hd__clkbuf_1
Xoutput69 net70 VSS VSS VDD VDD almost_full sky130_fd_sc_hd__clkbuf_1
Xoutput70 net71 VSS VSS VDD VDD data_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net72 VSS VSS VDD VDD data_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net73 VSS VSS VDD VDD data_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net74 VSS VSS VDD VDD data_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net223 VSS VSS VDD VDD data_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net76 VSS VSS VDD VDD empty sky130_fd_sc_hd__clkbuf_1
Xoutput76 net77 VSS VSS VDD VDD full sky130_fd_sc_hd__clkbuf_1
Xoutput77 net78 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net79 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net80 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net81 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net82 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net83 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net84 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net85 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net86 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net87 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net88 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net89 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net90 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net91 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net92 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net93 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net94 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net95 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net96 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net97 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net98 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net99 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net100 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net101 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net102 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net103 VSS VSS VDD VDD rd_data[32] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net104 VSS VSS VDD VDD rd_data[33] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net105 VSS VSS VDD VDD rd_data[34] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net106 VSS VSS VDD VDD rd_data[35] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net107 VSS VSS VDD VDD rd_data[36] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net108 VSS VSS VDD VDD rd_data[37] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net109 VSS VSS VDD VDD rd_data[38] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net110 VSS VSS VDD VDD rd_data[39] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net111 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net112 VSS VSS VDD VDD rd_data[40] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net113 VSS VSS VDD VDD rd_data[41] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net114 VSS VSS VDD VDD rd_data[42] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net115 VSS VSS VDD VDD rd_data[43] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net116 VSS VSS VDD VDD rd_data[44] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net117 VSS VSS VDD VDD rd_data[45] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net118 VSS VSS VDD VDD rd_data[46] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net119 VSS VSS VDD VDD rd_data[47] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net120 VSS VSS VDD VDD rd_data[48] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net121 VSS VSS VDD VDD rd_data[49] sky130_fd_sc_hd__clkbuf_1
Xoutput121 net122 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput122 net123 VSS VSS VDD VDD rd_data[50] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net124 VSS VSS VDD VDD rd_data[51] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net125 VSS VSS VDD VDD rd_data[52] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net126 VSS VSS VDD VDD rd_data[53] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net127 VSS VSS VDD VDD rd_data[54] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net128 VSS VSS VDD VDD rd_data[55] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net129 VSS VSS VDD VDD rd_data[56] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net130 VSS VSS VDD VDD rd_data[57] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net131 VSS VSS VDD VDD rd_data[58] sky130_fd_sc_hd__clkbuf_1
Xoutput131 net132 VSS VSS VDD VDD rd_data[59] sky130_fd_sc_hd__clkbuf_1
Xoutput132 net133 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput133 net134 VSS VSS VDD VDD rd_data[60] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net135 VSS VSS VDD VDD rd_data[61] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net136 VSS VSS VDD VDD rd_data[62] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net137 VSS VSS VDD VDD rd_data[63] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net138 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net139 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net140 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput140 net141 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput141 net142 VSS VSS VDD VDD rd_valid[0] sky130_fd_sc_hd__clkbuf_1
Xoutput142 net143 VSS VSS VDD VDD rd_valid[1] sky130_fd_sc_hd__clkbuf_1
Xoutput143 net144 VSS VSS VDD VDD wr_ready[0] sky130_fd_sc_hd__clkbuf_1
Xoutput144 net145 VSS VSS VDD VDD wr_ready[1] sky130_fd_sc_hd__clkbuf_1
Xmax_cap145 _0000_ VSS VSS VDD VDD net146 sky130_fd_sc_hd__buf_12
Xmax_cap146 _0001_ VSS VSS VDD VDD net147 sky130_fd_sc_hd__buf_16
Xload_slew147 _0005_ VSS VSS VDD VDD net148 sky130_fd_sc_hd__buf_16
Xload_slew148 _0013_ VSS VSS VDD VDD net149 sky130_fd_sc_hd__buf_16
Xload_slew149 _0013_ VSS VSS VDD VDD net150 sky130_fd_sc_hd__buf_16
Xmax_cap150 _0002_ VSS VSS VDD VDD net151 sky130_fd_sc_hd__buf_12
Xmax_cap151 _0014_ VSS VSS VDD VDD net152 sky130_fd_sc_hd__buf_12
Xload_slew152 _0012_ VSS VSS VDD VDD net153 sky130_fd_sc_hd__buf_16
Xload_slew153 _0012_ VSS VSS VDD VDD net154 sky130_fd_sc_hd__buf_16
Xwire154 _0011_ VSS VSS VDD VDD net155 sky130_fd_sc_hd__buf_12
Xload_slew155 _0010_ VSS VSS VDD VDD net156 sky130_fd_sc_hd__buf_16
Xload_slew156 _0010_ VSS VSS VDD VDD net157 sky130_fd_sc_hd__buf_16
Xwire157 _0009_ VSS VSS VDD VDD net158 sky130_fd_sc_hd__buf_12
Xload_slew158 net160 VSS VSS VDD VDD net159 sky130_fd_sc_hd__buf_16
Xload_slew159 _0006_ VSS VSS VDD VDD net160 sky130_fd_sc_hd__buf_16
Xmax_cap160 _0004_ VSS VSS VDD VDD net161 sky130_fd_sc_hd__buf_16
Xload_slew161 _0008_ VSS VSS VDD VDD net162 sky130_fd_sc_hd__buf_16
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_53_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_53_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_54_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_54_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_55_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_55_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_56_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_56_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_57_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_57_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_58_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_58_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_59_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_59_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_4__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_4__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_5__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_5__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_6__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_6__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_7__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_7__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_3_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__inv_6
Xclkload1 clknet_3_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkbuf_16
Xclkload2 clknet_3_3__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkinv_8
Xclkload3 clknet_3_4__leaf_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__clkbuf_16
Xclkload4 clknet_3_5__leaf_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__inv_6
Xclkload5 clknet_3_6__leaf_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__clkbuf_16
Xclkload6 clknet_3_7__leaf_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__inv_6
Xclkload7 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkbuf_8
Xclkload8 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkbuf_1
Xclkload9 clknet_leaf_2_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkbuf_8
Xclkload10 clknet_leaf_57_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkbuf_1
Xclkload11 clknet_leaf_58_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkinv_1
Xclkload12 clknet_leaf_59_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkinv_2
Xclkload13 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__clkbuf_1
Xclkload14 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__clkinv_2
Xclkload15 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkbuf_1
Xclkload16 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__clkbuf_8
Xclkload17 clknet_leaf_53_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkinv_2
Xclkload18 clknet_leaf_54_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkbuf_1
Xclkload19 clknet_leaf_56_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkbuf_1
Xclkload20 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkinv_2
Xclkload21 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkinv_2
Xclkload22 clknet_leaf_10_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkbuf_1
Xclkload23 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__clkinv_2
Xclkload24 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__clkinv_1
Xclkload25 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkinv_2
Xclkload26 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkbuf_8
Xclkload27 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkbuf_1
Xclkload28 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__clkbuf_1
Xclkload29 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkbuf_1
Xclkload30 clknet_leaf_19_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkbuf_1
Xclkload31 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkbuf_1
Xclkload32 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkinv_2
Xclkload33 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkbuf_1
Xclkload34 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkbuf_1
Xclkload35 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkbuf_1
Xclkload36 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkbuf_8
Xclkload37 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__bufinv_16
Xclkload38 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkbuf_1
Xclkload39 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkinv_2
Xclkload40 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__clkbuf_1
Xclkload41 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__clkinv_1
Xclkload42 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__clkinv_2
Xclkload43 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__bufinv_16
Xclkload44 clknet_leaf_43_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkbuf_1
Xclkload45 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_1
Xclkload46 clknet_leaf_22_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__clkbuf_1
Xclkload47 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkbuf_1
Xclkload48 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkbuf_1
Xclkload49 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__clkbuf_1
Xclkload50 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__clkbuf_1
Xclkload51 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_51
+ sky130_fd_sc_hd__clkbuf_8
Xclkload52 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_52
+ sky130_fd_sc_hd__clkbuf_8
Xclkload53 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_53
+ sky130_fd_sc_hd__clkbuf_8
Xclkload54 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_54
+ sky130_fd_sc_hd__clkbuf_1
Xclkload55 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_55
+ sky130_fd_sc_hd__clkinv_2
Xclkload56 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_56
+ sky130_fd_sc_hd__clkinv_2
Xclkload57 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_57
+ sky130_fd_sc_hd__clkbuf_1
Xclone1 net165 VSS VSS VDD VDD net163 sky130_fd_sc_hd__clkbuf_16
Xrebuffer2 _0720_ VSS VSS VDD VDD net164 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer3 net164 VSS VSS VDD VDD net165 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer5 _2547_ VSS VSS VDD VDD net167 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer6 net223 VSS VSS VDD VDD net168 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer7 net74 VSS VSS VDD VDD net169 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer8 net169 VSS VSS VDD VDD net170 sky130_fd_sc_hd__dlygate4sd1_1
Xhold9 rst_n VSS VSS VDD VDD net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 wr_data[18] VSS VSS VDD VDD net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 wr_data[50] VSS VSS VDD VDD net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 wr_data[58] VSS VSS VDD VDD net174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 _0162_ VSS VSS VDD VDD net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 wr_data[26] VSS VSS VDD VDD net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 wr_data[39] VSS VSS VDD VDD net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 wr_data[0] VSS VSS VDD VDD net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 _0048_ VSS VSS VDD VDD net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 wr_data[48] VSS VSS VDD VDD net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold19 wr_data[32] VSS VSS VDD VDD net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 wr_data[10] VSS VSS VDD VDD net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 _0049_ VSS VSS VDD VDD net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 wr_data[14] VSS VSS VDD VDD net184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 wr_data[13] VSS VSS VDD VDD net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 _0084_ VSS VSS VDD VDD net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 wr_data[42] VSS VSS VDD VDD net187 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 wr_data[46] VSS VSS VDD VDD net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 wr_data[4] VSS VSS VDD VDD net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 _0202_ VSS VSS VDD VDD net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 wr_data[45] VSS VSS VDD VDD net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 wr_data[36] VSS VSS VDD VDD net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 wr_data[44] VSS VSS VDD VDD net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 wr_data[63] VSS VSS VDD VDD net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 wr_data[21] VSS VSS VDD VDD net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 _0093_ VSS VSS VDD VDD net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 wr_data[53] VSS VSS VDD VDD net197 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 wr_data[60] VSS VSS VDD VDD net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 wr_data[47] VSS VSS VDD VDD net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 wr_data[55] VSS VSS VDD VDD net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 wr_data[62] VSS VSS VDD VDD net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold40 _0135_ VSS VSS VDD VDD net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 wr_data[43] VSS VSS VDD VDD net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 wr_data[33] VSS VSS VDD VDD net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 wr_data[25] VSS VSS VDD VDD net205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 _0161_ VSS VSS VDD VDD net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 wr_data[57] VSS VSS VDD VDD net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 wr_data[30] VSS VSS VDD VDD net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 wr_data[34] VSS VSS VDD VDD net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 wr_data[24] VSS VSS VDD VDD net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 wr_data[35] VSS VSS VDD VDD net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 _0073_ VSS VSS VDD VDD net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 wr_data[56] VSS VSS VDD VDD net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 wr_data[3] VSS VSS VDD VDD net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 wr_data[29] VSS VSS VDD VDD net215 sky130_fd_sc_hd__dlygate4sd3_1
Xload_slew1 _0003_ VSS VSS VDD VDD net216 sky130_fd_sc_hd__buf_16
Xload_slew2 _0015_ VSS VSS VDD VDD net217 sky130_fd_sc_hd__buf_16
Xload_slew3 _0007_ VSS VSS VDD VDD net218 sky130_fd_sc_hd__buf_16
Xrebuffer9 _0712_ VSS VSS VDD VDD net219 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer10 net219 VSS VSS VDD VDD net220 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer11 _0714_ VSS VSS VDD VDD net221 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer12 _0529_ VSS VSS VDD VDD net222 sky130_fd_sc_hd__buf_6
Xrebuffer13 net75 VSS VSS VDD VDD net223 sky130_fd_sc_hd__dlygate4sd1_1
XANTENNA_2 _0997_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 _1279_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 _1365_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 _2494_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS multi_ported_fifo
