* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT ddr_controller clk cmd_addr[0] cmd_addr[10] cmd_addr[11]
+ cmd_addr[12] cmd_addr[13] cmd_addr[14] cmd_addr[15] cmd_addr[16]
+ cmd_addr[17] cmd_addr[18] cmd_addr[19] cmd_addr[1] cmd_addr[20]
+ cmd_addr[21] cmd_addr[22] cmd_addr[23] cmd_addr[24] cmd_addr[25]
+ cmd_addr[26] cmd_addr[27] cmd_addr[2] cmd_addr[3] cmd_addr[4]
+ cmd_addr[5] cmd_addr[6] cmd_addr[7] cmd_addr[8] cmd_addr[9]
+ cmd_burst_len[0] cmd_burst_len[1] cmd_burst_len[2] cmd_burst_len[3]
+ cmd_ready cmd_valid cmd_write init_done phy_addr[0] phy_addr[10]
+ phy_addr[11] phy_addr[12] phy_addr[13] phy_addr[1] phy_addr[2]
+ phy_addr[3] phy_addr[4] phy_addr[5] phy_addr[6] phy_addr[7]
+ phy_addr[8] phy_addr[9] phy_bank[0] phy_bank[1] phy_bank[2]
+ phy_bank_group[0] phy_bank_group[1] phy_cas_n phy_cke phy_clk
+ phy_cs_n phy_dm[0] phy_dm[1] phy_dm[2] phy_dm[3] phy_dm[4]
+ phy_dm[5] phy_dm[6] phy_dm[7] phy_dq[0] phy_dq[10] phy_dq[11]
+ phy_dq[12] phy_dq[13] phy_dq[14] phy_dq[15] phy_dq[16] phy_dq[17]
+ phy_dq[18] phy_dq[19] phy_dq[1] phy_dq[20] phy_dq[21] phy_dq[22]
+ phy_dq[23] phy_dq[24] phy_dq[25] phy_dq[26] phy_dq[27] phy_dq[28]
+ phy_dq[29] phy_dq[2] phy_dq[30] phy_dq[31] phy_dq[32] phy_dq[33]
+ phy_dq[34] phy_dq[35] phy_dq[36] phy_dq[37] phy_dq[38] phy_dq[39]
+ phy_dq[3] phy_dq[40] phy_dq[41] phy_dq[42] phy_dq[43] phy_dq[44]
+ phy_dq[45] phy_dq[46] phy_dq[47] phy_dq[48] phy_dq[49] phy_dq[4]
+ phy_dq[50] phy_dq[51] phy_dq[52] phy_dq[53] phy_dq[54] phy_dq[55]
+ phy_dq[56] phy_dq[57] phy_dq[58] phy_dq[59] phy_dq[5] phy_dq[60]
+ phy_dq[61] phy_dq[62] phy_dq[63] phy_dq[6] phy_dq[7] phy_dq[8]
+ phy_dq[9] phy_dqs_n[0] phy_dqs_n[1] phy_dqs_n[2] phy_dqs_n[3]
+ phy_dqs_n[4] phy_dqs_n[5] phy_dqs_n[6] phy_dqs_n[7] phy_dqs_p[0]
+ phy_dqs_p[1] phy_dqs_p[2] phy_dqs_p[3] phy_dqs_p[4] phy_dqs_p[5]
+ phy_dqs_p[6] phy_dqs_p[7] phy_odt phy_ras_n phy_reset_n phy_we_n
+ rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[32] rd_data[33] rd_data[34] rd_data[35] rd_data[36]
+ rd_data[37] rd_data[38] rd_data[39] rd_data[3] rd_data[40]
+ rd_data[41] rd_data[42] rd_data[43] rd_data[44] rd_data[45]
+ rd_data[46] rd_data[47] rd_data[48] rd_data[49] rd_data[4]
+ rd_data[50] rd_data[51] rd_data[52] rd_data[53] rd_data[54]
+ rd_data[55] rd_data[56] rd_data[57] rd_data[58] rd_data[59]
+ rd_data[5] rd_data[60] rd_data[61] rd_data[62] rd_data[63]
+ rd_data[6] rd_data[7] rd_data[8] rd_data[9] rd_ready rd_valid
+ rst_n state[0] state[1] wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[32] wr_data[33] wr_data[34]
+ wr_data[35] wr_data[36] wr_data[37] wr_data[38] wr_data[39]
+ wr_data[3] wr_data[40] wr_data[41] wr_data[42] wr_data[43]
+ wr_data[44] wr_data[45] wr_data[46] wr_data[47] wr_data[48]
+ wr_data[49] wr_data[4] wr_data[50] wr_data[51] wr_data[52]
+ wr_data[53] wr_data[54] wr_data[55] wr_data[56] wr_data[57]
+ wr_data[58] wr_data[59] wr_data[5] wr_data[60] wr_data[61]
+ wr_data[62] wr_data[63] wr_data[6] wr_data[7] wr_data[8] wr_data[9]
+ wr_mask[0] wr_mask[1] wr_mask[2] wr_mask[3] wr_mask[4] wr_mask[5]
+ wr_mask[6] wr_mask[7] wr_ready wr_valid
X_0671_ _0660_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__buf_2
X_0672_ timer\[5\] timer\[4\] VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__nor2_1
X_0673_ timer\[3\] timer\[2\] VSS VSS VDD VDD _0052_ sky130_fd_sc_hd__nor2_2
X_0674_ _0654_ _0051_ _0052_ VSS VSS VDD VDD _0053_ sky130_fd_sc_hd__and3_1
X_0675_ timer\[7\] timer\[9\] timer\[8\] timer\[10\] VSS VSS
+ VDD VDD _0054_ sky130_fd_sc_hd__or4_2
X_0676_ timer\[6\] timer\[11\] VSS VSS VDD VDD _0055_ sky130_fd_sc_hd__or2_1
X_0677_ timer\[13\] timer\[12\] timer\[14\] timer\[15\] VSS
+ VSS VDD VDD _0056_ sky130_fd_sc_hd__or4_2
X_0678_ _0054_ _0055_ _0056_ VSS VSS VDD VDD _0057_ sky130_fd_sc_hd__nor3_2
X_0679_ _0050_ _0053_ _0057_ VSS VSS VDD VDD _0058_ sky130_fd_sc_hd__and3_1
X_0680_ _0058_ VSS VSS VDD VDD _0059_ sky130_fd_sc_hd__buf_2
X_0681_ init_state\[4\] _0059_ VSS VSS VDD VDD _0060_ sky130_fd_sc_hd__nand2_1
X_0682_ _0050_ VSS VSS VDD VDD _0061_ sky130_fd_sc_hd__clkbuf_4
X_0683_ _0061_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__clkbuf_4
X_0684_ _0654_ _0051_ _0052_ VSS VSS VDD VDD _0063_ sky130_fd_sc_hd__nand3_4
X_0685_ _0054_ _0055_ _0056_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__or3_2
X_0686_ _0063_ _0064_ VSS VSS VDD VDD _0065_ sky130_fd_sc_hd__nor2_1
X_0687_ _0065_ VSS VSS VDD VDD _0066_ sky130_fd_sc_hd__clkbuf_4
X_0688_ _0066_ VSS VSS VDD VDD _0067_ sky130_fd_sc_hd__clkbuf_4
X_0689_ _0062_ _0067_ VSS VSS VDD VDD _0068_ sky130_fd_sc_hd__nand2_2
X_0690_ init_state\[2\] _0068_ VSS VSS VDD VDD _0069_ sky130_fd_sc_hd__nand2_1
X_0691_ _0060_ _0069_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nand2_1
X_0692_ _0662_ VSS VSS VDD VDD _0070_ sky130_fd_sc_hd__clkbuf_4
X_0693_ net36 _0070_ _0067_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__and3_2
X_0694_ _0631_ _0071_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__and2_4
X_0695_ net120 VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__inv_1
X_0696_ _0628_ _0626_ _0071_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__and3_4
X_0697_ init_state\[5\] VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__buf_2
X_0698_ _0072_ _0059_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__nand2_1
X_0699_ init_state\[3\] _0068_ VSS VSS VDD VDD _0074_ sky130_fd_sc_hd__nand2_1
X_0700_ _0073_ _0074_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__nand2_1
X_0701_ _0628_ _0622_ _0071_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__and3_4
X_0702_ init_state\[0\] _0059_ VSS VSS VDD VDD _0075_ sky130_fd_sc_hd__nand2_1
X_0703_ init_state\[4\] _0068_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__nand2_1
X_0704_ _0075_ _0076_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__nand2_1
X_0705_ _0628_ _0624_ _0071_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__and3_4
X_0706_ _0629_ _0071_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__and2_4
X_0707_ init_state\[1\] _0059_ VSS VSS VDD VDD _0077_ sky130_fd_sc_hd__nand2_1
X_0708_ _0072_ _0068_ VSS VSS VDD VDD _0078_ sky130_fd_sc_hd__nand2_1
X_0709_ _0077_ _0078_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__nand2_1
X_0710_ net120 _0624_ _0071_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__and3_4
X_0711_ _0059_ init_state\[0\] VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2b_1
X_0712_ net120 _0626_ _0071_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__and3_4
X_0713_ init_state\[6\] _0059_ VSS VSS VDD VDD _0079_ sky130_fd_sc_hd__nand2_1
X_0714_ init_state\[1\] _0068_ VSS VSS VDD VDD _0080_ sky130_fd_sc_hd__nand2_1
X_0715_ _0079_ _0080_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nand2_1
X_0716_ net120 _0622_ _0071_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__and3_4
X_0717_ init_state\[2\] _0059_ VSS VSS VDD VDD _0081_ sky130_fd_sc_hd__nand2_1
X_0718_ init_state\[6\] _0068_ VSS VSS VDD VDD _0082_ sky130_fd_sc_hd__nand2_1
X_0719_ _0081_ _0082_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__nand2_1
X_0720_ init_state\[3\] _0059_ init_state\[7\] VSS VSS VDD
+ VDD _0008_ sky130_fd_sc_hd__a21o_1
X_0721_ _0666_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__clkbuf_4
X_0722_ _0083_ VSS VSS VDD VDD _0084_ sky130_fd_sc_hd__clkbuf_4
X_0723_ _0084_ VSS VSS VDD VDD _0085_ sky130_fd_sc_hd__clkbuf_4
X_0724_ net121 net131 VSS VSS VDD VDD _0086_ sky130_fd_sc_hd__nor2b_1
X_0725_ _0085_ net133 _0086_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__and3_4
X_0726_ burst_counter\[0\] VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__inv_1
X_0727_ net4 VSS VSS VDD VDD _0087_ sky130_fd_sc_hd__clkbuf_4
X_0728_ _0087_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__clkbuf_4
X_0729_ cmd_addr[12] VSS VSS VDD VDD _0089_ sky130_fd_sc_hd__buf_6
X_0730_ _0089_ VSS VSS VDD VDD _0090_ sky130_fd_sc_hd__buf_6
X_0731_ _0090_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__buf_6
X_0732_ _0091_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__buf_6
X_0733_ net3 VSS VSS VDD VDD _0093_ sky130_fd_sc_hd__buf_4
X_0734_ _0093_ VSS VSS VDD VDD _0094_ sky130_fd_sc_hd__buf_6
X_0735_ _0088_ _0092_ _0094_ VSS VSS VDD VDD _0095_ sky130_fd_sc_hd__nor3b_1
X_0736_ _0088_ _0092_ VSS VSS VDD VDD _0096_ sky130_fd_sc_hd__nand2_2
X_0737_ _0093_ VSS VSS VDD VDD _0097_ sky130_fd_sc_hd__buf_6
X_0738_ active_row\[6\]\[9\] active_row\[7\]\[9\] _0097_ VSS
+ VSS VDD VDD _0098_ sky130_fd_sc_hd__mux2i_1
X_0739_ active_row\[1\]\[9\] _0095_ _0096_ _0098_ VSS VSS
+ VDD VDD _0099_ sky130_fd_sc_hd__o2bb2ai_1
X_0740_ _0089_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__inv_1
X_0741_ _0100_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__buf_4
X_0742_ _0091_ active_row\[4\]\[9\] VSS VSS VDD VDD _0102_
+ sky130_fd_sc_hd__nor2b_1
X_0743_ net4 VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__inv_1
X_0744_ _0103_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__buf_4
X_0745_ _0093_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__clkinv_4
X_0746_ _0101_ active_row\[2\]\[9\] _0102_ _0104_ _0105_ VSS
+ VSS VDD VDD _0106_ sky130_fd_sc_hd__o221a_1
X_0747_ _0091_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__buf_6
X_0748_ active_row\[5\]\[9\] VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__inv_1
X_0749_ _0088_ _0097_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__nand2_4
X_0750_ _0107_ active_row\[3\]\[9\] VSS VSS VDD VDD _0110_
+ sky130_fd_sc_hd__nand2_1
X_0751_ net4 net3 VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__nand2b_4
X_0752_ _0107_ _0108_ _0109_ _0110_ _0111_ VSS VSS VDD VDD
+ _0112_ sky130_fd_sc_hd__o32ai_4
X_0753_ _0087_ _0093_ _0090_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__or3_1
X_0754_ _0113_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__buf_4
X_0755_ _0099_ _0106_ _0112_ _0114_ active_row\[0\]\[9\] VSS
+ VSS VDD VDD _0115_ sky130_fd_sc_hd__o32ai_4
X_0756_ net15 _0115_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__xor2_1
X_0757_ active_row\[6\]\[3\] active_row\[7\]\[3\] _0097_ VSS
+ VSS VDD VDD _0117_ sky130_fd_sc_hd__mux2i_1
X_0758_ active_row\[1\]\[3\] _0095_ _0096_ _0117_ VSS VSS
+ VDD VDD _0118_ sky130_fd_sc_hd__o2bb2ai_1
X_0759_ _0091_ active_row\[4\]\[3\] VSS VSS VDD VDD _0119_
+ sky130_fd_sc_hd__nor2b_1
X_0760_ _0101_ active_row\[2\]\[3\] _0119_ _0104_ _0105_ VSS
+ VSS VDD VDD _0120_ sky130_fd_sc_hd__o221a_1
X_0761_ _0092_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__buf_6
X_0762_ active_row\[5\]\[3\] VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__inv_1
X_0763_ _0121_ active_row\[3\]\[3\] VSS VSS VDD VDD _0123_
+ sky130_fd_sc_hd__nand2_1
X_0764_ _0121_ _0122_ _0109_ _0123_ _0111_ VSS VSS VDD VDD
+ _0124_ sky130_fd_sc_hd__o32ai_4
X_0765_ _0118_ _0120_ _0124_ _0114_ active_row\[0\]\[3\] VSS
+ VSS VDD VDD _0125_ sky130_fd_sc_hd__o32ai_4
X_0766_ net8 _0125_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__xor2_1
X_0767_ _0116_ _0126_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__nand2_1
X_0768_ active_row\[1\]\[2\] active_row\[3\]\[2\] _0090_ VSS
+ VSS VDD VDD _0128_ sky130_fd_sc_hd__mux2i_1
X_0769_ _0090_ active_row\[5\]\[2\] _0087_ VSS VSS VDD VDD
+ _0129_ sky130_fd_sc_hd__nand3b_1
X_0770_ _0087_ _0128_ _0129_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__o21ai_0
X_0771_ net4 _0089_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__and2_0
X_0772_ active_row\[6\]\[2\] active_row\[7\]\[2\] net3 VSS
+ VSS VDD VDD _0132_ sky130_fd_sc_hd__mux2_1
X_0773_ active_row\[2\]\[2\] _0089_ VSS VSS VDD VDD _0133_
+ sky130_fd_sc_hd__nand2b_1
X_0774_ net4 net3 VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__nor2_2
X_0775_ _0093_ _0090_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__nor2_1
X_0776_ _0131_ _0132_ _0133_ _0134_ _0135_ active_row\[4\]\[2\]
+ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__a222oi_1
X_0777_ _0094_ _0130_ _0136_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__a21boi_2
X_0778_ active_row\[0\]\[2\] _0113_ VSS VSS VDD VDD _0138_
+ sky130_fd_sc_hd__nor2_1
X_0779_ net7 _0137_ _0138_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__or3_1
X_0780_ net7 _0137_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__nand2_1
X_0781_ _0088_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__buf_4
X_0782_ _0094_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__clkbuf_8
X_0783_ active_row\[4\]\[12\] active_row\[6\]\[12\] _0107_
+ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__mux2i_1
X_0784_ _0121_ active_row\[5\]\[12\] _0142_ VSS VSS VDD VDD
+ _0144_ sky130_fd_sc_hd__nand3b_1
X_0785_ _0142_ _0143_ _0144_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__o21ai_0
X_0786_ active_row\[3\]\[12\] active_row\[7\]\[12\] _0141_
+ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__mux2i_1
X_0787_ _0105_ _0101_ _0146_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__nor3_1
X_0788_ _0092_ active_row\[1\]\[12\] VSS VSS VDD VDD _0148_
+ sky130_fd_sc_hd__nor2b_1
X_0789_ _0101_ active_row\[2\]\[12\] _0148_ _0105_ _0104_
+ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__o221a_1
X_0790_ _0141_ _0145_ _0147_ _0149_ VSS VSS VDD VDD _0150_
+ sky130_fd_sc_hd__a211oi_1
X_0791_ active_row\[0\]\[12\] _0114_ VSS VSS VDD VDD _0151_
+ sky130_fd_sc_hd__nor2_1
X_0792_ net18 _0150_ _0151_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__or3_1
X_0793_ _0150_ _0151_ net18 VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__o21ai_0
X_0794_ _0139_ _0140_ _0152_ _0153_ VSS VSS VDD VDD _0154_
+ sky130_fd_sc_hd__nand4_1
X_0795_ active_row\[6\]\[11\] active_row\[7\]\[11\] _0142_
+ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__mux2i_1
X_0796_ _0096_ _0155_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__nor2_1
X_0797_ _0101_ active_row\[2\]\[11\] _0134_ VSS VSS VDD VDD
+ _0157_ sky130_fd_sc_hd__o21ai_0
X_0798_ active_row\[4\]\[11\] _0135_ VSS VSS VDD VDD _0158_
+ sky130_fd_sc_hd__nand2_1
X_0799_ active_row\[1\]\[11\] active_row\[5\]\[11\] _0088_
+ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__mux2i_1
X_0800_ _0107_ active_row\[3\]\[11\] VSS VSS VDD VDD _0160_
+ sky130_fd_sc_hd__nand2_1
X_0801_ _0105_ _0092_ _0159_ _0160_ _0111_ VSS VSS VDD VDD
+ _0161_ sky130_fd_sc_hd__o32a_1
X_0802_ _0156_ _0157_ _0158_ _0161_ VSS VSS VDD VDD _0162_
+ sky130_fd_sc_hd__and4b_1
X_0803_ active_row\[0\]\[8\] VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__inv_1
X_0804_ _0087_ _0093_ _0090_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__nor3_1
X_0805_ _0163_ _0164_ net14 VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__a21oi_1
X_0806_ active_row\[5\]\[8\] active_row\[7\]\[8\] _0089_ VSS
+ VSS VDD VDD _0166_ sky130_fd_sc_hd__mux2i_1
X_0807_ _0089_ active_row\[6\]\[8\] net3 VSS VSS VDD VDD _0167_
+ sky130_fd_sc_hd__a21oi_1
X_0808_ _0093_ _0166_ _0167_ _0103_ VSS VSS VDD VDD _0168_
+ sky130_fd_sc_hd__a211oi_1
X_0809_ active_row\[1\]\[8\] active_row\[3\]\[8\] _0089_ VSS
+ VSS VDD VDD _0169_ sky130_fd_sc_hd__mux2i_1
X_0810_ _0111_ _0169_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__nor2_1
X_0811_ _0100_ active_row\[2\]\[8\] _0134_ VSS VSS VDD VDD
+ _0171_ sky130_fd_sc_hd__o21a_1
X_0812_ active_row\[4\]\[8\] _0135_ _0168_ _0170_ _0171_ VSS
+ VSS VDD VDD _0172_ sky130_fd_sc_hd__a2111oi_2
X_0813_ _0165_ net14 _0172_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__mux2_1
X_0814_ active_row\[1\]\[10\] active_row\[3\]\[10\] _0090_
+ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__mux2i_1
X_0815_ _0091_ active_row\[5\]\[10\] _0087_ VSS VSS VDD VDD
+ _0175_ sky130_fd_sc_hd__nand3b_1
X_0816_ _0088_ _0174_ _0175_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__o21ai_0
X_0817_ active_row\[2\]\[10\] _0090_ VSS VSS VDD VDD _0177_
+ sky130_fd_sc_hd__nand2b_1
X_0818_ active_row\[6\]\[10\] active_row\[7\]\[10\] _0093_
+ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__mux2_1
X_0819_ active_row\[4\]\[10\] _0135_ _0177_ _0134_ _0178_
+ _0131_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__a222oi_1
X_0820_ _0097_ _0176_ _0179_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__a21boi_2
X_0821_ net16 VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__inv_1
X_0822_ active_row\[0\]\[10\] _0113_ _0181_ VSS VSS VDD VDD
+ _0182_ sky130_fd_sc_hd__o21ai_0
X_0823_ _0180_ _0182_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__nor2_1
X_0824_ active_row\[1\]\[6\] active_row\[3\]\[6\] _0092_ VSS
+ VSS VDD VDD _0184_ sky130_fd_sc_hd__mux2_1
X_0825_ _0097_ _0092_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__nand2b_1
X_0826_ _0105_ _0184_ _0185_ active_row\[2\]\[6\] VSS VSS
+ VDD VDD _0186_ sky130_fd_sc_hd__o22ai_1
X_0827_ active_row\[0\]\[6\] _0114_ VSS VSS VDD VDD _0187_
+ sky130_fd_sc_hd__nor2_1
X_0828_ active_row\[4\]\[6\] active_row\[5\]\[6\] active_row\[6\]\[6\]
+ active_row\[7\]\[6\] _0097_ _0121_ VSS VSS VDD VDD _0188_
+ sky130_fd_sc_hd__mux4_1
X_0829_ net12 _0188_ _0141_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__nand3b_1
X_0830_ _0141_ net12 _0186_ _0187_ _0189_ VSS VSS VDD VDD
+ _0190_ sky130_fd_sc_hd__o41ai_1
X_0831_ _0186_ _0187_ _0104_ net12 VSS VSS VDD VDD _0191_
+ sky130_fd_sc_hd__o211ai_1
X_0832_ _0188_ net12 _0141_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__nand3b_1
X_0833_ _0190_ _0191_ _0192_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__nand3b_1
X_0834_ net17 _0162_ _0173_ _0183_ _0193_ VSS VSS VDD VDD
+ _0194_ sky130_fd_sc_hd__a2111o_1
X_0835_ active_row\[0\]\[7\] _0114_ net13 VSS VSS VDD VDD
+ _0195_ sky130_fd_sc_hd__o21ai_0
X_0836_ active_row\[1\]\[7\] active_row\[3\]\[7\] _0107_ VSS
+ VSS VDD VDD _0196_ sky130_fd_sc_hd__mux2i_1
X_0837_ active_row\[2\]\[7\] _0185_ _0196_ _0142_ VSS VSS
+ VDD VDD _0197_ sky130_fd_sc_hd__a2bb2oi_1
X_0838_ net13 _0195_ _0197_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__mux2_1
X_0839_ active_row\[4\]\[7\] active_row\[5\]\[7\] active_row\[6\]\[7\]
+ active_row\[7\]\[7\] _0097_ _0121_ VSS VSS VDD VDD _0199_
+ sky130_fd_sc_hd__mux4_1
X_0840_ net13 _0199_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__xnor2_1
X_0841_ active_row\[0\]\[7\] net13 _0114_ VSS VSS VDD VDD
+ _0201_ sky130_fd_sc_hd__nor3_1
X_0842_ _0141_ _0200_ _0201_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__a21oi_1
X_0843_ _0141_ _0198_ _0202_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__o21ai_1
X_0844_ active_row\[5\]\[4\] VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__inv_1
X_0845_ _0121_ active_row\[3\]\[4\] VSS VSS VDD VDD _0205_
+ sky130_fd_sc_hd__nand2_1
X_0846_ _0107_ _0204_ _0109_ _0205_ _0111_ VSS VSS VDD VDD
+ _0206_ sky130_fd_sc_hd__o32ai_4
X_0847_ _0093_ _0087_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__nor2b_1
X_0848_ _0087_ _0091_ active_row\[1\]\[4\] _0094_ VSS VSS
+ VDD VDD _0208_ sky130_fd_sc_hd__nor4bb_1
X_0849_ _0101_ active_row\[4\]\[4\] _0207_ _0208_ VSS VSS
+ VDD VDD _0209_ sky130_fd_sc_hd__a31o_1
X_0850_ active_row\[2\]\[4\] _0092_ VSS VSS VDD VDD _0210_
+ sky130_fd_sc_hd__nor2b_1
X_0851_ active_row\[6\]\[4\] active_row\[7\]\[4\] _0142_ VSS
+ VSS VDD VDD _0211_ sky130_fd_sc_hd__mux2i_1
X_0852_ _0141_ _0142_ _0210_ _0211_ _0096_ VSS VSS VDD VDD
+ _0212_ sky130_fd_sc_hd__o32ai_2
X_0853_ _0206_ _0209_ _0212_ _0114_ active_row\[0\]\[4\] VSS
+ VSS VDD VDD _0213_ sky130_fd_sc_hd__o32ai_4
X_0854_ net9 _0213_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__xor2_1
X_0855_ _0203_ _0214_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__nand2_1
X_0856_ _0127_ _0154_ _0194_ _0215_ VSS VSS VDD VDD _0216_
+ sky130_fd_sc_hd__nor4_2
X_0857_ active_row\[0\]\[11\] VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__inv_1
X_0858_ _0217_ _0164_ _0162_ net17 VSS VSS VDD VDD _0218_
+ sky130_fd_sc_hd__a211oi_1
X_0859_ net6 VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__inv_1
X_0860_ active_row\[5\]\[1\] VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__inv_1
X_0861_ _0121_ active_row\[3\]\[1\] VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__nand2_1
X_0862_ _0121_ _0220_ _0109_ _0221_ _0111_ VSS VSS VDD VDD
+ _0222_ sky130_fd_sc_hd__o32ai_2
X_0863_ _0088_ _0092_ active_row\[1\]\[1\] _0097_ VSS VSS
+ VDD VDD _0223_ sky130_fd_sc_hd__nor4bb_1
X_0864_ _0101_ active_row\[4\]\[1\] _0207_ _0223_ VSS VSS
+ VDD VDD _0224_ sky130_fd_sc_hd__a31o_1
X_0865_ active_row\[2\]\[1\] _0107_ VSS VSS VDD VDD _0225_
+ sky130_fd_sc_hd__nor2b_1
X_0866_ active_row\[6\]\[1\] active_row\[7\]\[1\] _0142_ VSS
+ VSS VDD VDD _0226_ sky130_fd_sc_hd__mux2i_2
X_0867_ _0141_ _0142_ _0225_ _0226_ _0096_ VSS VSS VDD VDD
+ _0227_ sky130_fd_sc_hd__o32ai_4
X_0868_ _0219_ _0222_ _0224_ _0227_ VSS VSS VDD VDD _0228_
+ sky130_fd_sc_hd__nor4_1
X_0869_ _0222_ _0224_ _0227_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__nor3_1
X_0870_ active_row\[0\]\[1\] _0114_ _0219_ VSS VSS VDD VDD
+ _0230_ sky130_fd_sc_hd__o21ai_0
X_0871_ net16 _0180_ _0229_ _0230_ VSS VSS VDD VDD _0231_
+ sky130_fd_sc_hd__o2bb2ai_1
X_0872_ _0218_ _0228_ _0231_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__or3_1
X_0873_ _0107_ active_row\[3\]\[0\] VSS VSS VDD VDD _0233_
+ sky130_fd_sc_hd__nand2_1
X_0874_ _0092_ active_row\[5\]\[0\] _0088_ VSS VSS VDD VDD
+ _0234_ sky130_fd_sc_hd__nand3b_1
X_0875_ _0088_ _0233_ _0234_ VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__o21ai_0
X_0876_ active_row\[1\]\[0\] _0094_ VSS VSS VDD VDD _0236_
+ sky130_fd_sc_hd__nand2b_1
X_0877_ _0105_ active_row\[4\]\[0\] _0236_ _0104_ VSS VSS
+ VDD VDD _0237_ sky130_fd_sc_hd__a22o_1
X_0878_ _0142_ _0235_ _0237_ _0101_ VSS VSS VDD VDD _0238_
+ sky130_fd_sc_hd__a22oi_1
X_0879_ active_row\[6\]\[0\] active_row\[7\]\[0\] _0097_ VSS
+ VSS VDD VDD _0239_ sky130_fd_sc_hd__mux2i_1
X_0880_ active_row\[2\]\[0\] _0134_ _0239_ _0104_ VSS VSS
+ VDD VDD _0240_ sky130_fd_sc_hd__o2bb2ai_1
X_0881_ _0121_ _0240_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__nand2_1
X_0882_ _0238_ _0241_ _0114_ active_row\[0\]\[0\] VSS VSS
+ VDD VDD _0242_ sky130_fd_sc_hd__o2bb2ai_1
X_0883_ net5 _0242_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__xnor2_1
X_0884_ active_row\[0\]\[13\] VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__inv_1
X_0885_ _0163_ net14 _0217_ net17 _0244_ net19 VSS VSS VDD
+ VDD _0245_ sky130_fd_sc_hd__a222oi_1
X_0886_ active_row\[0\]\[1\] _0219_ active_row\[0\]\[10\]
+ _0181_ _0245_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__o221ai_1
X_0887_ bank_active\[0\] bank_active\[1\] bank_active\[2\]
+ bank_active\[3\] _0094_ _0107_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__mux4_1
X_0888_ _0141_ _0247_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__nor2_1
X_0889_ bank_active\[4\] bank_active\[5\] bank_active\[6\]
+ bank_active\[7\] _0094_ _0107_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__mux4_1
X_0890_ _0104_ _0249_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__nor2_1
X_0891_ net7 _0138_ _0248_ _0250_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__a211o_1
X_0892_ _0164_ _0246_ _0251_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__a21oi_1
X_0893_ active_row\[1\]\[13\] active_row\[3\]\[13\] _0090_
+ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__mux2_1
X_0894_ active_row\[4\]\[13\] active_row\[6\]\[13\] _0091_
+ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__mux2i_2
X_0895_ _0111_ _0253_ _0254_ _0207_ VSS VSS VDD VDD _0255_
+ sky130_fd_sc_hd__a2bb2oi_1
X_0896_ active_row\[5\]\[13\] active_row\[7\]\[13\] _0091_
+ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__mux2i_1
X_0897_ _0087_ _0094_ active_row\[2\]\[13\] _0091_ VSS VSS
+ VDD VDD _0257_ sky130_fd_sc_hd__nor4b_1
X_0898_ _0088_ _0097_ _0256_ _0257_ VSS VSS VDD VDD _0258_
+ sky130_fd_sc_hd__a31oi_1
X_0899_ net19 VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__inv_1
X_0900_ active_row\[0\]\[13\] _0113_ _0255_ _0258_ _0259_
+ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__o2111ai_1
X_0901_ _0255_ _0258_ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__nand2_1
X_0902_ net19 _0261_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__nand2_1
X_0903_ _0252_ _0260_ _0262_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__nand3_1
X_0904_ _0232_ _0243_ _0263_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__nor3_2
X_0905_ _0090_ active_row\[4\]\[5\] VSS VSS VDD VDD _0265_
+ sky130_fd_sc_hd__nor2b_1
X_0906_ _0091_ active_row\[6\]\[5\] _0265_ _0094_ VSS VSS
+ VDD VDD _0266_ sky130_fd_sc_hd__a211oi_1
X_0907_ _0100_ active_row\[5\]\[5\] _0105_ VSS VSS VDD VDD
+ _0267_ sky130_fd_sc_hd__a21oi_1
X_0908_ active_row\[2\]\[5\] active_row\[3\]\[5\] _0093_ VSS
+ VSS VDD VDD _0268_ sky130_fd_sc_hd__mux2i_1
X_0909_ _0094_ active_row\[7\]\[5\] _0087_ VSS VSS VDD VDD
+ _0269_ sky130_fd_sc_hd__a21boi_0
X_0910_ _0103_ _0268_ _0269_ _0101_ VSS VSS VDD VDD _0270_
+ sky130_fd_sc_hd__a211o_1
X_0911_ _0105_ active_row\[1\]\[5\] _0101_ _0104_ VSS VSS
+ VDD VDD _0271_ sky130_fd_sc_hd__o211ai_1
X_0912_ _0104_ _0266_ _0267_ _0270_ _0271_ VSS VSS VDD VDD
+ _0272_ sky130_fd_sc_hd__o311a_1
X_0913_ active_row\[0\]\[5\] _0114_ VSS VSS VDD VDD _0273_
+ sky130_fd_sc_hd__nor2_1
X_0914_ net10 _0272_ _0273_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__or3_1
X_0915_ _0272_ _0273_ net10 VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__o21ai_0
X_0916_ _0274_ _0275_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__and2_1
X_0917_ net32 _0053_ _0057_ VSS VSS VDD VDD _0277_ sky130_fd_sc_hd__and3_1
X_0918_ net33 _0277_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__nand2_1
X_0919_ _0278_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__inv_1
X_0920_ _0216_ _0264_ _0276_ _0279_ VSS VSS VDD VDD _0280_
+ sky130_fd_sc_hd__nand4_4
X_0921_ _0664_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__clkbuf_4
X_0922_ refresh_counter\[15\] refresh_counter\[14\] refresh_counter\[13\]
+ refresh_counter\[12\] VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__or4_1
X_0923_ refresh_counter\[6\] refresh_counter\[5\] VSS VSS
+ VDD VDD _0283_ sky130_fd_sc_hd__nor2_1
X_0924_ _0645_ _0643_ refresh_counter\[4\] refresh_counter\[3\]
+ refresh_counter\[2\] VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__o2111ai_1
X_0925_ refresh_counter\[10\] refresh_counter\[9\] refresh_counter\[8\]
+ refresh_counter\[7\] VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__nand4_1
X_0926_ _0283_ _0284_ _0285_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__a21oi_1
X_0927_ refresh_counter\[11\] _0282_ _0286_ VSS VSS VDD VDD
+ _0287_ sky130_fd_sc_hd__or3_1
X_0928_ _0287_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__clkbuf_4
X_0929_ _0288_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__inv_2
X_0930_ _0281_ _0639_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__nand2_2
X_0931_ _0083_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__clkbuf_4
X_0932_ _0070_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__clkbuf_4
X_0933_ _0291_ net33 VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__nand2_1
X_0934_ burst_counter\[2\] burst_counter\[3\] VSS VSS VDD
+ VDD _0293_ sky130_fd_sc_hd__nor2_1
X_0935_ _0635_ _0293_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__nand2_2
X_0936_ net133 _0086_ _0294_ _0084_ VSS VSS VDD VDD _0295_
+ sky130_fd_sc_hd__nand4b_1
X_0937_ _0290_ _0292_ _0295_ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__o21ai_0
X_0938_ _0280_ _0289_ _0296_ _0067_ VSS VSS VDD VDD _0297_
+ sky130_fd_sc_hd__a2bb2oi_1
X_0939_ _0062_ _0297_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__nor2_1
X_0940_ _0664_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__clkinv_2
X_0941_ _0280_ _0288_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__nor2_1
X_0942_ _0070_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__clkinvlp_4
X_0943_ net33 _0067_ _0300_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__a21oi_1
X_0944_ _0050_ _0070_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__nor2_2
X_0945_ _0664_ _0083_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__nor2_1
X_0946_ _0302_ _0303_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__nand2_4
X_0947_ _0065_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__inv_1
X_0948_ _0305_ _0294_ _0083_ VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__o21ai_4
X_0949_ _0305_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__buf_2
X_0950_ _0072_ init_state\[1\] VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__or2_2
X_0951_ init_state\[6\] _0308_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__nor2_1
X_0952_ _0307_ _0309_ _0050_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__o21ai_2
X_0953_ _0304_ _0306_ _0310_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__nand3_1
X_0954_ _0301_ _0311_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__nor2_1
X_0955_ _0298_ _0299_ _0312_ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__o21ai_1
X_0956_ _0063_ _0064_ _0070_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__o21ai_4
X_0957_ _0300_ _0298_ _0313_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__a21boi_0
X_0958_ _0062_ _0314_ _0310_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__o21ai_0
X_0959_ _0085_ _0315_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__nor2_1
X_0960_ net32 _0053_ _0057_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__nand3_2
X_0961_ _0216_ _0264_ _0276_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__nand3_4
X_0962_ _0318_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__buf_4
X_0963_ _0298_ _0288_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__nor2_4
X_0964_ _0317_ _0319_ _0320_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__o21ai_0
X_0965_ _0316_ _0321_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__nand2_1
X_0966_ _0277_ _0318_ _0289_ VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__a21oi_1
X_0967_ _0291_ _0311_ _0322_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__or3_1
X_0968_ _0050_ _0281_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__nor2_2
X_0969_ init_state\[7\] _0066_ _0050_ VSS VSS VDD VDD _0324_
+ sky130_fd_sc_hd__a21boi_4
X_0970_ _0323_ _0324_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__nor2_1
X_0971_ _0281_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__clkbuf_4
X_0972_ _0326_ _0641_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__nand2_1
X_0973_ _0642_ _0325_ _0327_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__o21ai_0
X_0974_ _0320_ _0323_ _0324_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nor3_4
X_0975_ _0328_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__buf_2
X_0976_ refresh_counter\[1\] _0639_ VSS VSS VDD VDD _0330_
+ sky130_fd_sc_hd__nor2_1
X_0977_ _0644_ _0639_ _0329_ _0330_ VSS VSS VDD VDD _0593_
+ sky130_fd_sc_hd__a211oi_1
X_0978_ _0645_ _0639_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__nand2_1
X_0979_ refresh_counter\[2\] _0331_ VSS VSS VDD VDD _0332_
+ sky130_fd_sc_hd__xor2_1
X_0980_ _0329_ _0332_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__nor2_1
X_0981_ refresh_counter\[2\] refresh_counter\[1\] refresh_counter\[0\]
+ _0639_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__nand4_1
X_0982_ refresh_counter\[3\] _0333_ VSS VSS VDD VDD _0334_
+ sky130_fd_sc_hd__xor2_1
X_0983_ _0329_ _0334_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__nor2_1
X_0984_ refresh_counter\[3\] refresh_counter\[2\] _0645_ _0639_
+ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__nand4_1
X_0985_ refresh_counter\[4\] _0335_ VSS VSS VDD VDD _0336_
+ sky130_fd_sc_hd__xor2_1
X_0986_ _0329_ _0336_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__nor2_1
X_0987_ refresh_counter\[4\] refresh_counter\[3\] VSS VSS
+ VDD VDD _0337_ sky130_fd_sc_hd__nand2_1
X_0988_ _0337_ _0333_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__nor2_1
X_0989_ refresh_counter\[5\] _0338_ VSS VSS VDD VDD _0339_
+ sky130_fd_sc_hd__xnor2_1
X_0990_ _0329_ _0339_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__nor2_1
X_0991_ refresh_counter\[4\] refresh_counter\[3\] refresh_counter\[2\]
+ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__nand3_1
X_0992_ _0340_ _0331_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__nor2_1
X_0993_ refresh_counter\[5\] _0341_ VSS VSS VDD VDD _0342_
+ sky130_fd_sc_hd__nand2_1
X_0994_ refresh_counter\[6\] _0342_ VSS VSS VDD VDD _0343_
+ sky130_fd_sc_hd__xor2_1
X_0995_ _0329_ _0343_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__nor2_1
X_0996_ refresh_counter\[6\] refresh_counter\[5\] _0338_ VSS
+ VSS VDD VDD _0344_ sky130_fd_sc_hd__nand3_1
X_0997_ refresh_counter\[7\] _0344_ VSS VSS VDD VDD _0345_
+ sky130_fd_sc_hd__xor2_1
X_0998_ _0329_ _0345_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__nor2_1
X_0999_ refresh_counter\[7\] refresh_counter\[6\] refresh_counter\[5\]
+ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__and3_1
X_1000_ _0341_ _0346_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__nand2_1
X_1001_ refresh_counter\[8\] _0347_ VSS VSS VDD VDD _0348_
+ sky130_fd_sc_hd__xor2_1
X_1002_ _0329_ _0348_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__nor2_1
X_1003_ refresh_counter\[8\] _0338_ _0346_ VSS VSS VDD VDD
+ _0349_ sky130_fd_sc_hd__nand3_1
X_1004_ refresh_counter\[9\] _0349_ VSS VSS VDD VDD _0350_
+ sky130_fd_sc_hd__xor2_1
X_1005_ _0329_ _0350_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__nor2_1
X_1006_ refresh_counter\[9\] refresh_counter\[8\] _0341_ _0346_
+ refresh_counter\[10\] VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__a41oi_1
X_1007_ _0329_ _0351_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__nor2_1
X_1008_ _0328_ refresh_counter\[11\] VSS VSS VDD VDD _0588_
+ sky130_fd_sc_hd__nor2b_1
X_1009_ _0328_ refresh_counter\[12\] VSS VSS VDD VDD _0589_
+ sky130_fd_sc_hd__nor2b_1
X_1010_ _0328_ refresh_counter\[13\] VSS VSS VDD VDD _0590_
+ sky130_fd_sc_hd__nor2b_1
X_1011_ _0328_ refresh_counter\[14\] VSS VSS VDD VDD _0591_
+ sky130_fd_sc_hd__nor2b_1
X_1012_ _0328_ refresh_counter\[15\] VSS VSS VDD VDD _0592_
+ sky130_fd_sc_hd__nor2b_1
X_1013_ timer\[0\] VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__inv_1
X_1014_ timer\[5\] timer\[4\] VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__or2_0
X_1015_ net133 _0086_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__nand2_1
X_1016_ _0352_ _0064_ _0353_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__nor3_2
X_1017_ timer\[3\] timer\[2\] timer\[1\] VSS VSS VDD VDD _0355_
+ sky130_fd_sc_hd__nor3_1
X_1018_ _0355_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__inv_1
X_1019_ _0656_ _0356_ _0354_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__o21ai_0
X_1020_ net133 net101 VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__nand2b_1
X_1021_ net133 net198 net35 VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nand3_1
X_1022_ _0358_ _0359_ _0086_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__a21boi_1
X_1023_ _0294_ _0360_ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__nand2_1
X_1024_ _0650_ _0360_ _0361_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__o21ai_0
X_1025_ _0647_ _0354_ _0356_ _0357_ _0362_ VSS VSS VDD VDD
+ _0363_ sky130_fd_sc_hd__a32oi_1
X_1026_ _0650_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__inv_1
X_1027_ _0364_ _0066_ _0294_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__nand3_1
X_1028_ _0066_ _0363_ _0365_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__o21ai_0
X_1029_ init_state\[2\] init_state\[6\] _0308_ VSS VSS VDD
+ VDD _0367_ sky130_fd_sc_hd__nor3_2
X_1030_ init_state\[4\] init_state\[3\] init_state\[0\] VSS
+ VSS VDD VDD _0368_ sky130_fd_sc_hd__nor3_1
X_1031_ _0367_ _0368_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__nand2_1
X_1032_ _0649_ _0369_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__nand2_1
X_1033_ _0650_ _0369_ _0370_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__o21ai_0
X_1034_ _0300_ _0651_ _0304_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__o21ai_0
X_1035_ _0083_ _0366_ _0371_ _0061_ _0372_ VSS VSS VDD VDD
+ _0373_ sky130_fd_sc_hd__a221o_1
X_1036_ _0277_ _0373_ _0304_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__o21a_1
X_1037_ _0322_ _0373_ _0374_ _0364_ VSS VSS VDD VDD _0602_
+ sky130_fd_sc_hd__o22a_1
X_1038_ timer\[1\] VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__inv_1
X_1039_ _0307_ VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__clkbuf_4
X_1040_ net32 _0304_ _0307_ timer\[1\] VSS VSS VDD VDD _0375_
+ sky130_fd_sc_hd__a211oi_1
X_1041_ _0655_ _0648_ _0375_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__a21oi_1
X_1042_ _0635_ _0293_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__and2_2
X_1043_ _0352_ _0054_ _0055_ _0056_ VSS VSS VDD VDD _0378_
+ sky130_fd_sc_hd__nor4_1
X_1044_ net133 _0656_ _0086_ _0378_ _0360_ VSS VSS VDD VDD
+ _0379_ sky130_fd_sc_hd__a41oi_1
X_1045_ _0354_ _0356_ _0379_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__a21oi_2
X_1046_ _0655_ _0380_ _0307_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__o21ai_0
X_1047_ timer\[1\] _0307_ _0377_ _0381_ _0083_ VSS VSS VDD
+ VDD _0382_ sky130_fd_sc_hd__o311ai_0
X_1048_ timer\[1\] _0368_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__nand2_1
X_1049_ _0066_ _0367_ _0383_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__nand3_1
X_1050_ net33 _0066_ _0300_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__a21o_1
X_1051_ _0385_ _0304_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__nand2_1
X_1052_ _0061_ _0384_ _0386_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__a21oi_1
X_1053_ timer\[1\] _0307_ _0304_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nor3_1
X_1054_ _0655_ _0307_ _0382_ _0387_ _0388_ VSS VSS VDD VDD
+ _0389_ sky130_fd_sc_hd__a221oi_1
X_1055_ _0280_ _0320_ _0376_ _0389_ VSS VSS VDD VDD _0609_
+ sky130_fd_sc_hd__a31o_1
X_1056_ timer\[2\] _0654_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__xor2_1
X_1057_ _0307_ _0390_ _0288_ VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__a21oi_1
X_1058_ net33 _0317_ _0318_ _0391_ VSS VSS VDD VDD _0392_
+ sky130_fd_sc_hd__o31ai_1
X_1059_ _0307_ _0301_ _0390_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__o21ai_0
X_1060_ _0380_ _0083_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nor2b_1
X_1061_ _0061_ _0386_ _0394_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__nor3_1
X_1062_ _0075_ _0393_ _0395_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__a21oi_1
X_1063_ _0326_ _0392_ _0396_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__a21o_1
X_1064_ init_state\[4\] init_state\[3\] VSS VSS VDD VDD _0397_
+ sky130_fd_sc_hd__nor2_1
X_1065_ _0367_ _0397_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__nand2_1
X_1066_ _0290_ _0377_ _0398_ _0062_ _0648_ VSS VSS VDD VDD
+ _0399_ sky130_fd_sc_hd__a221oi_1
X_1067_ net32 _0280_ _0320_ _0304_ VSS VSS VDD VDD _0400_
+ sky130_fd_sc_hd__nand4_1
X_1068_ timer\[2\] timer\[1\] timer\[0\] VSS VSS VDD VDD _0401_
+ sky130_fd_sc_hd__nor3_1
X_1069_ timer\[3\] _0401_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__xnor2_1
X_1070_ _0289_ _0402_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__nor2_1
X_1071_ _0395_ _0402_ VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__nor2_1
X_1072_ _0067_ _0403_ _0404_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__nor3_1
X_1073_ _0385_ _0399_ _0400_ _0405_ VSS VSS VDD VDD _0611_
+ sky130_fd_sc_hd__a31oi_1
X_1074_ _0654_ _0052_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__nand2_1
X_1075_ timer\[4\] _0406_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__xor2_1
X_1076_ _0067_ _0407_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__nor2_1
X_1077_ _0288_ _0408_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__nor2_1
X_1078_ _0281_ _0084_ _0306_ _0380_ _0302_ VSS VSS VDD VDD
+ _0410_ sky130_fd_sc_hd__o221ai_2
X_1079_ _0408_ _0410_ _0326_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__a21oi_1
X_1080_ _0409_ _0411_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__nor2_1
X_1081_ _0653_ _0647_ _0052_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__nand3_1
X_1082_ timer\[4\] _0412_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__nor2_1
X_1083_ timer\[5\] _0413_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__xor2_1
X_1084_ _0648_ _0414_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__nand2_1
X_1085_ _0062_ init_state\[0\] _0067_ VSS VSS VDD VDD _0416_
+ sky130_fd_sc_hd__nand3_1
X_1086_ _0320_ _0410_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__nor2_1
X_1087_ _0415_ _0416_ _0417_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__a21oi_1
X_1088_ _0066_ _0367_ _0368_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__o21ai_0
X_1089_ _0061_ _0418_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__nand2_1
X_1090_ _0050_ _0309_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__nand2_1
X_1091_ init_state\[2\] _0368_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__nand2b_1
X_1092_ _0420_ _0421_ _0304_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__o21ai_0
X_1093_ _0307_ _0380_ _0306_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__a21oi_1
X_1094_ _0317_ _0320_ _0422_ _0423_ VSS VSS VDD VDD _0424_
+ sky130_fd_sc_hd__a211oi_2
X_1095_ _0057_ _0419_ timer\[6\] _0063_ VSS VSS VDD VDD _0425_
+ sky130_fd_sc_hd__a211oi_1
X_1096_ timer\[6\] _0063_ _0425_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__a21oi_1
X_1097_ _0300_ _0419_ _0424_ _0426_ VSS VSS VDD VDD _0614_
+ sky130_fd_sc_hd__a31oi_1
X_1098_ _0062_ _0369_ _0291_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__a21oi_1
X_1099_ timer\[6\] _0352_ _0412_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__or3_1
X_1100_ timer\[7\] _0428_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__xnor2_1
X_1101_ _0397_ _0648_ _0062_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__nor3b_1
X_1102_ _0648_ _0429_ _0430_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__a21oi_1
X_1103_ _0424_ _0427_ _0431_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__a21oi_1
X_1104_ _0067_ _0302_ _0424_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__o21a_1
X_1105_ timer\[7\] timer\[6\] _0063_ _0378_ VSS VSS VDD VDD
+ _0433_ sky130_fd_sc_hd__nor4_1
X_1106_ timer\[8\] _0433_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__xnor2_1
X_1107_ _0432_ _0434_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__nor2_1
X_1108_ timer\[7\] timer\[8\] _0428_ VSS VSS VDD VDD _0435_
+ sky130_fd_sc_hd__nor3_1
X_1109_ timer\[9\] _0435_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__xnor2_1
X_1110_ _0424_ _0427_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__nand2_1
X_1111_ _0648_ _0437_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__nand2_2
X_1112_ _0436_ _0438_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__nor2_1
X_1113_ timer\[7\] timer\[9\] timer\[8\] VSS VSS VDD VDD _0439_
+ sky130_fd_sc_hd__or3_1
X_1114_ timer\[6\] _0063_ _0439_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__nor3_1
X_1115_ timer\[10\] _0440_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__xnor2_1
X_1116_ _0438_ _0441_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__nor2_1
X_1117_ timer\[11\] _0054_ _0428_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__or3_1
X_1118_ _0054_ _0428_ timer\[11\] VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__o21ai_0
X_1119_ _0442_ _0443_ _0438_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__a21oi_1
X_1120_ _0063_ _0054_ _0055_ _0056_ VSS VSS VDD VDD _0444_
+ sky130_fd_sc_hd__nor4b_1
X_1121_ timer\[12\] _0444_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__xnor2_1
X_1122_ _0432_ _0445_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__nor2_1
X_1123_ timer\[12\] _0442_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__nor2_1
X_1124_ timer\[13\] _0446_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__xnor2_1
X_1125_ _0438_ _0447_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__nor2_1
X_1126_ timer\[13\] timer\[12\] VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__nor2_1
X_1127_ _0448_ _0444_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__nand2_1
X_1128_ timer\[14\] _0449_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__xor2_1
X_1129_ _0432_ _0450_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nor2_1
X_1130_ timer\[13\] timer\[12\] timer\[14\] _0442_ VSS VSS
+ VDD VDD _0451_ sky130_fd_sc_hd__nor4_1
X_1131_ timer\[15\] _0451_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__xnor2_1
X_1132_ _0438_ _0452_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__nor2_1
X_1133_ net35 _0294_ _0353_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__a21oi_1
X_1134_ _0067_ _0453_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__nand2_1
X_1135_ _0656_ _0648_ _0354_ _0355_ VSS VSS VDD VDD _0455_
+ sky130_fd_sc_hd__nand4_1
X_1136_ _0454_ _0455_ _0085_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__a21boi_0
X_1137_ net118 VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__inv_1
X_1138_ refresh_counter\[0\] VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__inv_1
X_1139_ net199 VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__inv_1
X_1140_ net119 VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__inv_1
X_1141_ burst_counter\[1\] VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__inv_1
X_1142_ net200 VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__inv_1
X_1143_ net2 net5 _0318_ VSS VSS VDD VDD _0456_ sky130_fd_sc_hd__mux2i_1
X_1144_ _0061_ _0308_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__nand2_1
X_1145_ _0317_ _0288_ _0664_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__o21ai_1
X_1146_ _0304_ _0306_ _0313_ _0458_ VSS VSS VDD VDD _0459_
+ sky130_fd_sc_hd__nand4_4
X_1147_ _0459_ _0310_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__nor2b_1
X_1148_ _0460_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__clkbuf_2
X_1149_ net104 _0457_ _0461_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__mux2_1
X_1150_ _0326_ _0462_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__nand2_1
X_1151_ _0061_ _0459_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__nor2_2
X_1152_ _0308_ _0461_ _0464_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__a21oi_1
X_1153_ _0291_ net2 _0290_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__a21o_1
X_1154_ _0465_ _0466_ _0462_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__o21ai_0
X_1155_ _0456_ _0463_ _0467_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__o21ai_0
X_1156_ _0281_ _0319_ _0464_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__nand3_1
X_1157_ _0459_ _0310_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__nand2b_1
X_1158_ _0469_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__buf_2
X_1159_ net105 _0470_ _0464_ _0085_ VSS VSS VDD VDD _0471_
+ sky130_fd_sc_hd__a22oi_1
X_1160_ _0181_ _0468_ _0471_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__o21ai_0
X_1161_ _0326_ net17 _0319_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__nand3_1
X_1162_ init_state\[1\] _0066_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__nand2_1
X_1163_ _0061_ _0473_ _0459_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__a21oi_2
X_1164_ _0061_ _0072_ _0083_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__a21oi_1
X_1165_ _0072_ init_state\[1\] _0461_ _0062_ VSS VSS VDD VDD
+ _0476_ sky130_fd_sc_hd__nand4b_1
X_1166_ net106 _0461_ _0476_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__o21ai_0
X_1167_ _0472_ _0474_ _0475_ _0477_ VSS VSS VDD VDD _0020_
+ sky130_fd_sc_hd__a31oi_1
X_1168_ net18 VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__inv_1
X_1169_ net107 _0470_ _0464_ _0085_ VSS VSS VDD VDD _0479_
+ sky130_fd_sc_hd__a22oi_1
X_1170_ _0478_ _0468_ _0479_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__o21ai_0
X_1171_ net108 _0470_ _0464_ _0085_ VSS VSS VDD VDD _0480_
+ sky130_fd_sc_hd__a22oi_1
X_1172_ _0259_ _0468_ _0480_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__o21ai_0
X_1173_ net11 net6 _0318_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__mux2i_1
X_1174_ net109 _0457_ _0461_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__mux2_1
X_1175_ _0326_ _0482_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__nand2_1
X_1176_ _0291_ net11 _0290_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__a21o_1
X_1177_ _0465_ _0484_ _0482_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__o21ai_0
X_1178_ _0481_ _0483_ _0485_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__o21ai_0
X_1179_ net20 net7 _0318_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__mux2i_1
X_1180_ _0326_ _0474_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__nand2_1
X_1181_ _0050_ _0083_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__nor2_1
X_1182_ _0291_ net20 VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__nand2_1
X_1183_ _0488_ _0489_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__nand2_1
X_1184_ net110 _0470_ _0474_ _0490_ VSS VSS VDD VDD _0491_
+ sky130_fd_sc_hd__a22oi_1
X_1185_ _0486_ _0487_ _0491_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__o21ai_0
X_1186_ _0326_ _0464_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__nand2_1
X_1187_ net21 net8 _0319_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__mux2i_1
X_1188_ _0291_ net21 _0290_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__a21oi_1
X_1189_ _0062_ _0459_ _0494_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__nor3_1
X_1190_ net111 _0470_ _0495_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__a21oi_1
X_1191_ _0492_ _0493_ _0496_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__o21ai_0
X_1192_ _0072_ _0066_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__nand2_1
X_1193_ _0061_ _0497_ _0459_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__a21oi_1
X_1194_ _0281_ _0498_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__nand2_1
X_1195_ net22 net9 _0319_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__mux2i_1
X_1196_ _0070_ net22 _0059_ _0072_ _0084_ VSS VSS VDD VDD
+ _0501_ sky130_fd_sc_hd__a221o_1
X_1197_ net112 _0470_ _0498_ _0501_ VSS VSS VDD VDD _0502_
+ sky130_fd_sc_hd__a22oi_1
X_1198_ _0499_ _0500_ _0502_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__o21ai_0
X_1199_ net23 net10 _0318_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__mux2i_1
X_1200_ net113 _0457_ _0461_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__mux2_1
X_1201_ _0326_ _0504_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__nand2_1
X_1202_ _0291_ net23 _0290_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__a21o_1
X_1203_ _0465_ _0506_ _0504_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__o21ai_0
X_1204_ _0503_ _0505_ _0507_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__o21ai_0
X_1205_ net24 net12 _0319_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__mux2i_1
X_1206_ _0070_ net24 _0058_ _0072_ _0084_ VSS VSS VDD VDD
+ _0509_ sky130_fd_sc_hd__a221o_1
X_1207_ net114 _0470_ _0498_ _0509_ VSS VSS VDD VDD _0510_
+ sky130_fd_sc_hd__a22oi_1
X_1208_ _0499_ _0508_ _0510_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__o21ai_0
X_1209_ net25 net13 _0319_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__mux2i_1
X_1210_ _0291_ net25 _0290_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__a21oi_1
X_1211_ _0062_ _0459_ _0512_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nor3_1
X_1212_ net115 _0470_ _0513_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__a21oi_1
X_1213_ _0492_ _0511_ _0514_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__o21ai_0
X_1214_ net26 net14 _0319_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__mux2i_1
X_1215_ _0291_ net26 VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__nand2_1
X_1216_ _0474_ _0475_ _0516_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__and3_1
X_1217_ _0474_ _0475_ _0516_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__nand3_1
X_1218_ net116 _0461_ _0518_ _0326_ _0476_ VSS VSS VDD VDD
+ _0519_ sky130_fd_sc_hd__o221ai_1
X_1219_ _0515_ _0517_ _0519_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__a21oi_1
X_1220_ net27 net15 _0319_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__mux2i_1
X_1221_ _0070_ net27 _0058_ _0072_ _0084_ VSS VSS VDD VDD
+ _0521_ sky130_fd_sc_hd__a221o_1
X_1222_ net117 _0470_ _0498_ _0521_ VSS VSS VDD VDD _0522_
+ sky130_fd_sc_hd__a22oi_1
X_1223_ _0499_ _0520_ _0522_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__o21ai_0
X_1224_ _0084_ _0377_ _0323_ VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__nand3_1
X_1225_ _0648_ _0523_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__nor2_4
X_1226_ _0630_ _0306_ _0313_ _0323_ VSS VSS VDD VDD _0525_
+ sky130_fd_sc_hd__and4b_1
X_1227_ net120 net119 VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__nor2_1
X_1228_ net118 _0621_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__nor2_1
X_1229_ _0525_ _0526_ _0527_ bank_active\[0\] VSS VSS VDD
+ VDD _0528_ sky130_fd_sc_hd__a31oi_1
X_1230_ _0524_ _0528_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__nor2_1
X_1231_ _0630_ _0306_ _0313_ _0323_ VSS VSS VDD VDD _0529_
+ sky130_fd_sc_hd__and4_1
X_1232_ _0624_ _0529_ bank_active\[1\] VSS VSS VDD VDD _0530_
+ sky130_fd_sc_hd__a21oi_1
X_1233_ _0524_ _0530_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__nor2_1
X_1234_ net118 _0526_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__nor2_1
X_1235_ _0621_ _0529_ _0531_ bank_active\[2\] VSS VSS VDD
+ VDD _0532_ sky130_fd_sc_hd__a31oi_1
X_1236_ _0524_ _0532_ VSS VSS VDD VDD _0034_ sky130_fd_sc_hd__nor2_1
X_1237_ _0626_ _0529_ bank_active\[3\] VSS VSS VDD VDD _0533_
+ sky130_fd_sc_hd__a21oi_1
X_1238_ _0524_ _0533_ VSS VSS VDD VDD _0035_ sky130_fd_sc_hd__nor2_1
X_1239_ net118 _0621_ _0526_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__nor3_1
X_1240_ _0529_ _0534_ bank_active\[4\] VSS VSS VDD VDD _0535_
+ sky130_fd_sc_hd__a21oi_1
X_1241_ _0524_ _0535_ VSS VSS VDD VDD _0036_ sky130_fd_sc_hd__nor2_1
X_1242_ _0624_ _0525_ bank_active\[5\] VSS VSS VDD VDD _0536_
+ sky130_fd_sc_hd__a21oi_1
X_1243_ _0524_ _0536_ VSS VSS VDD VDD _0037_ sky130_fd_sc_hd__nor2_1
X_1244_ _0621_ _0525_ _0531_ bank_active\[6\] VSS VSS VDD
+ VDD _0537_ sky130_fd_sc_hd__a31oi_1
X_1245_ _0524_ _0537_ VSS VSS VDD VDD _0038_ sky130_fd_sc_hd__nor2_1
X_1246_ _0626_ _0525_ bank_active\[7\] VSS VSS VDD VDD _0538_
+ sky130_fd_sc_hd__a21oi_1
X_1247_ _0524_ _0538_ VSS VSS VDD VDD _0039_ sky130_fd_sc_hd__nor2_1
X_1248_ net32 _0639_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__nand2_1
X_1249_ _0281_ _0539_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__nand2_1
X_1250_ _0323_ _0420_ _0540_ _0067_ VSS VSS VDD VDD _0541_
+ sky130_fd_sc_hd__nand4b_4
X_1251_ init_state\[1\] _0142_ _0281_ VSS VSS VDD VDD _0542_
+ sky130_fd_sc_hd__mux2i_2
X_1252_ net118 _0541_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__nand2_1
X_1253_ _0541_ _0542_ _0543_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__o21ai_0
X_1254_ _0281_ _0308_ VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__nor2_1
X_1255_ _0281_ _0121_ _0541_ _0544_ VSS VSS VDD VDD _0545_
+ sky130_fd_sc_hd__a211oi_1
X_1256_ _0619_ _0541_ _0545_ VSS VSS VDD VDD _0041_ sky130_fd_sc_hd__a21oi_1
X_1257_ net120 _0541_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__nand2_1
X_1258_ _0298_ _0104_ _0541_ _0546_ VSS VSS VDD VDD _0042_
+ sky130_fd_sc_hd__o31ai_1
X_1259_ _0290_ burst_counter\[0\] VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__nand2_1
X_1260_ _0290_ net28 _0547_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__o21ai_0
X_1261_ _0050_ _0377_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__nor2_1
X_1262_ _0313_ _0488_ _0549_ _0066_ VSS VSS VDD VDD _0550_
+ sky130_fd_sc_hd__a22oi_1
X_1263_ _0152_ _0153_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__and2_0
X_1264_ _0164_ _0246_ _0251_ _0228_ VSS VSS VDD VDD _0552_
+ sky130_fd_sc_hd__a211o_1
X_1265_ net17 _0162_ _0218_ _0231_ _0552_ VSS VSS VDD VDD
+ _0553_ sky130_fd_sc_hd__a2111oi_1
X_1266_ _0193_ _0203_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__nor2b_1
X_1267_ _0317_ _0288_ _0550_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nor3_1
X_1268_ _0551_ _0553_ _0554_ _0555_ VSS VSS VDD VDD _0556_
+ sky130_fd_sc_hd__nand4_1
X_1269_ _0116_ _0274_ _0275_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nand3_1
X_1270_ net7 _0137_ _0138_ _0260_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__o31ai_1
X_1271_ net7 _0137_ _0180_ _0182_ VSS VSS VDD VDD _0559_ sky130_fd_sc_hd__o2bb2ai_1
X_1272_ _0173_ _0558_ _0559_ _0262_ VSS VSS VDD VDD _0560_
+ sky130_fd_sc_hd__or4b_1
X_1273_ _0126_ _0214_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__nand2_1
X_1274_ _0243_ _0557_ _0560_ _0561_ VSS VSS VDD VDD _0562_
+ sky130_fd_sc_hd__or4_1
X_1275_ _0664_ _0550_ _0556_ _0562_ VSS VSS VDD VDD _0563_
+ sky130_fd_sc_hd__o22a_1
X_1276_ _0563_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__buf_6
X_1277_ burst_counter\[0\] _0564_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__nand2_1
X_1278_ _0548_ _0564_ _0565_ VSS VSS VDD VDD _0043_ sky130_fd_sc_hd__o21ai_0
X_1279_ _0085_ _0636_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__nand2_1
X_1280_ _0085_ net29 _0566_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__o21ai_0
X_1281_ burst_counter\[1\] _0564_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__nand2_1
X_1282_ _0564_ _0567_ _0568_ VSS VSS VDD VDD _0044_ sky130_fd_sc_hd__o21ai_0
X_1283_ burst_counter\[2\] _0564_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__nand2_1
X_1284_ _0084_ _0637_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__nand2_1
X_1285_ burst_counter\[2\] _0564_ _0570_ VSS VSS VDD VDD _0571_
+ sky130_fd_sc_hd__or3_1
X_1286_ _0564_ _0084_ net30 VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__or3b_1
X_1287_ _0637_ burst_counter\[2\] _0085_ VSS VSS VDD VDD _0573_
+ sky130_fd_sc_hd__nand3b_1
X_1288_ _0569_ _0571_ _0572_ _0573_ VSS VSS VDD VDD _0045_
+ sky130_fd_sc_hd__nand4_1
X_1289_ _0290_ net31 VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__nand2b_1
X_1290_ burst_counter\[2\] burst_counter\[1\] burst_counter\[0\]
+ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__or3_1
X_1291_ _0085_ burst_counter\[3\] _0575_ VSS VSS VDD VDD _0576_
+ sky130_fd_sc_hd__nand3_1
X_1292_ burst_counter\[3\] _0575_ _0084_ VSS VSS VDD VDD _0577_
+ sky130_fd_sc_hd__nor3b_1
X_1293_ _0577_ burst_counter\[3\] _0564_ VSS VSS VDD VDD _0578_
+ sky130_fd_sc_hd__mux2i_1
X_1294_ _0564_ _0574_ _0576_ _0578_ VSS VSS VDD VDD _0046_
+ sky130_fd_sc_hd__o211ai_1
X_1295_ _0324_ _0459_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__nor2_1
X_1296_ _0298_ _0319_ _0579_ _0661_ _0300_ VSS VSS VDD VDD
+ _0580_ sky130_fd_sc_hd__o2111ai_1
X_1297_ net199 _0579_ _0580_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__o21a_1
X_1298_ _0661_ _0579_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__nand2_1
X_1299_ _0659_ _0579_ _0581_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__o21ai_0
X_1300_ init_state\[7\] _0059_ net103 VSS VSS VDD VDD _0049_
+ sky130_fd_sc_hd__a21o_1
X_1301_ _0648_ _0289_ VSS VSS VDD VDD net102 sky130_fd_sc_hd__nor2_1
X_1302_ cmd_reg_valid VSS VSS VDD VDD net122 sky130_fd_sc_hd__inv_1
X_1303_ init_state\[7\] init_state\[3\] VSS VSS VDD VDD _0582_
+ sky130_fd_sc_hd__nor2_1
X_1304_ _0367_ _0582_ net36 VSS VSS VDD VDD net132 sky130_fd_sc_hd__a21boi_0
X_1305_ _0618_ _0619_ VSS VSS VDD VDD _0620_ _0621_ sky130_fd_sc_hd__ha_1
X_1306_ _0618_ net119 VSS VSS VDD VDD _0622_ _0623_ sky130_fd_sc_hd__ha_1
X_1307_ net118 _0619_ VSS VSS VDD VDD _0624_ _0625_ sky130_fd_sc_hd__ha_1
X_1308_ net118 net119 VSS VSS VDD VDD _0626_ _0627_ sky130_fd_sc_hd__ha_1
X_1309_ _0628_ _0620_ VSS VSS VDD VDD _0629_ _0630_ sky130_fd_sc_hd__ha_1
X_1310_ net120 _0620_ VSS VSS VDD VDD _0631_ _0632_ sky130_fd_sc_hd__ha_1
X_1311_ _0633_ _0634_ VSS VSS VDD VDD _0635_ _0636_ sky130_fd_sc_hd__ha_1
X_1312_ _0633_ _0634_ VSS VSS VDD VDD _0637_ _0638_ sky130_fd_sc_hd__ha_1
X_1313_ _0639_ _0640_ VSS VSS VDD VDD _0641_ _0642_ sky130_fd_sc_hd__ha_1
X_1314_ _0640_ refresh_counter\[1\] VSS VSS VDD VDD _0643_
+ _0644_ sky130_fd_sc_hd__ha_1
X_1315_ refresh_counter\[0\] refresh_counter\[1\] VSS VSS
+ VDD VDD _0645_ _0646_ sky130_fd_sc_hd__ha_1
X_1316_ _0647_ _0648_ VSS VSS VDD VDD _0649_ _0650_ sky130_fd_sc_hd__ha_1
X_1317_ timer\[0\] _0648_ VSS VSS VDD VDD _0651_ _0652_ sky130_fd_sc_hd__ha_1
X_1318_ _0647_ _0653_ VSS VSS VDD VDD _0654_ _0655_ sky130_fd_sc_hd__ha_1
X_1319_ timer\[0\] _0653_ VSS VSS VDD VDD _0656_ _0657_ sky130_fd_sc_hd__ha_1
X_1320_ _0658_ _0659_ VSS VSS VDD VDD _0660_ _0661_ sky130_fd_sc_hd__ha_1
X_1321_ _0658_ net200 VSS VSS VDD VDD _0662_ _0663_ sky130_fd_sc_hd__ha_1
X_1322_ net199 _0659_ VSS VSS VDD VDD _0664_ _0665_ sky130_fd_sc_hd__ha_2
X_1323_ net199 net200 VSS VSS VDD VDD _0666_ _0667_ sky130_fd_sc_hd__ha_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1328__211 VSS VSS VDD VDD net212 _unconnected_0 sky130_fd_sc_hd__conb_1
X_1326_ net202 VSS VSS VDD VDD phy_bank_group[0] sky130_fd_sc_hd__buf_4
X_1327_ net203 VSS VSS VDD VDD phy_bank_group[1] sky130_fd_sc_hd__buf_4
X_1328_ net212 VSS VSS VDD VDD phy_cke sky130_fd_sc_hd__buf_4
X_1329_ wr_mask[0] VSS VSS VDD VDD net123 sky130_fd_sc_hd__clkbuf_1
X_1330_ wr_mask[1] VSS VSS VDD VDD net124 sky130_fd_sc_hd__clkbuf_1
X_1331_ wr_mask[2] VSS VSS VDD VDD net125 sky130_fd_sc_hd__clkbuf_1
X_1332_ wr_mask[3] VSS VSS VDD VDD net126 sky130_fd_sc_hd__clkbuf_1
X_1333_ wr_mask[4] VSS VSS VDD VDD net127 sky130_fd_sc_hd__clkbuf_1
X_1334_ wr_mask[5] VSS VSS VDD VDD net128 sky130_fd_sc_hd__clkbuf_1
X_1335_ wr_mask[6] VSS VSS VDD VDD net129 sky130_fd_sc_hd__clkbuf_1
X_1336_ wr_mask[7] VSS VSS VDD VDD net130 sky130_fd_sc_hd__clkbuf_1
X_1337_ net37 VSS VSS VDD VDD phy_dq[0] sky130_fd_sc_hd__clkbuf_1
X_1338_ net48 VSS VSS VDD VDD phy_dq[1] sky130_fd_sc_hd__clkbuf_1
X_1339_ net59 VSS VSS VDD VDD phy_dq[2] sky130_fd_sc_hd__clkbuf_1
X_1340_ net70 VSS VSS VDD VDD phy_dq[3] sky130_fd_sc_hd__clkbuf_1
X_1341_ net81 VSS VSS VDD VDD phy_dq[4] sky130_fd_sc_hd__clkbuf_1
X_1342_ net92 VSS VSS VDD VDD phy_dq[5] sky130_fd_sc_hd__clkbuf_1
X_1343_ net97 VSS VSS VDD VDD phy_dq[6] sky130_fd_sc_hd__clkbuf_1
X_1344_ net98 VSS VSS VDD VDD phy_dq[7] sky130_fd_sc_hd__clkbuf_1
X_1345_ net99 VSS VSS VDD VDD phy_dq[8] sky130_fd_sc_hd__clkbuf_1
X_1346_ net100 VSS VSS VDD VDD phy_dq[9] sky130_fd_sc_hd__clkbuf_1
X_1347_ net38 VSS VSS VDD VDD phy_dq[10] sky130_fd_sc_hd__clkbuf_1
X_1348_ net39 VSS VSS VDD VDD phy_dq[11] sky130_fd_sc_hd__clkbuf_1
X_1349_ net40 VSS VSS VDD VDD phy_dq[12] sky130_fd_sc_hd__clkbuf_1
X_1350_ net41 VSS VSS VDD VDD phy_dq[13] sky130_fd_sc_hd__clkbuf_1
X_1351_ net42 VSS VSS VDD VDD phy_dq[14] sky130_fd_sc_hd__clkbuf_1
X_1352_ net43 VSS VSS VDD VDD phy_dq[15] sky130_fd_sc_hd__clkbuf_1
X_1353_ net44 VSS VSS VDD VDD phy_dq[16] sky130_fd_sc_hd__clkbuf_1
X_1354_ net45 VSS VSS VDD VDD phy_dq[17] sky130_fd_sc_hd__clkbuf_1
X_1355_ net46 VSS VSS VDD VDD phy_dq[18] sky130_fd_sc_hd__clkbuf_1
X_1356_ net47 VSS VSS VDD VDD phy_dq[19] sky130_fd_sc_hd__clkbuf_1
X_1357_ net49 VSS VSS VDD VDD phy_dq[20] sky130_fd_sc_hd__clkbuf_1
X_1358_ net50 VSS VSS VDD VDD phy_dq[21] sky130_fd_sc_hd__clkbuf_1
X_1359_ net51 VSS VSS VDD VDD phy_dq[22] sky130_fd_sc_hd__clkbuf_1
X_1360_ net52 VSS VSS VDD VDD phy_dq[23] sky130_fd_sc_hd__clkbuf_1
X_1361_ net53 VSS VSS VDD VDD phy_dq[24] sky130_fd_sc_hd__clkbuf_1
X_1362_ net54 VSS VSS VDD VDD phy_dq[25] sky130_fd_sc_hd__clkbuf_1
X_1363_ net55 VSS VSS VDD VDD phy_dq[26] sky130_fd_sc_hd__clkbuf_1
X_1364_ net56 VSS VSS VDD VDD phy_dq[27] sky130_fd_sc_hd__clkbuf_1
X_1365_ net57 VSS VSS VDD VDD phy_dq[28] sky130_fd_sc_hd__clkbuf_1
X_1366_ net58 VSS VSS VDD VDD phy_dq[29] sky130_fd_sc_hd__clkbuf_1
X_1367_ net60 VSS VSS VDD VDD phy_dq[30] sky130_fd_sc_hd__clkbuf_1
X_1368_ net61 VSS VSS VDD VDD phy_dq[31] sky130_fd_sc_hd__clkbuf_1
X_1369_ net62 VSS VSS VDD VDD phy_dq[32] sky130_fd_sc_hd__clkbuf_1
X_1370_ net63 VSS VSS VDD VDD phy_dq[33] sky130_fd_sc_hd__clkbuf_1
X_1371_ net64 VSS VSS VDD VDD phy_dq[34] sky130_fd_sc_hd__clkbuf_1
X_1372_ net65 VSS VSS VDD VDD phy_dq[35] sky130_fd_sc_hd__clkbuf_1
X_1373_ net66 VSS VSS VDD VDD phy_dq[36] sky130_fd_sc_hd__clkbuf_1
X_1374_ net67 VSS VSS VDD VDD phy_dq[37] sky130_fd_sc_hd__clkbuf_1
X_1375_ net68 VSS VSS VDD VDD phy_dq[38] sky130_fd_sc_hd__clkbuf_1
X_1376_ net69 VSS VSS VDD VDD phy_dq[39] sky130_fd_sc_hd__clkbuf_1
X_1377_ net71 VSS VSS VDD VDD phy_dq[40] sky130_fd_sc_hd__clkbuf_1
X_1378_ net72 VSS VSS VDD VDD phy_dq[41] sky130_fd_sc_hd__clkbuf_1
X_1379_ net73 VSS VSS VDD VDD phy_dq[42] sky130_fd_sc_hd__clkbuf_1
X_1380_ net74 VSS VSS VDD VDD phy_dq[43] sky130_fd_sc_hd__clkbuf_1
X_1381_ net75 VSS VSS VDD VDD phy_dq[44] sky130_fd_sc_hd__clkbuf_1
X_1382_ net76 VSS VSS VDD VDD phy_dq[45] sky130_fd_sc_hd__clkbuf_1
X_1383_ net77 VSS VSS VDD VDD phy_dq[46] sky130_fd_sc_hd__clkbuf_1
X_1384_ net78 VSS VSS VDD VDD phy_dq[47] sky130_fd_sc_hd__clkbuf_1
X_1385_ net79 VSS VSS VDD VDD phy_dq[48] sky130_fd_sc_hd__clkbuf_1
X_1386_ net80 VSS VSS VDD VDD phy_dq[49] sky130_fd_sc_hd__clkbuf_1
X_1387_ net82 VSS VSS VDD VDD phy_dq[50] sky130_fd_sc_hd__clkbuf_1
X_1388_ net83 VSS VSS VDD VDD phy_dq[51] sky130_fd_sc_hd__clkbuf_1
X_1389_ net84 VSS VSS VDD VDD phy_dq[52] sky130_fd_sc_hd__clkbuf_1
X_1390_ net85 VSS VSS VDD VDD phy_dq[53] sky130_fd_sc_hd__clkbuf_1
X_1391_ net86 VSS VSS VDD VDD phy_dq[54] sky130_fd_sc_hd__clkbuf_1
X_1392_ net87 VSS VSS VDD VDD phy_dq[55] sky130_fd_sc_hd__clkbuf_1
X_1393_ net88 VSS VSS VDD VDD phy_dq[56] sky130_fd_sc_hd__clkbuf_1
X_1394_ net89 VSS VSS VDD VDD phy_dq[57] sky130_fd_sc_hd__clkbuf_1
X_1395_ net90 VSS VSS VDD VDD phy_dq[58] sky130_fd_sc_hd__clkbuf_1
X_1396_ net91 VSS VSS VDD VDD phy_dq[59] sky130_fd_sc_hd__clkbuf_1
X_1397_ net93 VSS VSS VDD VDD phy_dq[60] sky130_fd_sc_hd__clkbuf_1
X_1398_ net94 VSS VSS VDD VDD phy_dq[61] sky130_fd_sc_hd__clkbuf_1
X_1399_ net95 VSS VSS VDD VDD phy_dq[62] sky130_fd_sc_hd__clkbuf_1
X_1400_ net96 VSS VSS VDD VDD phy_dq[63] sky130_fd_sc_hd__clkbuf_1
X_1401_ net204 VSS VSS VDD VDD phy_dqs_n[0] sky130_fd_sc_hd__buf_4
X_1402_ net205 VSS VSS VDD VDD phy_dqs_n[1] sky130_fd_sc_hd__buf_4
X_1403_ net206 VSS VSS VDD VDD phy_dqs_n[2] sky130_fd_sc_hd__buf_4
X_1404_ net207 VSS VSS VDD VDD phy_dqs_n[3] sky130_fd_sc_hd__buf_4
X_1405_ net208 VSS VSS VDD VDD phy_dqs_n[4] sky130_fd_sc_hd__buf_4
X_1406_ net209 VSS VSS VDD VDD phy_dqs_n[5] sky130_fd_sc_hd__buf_4
X_1407_ net210 VSS VSS VDD VDD phy_dqs_n[6] sky130_fd_sc_hd__buf_4
X_1408_ net211 VSS VSS VDD VDD phy_dqs_n[7] sky130_fd_sc_hd__buf_4
X_1409_ net213 VSS VSS VDD VDD phy_dqs_p[0] sky130_fd_sc_hd__buf_4
X_1410_ net214 VSS VSS VDD VDD phy_dqs_p[1] sky130_fd_sc_hd__buf_4
X_1411_ net215 VSS VSS VDD VDD phy_dqs_p[2] sky130_fd_sc_hd__buf_4
X_1412_ net216 VSS VSS VDD VDD phy_dqs_p[3] sky130_fd_sc_hd__buf_4
X_1413_ net217 VSS VSS VDD VDD phy_dqs_p[4] sky130_fd_sc_hd__buf_4
X_1414_ net218 VSS VSS VDD VDD phy_dqs_p[5] sky130_fd_sc_hd__buf_4
X_1415_ net219 VSS VSS VDD VDD phy_dqs_p[6] sky130_fd_sc_hd__buf_4
X_1416_ net220 VSS VSS VDD VDD phy_dqs_p[7] sky130_fd_sc_hd__buf_4
X_1417_ net221 VSS VSS VDD VDD phy_odt sky130_fd_sc_hd__buf_4
Xactive_row\[0\]\[0\]$_DFFE_PP_ clknet_4_11_0_clk net104 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[10\]$_DFFE_PP_ clknet_4_12_0_clk net105
+ _0016_ VSS VSS VDD VDD active_row\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[11\]$_DFFE_PP_ clknet_4_12_0_clk net106
+ _0016_ VSS VSS VDD VDD active_row\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[12\]$_DFFE_PP_ clknet_4_3_0_clk net107 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[13\]$_DFFE_PP_ clknet_4_12_0_clk net108
+ _0016_ VSS VSS VDD VDD active_row\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[1\]$_DFFE_PP_ clknet_4_9_0_clk net109 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[2\]$_DFFE_PP_ clknet_4_6_0_clk net110 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[3\]$_DFFE_PP_ clknet_4_11_0_clk net111 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[4\]$_DFFE_PP_ clknet_4_8_0_clk net112 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[5\]$_DFFE_PP_ clknet_4_3_0_clk net113 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[6\]$_DFFE_PP_ clknet_4_2_0_clk net114 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[7\]$_DFFE_PP_ clknet_4_2_0_clk net115 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[8\]$_DFFE_PP_ clknet_4_12_0_clk net116 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[0\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0016_
+ VSS VSS VDD VDD active_row\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net104 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[10\]$_DFFE_PP_ clknet_4_14_0_clk net105
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[11\]$_DFFE_PP_ clknet_4_11_0_clk net106
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[13\]$_DFFE_PP_ clknet_4_13_0_clk net108
+ _0015_ VSS VSS VDD VDD active_row\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[1\]$_DFFE_PP_ clknet_4_9_0_clk net109 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[2\]$_DFFE_PP_ clknet_4_13_0_clk net110 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[4\]$_DFFE_PP_ clknet_4_10_0_clk net112 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[5\]$_DFFE_PP_ clknet_4_13_0_clk net113 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[6\]$_DFFE_PP_ clknet_4_8_0_clk net114 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[7\]$_DFFE_PP_ clknet_4_8_0_clk net115 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[1\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0015_
+ VSS VSS VDD VDD active_row\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[0\]$_DFFE_PP_ clknet_4_11_0_clk net104 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[10\]$_DFFE_PP_ clknet_4_15_0_clk net105
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[11\]$_DFFE_PP_ clknet_4_14_0_clk net106
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[13\]$_DFFE_PP_ clknet_4_12_0_clk net108
+ _0014_ VSS VSS VDD VDD active_row\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[1\]$_DFFE_PP_ clknet_4_11_0_clk net109 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[2\]$_DFFE_PP_ clknet_4_15_0_clk net110 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[3\]$_DFFE_PP_ clknet_4_11_0_clk net111 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[4\]$_DFFE_PP_ clknet_4_10_0_clk net112 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[5\]$_DFFE_PP_ clknet_4_13_0_clk net113 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[6\]$_DFFE_PP_ clknet_4_9_0_clk net114 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[7\]$_DFFE_PP_ clknet_4_8_0_clk net115 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[2\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0014_
+ VSS VSS VDD VDD active_row\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[0\]$_DFFE_PP_ clknet_4_11_0_clk net104 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[10\]$_DFFE_PP_ clknet_4_15_0_clk net105
+ _0013_ VSS VSS VDD VDD active_row\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[11\]$_DFFE_PP_ clknet_4_14_0_clk net106
+ _0013_ VSS VSS VDD VDD active_row\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[13\]$_DFFE_PP_ clknet_4_13_0_clk net108
+ _0013_ VSS VSS VDD VDD active_row\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[1\]$_DFFE_PP_ clknet_4_9_0_clk net109 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[2\]$_DFFE_PP_ clknet_4_13_0_clk net110 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[4\]$_DFFE_PP_ clknet_4_8_0_clk net112 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[5\]$_DFFE_PP_ clknet_4_13_0_clk net113 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[6\]$_DFFE_PP_ clknet_4_8_0_clk net114 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[7\]$_DFFE_PP_ clknet_4_8_0_clk net115 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[3\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0013_
+ VSS VSS VDD VDD active_row\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net104 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[10\]$_DFFE_PP_ clknet_4_14_0_clk net105
+ _0012_ VSS VSS VDD VDD active_row\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[11\]$_DFFE_PP_ clknet_4_14_0_clk net106
+ _0012_ VSS VSS VDD VDD active_row\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[13\]$_DFFE_PP_ clknet_4_14_0_clk net108
+ _0012_ VSS VSS VDD VDD active_row\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[1\]$_DFFE_PP_ clknet_4_9_0_clk net109 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[2\]$_DFFE_PP_ clknet_4_15_0_clk net110 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[4\]$_DFFE_PP_ clknet_4_8_0_clk net112 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[5\]$_DFFE_PP_ clknet_4_12_0_clk net113 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[6\]$_DFFE_PP_ clknet_4_8_0_clk net114 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[7\]$_DFFE_PP_ clknet_4_8_0_clk net115 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[4\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0012_
+ VSS VSS VDD VDD active_row\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[0\]$_DFFE_PP_ clknet_4_11_0_clk net104 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[10\]$_DFFE_PP_ clknet_4_14_0_clk net105
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[11\]$_DFFE_PP_ clknet_4_14_0_clk net106
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[13\]$_DFFE_PP_ clknet_4_12_0_clk net108
+ _0011_ VSS VSS VDD VDD active_row\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[1\]$_DFFE_PP_ clknet_4_9_0_clk net109 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[2\]$_DFFE_PP_ clknet_4_13_0_clk net110 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[4\]$_DFFE_PP_ clknet_4_8_0_clk net112 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[5\]$_DFFE_PP_ clknet_4_13_0_clk net113 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[6\]$_DFFE_PP_ clknet_4_2_0_clk net114 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[7\]$_DFFE_PP_ clknet_4_2_0_clk net115 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[5\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0011_
+ VSS VSS VDD VDD active_row\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[0\]$_DFFE_PP_ clknet_4_14_0_clk net104 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[10\]$_DFFE_PP_ clknet_4_15_0_clk net105
+ _0010_ VSS VSS VDD VDD active_row\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[11\]$_DFFE_PP_ clknet_4_11_0_clk net106
+ _0010_ VSS VSS VDD VDD active_row\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[13\]$_DFFE_PP_ clknet_4_14_0_clk net108
+ _0010_ VSS VSS VDD VDD active_row\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[1\]$_DFFE_PP_ clknet_4_11_0_clk net109 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[2\]$_DFFE_PP_ clknet_4_15_0_clk net110 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[4\]$_DFFE_PP_ clknet_4_8_0_clk net112 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[5\]$_DFFE_PP_ clknet_4_12_0_clk net113 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[6\]$_DFFE_PP_ clknet_4_8_0_clk net114 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[7\]$_DFFE_PP_ clknet_4_8_0_clk net115 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[6\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0010_
+ VSS VSS VDD VDD active_row\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[0\]$_DFFE_PP_ clknet_4_11_0_clk net104 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[10\]$_DFFE_PP_ clknet_4_14_0_clk net105
+ _0009_ VSS VSS VDD VDD active_row\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[11\]$_DFFE_PP_ clknet_4_11_0_clk net106
+ _0009_ VSS VSS VDD VDD active_row\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[12\]$_DFFE_PP_ clknet_4_9_0_clk net107 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[13\]$_DFFE_PP_ clknet_4_12_0_clk net108
+ _0009_ VSS VSS VDD VDD active_row\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[1\]$_DFFE_PP_ clknet_4_11_0_clk net109 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[2\]$_DFFE_PP_ clknet_4_15_0_clk net110 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[3\]$_DFFE_PP_ clknet_4_10_0_clk net111 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[4\]$_DFFE_PP_ clknet_4_10_0_clk net112 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[5\]$_DFFE_PP_ clknet_4_13_0_clk net113 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[6\]$_DFFE_PP_ clknet_4_2_0_clk net114 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[7\]$_DFFE_PP_ clknet_4_2_0_clk net115 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[8\]$_DFFE_PP_ clknet_4_15_0_clk net116 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xactive_row\[7\]\[9\]$_DFFE_PP_ clknet_4_10_0_clk net117 _0009_
+ VSS VSS VDD VDD active_row\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xaddr_reg\[0\]$_DFFE_PN0P_ clknet_4_3_0_clk _0018_ net1 VSS
+ VSS VDD VDD net104 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[10\]$_DFFE_PN0P_ clknet_4_6_0_clk _0019_ net1 VSS
+ VSS VDD VDD net105 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[11\]$_DFFE_PN0P_ clknet_4_3_0_clk _0020_ net1 VSS
+ VSS VDD VDD net106 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[12\]$_DFFE_PN0P_ clknet_4_3_0_clk _0021_ net1 VSS
+ VSS VDD VDD net107 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[13\]$_DFFE_PN0P_ clknet_4_6_0_clk _0022_ net1 VSS
+ VSS VDD VDD net108 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[1\]$_DFFE_PN0P_ clknet_4_3_0_clk _0023_ net1 VSS
+ VSS VDD VDD net109 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[2\]$_DFFE_PN0P_ clknet_4_6_0_clk _0024_ net1 VSS
+ VSS VDD VDD net110 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[3\]$_DFFE_PN0P_ clknet_4_2_0_clk _0025_ net1 VSS
+ VSS VDD VDD net111 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[4\]$_DFFE_PN0P_ clknet_4_2_0_clk _0026_ net1 VSS
+ VSS VDD VDD net112 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[5\]$_DFFE_PN0P_ clknet_4_6_0_clk _0027_ net1 VSS
+ VSS VDD VDD net113 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[6\]$_DFFE_PN0P_ clknet_4_2_0_clk _0028_ net1 VSS
+ VSS VDD VDD net114 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[7\]$_DFFE_PN0P_ clknet_4_2_0_clk _0029_ net1 VSS
+ VSS VDD VDD net115 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[8\]$_DFFE_PN0P_ clknet_4_6_0_clk _0030_ net1 VSS
+ VSS VDD VDD net116 sky130_fd_sc_hd__dfrtp_4
Xaddr_reg\[9\]$_DFFE_PN0P_ clknet_4_2_0_clk _0031_ net1 VSS
+ VSS VDD VDD net117 sky130_fd_sc_hd__dfrtp_4
Xbank_active\[0\]$_DFFE_PN0P_ clknet_4_7_0_clk _0032_ net1
+ VSS VSS VDD VDD bank_active\[0\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[1\]$_DFFE_PN0P_ clknet_4_12_0_clk _0033_ net1
+ VSS VSS VDD VDD bank_active\[1\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[2\]$_DFFE_PN0P_ clknet_4_7_0_clk _0034_ net1
+ VSS VSS VDD VDD bank_active\[2\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[3\]$_DFFE_PN0P_ clknet_4_7_0_clk _0035_ net1
+ VSS VSS VDD VDD bank_active\[3\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[4\]$_DFFE_PN0P_ clknet_4_13_0_clk _0036_ net1
+ VSS VSS VDD VDD bank_active\[4\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[5\]$_DFFE_PN0P_ clknet_4_13_0_clk _0037_ net1
+ VSS VSS VDD VDD bank_active\[5\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[6\]$_DFFE_PN0P_ clknet_4_7_0_clk _0038_ net1
+ VSS VSS VDD VDD bank_active\[6\] sky130_fd_sc_hd__dfrtp_1
Xbank_active\[7\]$_DFFE_PN0P_ clknet_4_7_0_clk _0039_ net1
+ VSS VSS VDD VDD bank_active\[7\] sky130_fd_sc_hd__dfrtp_1
Xbank_reg\[0\]$_DFFE_PN0P_ clknet_4_6_0_clk _0040_ net1 VSS
+ VSS VDD VDD net118 sky130_fd_sc_hd__dfrtp_4
Xbank_reg\[1\]$_DFFE_PN0P_ clknet_4_6_0_clk _0041_ net1 VSS
+ VSS VDD VDD net119 sky130_fd_sc_hd__dfrtp_2
Xbank_reg\[2\]$_DFFE_PN0P_ clknet_4_6_0_clk _0042_ net1 VSS
+ VSS VDD VDD net120 sky130_fd_sc_hd__dfrtp_4
Xburst_counter\[0\]$_DFFE_PN0P_ clknet_4_5_0_clk _0043_ net1
+ VSS VSS VDD VDD burst_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[1\]$_DFFE_PN0P_ clknet_4_4_0_clk _0044_ net1
+ VSS VSS VDD VDD burst_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[2\]$_DFFE_PN0P_ clknet_4_4_0_clk _0045_ net1
+ VSS VSS VDD VDD burst_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xburst_counter\[3\]$_DFFE_PN0P_ clknet_4_5_0_clk _0046_ net1
+ VSS VSS VDD VDD burst_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xcmd_reg\[0\]$_DFF_PN1_ clknet_4_1_0_clk _0583_ net36 VSS
+ VSS VDD VDD net133 sky130_fd_sc_hd__dfstp_1
Xcmd_reg\[1\]$_DFF_PN1_ clknet_4_1_0_clk _0584_ net36 VSS
+ VSS VDD VDD net121 sky130_fd_sc_hd__dfstp_1
Xcmd_reg\[2\]$_DFF_PN1_ clknet_4_1_0_clk _0585_ net36 VSS
+ VSS VDD VDD net131 sky130_fd_sc_hd__dfstp_1
Xcmd_reg_valid$_DFF_PN0_ clknet_4_5_0_clk net222 net1 VSS
+ VSS VDD VDD cmd_reg_valid sky130_fd_sc_hd__dfrtp_1
Xcurr_state\[0\]$_DFFE_PN0P_ clknet_4_0_0_clk _0047_ net1
+ VSS VSS VDD VDD net199 sky130_fd_sc_hd__dfrtp_1
Xcurr_state\[1\]$_DFFE_PN0P_ clknet_4_0_0_clk _0048_ net1
+ VSS VSS VDD VDD net200 sky130_fd_sc_hd__dfrtp_1
Xinit_done_reg$_DFFE_PN0P_ clknet_4_0_0_clk _0049_ net1 VSS
+ VSS VDD VDD net103 sky130_fd_sc_hd__dfrtp_1
Xinit_state\[0\]$_DFF_PN1_ clknet_4_0_0_clk _0001_ net36 VSS
+ VSS VDD VDD init_state\[0\] sky130_fd_sc_hd__dfstp_1
Xinit_state\[1\]$_DFF_PN0_ clknet_4_0_0_clk _0002_ net1 VSS
+ VSS VDD VDD init_state\[1\] sky130_fd_sc_hd__dfrtp_2
Xinit_state\[2\]$_DFF_PN0_ clknet_4_0_0_clk _0003_ net1 VSS
+ VSS VDD VDD init_state\[2\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[3\]$_DFF_PN0_ clknet_4_0_0_clk _0004_ net1 VSS
+ VSS VDD VDD init_state\[3\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[4\]$_DFF_PN0_ clknet_4_0_0_clk _0005_ net1 VSS
+ VSS VDD VDD init_state\[4\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[5\]$_DFF_PN0_ clknet_4_0_0_clk _0006_ net1 VSS
+ VSS VDD VDD init_state\[5\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[6\]$_DFF_PN0_ clknet_4_0_0_clk _0007_ net1 VSS
+ VSS VDD VDD init_state\[6\] sky130_fd_sc_hd__dfrtp_1
Xinit_state\[7\]$_DFF_PN0_ clknet_4_0_0_clk _0008_ net1 VSS
+ VSS VDD VDD init_state\[7\] sky130_fd_sc_hd__dfrtp_2
Xrd_data_reg\[0\]$_DFFE_PP_ net34 net37 _0017_ VSS VSS VDD
+ VDD net134 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[10\]$_DFFE_PP_ net34 net38 _0017_ VSS VSS VDD
+ VDD net135 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[11\]$_DFFE_PP_ net34 net39 _0017_ VSS VSS VDD
+ VDD net136 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[12\]$_DFFE_PP_ net34 net40 _0017_ VSS VSS VDD
+ VDD net137 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[13\]$_DFFE_PP_ net34 net41 _0017_ VSS VSS VDD
+ VDD net138 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[14\]$_DFFE_PP_ net34 net42 _0017_ VSS VSS VDD
+ VDD net139 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[15\]$_DFFE_PP_ net34 net43 _0017_ VSS VSS VDD
+ VDD net140 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[16\]$_DFFE_PP_ net34 net44 _0017_ VSS VSS VDD
+ VDD net141 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[17\]$_DFFE_PP_ net34 net45 _0017_ VSS VSS VDD
+ VDD net142 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[18\]$_DFFE_PP_ net34 net46 _0017_ VSS VSS VDD
+ VDD net143 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[19\]$_DFFE_PP_ net34 net47 _0017_ VSS VSS VDD
+ VDD net144 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[1\]$_DFFE_PP_ net34 net48 _0017_ VSS VSS VDD
+ VDD net145 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[20\]$_DFFE_PP_ net34 net49 _0017_ VSS VSS VDD
+ VDD net146 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[21\]$_DFFE_PP_ net34 net50 _0017_ VSS VSS VDD
+ VDD net147 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[22\]$_DFFE_PP_ net34 net51 _0017_ VSS VSS VDD
+ VDD net148 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[23\]$_DFFE_PP_ net34 net52 _0017_ VSS VSS VDD
+ VDD net149 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[24\]$_DFFE_PP_ net34 net53 _0017_ VSS VSS VDD
+ VDD net150 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[25\]$_DFFE_PP_ net34 net54 _0017_ VSS VSS VDD
+ VDD net151 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[26\]$_DFFE_PP_ net34 net55 _0017_ VSS VSS VDD
+ VDD net152 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[27\]$_DFFE_PP_ net34 net56 _0017_ VSS VSS VDD
+ VDD net153 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[28\]$_DFFE_PP_ net34 net57 _0017_ VSS VSS VDD
+ VDD net154 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[29\]$_DFFE_PP_ net34 net58 _0017_ VSS VSS VDD
+ VDD net155 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[2\]$_DFFE_PP_ net34 net59 _0017_ VSS VSS VDD
+ VDD net156 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[30\]$_DFFE_PP_ net34 net60 _0017_ VSS VSS VDD
+ VDD net157 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[31\]$_DFFE_PP_ net34 net61 _0017_ VSS VSS VDD
+ VDD net158 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[32\]$_DFFE_PP_ net34 net62 _0017_ VSS VSS VDD
+ VDD net159 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[33\]$_DFFE_PP_ net34 net63 _0017_ VSS VSS VDD
+ VDD net160 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[34\]$_DFFE_PP_ net34 net64 _0017_ VSS VSS VDD
+ VDD net161 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[35\]$_DFFE_PP_ net34 net65 _0017_ VSS VSS VDD
+ VDD net162 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[36\]$_DFFE_PP_ net34 net66 _0017_ VSS VSS VDD
+ VDD net163 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[37\]$_DFFE_PP_ net34 net67 _0017_ VSS VSS VDD
+ VDD net164 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[38\]$_DFFE_PP_ net34 net68 _0017_ VSS VSS VDD
+ VDD net165 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[39\]$_DFFE_PP_ net34 net69 _0017_ VSS VSS VDD
+ VDD net166 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[3\]$_DFFE_PP_ net34 net70 _0017_ VSS VSS VDD
+ VDD net167 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[40\]$_DFFE_PP_ net34 net71 _0017_ VSS VSS VDD
+ VDD net168 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[41\]$_DFFE_PP_ net34 net72 _0017_ VSS VSS VDD
+ VDD net169 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[42\]$_DFFE_PP_ net34 net73 _0017_ VSS VSS VDD
+ VDD net170 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[43\]$_DFFE_PP_ net34 net74 _0017_ VSS VSS VDD
+ VDD net171 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[44\]$_DFFE_PP_ net34 net75 _0017_ VSS VSS VDD
+ VDD net172 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[45\]$_DFFE_PP_ net34 net76 _0017_ VSS VSS VDD
+ VDD net173 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[46\]$_DFFE_PP_ net34 net77 _0017_ VSS VSS VDD
+ VDD net174 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[47\]$_DFFE_PP_ net34 net78 _0017_ VSS VSS VDD
+ VDD net175 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[48\]$_DFFE_PP_ net34 net79 _0017_ VSS VSS VDD
+ VDD net176 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[49\]$_DFFE_PP_ net34 net80 _0017_ VSS VSS VDD
+ VDD net177 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[4\]$_DFFE_PP_ net34 net81 _0017_ VSS VSS VDD
+ VDD net178 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[50\]$_DFFE_PP_ net34 net82 _0017_ VSS VSS VDD
+ VDD net179 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[51\]$_DFFE_PP_ net34 net83 _0017_ VSS VSS VDD
+ VDD net180 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[52\]$_DFFE_PP_ net34 net84 _0017_ VSS VSS VDD
+ VDD net181 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[53\]$_DFFE_PP_ net34 net85 _0017_ VSS VSS VDD
+ VDD net182 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[54\]$_DFFE_PP_ net34 net86 _0017_ VSS VSS VDD
+ VDD net183 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[55\]$_DFFE_PP_ net34 net87 _0017_ VSS VSS VDD
+ VDD net184 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[56\]$_DFFE_PP_ net34 net88 _0017_ VSS VSS VDD
+ VDD net185 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[57\]$_DFFE_PP_ net34 net89 _0017_ VSS VSS VDD
+ VDD net186 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[58\]$_DFFE_PP_ net34 net90 _0017_ VSS VSS VDD
+ VDD net187 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[59\]$_DFFE_PP_ net34 net91 _0017_ VSS VSS VDD
+ VDD net188 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[5\]$_DFFE_PP_ net34 net92 _0017_ VSS VSS VDD
+ VDD net189 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[60\]$_DFFE_PP_ net34 net93 _0017_ VSS VSS VDD
+ VDD net190 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[61\]$_DFFE_PP_ net34 net94 _0017_ VSS VSS VDD
+ VDD net191 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[62\]$_DFFE_PP_ net34 net95 _0017_ VSS VSS VDD
+ VDD net192 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[63\]$_DFFE_PP_ net34 net96 _0017_ VSS VSS VDD
+ VDD net193 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[6\]$_DFFE_PP_ net34 net97 _0017_ VSS VSS VDD
+ VDD net194 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[7\]$_DFFE_PP_ net34 net98 _0017_ VSS VSS VDD
+ VDD net195 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[8\]$_DFFE_PP_ net34 net99 _0017_ VSS VSS VDD
+ VDD net196 sky130_fd_sc_hd__edfxtp_1
Xrd_data_reg\[9\]$_DFFE_PP_ net34 net100 _0017_ VSS VSS VDD
+ VDD net197 sky130_fd_sc_hd__edfxtp_1
Xrd_valid_reg$_DFF_PN0_ clknet_4_4_0_clk _0000_ net1 VSS VSS
+ VDD VDD net198 sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[0\]$_DFF_PN0_ clknet_4_5_0_clk _0586_ net1
+ VSS VSS VDD VDD refresh_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[10\]$_DFF_PN0_ clknet_4_7_0_clk _0587_ net1
+ VSS VSS VDD VDD refresh_counter\[10\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[11\]$_DFF_PN0_ clknet_4_5_0_clk _0588_ net1
+ VSS VSS VDD VDD refresh_counter\[11\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[12\]$_DFF_PN0_ clknet_4_5_0_clk _0589_ net1
+ VSS VSS VDD VDD refresh_counter\[12\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[13\]$_DFF_PN0_ clknet_4_5_0_clk _0590_ net1
+ VSS VSS VDD VDD refresh_counter\[13\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[14\]$_DFF_PN0_ clknet_4_5_0_clk _0591_ net1
+ VSS VSS VDD VDD refresh_counter\[14\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[15\]$_DFF_PN0_ clknet_4_5_0_clk _0592_ net1
+ VSS VSS VDD VDD refresh_counter\[15\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[1\]$_DFF_PN0_ clknet_4_5_0_clk _0593_ net1
+ VSS VSS VDD VDD refresh_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[2\]$_DFF_PN0_ clknet_4_5_0_clk _0594_ net1
+ VSS VSS VDD VDD refresh_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[3\]$_DFF_PN0_ clknet_4_7_0_clk _0595_ net1
+ VSS VSS VDD VDD refresh_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[4\]$_DFF_PN0_ clknet_4_7_0_clk _0596_ net1
+ VSS VSS VDD VDD refresh_counter\[4\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[5\]$_DFF_PN0_ clknet_4_5_0_clk _0597_ net1
+ VSS VSS VDD VDD refresh_counter\[5\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[6\]$_DFF_PN0_ clknet_4_5_0_clk _0598_ net1
+ VSS VSS VDD VDD refresh_counter\[6\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[7\]$_DFF_PN0_ clknet_4_7_0_clk _0599_ net1
+ VSS VSS VDD VDD refresh_counter\[7\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[8\]$_DFF_PN0_ clknet_4_7_0_clk _0600_ net1
+ VSS VSS VDD VDD refresh_counter\[8\] sky130_fd_sc_hd__dfrtp_1
Xrefresh_counter\[9\]$_DFF_PN0_ clknet_4_13_0_clk _0601_ net1
+ VSS VSS VDD VDD refresh_counter\[9\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[0\]$_DFF_PN0_ clknet_4_1_0_clk _0602_ net1 VSS VSS
+ VDD VDD timer\[0\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[10\]$_DFF_PN0_ clknet_4_4_0_clk _0603_ net1 VSS VSS
+ VDD VDD timer\[10\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[11\]$_DFF_PN0_ clknet_4_4_0_clk _0604_ net1 VSS VSS
+ VDD VDD timer\[11\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[12\]$_DFF_PN0_ clknet_4_5_0_clk _0605_ net1 VSS VSS
+ VDD VDD timer\[12\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[13\]$_DFF_PN0_ clknet_4_4_0_clk _0606_ net1 VSS VSS
+ VDD VDD timer\[13\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[14\]$_DFF_PN0_ clknet_4_5_0_clk _0607_ net1 VSS VSS
+ VDD VDD timer\[14\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[15\]$_DFF_PN0_ clknet_4_4_0_clk _0608_ net1 VSS VSS
+ VDD VDD timer\[15\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[1\]$_DFF_PN0_ clknet_4_1_0_clk _0609_ net1 VSS VSS
+ VDD VDD timer\[1\] sky130_fd_sc_hd__dfrtp_2
Xtimer\[2\]$_DFF_PN0_ clknet_4_1_0_clk _0610_ net1 VSS VSS
+ VDD VDD timer\[2\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[3\]$_DFF_PN0_ clknet_4_1_0_clk _0611_ net1 VSS VSS
+ VDD VDD timer\[3\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[4\]$_DFF_PN0_ clknet_4_6_0_clk _0612_ net1 VSS VSS
+ VDD VDD timer\[4\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[5\]$_DFF_PN0_ clknet_4_4_0_clk _0613_ net1 VSS VSS
+ VDD VDD timer\[5\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[6\]$_DFF_PN0_ clknet_4_6_0_clk _0614_ net1 VSS VSS
+ VDD VDD timer\[6\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[7\]$_DFF_PN0_ clknet_4_4_0_clk _0615_ net1 VSS VSS
+ VDD VDD timer\[7\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[8\]$_DFF_PN0_ clknet_4_4_0_clk _0616_ net1 VSS VSS
+ VDD VDD timer\[8\] sky130_fd_sc_hd__dfrtp_1
Xtimer\[9\]$_DFF_PN0_ clknet_4_4_0_clk _0617_ net1 VSS VSS
+ VDD VDD timer\[9\] sky130_fd_sc_hd__dfrtp_1
Xwr_ready_reg$_DFF_PN0_ clknet_4_0_0_clk _0670_ net1 VSS VSS
+ VDD VDD net201 sky130_fd_sc_hd__dfrtp_1
Xhold1 net36 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 cmd_addr[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 cmd_addr[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 cmd_addr[13] VSS VSS VDD VDD net4 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput4 cmd_addr[14] VSS VSS VDD VDD net5 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput5 cmd_addr[15] VSS VSS VDD VDD net6 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput6 cmd_addr[16] VSS VSS VDD VDD net7 sky130_fd_sc_hd__buf_2
Xinput7 cmd_addr[17] VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput8 cmd_addr[18] VSS VSS VDD VDD net9 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput9 cmd_addr[19] VSS VSS VDD VDD net10 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput10 cmd_addr[1] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 cmd_addr[20] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xinput12 cmd_addr[21] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xinput13 cmd_addr[22] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_2
Xinput14 cmd_addr[23] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 cmd_addr[24] VSS VSS VDD VDD net16 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput16 cmd_addr[25] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_2
Xinput17 cmd_addr[26] VSS VSS VDD VDD net18 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput18 cmd_addr[27] VSS VSS VDD VDD net19 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput19 cmd_addr[2] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput20 cmd_addr[3] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput21 cmd_addr[4] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput22 cmd_addr[5] VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput23 cmd_addr[6] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput24 cmd_addr[7] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput25 cmd_addr[8] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput26 cmd_addr[9] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput27 cmd_burst_len[0] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput28 cmd_burst_len[1] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput29 cmd_burst_len[2] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput30 cmd_burst_len[3] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput31 cmd_valid VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_2
Xinput32 cmd_write VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_2
Xinput33 phy_clk VSS VSS VDD VDD net34 sky130_fd_sc_hd__buf_12
Xinput34 rd_ready VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput35 net223 VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_4
Xinput36 wr_data[0] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput37 wr_data[10] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput38 wr_data[11] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput39 wr_data[12] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput40 wr_data[13] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput41 wr_data[14] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput42 wr_data[15] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput43 wr_data[16] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput44 wr_data[17] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput45 wr_data[18] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput46 wr_data[19] VSS VSS VDD VDD net47 sky130_fd_sc_hd__clkbuf_1
Xinput47 wr_data[1] VSS VSS VDD VDD net48 sky130_fd_sc_hd__clkbuf_1
Xinput48 wr_data[20] VSS VSS VDD VDD net49 sky130_fd_sc_hd__clkbuf_1
Xinput49 wr_data[21] VSS VSS VDD VDD net50 sky130_fd_sc_hd__clkbuf_1
Xinput50 wr_data[22] VSS VSS VDD VDD net51 sky130_fd_sc_hd__clkbuf_1
Xinput51 wr_data[23] VSS VSS VDD VDD net52 sky130_fd_sc_hd__clkbuf_1
Xinput52 wr_data[24] VSS VSS VDD VDD net53 sky130_fd_sc_hd__clkbuf_1
Xinput53 wr_data[25] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput54 wr_data[26] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput55 wr_data[27] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput56 wr_data[28] VSS VSS VDD VDD net57 sky130_fd_sc_hd__clkbuf_1
Xinput57 wr_data[29] VSS VSS VDD VDD net58 sky130_fd_sc_hd__clkbuf_1
Xinput58 wr_data[2] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput59 wr_data[30] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput60 wr_data[31] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput61 wr_data[32] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput62 wr_data[33] VSS VSS VDD VDD net63 sky130_fd_sc_hd__clkbuf_1
Xinput63 wr_data[34] VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput64 wr_data[35] VSS VSS VDD VDD net65 sky130_fd_sc_hd__clkbuf_1
Xinput65 wr_data[36] VSS VSS VDD VDD net66 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput66 wr_data[37] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_1
Xinput67 wr_data[38] VSS VSS VDD VDD net68 sky130_fd_sc_hd__clkbuf_1
Xinput68 wr_data[39] VSS VSS VDD VDD net69 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput69 wr_data[3] VSS VSS VDD VDD net70 sky130_fd_sc_hd__clkbuf_1
Xinput70 wr_data[40] VSS VSS VDD VDD net71 sky130_fd_sc_hd__clkbuf_1
Xinput71 wr_data[41] VSS VSS VDD VDD net72 sky130_fd_sc_hd__clkbuf_1
Xinput72 wr_data[42] VSS VSS VDD VDD net73 sky130_fd_sc_hd__clkbuf_1
Xinput73 wr_data[43] VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkbuf_1
Xinput74 wr_data[44] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_1
Xinput75 wr_data[45] VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkbuf_1
Xinput76 wr_data[46] VSS VSS VDD VDD net77 sky130_fd_sc_hd__clkbuf_1
Xinput77 wr_data[47] VSS VSS VDD VDD net78 sky130_fd_sc_hd__clkbuf_1
Xinput78 wr_data[48] VSS VSS VDD VDD net79 sky130_fd_sc_hd__clkbuf_1
Xinput79 wr_data[49] VSS VSS VDD VDD net80 sky130_fd_sc_hd__clkbuf_1
Xinput80 wr_data[4] VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkbuf_1
Xinput81 wr_data[50] VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkbuf_1
Xinput82 wr_data[51] VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkbuf_1
Xinput83 wr_data[52] VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkbuf_1
Xinput84 wr_data[53] VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkbuf_1
Xinput85 wr_data[54] VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkbuf_1
Xinput86 wr_data[55] VSS VSS VDD VDD net87 sky130_fd_sc_hd__clkbuf_1
Xinput87 wr_data[56] VSS VSS VDD VDD net88 sky130_fd_sc_hd__clkbuf_1
Xinput88 wr_data[57] VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkbuf_1
Xinput89 wr_data[58] VSS VSS VDD VDD net90 sky130_fd_sc_hd__clkbuf_1
Xinput90 wr_data[59] VSS VSS VDD VDD net91 sky130_fd_sc_hd__clkbuf_1
Xinput91 wr_data[5] VSS VSS VDD VDD net92 sky130_fd_sc_hd__clkbuf_1
Xinput92 wr_data[60] VSS VSS VDD VDD net93 sky130_fd_sc_hd__clkbuf_1
Xinput93 wr_data[61] VSS VSS VDD VDD net94 sky130_fd_sc_hd__clkbuf_1
Xinput94 wr_data[62] VSS VSS VDD VDD net95 sky130_fd_sc_hd__clkbuf_1
Xinput95 wr_data[63] VSS VSS VDD VDD net96 sky130_fd_sc_hd__clkbuf_1
Xinput96 wr_data[6] VSS VSS VDD VDD net97 sky130_fd_sc_hd__clkbuf_1
Xinput97 wr_data[7] VSS VSS VDD VDD net98 sky130_fd_sc_hd__clkbuf_1
Xinput98 wr_data[8] VSS VSS VDD VDD net99 sky130_fd_sc_hd__clkbuf_1
Xinput99 wr_data[9] VSS VSS VDD VDD net100 sky130_fd_sc_hd__clkbuf_1
Xinput100 wr_valid VSS VSS VDD VDD net101 sky130_fd_sc_hd__clkbuf_1
Xoutput101 net102 VSS VSS VDD VDD cmd_ready sky130_fd_sc_hd__clkbuf_1
Xoutput102 net103 VSS VSS VDD VDD init_done sky130_fd_sc_hd__clkbuf_1
Xoutput103 net104 VSS VSS VDD VDD phy_addr[0] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net105 VSS VSS VDD VDD phy_addr[10] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net106 VSS VSS VDD VDD phy_addr[11] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net107 VSS VSS VDD VDD phy_addr[12] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net108 VSS VSS VDD VDD phy_addr[13] sky130_fd_sc_hd__clkbuf_1
Xoutput108 net109 VSS VSS VDD VDD phy_addr[1] sky130_fd_sc_hd__clkbuf_1
Xoutput109 net110 VSS VSS VDD VDD phy_addr[2] sky130_fd_sc_hd__clkbuf_1
Xoutput110 net111 VSS VSS VDD VDD phy_addr[3] sky130_fd_sc_hd__clkbuf_1
Xoutput111 net112 VSS VSS VDD VDD phy_addr[4] sky130_fd_sc_hd__clkbuf_1
Xoutput112 net113 VSS VSS VDD VDD phy_addr[5] sky130_fd_sc_hd__clkbuf_1
Xoutput113 net114 VSS VSS VDD VDD phy_addr[6] sky130_fd_sc_hd__clkbuf_1
Xoutput114 net115 VSS VSS VDD VDD phy_addr[7] sky130_fd_sc_hd__clkbuf_1
Xoutput115 net116 VSS VSS VDD VDD phy_addr[8] sky130_fd_sc_hd__clkbuf_1
Xoutput116 net117 VSS VSS VDD VDD phy_addr[9] sky130_fd_sc_hd__clkbuf_1
Xoutput117 net118 VSS VSS VDD VDD phy_bank[0] sky130_fd_sc_hd__clkbuf_1
Xoutput118 net119 VSS VSS VDD VDD phy_bank[1] sky130_fd_sc_hd__clkbuf_1
Xoutput119 net120 VSS VSS VDD VDD phy_bank[2] sky130_fd_sc_hd__clkbuf_1
Xoutput120 net121 VSS VSS VDD VDD phy_cas_n sky130_fd_sc_hd__clkbuf_1
Xoutput121 net122 VSS VSS VDD VDD phy_cs_n sky130_fd_sc_hd__clkbuf_1
Xoutput122 net123 VSS VSS VDD VDD phy_dm[0] sky130_fd_sc_hd__clkbuf_1
Xoutput123 net124 VSS VSS VDD VDD phy_dm[1] sky130_fd_sc_hd__clkbuf_1
Xoutput124 net125 VSS VSS VDD VDD phy_dm[2] sky130_fd_sc_hd__clkbuf_1
Xoutput125 net126 VSS VSS VDD VDD phy_dm[3] sky130_fd_sc_hd__clkbuf_1
Xoutput126 net127 VSS VSS VDD VDD phy_dm[4] sky130_fd_sc_hd__clkbuf_1
Xoutput127 net128 VSS VSS VDD VDD phy_dm[5] sky130_fd_sc_hd__clkbuf_1
Xoutput128 net129 VSS VSS VDD VDD phy_dm[6] sky130_fd_sc_hd__clkbuf_1
Xoutput129 net130 VSS VSS VDD VDD phy_dm[7] sky130_fd_sc_hd__clkbuf_1
Xoutput130 net131 VSS VSS VDD VDD phy_ras_n sky130_fd_sc_hd__clkbuf_1
Xoutput131 net132 VSS VSS VDD VDD phy_reset_n sky130_fd_sc_hd__clkbuf_1
Xoutput132 net133 VSS VSS VDD VDD phy_we_n sky130_fd_sc_hd__clkbuf_1
Xoutput133 net134 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__clkbuf_1
Xoutput134 net135 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__clkbuf_1
Xoutput135 net136 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__clkbuf_1
Xoutput136 net137 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__clkbuf_1
Xoutput137 net138 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__clkbuf_1
Xoutput138 net139 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__clkbuf_1
Xoutput139 net140 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__clkbuf_1
Xoutput140 net141 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__clkbuf_1
Xoutput141 net142 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__clkbuf_1
Xoutput142 net143 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__clkbuf_1
Xoutput143 net144 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__clkbuf_1
Xoutput144 net145 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__clkbuf_1
Xoutput145 net146 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__clkbuf_1
Xoutput146 net147 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__clkbuf_1
Xoutput147 net148 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__clkbuf_1
Xoutput148 net149 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__clkbuf_1
Xoutput149 net150 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__clkbuf_1
Xoutput150 net151 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__clkbuf_1
Xoutput151 net152 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__clkbuf_1
Xoutput152 net153 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__clkbuf_1
Xoutput153 net154 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__clkbuf_1
Xoutput154 net155 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__clkbuf_1
Xoutput155 net156 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__clkbuf_1
Xoutput156 net157 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__clkbuf_1
Xoutput157 net158 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__clkbuf_1
Xoutput158 net159 VSS VSS VDD VDD rd_data[32] sky130_fd_sc_hd__clkbuf_1
Xoutput159 net160 VSS VSS VDD VDD rd_data[33] sky130_fd_sc_hd__clkbuf_1
Xoutput160 net161 VSS VSS VDD VDD rd_data[34] sky130_fd_sc_hd__clkbuf_1
Xoutput161 net162 VSS VSS VDD VDD rd_data[35] sky130_fd_sc_hd__clkbuf_1
Xoutput162 net163 VSS VSS VDD VDD rd_data[36] sky130_fd_sc_hd__clkbuf_1
Xoutput163 net164 VSS VSS VDD VDD rd_data[37] sky130_fd_sc_hd__clkbuf_1
Xoutput164 net165 VSS VSS VDD VDD rd_data[38] sky130_fd_sc_hd__clkbuf_1
Xoutput165 net166 VSS VSS VDD VDD rd_data[39] sky130_fd_sc_hd__clkbuf_1
Xoutput166 net167 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__clkbuf_1
Xoutput167 net168 VSS VSS VDD VDD rd_data[40] sky130_fd_sc_hd__clkbuf_1
Xoutput168 net169 VSS VSS VDD VDD rd_data[41] sky130_fd_sc_hd__clkbuf_1
Xoutput169 net170 VSS VSS VDD VDD rd_data[42] sky130_fd_sc_hd__clkbuf_1
Xoutput170 net171 VSS VSS VDD VDD rd_data[43] sky130_fd_sc_hd__clkbuf_1
Xoutput171 net172 VSS VSS VDD VDD rd_data[44] sky130_fd_sc_hd__clkbuf_1
Xoutput172 net173 VSS VSS VDD VDD rd_data[45] sky130_fd_sc_hd__clkbuf_1
Xoutput173 net174 VSS VSS VDD VDD rd_data[46] sky130_fd_sc_hd__clkbuf_1
Xoutput174 net175 VSS VSS VDD VDD rd_data[47] sky130_fd_sc_hd__clkbuf_1
Xoutput175 net176 VSS VSS VDD VDD rd_data[48] sky130_fd_sc_hd__clkbuf_1
Xoutput176 net177 VSS VSS VDD VDD rd_data[49] sky130_fd_sc_hd__clkbuf_1
Xoutput177 net178 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__clkbuf_1
Xoutput178 net179 VSS VSS VDD VDD rd_data[50] sky130_fd_sc_hd__clkbuf_1
Xoutput179 net180 VSS VSS VDD VDD rd_data[51] sky130_fd_sc_hd__clkbuf_1
Xoutput180 net181 VSS VSS VDD VDD rd_data[52] sky130_fd_sc_hd__clkbuf_1
Xoutput181 net182 VSS VSS VDD VDD rd_data[53] sky130_fd_sc_hd__clkbuf_1
Xoutput182 net183 VSS VSS VDD VDD rd_data[54] sky130_fd_sc_hd__clkbuf_1
Xoutput183 net184 VSS VSS VDD VDD rd_data[55] sky130_fd_sc_hd__clkbuf_1
Xoutput184 net185 VSS VSS VDD VDD rd_data[56] sky130_fd_sc_hd__clkbuf_1
Xoutput185 net186 VSS VSS VDD VDD rd_data[57] sky130_fd_sc_hd__clkbuf_1
Xoutput186 net187 VSS VSS VDD VDD rd_data[58] sky130_fd_sc_hd__clkbuf_1
Xoutput187 net188 VSS VSS VDD VDD rd_data[59] sky130_fd_sc_hd__clkbuf_1
Xoutput188 net189 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__clkbuf_1
Xoutput189 net190 VSS VSS VDD VDD rd_data[60] sky130_fd_sc_hd__clkbuf_1
Xoutput190 net191 VSS VSS VDD VDD rd_data[61] sky130_fd_sc_hd__clkbuf_1
Xoutput191 net192 VSS VSS VDD VDD rd_data[62] sky130_fd_sc_hd__clkbuf_1
Xoutput192 net193 VSS VSS VDD VDD rd_data[63] sky130_fd_sc_hd__clkbuf_1
Xoutput193 net194 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__clkbuf_1
Xoutput194 net195 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__clkbuf_1
Xoutput195 net196 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__clkbuf_1
Xoutput196 net197 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__clkbuf_1
Xoutput197 net198 VSS VSS VDD VDD rd_valid sky130_fd_sc_hd__clkbuf_1
Xoutput198 net199 VSS VSS VDD VDD state[0] sky130_fd_sc_hd__clkbuf_1
Xoutput199 net200 VSS VSS VDD VDD state[1] sky130_fd_sc_hd__clkbuf_1
Xoutput200 net201 VSS VSS VDD VDD wr_ready sky130_fd_sc_hd__clkbuf_1
X_1326__201 VSS VSS VDD VDD _unconnected_1 net202 sky130_fd_sc_hd__conb_1
X_1327__202 VSS VSS VDD VDD _unconnected_2 net203 sky130_fd_sc_hd__conb_1
X_1401__203 VSS VSS VDD VDD _unconnected_3 net204 sky130_fd_sc_hd__conb_1
X_1402__204 VSS VSS VDD VDD _unconnected_4 net205 sky130_fd_sc_hd__conb_1
X_1403__205 VSS VSS VDD VDD _unconnected_5 net206 sky130_fd_sc_hd__conb_1
X_1404__206 VSS VSS VDD VDD _unconnected_6 net207 sky130_fd_sc_hd__conb_1
X_1405__207 VSS VSS VDD VDD _unconnected_7 net208 sky130_fd_sc_hd__conb_1
X_1406__208 VSS VSS VDD VDD _unconnected_8 net209 sky130_fd_sc_hd__conb_1
X_1407__209 VSS VSS VDD VDD _unconnected_9 net210 sky130_fd_sc_hd__conb_1
X_1408__210 VSS VSS VDD VDD _unconnected_10 net211 sky130_fd_sc_hd__conb_1
X_1409__212 VSS VSS VDD VDD net213 _unconnected_11 sky130_fd_sc_hd__conb_1
X_1410__213 VSS VSS VDD VDD net214 _unconnected_12 sky130_fd_sc_hd__conb_1
X_1411__214 VSS VSS VDD VDD net215 _unconnected_13 sky130_fd_sc_hd__conb_1
X_1412__215 VSS VSS VDD VDD net216 _unconnected_14 sky130_fd_sc_hd__conb_1
X_1413__216 VSS VSS VDD VDD net217 _unconnected_15 sky130_fd_sc_hd__conb_1
X_1414__217 VSS VSS VDD VDD net218 _unconnected_16 sky130_fd_sc_hd__conb_1
X_1415__218 VSS VSS VDD VDD net219 _unconnected_17 sky130_fd_sc_hd__conb_1
X_1416__219 VSS VSS VDD VDD net220 _unconnected_18 sky130_fd_sc_hd__conb_1
X_1417__220 VSS VSS VDD VDD net221 _unconnected_19 sky130_fd_sc_hd__conb_1
Xcmd_reg_valid$_DFF_PN0__221 VSS VSS VDD VDD net222 _unconnected_20
+ sky130_fd_sc_hd__conb_1
Xclkbuf_4_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_4_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_5_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_6_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_7_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_8_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_9_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_10_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_11_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_12_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_13_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_14_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_15_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_4_0_0_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload1 clknet_4_1_0_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__inv_8
Xclkload2 clknet_4_2_0_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__clkinv_4
Xclkload3 clknet_4_3_0_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__clkinv_8
Xclkload4 clknet_4_4_0_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkinv_4
Xclkload5 clknet_4_5_0_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_1
Xclkload6 clknet_4_6_0_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkinv_4
Xclkload7 clknet_4_7_0_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__inv_6
Xclkload8 clknet_4_8_0_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkinv_2
Xclkload9 clknet_4_9_0_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__bufinv_16
Xclkload10 clknet_4_11_0_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__bufinv_16
Xclkload11 clknet_4_12_0_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__inv_6
Xclkload12 clknet_4_13_0_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__bufinv_16
Xclkload13 clknet_4_14_0_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__bufinv_16
Xclkload14 clknet_4_15_0_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkinv_2
Xhold2 rst_n VSS VSS VDD VDD net223 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS ddr_controller
