* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT shift_register_left clk en load parallel_in[0] parallel_in[1]
+ parallel_in[2] parallel_in[3] parallel_in[4] parallel_in[5]
+ parallel_in[6] parallel_in[7] parallel_out[0] parallel_out[1]
+ parallel_out[2] parallel_out[3] parallel_out[4] parallel_out[5]
+ parallel_out[6] parallel_out[7] rst_n serial_in serial_out
X_26_ net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_6
X_27_ en VSS VSS VDD VDD _09_ sky130_fd_sc_hd__buf_6
X_28_ net12 net11 _09_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2i_1
X_29_ _08_ net3 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nand2_1
X_30_ _08_ _10_ _11_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_31_ net13 net12 _09_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__mux2i_1
X_32_ _08_ net4 VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nand2_1
X_33_ _08_ _12_ _13_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_34_ net14 net13 _09_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__mux2i_1
X_35_ _08_ net5 VSS VSS VDD VDD _15_ sky130_fd_sc_hd__nand2_1
X_36_ net2 _14_ _15_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_37_ net15 net14 _09_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__mux2i_1
X_38_ _08_ net6 VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_39_ net2 _16_ _17_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__o21ai_0
X_40_ net16 net15 _09_ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__mux2i_1
X_41_ _08_ net7 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__nand2_1
X_42_ net2 _18_ _19_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21ai_0
X_43_ net17 net16 _09_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__mux2i_1
X_44_ _08_ net8 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nand2_1
X_45_ net2 _20_ _21_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__o21ai_0
X_46_ net18 net17 _09_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__mux2i_1
X_47_ _08_ net9 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand2_1
X_48_ net2 _22_ _23_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__o21ai_0
X_49_ net20 net18 _09_ VSS VSS VDD VDD _24_ sky130_fd_sc_hd__mux2i_1
X_50_ _08_ net10 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nand2_1
X_51_ net2 _24_ _25_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21ai_0
X_52_ net20 VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xparallel_out\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xhold1 net21 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 load VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 parallel_in[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 parallel_in[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 parallel_in[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 parallel_in[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 parallel_in[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 parallel_in[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 parallel_in[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 parallel_in[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 serial_in VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD serial_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net21 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS shift_register_left
