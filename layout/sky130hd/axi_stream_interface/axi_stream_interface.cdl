* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT axi_stream_interface clk m_tdata[0] m_tdata[10] m_tdata[11]
+ m_tdata[12] m_tdata[13] m_tdata[14] m_tdata[15] m_tdata[16]
+ m_tdata[17] m_tdata[18] m_tdata[19] m_tdata[1] m_tdata[20]
+ m_tdata[21] m_tdata[22] m_tdata[23] m_tdata[24] m_tdata[25]
+ m_tdata[26] m_tdata[27] m_tdata[28] m_tdata[29] m_tdata[2]
+ m_tdata[30] m_tdata[31] m_tdata[3] m_tdata[4] m_tdata[5] m_tdata[6]
+ m_tdata[7] m_tdata[8] m_tdata[9] m_tdest m_tid m_tkeep[0]
+ m_tkeep[1] m_tkeep[2] m_tkeep[3] m_tlast m_tready m_tstrb[0]
+ m_tstrb[1] m_tstrb[2] m_tstrb[3] m_tuser m_tvalid rst_n s_tdata[0]
+ s_tdata[10] s_tdata[11] s_tdata[12] s_tdata[13] s_tdata[14]
+ s_tdata[15] s_tdata[16] s_tdata[17] s_tdata[18] s_tdata[19]
+ s_tdata[1] s_tdata[20] s_tdata[21] s_tdata[22] s_tdata[23]
+ s_tdata[24] s_tdata[25] s_tdata[26] s_tdata[27] s_tdata[28]
+ s_tdata[29] s_tdata[2] s_tdata[30] s_tdata[31] s_tdata[3]
+ s_tdata[4] s_tdata[5] s_tdata[6] s_tdata[7] s_tdata[8] s_tdata[9]
+ s_tdest s_tid s_tkeep[0] s_tkeep[1] s_tkeep[2] s_tkeep[3]
+ s_tlast s_tready s_tstrb[0] s_tstrb[1] s_tstrb[2] s_tstrb[3]
+ s_tuser s_tvalid
X_00_ s_tdata[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
X_01_ s_tdata[1] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
X_02_ s_tdata[2] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
X_03_ s_tdata[3] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
X_04_ s_tdata[4] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
X_05_ s_tdata[5] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
X_06_ s_tdata[6] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
X_07_ s_tdata[7] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
X_08_ s_tdata[8] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
X_09_ s_tdata[9] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
X_10_ s_tdata[10] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
X_11_ s_tdata[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
X_12_ s_tdata[12] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
X_13_ s_tdata[13] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
X_14_ s_tdata[14] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
X_15_ s_tdata[15] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
X_16_ s_tdata[16] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
X_17_ s_tdata[17] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
X_18_ s_tdata[18] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
X_19_ s_tdata[19] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
X_20_ s_tdata[20] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
X_21_ s_tdata[21] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
X_22_ s_tdata[22] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
X_23_ s_tdata[23] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
X_24_ s_tdata[24] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
X_25_ s_tdata[25] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
X_26_ s_tdata[26] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
X_27_ s_tdata[27] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
X_28_ s_tdata[28] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
X_29_ s_tdata[29] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
X_30_ s_tdata[30] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
X_31_ s_tdata[31] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
X_32_ s_tdest VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
X_33_ s_tid VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
X_34_ s_tkeep[0] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
X_35_ s_tkeep[1] VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_1
X_36_ s_tkeep[2] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
X_37_ s_tkeep[3] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
X_38_ s_tlast VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
X_39_ s_tstrb[0] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
X_40_ s_tstrb[1] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
X_41_ s_tstrb[2] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
X_42_ s_tstrb[3] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
X_43_ s_tuser VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
X_44_ s_tvalid VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
X_45_ m_tready VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput1 net1 VSS VSS VDD VDD m_tdata[0] sky130_fd_sc_hd__clkbuf_1
Xoutput2 net2 VSS VSS VDD VDD m_tdata[10] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net3 VSS VSS VDD VDD m_tdata[11] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net4 VSS VSS VDD VDD m_tdata[12] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net5 VSS VSS VDD VDD m_tdata[13] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net6 VSS VSS VDD VDD m_tdata[14] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net7 VSS VSS VDD VDD m_tdata[15] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net8 VSS VSS VDD VDD m_tdata[16] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net9 VSS VSS VDD VDD m_tdata[17] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net10 VSS VSS VDD VDD m_tdata[18] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net11 VSS VSS VDD VDD m_tdata[19] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net12 VSS VSS VDD VDD m_tdata[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net13 VSS VSS VDD VDD m_tdata[20] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net14 VSS VSS VDD VDD m_tdata[21] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net15 VSS VSS VDD VDD m_tdata[22] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net16 VSS VSS VDD VDD m_tdata[23] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net17 VSS VSS VDD VDD m_tdata[24] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net18 VSS VSS VDD VDD m_tdata[25] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net19 VSS VSS VDD VDD m_tdata[26] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net20 VSS VSS VDD VDD m_tdata[27] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net21 VSS VSS VDD VDD m_tdata[28] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net22 VSS VSS VDD VDD m_tdata[29] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net23 VSS VSS VDD VDD m_tdata[2] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net24 VSS VSS VDD VDD m_tdata[30] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net25 VSS VSS VDD VDD m_tdata[31] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net26 VSS VSS VDD VDD m_tdata[3] sky130_fd_sc_hd__clkbuf_1
Xoutput27 net27 VSS VSS VDD VDD m_tdata[4] sky130_fd_sc_hd__clkbuf_1
Xoutput28 net28 VSS VSS VDD VDD m_tdata[5] sky130_fd_sc_hd__clkbuf_1
Xoutput29 net29 VSS VSS VDD VDD m_tdata[6] sky130_fd_sc_hd__clkbuf_1
Xoutput30 net30 VSS VSS VDD VDD m_tdata[7] sky130_fd_sc_hd__clkbuf_1
Xoutput31 net31 VSS VSS VDD VDD m_tdata[8] sky130_fd_sc_hd__clkbuf_1
Xoutput32 net32 VSS VSS VDD VDD m_tdata[9] sky130_fd_sc_hd__clkbuf_1
Xoutput33 net33 VSS VSS VDD VDD m_tdest sky130_fd_sc_hd__clkbuf_1
Xoutput34 net34 VSS VSS VDD VDD m_tid sky130_fd_sc_hd__clkbuf_1
Xoutput35 net35 VSS VSS VDD VDD m_tkeep[0] sky130_fd_sc_hd__clkbuf_1
Xoutput36 net36 VSS VSS VDD VDD m_tkeep[1] sky130_fd_sc_hd__clkbuf_1
Xoutput37 net37 VSS VSS VDD VDD m_tkeep[2] sky130_fd_sc_hd__clkbuf_1
Xoutput38 net38 VSS VSS VDD VDD m_tkeep[3] sky130_fd_sc_hd__clkbuf_1
Xoutput39 net39 VSS VSS VDD VDD m_tlast sky130_fd_sc_hd__clkbuf_1
Xoutput40 net40 VSS VSS VDD VDD m_tstrb[0] sky130_fd_sc_hd__clkbuf_1
Xoutput41 net41 VSS VSS VDD VDD m_tstrb[1] sky130_fd_sc_hd__clkbuf_1
Xoutput42 net42 VSS VSS VDD VDD m_tstrb[2] sky130_fd_sc_hd__clkbuf_1
Xoutput43 net43 VSS VSS VDD VDD m_tstrb[3] sky130_fd_sc_hd__clkbuf_1
Xoutput44 net44 VSS VSS VDD VDD m_tuser sky130_fd_sc_hd__clkbuf_1
Xoutput45 net45 VSS VSS VDD VDD m_tvalid sky130_fd_sc_hd__clkbuf_1
Xoutput46 net46 VSS VSS VDD VDD s_tready sky130_fd_sc_hd__clkbuf_1
.ENDS axi_stream_interface
