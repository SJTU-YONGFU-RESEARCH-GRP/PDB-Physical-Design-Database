* cell network_interface_cdc
* pin mem_rdata[17]
* pin router_out_data[15]
* pin mem_rdata[15]
* pin router_out_data[13]
* pin router_out_data[12]
* pin mem_rdata[12]
* pin router_out_data[10]
* pin router_out_data[16]
* pin mem_rdata[10]
* pin mem_rdata[16]
* pin router_out_data[14]
* pin mem_rdata[14]
* pin router_out_data[9]
* pin mem_rdata[9]
* pin router_out_data[8]
* pin router_out_data[7]
* pin mem_rdata[8]
* pin router_in_ready
* pin router_in_valid
* pin mem_rdata[7]
* pin router_out_ready
* pin router_out_valid
* pin router_out_data[5]
* pin mem_rdata[5]
* pin router_out_data[27]
* pin router_out_data[30]
* pin mem_rdata[27]
* pin mem_rdata[30]
* pin router_out_data[6]
* pin mem_rdata[6]
* pin router_out_data[28]
* pin mem_rdata[13]
* pin src_rst_n
* pin mem_rdata[28]
* pin router_out_data[17]
* pin dst_rst_n
* pin mem_rdata[29]
* pin router_out_data[0]
* pin mem_rdata[0]
* pin mem_rdata[31]
* pin router_out_data[29]
* pin router_out_data[31]
* pin mem_rdata[11]
* pin router_out_data[11]
* pin mem_rdata[3]
* pin router_out_data[3]
* pin mem_rdata[2]
* pin router_out_data[2]
* pin router_in_data[0]
* pin mem_rdata[4]
* pin router_out_data[4]
* pin mem_wdata[0]
* pin mem_ready
* pin mem_addr[0]
* pin router_in_data[10]
* pin mem_rdata[25]
* pin router_in_data[12]
* pin router_out_data[25]
* pin mem_rdata[19]
* pin mem_wdata[10]
* pin router_out_data[24]
* pin mem_rdata[24]
* pin mem_wdata[12]
* pin mem_addr[10]
* pin router_out_data[19]
* pin mem_addr[12]
* pin mem_rdata[21]
* pin mem_addr[13]
* pin router_out_data[21]
* pin router_in_data[11]
* pin mem_wdata[11]
* pin mem_rdata[18]
* pin router_in_data[13]
* pin mem_wdata[13]
* pin router_out_data[18]
* pin mem_rdata[26]
* pin mem_addr[11]
* pin mem_read
* pin mem_rdata[23]
* pin router_out_data[26]
* pin mem_write
* pin router_out_data[23]
* pin mem_addr[20]
* pin router_in_data[8]
* pin router_in_data[14]
* pin mem_rdata[1]
* pin mem_wdata[20]
* pin mem_wdata[14]
* pin router_out_data[22]
* pin mem_rdata[22]
* pin router_in_data[16]
* pin router_out_data[1]
* pin mem_wdata[16]
* pin router_out_data[20]
* pin mem_addr[16]
* pin mem_addr[15]
* pin mem_rdata[20]
* pin router_in_data[15]
* pin mem_addr[14]
* pin mem_wdata[15]
* pin mem_wdata[4]
* pin router_in_data[17]
* pin mem_wdata[17]
* pin router_in_data[6]
* pin router_in_data[4]
* pin mem_addr[17]
* pin mem_wdata[18]
* pin mem_wdata[6]
* pin router_in_data[18]
* pin mem_addr[18]
* pin router_in_data[31]
* pin msg_type[0]
* pin mem_wdata[21]
* pin router_in_data[21]
* pin mem_addr[1]
* pin dest_id[0]
* pin mem_addr[4]
* pin dest_id[7]
* pin dest_id[1]
* pin mem_wdata[25]
* pin mem_addr[9]
* pin msg_type[2]
* pin router_in_data[19]
* pin dest_id[2]
* pin mem_addr[6]
* pin router_in_data[5]
* pin router_in_data[25]
* pin router_in_data[20]
* pin src_clk
* pin dst_clk
* pin dest_id[5]
* pin mem_addr[2]
* pin router_in_data[2]
* pin mem_wdata[2]
* pin router_in_data[22]
* pin mem_wdata[23]
* pin mem_wdata[19]
* pin mem_wdata[26]
* pin mem_addr[7]
* pin mem_wdata[27]
* pin mem_wdata[30]
* pin mem_addr[3]
* pin mem_wdata[31]
* pin router_in_data[9]
* pin router_in_data[23]
* pin mem_wdata[1]
* pin router_in_data[1]
* pin msg_type[1]
* pin mem_addr[19]
* pin mem_wdata[22]
* pin mem_wdata[9]
* pin mem_wdata[24]
* pin router_in_data[24]
* pin router_in_data[26]
* pin dest_id[3]
* pin mem_addr[8]
* pin dest_id[4]
* pin mem_wdata[8]
* pin mem_wdata[28]
* pin mem_wdata[7]
* pin dest_id[6]
* pin router_in_data[27]
* pin router_in_data[28]
* pin router_in_data[7]
* pin mem_addr[5]
* pin mem_wdata[5]
* pin router_in_data[30]
* pin mem_wdata[3]
* pin router_in_data[3]
* pin mem_wdata[29]
* pin router_in_data[29]
.SUBCKT network_interface_cdc 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19
+ 20 21 22 23 24 25 26 27 28 29 30 31 34 77 86 93 98 126 128 129 132 133 141
+ 164 165 170 176 195 196 199 205 206 218 219 222 229 237 244 248 258 266 271
+ 272 283 284 291 298 302 306 309 313 314 319 328 329 332 333 339 340 342 343
+ 347 350 355 359 364 368 370 371 377 378 386 388 396 401 404 405 407 418 435
+ 436 439 445 446 451 452 461 462 465 475 490 495 504 505 513 532 534 538 546
+ 549 551 555 557 560 561 563 567 573 574 575 576 580 581 582 587 603 614 615
+ 617 618 619 620 621 622 636 637 638 639 640 641 642 644 645 647 648 649 650
+ 651 653 654 655 656 657 658 659 660 661 662 663 665 666 667
* net 1 mem_rdata[17]
* net 2 router_out_data[15]
* net 3 mem_rdata[15]
* net 4 router_out_data[13]
* net 5 router_out_data[12]
* net 6 mem_rdata[12]
* net 7 router_out_data[10]
* net 8 router_out_data[16]
* net 9 mem_rdata[10]
* net 10 mem_rdata[16]
* net 11 router_out_data[14]
* net 12 mem_rdata[14]
* net 13 router_out_data[9]
* net 14 mem_rdata[9]
* net 15 router_out_data[8]
* net 16 router_out_data[7]
* net 17 mem_rdata[8]
* net 18 router_in_ready
* net 19 router_in_valid
* net 20 mem_rdata[7]
* net 21 router_out_ready
* net 22 router_out_valid
* net 23 router_out_data[5]
* net 24 mem_rdata[5]
* net 25 router_out_data[27]
* net 26 router_out_data[30]
* net 27 mem_rdata[27]
* net 28 mem_rdata[30]
* net 29 router_out_data[6]
* net 30 mem_rdata[6]
* net 31 router_out_data[28]
* net 34 mem_rdata[13]
* net 77 src_rst_n
* net 86 mem_rdata[28]
* net 93 router_out_data[17]
* net 98 dst_rst_n
* net 126 mem_rdata[29]
* net 128 router_out_data[0]
* net 129 mem_rdata[0]
* net 132 mem_rdata[31]
* net 133 router_out_data[29]
* net 141 router_out_data[31]
* net 164 mem_rdata[11]
* net 165 router_out_data[11]
* net 170 mem_rdata[3]
* net 176 router_out_data[3]
* net 195 mem_rdata[2]
* net 196 router_out_data[2]
* net 199 router_in_data[0]
* net 205 mem_rdata[4]
* net 206 router_out_data[4]
* net 218 mem_wdata[0]
* net 219 mem_ready
* net 222 mem_addr[0]
* net 229 router_in_data[10]
* net 237 mem_rdata[25]
* net 244 router_in_data[12]
* net 248 router_out_data[25]
* net 258 mem_rdata[19]
* net 266 mem_wdata[10]
* net 271 router_out_data[24]
* net 272 mem_rdata[24]
* net 283 mem_wdata[12]
* net 284 mem_addr[10]
* net 291 router_out_data[19]
* net 298 mem_addr[12]
* net 302 mem_rdata[21]
* net 306 mem_addr[13]
* net 309 router_out_data[21]
* net 313 router_in_data[11]
* net 314 mem_wdata[11]
* net 319 mem_rdata[18]
* net 328 router_in_data[13]
* net 329 mem_wdata[13]
* net 332 router_out_data[18]
* net 333 mem_rdata[26]
* net 339 mem_addr[11]
* net 340 mem_read
* net 342 mem_rdata[23]
* net 343 router_out_data[26]
* net 347 mem_write
* net 350 router_out_data[23]
* net 355 mem_addr[20]
* net 359 router_in_data[8]
* net 364 router_in_data[14]
* net 368 mem_rdata[1]
* net 370 mem_wdata[20]
* net 371 mem_wdata[14]
* net 377 router_out_data[22]
* net 378 mem_rdata[22]
* net 386 router_in_data[16]
* net 388 router_out_data[1]
* net 396 mem_wdata[16]
* net 401 router_out_data[20]
* net 404 mem_addr[16]
* net 405 mem_addr[15]
* net 407 mem_rdata[20]
* net 418 router_in_data[15]
* net 435 mem_addr[14]
* net 436 mem_wdata[15]
* net 439 mem_wdata[4]
* net 445 router_in_data[17]
* net 446 mem_wdata[17]
* net 451 router_in_data[6]
* net 452 router_in_data[4]
* net 461 mem_addr[17]
* net 462 mem_wdata[18]
* net 465 mem_wdata[6]
* net 475 router_in_data[18]
* net 490 mem_addr[18]
* net 495 router_in_data[31]
* net 504 msg_type[0]
* net 505 mem_wdata[21]
* net 513 router_in_data[21]
* net 532 mem_addr[1]
* net 534 dest_id[0]
* net 538 mem_addr[4]
* net 546 dest_id[7]
* net 549 dest_id[1]
* net 551 mem_wdata[25]
* net 555 mem_addr[9]
* net 557 msg_type[2]
* net 560 router_in_data[19]
* net 561 dest_id[2]
* net 563 mem_addr[6]
* net 567 router_in_data[5]
* net 573 router_in_data[25]
* net 574 router_in_data[20]
* net 575 src_clk
* net 576 dst_clk
* net 580 dest_id[5]
* net 581 mem_addr[2]
* net 582 router_in_data[2]
* net 587 mem_wdata[2]
* net 603 router_in_data[22]
* net 614 mem_wdata[23]
* net 615 mem_wdata[19]
* net 617 mem_wdata[26]
* net 618 mem_addr[7]
* net 619 mem_wdata[27]
* net 620 mem_wdata[30]
* net 621 mem_addr[3]
* net 622 mem_wdata[31]
* net 636 router_in_data[9]
* net 637 router_in_data[23]
* net 638 mem_wdata[1]
* net 639 router_in_data[1]
* net 640 msg_type[1]
* net 641 mem_addr[19]
* net 642 mem_wdata[22]
* net 644 mem_wdata[9]
* net 645 mem_wdata[24]
* net 647 router_in_data[24]
* net 648 router_in_data[26]
* net 649 dest_id[3]
* net 650 mem_addr[8]
* net 651 dest_id[4]
* net 653 mem_wdata[8]
* net 654 mem_wdata[28]
* net 655 mem_wdata[7]
* net 656 dest_id[6]
* net 657 router_in_data[27]
* net 658 router_in_data[28]
* net 659 router_in_data[7]
* net 660 mem_addr[5]
* net 661 mem_wdata[5]
* net 662 router_in_data[30]
* net 663 mem_wdata[3]
* net 665 router_in_data[3]
* net 666 mem_wdata[29]
* net 667 router_in_data[29]
* cell instance $3 r0 *1 12.88,2.72
X$3 57 39 1 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $7 r0 *1 15.64,2.72
X$7 57 2 58 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $11 r0 *1 18.86,2.72
X$11 57 44 3 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $14 r0 *1 25.76,2.72
X$14 57 4 33 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $17 r0 *1 24.38,2.72
X$17 57 5 61 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $20 r0 *1 29.44,2.72
X$20 57 47 6 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $23 r0 *1 31.28,2.72
X$23 57 7 64 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $26 r0 *1 36.8,2.72
X$26 57 8 66 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $29 r0 *1 38.18,2.72
X$29 57 110 9 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $32 r0 *1 39.56,2.72
X$32 57 35 10 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $35 r0 *1 45.08,2.72
X$35 57 11 71 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $37 r0 *1 47.84,2.72
X$37 57 51 12 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $41 r0 *1 53.36,2.72
X$41 57 13 73 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $44 r0 *1 51.98,2.72
X$44 57 52 14 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $47 r0 *1 54.74,2.72
X$47 57 15 72 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $49 r0 *1 58.88,2.72
X$49 57 16 69 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $53 r0 *1 60.26,2.72
X$53 57 50 17 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $56 r0 *1 61.64,2.72
X$56 57 18 68 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $59 r0 *1 63.02,2.72
X$59 57 49 19 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $62 r0 *1 64.4,2.72
X$62 57 112 20 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $65 r0 *1 65.78,2.72
X$65 57 48 21 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $68 r0 *1 67.16,2.72
X$68 57 22 67 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $71 r0 *1 69,2.72
X$71 57 23 36 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $73 r0 *1 70.84,2.72
X$73 57 83 24 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $77 r0 *1 77.74,2.72
X$77 57 25 63 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $80 r0 *1 76.36,2.72
X$80 57 26 154 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $83 r0 *1 80.5,2.72
X$83 57 84 27 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $86 r0 *1 79.12,2.72
X$86 57 113 28 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $89 m0 *1 84.64,8.16
X$89 57 29 90 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $91 r0 *1 87.4,8.16
X$91 57 85 30 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $95 r0 *1 102.58,2.72
X$95 57 31 37 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $189 m0 *1 57.04,8.16
X$189 38 42 50 32 75 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $192 m0 *1 86.48,8.16
X$192 38 42 85 32 79 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $194 m0 *1 96.14,62.56
X$194 38 42 376 32 360 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $196 r0 *1 88.78,8.16
X$196 38 42 56 32 59 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $198 r0 *1 86.48,62.56
X$198 38 42 375 32 382 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $201 m0 *1 64.4,84.32
X$201 38 42 494 32 480 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $203 r0 *1 73.6,89.76
X$203 38 42 518 32 554 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $205 r0 *1 72.68,8.16
X$205 38 42 84 32 106 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $207 r0 *1 53.36,95.2
X$207 38 42 594 32 592 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $209 m0 *1 65.32,100.64
X$209 38 42 593 32 610 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $212 m0 *1 95.68,24.48
X$212 38 42 144 32 145 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $214 r0 *1 60.26,78.88
X$214 38 42 429 32 472 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $216 m0 *1 93.38,19.04
X$216 38 42 125 32 138 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $218 m0 *1 57.04,89.76
X$218 38 42 528 32 529 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $220 r0 *1 77.28,57.12
X$220 38 42 352 32 345 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $222 r0 *1 88.78,73.44
X$222 38 42 441 32 412 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $224 r0 *1 61.18,8.16
X$224 38 42 83 32 108 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $226 m0 *1 84.64,78.88
X$226 38 42 442 32 457 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $228 r0 *1 82.8,19.04
X$228 38 42 131 32 140 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $230 m0 *1 84.64,100.64
X$230 38 42 598 32 601 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $232 m0 *1 57.04,73.44
X$232 38 42 392 32 431 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $234 r0 *1 87.4,78.88
X$234 38 42 467 32 486 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $236 r0 *1 88.78,89.76
X$236 38 42 519 32 543 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $238 r0 *1 88.78,95.2
X$238 38 42 564 32 628 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $240 m0 *1 11.96,13.6
X$240 38 42 44 32 101 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $242 r0 *1 3.68,2.72
X$242 38 42 39 32 78 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $244 m0 *1 45.54,57.12
X$244 38 42 331 32 327 57 57 38 sky130_fd_sc_hd__dfrtp_2
* cell instance $246 r0 *1 43.24,62.56
X$246 38 42 349 32 357 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $249 m0 *1 29.44,68
X$249 38 42 394 32 395 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $252 r0 *1 78.66,40.8
X$252 38 42 246 32 249 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $254 r0 *1 49.22,46.24
X$254 38 42 282 32 295 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $256 m0 *1 72.68,51.68
X$256 38 42 301 32 300 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $259 r0 *1 20.24,8.16
X$259 38 42 46 32 102 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $261 m0 *1 17.02,57.12
X$261 38 42 338 32 336 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $263 r0 *1 5.98,62.56
X$263 38 42 372 32 390 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $265 m0 *1 44.62,73.44
X$265 38 42 423 32 434 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $267 r0 *1 4.6,51.68
X$267 38 42 316 32 322 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $269 m0 *1 88.78,40.8
X$269 38 42 228 32 227 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $271 r0 *1 83.26,35.36
X$271 38 42 211 32 212 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $273 m0 *1 19.78,51.68
X$273 38 42 292 32 277 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $275 r0 *1 22.54,35.36
X$275 38 42 204 32 216 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $277 r0 *1 88.78,51.68
X$277 38 42 318 32 324 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $279 r0 *1 5.98,35.36
X$279 38 42 221 32 220 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $281 m0 *1 9.2,46.24
X$281 38 42 275 32 274 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $283 m0 *1 12.88,40.8
X$283 38 42 215 32 240 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $285 r0 *1 29.44,51.68
X$285 38 42 317 32 294 57 57 38 sky130_fd_sc_hd__dfrtp_2
* cell instance $287 m0 *1 96.6,29.92
X$287 38 42 177 32 209 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $289 m0 *1 34.96,51.68
X$289 38 42 253 32 293 57 57 38 sky130_fd_sc_hd__dfstp_1
* cell instance $291 r0 *1 28.98,40.8
X$291 38 42 213 32 263 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $293 r0 *1 5.98,19.04
X$293 38 42 136 32 135 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $295 m0 *1 9.66,24.48
X$295 38 42 142 32 161 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $297 m0 *1 19.78,24.48
X$297 38 42 47 32 143 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $299 r0 *1 26.68,46.24
X$299 38 42 294 32 292 57 57 38 sky130_fd_sc_hd__dfrtp_2
* cell instance $302 m0 *1 34.04,40.8
X$302 38 42 217 32 233 57 57 38 sky130_fd_sc_hd__dfrtp_2
* cell instance $305 m0 *1 36.8,29.92
X$305 38 42 226 32 178 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $307 m0 *1 44.16,89.76
X$307 38 42 502 32 531 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $309 r0 *1 33.58,84.32
X$309 38 42 499 32 511 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $312 r0 *1 57.5,13.6
X$312 38 42 112 32 120 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $314 m0 *1 15.18,95.2
X$314 38 42 571 32 569 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $317 m0 *1 30.82,8.16
X$317 38 42 35 32 80 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $320 m0 *1 40.94,13.6
X$320 38 42 51 32 105 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $322 m0 *1 47.38,100.64
X$322 38 42 595 32 611 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $324 m0 *1 71.76,19.04
X$324 38 42 113 32 124 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $326 m0 *1 31.28,100.64
X$326 38 42 605 32 632 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $328 r0 *1 43.7,19.04
X$328 38 42 52 32 146 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $330 m0 *1 16.56,73.44
X$330 38 42 421 32 430 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $332 m0 *1 9.66,68
X$332 38 42 383 32 381 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $335 m0 *1 95.22,46.24
X$335 38 42 247 32 260 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $338 m0 *1 5.98,78.88
X$338 38 42 447 32 453 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $340 r0 *1 28.98,13.6
X$340 38 42 110 32 118 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $343 m0 *1 8.74,89.76
X$343 38 42 515 32 522 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $346 m0 *1 5.98,95.2
X$346 38 42 524 32 558 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $349 m0 *1 29.44,24.48
X$349 38 42 178 32 162 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $352 r0 *1 33.12,24.48
X$352 38 42 173 32 163 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $355 r0 *1 1.38,95.2
X$355 38 575 32 57 57 38 sky130_fd_sc_hd__buf_16
* cell instance $359 r0 *1 23.46,89.76
X$359 38 42 526 32 572 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $361 m0 *1 9.66,84.32
X$361 38 42 468 32 487 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $363 m0 *1 95.68,51.68
X$363 38 42 303 32 304 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $366 r0 *1 20.24,2.72
X$366 38 60 89 33 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $369 r0 *1 27.14,2.72
X$369 57 46 34 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $373 r0 *1 32.66,2.72
X$373 38 80 35 54 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $377 r0 *1 72.22,2.72
X$377 38 65 45 36 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $380 r0 *1 98.44,2.72
X$380 38 40 41 37 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $424 r0 *1 84.64,2.72
X$424 38 43 41 53 40 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $425 r0 *1 93.84,2.72
X$425 38 59 56 41 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $440 m0 *1 4.6,8.16
X$440 38 78 39 100 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $441 m0 *1 8.74,8.16
X$441 38 43 88 53 87 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $444 m0 *1 19.32,8.16
X$444 38 43 89 53 60 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $450 m0 *1 40.48,8.16
X$450 38 43 92 53 74 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $453 m0 *1 52.44,8.16
X$453 38 75 50 95 81 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $455 m0 *1 66.24,8.16
X$455 38 43 45 53 65 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $456 m0 *1 75.44,8.16
X$456 38 91 76 63 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $457 m0 *1 79.58,8.16
X$457 38 106 84 76 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $461 m0 *1 95.68,8.16
X$461 38 77 42 57 57 38 sky130_fd_sc_hd__buf_16
* cell instance $462 r0 *1 1.38,8.16
X$462 38 43 100 53 99 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $464 r0 *1 11.04,8.16
X$464 38 87 88 58 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $467 r0 *1 15.64,8.16
X$467 38 101 44 88 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $471 r0 *1 33.58,8.16
X$471 38 104 54 66 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $473 r0 *1 38.64,8.16
X$473 38 74 92 71 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $477 r0 *1 43.7,8.16
X$477 38 105 51 92 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $480 r0 *1 49.22,8.16
X$480 38 43 95 53 107 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $486 r0 *1 81.88,8.16
X$486 38 103 97 90 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $491 r0 *1 98.44,8.16
X$491 38 79 85 97 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $493 r0 *1 104.42,8.16
X$493 57 56 86 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $504 m0 *1 2.76,13.6
X$504 57 93 116 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $505 m0 *1 4.14,13.6
X$505 38 99 100 116 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $508 m0 *1 23,13.6
X$508 38 102 46 89 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $513 m0 *1 31.74,13.6
X$513 38 43 54 53 104 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $516 m0 *1 52.44,13.6
X$516 38 107 95 72 94 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $519 m0 *1 57.96,13.6
X$519 38 121 96 69 94 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $520 m0 *1 62.1,13.6
X$520 38 120 112 96 81 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $523 m0 *1 69,13.6
X$523 38 108 83 45 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $524 m0 *1 73.14,13.6
X$524 38 43 76 53 91 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $528 m0 *1 86.48,13.6
X$528 38 43 97 53 103 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $529 m0 *1 95.68,13.6
X$529 38 98 43 57 57 38 sky130_fd_sc_hd__buf_16
* cell instance $539 r0 *1 21.16,13.6
X$539 38 127 109 61 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $548 r0 *1 48.3,13.6
X$548 38 43 111 53 119 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $559 r0 *1 88.78,13.6
X$559 38 43 117 53 114 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $562 r0 *1 98.44,13.6
X$562 38 114 117 115 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $564 r0 *1 103.04,13.6
X$564 57 133 115 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $567 m0 *1 1.38,19.04
X$567 38 43 123 53 122 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $568 m0 *1 10.58,19.04
X$568 38 135 136 123 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $573 m0 *1 17.48,19.04
X$573 38 43 109 53 127 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $577 m0 *1 29.44,19.04
X$577 38 43 130 53 137 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $585 m0 *1 51.98,19.04
X$585 38 119 111 73 94 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $588 m0 *1 57.04,19.04
X$588 38 43 96 53 121 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $599 m0 *1 86.02,19.04
X$599 38 140 131 139 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $606 m0 *1 104.42,19.04
X$606 57 125 126 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $608 r0 *1 1.84,19.04
X$608 38 122 123 134 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $615 r0 *1 22.54,19.04
X$615 38 143 47 109 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $619 r0 *1 29.9,19.04
X$619 38 137 130 64 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $620 r0 *1 34.04,19.04
X$620 38 118 110 130 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $626 r0 *1 52.9,19.04
X$626 38 146 52 111 81 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $634 r0 *1 70.84,19.04
X$634 38 43 148 53 147 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $638 r0 *1 93.84,19.04
X$638 38 138 125 117 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $641 r0 *1 98.44,19.04
X$641 38 145 144 159 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $643 r0 *1 103.04,19.04
X$643 57 131 132 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $654 m0 *1 1.38,24.48
X$654 57 128 134 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $656 m0 *1 3.22,24.48
X$656 38 160 151 171 82 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $658 m0 *1 7.82,24.48
X$658 57 136 129 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $667 m0 *1 51.98,24.48
X$667 57 94 38 82 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $672 m0 *1 58.42,24.48
X$672 38 43 156 53 149 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $675 m0 *1 69,24.48
X$675 57 150 67 155 38 57 38 sky130_fd_sc_hd__nor2b_1
* cell instance $677 m0 *1 73.14,24.48
X$677 38 147 148 154 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $678 m0 *1 77.28,24.48
X$678 38 124 113 148 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $683 m0 *1 88.32,24.48
X$683 38 153 139 152 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $684 m0 *1 92.46,24.48
X$684 57 141 152 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $688 r0 *1 1.84,24.48
X$688 38 43 151 53 160 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $689 r0 *1 11.04,24.48
X$689 38 161 142 151 70 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $697 r0 *1 22.54,24.48
X$697 38 43 162 53 166 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $698 r0 *1 31.74,24.48
X$698 57 70 57 38 163 38 sky130_fd_sc_hd__inv_1
* cell instance $704 r0 *1 46.92,24.48
X$704 57 81 38 70 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $705 r0 *1 49.68,24.48
X$705 57 157 82 150 57 38 166 38 sky130_fd_sc_hd__o21ai_1
* cell instance $706 r0 *1 51.52,24.48
X$706 38 43 49 53 174 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $707 r0 *1 60.72,24.48
X$707 38 149 68 49 156 191 158 57 57 38 sky130_fd_sc_hd__a32o_1
* cell instance $709 r0 *1 65.32,24.48
X$709 57 157 167 48 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $710 r0 *1 66.7,24.48
X$710 57 158 167 168 157 175 38 57 38 sky130_fd_sc_hd__o22ai_1
* cell instance $716 r0 *1 70.84,24.48
X$716 38 38 155 94 156 57 57 sky130_fd_sc_hd__nand2_2
* cell instance $720 r0 *1 79.58,24.48
X$720 38 43 139 53 153 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $721 r0 *1 88.78,24.48
X$721 38 43 159 53 169 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $725 r0 *1 98.44,24.48
X$725 38 169 159 172 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $727 r0 *1 104.42,24.48
X$727 57 144 170 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $734 m0 *1 2.76,29.92
X$734 57 165 171 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $736 m0 *1 5.98,29.92
X$736 57 142 164 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $751 m0 *1 53.82,29.92
X$751 57 150 187 180 38 57 174 38 sky130_fd_sc_hd__a21o_1
* cell instance $755 m0 *1 59.8,29.92
X$755 57 49 68 181 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $756 m0 *1 61.18,29.92
X$756 57 49 68 150 182 57 38 38 sky130_fd_sc_hd__nand3_1
* cell instance $759 m0 *1 65.32,29.92
X$759 57 156 57 38 167 38 sky130_fd_sc_hd__inv_1
* cell instance $760 m0 *1 66.7,29.92
X$760 38 43 179 53 175 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $761 m0 *1 75.9,29.92
X$761 57 94 57 38 62 38 sky130_fd_sc_hd__buf_4
* cell instance $770 r0 *1 3.22,29.92
X$770 38 43 198 53 197 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $780 r0 *1 29.44,29.92
X$780 38 43 201 53 204 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $789 r0 *1 50.14,29.92
X$789 38 202 189 183 57 57 38 sky130_fd_sc_hd__xor2_4
* cell instance $792 r0 *1 61.64,29.92
X$792 38 187 183 156 203 179 57 57 38 sky130_fd_sc_hd__a31o_1
* cell instance $793 r0 *1 64.86,29.92
X$793 57 203 150 182 57 168 38 38 sky130_fd_sc_hd__o21ai_0
* cell instance $795 r0 *1 67.16,29.92
X$795 57 183 150 203 155 38 57 158 38 sky130_fd_sc_hd__a31oi_1
* cell instance $799 r0 *1 70.84,29.92
X$799 57 179 57 38 157 38 sky130_fd_sc_hd__inv_1
* cell instance $802 r0 *1 73.6,29.92
X$802 57 81 57 38 55 38 sky130_fd_sc_hd__buf_4
* cell instance $804 r0 *1 78.2,29.92
X$804 38 43 186 53 184 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $805 r0 *1 87.4,29.92
X$805 38 184 186 185 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $811 r0 *1 98.44,29.92
X$811 38 210 207 194 62 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $812 r0 *1 102.58,29.92
X$812 57 176 172 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $814 r0 *1 104.42,29.92
X$814 57 177 195 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $825 m0 *1 5.98,35.36
X$825 38 197 198 221 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $828 m0 *1 11.5,35.36
X$828 57 188 199 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $831 m0 *1 15.18,35.36
X$831 38 43 188 53 208 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $838 m0 *1 35.42,35.36
X$838 38 43 189 53 201 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $839 m0 *1 44.62,35.36
X$839 38 43 202 53 189 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $845 m0 *1 58.42,35.36
X$845 38 180 190 203 181 183 191 57 57 38 sky130_fd_sc_hd__a32o_1
* cell instance $848 m0 *1 64.86,35.36
X$848 57 203 183 192 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $849 m0 *1 66.24,35.36
X$849 57 179 168 190 192 38 193 57 38 sky130_fd_sc_hd__a22o_1
* cell instance $851 m0 *1 71.3,35.36
X$851 38 43 190 53 193 57 57 38 sky130_fd_sc_hd__dfstp_1
* cell instance $857 m0 *1 86.48,35.36
X$857 38 212 211 186 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $859 m0 *1 92.46,35.36
X$859 57 211 205 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $860 m0 *1 93.84,35.36
X$860 57 206 185 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $861 m0 *1 95.22,35.36
X$861 38 43 207 53 210 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $862 m0 *1 104.42,35.36
X$862 57 196 194 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $864 r0 *1 3.22,35.36
X$864 57 218 214 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $865 r0 *1 4.6,35.36
X$865 57 213 219 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $870 r0 *1 17.02,35.36
X$870 38 208 188 215 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $873 r0 *1 31.74,35.36
X$873 57 224 204 57 216 38 38 sky130_fd_sc_hd__xor2_1
* cell instance $882 r0 *1 52.44,35.36
X$882 38 43 191 53 180 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $885 r0 *1 63.02,35.36
X$885 38 230 150 190 156 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $886 r0 *1 67.16,35.36
X$886 57 203 190 183 256 57 38 38 sky130_fd_sc_hd__nand3_1
* cell instance $901 r0 *1 98.9,35.36
X$901 38 209 177 207 55 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $904 m0 *1 1.38,40.8
X$904 57 222 238 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $905 m0 *1 2.76,40.8
X$905 57 198 229 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $906 m0 *1 4.14,40.8
X$906 38 220 259 225 251 224 221 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $908 m0 *1 8.74,40.8
X$908 38 240 223 225 214 224 215 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $920 m0 *1 43.7,40.8
X$920 57 235 226 243 38 57 38 sky130_fd_sc_hd__nor2_1
* cell instance $922 m0 *1 45.54,40.8
X$922 38 226 217 265 57 81 57 38 sky130_fd_sc_hd__nand3_4
* cell instance $929 m0 *1 63.02,40.8
X$929 38 230 183 203 57 231 57 38 sky130_fd_sc_hd__nand3_4
* cell instance $932 m0 *1 69.46,40.8
X$932 57 241 57 38 203 38 sky130_fd_sc_hd__clkbuf_2
* cell instance $934 m0 *1 74.98,40.8
X$934 57 81 38 236 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $944 m0 *1 98.9,40.8
X$944 38 227 228 239 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $947 m0 *1 104.42,40.8
X$947 57 228 237 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $948 r0 *1 1.38,40.8
X$948 57 245 244 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $949 r0 *1 2.76,40.8
X$949 57 242 238 232 223 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $950 r0 *1 5.06,40.8
X$950 38 43 245 53 261 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $959 r0 *1 24.84,40.8
X$959 38 231 200 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $961 r0 *1 38.64,40.8
X$961 57 217 234 242 288 38 233 57 38 sky130_fd_sc_hd__a22o_1
* cell instance $967 r0 *1 43.24,40.8
X$967 57 235 254 243 38 57 234 38 sky130_fd_sc_hd__a21o_1
* cell instance $972 r0 *1 60.72,40.8
X$972 38 43 150 53 264 57 57 38 sky130_fd_sc_hd__dfrtp_2
* cell instance $979 r0 *1 75.44,40.8
X$979 57 94 57 38 289 38 sky130_fd_sc_hd__buf_4
* cell instance $981 r0 *1 87.86,40.8
X$981 38 43 239 53 262 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $987 r0 *1 98.44,40.8
X$987 38 260 247 273 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $988 r0 *1 102.58,40.8
X$988 57 246 258 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $990 r0 *1 104.42,40.8
X$990 57 248 257 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $991 m0 *1 1.38,46.24
X$991 57 242 250 232 259 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $992 m0 *1 3.68,46.24
X$992 57 266 251 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $993 m0 *1 5.06,46.24
X$993 38 261 245 275 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $996 m0 *1 19.78,46.24
X$996 38 43 277 53 276 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1000 m0 *1 34.04,46.24
X$1000 57 267 252 217 213 234 263 38 57 38 sky130_fd_sc_hd__a311o_1
* cell instance $1001 m0 *1 37.72,46.24
X$1001 57 253 173 213 252 38 57 38 sky130_fd_sc_hd__nor3b_1
* cell instance $1002 m0 *1 40.48,46.24
X$1002 57 173 253 217 255 57 38 38 sky130_fd_sc_hd__or3b_1
* cell instance $1003 m0 *1 43.7,46.24
X$1003 57 254 235 255 243 38 267 57 38 sky130_fd_sc_hd__a211oi_1
* cell instance $1006 m0 *1 48.76,46.24
X$1006 57 235 57 38 265 38 sky130_fd_sc_hd__inv_1
* cell instance $1011 m0 *1 57.04,46.24
X$1011 38 43 280 53 282 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1012 m0 *1 66.24,46.24
X$1012 38 264 150 281 256 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1015 m0 *1 74.98,46.24
X$1015 38 43 278 53 279 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1017 m0 *1 84.64,46.24
X$1017 38 249 246 278 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1020 m0 *1 90.16,46.24
X$1020 38 262 239 257 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1022 m0 *1 104.42,46.24
X$1022 57 247 272 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1023 r0 *1 1.38,46.24
X$1023 57 284 250 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1024 r0 *1 2.76,46.24
X$1024 57 283 286 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1025 r0 *1 4.14,46.24
X$1025 57 242 285 232 287 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1026 r0 *1 6.44,46.24
X$1026 38 274 287 225 286 224 275 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1033 r0 *1 18.4,46.24
X$1033 57 200 277 276 57 38 38 sky130_fd_sc_hd__xnor2_1
* cell instance $1039 r0 *1 38.64,46.24
X$1039 57 173 268 235 217 288 293 38 57 38 sky130_fd_sc_hd__a311o_1
* cell instance $1043 r0 *1 43.24,46.24
X$1043 57 242 254 297 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $1044 r0 *1 44.62,46.24
X$1044 57 242 217 254 38 57 296 38 sky130_fd_sc_hd__a21oi_1
* cell instance $1045 r0 *1 46.46,46.24
X$1045 57 265 296 297 232 295 57 38 38 sky130_fd_sc_hd__o211ai_1
* cell instance $1047 r0 *1 60.26,46.24
X$1047 38 43 241 53 280 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1054 r0 *1 80.04,46.24
X$1054 38 279 278 269 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1057 r0 *1 88.78,46.24
X$1057 38 43 273 53 290 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1061 r0 *1 98.9,46.24
X$1061 38 290 273 270 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1062 r0 *1 103.04,46.24
X$1062 57 271 270 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1063 r0 *1 104.42,46.24
X$1063 57 291 269 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1072 m0 *1 1.38,51.68
X$1072 57 306 299 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1073 m0 *1 2.76,51.68
X$1073 57 298 285 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1074 m0 *1 4.14,51.68
X$1074 57 314 305 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1091 m0 *1 58.42,51.68
X$1091 38 43 281 53 312 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1102 m0 *1 94.3,51.68
X$1102 57 301 302 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1104 r0 *1 1.38,51.68
X$1104 57 242 299 232 320 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1106 r0 *1 13.8,51.68
X$1106 57 307 313 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1111 r0 *1 15.64,51.68
X$1111 38 43 307 53 325 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1122 r0 *1 46.46,51.68
X$1122 57 232 297 327 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $1125 r0 *1 50.6,51.68
X$1125 38 43 312 53 349 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1135 r0 *1 70.84,51.68
X$1135 38 43 308 53 326 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1136 r0 *1 80.04,51.68
X$1136 38 300 301 308 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1143 r0 *1 98.44,51.68
X$1143 38 323 311 321 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1144 r0 *1 102.58,51.68
X$1144 57 309 310 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1146 r0 *1 104.42,51.68
X$1146 57 303 319 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1147 m0 *1 1.38,57.12
X$1147 57 329 315 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1149 m0 *1 3.68,57.12
X$1149 38 322 320 225 315 224 316 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1150 m0 *1 7.82,57.12
X$1150 38 43 335 53 334 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1156 m0 *1 34.96,57.12
X$1156 38 294 317 254 57 57 38 sky130_fd_sc_hd__xnor2_4
* cell instance $1167 m0 *1 74.52,57.12
X$1167 38 326 308 310 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1173 m0 *1 89.24,57.12
X$1173 38 324 318 337 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1175 m0 *1 93.84,57.12
X$1175 38 43 311 53 323 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1176 m0 *1 103.04,57.12
X$1176 57 318 333 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1177 m0 *1 104.42,57.12
X$1177 57 332 321 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1178 r0 *1 1.38,57.12
X$1178 57 242 379 232 341 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1180 r0 *1 4.14,57.12
X$1180 57 335 328 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1183 r0 *1 10.12,57.12
X$1183 38 334 335 316 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1187 r0 *1 15.64,57.12
X$1187 38 336 341 225 305 224 338 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1189 r0 *1 20.7,57.12
X$1189 38 325 307 338 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1193 r0 *1 35.88,57.12
X$1193 38 317 294 288 57 57 38 sky130_fd_sc_hd__xor2_2
* cell instance $1197 r0 *1 43.24,57.12
X$1197 38 288 346 268 330 235 57 57 38 sky130_fd_sc_hd__nand4b_4
* cell instance $1199 r0 *1 52.44,57.12
X$1199 57 331 38 330 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $1212 r0 *1 88.78,57.12
X$1212 38 43 337 53 344 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1216 r0 *1 98.9,57.12
X$1216 38 304 303 311 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1228 m0 *1 2.3,62.56
X$1228 38 43 361 53 351 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1229 m0 *1 11.5,62.56
X$1229 38 348 340 57 57 38 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $1239 m0 *1 39.1,62.56
X$1239 38 268 354 348 253 57 57 38 sky130_fd_sc_hd__nor3b_2
* cell instance $1240 m0 *1 43.7,62.56
X$1240 38 254 331 353 268 385 57 57 38 sky130_fd_sc_hd__a211oi_4
* cell instance $1241 m0 *1 51.06,62.56
X$1241 57 349 38 235 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1252 m0 *1 78.66,62.56
X$1252 38 345 352 363 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1258 m0 *1 90.16,62.56
X$1258 38 344 337 362 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1260 m0 *1 94.76,62.56
X$1260 57 352 342 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1262 r0 *1 1.38,62.56
X$1262 57 347 57 38 354 38 sky130_fd_sc_hd__clkbuf_2
* cell instance $1264 r0 *1 4.14,62.56
X$1264 57 242 389 380 57 38 356 38 sky130_fd_sc_hd__o21ai_1
* cell instance $1269 r0 *1 17.02,62.56
X$1269 38 373 374 383 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1270 r0 *1 21.16,62.56
X$1270 57 346 38 225 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $1273 r0 *1 29.44,62.56
X$1273 38 353 224 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $1276 r0 *1 37.72,62.56
X$1276 57 253 348 369 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $1278 r0 *1 39.56,62.56
X$1278 57 235 369 253 354 38 357 57 38 sky130_fd_sc_hd__a22o_1
* cell instance $1285 r0 *1 61.18,62.56
X$1285 38 43 358 53 384 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1288 r0 *1 70.84,62.56
X$1288 38 43 363 53 365 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1289 r0 *1 80.04,62.56
X$1289 38 365 363 366 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1294 r0 *1 96.6,62.56
X$1294 57 350 366 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1296 r0 *1 98.44,62.56
X$1296 38 360 376 367 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1297 r0 *1 102.58,62.56
X$1297 57 358 359 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1299 r0 *1 104.42,62.56
X$1299 57 343 362 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1308 m0 *1 1.38,68
X$1308 57 339 379 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1309 m0 *1 2.76,68
X$1309 57 355 387 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1310 m0 *1 4.14,68
X$1310 57 354 387 380 38 57 38 sky130_fd_sc_hd__nor2_1
* cell instance $1311 m0 *1 5.52,68
X$1311 38 351 361 372 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1312 m0 *1 18.86,68
X$1312 38 43 374 53 373 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1315 m0 *1 38.64,68
X$1315 57 354 348 253 38 393 57 38 sky130_fd_sc_hd__o21ai_2
* cell instance $1316 m0 *1 41.86,68
X$1316 57 330 38 242 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1318 m0 *1 45.54,68
X$1318 38 331 253 235 57 385 57 38 sky130_fd_sc_hd__mux2i_2
* cell instance $1326 m0 *1 65.32,68
X$1326 38 384 358 392 231 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1334 m0 *1 88.78,68
X$1334 38 382 375 400 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1336 m0 *1 93.84,68
X$1336 38 43 367 53 391 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1337 m0 *1 103.04,68
X$1337 57 375 378 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1338 m0 *1 104.42,68
X$1338 57 376 368 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1339 r0 *1 1.38,68
X$1339 57 371 398 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1340 r0 *1 2.76,68
X$1340 57 242 397 389 57 38 38 sky130_fd_sc_hd__nand2_1
* cell instance $1342 r0 *1 5.06,68
X$1342 38 390 403 225 398 224 372 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1343 r0 *1 9.2,68
X$1343 57 396 399 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1345 r0 *1 11.04,68
X$1345 38 381 411 225 399 224 383 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1349 r0 *1 16.56,68
X$1349 57 374 386 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1354 r0 *1 30.82,68
X$1354 38 395 356 394 353 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1363 r0 *1 46.46,68
X$1363 38 43 417 53 416 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1374 r0 *1 77.74,68
X$1374 38 43 400 53 414 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1376 r0 *1 88.78,68
X$1376 38 43 409 53 413 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1379 r0 *1 98.44,68
X$1379 38 391 367 402 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1391 m0 *1 1.38,73.44
X$1391 57 370 397 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1392 m0 *1 2.76,73.44
X$1392 57 419 408 232 403 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1393 m0 *1 5.06,73.44
X$1393 57 361 364 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1394 m0 *1 6.44,73.44
X$1394 57 404 410 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1395 m0 *1 7.82,73.44
X$1395 57 419 410 232 411 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1404 m0 *1 31.28,73.44
X$1404 38 231 415 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $1405 m0 *1 35.42,73.44
X$1405 38 432 433 394 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1408 m0 *1 40.94,73.44
X$1408 57 393 38 232 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1421 m0 *1 84.64,73.44
X$1421 38 414 400 406 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1425 m0 *1 92,73.44
X$1425 38 413 409 428 289 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1426 m0 *1 96.14,73.44
X$1426 38 412 441 409 236 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1427 m0 *1 100.28,73.44
X$1427 57 377 406 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1428 m0 *1 101.66,73.44
X$1428 57 388 402 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1431 r0 *1 1.38,73.44
X$1431 38 43 437 53 440 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1434 r0 *1 12.88,73.44
X$1434 57 419 455 232 420 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1437 r0 *1 15.64,73.44
X$1437 38 430 420 225 476 224 421 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1440 r0 *1 21.16,73.44
X$1440 57 422 418 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1441 r0 *1 22.54,73.44
X$1441 38 443 422 421 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1445 r0 *1 33.12,73.44
X$1445 38 43 433 53 432 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1451 r0 *1 47.84,73.44
X$1451 38 416 417 423 231 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1452 r0 *1 51.98,73.44
X$1452 57 330 635 393 424 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1454 r0 *1 55.2,73.44
X$1454 38 431 424 425 438 353 392 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1459 r0 *1 66.24,73.44
X$1459 38 426 427 429 231 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1462 r0 *1 70.84,73.44
X$1462 38 43 427 53 426 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1471 r0 *1 101.2,73.44
X$1471 57 401 428 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1484 m0 *1 1.84,78.88
X$1484 38 440 437 447 200 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1487 m0 *1 19.78,78.88
X$1487 38 43 422 53 443 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1493 m0 *1 38.18,78.88
X$1493 57 330 38 419 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1494 m0 *1 40.02,78.88
X$1494 57 393 57 38 444 38 sky130_fd_sc_hd__clkbuf_2
* cell instance $1496 m0 *1 43.7,78.88
X$1496 38 434 460 346 459 353 423 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1497 m0 *1 47.84,78.88
X$1497 57 346 38 425 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1505 m0 *1 62.56,78.88
X$1505 38 231 458 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $1515 m0 *1 95.22,78.88
X$1515 57 439 456 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1516 m0 *1 96.6,78.88
X$1516 38 43 450 53 454 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1517 r0 *1 1.38,78.88
X$1517 57 435 408 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1518 r0 *1 2.76,78.88
X$1518 57 419 483 444 463 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1519 r0 *1 5.06,78.88
X$1519 38 453 463 225 466 224 447 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1520 r0 *1 9.2,78.88
X$1520 38 487 485 225 464 448 468 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1521 r0 *1 13.34,78.88
X$1521 57 405 455 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1525 r0 *1 15.64,78.88
X$1525 38 43 477 53 469 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1529 r0 *1 28.06,78.88
X$1529 57 346 38 471 57 38 sky130_fd_sc_hd__clkbuf_4
* cell instance $1530 r0 *1 30.82,78.88
X$1530 38 353 448 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $1533 r0 *1 37.72,78.88
X$1533 38 489 473 499 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1539 r0 *1 44.62,78.88
X$1539 57 330 474 393 460 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1543 r0 *1 56.12,78.88
X$1543 38 353 449 57 57 38 sky130_fd_sc_hd__buf_6
* cell instance $1548 r0 *1 71.3,78.88
X$1548 38 43 470 53 488 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1550 r0 *1 81.42,78.88
X$1550 38 457 498 425 456 449 442 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1556 r0 *1 98.44,78.88
X$1556 38 454 450 442 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1557 r0 *1 102.58,78.88
X$1557 57 441 407 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1559 r0 *1 104.42,78.88
X$1559 57 450 452 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1568 m0 *1 1.38,84.32
X$1568 57 437 445 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1569 m0 *1 2.76,84.32
X$1569 57 461 483 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1570 m0 *1 4.14,84.32
X$1570 57 446 466 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1571 m0 *1 5.52,84.32
X$1571 57 490 484 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1572 m0 *1 6.9,84.32
X$1572 57 419 484 444 485 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1574 m0 *1 18.86,84.32
X$1574 38 469 477 468 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1581 m0 *1 34.04,84.32
X$1581 38 43 473 53 489 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1582 m0 *1 43.24,84.32
X$1582 38 43 491 53 501 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1584 m0 *1 54.28,84.32
X$1584 57 393 57 38 492 38 sky130_fd_sc_hd__clkbuf_2
* cell instance $1587 m0 *1 57.04,84.32
X$1587 57 330 634 393 478 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1588 m0 *1 59.34,84.32
X$1588 38 472 478 425 479 449 429 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1590 m0 *1 73.6,84.32
X$1590 38 488 470 494 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1596 m0 *1 85.1,84.32
X$1596 38 486 497 425 481 449 467 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1599 m0 *1 90.62,84.32
X$1599 38 496 482 467 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1603 m0 *1 102.58,84.32
X$1603 57 482 451 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1604 m0 *1 103.96,84.32
X$1604 57 465 481 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1607 r0 *1 1.84,84.32
X$1607 38 43 506 53 507 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1608 r0 *1 11.04,84.32
X$1608 57 436 476 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1617 r0 *1 17.02,84.32
X$1617 57 477 475 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1621 r0 *1 24.38,84.32
X$1621 38 43 525 53 510 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1627 r0 *1 44.16,84.32
X$1627 38 501 491 502 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1632 r0 *1 59.8,84.32
X$1632 38 43 512 53 503 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1639 r0 *1 70.84,84.32
X$1639 57 330 631 492 493 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1640 r0 *1 73.14,84.32
X$1640 38 480 493 425 500 449 494 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1643 r0 *1 79.58,84.32
X$1643 57 330 552 492 498 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1644 r0 *1 81.88,84.32
X$1644 57 330 508 492 497 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1647 r0 *1 88.78,84.32
X$1647 38 43 482 53 496 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1654 m0 *1 1.38,89.76
X$1654 57 506 513 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1655 m0 *1 2.76,89.76
X$1655 57 462 464 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1657 m0 *1 4.6,89.76
X$1657 38 507 506 515 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1664 m0 *1 30.82,89.76
X$1664 38 510 525 526 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1667 m0 *1 37.72,89.76
X$1667 38 511 527 471 548 448 499 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1678 m0 *1 73.14,89.76
X$1678 57 330 38 516 57 38 sky130_fd_sc_hd__buf_2
* cell instance $1679 m0 *1 74.98,89.76
X$1679 38 43 523 53 509 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1685 m0 *1 96.14,89.76
X$1685 38 43 520 53 521 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1687 r0 *1 1.38,89.76
X$1687 57 504 541 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1688 r0 *1 2.76,89.76
X$1688 57 505 533 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1690 r0 *1 4.6,89.76
X$1690 57 419 541 444 514 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1691 r0 *1 6.9,89.76
X$1691 38 522 514 471 533 448 515 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1692 r0 *1 11.04,89.76
X$1692 38 542 544 524 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1700 r0 *1 38.18,89.76
X$1700 57 516 547 444 527 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1701 r0 *1 40.48,89.76
X$1701 57 516 550 444 517 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1705 r0 *1 43.7,89.76
X$1705 38 531 517 471 553 448 502 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1709 r0 *1 56.12,89.76
X$1709 38 529 530 471 556 449 528 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1711 r0 *1 63.94,89.76
X$1711 38 503 512 528 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1718 r0 *1 82.8,89.76
X$1718 38 509 523 518 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1722 r0 *1 98.44,89.76
X$1722 38 521 520 519 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1724 r0 *1 104.42,89.76
X$1724 57 520 495 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1734 m0 *1 3.22,95.2
X$1734 57 419 624 444 559 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1743 m0 *1 38.18,95.2
X$1743 57 549 547 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1744 m0 *1 39.56,95.2
X$1744 57 551 548 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1745 m0 *1 40.94,95.2
X$1745 57 534 550 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1746 m0 *1 42.32,95.2
X$1746 57 473 573 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1748 m0 *1 44.62,95.2
X$1748 57 645 553 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1750 m0 *1 46.46,95.2
X$1750 57 555 474 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1754 m0 *1 54.28,95.2
X$1754 57 516 535 492 530 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1756 m0 *1 57.04,95.2
X$1756 38 43 613 53 570 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1760 m0 *1 74.52,95.2
X$1760 38 554 536 425 537 449 518 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1761 m0 *1 78.66,95.2
X$1761 57 470 567 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1762 m0 *1 80.04,95.2
X$1762 57 538 552 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1764 m0 *1 81.88,95.2
X$1764 57 546 545 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1767 m0 *1 84.64,95.2
X$1767 57 516 545 492 539 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1768 m0 *1 86.94,95.2
X$1768 38 543 539 425 540 449 519 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1771 m0 *1 96.6,95.2
X$1771 38 43 565 53 566 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1772 r0 *1 11.5,95.2
X$1772 57 557 583 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1773 r0 *1 12.88,95.2
X$1773 57 419 583 444 568 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1778 r0 *1 15.64,95.2
X$1778 38 569 559 471 585 448 571 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1781 r0 *1 22.54,95.2
X$1781 57 419 627 444 577 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1782 r0 *1 24.84,95.2
X$1782 38 572 577 471 629 448 526 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1783 r0 *1 28.98,95.2
X$1783 38 43 578 53 589 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1785 r0 *1 38.64,95.2
X$1785 57 578 560 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1786 r0 *1 40.02,95.2
X$1786 57 433 574 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1787 r0 *1 41.4,95.2
X$1787 57 561 606 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1792 r0 *1 43.24,95.2
X$1792 38 43 596 53 608 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1796 r0 *1 63.94,95.2
X$1796 57 516 633 492 579 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1797 r0 *1 66.24,95.2
X$1797 38 610 579 425 562 449 593 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1802 r0 *1 70.84,95.2
X$1802 38 43 591 53 607 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1803 r0 *1 80.04,95.2
X$1803 57 580 590 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1804 r0 *1 81.42,95.2
X$1804 57 563 508 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1805 r0 *1 82.8,95.2
X$1805 57 581 588 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1806 r0 *1 84.18,95.2
X$1806 57 516 588 492 586 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1807 r0 *1 86.48,95.2
X$1807 57 587 584 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1813 r0 *1 98.44,95.2
X$1813 38 566 565 564 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1815 r0 *1 104.42,95.2
X$1815 57 565 582 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1816 m0 *1 1.38,100.64
X$1816 38 576 53 57 57 38 sky130_fd_sc_hd__buf_16
* cell instance $1817 m0 *1 11.5,100.64
X$1817 38 558 568 471 625 448 524 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1819 m0 *1 16.56,100.64
X$1819 38 43 600 53 626 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1821 m0 *1 26.22,100.64
X$1821 57 419 602 444 616 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1825 m0 *1 29.9,100.64
X$1825 57 525 603 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1826 m0 *1 40.48,100.64
X$1826 57 516 606 444 609 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1827 m0 *1 42.78,100.64
X$1827 38 608 596 595 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1830 m0 *1 57.04,100.64
X$1830 38 592 612 471 597 448 594 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1831 m0 *1 61.18,100.64
X$1831 38 570 613 594 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1832 m0 *1 74.52,100.64
X$1832 57 516 630 492 536 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1833 m0 *1 76.82,100.64
X$1833 38 607 591 593 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1834 m0 *1 80.96,100.64
X$1834 57 516 590 492 604 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1837 m0 *1 93.84,100.64
X$1837 38 43 623 53 599 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1840 r0 *1 1.38,100.64
X$1840 57 532 624 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1841 r0 *1 2.76,100.64
X$1841 38 43 544 53 542 57 57 38 sky130_fd_sc_hd__dfrtp_1
* cell instance $1842 r0 *1 11.96,100.64
X$1842 57 544 637 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1843 r0 *1 13.34,100.64
X$1843 57 614 625 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1847 r0 *1 15.64,100.64
X$1847 57 638 585 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1848 r0 *1 17.02,100.64
X$1848 38 626 600 571 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1849 r0 *1 21.16,100.64
X$1849 57 600 639 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1851 r0 *1 23.46,100.64
X$1851 57 640 627 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1852 r0 *1 24.84,100.64
X$1852 57 641 602 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1853 r0 *1 26.22,100.64
X$1853 57 642 629 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1854 r0 *1 27.6,100.64
X$1854 57 615 643 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1856 r0 *1 29.44,100.64
X$1856 38 632 616 471 643 448 605 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1857 r0 *1 33.58,100.64
X$1857 38 589 578 605 415 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1859 r0 *1 38.64,100.64
X$1859 57 491 647 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1860 r0 *1 40.02,100.64
X$1860 57 644 459 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1861 r0 *1 41.4,100.64
X$1861 57 617 646 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1864 r0 *1 43.24,100.64
X$1864 38 611 609 471 646 448 595 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1865 r0 *1 47.38,100.64
X$1865 57 417 636 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1867 r0 *1 49.68,100.64
X$1867 57 649 652 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1868 r0 *1 51.06,100.64
X$1868 57 596 648 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1869 r0 *1 52.44,100.64
X$1869 57 650 635 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1871 r0 *1 54.28,100.64
X$1871 57 516 652 492 612 57 38 38 sky130_fd_sc_hd__or3_1
* cell instance $1873 r0 *1 57.04,100.64
X$1873 57 653 438 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1874 r0 *1 58.42,100.64
X$1874 57 618 634 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1875 r0 *1 59.8,100.64
X$1875 57 651 535 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1876 r0 *1 61.18,100.64
X$1876 57 655 479 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1877 r0 *1 62.56,100.64
X$1877 57 654 556 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1878 r0 *1 63.94,100.64
X$1878 57 619 597 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1879 r0 *1 65.32,100.64
X$1879 57 656 633 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1880 r0 *1 66.7,100.64
X$1880 57 613 657 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1881 r0 *1 68.08,100.64
X$1881 57 512 658 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1885 r0 *1 70.84,100.64
X$1885 57 620 562 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1886 r0 *1 72.22,100.64
X$1886 57 660 631 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1887 r0 *1 73.6,100.64
X$1887 57 661 500 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1888 r0 *1 74.98,100.64
X$1888 57 621 630 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1889 r0 *1 76.36,100.64
X$1889 57 427 659 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1890 r0 *1 77.74,100.64
X$1890 57 591 662 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1892 r0 *1 80.04,100.64
X$1892 38 601 604 425 664 449 598 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1894 r0 *1 84.64,100.64
X$1894 57 663 537 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1895 r0 *1 86.02,100.64
X$1895 57 666 664 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1896 r0 *1 87.4,100.64
X$1896 38 628 586 425 584 449 564 57 57 38 sky130_fd_sc_hd__o221a_1
* cell instance $1897 r0 *1 91.54,100.64
X$1897 57 622 540 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1899 r0 *1 93.84,100.64
X$1899 38 599 623 598 458 57 57 38 sky130_fd_sc_hd__mux2_1
* cell instance $1902 r0 *1 98.44,100.64
X$1902 57 523 665 38 57 38 sky130_fd_sc_hd__clkbuf_1
* cell instance $1903 r0 *1 99.82,100.64
X$1903 57 623 667 38 57 38 sky130_fd_sc_hd__clkbuf_1
.ENDS network_interface_cdc

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__a32o_1
* pin VGND
* pin X
* pin A2
* pin A1
* pin B1
* pin A3
* pin B2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a32o_1 1 2 3 4 5 7 8 13 14 15
* net 1 VGND
* net 2 X
* net 3 A2
* net 4 A1
* net 5 B1
* net 7 A3
* net 8 B2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 0.54,1.985 pfet_01v8_hvt
M$1 13 6 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=330000000000P
+ AD=242500000000P PS=2660000U PD=1485000U
* device instance $2 r0 *1 1.175,1.985 pfet_01v8_hvt
M$2 12 7 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=242500000000P
+ AD=165000000000P PS=1485000U PD=1330000U
* device instance $3 r0 *1 1.655,1.985 pfet_01v8_hvt
M$3 13 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=225000000000P PS=1330000U PD=1450000U
* device instance $4 r0 *1 2.255,1.985 pfet_01v8_hvt
M$4 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=225000000000P
+ AD=185000000000P PS=1450000U PD=1370000U
* device instance $5 r0 *1 2.775,1.985 pfet_01v8_hvt
M$5 6 5 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=185000000000P
+ AD=140000000000P PS=1370000U PD=1280000U
* device instance $6 r0 *1 3.205,1.985 pfet_01v8_hvt
M$6 12 8 6 14 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $7 r0 *1 0.54,0.56 nfet_01v8
M$7 1 6 2 15 nfet_01v8 L=150000U W=650000U AS=214500000000P AD=167375000000P
+ PS=1960000U PD=1165000U
* device instance $8 r0 *1 1.205,0.56 nfet_01v8
M$8 9 7 1 15 nfet_01v8 L=150000U W=650000U AS=167375000000P AD=97500000000P
+ PS=1165000U PD=950000U
* device instance $9 r0 *1 1.655,0.56 nfet_01v8
M$9 11 3 9 15 nfet_01v8 L=150000U W=650000U AS=97500000000P AD=146250000000P
+ PS=950000U PD=1100000U
* device instance $10 r0 *1 2.255,0.56 nfet_01v8
M$10 6 4 11 15 nfet_01v8 L=150000U W=650000U AS=146250000000P AD=143000000000P
+ PS=1100000U PD=1090000U
* device instance $11 r0 *1 2.845,0.56 nfet_01v8
M$11 10 5 6 15 nfet_01v8 L=150000U W=650000U AS=143000000000P AD=68250000000P
+ PS=1090000U PD=860000U
* device instance $12 r0 *1 3.205,0.56 nfet_01v8
M$12 1 8 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=172250000000P
+ PS=860000U PD=1830000U
.ENDS sky130_fd_sc_hd__a32o_1

* cell sky130_fd_sc_hd__a31o_1
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_1 1 2 6 7 8 9 11 12 13
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 3 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=172500000000P PS=2530000U PD=1345000U
* device instance $2 r0 *1 0.97,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=160000000000P PS=1345000U PD=1320000U
* device instance $3 r0 *1 1.44,1.985 pfet_01v8_hvt
M$3 11 7 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=165000000000P PS=1320000U PD=1330000U
* device instance $4 r0 *1 1.92,1.985 pfet_01v8_hvt
M$4 10 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 2.4,1.985 pfet_01v8_hvt
M$5 3 9 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=112125000000P
+ PS=1830000U PD=995000U
* device instance $7 r0 *1 0.97,0.56 nfet_01v8
M$7 4 6 1 13 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=104000000000P
+ PS=995000U PD=970000U
* device instance $8 r0 *1 1.44,0.56 nfet_01v8
M$8 5 7 4 13 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=107250000000P
+ PS=970000U PD=980000U
* device instance $9 r0 *1 1.92,0.56 nfet_01v8
M$9 3 8 5 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.4,0.56 nfet_01v8
M$10 1 9 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=208000000000P
+ PS=980000U PD=1940000U
.ENDS sky130_fd_sc_hd__a31o_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__or3b_1
* pin VPB
* pin A
* pin B
* pin C_N
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3b_1 1 2 3 5 6 7 8 10
* net 1 VPB
* net 2 A
* net 3 B
* net 5 C_N
* net 6 X
* net 7 VPWR
* net 8 VGND
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 4 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.77,1.695 pfet_01v8_hvt
M$2 12 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=68250000000P
+ PS=630000U PD=745000U
* device instance $3 r0 *1 2.245,1.695 pfet_01v8_hvt
M$3 7 2 12 1 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=148250000000P
+ PS=745000U PD=1340000U
* device instance $4 r0 *1 2.735,1.985 pfet_01v8_hvt
M$4 6 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $5 r0 *1 0.47,1.695 pfet_01v8_hvt
M$5 4 5 7 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.41,0.475 nfet_01v8
M$6 8 4 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $7 r0 *1 1.83,0.475 nfet_01v8
M$7 9 3 8 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 2.25,0.475 nfet_01v8
M$8 9 2 8 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=56700000000P
+ PS=985000U PD=690000U
* device instance $9 r0 *1 2.735,0.56 nfet_01v8
M$9 6 9 8 10 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=178750000000P
+ PS=985000U PD=1850000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or3b_1

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $17 r0 *1 2.15,0.56 nfet_01v8
M$17 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__a311o_1
* pin VPB
* pin C1
* pin B1
* pin A1
* pin A2
* pin A3
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a311o_1 1 2 3 4 5 6 7 8 10 12
* net 1 VPB
* net 2 C1
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 X
* net 8 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 11 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=285000000000P
+ AD=142500000000P PS=2570000U PD=1285000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 9 6 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=142500000000P
+ AD=165000000000P PS=1285000U PD=1330000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 10 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=305000000000P PS=1330000U PD=1610000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 9 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=305000000000P
+ AD=162500000000P PS=1610000U PD=1325000U
* device instance $5 r0 *1 2.645,1.985 pfet_01v8_hvt
M$5 13 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=207500000000P PS=1325000U PD=1415000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 11 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=207500000000P
+ AD=260000000000P PS=1415000U PD=2520000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 8 11 7 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112125000000P
+ PS=1820000U PD=995000U
* device instance $8 r0 *1 0.965,0.56 nfet_01v8
M$8 15 6 8 12 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=125125000000P
+ PS=995000U PD=1035000U
* device instance $9 r0 *1 1.5,0.56 nfet_01v8
M$9 14 5 15 12 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=169000000000P
+ PS=1035000U PD=1170000U
* device instance $10 r0 *1 2.17,0.56 nfet_01v8
M$10 11 4 14 12 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=105625000000P
+ PS=1170000U PD=975000U
* device instance $11 r0 *1 2.645,0.56 nfet_01v8
M$11 8 3 11 12 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=134875000000P
+ PS=975000U PD=1065000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 11 2 8 12 nfet_01v8 L=150000U W=650000U AS=134875000000P AD=169000000000P
+ PS=1065000U PD=1820000U
.ENDS sky130_fd_sc_hd__a311o_1

* cell sky130_fd_sc_hd__dfstp_1
* pin VGND
* pin SET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfstp_1 1 6 11 17 18 19 20 24
* net 1 VGND
* net 6 SET_B
* net 11 Q
* net 17 CLK
* net 18 D
* net 19 VPB
* net 20 VPWR
* device instance $1 r0 *1 6.925,2.275 pfet_01v8_hvt
M$1 8 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=122850000000P
+ AD=109200000000P PS=1170000U PD=1360000U
* device instance $2 r0 *1 7.405,2.065 pfet_01v8_hvt
M$2 9 8 20 19 pfet_01v8_hvt L=150000U W=840000U AS=122850000000P
+ AD=218400000000P PS=1170000U PD=2200000U
* device instance $3 r0 *1 0.47,2.135 pfet_01v8_hvt
M$3 20 17 2 19 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $4 r0 *1 0.89,2.135 pfet_01v8_hvt
M$4 3 2 20 19 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $5 r0 *1 1.83,2.065 pfet_01v8_hvt
M$5 4 18 20 19 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=124950000000P PS=2200000U PD=1175000U
* device instance $6 r0 *1 2.315,2.275 pfet_01v8_hvt
M$6 5 3 4 19 pfet_01v8_hvt L=150000U W=420000U AS=124950000000P AD=56700000000P
+ PS=1175000U PD=690000U
* device instance $7 r0 *1 2.735,2.275 pfet_01v8_hvt
M$7 21 2 5 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=94500000000P
+ PS=690000U PD=870000U
* device instance $8 r0 *1 3.335,2.275 pfet_01v8_hvt
M$8 20 7 21 19 pfet_01v8_hvt L=150000U W=420000U AS=94500000000P
+ AD=79800000000P PS=870000U PD=800000U
* device instance $9 r0 *1 3.865,2.275 pfet_01v8_hvt
M$9 7 6 20 19 pfet_01v8_hvt L=150000U W=420000U AS=79800000000P AD=56700000000P
+ PS=800000U PD=690000U
* device instance $10 r0 *1 4.285,2.275 pfet_01v8_hvt
M$10 20 5 7 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $11 r0 *1 4.705,2.275 pfet_01v8_hvt
M$11 22 5 20 19 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=48300000000P PS=690000U PD=650000U
* device instance $12 r0 *1 5.085,2.275 pfet_01v8_hvt
M$12 8 2 22 19 pfet_01v8_hvt L=150000U W=420000U AS=48300000000P
+ AD=81900000000P PS=650000U PD=810000U
* device instance $13 r0 *1 5.625,2.275 pfet_01v8_hvt
M$13 23 3 8 19 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P
+ AD=44100000000P PS=810000U PD=630000U
* device instance $14 r0 *1 5.985,2.275 pfet_01v8_hvt
M$14 20 9 23 19 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=109200000000P PS=630000U PD=1360000U
* device instance $15 r0 *1 8.345,2.165 pfet_01v8_hvt
M$15 10 8 20 19 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=166400000000P PS=1325000U PD=1800000U
* device instance $16 r0 *1 8.82,1.985 pfet_01v8_hvt
M$16 11 10 20 19 pfet_01v8_hvt L=150000U W=1000000U AS=149000000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $17 r0 *1 8.345,0.445 nfet_01v8
M$17 1 8 10 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $18 r0 *1 8.82,0.56 nfet_01v8
M$18 11 10 1 24 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $19 r0 *1 2.305,0.415 nfet_01v8
M$19 5 2 4 24 nfet_01v8 L=150000U W=360000U AS=93500000000P AD=72000000000P
+ PS=965000U PD=760000U
* device instance $20 r0 *1 2.855,0.415 nfet_01v8
M$20 14 3 5 24 nfet_01v8 L=150000U W=360000U AS=72000000000P AD=67050000000P
+ PS=760000U PD=750000U
* device instance $21 r0 *1 3.335,0.445 nfet_01v8
M$21 1 7 14 24 nfet_01v8 L=150000U W=420000U AS=67050000000P AD=88200000000P
+ PS=750000U PD=840000U
* device instance $22 r0 *1 3.905,0.445 nfet_01v8
M$22 16 6 1 24 nfet_01v8 L=150000U W=420000U AS=88200000000P AD=44100000000P
+ PS=840000U PD=630000U
* device instance $23 r0 *1 4.265,0.445 nfet_01v8
M$23 7 5 16 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=109200000000P
+ PS=630000U PD=1360000U
* device instance $24 r0 *1 1.83,0.555 nfet_01v8
M$24 4 18 1 24 nfet_01v8 L=150000U W=640000U AS=166400000000P AD=93500000000P
+ PS=1800000U PD=965000U
* device instance $25 r0 *1 0.47,0.445 nfet_01v8
M$25 1 17 2 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $26 r0 *1 0.89,0.445 nfet_01v8
M$26 3 2 1 24 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $27 r0 *1 5.205,0.445 nfet_01v8
M$27 15 5 1 24 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $28 r0 *1 5.565,0.445 nfet_01v8
M$28 8 3 15 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $29 r0 *1 6.045,0.445 nfet_01v8
M$29 12 2 8 24 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $30 r0 *1 6.405,0.445 nfet_01v8
M$30 13 9 12 24 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=48300000000P
+ PS=630000U PD=650000U
* device instance $31 r0 *1 6.785,0.445 nfet_01v8
M$31 1 6 13 24 nfet_01v8 L=150000U W=420000U AS=48300000000P AD=113700000000P
+ PS=650000U PD=1010000U
* device instance $32 r0 *1 7.405,0.505 nfet_01v8
M$32 9 8 1 24 nfet_01v8 L=150000U W=540000U AS=113700000000P AD=140400000000P
+ PS=1010000U PD=1600000U
.ENDS sky130_fd_sc_hd__dfstp_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__xnor2_4
* pin VGND
* pin B
* pin A
* pin Y
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_4 1 2 3 7 8 10 11
* net 1 VGND
* net 2 B
* net 3 A
* net 7 Y
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.435,1.985 pfet_01v8_hvt
M$1 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 6.115,1.985 pfet_01v8_hvt
M$5 7 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 8.335,1.985 pfet_01v8_hvt
M$9 8 5 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $13 r0 *1 0.545,1.985 pfet_01v8_hvt
M$13 8 2 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $17 r0 *1 2.225,1.985 pfet_01v8_hvt
M$17 8 3 5 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.335,0.56 nfet_01v8
M$21 7 5 6 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.435,0.56 nfet_01v8
M$25 6 3 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.115,0.56 nfet_01v8
M$29 6 2 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.545,0.56 nfet_01v8
M$33 5 2 4 11 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=351000000000P
+ PS=4620000U PD=3680000U
* device instance $37 r0 *1 2.225,0.56 nfet_01v8
M$37 1 3 4 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xnor2_4

* cell sky130_fd_sc_hd__nor3b_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_2 1 2 3 4 6 9 10 11
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 6 C_N
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 2 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=415000000000P PS=3830000U PD=3830000U
* device instance $3 r0 *1 0.49,1.985 pfet_01v8_hvt
M$3 9 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $5 r0 *1 1.33,1.985 pfet_01v8_hvt
M$5 8 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $7 r0 *1 4.13,1.695 pfet_01v8_hvt
M$7 9 6 5 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $8 r0 *1 4.13,0.675 nfet_01v8
M$8 1 6 5 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=269750000000P
+ PS=2740000U PD=2780000U
* device instance $11 r0 *1 0.49,0.56 nfet_01v8
M$11 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $13 r0 *1 1.33,0.56 nfet_01v8
M$13 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nor3b_2

* cell sky130_fd_sc_hd__xor2_2
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_2 1 3 4 6 8 10 11
* net 1 VGND
* net 3 A
* net 4 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 4.94,1.985 pfet_01v8_hvt
M$1 6 2 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=415000000000P PS=3790000U PD=3830000U
* device instance $3 r0 *1 2.685,1.985 pfet_01v8_hvt
M$3 8 3 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 3.525,1.985 pfet_01v8_hvt
M$5 8 4 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=422500000000P PS=2595000U PD=3845000U
* device instance $7 r0 *1 0.485,1.985 pfet_01v8_hvt
M$7 8 3 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=410000000000P
+ AD=270000000000P PS=3820000U PD=2540000U
* device instance $9 r0 *1 1.325,1.985 pfet_01v8_hvt
M$9 2 4 7 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 4.94,0.56 nfet_01v8
M$11 6 2 1 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=256750000000P
+ PS=2740000U PD=2740000U
* device instance $13 r0 *1 2.685,0.56 nfet_01v8
M$13 1 3 5 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 3.525,0.56 nfet_01v8
M$15 6 4 5 11 nfet_01v8 L=150000U W=1300000U AS=193375000000P AD=274625000000P
+ PS=1895000U PD=2795000U
* device instance $17 r0 *1 0.485,0.56 nfet_01v8
M$17 2 3 1 11 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=175500000000P
+ PS=2770000U PD=1840000U
* device instance $19 r0 *1 1.325,0.56 nfet_01v8
M$19 2 4 1 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__xor2_2

* cell sky130_fd_sc_hd__nand4b_4
* pin VGND
* pin D
* pin Y
* pin A_N
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_4 1 2 5 8 9 10 11 12 13
* net 1 VGND
* net 2 D
* net 5 Y
* net 8 A_N
* net 9 B
* net 10 C
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 3.09,1.985 pfet_01v8_hvt
M$5 5 9 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 5.29,1.985 pfet_01v8_hvt
M$9 5 10 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=540000000000P PS=5600000U PD=5080000U
* device instance $13 r0 *1 6.97,1.985 pfet_01v8_hvt
M$13 5 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.47,1.985 pfet_01v8_hvt
M$17 11 8 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $18 r0 *1 5.29,0.56 nfet_01v8
M$18 6 10 7 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.97,0.56 nfet_01v8
M$22 1 2 7 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 8 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $27 r0 *1 1.41,0.56 nfet_01v8
M$27 5 3 4 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 3.09,0.56 nfet_01v8
M$31 6 9 4 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4b_4

* cell sky130_fd_sc_hd__a211oi_4
* pin VGND
* pin A2
* pin A1
* pin Y
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_4 1 2 4 5 6 7 8 9 14
* net 1 VGND
* net 2 A2
* net 4 A1
* net 5 Y
* net 6 B1
* net 7 C1
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 10 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 10 4 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 3.83,1.985 pfet_01v8_hvt
M$9 11 6 10 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $11 r0 *1 4.67,1.985 pfet_01v8_hvt
M$11 13 6 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=150000000000P PS=1270000U PD=1300000U
* device instance $12 r0 *1 5.12,1.985 pfet_01v8_hvt
M$12 5 7 13 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=140000000000P PS=1300000U PD=1280000U
* device instance $13 r0 *1 5.55,1.985 pfet_01v8_hvt
M$13 11 7 5 9 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=290000000000P PS=2560000U PD=2580000U
* device instance $15 r0 *1 6.43,1.985 pfet_01v8_hvt
M$15 12 7 5 9 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=155000000000P PS=1300000U PD=1310000U
* device instance $16 r0 *1 6.89,1.985 pfet_01v8_hvt
M$16 10 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $17 r0 *1 0.47,0.56 nfet_01v8
M$17 3 2 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $20 r0 *1 1.73,0.56 nfet_01v8
M$20 5 4 3 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.83,0.56 nfet_01v8
M$25 5 6 1 14 nfet_01v8 L=150000U W=2600000U AS=378625000000P AD=477750000000P
+ PS=3765000U PD=4720000U
* device instance $28 r0 *1 5.17,0.56 nfet_01v8
M$28 1 7 5 14 nfet_01v8 L=150000U W=2600000U AS=352625000000P AD=354250000000P
+ PS=3685000U PD=3690000U
.ENDS sky130_fd_sc_hd__a211oi_4

* cell sky130_fd_sc_hd__mux2i_2
* pin VGND
* pin S
* pin A0
* pin A1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_2 1 2 6 7 8 11 12 13
* net 1 VGND
* net 2 S
* net 6 A0
* net 7 A1
* net 8 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 3.09,1.985 pfet_01v8_hvt
M$1 9 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=290000000000P PS=3790000U PD=2580000U
* device instance $3 r0 *1 3.97,1.985 pfet_01v8_hvt
M$3 10 7 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=592500000000P PS=2585000U PD=4185000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 9 2 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $8 r0 *1 1.73,1.985 pfet_01v8_hvt
M$8 10 3 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 3.09,0.56 nfet_01v8
M$10 5 6 11 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=188500000000P
+ PS=2740000U PD=1880000U
* device instance $12 r0 *1 3.97,0.56 nfet_01v8
M$12 4 7 11 13 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=385125000000P
+ PS=1885000U PD=3135000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 2 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 0.89,0.56 nfet_01v8
M$15 4 2 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 1.73,0.56 nfet_01v8
M$17 5 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__mux2i_2

* cell sky130_fd_sc_hd__o21ai_2
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_2 1 2 3 4 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 7 VGND
* net 8 Y
* net 9 VPWR
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 6 2 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=440000000000P
+ AD=300000000000P PS=3880000U PD=2600000U
* device instance $2 r0 *1 0.915,1.985 pfet_01v8_hvt
M$2 8 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=315000000000P PS=2560000U PD=2630000U
* device instance $5 r0 *1 2.315,1.985 pfet_01v8_hvt
M$5 8 4 9 1 pfet_01v8_hvt L=150000U W=2000000U AS=300000000000P
+ AD=405000000000P PS=2600000U PD=3810000U
* device instance $7 r0 *1 0.485,0.56 nfet_01v8
M$7 7 2 5 10 nfet_01v8 L=150000U W=1300000U AS=299000000000P AD=182000000000P
+ PS=2870000U PD=1860000U
* device instance $8 r0 *1 0.915,0.56 nfet_01v8
M$8 5 3 7 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=217750000000P
+ PS=1860000U PD=1970000U
* device instance $11 r0 *1 2.315,0.56 nfet_01v8
M$11 8 4 5 10 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__o21ai_2

* cell sky130_fd_sc_hd__a22o_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a22o_1 1 2 3 4 5 6 9 10 11
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 VGND
* net 9 X
* net 10 VPWR
* device instance $1 r0 *1 1.82,1.985 pfet_01v8_hvt
M$1 7 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=252900000000P
+ AD=160000000000P PS=2520000U PD=1320000U
* device instance $2 r0 *1 2.29,1.985 pfet_01v8_hvt
M$2 10 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=155000000000P PS=1320000U PD=1310000U
* device instance $3 r0 *1 2.75,1.985 pfet_01v8_hvt
M$3 9 8 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=260000000000P PS=1310000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=252850000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 1.79,0.56 nfet_01v8
M$6 12 4 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=113750000000P
+ PS=1820000U PD=1000000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 5 12 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=100750000000P
+ PS=1000000U PD=960000U
* device instance $8 r0 *1 2.75,0.56 nfet_01v8
M$8 9 8 6 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=169000000000P
+ PS=960000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 13 2 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $10 r0 *1 0.85,0.56 nfet_01v8
M$10 8 3 13 11 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22o_1

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__o221a_1
* pin VGND
* pin X
* pin C1
* pin B1
* pin B2
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o221a_1 1 5 6 7 8 9 10 11 12 15
* net 1 VGND
* net 5 X
* net 6 C1
* net 7 B1
* net 8 B2
* net 9 A2
* net 10 A1
* net 11 VPB
* net 12 VPWR
* device instance $1 r0 *1 0.67,1.985 pfet_01v8_hvt
M$1 12 6 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=340000000000P
+ AD=165000000000P PS=2680000U PD=1330000U
* device instance $2 r0 *1 1.15,1.985 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $3 r0 *1 1.51,1.985 pfet_01v8_hvt
M$3 2 8 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=412500000000P PS=1210000U PD=1825000U
* device instance $4 r0 *1 2.485,1.985 pfet_01v8_hvt
M$4 14 9 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=412500000000P
+ AD=105000000000P PS=1825000U PD=1210000U
* device instance $5 r0 *1 2.845,1.985 pfet_01v8_hvt
M$5 12 10 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $6 r0 *1 3.325,1.985 pfet_01v8_hvt
M$6 5 2 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=280000000000P PS=1330000U PD=2560000U
* device instance $7 r0 *1 2.485,0.56 nfet_01v8
M$7 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.905,0.56 nfet_01v8
M$8 1 10 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 3.325,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
* device instance $10 r0 *1 0.67,0.56 nfet_01v8
M$10 3 6 2 15 nfet_01v8 L=150000U W=650000U AS=201500000000P AD=99125000000P
+ PS=1920000U PD=955000U
* device instance $11 r0 *1 1.125,0.56 nfet_01v8
M$11 4 7 3 15 nfet_01v8 L=150000U W=650000U AS=99125000000P AD=87750000000P
+ PS=955000U PD=920000U
* device instance $12 r0 *1 1.545,0.56 nfet_01v8
M$12 3 8 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o221a_1

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__dfrtp_2
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_2 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=2000000U AS=436200000000P
+ AD=395000000000P PS=3930000U PD=3790000U
* device instance $3 r0 *1 5.35,2.065 pfet_01v8_hvt
M$3 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $4 r0 *1 5.845,2.275 pfet_01v8_hvt
M$4 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $5 r0 *1 6.275,2.275 pfet_01v8_hvt
M$5 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $6 r0 *1 6.695,2.275 pfet_01v8_hvt
M$6 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $7 r0 *1 7.235,2.275 pfet_01v8_hvt
M$7 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $8 r0 *1 7.655,2.275 pfet_01v8_hvt
M$8 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $9 r0 *1 2.225,2.275 pfet_01v8_hvt
M$9 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $10 r0 *1 2.685,2.275 pfet_01v8_hvt
M$10 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $11 r0 *1 3.18,2.275 pfet_01v8_hvt
M$11 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $12 r0 *1 3.88,2.275 pfet_01v8_hvt
M$12 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $13 r0 *1 4.365,2.275 pfet_01v8_hvt
M$13 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $14 r0 *1 0.47,2.135 pfet_01v8_hvt
M$14 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $15 r0 *1 0.89,2.135 pfet_01v8_hvt
M$15 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $16 r0 *1 8.73,0.56 nfet_01v8
M$16 9 8 1 21 nfet_01v8 L=150000U W=1300000U AS=296450000000P AD=256750000000P
+ PS=2940000U PD=2740000U
* device instance $18 r0 *1 0.47,0.445 nfet_01v8
M$18 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $19 r0 *1 0.89,0.445 nfet_01v8
M$19 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 2.64,0.415 nfet_01v8
M$20 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $21 r0 *1 3.12,0.415 nfet_01v8
M$21 11 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $22 r0 *1 5.465,0.415 nfet_01v8
M$22 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $23 r0 *1 6.01,0.415 nfet_01v8
M$23 12 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $24 r0 *1 2.165,0.445 nfet_01v8
M$24 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $25 r0 *1 3.95,0.445 nfet_01v8
M$25 13 16 11 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $26 r0 *1 4.31,0.445 nfet_01v8
M$26 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $27 r0 *1 6.49,0.445 nfet_01v8
M$27 1 8 12 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $28 r0 *1 7.235,0.445 nfet_01v8
M$28 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $29 r0 *1 7.69,0.445 nfet_01v8
M$29 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $30 r0 *1 4.97,0.555 nfet_01v8
M$30 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_2

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__xor2_4
* pin VGND
* pin A
* pin B
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__xor2_4 1 2 3 6 8 10 11
* net 1 VGND
* net 2 A
* net 3 B
* net 6 X
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 8.255,1.985 pfet_01v8_hvt
M$1 9 4 6 10 pfet_01v8_hvt L=150000U W=4000000U AS=677450000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 4.365,1.985 pfet_01v8_hvt
M$5 8 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 6.045,1.985 pfet_01v8_hvt
M$9 8 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=661800000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.485,1.985 pfet_01v8_hvt
M$13 8 2 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=680000000000P
+ AD=540000000000P PS=6360000U PD=5080000U
* device instance $17 r0 *1 2.165,1.985 pfet_01v8_hvt
M$17 4 3 7 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 8.255,0.56 nfet_01v8
M$21 6 4 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $25 r0 *1 4.365,0.56 nfet_01v8
M$25 6 3 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 6.045,0.56 nfet_01v8
M$29 1 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $33 r0 *1 0.485,0.56 nfet_01v8
M$33 4 2 1 11 nfet_01v8 L=150000U W=2600000U AS=442000000000P AD=351000000000P
+ PS=4610000U PD=3680000U
* device instance $37 r0 *1 2.165,0.56 nfet_01v8
M$37 4 3 1 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__xor2_4
