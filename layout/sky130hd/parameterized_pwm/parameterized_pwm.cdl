* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_pwm clk div[0] div[10] div[11] div[12]
+ div[13] div[14] div[15] div[1] div[2] div[3] div[4] div[5]
+ div[6] div[7] div[8] div[9] duty[0] duty[1] duty[2] duty[3]
+ duty[4] duty[5] duty[6] duty[7] enable pwm_out rst_n
X_211_ net1 VSS VSS VDD VDD _138_ sky130_fd_sc_hd__inv_1
X_212_ div_counter\[1\] VSS VSS VDD VDD _141_ sky130_fd_sc_hd__inv_1
X_213_ div_counter\[3\] VSS VSS VDD VDD _144_ sky130_fd_sc_hd__inv_1
X_214_ div_counter\[2\] VSS VSS VDD VDD _147_ sky130_fd_sc_hd__inv_1
X_215_ div_counter\[7\] VSS VSS VDD VDD _150_ sky130_fd_sc_hd__inv_1
X_216_ div_counter\[6\] VSS VSS VDD VDD _153_ sky130_fd_sc_hd__inv_1
X_217_ div_counter\[5\] VSS VSS VDD VDD _156_ sky130_fd_sc_hd__inv_1
X_218_ div_counter\[4\] VSS VSS VDD VDD _159_ sky130_fd_sc_hd__inv_1
X_219_ div_counter\[15\] VSS VSS VDD VDD _162_ sky130_fd_sc_hd__inv_1
X_220_ div_counter\[14\] VSS VSS VDD VDD _165_ sky130_fd_sc_hd__inv_1
X_221_ div_counter\[13\] VSS VSS VDD VDD _168_ sky130_fd_sc_hd__inv_1
X_222_ div_counter\[12\] VSS VSS VDD VDD _171_ sky130_fd_sc_hd__inv_1
X_223_ div_counter\[11\] VSS VSS VDD VDD _174_ sky130_fd_sc_hd__inv_1
X_224_ div_counter\[10\] VSS VSS VDD VDD _177_ sky130_fd_sc_hd__inv_1
X_225_ div_counter\[9\] VSS VSS VDD VDD _180_ sky130_fd_sc_hd__inv_1
X_226_ div_counter\[8\] VSS VSS VDD VDD _183_ sky130_fd_sc_hd__inv_1
X_227_ net24 VSS VSS VDD VDD _190_ sky130_fd_sc_hd__inv_1
X_228_ net23 VSS VSS VDD VDD _193_ sky130_fd_sc_hd__inv_1
X_229_ net22 VSS VSS VDD VDD _196_ sky130_fd_sc_hd__inv_1
X_230_ net21 VSS VSS VDD VDD _199_ sky130_fd_sc_hd__inv_1
X_231_ net20 VSS VSS VDD VDD _202_ sky130_fd_sc_hd__inv_1
X_232_ net19 VSS VSS VDD VDD _205_ sky130_fd_sc_hd__inv_1
X_233_ net18 VSS VSS VDD VDD _208_ sky130_fd_sc_hd__inv_1
X_234_ _164_ _173_ _170_ _167_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nand4_2
X_235_ _182_ _184_ _181_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__a21oi_1
X_236_ _176_ _179_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nand2_1
X_237_ _176_ _178_ _175_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a21oi_1
X_238_ _026_ _027_ _028_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__o21ai_0
X_239_ _025_ _029_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nand2b_2
X_240_ _139_ _143_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nor2b_1
X_241_ _142_ _031_ _146_ _149_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__o211ai_1
X_242_ _146_ _148_ _145_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_243_ _176_ _185_ _182_ _179_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand4_2
X_244_ _152_ _161_ _158_ _155_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nand4_1
X_245_ _032_ _033_ _025_ _034_ _035_ VSS VSS VDD VDD _036_
+ sky130_fd_sc_hd__a2111o_2
X_246_ _025_ _034_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2_1
X_247_ _152_ _155_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2_1
X_248_ _158_ _160_ _157_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__a21oi_1
X_249_ _152_ _154_ _151_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__a21oi_1
X_250_ _038_ _039_ _040_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o21ai_1
X_251_ _170_ _167_ _172_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nand3_1
X_252_ _167_ _169_ _166_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__a21oi_1
X_253_ _042_ _043_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nand2_1
X_254_ _037_ _041_ _044_ _164_ _163_ VSS VSS VDD VDD _045_
+ sky130_fd_sc_hd__a221oi_4
X_255_ net16 net15 net3 net6 VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nor4_1
X_256_ net2 net5 net4 net7 VSS VSS VDD VDD _047_ sky130_fd_sc_hd__nor4_1
X_257_ _046_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__nand2_1
X_258_ net8 net1 net10 net13 VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nor4_1
X_259_ net9 net12 net11 net14 VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nor4_1
X_260_ _049_ _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand2_1
X_261_ _143_ _140_ _146_ _149_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nand4_1
X_262_ _025_ _034_ _035_ _052_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__nor4_2
X_263_ _048_ _051_ _053_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__o21bai_1
X_264_ _030_ _036_ _045_ _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__a31oi_4
X_265_ _055_ net25 VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nand2b_1
X_266_ counter\[2\] counter\[3\] _186_ VSS VSS VDD VDD _057_
+ sky130_fd_sc_hd__and3_1
X_267_ counter\[4\] counter\[5\] _057_ VSS VSS VDD VDD _058_
+ sky130_fd_sc_hd__and3_1
X_268_ counter\[6\] counter\[7\] _058_ VSS VSS VDD VDD _059_
+ sky130_fd_sc_hd__and3_1
X_269_ counter\[0\] _059_ net26 VSS VSS VDD VDD _060_ sky130_fd_sc_hd__or3b_1
X_270_ net25 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__clkinv_2
X_271_ _055_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__buf_6
X_272_ net26 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__buf_2
X_273_ _061_ _062_ counter\[0\] _063_ VSS VSS VDD VDD _064_
+ sky130_fd_sc_hd__o211ai_1
X_274_ _056_ _060_ _064_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o21ai_0
X_275_ net26 _187_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nand2_1
X_276_ _061_ _062_ counter\[1\] _063_ VSS VSS VDD VDD _066_
+ sky130_fd_sc_hd__o211ai_1
X_277_ _056_ _065_ _066_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o21ai_0
X_278_ net25 VSS VSS VDD VDD _067_ sky130_fd_sc_hd__buf_2
X_279_ _067_ _186_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nand2_1
X_280_ _062_ _068_ counter\[2\] VSS VSS VDD VDD _069_ sky130_fd_sc_hd__o21ai_0
X_281_ counter\[2\] _062_ _068_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__or3_1
X_282_ _069_ _070_ _063_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__a21boi_0
X_283_ counter\[2\] counter\[0\] counter\[1\] VSS VSS VDD
+ VDD _071_ sky130_fd_sc_hd__and3_1
X_284_ _061_ counter\[3\] _055_ _071_ VSS VSS VDD VDD _072_
+ sky130_fd_sc_hd__or4b_1
X_285_ _059_ _071_ _067_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__o21ai_0
X_286_ _062_ _073_ counter\[3\] VSS VSS VDD VDD _074_ sky130_fd_sc_hd__o21ai_0
X_287_ _072_ _074_ _063_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__a21boi_0
X_288_ _067_ _057_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nand2_1
X_289_ _062_ _075_ counter\[4\] VSS VSS VDD VDD _076_ sky130_fd_sc_hd__o21ai_0
X_290_ counter\[4\] _062_ _075_ VSS VSS VDD VDD _077_ sky130_fd_sc_hd__or3_1
X_291_ _076_ _077_ _063_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__a21boi_0
X_292_ counter\[4\] counter\[3\] _071_ VSS VSS VDD VDD _078_
+ sky130_fd_sc_hd__and3_1
X_293_ _061_ counter\[5\] _055_ _078_ VSS VSS VDD VDD _079_
+ sky130_fd_sc_hd__or4b_1
X_294_ _059_ _078_ _067_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__o21ai_0
X_295_ _062_ _080_ counter\[5\] VSS VSS VDD VDD _081_ sky130_fd_sc_hd__o21ai_0
X_296_ _079_ _081_ _063_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__a21boi_0
X_297_ _067_ _058_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__nand2_1
X_298_ _062_ _082_ counter\[6\] VSS VSS VDD VDD _083_ sky130_fd_sc_hd__o21ai_0
X_299_ counter\[6\] _055_ _082_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__or3_1
X_300_ _083_ _084_ _063_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__a21boi_0
X_301_ net26 counter\[6\] VSS VSS VDD VDD _085_ sky130_fd_sc_hd__nand2_1
X_302_ counter\[5\] _078_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nand2_1
X_303_ counter\[5\] _078_ _058_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__a21oi_1
X_304_ _067_ counter\[6\] VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nand2_1
X_305_ _062_ _087_ _088_ counter\[7\] _063_ VSS VSS VDD VDD
+ _089_ sky130_fd_sc_hd__o311ai_0
X_306_ counter\[7\] _056_ _085_ _086_ _089_ VSS VSS VDD VDD
+ _007_ sky130_fd_sc_hd__o41ai_1
X_307_ _030_ _036_ _045_ _053_ VSS VSS VDD VDD _090_ sky130_fd_sc_hd__a31oi_4
X_308_ _061_ div_counter\[0\] _090_ VSS VSS VDD VDD _091_
+ sky130_fd_sc_hd__nor3b_1
X_309_ _067_ div_counter\[0\] VSS VSS VDD VDD _092_ sky130_fd_sc_hd__nor2b_1
X_310_ _091_ _092_ _063_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o21a_1
X_311_ net25 _188_ VSS VSS VDD VDD _093_ sky130_fd_sc_hd__nand2_1
X_312_ div_counter\[2\] div_counter\[3\] div_counter\[4\]
+ VSS VSS VDD VDD _094_ sky130_fd_sc_hd__nand3_2
X_313_ div_counter\[5\] div_counter\[6\] div_counter\[7\]
+ VSS VSS VDD VDD _095_ sky130_fd_sc_hd__nand3_1
X_314_ _093_ _094_ _095_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nor3_2
X_315_ div_counter\[8\] div_counter\[9\] _096_ VSS VSS VDD
+ VDD _097_ sky130_fd_sc_hd__nand3_1
X_316_ _177_ _097_ VSS VSS VDD VDD _098_ sky130_fd_sc_hd__xnor2_1
X_317_ _061_ _090_ net26 VSS VSS VDD VDD _099_ sky130_fd_sc_hd__o21ai_2
X_318_ _099_ VSS VSS VDD VDD _100_ sky130_fd_sc_hd__buf_2
X_319_ _098_ _100_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__nor2_1
X_320_ _183_ _180_ _177_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nor3_1
X_321_ net25 div_counter\[0\] div_counter\[1\] VSS VSS VDD
+ VDD _102_ sky130_fd_sc_hd__nand3_1
X_322_ _094_ _102_ VSS VSS VDD VDD _103_ sky130_fd_sc_hd__nor2_1
X_323_ _095_ _101_ _103_ VSS VSS VDD VDD _104_ sky130_fd_sc_hd__and3b_1
X_324_ div_counter\[11\] _104_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__xnor2_1
X_325_ _100_ _105_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nor2_1
X_326_ div_counter\[11\] _096_ _101_ VSS VSS VDD VDD _106_
+ sky130_fd_sc_hd__nand3_1
X_327_ _171_ _106_ VSS VSS VDD VDD _107_ sky130_fd_sc_hd__xnor2_1
X_328_ _100_ _107_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__nor2_1
X_329_ div_counter\[11\] div_counter\[12\] _104_ VSS VSS VDD
+ VDD _108_ sky130_fd_sc_hd__nand3_1
X_330_ _168_ _108_ VSS VSS VDD VDD _109_ sky130_fd_sc_hd__xnor2_1
X_331_ _100_ _109_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__nor2_1
X_332_ _174_ _171_ _168_ VSS VSS VDD VDD _110_ sky130_fd_sc_hd__nor3_1
X_333_ _096_ _101_ _110_ VSS VSS VDD VDD _111_ sky130_fd_sc_hd__nand3_1
X_334_ _165_ _111_ VSS VSS VDD VDD _112_ sky130_fd_sc_hd__xnor2_1
X_335_ _100_ _112_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__nor2_1
X_336_ div_counter\[14\] _104_ _110_ VSS VSS VDD VDD _113_
+ sky130_fd_sc_hd__nand3_1
X_337_ _162_ _113_ VSS VSS VDD VDD _114_ sky130_fd_sc_hd__xnor2_1
X_338_ _100_ _114_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nor2_1
X_339_ _061_ div_counter\[1\] VSS VSS VDD VDD _115_ sky130_fd_sc_hd__nand2_1
X_340_ _067_ _189_ _090_ VSS VSS VDD VDD _116_ sky130_fd_sc_hd__nand3_1
X_341_ _115_ _116_ net26 VSS VSS VDD VDD _015_ sky130_fd_sc_hd__a21boi_0
X_342_ _147_ _093_ VSS VSS VDD VDD _117_ sky130_fd_sc_hd__xnor2_1
X_343_ _100_ _117_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nor2_1
X_344_ _067_ div_counter\[0\] div_counter\[2\] div_counter\[1\]
+ VSS VSS VDD VDD _118_ sky130_fd_sc_hd__nand4_1
X_345_ _144_ _118_ VSS VSS VDD VDD _119_ sky130_fd_sc_hd__xnor2_1
X_346_ _100_ _119_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nor2_1
X_347_ _093_ _094_ VSS VSS VDD VDD _120_ sky130_fd_sc_hd__nor2_1
X_348_ _067_ _188_ div_counter\[2\] div_counter\[3\] div_counter\[4\]
+ VSS VSS VDD VDD _121_ sky130_fd_sc_hd__a41oi_1
X_349_ _120_ _099_ _121_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__nor3_1
X_350_ div_counter\[5\] _103_ VSS VSS VDD VDD _122_ sky130_fd_sc_hd__xnor2_1
X_351_ _100_ _122_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nor2_1
X_352_ div_counter\[5\] _120_ VSS VSS VDD VDD _123_ sky130_fd_sc_hd__nand2_1
X_353_ _153_ _123_ VSS VSS VDD VDD _124_ sky130_fd_sc_hd__xnor2_1
X_354_ _100_ _124_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nor2_1
X_355_ div_counter\[5\] div_counter\[6\] _103_ VSS VSS VDD
+ VDD _125_ sky130_fd_sc_hd__nand3_1
X_356_ _150_ _125_ VSS VSS VDD VDD _126_ sky130_fd_sc_hd__xnor2_1
X_357_ _099_ _126_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__nor2_1
X_358_ div_counter\[8\] _096_ VSS VSS VDD VDD _127_ sky130_fd_sc_hd__xnor2_1
X_359_ _099_ _127_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nor2_1
X_360_ _183_ _094_ _095_ _102_ VSS VSS VDD VDD _128_ sky130_fd_sc_hd__nor4_1
X_361_ div_counter\[9\] _128_ VSS VSS VDD VDD _129_ sky130_fd_sc_hd__xnor2_1
X_362_ _099_ _129_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nor2_1
X_363_ counter\[0\] net17 VSS VSS VDD VDD _130_ sky130_fd_sc_hd__nand2b_1
X_364_ _210_ _130_ _209_ VSS VSS VDD VDD _131_ sky130_fd_sc_hd__a21o_1
X_365_ _207_ _131_ _206_ VSS VSS VDD VDD _132_ sky130_fd_sc_hd__a21o_1
X_366_ _204_ _132_ _203_ _200_ VSS VSS VDD VDD _133_ sky130_fd_sc_hd__a211oi_1
X_367_ _200_ _201_ _198_ VSS VSS VDD VDD _134_ sky130_fd_sc_hd__o21ai_0
X_368_ _133_ _134_ _197_ VSS VSS VDD VDD _135_ sky130_fd_sc_hd__o21bai_1
X_369_ _192_ _194_ _191_ _061_ VSS VSS VDD VDD _136_ sky130_fd_sc_hd__a211oi_1
X_370_ _063_ _136_ VSS VSS VDD VDD _137_ sky130_fd_sc_hd__nand2_1
X_371_ _192_ _195_ _135_ _137_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a31oi_1
X_372_ _138_ div_counter\[0\] VSS VSS VDD VDD _139_ _140_
+ sky130_fd_sc_hd__ha_1
X_373_ net8 _141_ VSS VSS VDD VDD _142_ _143_ sky130_fd_sc_hd__ha_1
X_374_ net10 _144_ VSS VSS VDD VDD _145_ _146_ sky130_fd_sc_hd__ha_1
X_375_ net9 _147_ VSS VSS VDD VDD _148_ _149_ sky130_fd_sc_hd__ha_1
X_376_ net14 _150_ VSS VSS VDD VDD _151_ _152_ sky130_fd_sc_hd__ha_1
X_377_ net13 _153_ VSS VSS VDD VDD _154_ _155_ sky130_fd_sc_hd__ha_1
X_378_ net12 _156_ VSS VSS VDD VDD _157_ _158_ sky130_fd_sc_hd__ha_1
X_379_ net11 _159_ VSS VSS VDD VDD _160_ _161_ sky130_fd_sc_hd__ha_1
X_380_ net7 _162_ VSS VSS VDD VDD _163_ _164_ sky130_fd_sc_hd__ha_1
X_381_ net6 _165_ VSS VSS VDD VDD _166_ _167_ sky130_fd_sc_hd__ha_1
X_382_ net5 _168_ VSS VSS VDD VDD _169_ _170_ sky130_fd_sc_hd__ha_1
X_383_ net4 _171_ VSS VSS VDD VDD _172_ _173_ sky130_fd_sc_hd__ha_1
X_384_ net3 _174_ VSS VSS VDD VDD _175_ _176_ sky130_fd_sc_hd__ha_1
X_385_ net2 _177_ VSS VSS VDD VDD _178_ _179_ sky130_fd_sc_hd__ha_1
X_386_ net16 _180_ VSS VSS VDD VDD _181_ _182_ sky130_fd_sc_hd__ha_1
X_387_ net15 _183_ VSS VSS VDD VDD _184_ _185_ sky130_fd_sc_hd__ha_1
X_388_ counter\[0\] counter\[1\] VSS VSS VDD VDD _186_ _187_
+ sky130_fd_sc_hd__ha_1
X_389_ div_counter\[0\] div_counter\[1\] VSS VSS VDD VDD _188_
+ _189_ sky130_fd_sc_hd__ha_1
X_390_ counter\[7\] _190_ VSS VSS VDD VDD _191_ _192_ sky130_fd_sc_hd__ha_1
X_391_ counter\[6\] _193_ VSS VSS VDD VDD _194_ _195_ sky130_fd_sc_hd__ha_1
X_392_ counter\[5\] _196_ VSS VSS VDD VDD _197_ _198_ sky130_fd_sc_hd__ha_1
X_393_ counter\[4\] _199_ VSS VSS VDD VDD _200_ _201_ sky130_fd_sc_hd__ha_1
X_394_ counter\[3\] _202_ VSS VSS VDD VDD _203_ _204_ sky130_fd_sc_hd__ha_1
X_395_ counter\[2\] _205_ VSS VSS VDD VDD _206_ _207_ sky130_fd_sc_hd__ha_1
X_396_ counter\[1\] _208_ VSS VSS VDD VDD _209_ _210_ sky130_fd_sc_hd__ha_1
Xcounter\[0\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _000_ VSS
+ VSS VDD VDD counter\[0\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[1\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _001_ VSS
+ VSS VDD VDD counter\[1\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[2\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _002_ VSS
+ VSS VDD VDD counter\[2\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[3\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _003_ VSS
+ VSS VDD VDD counter\[3\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[4\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _004_ VSS
+ VSS VDD VDD counter\[4\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[5\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _005_ VSS
+ VSS VDD VDD counter\[5\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[6\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _006_ VSS
+ VSS VDD VDD counter\[6\] sky130_fd_sc_hd__dfxtp_1
Xcounter\[7\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _007_ VSS
+ VSS VDD VDD counter\[7\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[0\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _008_
+ VSS VSS VDD VDD div_counter\[0\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[10\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _009_
+ VSS VSS VDD VDD div_counter\[10\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[11\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _010_
+ VSS VSS VDD VDD div_counter\[11\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[12\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _011_
+ VSS VSS VDD VDD div_counter\[12\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[13\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _012_
+ VSS VSS VDD VDD div_counter\[13\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[14\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _013_
+ VSS VSS VDD VDD div_counter\[14\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[15\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _014_
+ VSS VSS VDD VDD div_counter\[15\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[1\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _015_
+ VSS VSS VDD VDD div_counter\[1\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[2\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _016_
+ VSS VSS VDD VDD div_counter\[2\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[3\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _017_
+ VSS VSS VDD VDD div_counter\[3\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[4\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _018_
+ VSS VSS VDD VDD div_counter\[4\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[5\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _019_
+ VSS VSS VDD VDD div_counter\[5\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[6\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _020_
+ VSS VSS VDD VDD div_counter\[6\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[7\]$_SDFFE_PN0P_ clknet_1_1__leaf_clk _021_
+ VSS VSS VDD VDD div_counter\[7\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[8\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _022_
+ VSS VSS VDD VDD div_counter\[8\] sky130_fd_sc_hd__dfxtp_1
Xdiv_counter\[9\]$_SDFFE_PN0P_ clknet_1_0__leaf_clk _023_
+ VSS VSS VDD VDD div_counter\[9\] sky130_fd_sc_hd__dfxtp_1
Xpwm_reg$_SDFF_PN0_ clknet_1_1__leaf_clk _024_ VSS VSS VDD
+ VDD net27 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 div[0] VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkbuf_1
Xinput2 div[10] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput3 div[11] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput4 div[12] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput5 div[13] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput6 div[14] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput7 div[15] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput8 div[1] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput9 div[2] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput10 div[3] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput11 div[4] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput12 div[5] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput13 div[6] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput14 div[7] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput15 div[8] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput16 div[9] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput17 duty[0] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput18 duty[1] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput19 duty[2] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput20 duty[3] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput21 duty[4] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput22 duty[5] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput23 duty[6] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput24 duty[7] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput25 enable VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_2
Xinput26 rst_n VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_2
Xoutput27 net27 VSS VSS VDD VDD pwm_out sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
.ENDS parameterized_pwm
