* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pipelined_fifo almost_empty almost_full clk data_count[0]
+ data_count[1] data_count[2] data_count[3] data_count[4] empty
+ full rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[3] rd_data[4] rd_data[5] rd_data[6] rd_data[7] rd_data[8]
+ rd_data[9] rd_en rst_n wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[3] wr_data[4] wr_data[5] wr_data[6]
+ wr_data[7] wr_data[8] wr_data[9] wr_en
X_166_ _125_ _130_ VDD VSS INV_X1
X_167_ _137_ _164_ VDD VSS INV_X1
X_168_ _162_ _105_ VDD VSS BUF_X2
X_169_ _105_ _124_ _106_ VDD VSS XNOR2_X2
X_170_ _106_ _143_ VDD VSS INV_X1
X_171_ _159_ _107_ VDD VSS BUF_X4
X_172_ _107_ _108_ VDD VSS INV_X1
X_173_ _136_ _123_ VDD VSS INV_X1
X_174_ _105_ _123_ _135_ _109_ VDD VSS NAND3_X2
X_175_ _161_ _163_ _105_ _110_ VDD VSS AOI21_X4
X_176_ _108_ _109_ _110_ _111_ VDD VSS AOI21_X4
X_177_ _105_ _123_ _135_ _023_ VDD VSS AND3_X1
X_178_ _110_ _024_ VDD VSS INV_X1
X_179_ _107_ _023_ _024_ _025_ VDD VSS NOR3_X4
X_180_ _111_ _025_ _146_ VDD VSS NOR2_X2
X_181_ pipeline_count\[1\] pipeline_count\[3\] pipeline_count\[2\]
+ pipeline_count\[4\] _026_ VDD VSS OR4_X1
X_182_ _107_ _105_ _027_ VDD VSS AND2_X1
X_183_ _158_ _161_ _107_ _027_ _124_ _028_ VDD VSS AOI221_X2
X_184_ wr_ptr\[4\] rd_ptr\[4\] _029_ VDD VSS XNOR2_X2
X_185_ _028_ _029_ _030_ VDD VSS XOR2_X2
X_186_ _125_ _164_ pipeline_count\[0\] _031_ VDD VSS NOR3_X1
X_187_ _106_ _030_ _031_ _032_ VDD VSS NAND3_X1
X_188_ _146_ _026_ _032_ net11 VDD VSS NOR3_X1
X_189_ _125_ _143_ _033_ VDD VSS NAND2_X2
X_190_ _111_ _025_ _033_ _034_ VDD VSS OR3_X2
X_191_ _030_ _034_ net12 VDD VSS NAND2_X1
X_192_ _134_ _131_ VDD VSS INV_X1
X_193_ _133_ net7 VDD VSS INV_X1
X_194_ _139_ _126_ VDD VSS INV_X2
X_195_ net2 _035_ VDD VSS BUF_X2
X_196_ _140_ _036_ VDD VSS BUF_X2
X_197_ _002_ pipeline_count\[0\] _036_ _037_ VDD VSS MUX2_X1
X_198_ _035_ _037_ _005_ VDD VSS AND2_X1
X_199_ net2 _038_ VDD VSS INV_X1
X_200_ _038_ _039_ VDD VSS CLKBUF_X3
X_201_ _128_ _036_ _040_ VDD VSS NOR2_X1
X_202_ _040_ _036_ pipeline_count\[1\] _041_ VDD VSS AOI21_X1
X_203_ _039_ _041_ _006_ VDD VSS NOR2_X1
X_204_ _127_ _154_ _042_ VDD VSS XOR2_X1
X_205_ _042_ pipeline_count\[2\] _036_ _043_ VDD VSS MUX2_X1
X_206_ _035_ _043_ _007_ VDD VSS AND2_X1
X_207_ _151_ _152_ pipeline_count\[0\] _044_ VDD VSS AOI21_X1
X_208_ _044_ _045_ VDD VSS INV_X1
X_209_ _153_ _045_ _154_ _046_ VDD VSS AOI21_X1
X_210_ _156_ _046_ _047_ VDD VSS XNOR2_X1
X_211_ _047_ pipeline_count\[3\] _036_ _048_ VDD VSS MUX2_X1
X_212_ _035_ _048_ _008_ VDD VSS AND2_X1
X_213_ _155_ _049_ VDD VSS INV_X1
X_214_ _153_ _154_ _127_ _050_ VDD VSS AOI21_X1
X_215_ _156_ _051_ VDD VSS INV_X1
X_216_ _049_ _050_ _051_ _052_ VDD VSS OAI21_X1
X_217_ _126_ _052_ _053_ VDD VSS XNOR2_X1
X_218_ _036_ _053_ _054_ VDD VSS NOR2_X1
X_219_ pipeline_count\[4\] _054_ _055_ VDD VSS XNOR2_X1
X_220_ _039_ _055_ _009_ VDD VSS NOR2_X1
X_221_ net1 _056_ VDD VSS INV_X1
X_222_ _028_ _029_ _057_ VDD VSS XNOR2_X1
X_223_ _143_ _026_ _058_ VDD VSS NOR2_X1
X_224_ _031_ _058_ _059_ VDD VSS NAND2_X1
X_225_ _107_ _023_ _024_ _060_ VDD VSS OAI21_X1
X_226_ _108_ _109_ _110_ _061_ VDD VSS NAND3_X1
X_227_ _057_ _059_ _060_ _061_ _062_ VDD VSS AOI211_X4
X_228_ _056_ _039_ _062_ _010_ VDD VSS NOR3_X1
X_229_ rd_ptr\[0\] _035_ _063_ VDD VSS AND2_X1
X_230_ _000_ _035_ _064_ VDD VSS AND2_X1
X_231_ _056_ _062_ _065_ VDD VSS NOR2_X1
X_232_ _063_ _064_ _065_ _011_ VDD VSS MUX2_X1
X_233_ rd_ptr\[1\] _035_ _066_ VDD VSS AND2_X1
X_234_ _001_ _035_ _067_ VDD VSS AND2_X1
X_235_ _066_ _067_ _065_ _012_ VDD VSS MUX2_X1
X_236_ net1 _150_ _068_ VDD VSS NAND2_X1
X_237_ rd_ptr\[2\] _062_ _068_ _069_ VDD VSS OAI21_X1
X_238_ rd_ptr\[2\] _062_ _068_ _070_ VDD VSS OR3_X1
X_239_ _039_ _069_ _070_ _013_ VDD VSS AOI21_X1
X_240_ rd_ptr\[3\] _035_ _071_ VDD VSS AND2_X1
X_241_ rd_ptr\[3\] _039_ _072_ VDD VSS NOR2_X1
X_242_ rd_ptr\[2\] rd_ptr\[1\] rd_ptr\[0\] _073_ VDD VSS NAND3_X1
X_243_ _056_ _062_ _073_ _074_ VDD VSS NOR3_X1
X_244_ _071_ _072_ _074_ _014_ VDD VSS MUX2_X1
X_245_ net1 _150_ rd_ptr\[2\] rd_ptr\[3\] _075_ VDD VSS NAND4_X1
X_246_ rd_ptr\[4\] _062_ _075_ _076_ VDD VSS OAI21_X1
X_247_ rd_ptr\[4\] _062_ _075_ _077_ VDD VSS OR3_X1
X_248_ _039_ _076_ _077_ _015_ VDD VSS AOI21_X1
X_249_ _111_ _025_ _033_ _078_ VDD VSS NOR3_X4
X_250_ net3 _030_ _079_ VDD VSS NAND2_X2
X_251_ _039_ _078_ _079_ _016_ VDD VSS NOR3_X1
X_252_ _035_ wr_en_pipe\[0\] _017_ VDD VSS AND2_X1
X_253_ net3 _030_ _080_ VDD VSS AND2_X1
X_254_ _003_ _034_ _080_ _081_ VDD VSS NAND3_X1
X_255_ wr_ptr\[0\] _078_ _079_ _082_ VDD VSS OAI21_X1
X_256_ _039_ _081_ _082_ _018_ VDD VSS AOI21_X1
X_257_ _004_ _034_ _080_ _083_ VDD VSS NAND3_X1
X_258_ wr_ptr\[1\] _078_ _079_ _084_ VDD VSS OAI21_X1
X_259_ _039_ _083_ _084_ _019_ VDD VSS AOI21_X1
X_260_ wr_ptr\[2\] _038_ _085_ VDD VSS NOR2_X1
X_261_ wr_ptr\[2\] _035_ _086_ VDD VSS AND2_X1
X_262_ _149_ _034_ _080_ _087_ VDD VSS NAND3_X1
X_263_ _085_ _086_ _087_ _020_ VDD VSS MUX2_X1
X_264_ wr_ptr\[3\] net2 _088_ VDD VSS AND2_X1
X_265_ wr_ptr\[3\] _039_ _089_ VDD VSS NOR2_X1
X_266_ wr_ptr\[2\] wr_ptr\[1\] wr_ptr\[0\] _090_ VDD VSS NAND3_X1
X_267_ _078_ _079_ _090_ _091_ VDD VSS NOR3_X1
X_268_ _088_ _089_ _091_ _021_ VDD VSS MUX2_X1
X_269_ wr_ptr\[4\] net2 _092_ VDD VSS AND2_X1
X_270_ wr_ptr\[4\] _038_ _093_ VDD VSS NOR2_X1
X_271_ _149_ wr_ptr\[2\] wr_ptr\[3\] _094_ VDD VSS NAND3_X1
X_272_ _078_ _079_ _094_ _095_ VDD VSS NOR3_X1
X_273_ _092_ _093_ _095_ _022_ VDD VSS MUX2_X1
X_274_ _106_ _137_ _130_ _096_ VDD VSS AOI21_X1
X_275_ _146_ _026_ _057_ _096_ net4 VDD VSS NOR4_X1
X_276_ _143_ _146_ _097_ VDD VSS NAND2_X1
X_277_ _030_ _097_ net5 VDD VSS NAND2_X1
X_278_ _145_ _132_ net8 VDD VSS XNOR2_X1
X_279_ _144_ _098_ VDD VSS INV_X1
X_280_ _141_ _134_ _142_ _099_ VDD VSS AOI21_X1
X_281_ _145_ _100_ VDD VSS INV_X1
X_282_ _098_ _099_ _100_ _101_ VDD VSS OAI21_X1
X_283_ _148_ _101_ net9 VDD VSS XOR2_X1
X_284_ _098_ _132_ _100_ _102_ VDD VSS OAI21_X1
X_285_ _147_ _102_ _148_ _103_ VDD VSS AOI21_X1
X_286_ pipeline_count\[4\] _103_ _104_ VDD VSS XNOR2_X1
X_287_ _030_ _104_ net10 VDD VSS XNOR2_X1
X_288_ _122_ wr_ptr\[1\] _123_ _124_ _125_ VDD VSS FA_X1
X_289_ pipeline_count\[0\] pipeline_count\[1\] _126_ _127_
+ _128_ VDD VSS FA_X1
X_290_ _129_ _130_ _131_ _132_ _133_ VDD VSS FA_X1
X_291_ rd_ptr\[0\] _003_ _136_ _137_ VDD VSS HA_X1
X_292_ _138_ wr_en_pipe\[1\] _139_ _140_ VDD VSS HA_X1
X_293_ pipeline_count\[1\] _125_ _141_ _142_ VDD VSS HA_X1
X_294_ pipeline_count\[2\] _143_ _144_ _145_ VDD VSS HA_X1
X_295_ pipeline_count\[3\] _146_ _147_ _148_ VDD VSS HA_X1
X_296_ wr_ptr\[0\] wr_ptr\[1\] _149_ _004_ VDD VSS HA_X1
X_297_ rd_ptr\[0\] rd_ptr\[1\] _150_ _001_ VDD VSS HA_X1
X_298_ pipeline_count\[1\] _126_ _151_ _152_ VDD VSS HA_X1
X_299_ pipeline_count\[2\] _126_ _153_ _154_ VDD VSS HA_X1
X_300_ pipeline_count\[3\] _126_ _155_ _156_ VDD VSS HA_X1
X_301_ _157_ wr_ptr\[3\] _158_ _159_ VDD VSS HA_X1
X_302_ _160_ wr_ptr\[2\] _161_ _162_ VDD VSS HA_X1
X_303_ _122_ wr_ptr\[1\] _163_ _135_ VDD VSS HA_X1
X_304_ pipeline_count\[0\] _164_ _134_ net6 VDD VSS HA_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
X_306_ net13 rd_data[0] VDD VSS BUF_X1
X_307_ net14 rd_data[1] VDD VSS BUF_X1
X_308_ net15 rd_data[2] VDD VSS BUF_X1
X_309_ net16 rd_data[3] VDD VSS BUF_X1
X_310_ net17 rd_data[4] VDD VSS BUF_X1
X_311_ net18 rd_data[5] VDD VSS BUF_X1
X_312_ net19 rd_data[6] VDD VSS BUF_X1
X_313_ net20 rd_data[7] VDD VSS BUF_X1
X_314_ net21 rd_data[8] VDD VSS BUF_X1
X_315_ net22 rd_data[9] VDD VSS BUF_X1
X_316_ net23 rd_data[10] VDD VSS BUF_X1
X_317_ net24 rd_data[11] VDD VSS BUF_X1
X_318_ net25 rd_data[12] VDD VSS BUF_X1
X_319_ net26 rd_data[13] VDD VSS BUF_X1
X_320_ net27 rd_data[14] VDD VSS BUF_X1
X_321_ net28 rd_data[15] VDD VSS BUF_X1
X_322_ net29 rd_data[16] VDD VSS BUF_X1
X_323_ net30 rd_data[17] VDD VSS BUF_X1
X_324_ net31 rd_data[18] VDD VSS BUF_X1
X_325_ net32 rd_data[19] VDD VSS BUF_X1
X_326_ net33 rd_data[20] VDD VSS BUF_X1
X_327_ net34 rd_data[21] VDD VSS BUF_X1
X_328_ net35 rd_data[22] VDD VSS BUF_X1
X_329_ net36 rd_data[23] VDD VSS BUF_X1
X_330_ net37 rd_data[24] VDD VSS BUF_X1
X_331_ net38 rd_data[25] VDD VSS BUF_X1
X_332_ net39 rd_data[26] VDD VSS BUF_X1
X_333_ net40 rd_data[27] VDD VSS BUF_X1
X_334_ net41 rd_data[28] VDD VSS BUF_X1
X_335_ net42 rd_data[29] VDD VSS BUF_X1
X_336_ net43 rd_data[30] VDD VSS BUF_X1
X_337_ net44 rd_data[31] VDD VSS BUF_X1
Xpipeline_count\[0\]$_SDFFE_PN0P_ _005_ clknet_1_1__leaf_clk
+ pipeline_count\[0\] _002_ VDD VSS DFF_X2
Xpipeline_count\[1\]$_SDFFE_PN0P_ _006_ clknet_1_1__leaf_clk
+ pipeline_count\[1\] _129_ VDD VSS DFF_X2
Xpipeline_count\[2\]$_SDFFE_PN0P_ _007_ clknet_1_1__leaf_clk
+ pipeline_count\[2\] _121_ VDD VSS DFF_X2
Xpipeline_count\[3\]$_SDFFE_PN0P_ _008_ clknet_1_1__leaf_clk
+ pipeline_count\[3\] _120_ VDD VSS DFF_X2
Xpipeline_count\[4\]$_SDFFE_PN0P_ _009_ clknet_1_1__leaf_clk
+ pipeline_count\[4\] _119_ VDD VSS DFF_X1
Xrd_en_pipe$_SDFF_PN0_ _010_ clknet_1_1__leaf_clk rd_en_pipe
+ _138_ VDD VSS DFF_X1
Xrd_ptr\[0\]$_SDFFE_PN0P_ _011_ clknet_1_1__leaf_clk rd_ptr\[0\]
+ _000_ VDD VSS DFF_X2
Xrd_ptr\[1\]$_SDFFE_PN0P_ _012_ clknet_1_1__leaf_clk rd_ptr\[1\]
+ _122_ VDD VSS DFF_X1
Xrd_ptr\[2\]$_SDFFE_PN0P_ _013_ clknet_1_0__leaf_clk rd_ptr\[2\]
+ _160_ VDD VSS DFF_X1
Xrd_ptr\[3\]$_SDFFE_PN0P_ _014_ clknet_1_0__leaf_clk rd_ptr\[3\]
+ _157_ VDD VSS DFF_X1
Xrd_ptr\[4\]$_SDFFE_PN0P_ _015_ clknet_1_0__leaf_clk rd_ptr\[4\]
+ _118_ VDD VSS DFF_X1
Xwr_en_pipe\[0\]$_SDFF_PN0_ _016_ clknet_1_0__leaf_clk wr_en_pipe\[0\]
+ _117_ VDD VSS DFF_X1
Xwr_en_pipe\[1\]$_SDFF_PN0_ _017_ clknet_1_0__leaf_clk wr_en_pipe\[1\]
+ _116_ VDD VSS DFF_X1
Xwr_ptr\[0\]$_SDFFE_PN0P_ _018_ clknet_1_0__leaf_clk wr_ptr\[0\]
+ _003_ VDD VSS DFF_X1
Xwr_ptr\[1\]$_SDFFE_PN0P_ _019_ clknet_1_0__leaf_clk wr_ptr\[1\]
+ _115_ VDD VSS DFF_X2
Xwr_ptr\[2\]$_SDFFE_PN0P_ _020_ clknet_1_0__leaf_clk wr_ptr\[2\]
+ _114_ VDD VSS DFF_X2
Xwr_ptr\[3\]$_SDFFE_PN0P_ _021_ clknet_1_0__leaf_clk wr_ptr\[3\]
+ _113_ VDD VSS DFF_X2
Xwr_ptr\[4\]$_SDFFE_PN0P_ _022_ clknet_1_0__leaf_clk wr_ptr\[4\]
+ _112_ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_75 VDD VSS TAPCELL_X1
Xinput1 rd_en net1 VDD VSS BUF_X1
Xinput2 rst_n net2 VDD VSS BUF_X1
Xinput3 wr_en net3 VDD VSS BUF_X1
Xoutput4 net4 almost_empty VDD VSS BUF_X1
Xoutput5 net5 almost_full VDD VSS BUF_X1
Xoutput6 net6 data_count[0] VDD VSS BUF_X1
Xoutput7 net7 data_count[1] VDD VSS BUF_X1
Xoutput8 net8 data_count[2] VDD VSS BUF_X1
Xoutput9 net9 data_count[3] VDD VSS BUF_X1
Xoutput10 net10 data_count[4] VDD VSS BUF_X1
Xoutput11 net11 empty VDD VSS BUF_X1
Xoutput12 net12 full VDD VSS BUF_X1
X_306__13 net13 VDD VSS LOGIC0_X1
X_307__14 net14 VDD VSS LOGIC0_X1
X_308__15 net15 VDD VSS LOGIC0_X1
X_309__16 net16 VDD VSS LOGIC0_X1
X_310__17 net17 VDD VSS LOGIC0_X1
X_311__18 net18 VDD VSS LOGIC0_X1
X_312__19 net19 VDD VSS LOGIC0_X1
X_313__20 net20 VDD VSS LOGIC0_X1
X_314__21 net21 VDD VSS LOGIC0_X1
X_315__22 net22 VDD VSS LOGIC0_X1
X_316__23 net23 VDD VSS LOGIC0_X1
X_317__24 net24 VDD VSS LOGIC0_X1
X_318__25 net25 VDD VSS LOGIC0_X1
X_319__26 net26 VDD VSS LOGIC0_X1
X_320__27 net27 VDD VSS LOGIC0_X1
X_321__28 net28 VDD VSS LOGIC0_X1
X_322__29 net29 VDD VSS LOGIC0_X1
X_323__30 net30 VDD VSS LOGIC0_X1
X_324__31 net31 VDD VSS LOGIC0_X1
X_325__32 net32 VDD VSS LOGIC0_X1
X_326__33 net33 VDD VSS LOGIC0_X1
X_327__34 net34 VDD VSS LOGIC0_X1
X_328__35 net35 VDD VSS LOGIC0_X1
X_329__36 net36 VDD VSS LOGIC0_X1
X_330__37 net37 VDD VSS LOGIC0_X1
X_331__38 net38 VDD VSS LOGIC0_X1
X_332__39 net39 VDD VSS LOGIC0_X1
X_333__40 net40 VDD VSS LOGIC0_X1
X_334__41 net41 VDD VSS LOGIC0_X1
X_335__42 net42 VDD VSS LOGIC0_X1
X_336__43 net43 VDD VSS LOGIC0_X1
X_337__44 net44 VDD VSS LOGIC0_X1
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS INV_X1
.ENDS pipelined_fifo
