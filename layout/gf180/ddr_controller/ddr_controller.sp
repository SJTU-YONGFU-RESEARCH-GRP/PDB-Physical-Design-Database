* cell ddr_controller
* pin phy_dqs_p[3]
* pin phy_dqs_n[2]
* pin phy_dqs_p[6]
* pin phy_dqs_n[0]
* pin cmd_addr[13]
* pin phy_addr[12]
* pin phy_bank_group[0]
* pin wr_mask[6]
* pin phy_dm[6]
* pin phy_dqs_p[2]
* pin phy_addr[10]
* pin cmd_addr[4]
* pin cmd_addr[18]
* pin cmd_addr[3]
* pin cmd_addr[16]
* pin cmd_addr[17]
* pin phy_addr[11]
* pin cmd_addr[24]
* pin cmd_addr[25]
* pin cmd_addr[8]
* pin cmd_addr[22]
* pin cmd_addr[26]
* pin phy_addr[0]
* pin cmd_addr[0]
* pin cmd_addr[14]
* pin phy_addr[1]
* pin cmd_addr[15]
* pin phy_addr[13]
* pin phy_addr[5]
* pin wr_mask[1]
* pin cmd_addr[12]
* pin phy_dm[1]
* pin wr_mask[5]
* pin phy_dm[5]
* pin phy_dqs_n[4]
* pin wr_mask[4]
* pin phy_dm[4]
* pin phy_dqs_n[6]
* pin phy_dqs_n[3]
* pin phy_cke
* pin cmd_addr[11]
* pin phy_dqs_p[1]
* pin phy_dqs_n[1]
* pin phy_addr[8]
* pin phy_dqs_n[7]
* pin phy_addr[9]
* pin phy_dqs_p[5]
* pin cmd_addr[19]
* pin phy_addr[3]
* pin phy_addr[4]
* pin cmd_addr[27]
* pin phy_addr[7]
* pin phy_odt
* pin phy_addr[2]
* pin phy_dqs_n[5]
* pin phy_bank_group[1]
* pin cmd_addr[21]
* pin cmd_addr[23]
* pin phy_dqs_p[4]
* pin cmd_addr[7]
* pin cmd_addr[5]
* pin rd_data[31]
* pin wr_data[31]
* pin phy_dqs_p[0]
* pin cmd_addr[20]
* pin phy_addr[6]
* pin wr_data[33]
* pin rd_data[33]
* pin phy_dq[31]
* pin phy_dqs_p[7]
* pin rd_data[28]
* pin phy_dq[33]
* pin phy_cs_n
* pin cmd_addr[6]
* pin wr_data[28]
* pin phy_dq[28]
* pin phy_dq[30]
* pin clk
* pin phy_bank[2]
* pin wr_data[30]
* pin rd_data[30]
* pin wr_data[27]
* pin phy_dq[27]
* pin wr_data[29]
* pin phy_dq[29]
* pin cmd_addr[2]
* pin rd_data[27]
* pin rd_data[29]
* pin cmd_burst_len[1]
* pin rd_data[35]
* pin wr_data[35]
* pin phy_dq[35]
* pin phy_dq[32]
* pin rd_data[32]
* pin wr_data[32]
* pin cmd_ready
* pin cmd_burst_len[0]
* pin wr_data[34]
* pin phy_dq[47]
* pin phy_dq[34]
* pin rd_data[34]
* pin rd_data[47]
* pin wr_data[47]
* pin cmd_burst_len[2]
* pin wr_data[46]
* pin rd_data[46]
* pin phy_dq[46]
* pin wr_data[51]
* pin rd_data[45]
* pin phy_bank[0]
* pin cmd_burst_len[3]
* pin rd_data[55]
* pin rd_data[56]
* pin rd_data[48]
* pin wr_data[45]
* pin phy_dq[51]
* pin phy_dq[45]
* pin wr_data[48]
* pin phy_dq[56]
* pin rd_data[2]
* pin wr_data[56]
* pin init_done
* pin rd_data[60]
* pin rd_data[52]
* pin phy_dq[48]
* pin phy_dq[55]
* pin wr_data[2]
* pin rd_data[4]
* pin rd_data[51]
* pin phy_dq[2]
* pin wr_data[55]
* pin rd_data[50]
* pin wr_data[53]
* pin rd_data[53]
* pin rd_data[54]
* pin phy_dq[54]
* pin wr_data[4]
* pin phy_dq[52]
* pin phy_dq[4]
* pin phy_dq[60]
* pin phy_dq[53]
* pin phy_bank[1]
* pin wr_data[54]
* pin cmd_addr[9]
* pin phy_reset_n
* pin rd_data[59]
* pin rd_data[49]
* pin phy_dq[9]
* pin wr_data[60]
* pin wr_data[61]
* pin wr_data[52]
* pin rd_data[9]
* pin wr_data[59]
* pin phy_dq[49]
* pin wr_data[9]
* pin cmd_write
* pin wr_ready
* pin rd_data[61]
* pin wr_data[49]
* pin rd_data[25]
* pin rd_data[7]
* pin rd_data[57]
* pin rd_data[19]
* pin rd_data[63]
* pin wr_data[7]
* pin phy_dq[7]
* pin phy_dq[25]
* pin wr_data[25]
* pin state[0]
* pin rd_data[40]
* pin phy_dq[59]
* pin wr_data[63]
* pin phy_dq[40]
* pin phy_dq[63]
* pin wr_data[19]
* pin state[1]
* pin wr_data[1]
* pin rd_data[1]
* pin wr_data[24]
* pin phy_dq[24]
* pin phy_dq[1]
* pin rd_data[38]
* pin rd_data[6]
* pin rd_data[23]
* pin rd_data[44]
* pin wr_valid
* pin rd_ready
* pin wr_data[39]
* pin phy_dq[44]
* pin wr_data[43]
* pin wr_data[40]
* pin phy_dq[43]
* pin wr_data[23]
* pin wr_mask[3]
* pin phy_dq[23]
* pin rd_data[14]
* pin rst_n
* pin rd_data[43]
* pin phy_dq[39]
* pin rd_data[24]
* pin wr_data[44]
* pin rd_data[16]
* pin wr_data[18]
* pin rd_data[18]
* pin cmd_addr[1]
* pin rd_data[10]
* pin wr_data[14]
* pin phy_dq[14]
* pin rd_data[12]
* pin rd_data[39]
* pin phy_dq[18]
* pin wr_data[26]
* pin rd_data[26]
* pin wr_data[38]
* pin rd_data[37]
* pin phy_dq[26]
* pin rd_data[62]
* pin phy_we_n
* pin wr_data[37]
* pin phy_dq[37]
* pin phy_dm[3]
* pin rd_data[21]
* pin phy_dq[21]
* pin wr_data[21]
* pin phy_cas_n
* pin phy_ras_n
* pin rd_data[17]
* pin wr_data[5]
* pin wr_data[20]
* pin phy_dq[22]
* pin rd_data[11]
* pin wr_data[62]
* pin rd_valid
* pin phy_dq[5]
* pin rd_data[5]
* pin phy_dq[13]
* pin phy_dq[20]
* pin phy_dq[38]
* pin wr_data[50]
* pin wr_data[11]
* pin rd_data[41]
* pin rd_data[36]
* pin phy_dq[62]
* pin rd_data[15]
* pin wr_data[16]
* pin rd_data[22]
* pin phy_dq[19]
* pin phy_dq[11]
* pin rd_data[0]
* pin rd_data[42]
* pin phy_dq[36]
* pin wr_data[36]
* pin phy_dq[58]
* pin wr_data[57]
* pin wr_data[58]
* pin wr_data[17]
* pin wr_data[6]
* pin phy_clk
* pin wr_data[22]
* pin phy_dq[50]
* pin phy_dq[61]
* pin rd_data[20]
* pin phy_dm[0]
* pin phy_dm[2]
* pin wr_data[13]
* pin cmd_valid
* pin rd_data[13]
* pin wr_data[8]
* pin phy_dq[17]
* pin rd_data[3]
* pin phy_dq[42]
* pin phy_dq[12]
* pin rd_data[8]
* pin wr_data[41]
* pin rd_data[58]
* pin wr_data[12]
* pin wr_mask[7]
* pin wr_data[0]
* pin wr_mask[0]
* pin wr_mask[2]
* pin phy_dq[15]
* pin phy_dq[0]
* pin phy_dq[8]
* pin wr_data[10]
* pin phy_dq[10]
* pin phy_dm[7]
* pin phy_dq[57]
* pin phy_dq[41]
* pin wr_data[42]
* pin wr_data[3]
* pin phy_dq[3]
* pin wr_data[15]
* pin phy_dq[6]
* pin phy_dq[16]
* pin VDD
* pin VSS,gf180mcu_gnd
.SUBCKT ddr_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22
+ 23 24 25 26 27 28 29 30 31 32 33 34 56 71 85 123 173 191 224 245 304 322 353
+ 382 403 438 445 446 461 462 468 469 470 471 485 486 495 534 555 558 582 617
+ 634 635 650 651 652 657 674 675 684 695 697 698 708 710 718 721 722 741 757
+ 758 759 761 778 779 788 796 797 798 812 813 814 818 834 845 847 848 849 864
+ 867 876 885 886 903 921 944 946 965 973 974 988 989 990 991 1020 1021 1022
+ 1024 1030 1045 1046 1047 1048 1049 1050 1051 1052 1067 1082 1083 1085 1093
+ 1094 1095 1096 1097 1098 1099 1110 1113 1119 1122 1140 1141 1142 1143 1144
+ 1145 1147 1157 1158 1159 1167 1173 1175 1178 1179 1183 1195 1197 1198 1200
+ 1201 1202 1203 1231 1240 1242 1243 1245 1246 1247 1257 1263 1264 1280 1282
+ 1283 1284 1294 1304 1306 1308 1309 1319 1321 1323 1325 1326 1327 1328 1329
+ 1331 1337 1338 1339 1340 1341 1343 1351 1352 1355 1357 1363 1364 1365 1368
+ 1369 1370 1371 1387 1389 1390 1396 1401 1403 1404 1406 1407 1408 1409 1413
+ 1415 1418 1420 1425 1426 1428 1429 1430 1434 1435 1437 1443 1444 1445 1448
+ 1449 1450 1451 1452 1456 1462 1463 1465 1467 1468 1469 1470 1471 1472 1473
+ 1478 1479 1480 1481 1482 1483 1484 1485 1486 1487 1488 1489 1490 1491 1492
+ 1493 1494 1495 1496 1497 1498 1500 1501 1502 1503 1504 1505 1506 1507 1508
+ 1509 1510 1511 1512 1513 1514 1515 1516 1517 1518 1519
* net 1 phy_dqs_p[3]
* net 2 phy_dqs_n[2]
* net 3 phy_dqs_p[6]
* net 4 phy_dqs_n[0]
* net 5 cmd_addr[13]
* net 6 phy_addr[12]
* net 7 phy_bank_group[0]
* net 8 wr_mask[6]
* net 9 phy_dm[6]
* net 10 phy_dqs_p[2]
* net 11 phy_addr[10]
* net 12 cmd_addr[4]
* net 13 cmd_addr[18]
* net 14 cmd_addr[3]
* net 15 cmd_addr[16]
* net 16 cmd_addr[17]
* net 17 phy_addr[11]
* net 18 cmd_addr[24]
* net 19 cmd_addr[25]
* net 20 cmd_addr[8]
* net 21 cmd_addr[22]
* net 22 cmd_addr[26]
* net 23 phy_addr[0]
* net 24 cmd_addr[0]
* net 25 cmd_addr[14]
* net 26 phy_addr[1]
* net 27 cmd_addr[15]
* net 28 phy_addr[13]
* net 29 phy_addr[5]
* net 30 wr_mask[1]
* net 31 cmd_addr[12]
* net 32 phy_dm[1]
* net 33 wr_mask[5]
* net 34 phy_dm[5]
* net 56 phy_dqs_n[4]
* net 71 wr_mask[4]
* net 85 phy_dm[4]
* net 123 phy_dqs_n[6]
* net 173 phy_dqs_n[3]
* net 191 phy_cke
* net 224 cmd_addr[11]
* net 245 phy_dqs_p[1]
* net 304 phy_dqs_n[1]
* net 322 phy_addr[8]
* net 353 phy_dqs_n[7]
* net 382 phy_addr[9]
* net 403 phy_dqs_p[5]
* net 438 cmd_addr[19]
* net 445 phy_addr[3]
* net 446 phy_addr[4]
* net 461 cmd_addr[27]
* net 462 phy_addr[7]
* net 468 phy_odt
* net 469 phy_addr[2]
* net 470 phy_dqs_n[5]
* net 471 phy_bank_group[1]
* net 485 cmd_addr[21]
* net 486 cmd_addr[23]
* net 495 phy_dqs_p[4]
* net 534 cmd_addr[7]
* net 555 cmd_addr[5]
* net 558 rd_data[31]
* net 582 wr_data[31]
* net 617 phy_dqs_p[0]
* net 634 cmd_addr[20]
* net 635 phy_addr[6]
* net 650 wr_data[33]
* net 651 rd_data[33]
* net 652 phy_dq[31]
* net 657 phy_dqs_p[7]
* net 674 rd_data[28]
* net 675 phy_dq[33]
* net 684 phy_cs_n
* net 695 cmd_addr[6]
* net 697 wr_data[28]
* net 698 phy_dq[28]
* net 708 phy_dq[30]
* net 710 clk
* net 718 phy_bank[2]
* net 721 wr_data[30]
* net 722 rd_data[30]
* net 741 wr_data[27]
* net 757 phy_dq[27]
* net 758 wr_data[29]
* net 759 phy_dq[29]
* net 761 cmd_addr[2]
* net 778 rd_data[27]
* net 779 rd_data[29]
* net 788 cmd_burst_len[1]
* net 796 rd_data[35]
* net 797 wr_data[35]
* net 798 phy_dq[35]
* net 812 phy_dq[32]
* net 813 rd_data[32]
* net 814 wr_data[32]
* net 818 cmd_ready
* net 834 cmd_burst_len[0]
* net 845 wr_data[34]
* net 847 phy_dq[47]
* net 848 phy_dq[34]
* net 849 rd_data[34]
* net 864 rd_data[47]
* net 867 wr_data[47]
* net 876 cmd_burst_len[2]
* net 885 wr_data[46]
* net 886 rd_data[46]
* net 903 phy_dq[46]
* net 921 wr_data[51]
* net 944 rd_data[45]
* net 946 phy_bank[0]
* net 965 cmd_burst_len[3]
* net 973 rd_data[55]
* net 974 rd_data[56]
* net 988 rd_data[48]
* net 989 wr_data[45]
* net 990 phy_dq[51]
* net 991 phy_dq[45]
* net 1020 wr_data[48]
* net 1021 phy_dq[56]
* net 1022 rd_data[2]
* net 1024 wr_data[56]
* net 1030 init_done
* net 1045 rd_data[60]
* net 1046 rd_data[52]
* net 1047 phy_dq[48]
* net 1048 phy_dq[55]
* net 1049 wr_data[2]
* net 1050 rd_data[4]
* net 1051 rd_data[51]
* net 1052 phy_dq[2]
* net 1067 wr_data[55]
* net 1082 rd_data[50]
* net 1083 wr_data[53]
* net 1085 rd_data[53]
* net 1093 rd_data[54]
* net 1094 phy_dq[54]
* net 1095 wr_data[4]
* net 1096 phy_dq[52]
* net 1097 phy_dq[4]
* net 1098 phy_dq[60]
* net 1099 phy_dq[53]
* net 1110 phy_bank[1]
* net 1113 wr_data[54]
* net 1119 cmd_addr[9]
* net 1122 phy_reset_n
* net 1140 rd_data[59]
* net 1141 rd_data[49]
* net 1142 phy_dq[9]
* net 1143 wr_data[60]
* net 1144 wr_data[61]
* net 1145 wr_data[52]
* net 1147 rd_data[9]
* net 1157 wr_data[59]
* net 1158 phy_dq[49]
* net 1159 wr_data[9]
* net 1167 cmd_write
* net 1173 wr_ready
* net 1175 rd_data[61]
* net 1178 wr_data[49]
* net 1179 rd_data[25]
* net 1183 rd_data[7]
* net 1195 rd_data[57]
* net 1197 rd_data[19]
* net 1198 rd_data[63]
* net 1200 wr_data[7]
* net 1201 phy_dq[7]
* net 1202 phy_dq[25]
* net 1203 wr_data[25]
* net 1231 state[0]
* net 1240 rd_data[40]
* net 1242 phy_dq[59]
* net 1243 wr_data[63]
* net 1245 phy_dq[40]
* net 1246 phy_dq[63]
* net 1247 wr_data[19]
* net 1257 state[1]
* net 1263 wr_data[1]
* net 1264 rd_data[1]
* net 1280 wr_data[24]
* net 1282 phy_dq[24]
* net 1283 phy_dq[1]
* net 1284 rd_data[38]
* net 1294 rd_data[6]
* net 1304 rd_data[23]
* net 1306 rd_data[44]
* net 1308 wr_valid
* net 1309 rd_ready
* net 1319 wr_data[39]
* net 1321 phy_dq[44]
* net 1323 wr_data[43]
* net 1325 wr_data[40]
* net 1326 phy_dq[43]
* net 1327 wr_data[23]
* net 1328 wr_mask[3]
* net 1329 phy_dq[23]
* net 1331 rd_data[14]
* net 1337 rst_n
* net 1338 rd_data[43]
* net 1339 phy_dq[39]
* net 1340 rd_data[24]
* net 1341 wr_data[44]
* net 1343 rd_data[16]
* net 1351 wr_data[18]
* net 1352 rd_data[18]
* net 1355 cmd_addr[1]
* net 1357 rd_data[10]
* net 1363 wr_data[14]
* net 1364 phy_dq[14]
* net 1365 rd_data[12]
* net 1368 rd_data[39]
* net 1369 phy_dq[18]
* net 1370 wr_data[26]
* net 1371 rd_data[26]
* net 1387 wr_data[38]
* net 1389 rd_data[37]
* net 1390 phy_dq[26]
* net 1396 rd_data[62]
* net 1401 phy_we_n
* net 1403 wr_data[37]
* net 1404 phy_dq[37]
* net 1406 phy_dm[3]
* net 1407 rd_data[21]
* net 1408 phy_dq[21]
* net 1409 wr_data[21]
* net 1413 phy_cas_n
* net 1415 phy_ras_n
* net 1418 rd_data[17]
* net 1420 wr_data[5]
* net 1425 wr_data[20]
* net 1426 phy_dq[22]
* net 1428 rd_data[11]
* net 1429 wr_data[62]
* net 1430 rd_valid
* net 1434 phy_dq[5]
* net 1435 rd_data[5]
* net 1437 phy_dq[13]
* net 1443 phy_dq[20]
* net 1444 phy_dq[38]
* net 1445 wr_data[50]
* net 1448 wr_data[11]
* net 1449 rd_data[41]
* net 1450 rd_data[36]
* net 1451 phy_dq[62]
* net 1452 rd_data[15]
* net 1456 wr_data[16]
* net 1462 rd_data[22]
* net 1463 phy_dq[19]
* net 1465 phy_dq[11]
* net 1467 rd_data[0]
* net 1468 rd_data[42]
* net 1469 phy_dq[36]
* net 1470 wr_data[36]
* net 1471 phy_dq[58]
* net 1472 wr_data[57]
* net 1473 wr_data[58]
* net 1478 wr_data[17]
* net 1479 wr_data[6]
* net 1480 phy_clk
* net 1481 wr_data[22]
* net 1482 phy_dq[50]
* net 1483 phy_dq[61]
* net 1484 rd_data[20]
* net 1485 phy_dm[0]
* net 1486 phy_dm[2]
* net 1487 wr_data[13]
* net 1488 cmd_valid
* net 1489 rd_data[13]
* net 1490 wr_data[8]
* net 1491 phy_dq[17]
* net 1492 rd_data[3]
* net 1493 phy_dq[42]
* net 1494 phy_dq[12]
* net 1495 rd_data[8]
* net 1496 wr_data[41]
* net 1497 rd_data[58]
* net 1498 wr_data[12]
* net 1500 wr_mask[7]
* net 1501 wr_data[0]
* net 1502 wr_mask[0]
* net 1503 wr_mask[2]
* net 1504 phy_dq[15]
* net 1505 phy_dq[0]
* net 1506 phy_dq[8]
* net 1507 wr_data[10]
* net 1508 phy_dq[10]
* net 1509 phy_dm[7]
* net 1510 phy_dq[57]
* net 1511 phy_dq[41]
* net 1512 wr_data[42]
* net 1513 wr_data[3]
* net 1514 phy_dq[3]
* net 1515 wr_data[15]
* net 1516 phy_dq[6]
* net 1517 phy_dq[16]
* net 1518 VDD
* net 1519 VSS,gf180mcu_gnd
* cell instance $3 r0 *1 51.52,5.04
X$3 1519 1518 1 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $6 r0 *1 53.76,5.04
X$6 1519 1518 2 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10 r0 *1 59.36,5.04
X$10 1519 1518 3 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $14 r0 *1 61.6,5.04
X$14 1519 1518 4 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $18 r0 *1 72.24,5.04
X$18 5 1518 1519 59 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23 m0 *1 75.6,15.12
X$23 58 1518 1519 6 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $26 r0 *1 85.12,5.04
X$26 1519 1518 7 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $31 m0 *1 84,15.12
X$31 8 35 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $35 r0 *1 87.92,5.04
X$35 35 1518 1519 9 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $39 r0 *1 96.32,5.04
X$39 1519 1518 10 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $43 m0 *1 99.68,15.12
X$43 60 1518 1519 11 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $47 r0 *1 107.52,5.04
X$47 12 1518 1519 36 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50 m0 *1 109.2,15.12
X$50 13 1518 1519 55 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $55 r0 *1 116.48,15.12
X$55 14 1518 1519 91 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58 r0 *1 115.92,5.04
X$58 15 1518 1519 79 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63 r0 *1 124.32,5.04
X$63 16 1518 1519 61 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66 m0 *1 117.6,15.12
X$66 45 1518 1519 17 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $70 r0 *1 129.36,15.12
X$70 18 1518 1519 177 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75 m0 *1 134.4,15.12
X$75 19 1518 1519 156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79 r0 *1 140,5.04
X$79 20 1518 1519 157 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82 m0 *1 142.8,15.12
X$82 21 1518 1519 158 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86 r0 *1 156.24,5.04
X$86 22 1518 1519 37 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90 m0 *1 155.68,15.12
X$90 46 1518 1519 23 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $95 r0 *1 155.12,15.12
X$95 24 1518 1519 69 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99 r0 *1 165.2,15.12
X$99 25 1518 1519 142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $103 m0 *1 164.64,15.12
X$103 49 1518 1519 26 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $107 r0 *1 171.36,5.04
X$107 27 1518 1519 38 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $111 r0 *1 220.08,5.04
X$111 41 1518 1519 28 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $114 r0 *1 228.48,5.04
X$114 44 1518 1519 29 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $119 r0 *1 260.96,5.04
X$119 30 42 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $122 m0 *1 258.72,15.12
X$122 31 1518 1519 67 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $126 m0 *1 267.12,15.12
X$126 42 1518 1519 32 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $131 r0 *1 309.12,5.04
X$131 33 43 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $135 r0 *1 318.64,5.04
X$135 43 1518 1519 34 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $141 m0 *1 112,126
X$141 1519 1518 475 36 476 55 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $143 r0 *1 108.64,105.84
X$143 1519 452 1518 475 407 36 501 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $146 r0 *1 159.6,45.36
X$146 1519 37 1518 189 195 209 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $149 r0 *1 156.24,45.36
X$149 1519 1518 37 159 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $151 r0 *1 168,55.44
X$151 1519 37 1518 209 248 38 210 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $156 m0 *1 193.76,65.52
X$156 1519 1518 38 263 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $158 r0 *1 191.52,55.44
X$158 1519 38 1518 265 195 210 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $161 r0 *1 170.8,146.16
X$161 1519 1518 598 626 476 38 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $168 m0 *1 135.52,35.28
X$168 1519 126 39 138 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $171 m0 *1 166.88,45.36
X$171 1519 143 39 160 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $174 r0 *1 155.68,25.2
X$174 1519 94 39 93 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $177 r0 *1 138.32,15.12
X$177 1519 62 39 84 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $179 m0 *1 179.2,85.68
X$179 1519 39 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $182 r0 *1 191.52,75.6
X$182 1519 333 39 339 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $184 r0 *1 180.32,15.12
X$184 1519 47 39 70 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $186 r0 *1 172.48,25.2
X$186 1519 127 39 111 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $189 r0 *1 201.6,5.04
X$189 1519 48 39 40 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $191 m0 *1 149.52,55.44
X$191 1519 229 39 244 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $194 m0 *1 147.28,75.6
X$194 1519 264 39 303 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $196 r0 *1 183.12,85.68
X$196 1519 359 39 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $199 m0 *1 212.8,85.68
X$199 1519 346 39 360 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $202 m0 *1 175.84,65.52
X$202 1519 231 39 249 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $204 r0 *1 196.56,35.28
X$204 1519 144 39 163 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $206 r0 *1 197.12,15.12
X$206 1519 63 39 80 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $221 m0 *1 204.96,15.12
X$221 1519 1518 40 46 53 48 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $223 m0 *1 172.48,105.84
X$223 1519 407 1518 408 421 410 41 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $225 m0 *1 299.6,75.6
X$225 1519 1518 320 41 53 321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $228 r0 *1 281.12,85.68
X$228 1519 1518 381 41 154 364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $230 m0 *1 291.2,75.6
X$230 1519 1518 318 41 101 319 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $233 r0 *1 268.8,75.6
X$233 1519 1518 335 41 87 349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $235 r0 *1 260.96,65.52
X$235 1519 1518 297 41 129 317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $237 m0 *1 249.2,85.68
X$237 1519 1518 347 41 103 348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $239 m0 *1 239.68,75.6
X$239 1519 1518 315 41 50 296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $242 r0 *1 210.56,95.76
X$242 1519 1518 401 41 230 377 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $244 r0 *1 183.12,95.76
X$244 1519 409 41 344 392 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $263 m0 *1 277.76,15.12
X$263 1519 1518 52 44 53 68 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $265 m0 *1 273.28,45.36
X$265 1519 1518 168 44 154 169 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $267 r0 *1 273.84,25.2
X$267 1519 1518 99 44 101 117 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $270 m0 *1 235.2,35.28
X$270 1519 1518 145 44 129 164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $272 r0 *1 172.48,75.6
X$272 1519 1518 330 44 230 331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $274 m0 *1 238,25.2
X$274 1519 1518 82 44 87 83 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $276 r0 *1 249.2,15.12
X$276 1519 1518 51 44 50 66 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $279 r0 *1 250.88,25.2
X$279 1519 1518 116 44 103 128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $281 r0 *1 173.04,126
X$281 1519 409 44 589 548 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $283 m0 *1 165.76,136.08
X$283 1518 547 1519 546 565 44 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $299 r0 *1 63.84,95.76
X$299 1519 1518 384 45 87 371 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $302 m0 *1 76.16,105.84
X$302 1519 1518 390 45 129 372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $304 m0 *1 106.4,75.6
X$304 1519 1518 308 45 154 309 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $306 r0 *1 50.96,75.6
X$306 1519 1518 323 45 101 324 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $308 r0 *1 62.16,85.68
X$308 1519 1518 365 45 53 354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $310 m0 *1 154.56,85.68
X$310 1519 1518 342 45 230 343 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $312 r0 *1 101.92,85.68
X$312 1519 1518 368 45 50 357 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $315 r0 *1 92.4,95.76
X$315 1519 1518 391 45 103 386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $318 m0 *1 140.56,136.08
X$318 1519 409 45 589 522 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $320 r0 *1 154,126
X$320 1519 1518 538 45 546 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $336 r0 *1 155.68,65.52
X$336 1519 1518 303 46 230 264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $339 m0 *1 159.6,25.2
X$339 1519 1518 93 46 87 94 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $342 m0 *1 201.6,45.36
X$342 1519 1518 163 46 154 144 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $344 m0 *1 201.6,25.2
X$344 1519 1518 80 46 101 63 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $346 r0 *1 161.84,126
X$346 1518 547 1519 546 566 46 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $348 m0 *1 154,126
X$348 1519 409 46 344 539 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $350 m0 *1 183.68,15.12
X$350 1519 1518 70 46 50 47 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $353 r0 *1 172.48,35.28
X$353 1519 1518 160 46 129 143 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $355 m0 *1 175.28,35.28
X$355 1519 1518 111 46 103 127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $371 m0 *1 185.36,25.2
X$371 76 81 96 47 1519 1518 95 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $375 m0 *1 210,25.2
X$375 1519 1518 102 63 109 48 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $379 m0 *1 171.92,156.24
X$379 1519 409 49 589 683 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $382 r0 *1 187.6,65.52
X$382 1519 1518 292 49 87 293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $384 m0 *1 201.6,85.68
X$384 1519 1518 339 49 129 333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $387 r0 *1 218.4,85.68
X$387 1519 1518 360 49 101 346 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $389 r0 *1 181.44,55.44
X$389 1519 1518 249 49 230 231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $391 m0 *1 222.88,75.6
X$391 1519 1518 314 49 53 295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $394 m0 *1 221.76,15.12
X$394 1519 1518 54 49 50 65 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $397 m0 *1 162.96,156.24
X$397 1518 547 1519 546 691 49 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $400 m0 *1 218.96,35.28
X$400 1519 1518 121 49 103 114 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $402 m0 *1 220.08,45.36
X$402 1519 1518 180 49 154 181 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $414 r0 *1 239.68,136.08
X$414 1519 1518 577 527 50 578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $417 r0 *1 239.12,55.44
X$417 1519 1518 253 184 50 254 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $420 m0 *1 221.76,156.24
X$420 1519 1518 671 628 50 647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $422 r0 *1 181.44,156.24
X$422 1518 693 668 1519 50 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $424 r0 *1 77.28,136.08
X$424 1519 1518 544 418 50 518 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $427 r0 *1 75.6,25.2
X$427 1519 1518 106 58 50 124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $429 r0 *1 65.52,55.44
X$429 1519 1518 206 225 50 216 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $432 r0 *1 92.4,146.16
X$432 1519 1518 621 517 50 622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $439 r0 *1 124.32,25.2
X$439 1519 1518 90 60 50 110 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $441 r0 *1 236.88,115.92
X$441 1519 1518 492 396 50 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $458 m0 *1 240.8,15.12
X$458 1519 66 98 51 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $462 r0 *1 273.84,15.12
X$462 1519 68 98 52 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $466 r0 *1 280.56,156.24
X$466 1519 1518 673 628 53 649 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $470 r0 *1 301.84,45.36
X$470 1519 1518 201 184 53 215 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $472 m0 *1 308,126
X$472 1519 1518 508 527 53 533 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $474 r0 *1 175.28,156.24
X$474 692 1518 716 668 1519 53 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $477 m0 *1 306.88,105.84
X$477 1519 1518 399 396 53 416 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $479 r0 *1 45.92,105.84
X$479 1519 1518 440 418 53 406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $481 r0 *1 54.32,15.12
X$481 1519 1518 73 58 53 57 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $487 m0 *1 52.64,55.44
X$487 1519 1518 204 225 53 205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $490 r0 *1 101.92,15.12
X$490 1519 1518 77 60 53 78 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $493 r0 *1 64.96,156.24
X$493 1519 1518 645 517 53 646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $512 r0 *1 214.48,15.12
X$512 1519 65 64 54 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $517 m0 *1 122.08,95.76
X$517 1518 55 388 1519 373 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $526 r0 *1 10.08,15.12
X$526 1519 1518 56 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $529 m0 *1 49.84,25.2
X$529 1519 57 86 73 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $531 r0 *1 59.92,25.2
X$531 1519 1518 119 105 109 57 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $534 m0 *1 151.76,105.84
X$534 1519 407 1518 408 376 410 58 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $536 r0 *1 155.68,55.44
X$536 1519 1518 244 58 230 229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $541 m0 *1 70,25.2
X$541 1519 1518 74 58 87 75 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $545 r0 *1 51.52,25.2
X$545 1519 1518 104 58 101 105 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $548 r0 *1 61.04,35.28
X$548 1519 1518 151 58 129 133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $550 m0 *1 141.68,25.2
X$550 1519 1518 84 58 103 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $552 r0 *1 136.08,35.28
X$552 1519 1518 138 58 154 126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $554 r0 *1 154,95.76
X$554 1519 409 58 344 402 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $572 r0 *1 79.52,15.12
X$572 1519 1518 59 76 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $574 m0 *1 131.6,105.84
X$574 1519 407 1518 408 374 410 60 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $576 r0 *1 134.4,55.44
X$576 1519 1518 227 60 230 228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $578 r0 *1 108.08,55.44
X$578 1519 1518 246 60 103 226 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $580 r0 *1 92.4,45.36
X$580 1519 1518 192 60 87 193 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $582 r0 *1 113.12,35.28
X$582 1519 1518 172 60 154 155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $589 r0 *1 92.4,35.28
X$589 1519 1518 153 60 129 135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $592 m0 *1 87.92,25.2
X$592 1519 1518 89 60 101 107 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $594 r0 *1 132.16,95.76
X$594 1519 409 60 344 389 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $609 m0 *1 138.88,75.6
X$609 1519 61 1518 312 195 287 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $611 r0 *1 144.48,65.52
X$611 1519 158 1518 291 247 61 287 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $613 m0 *1 130.48,75.6
X$613 1519 1518 311 61 280 312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $616 m0 *1 128.8,115.92
X$616 1519 1518 464 91 476 61 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $621 r0 *1 148.4,25.2
X$621 1519 1518 96 140 62 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $634 m0 *1 262.08,65.52
X$634 1519 238 64 256 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $636 r0 *1 283.36,45.36
X$636 1519 185 64 186 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $638 r0 *1 231.84,15.12
X$638 1519 83 64 82 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $640 r0 *1 229.6,35.28
X$640 1519 164 64 145 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $642 r0 *1 211.12,25.2
X$642 1519 114 64 121 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $644 m0 *1 223.44,105.84
X$644 1519 64 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $647 m0 *1 238.56,55.44
X$647 1519 213 64 198 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $649 r0 *1 217.84,75.6
X$649 1519 295 64 314 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $651 m0 *1 255.92,75.6
X$651 1519 317 64 297 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $653 r0 *1 215.04,45.36
X$653 1519 181 64 180 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $655 m0 *1 297.36,55.44
X$655 1519 215 64 201 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $657 m0 *1 267.68,25.2
X$657 1519 117 64 99 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $659 r0 *1 223.44,95.76
X$659 1519 359 64 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $662 r0 *1 227.92,85.68
X$662 1519 362 64 361 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $664 m0 *1 246.96,35.28
X$664 1519 128 64 116 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $687 m0 *1 222.32,25.2
X$687 76 81 96 65 1519 1518 97 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $693 m0 *1 250.88,25.2
X$693 76 81 96 66 1519 1518 147 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $696 m0 *1 268.8,126
X$696 134 109 67 528 1519 1518 507 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $698 r0 *1 266.56,95.76
X$698 134 109 67 380 1519 1518 400 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $700 r0 *1 261.52,75.6
X$700 134 109 67 317 1519 1518 363 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $703 r0 *1 175.84,45.36
X$703 134 109 67 143 1519 1518 161 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $705 r0 *1 269.36,45.36
X$705 134 109 67 200 1519 1518 276 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $707 m0 *1 82.32,156.24
X$707 1519 620 67 622 646 109 662 663 1518 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $710 m0 *1 237.44,45.36
X$710 134 109 67 164 1519 1518 165 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $712 m0 *1 154.56,186.48
X$712 1519 1518 833 736 666 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $714 m0 *1 151.2,146.16
X$714 1519 1518 67 76 242 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $716 m0 *1 84.56,95.76
X$716 134 109 67 372 1519 1518 355 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $719 r0 *1 258.72,15.12
X$719 1519 1518 67 100 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $721 m0 *1 269.92,35.28
X$721 1518 76 67 1519 92 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $723 r0 *1 214.48,176.4
X$723 1519 753 67 795 811 109 794 755 1518 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $725 m0 *1 215.04,206.64
X$725 1519 739 67 902 915 109 916 917 1518 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $727 r0 *1 104.72,35.28
X$727 134 1518 67 135 1519 136 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $729 r0 *1 87.36,35.28
X$729 1518 67 170 1519 148 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $731 r0 *1 208.32,75.6
X$731 134 109 67 333 1519 1518 313 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $735 r0 *1 90.16,65.52
X$735 1519 1518 299 268 67 286 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $737 m0 *1 257.04,176.4
X$737 1519 1518 654 772 67 717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $740 m0 *1 134.96,156.24
X$740 1519 1518 682 665 67 624 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $772 r0 *1 283.36,25.2
X$772 1519 1518 118 117 109 68 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $777 r0 *1 165.2,105.84
X$777 1519 1518 455 69 476 142 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $779 r0 *1 160.72,115.92
X$779 1519 452 1518 455 477 69 545 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $784 m0 *1 3.92,25.2
X$784 71 72 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $788 m0 *1 13.44,25.2
X$788 72 1518 1519 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $792 r0 *1 62.72,15.12
X$792 1519 75 86 74 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $795 m0 *1 82.88,25.2
X$795 1518 76 75 1519 88 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $802 m0 *1 271.04,166.32
X$802 1519 1518 76 134 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $804 m0 *1 250.32,146.16
X$804 76 81 96 578 1519 1518 552 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $806 r0 *1 271.6,126
X$806 76 109 96 553 1519 1518 529 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $808 r0 *1 269.36,85.68
X$808 76 109 96 349 1519 1518 367 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $810 r0 *1 146.72,35.28
X$810 1519 76 1518 139 140 188 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $812 m0 *1 268.24,115.92
X$812 76 109 96 458 1519 1518 488 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $814 m0 *1 166.88,35.28
X$814 76 109 96 94 1519 1518 150 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $816 m0 *1 272.72,55.44
X$816 76 109 96 238 1519 1518 257 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $819 r0 *1 239.68,25.2
X$819 76 109 96 83 1519 1518 146 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $822 m0 *1 120.96,146.16
X$822 1518 1519 595 76 610 596 388 623 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $826 m0 *1 91.84,95.76
X$826 76 81 96 357 1519 1518 327 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $831 m0 *1 92.96,126
X$831 1519 500 76 520 518 109 499 519 1518 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $834 m0 *1 248.08,75.6
X$834 76 81 96 296 1519 1518 316 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $837 m0 *1 106.4,45.36
X$837 76 1518 96 193 1519 175 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $839 m0 *1 248.08,115.92
X$839 76 81 96 482 1519 1518 393 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $841 m0 *1 249.76,65.52
X$841 76 81 96 254 1519 1518 255 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $843 r0 *1 196,65.52
X$843 76 109 96 293 1519 1518 302 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $845 m0 *1 68.32,126
X$845 1519 510 76 451 406 109 498 422 1518 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $848 r0 *1 82.32,85.68
X$848 76 109 96 371 1519 1518 356 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $851 r0 *1 145.04,186.48
X$851 1519 807 76 1518 714 840 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $853 m0 *1 257.6,156.24
X$853 1519 613 76 1518 96 648 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $890 m0 *1 96.32,25.2
X$890 1519 78 174 77 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $894 r0 *1 103.6,25.2
X$894 1519 1518 108 107 109 78 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $901 r0 *1 120.96,126
X$901 1518 79 489 1519 537 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $903 m0 *1 116.48,176.4
X$903 1519 1518 760 765 476 79 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $909 m0 *1 243.04,146.16
X$909 1519 81 1518 640 613 612 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $913 r0 *1 156.8,146.16
X$913 1519 1518 81 623 242 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $920 m0 *1 220.64,65.52
X$920 1518 81 242 1519 195 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $922 m0 *1 287.84,35.28
X$922 1519 1518 109 81 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $926 m0 *1 285.04,85.68
X$926 1518 364 350 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $928 r0 *1 233.52,146.16
X$928 631 81 640 655 638 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $931 r0 *1 283.92,105.84
X$931 1518 460 441 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $933 m0 *1 277.76,35.28
X$933 1518 169 183 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $935 r0 *1 285.04,55.44
X$935 1518 258 239 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $937 r0 *1 282.24,126
X$937 1518 554 530 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $939 m0 *1 112,85.68
X$939 1518 309 310 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $941 m0 *1 223.44,55.44
X$941 1518 181 236 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $943 m0 *1 123.76,156.24
X$943 1519 1518 595 681 81 682 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $945 m0 *1 145.6,45.36
X$945 1518 81 1519 126 188 96 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $947 m0 *1 111.44,55.44
X$947 81 1519 136 175 1518 220 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $949 m0 *1 204.4,35.28
X$949 1518 144 132 96 134 81 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $951 m0 *1 123.2,35.28
X$951 1519 125 81 1518 137 131 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $1001 m0 *1 13.44,105.84
X$1001 1519 447 404 86 417 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1007 m0 *1 46.48,35.28
X$1007 1519 105 86 104 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1009 m0 *1 53.76,45.36
X$1009 1519 133 86 151 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1012 r0 *1 45.92,55.44
X$1012 1519 205 86 204 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1014 r0 *1 63.84,65.52
X$1014 1519 268 86 284 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1016 r0 *1 73.92,55.44
X$1016 1519 208 86 219 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1018 m0 *1 63.84,95.76
X$1018 1519 371 86 384 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1020 m0 *1 71.12,85.68
X$1020 1519 340 86 325 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1023 r0 *1 45.36,85.68
X$1023 1519 354 86 365 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1025 m0 *1 70.56,35.28
X$1025 1519 124 86 106 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1027 m0 *1 68.88,105.84
X$1027 1519 1518 86 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $1030 m0 *1 67.2,115.92
X$1030 1519 359 86 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1032 m0 *1 42.56,65.52
X$1032 1519 267 86 278 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1034 m0 *1 62.72,55.44
X$1034 1519 216 86 206 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1036 m0 *1 42.56,85.68
X$1036 1519 324 86 323 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1052 m0 *1 249.2,156.24
X$1052 1519 1518 632 628 87 648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1056 m0 *1 267.68,105.84
X$1056 1519 1518 437 396 87 458 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1058 m0 *1 185.36,166.32
X$1058 692 1518 752 668 1519 87 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1060 m0 *1 266,136.08
X$1060 1519 1518 579 527 87 553 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1062 r0 *1 266.56,55.44
X$1062 1519 1518 256 184 87 238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1068 r0 *1 73.36,75.6
X$1068 1519 1518 325 225 87 340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1070 r0 *1 85.68,136.08
X$1070 1519 1518 586 418 87 499 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1076 m0 *1 82.88,166.32
X$1076 1519 1518 727 517 87 663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1097 m0 *1 87.36,35.28
X$1097 1519 1518 130 88 109 124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1100 r0 *1 84,25.2
X$1100 1519 107 174 89 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1103 m0 *1 121.52,25.2
X$1103 1519 110 174 90 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1107 r0 *1 120.4,105.84
X$1107 1519 452 1518 464 407 91 387 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $1110 m0 *1 285.04,105.84
X$1110 1519 1518 92 419 442 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1112 r0 *1 266,146.16
X$1112 1518 92 639 1519 638 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1114 r0 *1 291.76,126
X$1114 1519 1518 92 536 560 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1116 r0 *1 206.08,25.2
X$1116 1519 1518 92 122 102 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1118 m0 *1 101.36,75.6
X$1118 1519 1518 92 301 307 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1120 m0 *1 77.84,65.52
X$1120 1518 92 260 1519 279 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1123 r0 *1 284.48,35.28
X$1123 1519 1518 92 187 118 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1125 m0 *1 283.36,55.44
X$1125 1519 1518 92 217 214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1127 r0 *1 225.12,65.52
X$1127 1519 1518 92 294 275 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1130 r0 *1 294,85.68
X$1130 1519 1518 336 366 92 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1134 r0 *1 106.4,45.36
X$1134 1519 202 108 220 92 240 125 1518 gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $1163 r0 *1 189.28,25.2
X$1163 1519 112 95 1518 113 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1171 m0 *1 130.48,35.28
X$1171 1519 1518 96 131 110 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1176 m0 *1 152.32,35.28
X$1176 1518 96 130 1519 141 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1180 m0 *1 221.2,146.16
X$1180 1518 96 647 1519 641 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1183 m0 *1 257.6,85.68
X$1183 134 109 96 348 1519 1518 337 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1190 m0 *1 227.36,35.28
X$1190 134 109 96 114 1519 1518 120 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1192 m0 *1 183.68,35.28
X$1192 134 109 96 127 1519 1518 112 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1194 r0 *1 110.32,85.68
X$1194 134 109 96 386 1519 1518 326 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1198 m0 *1 239.68,85.68
X$1198 134 109 96 362 1519 1518 378 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1200 r0 *1 258.16,35.28
X$1200 134 109 96 128 1519 1518 171 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1202 m0 *1 259.84,25.2
X$1202 1519 1518 100 96 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1205 r0 *1 236.32,126
X$1205 134 109 96 551 1519 1518 562 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1210 m0 *1 87.92,85.68
X$1210 1518 96 340 1519 305 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1213 r0 *1 247.52,55.44
X$1213 134 109 96 213 1519 1518 237 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1216 r0 *1 80.64,45.36
X$1216 1519 1518 96 207 216 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1228 r0 *1 92.4,115.92
X$1228 1519 1518 489 500 96 510 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1232 r0 *1 119.28,156.24
X$1232 1519 96 689 1518 681 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1234 m0 *1 90.16,65.52
X$1234 1518 134 1519 208 281 96 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1237 r0 *1 123.76,35.28
X$1237 1518 134 1519 155 137 96 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $1300 r0 *1 227.92,25.2
X$1300 1519 120 97 1518 115 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1302 m0 *1 290.08,105.84
X$1302 1519 398 98 397 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1304 m0 *1 288.96,126
X$1304 1519 532 98 531 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1306 m0 *1 276.08,115.92
X$1306 1519 460 98 484 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1308 m0 *1 273.84,95.76
X$1308 1519 364 98 381 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1310 r0 *1 262.64,105.84
X$1310 1519 458 98 437 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1312 r0 *1 303.52,115.92
X$1312 1519 533 98 508 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1315 m0 *1 264.88,85.68
X$1315 1519 349 98 335 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1318 m0 *1 278.88,65.52
X$1318 1519 258 98 277 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1321 m0 *1 294.56,85.68
X$1321 1519 321 98 320 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1324 r0 *1 283.36,75.6
X$1324 1519 319 98 318 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1327 m0 *1 226.8,95.76
X$1327 1519 359 98 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $1332 r0 *1 246.4,85.68
X$1332 1519 348 98 347 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1335 m0 *1 231.28,115.92
X$1335 1519 482 98 492 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1337 m0 *1 256.48,95.76
X$1337 1519 380 98 395 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1339 r0 *1 267.68,35.28
X$1339 1519 169 98 168 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1341 m0 *1 232.96,65.52
X$1341 1519 254 98 253 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1344 r0 *1 301.28,95.76
X$1344 1519 416 98 399 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1346 r0 *1 234.64,75.6
X$1346 1519 296 98 315 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1348 m0 *1 255.92,55.44
X$1348 1519 200 98 199 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1374 m0 *1 179.2,166.32
X$1374 692 1518 732 668 1519 101 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1377 m0 *1 292.32,45.36
X$1377 1519 1518 186 184 101 185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1379 r0 *1 291.76,95.76
X$1379 1519 1518 397 396 101 398 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1381 m0 *1 265.44,156.24
X$1381 1519 1518 672 628 101 633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1384 m0 *1 292.32,136.08
X$1384 1519 1518 531 527 101 532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1386 m0 *1 57.12,115.92
X$1386 1519 1518 474 418 101 498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1390 r0 *1 49.28,65.52
X$1390 1519 1518 278 225 101 267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1395 r0 *1 73.36,156.24
X$1395 1519 1518 680 517 101 662 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1419 r0 *1 231.28,105.84
X$1419 1519 1518 361 396 103 362 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1421 r0 *1 228.48,136.08
X$1421 1519 1518 600 527 103 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1423 m0 *1 262.64,166.32
X$1423 1519 1518 728 628 103 717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1425 m0 *1 92.4,75.6
X$1425 1519 1518 306 225 103 286 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1428 r0 *1 244.16,45.36
X$1428 1519 1518 198 184 103 213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1431 r0 *1 101.92,136.08
X$1431 1519 1518 587 418 103 519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1433 m0 *1 193.2,176.4
X$1433 1518 752 737 1519 103 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1437 m0 *1 134.96,146.16
X$1437 1519 1518 597 517 103 624 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1507 r0 *1 116.48,55.44
X$1507 109 1518 226 242 1519 240 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $1513 r0 *1 38.08,55.44
X$1513 1519 1518 259 109 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $1515 m0 *1 82.88,65.52
X$1515 1519 109 1518 300 281 207 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1522 m0 *1 70.56,45.36
X$1522 1518 109 133 1519 152 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1525 r0 *1 154.56,186.48
X$1525 1519 1518 841 109 452 768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1528 r0 *1 301.28,75.6
X$1528 1519 1518 336 319 109 321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1530 m0 *1 288.96,55.44
X$1530 1519 1518 214 185 109 215 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1532 r0 *1 301.28,126
X$1532 1519 1518 560 532 109 533 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1535 r0 *1 301.28,105.84
X$1535 1519 1518 442 398 109 416 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1537 r0 *1 273.84,146.16
X$1537 1519 1518 639 633 109 649 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1541 m0 *1 229.6,85.68
X$1541 1519 1518 275 346 109 295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1544 r0 *1 80.64,65.52
X$1544 285 109 300 280 279 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $1546 m0 *1 59.36,85.68
X$1546 1519 1518 307 324 109 354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1548 m0 *1 59.36,65.52
X$1548 1519 1518 260 267 109 205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1630 r0 *1 185.92,45.36
X$1630 196 162 113 179 1518 1519 223 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1632 m0 *1 184.8,45.36
X$1632 1518 178 1519 203 113 162 179 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1641 m0 *1 202.72,65.52
X$1641 1518 265 1519 273 115 274 251 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1643 m0 *1 212.8,65.52
X$1643 263 274 115 251 1518 1519 261 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1660 r0 *1 71.68,35.28
X$1660 1519 1518 170 152 134 119 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1673 m0 *1 195.44,35.28
X$1673 1519 1518 122 179 132 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1678 m0 *1 3.36,35.28
X$1678 1519 1518 123 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $1705 m0 *1 260.4,126
X$1705 1519 1518 526 527 129 528 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1708 r0 *1 258.16,95.76
X$1708 1519 1518 395 396 129 380 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1710 r0 *1 174.16,166.32
X$1710 1518 732 737 1519 129 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1713 r0 *1 260.96,45.36
X$1713 1519 1518 199 184 129 200 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1717 r0 *1 66.64,126
X$1717 1519 1518 450 418 129 422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1720 m0 *1 73.36,75.6
X$1720 1519 1518 284 225 129 268 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1724 m0 *1 132.72,166.32
X$1724 1519 1518 690 517 129 665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1726 m0 *1 247.52,176.4
X$1726 1519 1518 787 628 129 772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1766 r0 *1 259.84,146.16
X$1766 1519 1518 134 612 654 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $1786 r0 *1 234.08,176.4
X$1786 1518 134 771 1519 630 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1790 m0 *1 81.76,75.6
X$1790 1519 1518 285 299 134 305 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1797 r0 *1 218.96,166.32
X$1797 1519 1518 493 753 134 739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1807 m0 *1 87.92,146.16
X$1807 1519 134 620 1518 610 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1856 m0 *1 89.6,45.36
X$1856 1519 135 174 153 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1867 r0 *1 158.48,35.28
X$1867 159 141 139 148 1518 1519 149 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $1869 m0 *1 156.8,45.36
X$1869 1518 189 1519 190 139 141 148 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $1881 m0 *1 172.48,55.44
X$1881 1519 142 1518 178 195 266 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1883 r0 *1 170.8,45.36
X$1883 1519 1518 142 196 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1900 r0 *1 246.4,35.28
X$1900 1519 165 146 1518 166 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1904 r0 *1 252,35.28
X$1904 1519 171 147 1518 167 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1913 m0 *1 191.52,55.44
X$1913 223 222 149 190 1519 1518 221 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $1918 r0 *1 180.88,35.28
X$1918 1519 161 150 1518 162 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $1931 r0 *1 281.12,115.92
X$1931 1519 1518 484 396 154 460 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1934 m0 *1 283.92,136.08
X$1934 1519 1518 580 527 154 554 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1936 r0 *1 283.36,65.52
X$1936 1519 1518 277 184 154 258 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1938 m0 *1 84.56,105.84
X$1938 1519 1518 424 418 154 451 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1944 m0 *1 174.16,166.32
X$1944 1518 716 737 1519 154 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $1948 r0 *1 109.76,156.24
X$1948 1519 1518 664 517 154 689 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1954 m0 *1 236.32,186.48
X$1954 1519 1518 740 628 154 771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1956 m0 *1 82.32,55.44
X$1956 1519 1518 219 225 154 208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1978 m0 *1 114.24,45.36
X$1978 1519 155 174 172 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $1984 m0 *1 137.2,85.68
X$1984 1519 156 1518 351 195 352 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1986 r0 *1 140,75.6
X$1986 1519 1518 156 329 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $1990 r0 *1 133.84,105.84
X$1990 1519 452 1518 443 453 157 465 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $1992 m0 *1 141.68,105.84
X$1992 1519 1518 443 157 476 158 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1997 r0 *1 199.36,55.44
X$1997 1519 1518 158 233 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2001 r0 *1 203.28,65.52
X$2001 1519 158 1518 250 195 291 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2010 m0 *1 155.12,95.76
X$2010 1518 376 1519 402 370 159 375 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2035 r0 *1 196,45.36
X$2035 1518 197 1519 222 166 167 182 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2037 m0 *1 203.28,55.44
X$2037 211 167 166 182 1518 1519 232 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2066 m0 *1 3.92,45.36
X$2066 1519 1518 173 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $2070 r0 *1 84,75.6
X$2070 1519 286 174 306 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2072 r0 *1 101.92,95.76
X$2072 1519 359 174 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $2076 m0 *1 99.12,95.76
X$2076 1519 174 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $2079 m0 *1 110.88,105.84
X$2079 1519 409 225 174 385 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $2081 m0 *1 132.72,55.44
X$2081 1519 228 174 227 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2088 r0 *1 101.92,75.6
X$2088 1519 309 174 308 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2090 m0 *1 102.48,65.52
X$2090 1519 226 174 246 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2092 m0 *1 91.84,55.44
X$2092 1519 193 174 192 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2094 m0 *1 94.64,85.68
X$2094 1519 357 174 368 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2097 r0 *1 72.24,95.76
X$2097 1519 372 174 390 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2099 r0 *1 116.48,65.52
X$2099 1519 270 174 269 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2117 r0 *1 137.2,45.36
X$2117 1519 177 1518 176 195 262 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2119 r0 *1 128.8,45.36
X$2119 1519 1518 194 177 202 176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2122 m0 *1 137.2,65.52
X$2122 1519 1518 177 271 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2151 m0 *1 281.68,45.36
X$2151 1519 1518 187 182 183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2158 r0 *1 161.28,105.84
X$2158 1519 1518 184 466 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2160 r0 *1 313.04,75.6
X$2160 184 1518 1519 322 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2169 r0 *1 169.12,65.52
X$2169 1519 1518 289 184 230 290 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2173 m0 *1 148.96,115.92
X$2173 1519 409 184 344 454 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $2215 r0 *1 3.36,45.36
X$2215 1519 1518 191 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $2226 r0 *1 126,85.68
X$2226 1519 426 373 194 311 358 1518 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $2230 r0 *1 184.24,75.6
X$2230 1519 411 1518 197 195 332 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2238 r0 *1 224,105.84
X$2238 1519 428 1518 433 195 432 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2242 m0 *1 230.16,126
X$2242 1519 415 1518 413 195 525 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2244 r0 *1 225.68,115.92
X$2244 1519 459 1518 490 195 481 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $2248 r0 *1 175.28,105.84
X$2248 1518 195 1519 456 345 444 283 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2268 m0 *1 150.08,65.52
X$2268 1518 1519 228 271 247 264 283 196 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $2292 r0 *1 212.8,55.44
X$2292 261 203 234 241 1519 1518 252 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2316 r0 *1 164.08,55.44
X$2316 1519 1518 229 209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2321 m0 *1 188.16,55.44
X$2321 1519 1518 231 210 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2327 m0 *1 166.88,85.68
X$2327 1518 1519 343 329 248 331 345 211 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $2330 m0 *1 191.52,105.84
X$2330 1519 1518 411 211 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2335 r0 *1 202.72,55.44
X$2335 1518 250 1519 243 235 212 218 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2337 r0 *1 274.96,65.52
X$2337 1519 276 257 1518 212 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2339 r0 *1 221.2,55.44
X$2339 233 212 235 218 1518 1519 241 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2366 r0 *1 280,55.44
X$2366 1519 1518 217 218 239 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2388 m0 *1 206.64,75.6
X$2388 1519 288 252 221 298 1518 282 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $2399 r0 *1 21.84,55.44
X$2399 224 1518 1519 259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2402 m0 *1 121.52,85.68
X$2402 1519 1518 225 369 410 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2405 r0 *1 48.72,115.92
X$2405 225 1518 1519 445 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $2419 m0 *1 121.52,65.52
X$2419 1519 1518 269 225 230 270 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2436 m0 *1 140.56,65.52
X$2436 1519 1518 228 262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2449 m0 *1 212.8,146.16
X$2449 1519 1518 599 628 230 576 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2451 r0 *1 179.2,166.32
X$2451 1518 738 668 1519 230 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2455 r0 *1 213.36,126
X$2455 1519 1518 523 527 230 524 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2459 m0 *1 210.56,115.92
X$2459 1519 1518 429 396 230 412 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2466 m0 *1 111.44,146.16
X$2466 1519 1518 611 517 230 596 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2468 m0 *1 111.44,136.08
X$2468 1519 1518 561 418 230 520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2491 r0 *1 210.56,65.52
X$2491 232 243 273 272 1519 1518 282 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2499 m0 *1 245.28,126
X$2499 512 511 506 505 1518 1519 234 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2507 r0 *1 254.8,55.44
X$2507 1519 237 255 1518 235 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2511 m0 *1 225.68,65.52
X$2511 1519 1518 294 251 236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2539 r0 *1 226.8,146.16
X$2539 242 1519 641 630 1518 631 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $2555 r0 *1 8.4,55.44
X$2555 1519 1518 245 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $2615 m0 *1 168.56,65.52
X$2615 1519 1518 264 266 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2646 r0 *1 141.12,65.52
X$2646 1519 1518 270 287 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2653 m0 *1 137.2,95.76
X$2653 1518 374 1519 389 370 271 375 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2660 m0 *1 126.56,85.68
X$2660 1518 351 1519 272 338 341 328 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2670 m0 *1 215.6,75.6
X$2670 1519 313 302 1518 274 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2720 m0 *1 143.36,146.16
X$2720 625 288 426 563 1518 1519 614 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2723 r0 *1 144.48,136.08
X$2723 426 1518 563 476 1519 288 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $2729 m0 *1 164.08,75.6
X$2729 1519 290 344 289 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2732 r0 *1 177.52,65.52
X$2732 1519 1518 290 291 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2744 m0 *1 182,75.6
X$2744 1519 293 344 292 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2768 m0 *1 255.36,115.92
X$2768 434 483 457 414 1519 1518 298 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $2779 m0 *1 121.52,75.6
X$2779 1519 1518 301 328 310 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $2792 r0 *1 2.24,75.6
X$2792 1519 1518 304 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $2830 r0 *1 251.44,75.6
X$2830 1519 337 316 1518 334 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2867 r0 *1 118.72,75.6
X$2867 1519 326 327 1518 338 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2876 r0 *1 126.56,75.6
X$2876 1519 358 328 1518 338 329 341 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $2885 r0 *1 140.56,115.92
X$2885 1519 329 375 1518 503 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2891 r0 *1 166.32,85.68
X$2891 1519 331 344 330 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2900 r0 *1 180.88,75.6
X$2900 1519 1518 331 332 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2913 m0 *1 244.72,105.84
X$2913 1518 413 1519 434 334 379 383 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $2915 r0 *1 241.36,105.84
X$2915 430 379 334 383 1518 1519 491 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $2950 r0 *1 90.16,85.68
X$2950 1519 355 356 1518 341 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $2956 r0 *1 149.52,85.68
X$2956 1519 343 344 342 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2959 m0 *1 147.84,85.68
X$2959 1519 1518 343 352 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $2969 r0 *1 173.04,95.76
X$2969 1519 344 1518 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $2982 m0 *1 207.2,95.76
X$2982 1519 377 344 401 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $2985 m0 *1 172.48,95.76
X$2985 1519 359 344 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3019 m0 *1 290.64,95.76
X$3019 1519 1518 366 383 350 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3032 r0 *1 2.24,85.68
X$3032 1519 1518 353 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $3053 r0 *1 186.48,186.48
X$3053 1519 359 810 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3055 r0 *1 184.24,176.4
X$3055 1519 359 589 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3059 m0 *1 234.64,166.32
X$3059 1519 359 707 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3061 r0 *1 235.76,156.24
X$3061 1519 359 513 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3063 m0 *1 104.16,226.8
X$3063 1519 359 968 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3065 m0 *1 113.12,216.72
X$3065 1519 359 705 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3067 m0 *1 152.88,166.32
X$3067 1519 710 359 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $3070 m0 *1 100.8,115.92
X$3070 1519 359 423 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3077 m0 *1 65.52,206.64
X$3077 1519 359 791 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3079 r0 *1 68.88,206.64
X$3079 1519 359 940 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3083 r0 *1 60.48,115.92
X$3083 1519 359 405 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $3105 r0 *1 263.76,85.68
X$3105 1519 363 367 1518 379 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3128 r0 *1 118.16,85.68
X$3128 1518 369 1519 387 385 370 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3132 m0 *1 181.44,105.84
X$3132 1518 421 1519 392 370 430 375 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3139 m0 *1 133.84,176.4
X$3139 1519 1518 751 370 766 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3141 m0 *1 192.64,115.92
X$3141 1518 478 1519 479 514 370 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3143 m0 *1 192.64,166.32
X$3143 1518 706 1519 731 694 370 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3145 r0 *1 180.88,136.08
X$3145 1518 590 1519 616 573 370 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3148 m0 *1 122.08,136.08
X$3148 1518 588 1519 501 502 370 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3184 m0 *1 152.88,156.24
X$3184 1519 476 666 1518 375 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $3198 r0 *1 222.32,115.92
X$3198 1519 1518 377 525 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3200 r0 *1 211.12,105.84
X$3200 1518 1519 377 430 467 576 444 431 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $3208 r0 *1 251.44,95.76
X$3208 1519 378 393 1518 394 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3227 m0 *1 324.8,126
X$3227 527 1518 1519 382 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3252 m0 *1 92.96,105.84
X$3252 1519 386 423 391 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3279 m0 *1 254.8,105.84
X$3279 435 420 394 436 1518 1519 414 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3281 r0 *1 249.2,105.84
X$3281 1518 433 1519 457 394 420 436 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $3286 r0 *1 188.16,115.92
X$3286 1519 1518 396 478 410 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3290 m0 *1 318.08,115.92
X$3290 396 1518 1519 462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3297 r0 *1 193.2,115.92
X$3297 1519 409 396 589 514 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3325 m0 *1 262.64,115.92
X$3325 1519 400 488 1518 420 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $3336 m0 *1 3.36,105.84
X$3336 1519 1518 403 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $3339 m0 *1 32.48,105.84
X$3339 1518 404 449 1519 417 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3342 r0 *1 25.76,115.92
X$3342 496 404 448 472 1518 1519 487 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3344 m0 *1 65.52,156.24
X$3344 1519 662 405 680 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3347 r0 *1 63.84,146.16
X$3347 1519 646 405 645 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3349 m0 *1 50.4,136.08
X$3349 1519 447 572 405 543 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3351 r0 *1 58.24,136.08
X$3351 1519 447 568 405 608 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3353 r0 *1 3.92,105.84
X$3353 1519 447 448 405 439 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3355 m0 *1 26.32,136.08
X$3355 1519 447 542 405 540 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3358 m0 *1 34.16,115.92
X$3358 1519 447 497 405 473 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3360 m0 *1 7.28,115.92
X$3360 1519 447 472 405 463 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3362 m0 *1 9.52,126
X$3362 1519 447 496 405 509 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3364 r0 *1 13.44,126
X$3364 1519 447 541 405 584 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3367 m0 *1 2.24,156.24
X$3367 1519 447 658 405 653 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3369 m0 *1 77.84,136.08
X$3369 1519 499 405 586 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3372 r0 *1 19.6,146.16
X$3372 1519 447 619 405 618 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3374 m0 *1 2.24,136.08
X$3374 1519 447 585 405 583 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3376 r0 *1 84,156.24
X$3376 1519 622 405 621 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3379 m0 *1 51.52,126
X$3379 1519 498 405 474 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3381 r0 *1 58.8,126
X$3381 1519 1518 405 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $3383 r0 *1 75.04,126
X$3383 1519 518 405 544 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3385 m0 *1 52.08,105.84
X$3385 1519 406 405 440 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3407 r0 *1 191.52,206.64
X$3407 1518 407 914 1519 826 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3412 r0 *1 195.44,126
X$3412 1519 452 1518 494 407 480 479 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $3414 m0 *1 176.4,257.04
X$3414 1519 1518 1154 407 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3416 r0 *1 196,136.08
X$3416 1519 452 1518 550 407 575 616 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $3418 m0 *1 201.6,166.32
X$3418 1519 452 1518 669 407 670 731 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $3422 m0 *1 122.08,206.64
X$3422 1519 407 1518 931 822 767 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3424 r0 *1 109.2,236.88
X$3424 1518 407 1076 1519 1008 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3427 r0 *1 157.92,206.64
X$3427 1519 1518 407 948 880 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3430 r0 *1 162.96,257.04
X$3430 1172 1133 407 1519 1518 1210 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $3432 r0 *1 151.76,156.24
X$3432 700 736 410 667 407 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3434 m0 *1 146.72,216.72
X$3434 1519 1518 407 912 925 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3439 m0 *1 51.52,216.72
X$3439 407 1518 898 939 1519 909 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3441 m0 *1 152.88,246.96
X$3441 1519 1518 407 1100 1091 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3443 m0 *1 151.76,257.04
X$3443 407 1166 925 1172 1519 1518 1148 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3445 r0 *1 39.76,206.64
X$3445 407 938 923 878 1519 1518 908 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3447 r0 *1 15.68,206.64
X$3447 1519 1518 934 936 407 887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3449 r0 *1 16.24,186.48
X$3449 1519 1518 835 850 407 829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3451 m0 *1 39.76,216.72
X$3451 1519 966 407 1518 950 937 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $3454 m0 *1 94.08,246.96
X$3454 1518 407 1519 930 1104 1103 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3491 m0 *1 138.88,176.4
X$3491 1518 751 766 1519 408 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3494 r0 *1 131.04,166.32
X$3494 1519 1518 730 408 750 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $3499 r0 *1 173.6,176.4
X$3499 409 1518 425 804 1519 668 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3502 r0 *1 165.76,176.4
X$3502 1519 1518 409 447 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3505 m0 *1 172.48,226.8
X$3505 1519 409 1015 810 1029 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3507 r0 *1 161.28,246.96
X$3507 1519 1133 810 1033 409 1518 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $3510 r0 *1 132.72,206.64
X$3510 1519 409 913 705 947 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3512 m0 *1 181.44,146.16
X$3512 1519 409 527 589 573 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3514 r0 *1 196.56,156.24
X$3514 1519 409 628 589 694 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3516 r0 *1 225.12,216.72
X$3516 1519 409 917 707 1001 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3520 m0 *1 246.96,257.04
X$3520 1163 1518 1519 409 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $3522 r0 *1 170.8,236.88
X$3522 1519 409 1072 810 1073 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3524 r0 *1 187.04,246.96
X$3524 1519 409 1135 810 1134 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3526 m0 *1 159.04,176.4
X$3526 1519 409 692 589 769 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3528 r0 *1 162.96,186.48
X$3528 1519 409 843 810 824 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3530 r0 *1 163.52,196.56
X$3530 1519 409 893 810 842 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3538 r0 *1 111.44,166.32
X$3538 1519 409 418 705 744 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3540 r0 *1 232.4,186.48
X$3540 1519 409 795 707 853 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3542 m0 *1 203.28,176.4
X$3542 1519 409 794 589 799 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3544 m0 *1 228.48,176.4
X$3544 1519 409 755 707 754 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3547 r0 *1 204.96,206.64
X$3547 1519 409 916 810 942 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3550 m0 *1 201.6,186.48
X$3550 1519 409 811 810 890 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3552 m0 *1 201.6,216.72
X$3552 1519 409 915 810 956 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3556 m0 *1 234.64,206.64
X$3556 1519 409 902 707 905 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3559 m0 *1 122.64,126
X$3559 1519 409 517 423 502 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3595 r0 *1 188.72,156.24
X$3595 1519 574 1518 706 410 628 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3602 r0 *1 188.72,136.08
X$3602 1519 574 1518 590 410 527 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3609 m0 *1 125.44,166.32
X$3609 1519 1518 418 729 410 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3611 m0 *1 132.72,136.08
X$3611 1519 574 1518 588 410 517 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $3613 r0 *1 147.28,105.84
X$3613 410 466 427 454 465 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3616 r0 *1 132.16,176.4
X$3616 1518 751 1519 766 410 806 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3618 r0 *1 152.88,166.32
X$3618 745 1519 736 410 1518 547 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $3630 r0 *1 179.76,115.92
X$3630 1519 1518 515 504 476 411 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3634 r0 *1 333.2,105.84
X$3634 438 1518 1519 411 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3641 r0 *1 220.08,95.76
X$3641 1519 1518 412 432 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3643 m0 *1 204.96,105.84
X$3643 1519 412 513 429 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3655 r0 *1 233.52,115.92
X$3655 1519 1518 415 430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3659 r0 *1 314.16,105.84
X$3659 461 1518 1519 415 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3679 r0 *1 54.32,105.84
X$3679 418 1518 1519 469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3702 r0 *1 295.12,105.84
X$3702 1519 1518 419 436 441 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3719 r0 *1 62.72,105.84
X$3719 1519 422 423 450 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3725 m0 *1 94.64,136.08
X$3725 1519 519 423 587 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3728 m0 *1 104.16,156.24
X$3728 1519 689 423 664 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3731 r0 *1 101.92,115.92
X$3731 1519 423 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $3733 r0 *1 113.12,146.16
X$3733 1519 596 423 611 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3736 r0 *1 133.28,146.16
X$3736 1519 624 423 597 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3740 r0 *1 79.52,105.84
X$3740 1519 451 423 424 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3748 r0 *1 104.16,126
X$3748 1519 520 423 561 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $3757 m0 *1 167.44,146.16
X$3757 1519 452 1518 598 477 626 615 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $3760 m0 *1 173.04,126
X$3760 1519 452 1518 515 477 504 564 425 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $3763 r0 *1 202.72,236.88
X$3763 1519 1518 1087 425 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3766 m0 *1 124.32,246.96
X$3766 1519 1518 425 1034 1101 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3768 r0 *1 115.36,236.88
X$3768 1076 1010 425 1108 714 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3770 r0 *1 115.92,176.4
X$3770 1519 1518 425 785 765 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3774 r0 *1 105.84,196.56
X$3774 1519 1518 425 749 880 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $3778 r0 *1 129.92,236.88
X$3778 625 714 1078 1131 425 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3780 m0 *1 129.36,246.96
X$3780 425 1518 823 1006 1519 1121 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3782 r0 *1 159.6,216.72
X$3782 1519 1518 425 856 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3786 m0 *1 114.24,206.64
X$3786 1518 749 1519 452 839 425 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3817 r0 *1 141.68,126
X$3817 503 521 427 522 538 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $3820 r0 *1 145.04,176.4
X$3820 767 801 768 546 1519 1518 427 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $3825 r0 *1 259.28,105.84
X$3825 1519 1518 428 435 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3830 m0 *1 220.08,115.92
X$3830 1519 459 1518 481 467 428 432 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $3832 m0 *1 309.68,115.92
X$3832 485 1518 1519 428 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3834 m0 *1 201.6,115.92
X$3834 1519 1518 494 480 476 428 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3852 r0 *1 210.56,146.16
X$3852 1519 1518 627 431 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3854 m0 *1 212.8,156.24
X$3854 1519 1518 656 431 655 629 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3856 r0 *1 214.48,146.16
X$3856 1518 431 1519 623 629 576 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $3889 r0 *1 22.96,105.84
X$3889 1518 448 449 1519 439 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3914 m0 *1 43.12,126
X$3914 517 1518 1519 446 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $3918 m0 *1 33.6,236.88
X$3918 1518 447 982 1519 1084 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3920 m0 *1 90.16,176.4
X$3920 1519 447 764 791 783 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3922 m0 *1 2.24,226.8
X$3922 1519 447 1004 940 992 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3924 m0 *1 91.84,186.48
X$3924 1519 447 768 705 803 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3926 r0 *1 44.24,196.56
X$3926 1519 447 898 791 879 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3928 r0 *1 39.76,277.2
X$3928 1519 447 1266 940 1285 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3930 r0 *1 31.36,186.48
X$3930 1519 447 701 791 831 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3932 r0 *1 63.84,196.56
X$3932 1519 447 837 940 926 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3935 m0 *1 7.28,216.72
X$3935 1519 447 935 940 949 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3938 r0 *1 7.28,196.56
X$3938 1519 447 894 791 877 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3940 r0 *1 15.68,176.4
X$3940 1519 447 685 791 815 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3943 m0 *1 57.68,196.56
X$3943 1519 447 820 791 852 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3946 m0 *1 66.08,216.72
X$3946 1519 447 952 940 960 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3948 m0 *1 161.84,287.28
X$3948 1519 447 1274 810 1273 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3950 m0 *1 2.24,176.4
X$3950 1519 447 686 791 780 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3952 m0 *1 31.36,226.8
X$3952 1519 447 950 940 995 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3954 m0 *1 46.48,257.04
X$3954 1519 447 1149 940 1180 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3956 r0 *1 47.6,236.88
X$3956 1519 1023 940 1068 447 1518 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $3958 r0 *1 68.88,176.4
X$3958 1519 447 713 791 763 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3960 m0 *1 44.24,267.12
X$3960 1519 447 1188 940 1224 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3963 m0 *1 41.44,287.28
X$3963 1519 447 1295 940 1305 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3965 m0 *1 76.72,196.56
X$3965 1519 447 821 791 836 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3967 m0 *1 54.32,186.48
X$3967 1519 447 762 791 832 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3969 r0 *1 57.12,226.8
X$3969 1519 447 951 940 1005 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3972 m0 *1 126,307.44
X$3972 1519 1375 968 1027 447 1518 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $3986 m0 *1 94.08,307.44
X$3986 1519 447 1298 968 1392 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3989 r0 *1 112,297.36
X$3989 1519 447 1333 968 1345 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3993 m0 *1 92.96,317.52
X$3993 1519 447 1297 968 1412 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3996 r0 *1 67.2,307.44
X$3996 1519 447 1312 940 1410 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $3999 m0 *1 52.08,307.44
X$3999 1519 447 1311 940 1391 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4001 m0 *1 76.16,277.2
X$4001 1519 447 1254 940 1232 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4004 r0 *1 81.76,267.12
X$4004 1519 447 1103 968 1205 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4006 m0 *1 95.2,277.2
X$4006 1519 447 1233 968 1126 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4009 r0 *1 112,287.28
X$4009 1519 447 1299 968 1214 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4011 m0 *1 140.56,297.36
X$4011 1519 447 1300 968 1335 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4014 r0 *1 136.64,297.36
X$4014 1519 1360 968 1035 447 1518 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $4017 r0 *1 114.24,257.04
X$4017 1519 447 1209 705 1185 1518 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $4067 r0 *1 53.2,136.08
X$4067 1518 449 571 1519 608 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4071 m0 *1 26.32,115.92
X$4071 1518 472 449 1519 463 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4073 r0 *1 38.08,115.92
X$4073 1518 497 449 1519 473 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4075 r0 *1 20.72,115.92
X$4075 1518 496 449 1519 509 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4077 r0 *1 27.44,136.08
X$4077 1518 449 559 1519 540 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4080 r0 *1 21.28,136.08
X$4080 1518 449 605 1519 584 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4083 r0 *1 8.4,146.16
X$4083 1518 449 676 1519 653 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4086 r0 *1 57.12,186.48
X$4086 1518 449 819 1519 832 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4088 r0 *1 26.32,186.48
X$4088 1518 449 830 1519 831 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4091 r0 *1 7.28,176.4
X$4091 1518 449 789 1519 780 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4094 r0 *1 50.4,126
X$4094 1518 449 570 1519 543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4096 m0 *1 85.12,216.72
X$4096 1518 953 1519 954 449 962 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4098 m0 *1 23.52,186.48
X$4098 1518 449 790 1519 815 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4101 m0 *1 68.88,176.4
X$4101 1518 449 735 1519 763 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4103 r0 *1 19.04,156.24
X$4103 1518 449 678 1519 618 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4134 m0 *1 192.64,226.8
X$4134 1519 1518 985 452 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4139 m0 *1 114.8,196.56
X$4139 1519 1518 452 875 703 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4141 r0 *1 79.52,166.32
X$4141 452 1518 688 726 1519 714 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4143 r0 *1 103.6,226.8
X$4143 1518 880 1519 1009 910 452 1008 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4145 m0 *1 142.24,196.56
X$4145 1519 1518 452 874 625 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4147 m0 *1 148.4,166.32
X$4147 1519 1518 452 666 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4149 r0 *1 115.92,196.56
X$4149 1519 1518 452 892 900 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4151 m0 *1 92.96,216.72
X$4151 1518 745 452 1519 962 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4158 m0 *1 167.44,226.8
X$4158 1519 1518 452 984 476 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4161 m0 *1 109.2,176.4
X$4161 1519 784 1518 715 760 452 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $4164 m0 *1 102.48,206.64
X$4164 1519 928 1518 930 767 703 899 452 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $4168 m0 *1 78.96,186.48
X$4168 452 1518 805 688 1519 816 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4202 m0 *1 137.2,115.92
X$4202 1519 1518 521 453 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4208 m0 *1 182.56,115.92
X$4208 491 537 456 493 1519 1518 549 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4219 m0 *1 201.6,136.08
X$4219 1519 1518 550 575 476 459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4222 m0 *1 241.92,126
X$4222 1519 1518 459 512 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4226 m0 *1 326.48,115.92
X$4226 486 1518 1519 459 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4264 m0 *1 2.24,115.92
X$4264 1519 1518 468 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $4269 m0 *1 5.04,115.92
X$4269 1519 1518 470 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $4272 r0 *1 4.48,115.92
X$4272 1519 1518 471 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $4286 r0 *1 114.24,226.8
X$4286 1518 1012 476 1519 955 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4290 m0 *1 129.36,236.88
X$4290 1006 1518 1012 476 1519 1007 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4295 m0 *1 202.72,156.24
X$4295 1519 1518 669 670 476 627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4297 m0 *1 143.36,226.8
X$4297 1519 625 476 1518 1013 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4327 r0 *1 161.28,156.24
X$4327 1519 1518 667 477 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4338 m0 *1 316.4,126
X$4338 534 1518 1519 480 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4345 m0 *1 225.68,126
X$4345 1519 1518 524 481 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $4357 r0 *1 246.4,115.92
X$4357 1518 490 1519 483 506 511 505 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $4366 r0 *1 43.12,115.92
X$4366 1519 1518 594 497 487 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4399 r0 *1 2.24,115.92
X$4399 1519 1518 495 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $4437 r0 *1 311.36,126
X$4437 555 1518 1519 504 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4443 m0 *1 283.92,126
X$4443 1519 1518 536 505 530 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4453 m0 *1 276.08,126
X$4453 1519 507 529 1518 506 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4473 r0 *1 245.28,126
X$4473 1519 562 552 1518 511 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4481 r0 *1 260.96,136.08
X$4481 1519 553 513 579 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4483 r0 *1 243.04,146.16
X$4483 1519 648 513 632 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4485 r0 *1 263.76,156.24
X$4485 1519 633 513 672 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4487 r0 *1 277.76,136.08
X$4487 1519 554 513 580 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4491 m0 *1 208.88,126
X$4491 1519 524 513 523 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4493 r0 *1 211.68,136.08
X$4493 1519 576 513 599 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4495 m0 *1 224.56,166.32
X$4495 1519 1518 513 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $4497 r0 *1 216.72,156.24
X$4497 1519 647 513 671 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4499 m0 *1 226.24,146.16
X$4499 1519 551 513 600 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4501 m0 *1 234.08,136.08
X$4501 1519 578 513 577 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4504 r0 *1 254.8,126
X$4504 1519 528 513 526 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4506 m0 *1 276.08,156.24
X$4506 1519 649 513 673 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4527 r0 *1 34.16,126
X$4527 1518 542 516 1519 559 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4529 r0 *1 32.48,136.08
X$4529 1519 1518 567 516 569 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4572 m0 *1 127.68,176.4
X$4572 748 1518 749 751 1519 521 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4642 m0 *1 312.48,136.08
X$4642 1519 535 581 556 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4644 r0 *1 319.76,126
X$4644 1519 1518 556 557 602 535 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4647 r0 *1 330.96,126
X$4647 535 1518 1519 558 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4662 m0 *1 160.16,136.08
X$4662 1519 1518 539 566 545 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4669 m0 *1 11.76,166.32
X$4669 686 1518 541 567 1519 723 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4671 r0 *1 26.88,156.24
X$4671 685 658 686 541 1519 1518 642 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4673 m0 *1 32.48,166.32
X$4673 619 686 541 701 1519 1518 711 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4676 r0 *1 11.2,136.08
X$4676 541 1519 567 1518 605 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $4678 r0 *1 16.24,166.32
X$4678 1519 1518 541 742 733 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4681 r0 *1 21.28,166.32
X$4681 658 686 541 733 1519 1518 724 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4690 m0 *1 45.92,146.16
X$4690 572 1518 542 568 1519 644 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4694 m0 *1 39.76,146.16
X$4694 542 1518 592 569 1519 607 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4707 m0 *1 148.96,176.4
X$4707 767 1518 764 546 1519 574 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $4713 m0 *1 143.92,186.48
X$4713 1518 751 817 1519 546 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4732 m0 *1 173.6,136.08
X$4732 1519 1518 548 565 564 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $4736 m0 *1 185.36,136.08
X$4736 1519 1518 656 563 549 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4769 m0 *1 332.08,136.08
X$4769 582 1518 1519 557 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4771 r0 *1 332.08,136.08
X$4771 557 652 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $4816 m0 *1 42.56,176.4
X$4816 701 713 762 688 1519 1518 567 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $4818 m0 *1 30.8,156.24
X$4818 1518 567 642 1519 677 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4824 r0 *1 43.68,136.08
X$4824 1518 568 606 1519 571 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $4826 m0 *1 45.36,136.08
X$4826 1518 568 593 1519 569 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4841 m0 *1 52.08,146.16
X$4841 1519 572 607 1518 570 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4863 m0 *1 201.6,246.96
X$4863 1119 1518 1519 575 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $4888 r0 *1 254.8,267.12
X$4888 1519 1221 581 1229 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4891 r0 *1 238,267.12
X$4891 1519 1239 581 1250 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4894 r0 *1 249.2,236.88
X$4894 1519 1066 581 1071 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4897 m0 *1 227.92,277.2
X$4897 1519 1220 581 1261 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4899 r0 *1 201.6,277.2
X$4899 1519 1260 581 1258 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4902 m0 *1 221.2,287.28
X$4902 1519 1302 581 1332 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4905 m0 *1 250.88,226.8
X$4905 1519 1016 581 1025 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4908 r0 *1 213.92,297.36
X$4908 1519 1378 581 1362 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4910 r0 *1 179.76,297.36
X$4910 1519 1347 581 1356 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4912 r0 *1 315.28,136.08
X$4912 1519 604 581 603 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4916 r0 *1 301.28,146.16
X$4916 1519 601 581 609 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4918 r0 *1 206.64,246.96
X$4918 1519 1137 581 1136 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4920 m0 *1 290.64,166.32
X$4920 1519 719 581 725 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4923 r0 *1 196,257.04
X$4923 1519 1194 581 1212 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4925 r0 *1 218.4,226.8
X$4925 1519 1039 581 1054 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4928 m0 *1 237.44,246.96
X$4928 1519 1111 581 1118 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4930 r0 *1 209.44,287.28
X$4930 1519 1336 581 1313 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4932 r0 *1 304.64,257.04
X$4932 1519 1199 581 1208 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4934 m0 *1 285.6,327.6
X$4934 1519 1459 581 1458 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4936 r0 *1 160.72,307.44
X$4936 1519 1399 581 1414 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4938 m0 *1 282.24,297.36
X$4938 1519 1350 581 1349 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4941 m0 *1 300.72,297.36
X$4941 1519 1324 581 1322 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4944 r0 *1 283.36,317.52
X$4944 1519 1423 581 1431 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4947 m0 *1 292.88,307.44
X$4947 1519 1386 581 1394 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4949 r0 *1 263.2,297.36
X$4949 1519 1385 581 1366 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4952 m0 *1 272.16,267.12
X$4952 1519 1196 581 1228 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4954 m0 *1 276.64,287.28
X$4954 1519 1303 581 1278 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4956 r0 *1 261.52,317.52
X$4956 1519 1442 581 1432 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4959 m0 *1 295.68,277.2
X$4959 1519 1222 581 1248 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4961 r0 *1 301.28,327.6
X$4961 1519 1461 581 1466 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4963 m0 *1 269.36,226.8
X$4963 1519 1017 581 1000 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4966 m0 *1 262.08,246.96
X$4966 1519 1112 581 1117 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4968 m0 *1 275.52,257.04
X$4968 1519 1177 581 1176 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4971 r0 *1 198.24,317.52
X$4971 1519 1438 581 1419 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4973 m0 *1 254.24,216.72
X$4973 1519 972 581 978 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4975 m0 *1 257.04,196.56
X$4975 1519 863 581 869 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4978 m0 *1 183.68,327.6
X$4978 1519 1455 581 1453 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4980 m0 *1 173.6,307.44
X$4980 1519 1376 581 1395 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4983 m0 *1 229.6,307.44
X$4983 1519 1379 581 1397 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4985 r0 *1 305.76,206.64
X$4985 1519 958 581 943 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4988 r0 *1 305.2,186.48
X$4988 1519 866 581 851 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4990 m0 *1 301.84,176.4
X$4990 1519 777 581 782 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4992 r0 *1 281.68,176.4
X$4992 1519 776 581 775 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4994 r0 *1 263.2,176.4
X$4994 1519 774 581 786 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4996 m0 *1 259.28,206.64
X$4996 1519 918 581 929 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $4998 r0 *1 261.52,206.64
X$4998 1519 957 581 945 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5000 r0 *1 151.2,327.6
X$5000 1519 1477 581 1464 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5002 m0 *1 151.2,317.52
X$5002 1519 1398 581 1427 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5004 r0 *1 141.68,317.52
X$5004 1519 1416 581 1446 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5007 r0 *1 244.16,317.52
X$5007 1519 1440 581 1433 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5010 m0 *1 288.4,196.56
X$5010 1519 827 581 868 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5013 m0 *1 291.2,216.72
X$5013 1519 975 581 977 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5015 m0 *1 313.04,327.6
X$5015 1519 1518 1460 581 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5017 m0 *1 289.52,226.8
X$5017 1519 1019 581 1018 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5020 m0 *1 252,287.28
X$5020 1519 1383 581 1318 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5022 m0 *1 207.76,236.88
X$5022 1519 1065 581 1081 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5024 m0 *1 256.48,277.2
X$5024 1519 1277 581 1262 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5026 r0 *1 235.2,226.8
X$5026 1519 1028 581 1053 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5029 m0 *1 226.8,257.04
X$5029 1519 1174 581 1187 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5031 m0 *1 255.92,257.04
X$5031 1519 1155 581 1138 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5033 m0 *1 297.36,156.24
X$5033 1519 696 581 679 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5035 m0 *1 240.24,297.36
X$5035 1519 1317 581 1315 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5037 m0 *1 286.72,206.64
X$5037 1519 919 581 927 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5039 r0 *1 252,307.44
X$5039 1519 1382 581 1380 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5102 r0 *1 3.92,126
X$5102 1519 1518 583 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $5109 r0 *1 4.48,136.08
X$5109 1519 1518 585 591 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5130 r0 *1 184.24,166.32
X$5130 1519 589 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $5151 m0 *1 4.48,146.16
X$5151 591 1518 1519 684 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5153 r0 *1 38.64,136.08
X$5153 1519 1518 592 606 593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5156 r0 *1 36.4,166.32
X$5156 701 1518 746 688 1519 592 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5160 r0 *1 38.64,146.16
X$5160 1518 619 642 1519 593 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5165 m0 *1 49.84,166.32
X$5165 1518 702 703 704 709 594 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $5167 r0 *1 53.2,156.24
X$5167 1518 594 661 1519 688 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5187 m0 *1 309.68,146.16
X$5187 1519 1518 609 637 602 601 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5189 m0 *1 318.64,156.24
X$5189 601 1518 1519 674 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5194 m0 *1 231.84,267.12
X$5194 1519 1518 1210 602 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5196 r0 *1 250.32,246.96
X$5196 1519 1518 1118 1114 602 1111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5200 m0 *1 311.36,196.56
X$5200 1519 1518 851 865 602 866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5202 m0 *1 276.08,206.64
X$5202 1519 1518 929 924 602 918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5204 m0 *1 274.4,196.56
X$5204 1519 1518 869 846 602 863 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5207 r0 *1 230.16,257.04
X$5207 1519 1518 1187 1160 602 1174 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5209 r0 *1 302.4,166.32
X$5209 1519 1518 725 720 602 719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5212 m0 *1 318.08,146.16
X$5212 1519 1518 603 636 602 604 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5214 r0 *1 308.56,156.24
X$5214 1519 1518 679 699 602 696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5217 m0 *1 248.08,277.2
X$5217 1519 1518 1250 1265 602 1239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5220 r0 *1 241.36,277.2
X$5220 1519 1518 1261 1276 602 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5222 m0 *1 248.08,236.88
X$5222 1519 1518 1053 1040 602 1028 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5224 m0 *1 226.24,236.88
X$5224 1519 1518 1054 1044 602 1039 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5226 m0 *1 216.72,257.04
X$5226 1519 1518 1136 1156 602 1137 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5228 r0 *1 215.6,236.88
X$5228 1519 1518 1081 1092 602 1065 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5230 r0 *1 301.28,216.72
X$5230 1519 1518 977 987 602 975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5233 r0 *1 260.96,246.96
X$5233 1519 1518 1138 1139 602 1155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5236 r0 *1 269.92,246.96
X$5236 1519 1518 1117 1115 602 1112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5238 m0 *1 271.04,216.72
X$5238 1519 1518 945 959 602 957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5240 m0 *1 270.48,176.4
X$5240 1519 1518 786 773 602 774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5242 r0 *1 291.76,186.48
X$5242 1519 1518 868 828 602 827 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5244 r0 *1 261.52,216.72
X$5244 1519 1518 978 998 602 972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5246 m0 *1 257.04,236.88
X$5246 1519 1518 1071 1042 602 1066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5248 r0 *1 267.12,226.8
X$5248 1519 1518 1025 1041 602 1016 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5251 r0 *1 291.76,226.8
X$5251 1519 1518 1018 1043 602 1019 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5253 r0 *1 278.32,216.72
X$5253 1519 1518 1000 986 602 1017 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5256 r0 *1 309.68,176.4
X$5256 1519 1518 782 756 602 777 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5258 m0 *1 290.08,176.4
X$5258 1519 1518 775 781 602 776 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5260 m0 *1 308.56,206.64
X$5260 1519 1518 927 920 602 919 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5262 m0 *1 312.48,216.72
X$5262 1519 1518 943 976 602 958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5264 r0 *1 286.72,277.2
X$5264 1519 1518 1278 1279 602 1303 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5266 r0 *1 272.16,267.12
X$5266 1519 1518 1229 1249 602 1221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5269 r0 *1 269.36,277.2
X$5269 1519 1518 1262 1281 602 1277 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5271 m0 *1 313.6,267.12
X$5271 1519 1518 1208 1223 602 1199 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5273 r0 *1 302.96,267.12
X$5273 1519 1518 1248 1241 602 1222 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5276 r0 *1 282.8,257.04
X$5276 1519 1518 1176 1184 602 1177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5278 r0 *1 280.56,267.12
X$5278 1519 1518 1228 1244 602 1196 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5317 r0 *1 330.4,146.16
X$5317 604 1518 1519 651 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5354 m0 *1 95.76,196.56
X$5354 1519 878 714 614 891 1518 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $5359 r0 *1 167.44,156.24
X$5359 1519 1518 683 691 615 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5368 r0 *1 3.92,146.16
X$5368 1519 1518 617 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $5373 m0 *1 41.44,156.24
X$5373 1519 1518 619 643 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5378 m0 *1 39.76,166.32
X$5378 1518 658 709 685 644 619 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $5407 r0 *1 131.04,246.96
X$5407 1006 1519 625 984 1518 1130 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5411 r0 *1 124.32,246.96
X$5411 900 1519 1128 1129 1518 625 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5420 m0 *1 170.24,297.36
X$5420 1355 1518 1519 626 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5428 r0 *1 282.24,146.16
X$5428 634 1518 1519 627 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5446 r0 *1 291.76,146.16
X$5446 628 1518 1519 635 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5480 m0 *1 330.96,156.24
X$5480 636 675 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5483 r0 *1 322,146.16
X$5483 650 1518 1519 636 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5490 r0 *1 323.68,156.24
X$5490 697 1518 1519 637 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5492 r0 *1 332.08,156.24
X$5492 637 698 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5520 m0 *1 21.28,156.24
X$5520 1518 643 677 1519 678 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5522 m0 *1 44.8,156.24
X$5522 1519 1518 660 643 659 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5526 r0 *1 50.4,166.32
X$5526 1519 1518 644 704 711 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5528 m0 *1 59.36,166.32
X$5528 1519 726 659 644 712 1518 711 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $5531 r0 *1 44.8,156.24
X$5531 1518 644 1519 687 661 660 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5583 r0 *1 3.36,156.24
X$5583 1519 1518 657 gf180mcu_fd_sc_mcu9t5v0__tieh
* cell instance $5587 r0 *1 36.96,156.24
X$5587 1519 1518 659 685 658 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $5589 r0 *1 7.84,156.24
X$5589 658 1519 723 1518 676 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5604 m0 *1 49.84,176.4
X$5604 1519 713 1518 702 659 712 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5620 m0 *1 91.28,166.32
X$5620 1519 663 705 727 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5629 r0 *1 128.24,156.24
X$5629 1519 665 705 690 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5634 r0 *1 110.88,196.56
X$5634 1519 1518 745 881 666 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5636 r0 *1 146.72,236.88
X$5636 1519 1132 1100 666 856 1518 1079 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $5638 r0 *1 128.8,226.8
X$5638 1518 1077 1033 666 1011 1034 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $5659 m0 *1 178.64,176.4
X$5659 1518 770 668 1519 737 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5671 m0 *1 213.36,166.32
X$5671 695 1518 1519 670 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5723 m0 *1 21.28,176.4
X$5723 685 1519 724 1518 790 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $5736 r0 *1 6.72,166.32
X$5736 1518 686 742 1519 789 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5745 r0 *1 45.36,166.32
X$5745 1518 713 711 1519 687 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5753 m0 *1 36.4,176.4
X$5753 701 1518 746 688 1519 733 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $5756 r0 *1 36.96,176.4
X$5756 1519 1518 746 802 688 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5758 r0 *1 54.32,176.4
X$5758 1518 747 688 1519 819 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5761 r0 *1 71.12,166.32
X$5761 1519 1518 735 743 688 713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5779 m0 *1 183.68,176.4
X$5779 693 1519 1518 692 809 1520 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5782 m0 *1 196.56,186.48
X$5782 1519 1518 692 770 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5784 r0 *1 264.32,166.32
X$5784 692 1518 1519 718 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5806 m0 *1 311.92,166.32
X$5806 696 1518 1519 722 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5812 m0 *1 330.4,166.32
X$5812 699 708 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $5814 m0 *1 322,166.32
X$5814 721 1518 1519 699 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5821 m0 *1 143.92,176.4
X$5821 1519 1518 745 700 749 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5827 m0 *1 34.16,186.48
X$5827 1518 701 802 1519 830 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $5839 m0 *1 129.36,206.64
X$5839 1519 1518 703 911 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5858 r0 *1 113.12,206.64
X$5858 1519 705 1518 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $5871 r0 *1 245.28,166.32
X$5871 1519 717 707 728 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5875 m0 *1 234.64,156.24
X$5875 1519 707 1518 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $5882 r0 *1 240.24,176.4
X$5882 1519 772 707 787 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5884 r0 *1 227.92,166.32
X$5884 1519 771 707 740 1518 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $5910 r0 *1 58.24,166.32
X$5910 712 1519 1518 747 713 734 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5922 r0 *1 42.56,176.4
X$5922 746 1519 1518 762 713 1527 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5933 r0 *1 90.72,216.72
X$5933 1519 1518 714 953 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $5937 m0 *1 135.52,246.96
X$5937 1519 1007 1518 714 1120 1109 805 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5939 m0 *1 137.2,236.88
X$5939 1519 1518 714 1055 1013 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5944 r0 *1 141.68,216.72
X$5944 1519 970 1518 980 1013 714 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $5961 m0 *1 117.6,166.32
X$5961 1518 729 1519 730 744 715 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $5966 m0 *1 182,196.56
X$5966 716 1519 1518 859 843 1522 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $5983 r0 *1 301.28,176.4
X$5983 719 1518 1519 778 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5987 r0 *1 322,166.32
X$5987 741 1518 1519 720 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $5990 r0 *1 330.4,166.32
X$5990 720 757 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6037 r0 *1 210.56,216.72
X$6037 1519 916 1518 979 862 732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6040 m0 *1 207.2,196.56
X$6040 1519 794 1518 873 844 732 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6042 r0 *1 181.44,206.64
X$6042 732 1519 1518 893 843 1529 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6058 r0 *1 67.76,166.32
X$6058 1519 1518 734 743 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6064 m0 *1 148.96,186.48
X$6064 1519 1518 736 764 768 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6078 m0 *1 176.96,186.48
X$6078 738 1519 1518 770 809 808 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6102 m0 *1 109.76,196.56
X$6102 1519 1518 745 855 839 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6107 r0 *1 124.32,186.48
X$6107 1518 745 823 1519 748 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6109 r0 *1 89.04,176.4
X$6109 1519 1518 767 745 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6111 m0 *1 142.24,236.88
X$6111 1518 901 1519 1036 1078 745 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6113 m0 *1 119.84,196.56
X$6113 1519 745 838 1518 872 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6135 m0 *1 58.8,176.4
X$6135 1519 1518 762 747 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6138 r0 *1 120.96,176.4
X$6138 1519 1518 748 784 785 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6150 m0 *1 97.44,206.64
X$6150 1519 1518 823 928 749 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6158 m0 *1 126.56,186.48
X$6158 768 1518 805 751 1519 750 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6160 r0 *1 141.68,196.56
X$6160 1519 875 901 882 751 874 1518 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $6163 r0 *1 151.76,206.64
X$6163 1518 751 963 1519 941 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6179 m0 *1 183.68,206.64
X$6179 752 1519 1518 893 858 1521 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6182 r0 *1 225.12,186.48
X$6182 1519 755 1518 825 844 752 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6184 r0 *1 225.12,206.64
X$6184 1519 917 1518 961 862 752 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6194 m0 *1 230.72,186.48
X$6194 1519 1518 754 826 825 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6202 r0 *1 311.36,166.32
X$6202 756 759 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6204 m0 *1 328.16,176.4
X$6204 758 1518 1519 756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6219 m0 *1 110.88,186.48
X$6219 761 1518 1519 765 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6235 r0 *1 141.12,176.4
X$6235 1519 1518 764 801 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6238 r0 *1 92.4,176.4
X$6238 1519 1518 783 768 792 764 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6241 r0 *1 101.92,186.48
X$6241 764 1519 768 821 1518 838 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6245 r0 *1 66.08,186.48
X$6245 1519 1518 852 764 792 820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6256 r0 *1 132.72,196.56
X$6256 1519 767 1518 766 857 880 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6261 m0 *1 136.08,186.48
X$6261 1519 806 766 1518 817 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6263 m0 *1 141.12,216.72
X$6263 1519 969 766 1518 963 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6267 r0 *1 182.56,226.8
X$6267 1519 1518 1057 767 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6275 r0 *1 101.92,176.4
X$6275 1518 767 804 1519 792 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6280 r0 *1 139.44,236.88
X$6280 1519 1078 1518 1079 880 767 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6282 r0 *1 69.44,257.04
X$6282 1519 880 1518 1164 1204 1168 767 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $6284 m0 *1 74.48,257.04
X$6284 1519 767 1518 1124 1161 1162 880 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $6287 r0 *1 151.76,226.8
X$6287 1519 1014 1518 983 1056 767 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6289 r0 *1 78.4,257.04
X$6289 1519 767 1164 1518 1189 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6291 m0 *1 80.64,246.96
X$6291 1518 767 1519 1116 907 880 1089 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $6293 r0 *1 85.68,236.88
X$6293 1518 767 1519 880 1090 1023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6295 m0 *1 104.72,236.88
X$6295 1518 880 1519 1008 1061 767 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6297 m0 *1 185.92,257.04
X$6297 1519 1518 1134 767 1120 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6299 m0 *1 73.92,226.8
X$6299 1518 767 1519 999 820 951 907 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $6301 r0 *1 119.28,226.8
X$6301 822 767 1010 1011 910 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6332 r0 *1 92.4,186.48
X$6332 1519 1518 803 821 792 768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6346 r0 *1 157.36,176.4
X$6346 1518 807 1519 800 769 770 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6352 r0 *1 194.88,196.56
X$6352 770 858 859 883 1519 1518 871 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6354 m0 *1 176.96,196.56
X$6354 1519 1518 770 860 858 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6369 r0 *1 318.08,176.4
X$6369 797 1518 1519 773 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6373 r0 *1 332.08,176.4
X$6373 773 798 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6380 m0 *1 278.88,176.4
X$6380 774 1518 1519 796 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6388 m0 *1 311.36,186.48
X$6388 776 1518 1519 813 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6394 m0 *1 318.64,176.4
X$6394 777 1518 1519 779 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6407 m0 *1 330.4,186.48
X$6407 781 812 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6409 m0 *1 322,186.48
X$6409 814 1518 1519 781 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6432 m0 *1 2.24,186.48
X$6432 788 1518 1519 829 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6447 m0 *1 55.44,206.64
X$6447 1519 791 1518 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $6469 r0 *1 78.4,216.72
X$6469 1518 952 792 1519 954 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6471 r0 *1 61.04,216.72
X$6471 1518 820 792 1519 997 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6473 m0 *1 61.04,236.88
X$6473 1519 1518 792 1069 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6475 m0 *1 57.12,226.8
X$6475 1519 1518 1005 1023 792 951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6480 r0 *1 81.2,186.48
X$6480 1519 1518 836 837 792 821 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6482 r0 *1 60.48,206.64
X$6482 1519 1518 926 951 792 837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6491 m0 *1 195.44,216.72
X$6491 1518 793 914 1519 862 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6494 r0 *1 180.88,176.4
X$6494 1519 1518 808 793 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6502 m0 *1 224.56,196.56
X$6502 1519 795 1518 870 871 862 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6516 m0 *1 201.6,196.56
X$6516 1519 1518 799 826 873 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6522 m0 *1 163.52,186.48
X$6522 1519 1518 824 833 800 843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6524 m0 *1 163.52,196.56
X$6524 1519 1518 842 841 800 893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6527 m0 *1 147.28,196.56
X$6527 1518 875 840 1519 800 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6540 r0 *1 101.92,277.2
X$6540 804 1518 1519 1268 1289 1290 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6542 m0 *1 98.56,216.72
X$6542 1519 1518 804 930 925 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6550 m0 *1 118.16,236.88
X$6550 1519 823 1518 1010 964 805 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6552 m0 *1 125.44,196.56
X$6552 805 881 892 872 1519 1518 840 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6554 m0 *1 104.16,267.12
X$6554 1519 1518 1129 1128 805 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $6556 m0 *1 113.12,236.88
X$6556 1518 1031 805 1519 1012 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6558 m0 *1 119.28,246.96
X$6558 1519 1518 1006 1101 805 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6560 m0 *1 87.36,257.04
X$6560 1518 1182 1181 805 1150 1125 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $6562 r0 *1 91.28,226.8
X$6562 1032 805 1086 1075 910 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6565 r0 *1 127.68,206.64
X$6565 1519 1518 805 932 912 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6567 r0 *1 102.48,196.56
X$6567 1519 1518 805 880 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $6569 r0 *1 119.28,186.48
X$6569 1519 1518 805 822 838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6573 m0 *1 110.88,257.04
X$6573 1090 805 1106 1214 1191 1518 1519 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $6577 r0 *1 85.68,216.72
X$6577 1518 952 805 1519 969 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6580 m0 *1 90.72,236.88
X$6580 1519 1518 1074 1070 805 1060 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6582 m0 *1 92.4,267.12
X$6582 1519 1518 1207 1226 805 1190 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6607 m0 *1 132.72,186.48
X$6607 1519 1518 822 806 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6615 r0 *1 216.16,196.56
X$6615 1518 808 914 1519 844 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6624 r0 *1 185.36,196.56
X$6624 809 1519 1518 859 858 854 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $6629 m0 *1 186.48,186.48
X$6629 1519 810 1518 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $6653 r0 *1 208.88,196.56
X$6653 1519 811 1518 889 861 844 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6671 m0 *1 10.64,186.48
X$6671 816 1518 1519 818 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6687 r0 *1 75.6,236.88
X$6687 1102 1518 1519 820 951 1023 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $6690 m0 *1 66.08,246.96
X$6690 951 1519 820 1088 1518 1168 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6692 m0 *1 77.84,236.88
X$6692 951 820 1023 907 1518 1519 1036 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6694 r0 *1 66.08,216.72
X$6694 952 1519 820 907 1518 982 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6722 m0 *1 85.68,226.8
X$6722 1518 1519 925 823 999 856 1032 1006 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $6725 m0 *1 132.72,196.56
X$6725 1519 1518 856 857 823 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6728 m0 *1 140.56,257.04
X$6728 1518 1131 1519 1162 1170 823 1171 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $6731 m0 *1 169.68,257.04
X$6731 1519 1518 1154 823 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6733 r0 *1 27.44,216.72
X$6733 1519 1518 823 994 993 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6735 r0 *1 30.8,196.56
X$6735 1518 823 904 1519 888 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6737 m0 *1 31.92,216.72
X$6737 823 1519 950 937 1518 967 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $6740 r0 *1 101.92,246.96
X$6740 1518 1131 1519 1127 1164 823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6762 r0 *1 204.96,216.72
X$6762 1519 1518 942 826 979 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6766 r0 *1 198.8,216.72
X$6766 1519 1518 956 826 933 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6771 m0 *1 232.96,196.56
X$6771 1519 1518 853 826 870 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6773 r0 *1 203.28,196.56
X$6773 1519 1518 890 826 889 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6776 r0 *1 232.4,196.56
X$6776 1519 1518 905 826 884 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6779 m0 *1 226.24,216.72
X$6779 1519 1518 1001 826 961 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6785 r0 *1 301.28,196.56
X$6785 827 1518 1519 849 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6794 r0 *1 330.4,186.48
X$6794 828 848 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6796 r0 *1 322,186.48
X$6796 845 1518 1519 828 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6820 m0 *1 3.92,196.56
X$6820 834 1518 1519 887 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6823 m0 *1 12.32,196.56
X$6823 1519 1518 877 835 878 894 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $6831 r0 *1 83.44,196.56
X$6831 1519 837 838 1518 907 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6860 m0 *1 176.96,206.64
X$6860 1519 1518 843 858 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6864 r0 *1 190.4,216.72
X$6864 843 1518 1519 1110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6876 m0 *1 204.96,206.64
X$6876 859 883 860 844 1519 1518 906 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $6886 m0 *1 322,196.56
X$6886 867 1518 1519 846 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $6891 m0 *1 330.4,196.56
X$6891 846 847 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $6900 m0 *1 24.64,196.56
X$6900 1519 1518 895 850 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6915 r0 *1 183.12,186.48
X$6915 1519 1518 854 883 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6917 m0 *1 193.76,196.56
X$6917 859 1518 854 860 1519 861 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $6923 m0 *1 103.6,216.72
X$6923 1518 955 1027 953 855 931 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $6927 m0 *1 150.08,226.8
X$6927 1518 901 1519 1002 1014 856 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6930 r0 *1 138.32,226.8
X$6930 1519 1035 856 1518 1011 1055 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6932 m0 *1 168.56,236.88
X$6932 1519 1058 856 1518 1064 984 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $6944 r0 *1 120.96,196.56
X$6944 1519 1518 910 881 857 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $6948 m0 *1 133.84,206.64
X$6948 1519 881 1518 914 932 857 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $6950 r0 *1 126.56,196.56
X$6950 1519 881 857 1518 901 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6968 m0 *1 180.32,206.64
X$6968 1519 1518 893 859 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $6987 m0 *1 193.2,206.64
X$6987 1519 915 1518 933 861 862 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7002 r0 *1 272.16,196.56
X$7002 863 1518 1519 864 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7008 r0 *1 322,196.56
X$7008 865 903 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7010 r0 *1 313.6,196.56
X$7010 885 1518 1519 865 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7018 r0 *1 331.52,196.56
X$7018 866 1518 1519 886 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7055 r0 *1 141.68,287.28
X$7055 1519 1518 875 1335 1301 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7058 m0 *1 132.72,257.04
X$7058 1519 1185 1165 1518 875 1130 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7072 m0 *1 4.48,206.64
X$7072 876 1518 1519 904 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7080 r0 *1 14,216.72
X$7080 1519 1518 949 934 878 935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7082 r0 *1 42,216.72
X$7082 1519 1518 996 967 878 981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7084 r0 *1 35.84,196.56
X$7084 1519 1518 896 888 878 898 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7090 m0 *1 44.8,206.64
X$7090 908 1519 909 896 1518 879 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7092 m0 *1 77.84,287.28
X$7092 1518 880 1189 1519 1267 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7094 m0 *1 118.16,277.2
X$7094 880 1518 1255 1234 1519 1191 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7101 r0 *1 151.76,246.96
X$7101 1062 1519 1518 1151 880 971 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7105 m0 *1 75.6,246.96
X$7105 1519 1518 880 1146 907 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $7108 m0 *1 157.92,226.8
X$7108 1002 1519 1518 913 880 1523 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7112 m0 *1 142.24,206.64
X$7112 1519 880 912 1518 882 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7115 r0 *1 87.92,246.96
X$7115 1103 1519 880 901 1518 1125 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7118 m0 *1 67.2,267.12
X$7118 1519 1204 1518 1224 1213 880 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7121 m0 *1 157.92,246.96
X$7121 1519 1518 1091 1076 880 925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7123 r0 *1 68.32,236.88
X$7123 1518 880 1059 1519 1088 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7125 r0 *1 76.72,277.2
X$7125 880 1518 1189 1288 1519 1232 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7164 m0 *1 151.76,216.72
X$7164 1518 1519 882 971 983 1037 970 948 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $7174 r0 *1 226.8,196.56
X$7174 1519 1518 884 902 906 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $7194 r0 *1 97.44,196.56
X$7194 1519 1518 899 891 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $7211 r0 *1 196.56,206.64
X$7211 893 1518 1519 946 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7217 r0 *1 28.56,206.64
X$7217 898 1519 894 935 1518 937 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7219 m0 *1 15.12,206.64
X$7219 1519 1518 894 922 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7227 m0 *1 19.6,206.64
X$7227 923 1519 1518 936 922 895 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7233 r0 *1 105.28,206.64
X$7233 1518 899 1519 955 897 953 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7235 r0 *1 32.48,216.72
X$7235 1518 994 995 897 966 996 1519 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $7240 r0 *1 36.4,206.64
X$7240 1519 1518 898 938 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7246 r0 *1 50.4,206.64
X$7246 950 1519 898 939 1518 925 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7261 m0 *1 122.64,257.04
X$7261 1519 1518 1031 900 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7266 m0 *1 85.12,267.12
X$7266 1519 1103 1518 1226 901 1031 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7268 m0 *1 101.92,246.96
X$7268 901 1518 1034 1116 1519 1105 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7271 r0 *1 112.56,246.96
X$7271 901 1518 1090 1108 1519 1106 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7277 r0 *1 83.44,226.8
X$7277 1518 901 1519 1032 1070 1031 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7279 m0 *1 133.84,226.8
X$7279 1518 901 1519 970 1003 1012 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7321 m0 *1 67.2,236.88
X$7321 1519 1023 907 1518 1059 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7348 r0 *1 124.88,236.88
X$7348 1518 1007 911 1519 1077 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7356 r0 *1 118.16,267.12
X$7356 1518 1233 1519 1227 913 1209 1103 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7358 r0 *1 136.64,267.12
X$7358 1218 1519 1518 913 1217 1526 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7361 m0 *1 143.92,267.12
X$7361 1519 1518 913 1151 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7365 r0 *1 154,267.12
X$7365 913 1519 1219 1238 1518 1153 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7404 r0 *1 286.16,206.64
X$7404 918 1518 1519 944 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7413 r0 *1 322.56,206.64
X$7413 919 1518 1519 1051 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7416 m0 *1 332.08,206.64
X$7416 921 1518 1519 920 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7419 r0 *1 331.52,206.64
X$7419 920 990 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7432 r0 *1 47.04,206.64
X$7432 1519 1518 923 939 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7437 r0 *1 50.4,216.72
X$7437 981 1518 938 923 1519 964 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7443 r0 *1 330.4,216.72
X$7443 989 1518 1519 924 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7446 m0 *1 332.08,216.72
X$7446 924 991 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7457 r0 *1 165.2,277.2
X$7457 1519 1292 1192 1518 1275 925 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $7507 r0 *1 24.08,206.64
X$7507 1519 1518 935 936 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7552 m0 *1 60.48,216.72
X$7552 1519 1518 940 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $7571 m0 *1 175.84,236.88
X$7571 1519 1518 1073 1064 941 1072 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7573 r0 *1 174.16,226.8
X$7573 1519 1518 1029 1058 941 1015 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7599 r0 *1 148.96,216.72
X$7599 1519 980 1518 947 1003 971 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $7610 m0 *1 50.4,226.8
X$7610 1519 1518 950 981 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7634 r0 *1 72.8,216.72
X$7634 1519 952 997 1518 960 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7645 m0 *1 98,226.8
X$7645 1519 953 1007 1518 1026 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7654 m0 *1 21.28,226.8
X$7654 1519 1004 954 1518 992 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7671 r0 *1 287.28,216.72
X$7671 957 1518 1519 974 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7677 r0 *1 322,216.72
X$7677 958 1518 1519 1022 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7684 m0 *1 330.4,226.8
X$7684 959 1021 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7686 m0 *1 320.88,226.8
X$7686 1024 1518 1519 959 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7708 r0 *1 148.96,257.04
X$7708 1519 1518 1186 964 1171 971 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7714 r0 *1 4.48,216.72
X$7714 965 1518 1519 993 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7728 r0 *1 104.16,216.72
X$7728 1519 968 1518 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7759 r0 *1 156.8,236.88
X$7759 1519 1518 971 1063 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7772 r0 *1 269.92,216.72
X$7772 972 1518 1519 973 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7784 r0 *1 309.68,216.72
X$7784 975 1518 1519 988 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7787 r0 *1 332.08,226.8
X$7787 1049 1518 1519 976 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7790 r0 *1 322.56,226.8
X$7790 976 1052 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7828 r0 *1 192.08,226.8
X$7828 985 1519 1518 1015 1038 1524 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7830 m0 *1 289.52,246.96
X$7830 986 1094 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7832 m0 *1 281.12,246.96
X$7832 1113 1518 1519 986 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7837 m0 *1 309.68,226.8
X$7837 1020 1518 1519 987 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7839 m0 *1 312.48,236.88
X$7839 987 1047 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7875 m0 *1 322,236.88
X$7875 1067 1518 1519 998 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7879 m0 *1 330.4,236.88
X$7879 998 1048 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $7900 r0 *1 12.88,226.8
X$7900 1004 1518 1519 1030 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7914 m0 *1 12.88,257.04
X$7914 1167 1518 1519 1006 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7938 m0 *1 111.44,246.96
X$7938 1034 1518 1090 1009 1519 1107 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $7968 r0 *1 178.08,257.04
X$7968 1154 1519 1518 1015 1072 1528 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $7971 r0 *1 189.84,236.88
X$7971 1519 1518 1015 1080 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $7976 m0 *1 192.08,267.12
X$7976 1015 1518 1519 1231 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7986 r0 *1 276.08,226.8
X$7986 1016 1518 1519 1045 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $7992 r0 *1 290.08,236.88
X$7992 1017 1518 1519 1093 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8001 r0 *1 306.32,226.8
X$8001 1019 1518 1519 1046 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8017 m0 *1 56,236.88
X$8017 1518 1023 1069 1519 1068 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8037 r0 *1 93.52,236.88
X$8037 1519 1074 1518 1126 1075 1026 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8041 r0 *1 90.72,257.04
X$8041 1518 1181 1519 1207 1205 1026 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8058 m0 *1 265.44,236.88
X$8058 1028 1518 1519 1050 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8069 m0 *1 117.04,337.68
X$8069 1488 1518 1519 1031 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8094 r0 *1 101.92,236.88
X$8094 1519 1060 1518 1086 1061 1034 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8104 m0 *1 152.88,236.88
X$8104 1519 1518 1056 1062 1036 1063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8110 m0 *1 160.16,257.04
X$8110 1518 1152 1153 1519 1037 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8114 m0 *1 197.12,236.88
X$8114 1519 1518 1072 1038 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8116 m0 *1 187.6,236.88
X$8116 1057 1519 1518 1080 1038 1064 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8121 r0 *1 234.64,236.88
X$8121 1039 1518 1519 1085 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8127 r0 *1 313.04,236.88
X$8127 1040 1097 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8129 r0 *1 304.64,236.88
X$8129 1095 1518 1519 1040 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8133 m0 *1 330.4,246.96
X$8133 1041 1098 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8135 r0 *1 319.2,246.96
X$8135 1143 1518 1519 1041 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8141 m0 *1 311.36,246.96
X$8141 1042 1242 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8143 m0 *1 304.64,257.04
X$8143 1157 1518 1519 1042 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8148 m0 *1 300.16,246.96
X$8148 1043 1096 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8151 r0 *1 290.64,246.96
X$8151 1145 1518 1519 1043 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8154 r0 *1 330.4,236.88
X$8154 1044 1099 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8156 m0 *1 322,246.96
X$8156 1083 1518 1519 1044 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8213 r0 *1 112.56,267.12
X$8213 1518 1227 1235 1519 1060 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8235 r0 *1 224,236.88
X$8235 1065 1518 1519 1082 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8238 r0 *1 276.64,236.88
X$8238 1066 1518 1519 1140 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8262 r0 *1 193.2,236.88
X$8262 1087 1519 1518 1080 1072 1525 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8270 r0 *1 189.84,267.12
X$8270 1072 1518 1519 1257 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8286 r0 *1 107.52,257.04
X$8286 1519 1518 1076 1127 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8291 m0 *1 157.36,267.12
X$8291 1519 1193 1518 1171 1076 1211 1230 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8308 r0 *1 118.72,246.96
X$8308 1519 1518 1079 1215 1108 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8326 r0 *1 13.44,236.88
X$8326 1084 1518 1519 1122 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8345 r0 *1 82.32,246.96
X$8345 1518 1103 1102 1519 1089 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8356 m0 *1 322,327.6
X$8356 1445 1518 1519 1092 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8360 m0 *1 330.4,337.68
X$8360 1092 1482 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8387 r0 *1 76.16,246.96
X$8387 1519 1518 1102 1124 1146 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8394 m0 *1 124.32,277.2
X$8394 1519 1518 1103 1217 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8410 r0 *1 95.76,246.96
X$8410 1519 1518 1105 1150 1104 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8412 m0 *1 100.8,257.04
X$8412 1519 1190 1518 1182 1127 1105 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8422 m0 *1 126,257.04
X$8422 1519 1107 1169 1518 1165 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8433 r0 *1 138.32,246.96
X$8433 1519 1121 1148 1518 1109 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8440 r0 *1 256.48,257.04
X$8440 1111 1518 1519 1175 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8445 r0 *1 278.32,246.96
X$8445 1112 1518 1519 1147 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8452 r0 *1 330.4,337.68
X$8452 1114 1483 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8454 r0 *1 327.6,246.96
X$8454 1144 1518 1519 1114 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8460 m0 *1 313.6,257.04
X$8460 1159 1518 1519 1115 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8462 r0 *1 306.88,246.96
X$8462 1115 1142 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8493 m0 *1 66.64,257.04
X$8493 1519 1518 1180 1161 1123 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8495 r0 *1 57.68,246.96
X$8495 1149 1519 1128 1518 1123 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $8507 m0 *1 57.68,277.2
X$8507 1253 1518 1519 1149 1188 1128 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $8510 r0 *1 82.32,297.36
X$8510 1311 1312 1128 1289 1518 1519 1354 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8514 r0 *1 69.44,297.36
X$8514 1519 1518 1353 1128 1289 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8517 r0 *1 120.96,277.2
X$8517 1233 1209 1291 1269 1518 1519 1128 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8520 r0 *1 90.16,297.36
X$8520 1128 1519 1289 1268 1518 1359 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $8529 m0 *1 95.76,287.28
X$8529 1519 1129 1268 1289 1297 1298 1518 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $8531 m0 *1 132.72,287.28
X$8531 1519 1518 1252 1269 1129 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8546 r0 *1 145.6,277.2
X$8546 1519 1518 1132 1301 1271 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8550 r0 *1 164.64,267.12
X$8550 1133 1518 1172 1252 1519 1230 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $8552 m0 *1 166.32,257.04
X$8552 1519 1518 1133 1166 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8555 r0 *1 191.52,277.2
X$8555 1133 1518 1519 1401 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8557 m0 *1 178.64,277.2
X$8557 1519 1518 1251 1256 1133 1293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8560 m0 *1 155.68,277.2
X$8560 1519 1193 1172 1236 1133 1518 1252 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $8562 r0 *1 150.64,277.2
X$8562 1519 1219 1133 1518 1172 1252 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8574 r0 *1 212.8,257.04
X$8574 1135 1518 1519 1173 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8583 r0 *1 223.44,246.96
X$8583 1137 1518 1519 1141 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8587 m0 *1 322,267.12
X$8587 1203 1518 1519 1139 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8590 m0 *1 330.4,267.12
X$8590 1139 1202 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8621 m0 *1 59.36,297.36
X$8621 1188 1149 1295 1266 1518 1519 1289 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8625 r0 *1 59.36,287.28
X$8625 1188 1149 1266 1234 1518 1519 1296 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8629 m0 *1 65.52,277.2
X$8629 1519 1518 1225 1149 1234 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8635 m0 *1 130.48,267.12
X$8635 1192 1519 1518 1151 1217 1190 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $8638 r0 *1 128.8,267.12
X$8638 1519 1235 1151 1518 1217 1216 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $8646 r0 *1 157.36,257.04
X$8646 1519 1170 1186 1518 1152 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $8662 r0 *1 271.04,257.04
X$8662 1155 1518 1519 1179 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8665 m0 *1 322,257.04
X$8665 1178 1518 1519 1156 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8670 m0 *1 330.4,257.04
X$8670 1156 1158 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8680 r0 *1 330.4,257.04
X$8680 1160 1201 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8682 r0 *1 322,257.04
X$8682 1200 1518 1519 1160 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8698 m0 *1 262.08,297.36
X$8698 1519 1163 1337 1518 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $8721 m0 *1 120.4,267.12
X$8721 1518 1209 1192 1519 1169 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8723 m0 *1 143.36,277.2
X$8723 1519 1219 1518 1170 1237 1272 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $8733 m0 *1 165.76,277.2
X$8733 1518 1172 1251 1519 1171 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8746 m0 *1 155.12,307.44
X$8746 1518 1360 1361 1519 1172 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8760 r0 *1 241.92,257.04
X$8760 1174 1518 1519 1183 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8770 r0 *1 291.2,257.04
X$8770 1177 1518 1519 1197 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8792 r0 *1 326.48,327.6
X$8792 1184 1463 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8794 m0 *1 318.64,277.2
X$8794 1247 1518 1519 1184 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8810 r0 *1 62.72,267.12
X$8810 1518 1188 1225 1519 1213 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $8831 r0 *1 140.56,277.2
X$8831 1518 1192 1216 1519 1272 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8833 r0 *1 128.8,277.2
X$8833 1519 1518 1192 1291 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $8835 r0 *1 135.52,277.2
X$8835 1519 1518 1192 1236 1216 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $8848 r0 *1 221.2,267.12
X$8848 1194 1518 1519 1198 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8850 m0 *1 212.24,267.12
X$8850 1519 1518 1212 1206 1210 1194 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8857 m0 *1 249.2,267.12
X$8857 1220 1518 1519 1195 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8863 r0 *1 289.52,267.12
X$8863 1196 1518 1519 1240 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8873 r0 *1 313.6,267.12
X$8873 1199 1518 1519 1284 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8893 r0 *1 322,267.12
X$8893 1243 1518 1519 1206 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $8896 r0 *1 330.4,267.12
X$8896 1206 1246 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $8909 m0 *1 127.68,277.2
X$8909 1519 1518 1216 1233 1209 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $8918 m0 *1 188.72,297.36
X$8918 1519 1518 1356 1346 1210 1347 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8922 r0 *1 308,287.28
X$8922 1519 1518 1322 1330 1210 1324 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8925 r0 *1 157.92,277.2
X$8925 1252 1238 1210 1292 1519 1518 1273 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8930 r0 *1 190.4,307.44
X$8930 1519 1518 1395 1400 1210 1376 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8932 m0 *1 150.08,327.6
X$8932 1519 1518 1446 1447 1210 1416 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8934 r0 *1 301.28,307.44
X$8934 1519 1518 1394 1405 1210 1386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8936 r0 *1 238,307.44
X$8936 1519 1518 1397 1402 1210 1379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8938 m0 *1 252,317.52
X$8938 1519 1518 1433 1421 1210 1440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8940 m0 *1 263.2,307.44
X$8940 1519 1518 1318 1320 1210 1383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8942 m0 *1 268.8,327.6
X$8942 1519 1518 1432 1441 1210 1442 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8944 m0 *1 271.6,307.44
X$8944 1519 1518 1366 1384 1210 1385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8946 r0 *1 246.4,287.28
X$8946 1519 1518 1315 1316 1210 1317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8949 m0 *1 254.8,307.44
X$8949 1519 1518 1380 1381 1210 1382 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8952 m0 *1 211.12,297.36
X$8952 1519 1518 1313 1348 1210 1336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8954 r0 *1 229.6,287.28
X$8954 1519 1518 1332 1314 1210 1302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8959 m0 *1 209.44,277.2
X$8959 1519 1518 1258 1259 1210 1260 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8961 r0 *1 318.08,327.6
X$8961 1519 1518 1466 1424 1210 1461 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8964 m0 *1 296.24,317.52
X$8964 1519 1518 1431 1422 1210 1423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8966 r0 *1 286.16,327.6
X$8966 1519 1518 1458 1457 1210 1459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8969 r0 *1 189.28,327.6
X$8969 1519 1518 1453 1454 1210 1455 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8971 r0 *1 162.4,317.52
X$8971 1519 1518 1427 1436 1210 1398 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8974 m0 *1 148.96,337.68
X$8974 1519 1518 1464 1476 1210 1477 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8976 m0 *1 176.4,317.52
X$8976 1519 1518 1414 1417 1210 1399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8978 m0 *1 206.64,327.6
X$8978 1519 1518 1419 1439 1210 1438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8980 m0 *1 218.96,307.44
X$8980 1519 1518 1362 1377 1210 1378 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8983 r0 *1 290.08,297.36
X$8983 1519 1518 1349 1367 1210 1350 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9011 m0 *1 148.4,267.12
X$9011 1518 1218 1216 1519 1211 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9022 m0 *1 113.12,307.44
X$9022 1518 1215 1373 1519 1345 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9029 r0 *1 146.72,267.12
X$9029 1519 1518 1218 1237 1216 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9067 m0 *1 273.28,277.2
X$9067 1221 1518 1519 1264 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9073 r0 *1 311.36,277.2
X$9073 1222 1518 1519 1338 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9076 r0 *1 320.32,307.44
X$9076 1223 1444 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9078 m0 *1 313.6,307.44
X$9078 1387 1518 1519 1223 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9134 r0 *1 74.48,287.28
X$9134 1519 1289 1234 1518 1310 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9138 r0 *1 114.8,277.2
X$9138 1519 1269 1235 1518 1234 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9146 m0 *1 124.88,287.28
X$9146 1518 1299 1519 1235 1255 1300 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9153 m0 *1 150.64,277.2
X$9153 1519 1518 1236 1238 1237 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9156 m0 *1 110.32,287.28
X$9156 1298 1297 1236 1269 1518 1519 1290 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9172 r0 *1 260.96,277.2
X$9172 1239 1518 1519 1304 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9178 r0 *1 316.4,287.28
X$9178 1241 1326 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9180 m0 *1 305.76,287.28
X$9180 1323 1518 1519 1241 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9189 m0 *1 330.4,277.2
X$9189 1244 1245 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9192 m0 *1 322,287.28
X$9192 1325 1518 1519 1244 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9208 m0 *1 285.04,277.2
X$9208 1263 1518 1519 1249 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9213 r0 *1 301.84,277.2
X$9213 1249 1283 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9226 m0 *1 140,287.28
X$9226 1519 1518 1270 1300 1252 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9243 r0 *1 58.8,277.2
X$9243 1266 1519 1253 1518 1286 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9246 r0 *1 83.44,277.2
X$9246 1518 1254 1287 1519 1288 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9249 r0 *1 82.88,287.28
X$9249 1311 1312 1254 1333 1518 1519 1268 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9258 r0 *1 177.52,277.2
X$9258 1518 1274 1275 1519 1256 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9268 m0 *1 205.52,337.68
X$9268 1479 1518 1519 1259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9270 m0 *1 213.92,337.68
X$9270 1259 1516 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9273 r0 *1 224,277.2
X$9273 1260 1518 1519 1294 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9291 m0 *1 332.08,287.28
X$9291 1265 1329 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9294 r0 *1 328.16,287.28
X$9294 1327 1518 1519 1265 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9306 m0 *1 71.12,287.28
X$9306 1518 1267 1307 1519 1305 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9308 m0 *1 87.92,317.52
X$9308 1518 1267 1411 1519 1412 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9310 r0 *1 86.24,307.44
X$9310 1518 1267 1393 1519 1392 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9313 r0 *1 59.36,307.44
X$9313 1518 1267 1372 1519 1391 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9318 r0 *1 68.32,277.2
X$9318 1518 1267 1286 1519 1285 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9320 m0 *1 78.96,317.52
X$9320 1518 1267 1374 1519 1410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9330 m0 *1 101.36,297.36
X$9330 1334 1518 1519 1297 1298 1268 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $9333 m0 *1 90.16,297.36
X$9333 1297 1519 1268 1310 1518 1342 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $9344 r0 *1 131.04,287.28
X$9344 1519 1299 1300 1518 1269 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9352 m0 *1 145.6,287.28
X$9352 1519 1518 1271 1270 1272 1300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9366 r0 *1 190.96,287.28
X$9366 1274 1518 1519 1430 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9372 m0 *1 182.56,287.28
X$9372 1309 1518 1519 1275 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9378 r0 *1 240.24,327.6
X$9378 1472 1518 1519 1276 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9380 r0 *1 246.4,337.68
X$9380 1276 1510 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9385 r0 *1 278.32,277.2
X$9385 1277 1518 1519 1340 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9394 r0 *1 280,297.36
X$9394 1341 1518 1519 1279 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9396 r0 *1 285.6,287.28
X$9396 1279 1321 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9398 r0 *1 323.12,277.2
X$9398 1280 1518 1519 1281 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9401 r0 *1 332.08,277.2
X$9401 1281 1282 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9423 m0 *1 82.32,297.36
X$9423 1311 1312 1333 1310 1518 1519 1287 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9460 m0 *1 192.08,287.28
X$9460 1308 1518 1519 1293 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9470 m0 *1 60.48,287.28
X$9470 1518 1295 1296 1519 1307 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9481 r0 *1 91.28,307.44
X$9481 1518 1297 1359 1519 1411 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9495 m0 *1 84.56,307.44
X$9495 1518 1298 1342 1519 1393 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9526 r0 *1 238,287.28
X$9526 1302 1518 1519 1331 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9529 m0 *1 293.44,287.28
X$9529 1303 1518 1519 1306 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9561 r0 *1 76.16,297.36
X$9561 1519 1311 1310 1518 1358 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9567 r0 *1 59.92,297.36
X$9567 1311 1519 1353 1518 1372 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $9579 m0 *1 73.36,307.44
X$9579 1518 1312 1358 1519 1374 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $9589 r0 *1 232.4,297.36
X$9589 1363 1518 1519 1314 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9592 r0 *1 240.8,297.36
X$9592 1314 1364 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9599 m0 *1 242.48,337.68
X$9599 1498 1518 1519 1316 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9601 m0 *1 252,337.68
X$9601 1316 1494 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9607 r0 *1 251.44,297.36
X$9607 1317 1518 1519 1365 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9616 r0 *1 257.04,287.28
X$9616 1319 1518 1519 1320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9621 r0 *1 269.92,287.28
X$9621 1320 1339 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9632 m0 *1 317.52,297.36
X$9632 1324 1518 1519 1352 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9644 m0 *1 328.16,297.36
X$9644 1328 1388 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9649 r0 *1 330.4,297.36
X$9649 1330 1369 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9651 r0 *1 322,297.36
X$9651 1351 1518 1519 1330 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9670 r0 *1 103.6,297.36
X$9670 1519 1518 1373 1333 1354 1344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9672 m0 *1 109.2,297.36
X$9672 1519 1518 1344 1333 1334 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $9685 m0 *1 219.52,297.36
X$9685 1336 1518 1519 1343 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9718 r0 *1 202.72,337.68
X$9718 1507 1518 1519 1346 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9721 r0 *1 212.8,337.68
X$9721 1346 1508 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9730 r0 *1 201.6,297.36
X$9730 1347 1518 1519 1357 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9733 r0 *1 222.32,327.6
X$9733 1456 1518 1519 1348 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9735 r0 *1 230.72,327.6
X$9735 1348 1517 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9747 r0 *1 310.24,297.36
X$9747 1350 1518 1519 1371 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9778 m0 *1 160.16,307.44
X$9778 1360 1518 1519 1415 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9784 m0 *1 151.76,307.44
X$9784 1519 1518 1375 1361 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $9803 m0 *1 322,307.44
X$9803 1370 1518 1519 1367 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9806 m0 *1 330.4,307.44
X$9806 1367 1390 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9811 m0 *1 280,307.44
X$9811 1383 1518 1519 1368 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9834 r0 *1 152.32,307.44
X$9834 1375 1518 1519 1413 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9840 r0 *1 199.36,307.44
X$9840 1376 1518 1519 1396 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9844 m0 *1 220.64,317.52
X$9844 1420 1518 1519 1377 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9848 r0 *1 224.56,317.52
X$9848 1377 1434 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9855 m0 *1 229.04,317.52
X$9855 1378 1518 1519 1435 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9859 m0 *1 243.6,317.52
X$9859 1379 1518 1519 1497 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9864 r0 *1 260.96,337.68
X$9864 1381 1511 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9866 m0 *1 261.52,337.68
X$9866 1496 1518 1519 1381 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9874 m0 *1 260.96,317.52
X$9874 1382 1518 1519 1449 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9884 r0 *1 290.64,307.44
X$9884 1384 1404 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9888 m0 *1 282.24,317.52
X$9888 1403 1518 1519 1384 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9893 r0 *1 281.68,307.44
X$9893 1385 1518 1519 1389 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9898 r0 *1 309.68,307.44
X$9898 1386 1518 1519 1407 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9903 r0 *1 330.96,307.44
X$9903 1388 1518 1519 1406 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9939 r0 *1 171.36,317.52
X$9939 1398 1518 1519 1418 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9945 m0 *1 185.36,317.52
X$9945 1399 1518 1519 1428 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9950 r0 *1 215.04,317.52
X$9950 1400 1451 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9953 r0 *1 189.84,317.52
X$9953 1429 1518 1519 1400 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9960 m0 *1 236.32,327.6
X$9960 1473 1518 1519 1402 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9963 r0 *1 234.64,317.52
X$9963 1402 1471 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $9973 m0 *1 314.16,317.52
X$9973 1409 1518 1519 1405 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $9975 m0 *1 330.4,317.52
X$9975 1405 1408 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10016 m0 *1 159.04,337.68
X$10016 1416 1518 1519 1452 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10018 m0 *1 170.24,327.6
X$10018 1448 1518 1519 1417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10022 r0 *1 174.72,327.6
X$10022 1417 1465 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10034 r0 *1 260.4,327.6
X$10034 1421 1469 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10036 r0 *1 252,327.6
X$10036 1470 1518 1519 1421 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10043 r0 *1 330.4,317.52
X$10043 1422 1426 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10046 m0 *1 318.08,337.68
X$10046 1481 1518 1519 1422 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10053 r0 *1 305.76,317.52
X$10053 1423 1518 1519 1462 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10057 r0 *1 322,317.52
X$10057 1425 1518 1519 1424 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10060 m0 *1 330.4,327.6
X$10060 1424 1443 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10103 m0 *1 169.68,337.68
X$10103 1478 1518 1519 1436 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10106 m0 *1 179.2,337.68
X$10106 1436 1491 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10111 r0 *1 142.8,337.68
X$10111 1476 1437 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10115 r0 *1 213.92,327.6
X$10115 1438 1518 1519 1467 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10120 r0 *1 224,337.68
X$10120 1439 1505 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10122 m0 *1 223.44,337.68
X$10122 1501 1518 1519 1439 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10128 m0 *1 258.16,327.6
X$10128 1440 1518 1519 1450 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10131 r0 *1 271.04,337.68
X$10131 1512 1518 1519 1441 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10134 m0 *1 274.4,337.68
X$10134 1441 1493 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10141 r0 *1 277.2,327.6
X$10141 1442 1518 1519 1468 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10157 r0 *1 168.56,337.68
X$10157 1515 1518 1519 1447 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10159 r0 *1 176.96,337.68
X$10159 1447 1504 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10181 r0 *1 190.96,337.68
X$10181 1454 1506 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10184 m0 *1 190.96,337.68
X$10184 1490 1518 1519 1454 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10190 r0 *1 198.24,327.6
X$10190 1455 1518 1519 1495 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10195 r0 *1 290.64,337.68
X$10195 1457 1514 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10198 r0 *1 282.24,337.68
X$10198 1513 1518 1519 1457 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10205 m0 *1 290.64,337.68
X$10205 1459 1518 1519 1492 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10209 m0 *1 309.68,337.68
X$10209 1480 1518 1519 1460 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10211 r0 *1 322,337.68
X$10211 1461 1518 1519 1484 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10255 r0 *1 7.84,337.68
X$10255 1502 1474 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10257 m0 *1 14,337.68
X$10257 1474 1518 1519 1485 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10259 r0 *1 17.36,337.68
X$10259 1503 1475 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $10261 m0 *1 24.64,337.68
X$10261 1475 1518 1519 1486 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10263 m0 *1 140.56,337.68
X$10263 1487 1518 1519 1476 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $10272 r0 *1 160.16,337.68
X$10272 1477 1518 1519 1489 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $19891 m0 *1 232.96,337.68
X$19891 1500 1499 1518 1519 gf180mcu_fd_sc_mcu9t5v0__dlya_4
* cell instance $19893 r0 *1 233.52,337.68
X$19893 1499 1518 1519 1509 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
.ENDS ddr_controller

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_8 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.3 nmos_5p0
M$9 4 3 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.6498P AD=1.6498P PS=11.09U PD=11.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_8

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A4
* pin NWELL,VDD
* pin A3
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A4
* net 4 NWELL,VDD
* net 5 A3
* net 6 A1
* net 7 A2
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 13 5 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.045,3.78 pmos_5p0
M$2 4 3 13 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.165,3.78 pmos_5p0
M$3 12 3 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.465,3.78 pmos_5p0
M$4 11 5 12 4 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.77775P PS=2.63U PD=2.68U
* device instance $5 r0 *1 5.815,3.78 pmos_5p0
M$5 10 7 11 4 pmos_5p0 L=0.5U W=1.83U AS=0.77775P AD=0.52155P PS=2.68U PD=2.4U
* device instance $6 r0 *1 6.885,3.78 pmos_5p0
M$6 2 6 10 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 8.055,3.78 pmos_5p0
M$7 9 6 2 4 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $8 r0 *1 9.075,3.78 pmos_5p0
M$8 8 7 9 4 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 4.465,0.695 nmos_5p0
M$9 1 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.52165P AD=0.40285P PS=3.565U PD=2.545U
* device instance $11 r0 *1 2.045,0.7 nmos_5p0
M$11 1 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.3432P PS=2.545U PD=2.36U
* device instance $13 r0 *1 5.765,0.7 nmos_5p0
M$13 2 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.462P PS=2.545U PD=3.38U
* device instance $14 r0 *1 6.885,0.7 nmos_5p0
M$14 1 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=2.36U PD=2.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__tieh
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tieh 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 Z
* device instance $1 r0 *1 0.875,3.315 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.925,1.335 nmos_5p0
M$2 3 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tieh

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__or2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 2 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 6 3 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 7 3 6 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 4 2 7 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.7869P PS=2.4U PD=2.69U
* device instance $5 r0 *1 5.59,3.78 pmos_5p0
M$5 5 6 4 4 pmos_5p0 L=0.5U W=7.32U AS=2.3973P AD=2.4156P PS=9.94U PD=11.79U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 6 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7788P PS=5.36U PD=3.82U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 1 3 6 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.54,1.005 nmos_5p0
M$13 5 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4652P AD=1.6104P PS=7.5U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__and4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A1
* pin A2
* pin Z
* pin A4
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_4 1 2 3 5 6 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 A1
* net 5 A2
* net 6 Z
* net 13 A4
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.885,3.505 pmos_5p0
M$1 4 13 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.8908P PS=5.24U PD=4.33U
* device instance $2 r0 *1 1.905,3.505 pmos_5p0
M$2 14 2 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.925,3.505 pmos_5p0
M$3 4 5 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.945,3.505 pmos_5p0
M$4 14 3 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 9.225,3.78 pmos_5p0
M$9 6 4 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9854P AD=2.2326P PS=9.58U PD=11.59U
* device instance $13 r0 *1 0.935,1.005 nmos_5p0
M$13 7 13 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.855,1.005 nmos_5p0
M$14 8 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $15 r0 *1 2.875,1.005 nmos_5p0
M$15 10 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $16 r0 *1 3.895,1.005 nmos_5p0
M$16 4 3 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.015,1.005 nmos_5p0
M$17 9 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.935,1.005 nmos_5p0
M$18 12 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $19 r0 *1 6.955,1.005 nmos_5p0
M$19 11 2 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $20 r0 *1 7.975,1.005 nmos_5p0
M$20 1 13 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 9.095,1.005 nmos_5p0
M$21 6 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_12 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=8.76U AS=2.409P AD=2.409P PS=16.09U PD=16.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_12

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 12 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 11 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 10 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 10 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 9 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 9 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_4 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.46135P AD=2.31495P PS=11.84U PD=9.85U
* device instance $5 r0 *1 5.505,3.78 pmos_5p0
M$5 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $6 r0 *1 6.785,3.78 pmos_5p0
M$6 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $7 r0 *1 7.805,3.78 pmos_5p0
M$7 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $8 r0 *1 8.545,3.78 pmos_5p0
M$8 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $9 r0 *1 9.565,3.78 pmos_5p0
M$9 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 0.975,1.005 nmos_5p0
M$10 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 5.455,1.005 nmos_5p0
M$14 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $15 r0 *1 6.295,1.005 nmos_5p0
M$15 6 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $16 r0 *1 7.415,1.005 nmos_5p0
M$16 10 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $17 r0 *1 8.495,1.005 nmos_5p0
M$17 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $18 r0 *1 9.615,1.005 nmos_5p0
M$18 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 11 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 9 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 10 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__or4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 4 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 6 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 7 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 12 7 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 13 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 14 5 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.77775P PS=2.45U PD=2.68U
* device instance $9 r0 *1 10.11,3.78 pmos_5p0
M$9 3 2 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.4156P PS=9.93U PD=11.79U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.5879P PS=3.77U PD=3.33U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $15 r0 *1 3.16,0.74 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $16 r0 *1 4.28,0.74 nmos_5p0
M$16 1 7 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $21 r0 *1 10.06,1.005 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4121P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 10 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 10 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 9 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 9 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_8 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.9832P PS=16.4U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_8

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__mux4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin S1
* pin I0
* pin I2
* pin S0
* pin I3
* pin I1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux4_2 1 6 7 11 12 13 14 16 18
* net 1 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* net 7 S1
* net 11 I0
* net 12 I2
* net 13 S0
* net 14 I3
* net 16 I1
* net 18 NWELL,VDD
* device instance $1 r0 *1 0.97,3.62 pmos_5p0
M$1 3 12 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.6848P AD=0.5504P PS=3.63U PD=2.14U
* device instance $2 r0 *1 2.33,3.62 pmos_5p0
M$2 4 13 3 18 pmos_5p0 L=0.5U W=1.28U AS=0.5504P AD=0.4544P PS=2.14U PD=1.99U
* device instance $3 r0 *1 3.54,3.62 pmos_5p0
M$3 5 17 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.4544P AD=0.4032P PS=1.99U PD=1.91U
* device instance $4 r0 *1 4.67,3.62 pmos_5p0
M$4 18 14 5 18 pmos_5p0 L=0.5U W=1.28U AS=0.4032P AD=0.6432P PS=1.91U PD=2.4U
* device instance $5 r0 *1 6.13,3.62 pmos_5p0
M$5 6 2 18 18 pmos_5p0 L=0.5U W=2.56U AS=0.976P AD=0.896P PS=4.2U PD=5.24U
* device instance $7 r0 *1 9.555,3.62 pmos_5p0
M$7 2 15 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.7616P AD=0.4672P PS=3.75U PD=2.01U
* device instance $8 r0 *1 10.785,3.62 pmos_5p0
M$8 8 7 2 18 pmos_5p0 L=0.5U W=1.28U AS=0.4672P AD=0.5632P PS=2.01U PD=3.44U
* device instance $9 r0 *1 12.605,3.62 pmos_5p0
M$9 18 7 15 18 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3712P PS=3.44U PD=1.86U
* device instance $10 r0 *1 13.685,3.62 pmos_5p0
M$10 9 16 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3712P AD=0.3776P PS=1.86U PD=1.87U
* device instance $11 r0 *1 14.775,3.62 pmos_5p0
M$11 8 17 9 18 pmos_5p0 L=0.5U W=1.28U AS=0.3776P AD=0.3328P PS=1.87U PD=1.8U
* device instance $12 r0 *1 15.795,3.62 pmos_5p0
M$12 10 13 8 18 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.416P PS=1.8U PD=1.93U
* device instance $13 r0 *1 16.945,3.62 pmos_5p0
M$13 18 11 10 18 pmos_5p0 L=0.5U W=1.28U AS=0.416P AD=0.3968P PS=1.93U PD=1.9U
* device instance $14 r0 *1 18.065,3.62 pmos_5p0
M$14 17 13 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.5632P PS=1.9U PD=3.44U
* device instance $15 r0 *1 12.515,1.18 nmos_5p0
M$15 1 7 15 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $16 r0 *1 13.635,1.18 nmos_5p0
M$16 9 16 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $17 r0 *1 14.755,1.18 nmos_5p0
M$17 8 13 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $18 r0 *1 15.875,1.18 nmos_5p0
M$18 10 17 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 16.995,1.18 nmos_5p0
M$19 1 11 10 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 18.115,1.18 nmos_5p0
M$20 17 13 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
* device instance $21 r0 *1 0.92,1.18 nmos_5p0
M$21 3 12 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.48P PS=2.48U PD=2U
* device instance $22 r0 *1 2.72,1.18 nmos_5p0
M$22 4 17 3 1 nmos_5p0 L=0.6U W=0.8U AS=0.48P AD=0.208P PS=2U PD=1.32U
* device instance $23 r0 *1 3.84,1.18 nmos_5p0
M$23 5 13 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $24 r0 *1 4.96,1.18 nmos_5p0
M$24 1 14 5 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $25 r0 *1 6.08,1.18 nmos_5p0
M$25 6 2 1 1 nmos_5p0 L=0.6U W=1.6U AS=0.416P AD=0.56P PS=2.64U PD=3.8U
* device instance $27 r0 *1 9.555,1.18 nmos_5p0
M$27 2 7 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.544P AD=0.208P PS=2.96U PD=1.32U
* device instance $28 r0 *1 10.675,1.18 nmos_5p0
M$28 8 15 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux4_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlya_4
* pin I
* pin Z
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlya_4 1 5 6 7
* net 1 I
* net 5 Z
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 3.885,3.61 pmos_5p0
M$1 4 3 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.429P AD=0.1584P PS=2.58U PD=1.6U
* device instance $2 r0 *1 5.135,3.78 pmos_5p0
M$2 5 4 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.1309P AD=2.5071P PS=9.93U PD=11.89U
* device instance $6 r0 *1 0.875,3.61 pmos_5p0
M$6 6 1 2 6 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1116P PS=1.6U PD=0.98U
* device instance $7 r0 *1 1.995,3.61 pmos_5p0
M$7 3 2 6 6 pmos_5p0 L=0.5U W=0.36U AS=0.1116P AD=0.1584P PS=0.98U PD=1.6U
* device instance $8 r0 *1 3.885,0.94 nmos_5p0
M$8 4 3 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.1584P PS=2.02U PD=1.6U
* device instance $9 r0 *1 5.185,1.005 nmos_5p0
M$9 5 4 7 7 nmos_5p0 L=0.6U W=5.28U AS=1.3476P AD=1.6104P PS=7.54U PD=9.04U
* device instance $13 r0 *1 0.925,0.94 nmos_5p0
M$13 7 1 2 7 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.045,0.94 nmos_5p0
M$14 3 2 7 7 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.1584P PS=0.88U PD=1.6U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlya_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 10 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 10 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 11 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 11 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 8 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 8 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 9 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_2 1 5 7 8 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 7 CLK
* net 8 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 18.73,3.78 pmos_5p0
M$1 5 4 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 14.48,3.365 pmos_5p0
M$3 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 15.5,3.365 pmos_5p0
M$4 17 4 12 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $5 r0 *1 16.74,3.78 pmos_5p0
M$5 4 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.536P AD=0.8052P PS=2.57U PD=4.54U
* device instance $6 r0 *1 0.97,3.555 pmos_5p0
M$6 17 7 6 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $7 r0 *1 1.99,3.555 pmos_5p0
M$7 2 6 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $8 r0 *1 11.4,3.365 pmos_5p0
M$8 3 6 11 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $9 r0 *1 12.74,3.365 pmos_5p0
M$9 12 2 3 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $10 r0 *1 3.93,3.465 pmos_5p0
M$10 9 8 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $11 r0 *1 5.195,3.465 pmos_5p0
M$11 10 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $12 r0 *1 6.215,3.465 pmos_5p0
M$12 18 6 10 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.1825P PS=1.52U PD=1.365U
* device instance $13 r0 *1 7.08,3.465 pmos_5p0
M$13 17 11 18 17 pmos_5p0 L=0.5U W=1U AS=0.1825P AD=0.3P PS=1.365U PD=1.6U
* device instance $14 r0 *1 8.18,3.465 pmos_5p0
M$14 11 10 17 17 pmos_5p0 L=0.5U W=1U AS=0.3P AD=0.29P PS=1.6U PD=1.58U
* device instance $15 r0 *1 9.26,3.465 pmos_5p0
M$15 17 13 11 17 pmos_5p0 L=0.5U W=1U AS=0.29P AD=0.7374P PS=1.58U PD=3.75U
* device instance $16 r0 *1 18.68,1.005 nmos_5p0
M$16 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $18 r0 *1 3.88,1.265 nmos_5p0
M$18 9 8 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $19 r0 *1 5,1.265 nmos_5p0
M$19 10 6 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1711P PS=1.11U PD=1.17U
* device instance $20 r0 *1 6.18,1.265 nmos_5p0
M$20 14 2 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.1711P AD=0.07375P PS=1.17U PD=0.84U
* device instance $21 r0 *1 7.03,1.265 nmos_5p0
M$21 1 11 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.07375P AD=0.22355P PS=0.84U
+ PD=1.435U
* device instance $22 r0 *1 8.37,1.37 nmos_5p0
M$22 15 10 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.22355P AD=0.0708P PS=1.435U PD=0.83U
* device instance $23 r0 *1 9.21,1.37 nmos_5p0
M$23 11 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.1534P PS=0.83U PD=1.11U
* device instance $24 r0 *1 10.33,1.37 nmos_5p0
M$24 3 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $25 r0 *1 11.45,1.37 nmos_5p0
M$25 12 6 3 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
* device instance $26 r0 *1 0.92,1.27 nmos_5p0
M$26 1 7 6 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $27 r0 *1 2.04,1.27 nmos_5p0
M$27 2 6 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $28 r0 *1 14.61,1.37 nmos_5p0
M$28 16 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $29 r0 *1 15.45,1.37 nmos_5p0
M$29 16 4 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $30 r0 *1 16.79,1.005 nmos_5p0
M$30 4 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3789P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_2 1 5 6 7 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 6 CLK
* net 7 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 14.6,3.78 pmos_5p0
M$1 5 4 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 4.24,3.41 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9462P AD=0.12P PS=4.91U PD=1.24U
* device instance $4 r0 *1 4.98,3.41 pmos_5p0
M$4 8 7 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.31P PS=1.24U PD=1.62U
* device instance $5 r0 *1 6.1,3.41 pmos_5p0
M$5 16 3 8 14 pmos_5p0 L=0.5U W=1U AS=0.31P AD=0.12P PS=1.62U PD=1.24U
* device instance $6 r0 *1 6.84,3.41 pmos_5p0
M$6 14 9 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.35P PS=1.24U PD=1.7U
* device instance $7 r0 *1 8.04,3.41 pmos_5p0
M$7 9 8 14 14 pmos_5p0 L=0.5U W=1U AS=0.35P AD=0.46P PS=1.7U PD=1.92U
* device instance $8 r0 *1 9.46,3.41 pmos_5p0
M$8 10 3 9 14 pmos_5p0 L=0.5U W=1U AS=0.46P AD=0.4P PS=1.92U PD=1.8U
* device instance $9 r0 *1 10.76,3.41 pmos_5p0
M$9 17 2 10 14 pmos_5p0 L=0.5U W=1U AS=0.4P AD=0.13P PS=1.8U PD=1.26U
* device instance $10 r0 *1 11.52,3.41 pmos_5p0
M$10 17 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.6017P AD=0.13P PS=2.67U PD=1.26U
* device instance $11 r0 *1 12.86,3.78 pmos_5p0
M$11 4 10 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6017P AD=0.8052P PS=2.67U PD=4.54U
* device instance $12 r0 *1 0.87,3.555 pmos_5p0
M$12 14 6 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.4278P PS=3.64U PD=2U
* device instance $13 r0 *1 1.99,3.555 pmos_5p0
M$13 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.4278P AD=0.6072P PS=2U PD=3.64U
* device instance $14 r0 *1 14.65,1.005 nmos_5p0
M$14 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $16 r0 *1 0.92,1.125 nmos_5p0
M$16 1 6 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.125 nmos_5p0
M$17 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 4.09,1.365 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.6463P AD=0.0696P PS=4U PD=0.82U
* device instance $19 r0 *1 4.93,1.365 nmos_5p0
M$19 8 7 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $20 r0 *1 6.05,1.365 nmos_5p0
M$20 12 2 8 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $21 r0 *1 6.89,1.365 nmos_5p0
M$21 12 9 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.0696P PS=2.425U PD=0.82U
* device instance $22 r0 *1 8.39,1.37 nmos_5p0
M$22 9 8 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.1508P PS=2.425U PD=1.1U
* device instance $23 r0 *1 9.51,1.37 nmos_5p0
M$23 10 2 9 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $24 r0 *1 10.63,1.37 nmos_5p0
M$24 13 3 10 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $25 r0 *1 11.47,1.37 nmos_5p0
M$25 13 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $26 r0 *1 12.81,1 nmos_5p0
M$26 4 10 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3774P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 11 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 11 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 10 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 10 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 10 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 9 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 9 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 11 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 9 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2
