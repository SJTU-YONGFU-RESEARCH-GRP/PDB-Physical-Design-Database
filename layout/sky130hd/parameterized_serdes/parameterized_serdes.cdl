* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_serdes clk enable load mode parallel_in[0]
+ parallel_in[1] parallel_in[2] parallel_in[3] parallel_in[4]
+ parallel_in[5] parallel_in[6] parallel_in[7] parallel_out[0]
+ parallel_out[1] parallel_out[2] parallel_out[3] parallel_out[4]
+ parallel_out[5] parallel_out[6] parallel_out[7] rst_n rx_done
+ serial_in serial_out tx_done
X_082_ net2 net4 VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nand2_4
X_083_ net3 net22 VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nor2b_1
X_084_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__buf_6
X_085_ rx_bit_counter\[2\] _078_ net3 rx_bit_counter\[3\]
+ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__a211o_1
X_086_ rx_bit_counter\[2\] rx_bit_counter\[0\] rx_bit_counter\[1\]
+ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nand3_1
X_087_ _065_ _067_ rx_bit_counter\[3\] VSS VSS VDD VDD _070_
+ sky130_fd_sc_hd__o21ai_0
X_088_ _065_ _067_ _068_ _069_ _070_ VSS VSS VDD VDD _000_
+ sky130_fd_sc_hd__o41ai_1
X_089_ net3 VSS VSS VDD VDD _071_ sky130_fd_sc_hd__inv_1
X_090_ rx_bit_counter\[2\] _078_ rx_bit_counter\[3\] VSS VSS
+ VDD VDD _072_ sky130_fd_sc_hd__a21o_1
X_091_ _071_ _072_ _067_ _065_ VSS VSS VDD VDD _073_ sky130_fd_sc_hd__a211oi_4
X_092_ net2 net4 net22 VSS VSS VDD VDD _074_ sky130_fd_sc_hd__a21oi_1
X_093_ _073_ _074_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor2_1
X_094_ net3 VSS VSS VDD VDD _075_ sky130_fd_sc_hd__clkbuf_4
X_095_ _075_ net13 VSS VSS VDD VDD _076_ sky130_fd_sc_hd__nor2b_1
X_096_ rx_shift_reg\[0\] _076_ _073_ VSS VSS VDD VDD _002_
+ sky130_fd_sc_hd__mux2_1
X_097_ _075_ rx_shift_reg\[0\] VSS VSS VDD VDD _077_ sky130_fd_sc_hd__nor2b_1
X_098_ rx_shift_reg\[1\] _077_ _073_ VSS VSS VDD VDD _003_
+ sky130_fd_sc_hd__mux2_1
X_099_ _075_ rx_shift_reg\[1\] VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nor2b_1
X_100_ rx_shift_reg\[2\] _033_ _073_ VSS VSS VDD VDD _004_
+ sky130_fd_sc_hd__mux2_1
X_101_ _075_ rx_shift_reg\[2\] VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nor2b_1
X_102_ rx_shift_reg\[3\] _034_ _073_ VSS VSS VDD VDD _005_
+ sky130_fd_sc_hd__mux2_1
X_103_ _075_ rx_shift_reg\[3\] VSS VSS VDD VDD _035_ sky130_fd_sc_hd__nor2b_1
X_104_ rx_shift_reg\[4\] _035_ _073_ VSS VSS VDD VDD _006_
+ sky130_fd_sc_hd__mux2_1
X_105_ _075_ rx_shift_reg\[4\] VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor2b_1
X_106_ rx_shift_reg\[5\] _036_ _073_ VSS VSS VDD VDD _007_
+ sky130_fd_sc_hd__mux2_1
X_107_ _075_ rx_shift_reg\[5\] VSS VSS VDD VDD _037_ sky130_fd_sc_hd__nor2b_1
X_108_ rx_shift_reg\[6\] _037_ _073_ VSS VSS VDD VDD _008_
+ sky130_fd_sc_hd__mux2_1
X_109_ net4 net2 VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2b_1
X_110_ tx_bit_counter\[2\] _080_ _075_ tx_bit_counter\[3\]
+ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__a211o_1
X_111_ net24 _038_ _039_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor3_1
X_112_ net4 net2 VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nor2b_1
X_113_ _075_ net24 VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nand2b_1
X_114_ _041_ _042_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand2_1
X_115_ _040_ _043_ tx_bit_counter\[0\] VSS VSS VDD VDD _009_
+ sky130_fd_sc_hd__mux2_1
X_116_ tx_bit_counter\[1\] _043_ _040_ _081_ VSS VSS VDD VDD
+ _010_ sky130_fd_sc_hd__a22o_1
X_117_ _071_ net24 _038_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__a21oi_1
X_118_ _080_ _041_ _042_ tx_bit_counter\[2\] VSS VSS VDD VDD
+ _045_ sky130_fd_sc_hd__a31oi_1
X_119_ _044_ _039_ _045_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__a21oi_1
X_120_ tx_bit_counter\[2\] tx_bit_counter\[0\] tx_bit_counter\[1\]
+ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nand3_1
X_121_ _039_ _046_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__nor2_1
X_122_ tx_bit_counter\[3\] _047_ _044_ VSS VSS VDD VDD _012_
+ sky130_fd_sc_hd__mux2_1
X_123_ tx_bit_counter\[2\] _080_ tx_bit_counter\[3\] VSS VSS
+ VDD VDD _048_ sky130_fd_sc_hd__a21oi_1
X_124_ _038_ _048_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__nor2_1
X_125_ _075_ _041_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__nand2_4
X_126_ net24 _049_ _050_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__o21a_1
X_127_ net5 tx_shift_reg\[0\] _050_ VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__mux2_1
X_128_ net6 tx_shift_reg\[1\] _050_ VSS VSS VDD VDD _015_
+ sky130_fd_sc_hd__mux2_1
X_129_ net7 tx_shift_reg\[2\] _050_ VSS VSS VDD VDD _016_
+ sky130_fd_sc_hd__mux2_1
X_130_ net8 tx_shift_reg\[3\] _050_ VSS VSS VDD VDD _017_
+ sky130_fd_sc_hd__mux2_1
X_131_ net9 tx_shift_reg\[4\] _050_ VSS VSS VDD VDD _018_
+ sky130_fd_sc_hd__mux2_1
X_132_ net10 tx_shift_reg\[5\] _050_ VSS VSS VDD VDD _019_
+ sky130_fd_sc_hd__mux2_1
X_133_ net11 tx_shift_reg\[6\] _050_ VSS VSS VDD VDD _020_
+ sky130_fd_sc_hd__mux2_1
X_134_ net12 tx_shift_reg\[7\] _050_ VSS VSS VDD VDD _021_
+ sky130_fd_sc_hd__mux2_1
X_135_ net3 net22 _065_ _072_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nor4b_4
X_136_ net14 net13 _051_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__mux2_1
X_137_ net15 rx_shift_reg\[0\] _051_ VSS VSS VDD VDD _023_
+ sky130_fd_sc_hd__mux2_1
X_138_ net16 rx_shift_reg\[1\] _051_ VSS VSS VDD VDD _024_
+ sky130_fd_sc_hd__mux2_1
X_139_ net17 rx_shift_reg\[2\] _051_ VSS VSS VDD VDD _025_
+ sky130_fd_sc_hd__mux2_1
X_140_ net18 rx_shift_reg\[3\] _051_ VSS VSS VDD VDD _026_
+ sky130_fd_sc_hd__mux2_1
X_141_ net19 rx_shift_reg\[4\] _051_ VSS VSS VDD VDD _027_
+ sky130_fd_sc_hd__mux2_1
X_142_ net20 rx_shift_reg\[5\] _051_ VSS VSS VDD VDD _028_
+ sky130_fd_sc_hd__mux2_1
X_143_ net21 rx_shift_reg\[6\] _051_ VSS VSS VDD VDD _029_
+ sky130_fd_sc_hd__mux2_1
X_144_ _065_ _067_ rx_bit_counter\[0\] VSS VSS VDD VDD _052_
+ sky130_fd_sc_hd__o21ai_0
X_145_ rx_bit_counter\[0\] _065_ _067_ _068_ VSS VSS VDD VDD
+ _053_ sky130_fd_sc_hd__or4_1
X_146_ _052_ _053_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__nand2_1
X_147_ _079_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__inv_1
X_148_ _065_ _067_ rx_bit_counter\[1\] VSS VSS VDD VDD _055_
+ sky130_fd_sc_hd__o21ai_0
X_149_ _054_ _065_ _067_ _068_ _055_ VSS VSS VDD VDD _031_
+ sky130_fd_sc_hd__o41ai_1
X_150_ _067_ _065_ _078_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__nor3b_1
X_151_ _065_ _067_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__nor2_1
X_152_ rx_bit_counter\[2\] _056_ _068_ _057_ VSS VSS VDD VDD
+ _032_ sky130_fd_sc_hd__a2bb2oi_1
X_153_ tx_bit_counter\[2\] VSS VSS VDD VDD _058_ sky130_fd_sc_hd__inv_1
X_154_ tx_shift_reg\[6\] tx_shift_reg\[4\] tx_bit_counter\[1\]
+ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__mux2i_1
X_155_ tx_bit_counter\[2\] tx_bit_counter\[0\] VSS VSS VDD
+ VDD _060_ sky130_fd_sc_hd__nor2_1
X_156_ tx_shift_reg\[7\] tx_shift_reg\[5\] tx_bit_counter\[1\]
+ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__mux2i_1
X_157_ _060_ _061_ tx_bit_counter\[3\] VSS VSS VDD VDD _062_
+ sky130_fd_sc_hd__a21o_1
X_158_ tx_shift_reg\[3\] tx_shift_reg\[2\] tx_shift_reg\[1\]
+ tx_shift_reg\[0\] tx_bit_counter\[0\] tx_bit_counter\[1\]
+ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__mux4_1
X_159_ _058_ _063_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__nor2_1
X_160_ _058_ tx_bit_counter\[0\] _059_ _062_ _064_ VSS VSS
+ VDD VDD net23 sky130_fd_sc_hd__a311oi_1
X_161_ rx_bit_counter\[0\] rx_bit_counter\[1\] VSS VSS VDD
+ VDD _078_ _079_ sky130_fd_sc_hd__ha_1
X_162_ tx_bit_counter\[0\] tx_bit_counter\[1\] VSS VSS VDD
+ VDD _080_ _081_ sky130_fd_sc_hd__ha_1
Xparallel_out\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _022_
+ net1 VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[1\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _023_
+ net1 VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _024_
+ net1 VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[3\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _025_
+ net1 VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[4\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _026_
+ net1 VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[5\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _027_
+ net1 VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[6\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _028_
+ net1 VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[7\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _029_
+ net1 VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xrx_bit_counter\[0\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _030_
+ net1 VSS VSS VDD VDD rx_bit_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xrx_bit_counter\[1\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _031_
+ net1 VSS VSS VDD VDD rx_bit_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xrx_bit_counter\[2\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _032_
+ net1 VSS VSS VDD VDD rx_bit_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xrx_bit_counter\[3\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _000_
+ net1 VSS VSS VDD VDD rx_bit_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xrx_done$_DFFE_PN0P_ clknet_2_1__leaf_clk _001_ net1 VSS VSS
+ VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _002_
+ net1 VSS VSS VDD VDD rx_shift_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[1\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _003_
+ net1 VSS VSS VDD VDD rx_shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _004_
+ net1 VSS VSS VDD VDD rx_shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[3\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _005_
+ net1 VSS VSS VDD VDD rx_shift_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[4\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _006_
+ net1 VSS VSS VDD VDD rx_shift_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[5\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _007_
+ net1 VSS VSS VDD VDD rx_shift_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xrx_shift_reg\[6\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _008_
+ net1 VSS VSS VDD VDD rx_shift_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xtx_bit_counter\[0\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _009_
+ net1 VSS VSS VDD VDD tx_bit_counter\[0\] sky130_fd_sc_hd__dfrtp_2
Xtx_bit_counter\[1\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _010_
+ net1 VSS VSS VDD VDD tx_bit_counter\[1\] sky130_fd_sc_hd__dfrtp_2
Xtx_bit_counter\[2\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _011_
+ net1 VSS VSS VDD VDD tx_bit_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xtx_bit_counter\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _012_
+ net1 VSS VSS VDD VDD tx_bit_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xtx_done_reg$_DFFE_PN0P_ clknet_2_3__leaf_clk _013_ net1 VSS
+ VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[0\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _014_
+ net1 VSS VSS VDD VDD tx_shift_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[1\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _015_
+ net1 VSS VSS VDD VDD tx_shift_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[2\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _016_
+ net1 VSS VSS VDD VDD tx_shift_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[3\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _017_
+ net1 VSS VSS VDD VDD tx_shift_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[4\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _018_
+ net1 VSS VSS VDD VDD tx_shift_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[5\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _019_
+ net1 VSS VSS VDD VDD tx_shift_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[6\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _020_
+ net1 VSS VSS VDD VDD tx_shift_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xtx_shift_reg\[7\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _021_
+ net1 VSS VSS VDD VDD tx_shift_reg\[7\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net25 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 load VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 mode VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 parallel_in[0] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 parallel_in[1] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 parallel_in[2] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 parallel_in[3] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 parallel_in[4] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 parallel_in[5] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 parallel_in[6] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 parallel_in[7] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 serial_in VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD rx_done sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD serial_out sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD tx_done sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_2_2__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xclkload1 clknet_2_3__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkinv_2
Xhold2 rst_n VSS VSS VDD VDD net25 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_serdes
