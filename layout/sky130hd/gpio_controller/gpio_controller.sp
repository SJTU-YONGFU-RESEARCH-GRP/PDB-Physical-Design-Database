* cell gpio_controller
* pin int_polarity[13]
* pin int_type[13]
* pin int_polarity[15]
* pin int_clear[13]
* pin int_enable[13]
* pin int_type[15]
* pin gpio_out[6]
* pin gpio_pins[6]
* pin gpio_in[6]
* pin int_status[13]
* pin int_clear[15]
* pin int_enable[15]
* pin gpio_in[12]
* pin int_status[15]
* pin int_clear[6]
* pin int_status[12]
* pin gpio_out[12]
* pin int_status[9]
* pin gpio_pins[12]
* pin int_status[6]
* pin int_polarity[6]
* pin int_type[6]
* pin int_enable[12]
* pin int_clear[12]
* pin int_enable[6]
* pin int_enable[9]
* pin int_clear[9]
* pin int_type[9]
* pin int_polarity[9]
* pin int_polarity[12]
* pin gpio_out[18]
* pin gpio_out[30]
* pin gpio_pins[18]
* pin gpio_pins[30]
* pin gpio_out[28]
* pin int_type[12]
* pin gpio_pins[21]
* pin gpio_out[21]
* pin gpio_out[19]
* pin gpio_in[28]
* pin gpio_pins[19]
* pin gpio_in[21]
* pin gpio_in[30]
* pin gpio_in[19]
* pin gpio_in[18]
* pin int_polarity[21]
* pin int_type[21]
* pin int_enable[21]
* pin int_polarity[18]
* pin int_clear[21]
* pin int_type[18]
* pin int_enable[18]
* pin int_clear[18]
* pin int_polarity[19]
* pin int_type[19]
* pin int_clear[19]
* pin int_enable[19]
* pin int_status[18]
* pin gpio_in[10]
* pin int_type[11]
* pin gpio_pins[28]
* pin int_status[21]
* pin gpio_in[13]
* pin gpio_in[16]
* pin int_clear[16]
* pin gpio_pins[13]
* pin int_polarity[30]
* pin gpio_out[13]
* pin int_clear[30]
* pin int_clear[11]
* pin rst_n
* pin int_status[19]
* pin int_clear[25]
* pin gpio_in[11]
* pin gpio_in[25]
* pin int_status[25]
* pin int_polarity[8]
* pin gpio_out[8]
* pin int_enable[16]
* pin int_status[10]
* pin gpio_in[15]
* pin int_status[16]
* pin int_type[25]
* pin gpio_pins[15]
* pin int_enable[25]
* pin gpio_pins[11]
* pin gpio_out[15]
* pin int_type[8]
* pin int_type[28]
* pin int_polarity[16]
* pin gpio_pins[25]
* pin int_enable[8]
* pin gpio_pins[8]
* pin int_enable[28]
* pin gpio_pins[10]
* pin int_status[30]
* pin int_enable[30]
* pin gpio_in[8]
* pin int_type[16]
* pin int_status[8]
* pin int_status[28]
* pin int_polarity[28]
* pin gpio_pins[16]
* pin gpio_out[16]
* pin int_polarity[10]
* pin int_type[10]
* pin int_polarity[11]
* pin int_clear[8]
* pin gpio_out[11]
* pin int_polarity[25]
* pin int_clear[28]
* pin int_enable[11]
* pin gpio_out[25]
* pin int_status[11]
* pin int_type[30]
* pin gpio_pins[9]
* pin gpio_out[10]
* pin int_clear[10]
* pin int_status[31]
* pin int_enable[10]
* pin gpio_pins[22]
* pin gpio_out[22]
* pin gpio_in[9]
* pin int_polarity[22]
* pin gpio_in[22]
* pin gpio_out[9]
* pin int_clear[31]
* pin gpio_pins[3]
* pin gpio_in[3]
* pin int_type[22]
* pin gpio_out[3]
* pin int_enable[22]
* pin int_enable[3]
* pin int_enable[31]
* pin int_polarity[3]
* pin int_clear[22]
* pin clk
* pin int_out
* pin int_type[31]
* pin gpio_in[0]
* pin int_clear[3]
* pin int_status[3]
* pin int_type[17]
* pin int_status[22]
* pin int_type[29]
* pin int_polarity[29]
* pin int_enable[0]
* pin gpio_pins[0]
* pin int_status[17]
* pin int_clear[17]
* pin int_type[0]
* pin gpio_out[0]
* pin int_polarity[20]
* pin int_polarity[31]
* pin int_enable[17]
* pin int_status[0]
* pin int_status[2]
* pin int_clear[2]
* pin gpio_in[7]
* pin int_status[20]
* pin int_status[23]
* pin gpio_in[14]
* pin gpio_pins[14]
* pin int_polarity[2]
* pin int_enable[2]
* pin gpio_in[1]
* pin gpio_pins[23]
* pin int_enable[29]
* pin gpio_out[2]
* pin gpio_pins[7]
* pin int_type[23]
* pin int_polarity[24]
* pin int_type[2]
* pin gpio_pins[2]
* pin int_status[1]
* pin int_clear[20]
* pin int_status[24]
* pin gpio_out[1]
* pin int_enable[20]
* pin int_status[29]
* pin gpio_out[23]
* pin int_enable[23]
* pin gpio_in[2]
* pin int_clear[0]
* pin int_polarity[17]
* pin int_polarity[23]
* pin int_type[3]
* pin gpio_in[20]
* pin gpio_out[14]
* pin int_type[20]
* pin int_type[14]
* pin int_polarity[14]
* pin int_enable[14]
* pin int_status[4]
* pin int_clear[29]
* pin int_clear[23]
* pin gpio_in[5]
* pin int_polarity[7]
* pin gpio_pins[1]
* pin int_type[5]
* pin int_status[5]
* pin int_enable[1]
* pin int_enable[4]
* pin int_type[24]
* pin int_polarity[5]
* pin gpio_out[7]
* pin int_polarity[0]
* pin int_type[7]
* pin gpio_pins[5]
* pin int_polarity[1]
* pin int_polarity[26]
* pin int_type[27]
* pin int_enable[27]
* pin int_polarity[27]
* pin int_type[1]
* pin gpio_in[24]
* pin gpio_in[23]
* pin int_status[27]
* pin gpio_pins[20]
* pin gpio_pins[27]
* pin int_type[26]
* pin int_enable[26]
* pin int_status[26]
* pin gpio_in[29]
* pin gpio_pins[17]
* pin int_status[7]
* pin int_enable[5]
* pin gpio_out[26]
* pin gpio_in[27]
* pin gpio_pins[24]
* pin gpio_in[4]
* pin gpio_in[26]
* pin int_polarity[4]
* pin gpio_pins[29]
* pin gpio_out[5]
* pin int_clear[4]
* pin gpio_out[17]
* pin gpio_out[24]
* pin gpio_out[27]
* pin gpio_out[20]
* pin int_enable[24]
* pin int_clear[24]
* pin int_enable[7]
* pin int_clear[14]
* pin int_clear[7]
* pin int_clear[27]
* pin int_clear[26]
* pin int_type[4]
* pin int_clear[5]
* pin int_clear[1]
* pin gpio_out[31]
* pin gpio_in[31]
* pin gpio_out[29]
* pin int_status[14]
* pin gpio_out[4]
* pin gpio_pins[4]
* pin gpio_pins[31]
* pin gpio_pins[26]
* pin gpio_in[17]
.SUBCKT gpio_controller 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 61 62 65 67 79 88 89 97 109 124 137 149 150
+ 164 165 177 189 190 199 200 213 215 220 230 239 243 250 252 266 267 268 272
+ 273 274 277 281 284 288 291 296 301 306 320 321 322 323 325 327 334 351 356
+ 372 373 386 391 393 399 400 406 407 410 421 424 425 426 431 433 438 442 448
+ 449 453 460 462 467 476 482 487 493 497 502 503 507 508 512 513 522 523 529
+ 530 536 537 550 551 553 555 556 562 578 579 582 586 587 597 598 600 601 603
+ 607 608 615 620 623 632 635 639 640 643 645 652 657 660 664 665 677 678 685
+ 686 700 702 703 712 722 723 727 728 731 732 738 740 741 742 749 751 755 759
+ 765 767 768 769 770 771 775 776 781 784 791 795 796 797 804 805 808 831 842
+ 846 847 850 852 855 856 857 863 872 873 878 881 882 883 884 885 886 887 888
+ 889 891 893 894 895 896 897 898 899 900 902 903 904 905 906 907 908
* net 1 int_polarity[13]
* net 2 int_type[13]
* net 3 int_polarity[15]
* net 4 int_clear[13]
* net 5 int_enable[13]
* net 6 int_type[15]
* net 7 gpio_out[6]
* net 8 gpio_pins[6]
* net 9 gpio_in[6]
* net 10 int_status[13]
* net 11 int_clear[15]
* net 12 int_enable[15]
* net 13 gpio_in[12]
* net 14 int_status[15]
* net 15 int_clear[6]
* net 16 int_status[12]
* net 17 gpio_out[12]
* net 18 int_status[9]
* net 19 gpio_pins[12]
* net 20 int_status[6]
* net 21 int_polarity[6]
* net 22 int_type[6]
* net 23 int_enable[12]
* net 24 int_clear[12]
* net 25 int_enable[6]
* net 26 int_enable[9]
* net 27 int_clear[9]
* net 28 int_type[9]
* net 29 int_polarity[9]
* net 30 int_polarity[12]
* net 31 gpio_out[18]
* net 32 gpio_out[30]
* net 33 gpio_pins[18]
* net 34 gpio_pins[30]
* net 35 gpio_out[28]
* net 36 int_type[12]
* net 37 gpio_pins[21]
* net 38 gpio_out[21]
* net 39 gpio_out[19]
* net 40 gpio_in[28]
* net 41 gpio_pins[19]
* net 42 gpio_in[21]
* net 43 gpio_in[30]
* net 44 gpio_in[19]
* net 45 gpio_in[18]
* net 46 int_polarity[21]
* net 47 int_type[21]
* net 48 int_enable[21]
* net 49 int_polarity[18]
* net 50 int_clear[21]
* net 51 int_type[18]
* net 52 int_enable[18]
* net 53 int_clear[18]
* net 54 int_polarity[19]
* net 55 int_type[19]
* net 56 int_clear[19]
* net 57 int_enable[19]
* net 58 int_status[18]
* net 61 gpio_in[10]
* net 62 int_type[11]
* net 65 gpio_pins[28]
* net 67 int_status[21]
* net 79 gpio_in[13]
* net 88 gpio_in[16]
* net 89 int_clear[16]
* net 97 gpio_pins[13]
* net 109 int_polarity[30]
* net 124 gpio_out[13]
* net 137 int_clear[30]
* net 149 int_clear[11]
* net 150 rst_n
* net 164 int_status[19]
* net 165 int_clear[25]
* net 177 gpio_in[11]
* net 189 gpio_in[25]
* net 190 int_status[25]
* net 199 int_polarity[8]
* net 200 gpio_out[8]
* net 213 int_enable[16]
* net 215 int_status[10]
* net 220 gpio_in[15]
* net 230 int_status[16]
* net 239 int_type[25]
* net 243 gpio_pins[15]
* net 250 int_enable[25]
* net 252 gpio_pins[11]
* net 266 gpio_out[15]
* net 267 int_type[8]
* net 268 int_type[28]
* net 272 int_polarity[16]
* net 273 gpio_pins[25]
* net 274 int_enable[8]
* net 277 gpio_pins[8]
* net 281 int_enable[28]
* net 284 gpio_pins[10]
* net 288 int_status[30]
* net 291 int_enable[30]
* net 296 gpio_in[8]
* net 301 int_type[16]
* net 306 int_status[8]
* net 320 int_status[28]
* net 321 int_polarity[28]
* net 322 gpio_pins[16]
* net 323 gpio_out[16]
* net 325 int_polarity[10]
* net 327 int_type[10]
* net 334 int_polarity[11]
* net 351 int_clear[8]
* net 356 gpio_out[11]
* net 372 int_polarity[25]
* net 373 int_clear[28]
* net 386 int_enable[11]
* net 391 gpio_out[25]
* net 393 int_status[11]
* net 399 int_type[30]
* net 400 gpio_pins[9]
* net 406 gpio_out[10]
* net 407 int_clear[10]
* net 410 int_status[31]
* net 421 int_enable[10]
* net 424 gpio_pins[22]
* net 425 gpio_out[22]
* net 426 gpio_in[9]
* net 431 int_polarity[22]
* net 433 gpio_in[22]
* net 438 gpio_out[9]
* net 442 int_clear[31]
* net 448 gpio_pins[3]
* net 449 gpio_in[3]
* net 453 int_type[22]
* net 460 gpio_out[3]
* net 462 int_enable[22]
* net 467 int_enable[3]
* net 476 int_enable[31]
* net 482 int_polarity[3]
* net 487 int_clear[22]
* net 493 clk
* net 497 int_out
* net 502 int_type[31]
* net 503 gpio_in[0]
* net 507 int_clear[3]
* net 508 int_status[3]
* net 512 int_type[17]
* net 513 int_status[22]
* net 522 int_type[29]
* net 523 int_polarity[29]
* net 529 int_enable[0]
* net 530 gpio_pins[0]
* net 536 int_status[17]
* net 537 int_clear[17]
* net 550 int_type[0]
* net 551 gpio_out[0]
* net 553 int_polarity[20]
* net 555 int_polarity[31]
* net 556 int_enable[17]
* net 562 int_status[0]
* net 578 int_status[2]
* net 579 int_clear[2]
* net 582 gpio_in[7]
* net 586 int_status[20]
* net 587 int_status[23]
* net 597 gpio_in[14]
* net 598 gpio_pins[14]
* net 600 int_polarity[2]
* net 601 int_enable[2]
* net 603 gpio_in[1]
* net 607 gpio_pins[23]
* net 608 int_enable[29]
* net 615 gpio_out[2]
* net 620 gpio_pins[7]
* net 623 int_type[23]
* net 632 int_polarity[24]
* net 635 int_type[2]
* net 639 gpio_pins[2]
* net 640 int_status[1]
* net 643 int_clear[20]
* net 645 int_status[24]
* net 652 gpio_out[1]
* net 657 int_enable[20]
* net 660 int_status[29]
* net 664 gpio_out[23]
* net 665 int_enable[23]
* net 677 gpio_in[2]
* net 678 int_clear[0]
* net 685 int_polarity[17]
* net 686 int_polarity[23]
* net 700 int_type[3]
* net 702 gpio_in[20]
* net 703 gpio_out[14]
* net 712 int_type[20]
* net 722 int_type[14]
* net 723 int_polarity[14]
* net 727 int_enable[14]
* net 728 int_status[4]
* net 731 int_clear[29]
* net 732 int_clear[23]
* net 738 gpio_in[5]
* net 740 int_polarity[7]
* net 741 gpio_pins[1]
* net 742 int_type[5]
* net 749 int_status[5]
* net 751 int_enable[1]
* net 755 int_enable[4]
* net 759 int_type[24]
* net 765 int_polarity[5]
* net 767 gpio_out[7]
* net 768 int_polarity[0]
* net 769 int_type[7]
* net 770 gpio_pins[5]
* net 771 int_polarity[1]
* net 775 int_polarity[26]
* net 776 int_type[27]
* net 781 int_enable[27]
* net 784 int_polarity[27]
* net 791 int_type[1]
* net 795 gpio_in[24]
* net 796 gpio_in[23]
* net 797 int_status[27]
* net 804 gpio_pins[20]
* net 805 gpio_pins[27]
* net 808 int_type[26]
* net 831 int_enable[26]
* net 842 int_status[26]
* net 846 gpio_in[29]
* net 847 gpio_pins[17]
* net 850 int_status[7]
* net 852 int_enable[5]
* net 855 gpio_out[26]
* net 856 gpio_in[27]
* net 857 gpio_pins[24]
* net 863 gpio_in[4]
* net 872 gpio_in[26]
* net 873 int_polarity[4]
* net 878 gpio_pins[29]
* net 881 gpio_out[5]
* net 882 int_clear[4]
* net 883 gpio_out[17]
* net 884 gpio_out[24]
* net 885 gpio_out[27]
* net 886 gpio_out[20]
* net 887 int_enable[24]
* net 888 int_clear[24]
* net 889 int_enable[7]
* net 891 int_clear[14]
* net 893 int_clear[7]
* net 894 int_clear[27]
* net 895 int_clear[26]
* net 896 int_type[4]
* net 897 int_clear[5]
* net 898 int_clear[1]
* net 899 gpio_out[31]
* net 900 gpio_in[31]
* net 902 gpio_out[29]
* net 903 int_status[14]
* net 904 gpio_out[4]
* net 905 gpio_pins[4]
* net 906 gpio_pins[31]
* net 907 gpio_pins[26]
* net 908 gpio_in[17]
* cell instance $2 r0 *1 16.56,13.6
X$2 111 1 100 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 20.24,24.48
X$6 111 2 94 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $11 r0 *1 23,24.48
X$11 111 3 240 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $13 r0 *1 22.08,2.72
X$13 111 4 111 95 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $17 r0 *1 19.78,19.04
X$17 111 5 181 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $20 r0 *1 21.62,24.48
X$20 111 6 204 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $23 r0 *1 16.56,2.72
X$23 111 7 111 80 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $26 r0 *1 22.54,13.6
X$26 111 203 8 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $34 m0 *1 15.18,13.6
X$34 111 202 9 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $38 m0 *1 20.7,13.6
X$38 111 180 10 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $41 m0 *1 25.3,8.16
X$41 111 11 111 154 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $48 r0 *1 22.54,19.04
X$48 111 12 217 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $50 r0 *1 30.36,13.6
X$50 111 225 13 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $54 r0 *1 31.74,13.6
X$54 111 73 14 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $57 r0 *1 30.36,2.72
X$57 111 15 111 91 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $61 r0 *1 8.28,2.72
X$61 111 101 16 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $64 r0 *1 34.04,2.72
X$64 111 17 111 77 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $70 m0 *1 13.8,13.6
X$70 111 179 18 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $73 r0 *1 34.04,13.6
X$73 111 71 19 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $76 r0 *1 17.94,13.6
X$76 111 155 20 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $81 r0 *1 35.42,13.6
X$81 111 21 126 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $83 r0 *1 36.8,13.6
X$83 111 22 226 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $89 r0 *1 20.7,2.72
X$89 111 23 63 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $92 r0 *1 39.1,2.72
X$92 111 24 111 105 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $98 r0 *1 41.4,13.6
X$98 111 25 104 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $104 r0 *1 40.02,13.6
X$104 111 26 262 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $106 m0 *1 43.24,8.16
X$106 111 27 111 127 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $114 r0 *1 51.98,8.16
X$114 111 28 158 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $117 m0 *1 51.06,13.6
X$117 111 29 198 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $122 r0 *1 50.6,8.16
X$122 111 30 196 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $125 r0 *1 44.62,2.72
X$125 111 31 111 123 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $128 r0 *1 48.3,2.72
X$128 111 32 111 64 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $131 r0 *1 43.24,2.72
X$131 111 82 33 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $134 m0 *1 52.9,8.16
X$134 111 78 34 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $137 r0 *1 51.98,2.72
X$137 111 35 111 122 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $140 m0 *1 50.14,8.16
X$140 111 36 208 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $145 m0 *1 54.28,8.16
X$145 111 128 37 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $148 r0 *1 57.04,2.72
X$148 111 38 111 121 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $151 r0 *1 60.72,2.72
X$151 111 39 111 96 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $154 m0 *1 59.8,8.16
X$154 111 129 40 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $157 r0 *1 56.12,8.16
X$157 111 66 41 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $160 r0 *1 65.78,2.72
X$160 111 83 42 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $163 r0 *1 59.8,8.16
X$163 111 159 43 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $166 r0 *1 70.84,2.72
X$166 111 171 44 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $169 r0 *1 62.56,8.16
X$169 111 120 45 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $172 m0 *1 67.62,13.6
X$172 111 46 132 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $177 m0 *1 55.2,13.6
X$177 111 47 186 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $182 r0 *1 84.64,2.72
X$182 111 48 108 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $185 r0 *1 69,13.6
X$185 111 49 133 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $188 r0 *1 72.22,2.72
X$188 111 50 111 115 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $190 m0 *1 70.38,35.36
X$190 111 51 300 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $196 r0 *1 58.42,8.16
X$196 111 52 192 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $199 r0 *1 76.82,2.72
X$199 111 53 111 76 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $206 m0 *1 53.82,13.6
X$206 111 54 140 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $211 r0 *1 53.82,13.6
X$211 111 55 214 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $214 m0 *1 76.82,8.16
X$214 111 56 111 160 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $219 m0 *1 53.82,19.04
X$219 111 57 85 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $226 m0 *1 68.08,29.92
X$226 111 163 58 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $231 r0 *1 92.46,2.72
X$231 111 89 111 59 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $233 m0 *1 55.2,24.48
X$233 111 59 211 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $239 r0 *1 6.9,2.72
X$239 111 73 111 70 60 70 sky130_fd_sc_hd__inv_1
* cell instance $242 m0 *1 26.68,13.6
X$242 111 205 193 60 182 144 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $246 r0 *1 8.28,13.6
X$246 111 236 61 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $250 r0 *1 9.66,13.6
X$250 111 62 221 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $255 m0 *1 46.92,8.16
X$255 111 63 157 176 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $260 r0 *1 37.72,2.72
X$260 111 64 78 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $263 m0 *1 58.42,8.16
X$263 111 130 65 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $274 m0 *1 71.76,8.16
X$274 111 66 171 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $276 r0 *1 55.2,13.6
X$276 70 125 261 206 66 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $279 r0 *1 64.4,2.72
X$279 111 96 66 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $287 m0 *1 52.44,13.6
X$287 111 161 67 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $294 r0 *1 86.94,2.72
X$294 111 68 72 69 70 111 87 70 sky130_fd_sc_hd__a21oi_1
* cell instance $296 r0 *1 69,8.16
X$296 111 160 68 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $299 r0 *1 80.5,2.72
X$299 111 86 114 92 85 69 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $309 r0 *1 2.76,2.72
X$309 111 124 111 90 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $310 r0 *1 1.38,2.72
X$310 111 199 110 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $312 r0 *1 9.66,2.72
X$312 111 91 113 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $313 r0 *1 11.04,2.72
X$313 111 77 71 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $314 r0 *1 12.42,2.72
X$314 111 100 93 94 70 111 81 70 sky130_fd_sc_hd__a21boi_0
* cell instance $319 r0 *1 25.76,2.72
X$319 111 74 151 75 81 111 116 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $327 r0 *1 67.16,2.72
X$327 111 82 120 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $328 r0 *1 68.54,2.72
X$328 111 107 84 118 70 111 117 70 sky130_fd_sc_hd__a21oi_1
* cell instance $335 r0 *1 88.78,2.72
X$335 111 87 111 138 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $343 m0 *1 1.84,8.16
X$343 70 125 167 98 99 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $345 m0 *1 11.5,8.16
X$345 70 125 93 98 75 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $347 m0 *1 21.62,8.16
X$347 111 142 111 170 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $350 m0 *1 29.9,8.16
X$350 111 144 111 145 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $351 m0 *1 33.58,8.16
X$351 111 102 111 172 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $352 m0 *1 37.26,8.16
X$352 111 126 147 103 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $353 m0 *1 40.48,8.16
X$353 111 148 146 103 104 175 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $355 m0 *1 51.52,8.16
X$355 111 121 128 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $358 m0 *1 57.04,8.16
X$358 111 130 129 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $359 m0 *1 61.18,8.16
X$359 111 128 83 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $360 m0 *1 62.56,8.16
X$360 111 132 131 106 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $361 m0 *1 65.78,8.16
X$361 111 219 143 106 108 118 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $362 m0 *1 68.54,8.16
X$362 111 133 119 134 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $363 m0 *1 73.14,8.16
X$363 111 117 111 169 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $364 m0 *1 80.5,8.16
X$364 111 140 141 92 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $367 m0 *1 84.64,8.16
X$367 111 139 168 136 70 111 112 70 sky130_fd_sc_hd__a21oi_1
* cell instance $369 m0 *1 86.94,8.16
X$369 70 125 162 135 138 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $370 r0 *1 1.38,8.16
X$370 111 150 111 178 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $372 r0 *1 5.98,8.16
X$372 70 125 75 98 167 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $377 r0 *1 15.64,8.16
X$377 111 94 93 151 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $378 r0 *1 17.94,8.16
X$378 111 116 152 191 153 142 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $379 r0 *1 20.24,8.16
X$379 70 125 180 98 170 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $380 r0 *1 29.44,8.16
X$380 111 73 180 155 101 70 195 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $381 r0 *1 31.74,8.16
X$381 70 125 155 173 172 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $382 r0 *1 40.94,8.16
X$382 111 113 174 175 70 111 102 70 sky130_fd_sc_hd__a21oi_1
* cell instance $387 r0 *1 43.24,8.16
X$387 111 184 111 156 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $388 r0 *1 46.92,8.16
X$388 111 185 176 197 157 184 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $389 r0 *1 49.22,8.16
X$389 111 101 111 70 197 70 sky130_fd_sc_hd__inv_1
* cell instance $390 r0 *1 53.36,8.16
X$390 111 122 130 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $391 r0 *1 54.74,8.16
X$391 111 105 157 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $393 r0 *1 61.18,8.16
X$393 111 78 159 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $395 r0 *1 64.86,8.16
X$395 111 194 131 111 143 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $401 r0 *1 70.84,8.16
X$401 70 125 161 135 169 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $402 r0 *1 80.04,8.16
X$402 70 125 163 135 187 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $403 r0 *1 89.24,8.16
X$403 70 188 216 162 163 161 111 111 70 sky130_fd_sc_hd__nor4_2
* cell instance $405 r0 *1 94.76,8.16
X$405 111 166 190 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $406 m0 *1 1.38,13.6
X$406 70 178 125 111 111 70 sky130_fd_sc_hd__buf_16
* cell instance $407 m0 *1 11.5,13.6
X$407 111 201 79 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $409 m0 *1 16.56,13.6
X$409 111 75 100 74 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $410 m0 *1 17.94,13.6
X$410 111 180 111 70 191 70 sky130_fd_sc_hd__inv_1
* cell instance $411 m0 *1 19.32,13.6
X$411 111 203 202 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $412 m0 *1 22.08,13.6
X$412 111 181 153 152 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $413 m0 *1 24.38,13.6
X$413 111 217 182 193 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $415 m0 *1 29.44,13.6
X$415 70 125 73 173 145 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $417 m0 *1 39.1,13.6
X$417 111 127 183 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $418 m0 *1 40.48,13.6
X$418 70 125 101 206 156 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $419 m0 *1 49.68,13.6
X$419 111 123 82 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $421 m0 *1 57.04,13.6
X$421 111 76 139 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $422 m0 *1 58.42,13.6
X$422 70 125 194 206 131 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $423 m0 *1 69,13.6
X$423 111 162 164 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $424 m0 *1 70.38,13.6
X$424 111 162 111 70 72 70 sky130_fd_sc_hd__inv_1
* cell instance $425 m0 *1 71.76,13.6
X$425 111 209 210 134 192 136 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $427 m0 *1 75.44,13.6
X$427 111 218 141 111 114 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $428 m0 *1 78.66,13.6
X$428 111 112 111 187 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $429 m0 *1 82.34,13.6
X$429 111 161 111 70 84 70 sky130_fd_sc_hd__inv_1
* cell instance $432 m0 *1 84.64,13.6
X$432 70 125 216 135 212 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $433 m0 *1 93.84,13.6
X$433 111 214 111 70 86 70 sky130_fd_sc_hd__inv_1
* cell instance $435 r0 *1 1.38,13.6
X$435 111 200 111 253 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $436 r0 *1 5.06,13.6
X$436 111 237 252 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $438 r0 *1 6.9,13.6
X$438 111 254 222 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $439 r0 *1 11.04,13.6
X$439 111 238 110 244 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $440 r0 *1 12.42,13.6
X$440 111 222 257 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $441 r0 *1 13.8,13.6
X$441 111 223 215 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $445 r0 *1 19.32,13.6
X$445 111 155 111 70 174 70 sky130_fd_sc_hd__inv_1
* cell instance $446 r0 *1 20.7,13.6
X$446 111 95 153 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $448 r0 *1 23.92,13.6
X$448 111 154 182 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $449 r0 *1 25.3,13.6
X$449 111 240 204 224 70 111 259 70 sky130_fd_sc_hd__a21boi_0
* cell instance $450 r0 *1 28.06,13.6
X$450 111 204 224 280 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $452 r0 *1 38.18,13.6
X$452 111 226 111 70 148 70 sky130_fd_sc_hd__inv_1
* cell instance $456 r0 *1 43.24,13.6
X$456 111 227 196 242 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $458 r0 *1 45.08,13.6
X$458 111 242 207 227 228 111 185 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $459 r0 *1 47.84,13.6
X$459 111 196 241 208 70 111 228 70 sky130_fd_sc_hd__a21boi_0
* cell instance $461 r0 *1 51.06,13.6
X$461 111 208 241 207 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $464 r0 *1 64.86,13.6
X$464 111 239 318 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $465 r0 *1 66.24,13.6
X$465 111 186 111 70 219 70 sky130_fd_sc_hd__inv_1
* cell instance $466 r0 *1 67.62,13.6
X$466 111 109 263 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $469 r0 *1 70.84,13.6
X$469 70 125 218 135 141 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $470 r0 *1 80.04,13.6
X$470 111 163 111 70 168 70 sky130_fd_sc_hd__inv_1
* cell instance $472 r0 *1 82.34,13.6
X$472 111 234 211 233 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $473 r0 *1 84.64,13.6
X$473 111 232 233 231 211 229 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $474 r0 *1 86.94,13.6
X$474 111 229 111 212 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $476 r0 *1 91.08,13.6
X$476 111 165 111 248 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $477 r0 *1 94.76,13.6
X$477 111 251 88 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $484 m0 *1 1.38,19.04
X$484 111 274 276 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $485 m0 *1 2.76,19.04
X$485 111 341 237 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $486 m0 *1 4.14,19.04
X$486 111 266 111 254 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $488 m0 *1 8.28,19.04
X$488 111 222 243 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $489 m0 *1 9.66,19.04
X$489 70 125 245 98 222 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $490 m0 *1 18.86,19.04
X$490 70 125 246 98 245 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $493 m0 *1 29.44,19.04
X$493 111 282 280 246 259 111 205 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $494 m0 *1 32.2,19.04
X$494 111 246 240 282 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $495 m0 *1 33.58,19.04
X$495 111 71 225 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $497 m0 *1 35.42,19.04
X$497 70 125 227 173 295 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $498 m0 *1 44.62,19.04
X$498 70 125 241 173 227 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $499 m0 *1 55.2,19.04
X$499 111 281 270 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $502 m0 *1 57.5,19.04
X$502 111 290 265 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $503 m0 *1 58.88,19.04
X$503 111 255 235 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $504 m0 *1 60.26,19.04
X$504 111 268 264 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $505 m0 *1 61.64,19.04
X$505 111 264 111 70 279 70 sky130_fd_sc_hd__inv_1
* cell instance $506 m0 *1 63.02,19.04
X$506 70 125 141 206 261 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $507 m0 *1 72.22,19.04
X$507 111 115 107 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $509 m0 *1 74.06,19.04
X$509 111 247 260 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $510 m0 *1 75.44,19.04
X$510 111 248 278 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $511 m0 *1 76.82,19.04
X$511 111 269 256 249 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $512 m0 *1 78.2,19.04
X$512 111 260 189 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $513 m0 *1 79.58,19.04
X$513 111 250 258 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $514 m0 *1 80.96,19.04
X$514 111 247 273 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $515 m0 *1 82.34,19.04
X$515 111 265 251 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $518 m0 *1 84.64,19.04
X$518 111 213 234 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $519 m0 *1 86.02,19.04
X$519 111 249 309 269 271 111 232 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $521 m0 *1 89.7,19.04
X$521 111 256 292 275 70 111 271 70 sky130_fd_sc_hd__a21boi_0
* cell instance $522 m0 *1 92.46,19.04
X$522 111 137 111 255 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $524 r0 *1 1.84,19.04
X$524 70 125 310 98 238 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $525 r0 *1 11.04,19.04
X$525 111 244 293 238 283 111 311 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $526 r0 *1 13.8,19.04
X$526 111 267 312 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $531 r0 *1 15.64,19.04
X$531 111 257 220 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $532 r0 *1 17.02,19.04
X$532 111 286 284 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $533 r0 *1 18.4,19.04
X$533 111 285 277 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $534 r0 *1 21.16,19.04
X$534 111 285 314 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $536 r0 *1 24.38,19.04
X$536 70 125 224 173 246 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $537 r0 *1 33.58,19.04
X$537 70 125 295 173 71 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $544 r0 *1 48.76,19.04
X$544 111 216 111 70 231 70 sky130_fd_sc_hd__inv_1
* cell instance $545 r0 *1 50.14,19.04
X$545 70 125 287 206 128 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $546 r0 *1 59.34,19.04
X$546 70 125 131 206 287 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $551 r0 *1 69,19.04
X$551 111 265 322 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $553 r0 *1 70.84,19.04
X$553 70 125 315 135 265 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $555 r0 *1 80.5,19.04
X$555 111 294 288 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $556 r0 *1 81.88,19.04
X$556 70 125 275 135 269 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $557 r0 *1 91.08,19.04
X$557 111 291 289 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $558 r0 *1 92.46,19.04
X$558 111 323 111 290 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $559 m0 *1 1.38,24.48
X$559 111 325 324 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $560 m0 *1 2.76,24.48
X$560 111 327 297 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $562 m0 *1 4.6,24.48
X$562 111 316 306 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $563 m0 *1 5.98,24.48
X$563 111 299 298 328 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $564 m0 *1 7.36,24.48
X$564 70 125 313 98 285 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $565 m0 *1 16.56,24.48
X$565 70 125 238 98 313 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $566 m0 *1 25.76,24.48
X$566 111 317 177 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $567 m0 *1 27.14,24.48
X$567 111 99 201 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $570 m0 *1 29.44,24.48
X$570 111 80 203 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $571 m0 *1 30.82,24.48
X$571 111 253 285 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $572 m0 *1 32.2,24.48
X$572 111 286 236 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $573 m0 *1 33.58,24.48
X$573 111 99 97 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $575 m0 *1 35.42,24.48
X$575 111 173 111 70 70 sky130_fd_sc_hd__clkinv_2
* cell instance $577 m0 *1 37.72,24.48
X$577 70 125 333 173 147 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $580 m0 *1 51.52,24.48
X$580 111 300 111 70 209 70 sky130_fd_sc_hd__inv_1
* cell instance $582 m0 *1 53.82,24.48
X$582 111 301 292 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $584 m0 *1 57.04,24.48
X$584 70 352 206 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $585 m0 *1 66.24,24.48
X$585 70 125 332 206 119 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $587 m0 *1 75.9,24.48
X$587 111 331 320 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $588 m0 *1 77.28,24.48
X$588 111 372 303 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $589 m0 *1 78.66,24.48
X$589 111 292 275 309 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $590 m0 *1 80.96,24.48
X$590 111 302 330 304 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $592 m0 *1 84.64,24.48
X$592 111 321 302 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $594 m0 *1 86.48,24.48
X$594 111 303 319 305 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $595 m0 *1 89.7,24.48
X$595 111 329 308 305 258 371 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $596 m0 *1 92.46,24.48
X$596 111 279 307 304 270 326 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $599 r0 *1 1.84,24.48
X$599 111 221 335 342 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $601 r0 *1 4.6,24.48
X$601 111 110 312 310 70 111 283 70 sky130_fd_sc_hd__a21boi_0
* cell instance $602 r0 *1 7.36,24.48
X$602 111 276 338 339 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $603 r0 *1 9.66,24.48
X$603 111 312 310 293 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $604 r0 *1 11.96,24.48
X$604 111 237 317 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $605 r0 *1 13.34,24.48
X$605 111 337 338 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $611 r0 *1 15.64,24.48
X$611 111 98 111 70 70 sky130_fd_sc_hd__clkinv_2
* cell instance $612 r0 *1 17.48,24.48
X$612 111 334 298 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $613 r0 *1 18.86,24.48
X$613 111 314 296 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $614 r0 *1 24.38,24.48
X$614 70 125 348 173 203 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $615 r0 *1 33.58,24.48
X$615 70 352 173 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $620 r0 *1 43.24,24.48
X$620 111 333 147 111 146 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $622 r0 *1 47.38,24.48
X$622 70 125 350 206 82 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $623 r0 *1 56.58,24.48
X$623 70 206 111 111 70 sky130_fd_sc_hd__bufinv_16
* cell instance $624 r0 *1 67.62,24.48
X$624 111 331 111 70 349 70 sky130_fd_sc_hd__inv_1
* cell instance $628 r0 *1 69,24.48
X$628 111 318 111 70 329 70 sky130_fd_sc_hd__inv_1
* cell instance $631 r0 *1 71.3,24.48
X$631 111 340 347 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $632 r0 *1 72.68,24.48
X$632 70 125 384 135 319 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $633 r0 *1 81.88,24.48
X$633 70 125 269 135 315 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $634 r0 *1 91.08,24.48
X$634 111 343 111 70 344 70 sky130_fd_sc_hd__inv_1
* cell instance $635 r0 *1 92.46,24.48
X$635 111 373 111 340 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $637 m0 *1 2.3,29.92
X$637 111 356 111 341 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $638 m0 *1 5.98,29.92
X$638 111 223 111 70 358 70 sky130_fd_sc_hd__inv_1
* cell instance $639 m0 *1 7.36,29.92
X$639 111 359 336 363 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $640 m0 *1 9.66,29.92
X$640 111 346 111 345 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $641 m0 *1 13.34,29.92
X$641 111 311 339 362 338 346 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $643 m0 *1 16.56,29.92
X$643 70 352 98 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $644 m0 *1 25.76,29.92
X$644 111 90 99 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $645 m0 *1 27.14,29.92
X$645 111 149 336 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $651 m0 *1 32.66,29.92
X$651 70 125 147 173 348 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $652 m0 *1 41.86,29.92
X$652 111 262 183 381 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $660 m0 *1 57.96,29.92
X$660 70 125 119 354 350 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $662 m0 *1 69.46,29.92
X$662 111 272 256 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $663 m0 *1 70.84,29.92
X$663 111 332 119 111 210 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $665 m0 *1 74.98,29.92
X$665 70 352 135 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $667 m0 *1 84.64,29.92
X$667 70 125 331 135 361 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $668 m0 *1 93.84,29.92
X$668 111 347 349 326 70 111 360 70 sky130_fd_sc_hd__a21oi_1
* cell instance $671 r0 *1 2.3,29.92
X$671 111 351 111 337 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $672 r0 *1 5.98,29.92
X$672 70 125 316 367 345 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $677 r0 *1 15.64,29.92
X$677 111 316 111 70 362 70 sky130_fd_sc_hd__inv_1
* cell instance $678 r0 *1 17.02,29.92
X$678 70 125 335 369 299 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $682 r0 *1 31.28,29.92
X$682 70 125 179 369 380 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $683 r0 *1 40.48,29.92
X$683 111 353 381 379 183 377 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $688 r0 *1 43.24,29.92
X$688 111 364 198 405 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $689 r0 *1 44.62,29.92
X$689 111 198 158 365 70 111 383 70 sky130_fd_sc_hd__a21boi_0
* cell instance $691 r0 *1 51.06,29.92
X$691 70 125 385 354 130 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $693 r0 *1 61.18,29.92
X$693 70 125 355 135 247 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $698 r0 *1 70.84,29.92
X$698 70 125 319 135 355 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $699 r0 *1 80.04,29.92
X$699 111 384 319 111 308 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $700 r0 *1 83.26,29.92
X$700 111 378 330 111 307 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $702 r0 *1 86.94,29.92
X$702 111 376 111 375 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $703 r0 *1 90.62,29.92
X$703 111 360 111 361 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $704 r0 *1 94.3,29.92
X$704 111 357 111 70 374 70 sky130_fd_sc_hd__inv_1
* cell instance $706 m0 *1 1.38,35.36
X$706 111 298 335 221 70 111 366 70 sky130_fd_sc_hd__a21boi_0
* cell instance $708 m0 *1 4.6,35.36
X$708 111 328 342 299 366 111 368 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $709 m0 *1 7.36,35.36
X$709 70 352 367 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $710 m0 *1 16.56,35.36
X$710 70 125 392 367 237 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $718 m0 *1 32.66,35.36
X$718 111 179 111 70 379 70 sky130_fd_sc_hd__inv_1
* cell instance $719 m0 *1 34.04,35.36
X$719 111 369 111 70 70 sky130_fd_sc_hd__clkinvlp_4
* cell instance $721 m0 *1 37.26,35.36
X$721 111 377 111 380 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $723 m0 *1 41.4,35.36
X$723 70 125 365 369 364 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $726 m0 *1 53.36,35.36
X$726 111 354 70 111 70 sky130_fd_sc_hd__clkinv_4
* cell instance $728 m0 *1 57.04,35.36
X$728 70 352 354 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $731 m0 *1 71.76,35.36
X$731 111 166 111 70 370 70 sky130_fd_sc_hd__inv_1
* cell instance $732 m0 *1 73.14,35.36
X$732 70 125 378 390 330 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $734 m0 *1 82.8,35.36
X$734 111 294 111 70 382 70 sky130_fd_sc_hd__inv_1
* cell instance $736 m0 *1 84.64,35.36
X$736 111 278 370 371 70 111 376 70 sky130_fd_sc_hd__a21oi_1
* cell instance $738 m0 *1 86.94,35.36
X$738 70 125 166 390 375 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $739 r0 *1 1.38,35.36
X$739 111 394 400 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $740 r0 *1 2.76,35.36
X$740 111 386 111 402 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $741 r0 *1 6.44,35.36
X$741 111 324 387 297 70 111 401 70 sky130_fd_sc_hd__a21boi_0
* cell instance $743 r0 *1 10.12,35.36
X$743 111 397 111 415 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $744 r0 *1 13.8,35.36
X$744 111 396 111 70 388 70 sky130_fd_sc_hd__inv_1
* cell instance $749 r0 *1 15.64,35.36
X$749 111 367 70 111 70 sky130_fd_sc_hd__clkinv_4
* cell instance $750 r0 *1 18.86,35.36
X$750 111 223 316 179 396 70 504 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $751 r0 *1 21.16,35.36
X$751 111 368 363 388 336 397 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $752 r0 *1 23.46,35.36
X$752 70 125 299 369 392 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $754 r0 *1 33.58,35.36
X$754 70 352 369 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $759 r0 *1 43.24,35.36
X$759 111 405 389 364 383 111 353 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $760 r0 *1 46,35.36
X$760 111 158 365 389 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $763 r0 *1 50.6,35.36
X$763 70 125 404 354 78 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $764 r0 *1 59.8,35.36
X$764 70 125 330 354 385 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $773 r0 *1 73.14,35.36
X$773 111 216 230 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $774 r0 *1 74.52,35.36
X$774 111 390 111 70 70 sky130_fd_sc_hd__clkinvlp_4
* cell instance $775 r0 *1 77.28,35.36
X$775 70 352 390 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $776 r0 *1 86.48,35.36
X$776 70 125 294 390 414 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $779 m0 *1 1.84,40.8
X$779 111 411 439 395 401 111 443 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $780 m0 *1 4.6,40.8
X$780 111 407 111 408 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $781 m0 *1 8.28,40.8
X$781 111 396 393 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $782 m0 *1 9.66,40.8
X$782 70 125 396 367 415 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $784 m0 *1 19.78,40.8
X$784 70 125 387 369 395 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $790 m0 *1 36.34,40.8
X$790 70 125 364 369 419 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $796 m0 *1 60.72,40.8
X$796 70 125 398 354 404 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $798 m0 *1 70.38,40.8
X$798 70 125 420 390 398 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $799 m0 *1 79.58,40.8
X$799 111 420 398 111 403 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $800 m0 *1 82.8,40.8
X$800 111 418 417 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $802 m0 *1 84.64,40.8
X$802 111 263 398 416 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $803 m0 *1 87.86,40.8
X$803 111 391 111 413 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $804 m0 *1 91.54,40.8
X$804 70 247 413 111 111 70 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $805 r0 *1 1.38,40.8
X$805 70 286 422 111 111 70 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $806 r0 *1 5.98,40.8
X$806 70 125 223 367 434 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $809 r0 *1 15.64,40.8
X$809 111 408 428 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $810 r0 *1 17.02,40.8
X$810 111 402 359 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $812 r0 *1 18.86,40.8
X$812 70 125 395 367 435 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $826 r0 *1 61.18,40.8
X$826 70 125 436 354 418 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $831 r0 *1 78.2,40.8
X$831 111 412 418 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $832 r0 *1 79.58,40.8
X$832 111 418 424 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $833 r0 *1 80.96,40.8
X$833 111 399 343 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $834 r0 *1 82.34,40.8
X$834 111 357 410 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $835 r0 *1 83.72,40.8
X$835 111 235 382 409 70 111 423 70 sky130_fd_sc_hd__a21oi_1
* cell instance $836 r0 *1 85.56,40.8
X$836 111 344 403 416 289 409 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $837 r0 *1 88.32,40.8
X$837 111 423 111 414 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $839 r0 *1 92.46,40.8
X$839 111 425 111 412 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $846 m0 *1 1.38,46.24
X$846 111 406 111 422 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $848 m0 *1 5.52,46.24
X$848 111 395 324 411 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $849 m0 *1 6.9,46.24
X$849 111 427 111 434 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $850 m0 *1 10.58,46.24
X$850 111 429 428 447 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $852 m0 *1 13.8,46.24
X$852 70 125 435 367 286 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $857 m0 *1 29.44,46.24
X$857 70 125 419 369 394 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $870 m0 *1 68.54,46.24
X$870 70 125 430 390 436 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $872 m0 *1 78.66,46.24
X$872 111 437 445 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $873 m0 *1 80.04,46.24
X$873 111 453 446 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $874 m0 *1 81.42,46.24
X$874 111 431 451 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $875 m0 *1 82.8,46.24
X$875 111 417 433 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $877 m0 *1 84.64,46.24
X$877 70 125 357 390 432 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $878 m0 *1 93.84,46.24
X$878 111 294 331 166 357 70 444 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $879 r0 *1 1.38,46.24
X$879 111 438 111 440 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $881 r0 *1 5.52,46.24
X$881 111 443 447 358 428 427 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $882 r0 *1 7.82,46.24
X$882 111 297 387 439 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $883 r0 *1 10.12,46.24
X$883 111 421 429 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $884 r0 *1 11.5,46.24
X$884 111 394 441 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $885 r0 *1 12.88,46.24
X$885 111 441 426 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $889 r0 *1 15.64,46.24
X$889 111 440 394 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $912 r0 *1 72.22,46.24
X$912 70 125 459 390 430 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $914 r0 *1 81.88,46.24
X$914 111 459 430 111 452 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $915 r0 *1 85.1,46.24
X$915 111 446 111 70 454 70 sky130_fd_sc_hd__inv_1
* cell instance $916 r0 *1 86.48,46.24
X$916 111 458 111 70 457 70 sky130_fd_sc_hd__inv_1
* cell instance $917 r0 *1 87.86,46.24
X$917 111 455 111 432 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $919 r0 *1 92.46,46.24
X$919 111 442 111 437 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $926 m0 *1 1.38,51.68
X$926 111 461 448 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $927 m0 *1 2.76,51.68
X$927 111 456 111 70 477 70 sky130_fd_sc_hd__inv_1
* cell instance $928 m0 *1 4.14,51.68
X$928 111 477 450 468 488 478 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $929 m0 *1 6.9,51.68
X$929 111 461 469 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $930 m0 *1 8.28,51.68
X$930 111 469 449 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $932 m0 *1 10.58,51.68
X$932 70 125 466 470 461 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $933 m0 *1 19.78,51.68
X$933 70 125 480 470 466 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $941 m0 *1 45.54,51.68
X$941 70 493 352 111 111 70 sky130_fd_sc_hd__clkbuf_8
* cell instance $949 m0 *1 64.86,51.68
X$949 70 125 496 465 472 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $952 m0 *1 81.42,51.68
X$952 111 462 463 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $953 m0 *1 82.8,51.68
X$953 111 476 479 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $956 m0 *1 85.56,51.68
X$956 111 451 430 474 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $958 m0 *1 89.24,51.68
X$958 111 445 374 473 70 111 455 70 sky130_fd_sc_hd__a21oi_1
* cell instance $960 m0 *1 91.54,51.68
X$960 111 454 452 474 463 475 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $961 m0 *1 94.3,51.68
X$961 111 464 572 475 70 111 515 70 sky130_fd_sc_hd__a21oi_1
* cell instance $962 r0 *1 1.38,51.68
X$962 111 460 111 483 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $963 r0 *1 5.06,51.68
X$963 111 467 488 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $965 r0 *1 7.36,51.68
X$965 111 489 480 468 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $966 r0 *1 10.58,51.68
X$966 111 483 461 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $967 r0 *1 11.96,51.68
X$967 111 471 503 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $973 r0 *1 18.4,51.68
X$973 111 484 480 111 450 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $977 r0 *1 24.84,51.68
X$977 70 125 484 491 480 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $988 r0 *1 55.2,51.68
X$988 70 125 472 494 495 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $995 r0 *1 74.52,51.68
X$995 111 496 472 111 506 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $997 r0 *1 78.66,51.68
X$997 111 485 472 492 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $998 r0 *1 81.88,51.68
X$998 70 125 558 465 490 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $999 r0 *1 91.08,51.68
X$999 70 778 444 188 486 111 481 111 70 sky130_fd_sc_hd__nand4_2
* cell instance $1008 m0 *1 2.3,57.12
X$1008 111 516 517 478 70 111 509 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1009 m0 *1 4.14,57.12
X$1009 70 125 505 470 498 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1010 m0 *1 13.34,57.12
X$1010 111 499 497 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1012 m0 *1 15.64,57.12
X$1012 70 125 520 470 505 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1014 m0 *1 26.68,57.12
X$1014 111 195 510 519 504 111 500 70 70 sky130_fd_sc_hd__nand4_1
* cell instance $1016 m0 *1 29.44,57.12
X$1016 111 500 481 499 70 111 70 sky130_fd_sc_hd__or2_0
* cell instance $1023 m0 *1 46,57.12
X$1023 70 125 495 494 752 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1029 m0 *1 61.18,57.12
X$1029 70 125 511 494 528 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1032 m0 *1 74.98,57.12
X$1032 70 125 518 465 511 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1035 m0 *1 85.1,57.12
X$1035 111 457 506 492 479 473 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1036 m0 *1 87.86,57.12
X$1036 111 515 111 490 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1038 m0 *1 92.46,57.12
X$1038 111 487 111 514 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1040 r0 *1 2.3,57.12
X$1040 111 507 111 539 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1041 r0 *1 5.98,57.12
X$1041 70 125 544 470 538 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1045 r0 *1 16.56,57.12
X$1045 70 125 532 470 520 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1049 r0 *1 33.58,57.12
X$1049 70 125 548 491 549 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1056 r0 *1 52.9,57.12
X$1056 70 125 528 494 521 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1064 r0 *1 75.44,57.12
X$1064 111 522 546 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1065 r0 *1 76.82,57.12
X$1065 111 527 545 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1066 r0 *1 78.2,57.12
X$1066 111 523 642 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1067 r0 *1 79.58,57.12
X$1067 111 526 111 70 525 70 sky130_fd_sc_hd__inv_1
* cell instance $1068 r0 *1 80.96,57.12
X$1068 111 502 458 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1069 r0 *1 82.34,57.12
X$1069 111 542 111 543 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1070 r0 *1 86.02,57.12
X$1070 111 518 511 111 540 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1071 r0 *1 89.24,57.12
X$1071 111 524 540 535 688 534 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1073 r0 *1 92.46,57.12
X$1073 111 560 511 535 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1081 m0 *1 1.38,62.56
X$1081 111 482 489 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1082 m0 *1 2.76,62.56
X$1082 111 559 566 531 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1083 m0 *1 5.98,62.56
X$1083 111 509 111 538 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1085 m0 *1 10.12,62.56
X$1085 111 532 520 111 541 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1086 m0 *1 13.34,62.56
X$1086 70 352 470 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1087 m0 *1 22.54,62.56
X$1087 111 498 471 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1088 m0 *1 23.92,62.56
X$1088 111 533 498 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1089 m0 *1 25.3,62.56
X$1089 111 552 562 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1093 m0 *1 29.44,62.56
X$1093 70 125 549 491 563 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1094 m0 *1 38.64,62.56
X$1094 70 125 565 491 548 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1105 m0 *1 72.22,62.56
X$1105 111 553 547 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1106 m0 *1 73.6,62.56
X$1106 111 554 564 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1107 m0 *1 74.98,62.56
X$1107 70 125 526 465 543 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1109 m0 *1 84.64,62.56
X$1109 70 125 501 465 561 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1110 m0 *1 93.84,62.56
X$1110 111 558 501 526 557 70 486 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $1112 r0 *1 1.84,62.56
X$1112 111 551 111 533 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1113 r0 *1 5.52,62.56
X$1113 111 539 516 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1114 r0 *1 6.9,62.56
X$1114 111 590 520 588 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1115 r0 *1 10.12,62.56
X$1115 111 544 508 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1117 r0 *1 11.96,62.56
X$1117 111 581 566 111 592 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1120 r0 *1 15.64,62.56
X$1120 111 544 111 70 517 70 sky130_fd_sc_hd__inv_1
* cell instance $1122 r0 *1 17.94,62.56
X$1122 70 125 581 491 566 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1123 r0 *1 27.14,62.56
X$1123 111 573 111 70 595 70 sky130_fd_sc_hd__inv_1
* cell instance $1124 r0 *1 28.52,62.56
X$1124 111 584 598 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1126 r0 *1 30.36,62.56
X$1126 111 491 70 111 70 sky130_fd_sc_hd__clkinv_4
* cell instance $1127 r0 *1 33.58,62.56
X$1127 70 352 491 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1130 r0 *1 43.24,62.56
X$1130 111 565 548 111 599 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1133 r0 *1 47.84,62.56
X$1133 70 125 567 494 577 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1134 r0 *1 57.04,62.56
X$1134 70 125 596 494 567 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1137 r0 *1 67.62,62.56
X$1137 111 576 660 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1139 r0 *1 69,62.56
X$1139 111 571 585 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1141 r0 *1 70.84,62.56
X$1141 111 575 111 70 574 70 sky130_fd_sc_hd__inv_1
* cell instance $1142 r0 *1 72.22,62.56
X$1142 111 569 568 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1143 r0 *1 73.6,62.56
X$1143 111 570 111 70 524 70 sky130_fd_sc_hd__inv_1
* cell instance $1144 r0 *1 74.98,62.56
X$1144 111 555 485 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1145 r0 *1 76.36,62.56
X$1145 70 465 111 111 70 sky130_fd_sc_hd__bufinv_16
* cell instance $1146 r0 *1 87.4,62.56
X$1146 111 568 525 534 70 111 542 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1147 r0 *1 89.24,62.56
X$1147 111 514 464 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1148 r0 *1 90.62,62.56
X$1148 111 558 111 70 572 70 sky130_fd_sc_hd__inv_1
* cell instance $1150 r0 *1 92.46,62.56
X$1150 111 537 111 569 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1157 m0 *1 1.38,68
X$1157 111 498 530 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1158 m0 *1 2.76,68
X$1158 70 125 591 470 609 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1159 m0 *1 11.96,68
X$1159 111 529 580 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1160 m0 *1 13.34,68
X$1160 70 470 111 111 70 sky130_fd_sc_hd__bufinv_16
* cell instance $1161 m0 *1 24.38,68
X$1161 111 550 573 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1162 m0 *1 25.76,68
X$1162 111 602 603 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1163 m0 *1 27.14,68
X$1163 111 621 604 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1166 m0 *1 29.44,68
X$1166 111 584 583 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1167 m0 *1 30.82,68
X$1167 111 563 602 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1168 m0 *1 32.2,68
X$1168 111 583 597 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1169 m0 *1 33.58,68
X$1169 111 604 582 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1172 m0 *1 37.26,68
X$1172 70 125 614 491 613 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1176 m0 *1 52.44,68
X$1176 111 494 111 70 70 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1183 m0 *1 63.02,68
X$1183 70 125 649 658 596 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1184 m0 *1 72.22,68
X$1184 70 125 593 465 594 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1185 m0 *1 81.42,68
X$1185 111 623 611 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1186 m0 *1 82.8,68
X$1186 111 526 536 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1188 m0 *1 84.64,68
X$1188 70 125 557 465 610 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1189 m0 *1 93.84,68
X$1189 111 585 605 644 70 111 589 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1192 r0 *1 1.84,68
X$1192 111 595 541 588 580 624 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1193 r0 *1 4.6,68
X$1193 111 626 111 609 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1194 r0 *1 8.28,68
X$1194 111 579 111 617 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1195 r0 *1 11.96,68
X$1195 111 654 592 531 618 628 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1201 r0 *1 15.64,68
X$1201 111 591 552 612 544 70 519 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $1202 r0 *1 17.94,68
X$1202 70 125 566 630 629 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1203 r0 *1 27.14,68
X$1203 111 621 620 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1204 r0 *1 28.52,68
X$1204 111 635 637 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1206 r0 *1 30.36,68
X$1206 70 125 613 638 619 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1214 r0 *1 43.24,68
X$1214 70 125 634 638 636 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1215 r0 *1 52.44,68
X$1215 70 352 494 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1217 r0 *1 62.56,68
X$1217 111 632 633 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1218 r0 *1 63.94,68
X$1218 111 501 586 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1219 r0 *1 65.32,68
X$1219 70 631 910 111 111 70 sky130_fd_sc_hd__clkbuf_8
* cell instance $1224 r0 *1 70.84,68
X$1224 70 125 594 465 606 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1225 r0 *1 80.04,68
X$1225 70 352 465 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1226 r0 *1 89.24,68
X$1226 111 646 111 561 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1227 r0 *1 92.92,68
X$1227 111 622 593 111 625 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1229 m0 *1 1.84,73.44
X$1229 70 563 666 111 111 70 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $1230 m0 *1 6.44,73.44
X$1230 70 125 629 470 647 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1231 m0 *1 15.64,73.44
X$1231 70 352 630 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1232 m0 *1 24.84,73.44
X$1232 111 671 584 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1233 m0 *1 26.22,73.44
X$1233 111 674 672 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1234 m0 *1 27.6,73.44
X$1234 111 612 640 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1236 m0 *1 29.44,73.44
X$1236 111 740 673 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1237 m0 *1 30.82,73.44
X$1237 111 616 621 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1239 m0 *1 33.12,73.44
X$1239 111 638 111 70 70 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1240 m0 *1 35.88,73.44
X$1240 70 352 638 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1241 m0 *1 45.08,73.44
X$1241 111 651 548 676 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1246 m0 *1 55.2,73.44
X$1246 111 641 645 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1248 m0 *1 57.04,73.44
X$1248 70 125 659 658 650 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1249 m0 *1 66.24,73.44
X$1249 111 557 111 70 605 70 sky130_fd_sc_hd__inv_1
* cell instance $1250 m0 *1 67.62,73.44
X$1250 111 501 111 70 661 70 sky130_fd_sc_hd__inv_1
* cell instance $1251 m0 *1 69,73.44
X$1251 111 649 596 111 648 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1252 m0 *1 72.22,73.44
X$1252 111 558 513 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1253 m0 *1 73.6,73.44
X$1253 70 352 631 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1254 m0 *1 82.8,73.44
X$1254 111 608 670 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1256 m0 *1 84.64,73.44
X$1256 111 642 596 669 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1257 m0 *1 87.86,73.44
X$1257 111 663 661 734 70 111 646 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1258 m0 *1 89.7,73.44
X$1258 111 589 111 610 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1259 m0 *1 93.38,73.44
X$1259 111 689 625 667 668 644 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1261 r0 *1 1.84,73.44
X$1261 111 811 653 628 70 111 626 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1262 r0 *1 3.68,73.44
X$1262 70 125 552 630 687 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1263 r0 *1 12.88,73.44
X$1263 111 591 111 70 653 70 sky130_fd_sc_hd__inv_1
* cell instance $1267 r0 *1 15.64,73.44
X$1267 111 630 911 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1268 r0 *1 17.02,73.44
X$1268 111 591 578 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1269 r0 *1 18.4,73.44
X$1269 111 647 692 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1271 r0 *1 20.24,73.44
X$1271 70 125 695 630 672 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1272 r0 *1 29.44,73.44
X$1272 70 125 612 638 696 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1273 r0 *1 38.64,73.44
X$1273 111 612 111 70 697 70 sky130_fd_sc_hd__inv_1
* cell instance $1274 r0 *1 40.02,73.44
X$1274 111 655 599 676 699 656 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1277 r0 *1 43.24,73.44
X$1277 111 675 697 656 70 111 698 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1278 r0 *1 45.08,73.44
X$1278 111 700 456 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1279 r0 *1 46.46,73.44
X$1279 111 637 111 70 654 70 sky130_fd_sc_hd__inv_1
* cell instance $1283 r0 *1 51.06,73.44
X$1283 111 657 627 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1284 r0 *1 52.44,73.44
X$1284 70 125 650 494 634 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1286 r0 *1 62.1,73.44
X$1286 111 659 650 111 701 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1287 r0 *1 65.32,73.44
X$1287 111 658 111 70 70 sky130_fd_sc_hd__clkinvlp_4
* cell instance $1290 r0 *1 69,73.44
X$1290 111 682 111 70 683 70 sky130_fd_sc_hd__inv_1
* cell instance $1292 r0 *1 70.84,73.44
X$1292 111 546 111 70 684 70 sky130_fd_sc_hd__inv_1
* cell instance $1293 r0 *1 72.22,73.44
X$1293 111 662 663 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1294 r0 *1 73.6,73.44
X$1294 70 125 622 631 593 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1296 r0 *1 83.26,73.44
X$1296 111 691 593 667 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1297 r0 *1 86.48,73.44
X$1297 111 664 111 690 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1298 r0 *1 90.16,73.44
X$1298 70 606 690 111 111 70 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $1299 r0 *1 94.76,73.44
X$1299 111 512 570 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1306 m0 *1 1.38,78.88
X$1306 111 652 111 666 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1308 m0 *1 5.52,78.88
X$1308 111 679 111 687 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1309 m0 *1 9.2,78.88
X$1309 111 615 111 705 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1310 m0 *1 12.88,78.88
X$1310 111 680 704 624 70 111 679 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1312 m0 *1 15.18,78.88
X$1312 70 125 707 630 693 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1313 m0 *1 24.38,78.88
X$1313 111 601 618 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1314 m0 *1 25.76,78.88
X$1314 111 761 680 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1315 m0 *1 27.14,78.88
X$1315 111 705 647 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1319 m0 *1 29.9,78.88
X$1319 70 125 710 638 695 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1320 m0 *1 39.1,78.88
X$1320 111 698 111 696 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1322 m0 *1 43.24,78.88
X$1322 70 125 721 638 614 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1323 m0 *1 52.44,78.88
X$1323 111 641 111 70 719 70 sky130_fd_sc_hd__inv_1
* cell instance $1324 m0 *1 53.82,78.88
X$1324 111 606 607 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1325 m0 *1 55.2,78.88
X$1325 111 681 702 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1328 m0 *1 57.5,78.88
X$1328 70 352 658 111 111 70 sky130_fd_sc_hd__clkbuf_16
* cell instance $1329 m0 *1 66.7,78.88
X$1329 70 125 717 631 711 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1330 m0 *1 75.9,78.88
X$1330 111 611 111 70 689 70 sky130_fd_sc_hd__inv_1
* cell instance $1331 m0 *1 77.28,78.88
X$1331 111 686 691 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1332 m0 *1 78.66,78.88
X$1332 111 712 716 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1333 m0 *1 80.04,78.88
X$1333 111 887 694 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1334 m0 *1 81.42,78.88
X$1334 111 684 648 669 670 757 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1336 m0 *1 84.64,78.88
X$1336 70 125 714 631 715 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1337 m0 *1 93.84,78.88
X$1337 111 556 688 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1340 r0 *1 2.3,78.88
X$1340 70 125 760 630 584 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1342 r0 *1 12.42,78.88
X$1342 111 723 724 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1343 r0 *1 13.8,78.88
X$1343 111 693 724 736 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $1347 r0 *1 16.1,78.88
X$1347 111 725 738 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1348 r0 *1 17.48,78.88
X$1348 111 736 706 693 726 111 815 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $1349 r0 *1 20.24,78.88
X$1349 111 724 708 707 70 111 726 70 sky130_fd_sc_hd__a21boi_0
* cell instance $1350 r0 *1 23,78.88
X$1350 111 708 707 706 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $1351 r0 *1 25.3,78.88
X$1351 111 768 590 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1352 r0 *1 26.68,78.88
X$1352 111 563 741 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1353 r0 *1 28.06,78.88
X$1353 111 727 739 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1355 r0 *1 29.9,78.88
X$1355 111 709 111 70 720 70 sky130_fd_sc_hd__inv_1
* cell instance $1357 r0 *1 31.74,78.88
X$1357 111 742 743 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1359 r0 *1 33.58,78.88
X$1359 70 125 750 638 710 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1364 r0 *1 44.62,78.88
X$1364 111 685 560 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1365 r0 *1 46,78.88
X$1365 111 721 614 111 746 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1366 r0 *1 49.22,78.88
X$1366 111 557 587 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1367 r0 *1 50.6,78.88
X$1367 111 576 111 70 718 70 sky130_fd_sc_hd__inv_1
* cell instance $1368 r0 *1 51.98,78.88
X$1368 70 125 729 658 745 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1369 r0 *1 61.18,78.88
X$1369 70 125 711 658 729 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1373 r0 *1 71.3,78.88
X$1373 70 125 713 631 564 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1374 r0 *1 80.5,78.88
X$1374 70 125 715 631 713 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1375 r0 *1 89.7,78.88
X$1375 111 735 733 812 627 734 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1376 r0 *1 92.46,78.88
X$1376 111 643 111 662 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1383 m0 *1 1.38,84.32
X$1383 111 600 559 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1384 m0 *1 2.76,84.32
X$1384 111 678 111 761 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1386 m0 *1 6.9,84.32
X$1386 111 552 111 70 704 70 sky130_fd_sc_hd__inv_1
* cell instance $1387 m0 *1 8.28,84.32
X$1387 111 692 677 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1388 m0 *1 9.66,84.32
X$1388 70 125 693 630 760 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1390 m0 *1 19.78,84.32
X$1390 70 125 747 630 737 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1392 m0 *1 29.44,84.32
X$1392 111 743 111 70 785 70 sky130_fd_sc_hd__inv_1
* cell instance $1393 m0 *1 30.82,84.32
X$1393 111 748 728 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1394 m0 *1 32.2,84.32
X$1394 111 762 675 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1395 m0 *1 33.58,84.32
X$1395 111 709 749 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1396 m0 *1 34.96,84.32
X$1396 111 748 111 70 764 70 sky130_fd_sc_hd__inv_1
* cell instance $1397 m0 *1 36.34,84.32
X$1397 111 750 710 111 766 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1399 m0 *1 40.48,84.32
X$1399 111 751 699 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1400 m0 *1 41.86,84.32
X$1400 111 765 790 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1401 m0 *1 43.24,84.32
X$1401 111 763 111 70 655 70 sky130_fd_sc_hd__inv_1
* cell instance $1402 m0 *1 44.62,84.32
X$1402 111 874 752 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1404 m0 *1 46.92,84.32
X$1404 111 665 668 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1405 m0 *1 48.3,84.32
X$1405 111 716 111 70 735 70 sky130_fd_sc_hd__inv_1
* cell instance $1406 m0 *1 49.68,84.32
X$1406 111 564 681 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1407 m0 *1 51.06,84.32
X$1407 111 777 758 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1408 m0 *1 52.44,84.32
X$1408 111 606 753 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1409 m0 *1 53.82,84.32
X$1409 111 754 798 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1410 m0 *1 55.2,84.32
X$1410 111 753 796 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1412 m0 *1 57.04,84.32
X$1412 111 521 786 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1413 m0 *1 58.42,84.32
X$1413 111 755 744 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1414 m0 *1 59.8,84.32
X$1414 111 820 795 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1416 m0 *1 62.1,84.32
X$1416 70 125 730 658 792 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1417 m0 *1 71.3,84.32
X$1417 70 125 783 631 730 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1418 m0 *1 80.5,84.32
X$1418 111 759 575 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1420 m0 *1 82.34,84.32
X$1420 111 758 718 757 70 111 756 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1423 m0 *1 85.56,84.32
X$1423 111 756 111 780 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1424 m0 *1 89.24,84.32
X$1424 111 714 715 111 733 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1425 m0 *1 92.46,84.32
X$1425 111 731 111 777 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1427 r0 *1 1.84,84.32
X$1427 111 703 111 671 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1428 r0 *1 5.52,84.32
X$1428 70 125 814 630 833 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1434 r0 *1 16.56,84.32
X$1434 111 672 725 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1435 r0 *1 17.94,84.32
X$1435 111 672 770 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1436 r0 *1 19.32,84.32
X$1436 111 747 111 70 818 70 sky130_fd_sc_hd__inv_1
* cell instance $1437 r0 *1 20.7,84.32
X$1437 111 816 111 737 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1438 r0 *1 24.38,84.32
X$1438 70 125 800 630 819 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1440 r0 *1 34.5,84.32
X$1440 111 790 710 870 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1442 r0 *1 38.64,84.32
X$1442 111 771 651 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1443 r0 *1 40.02,84.32
X$1443 111 791 763 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1444 r0 *1 41.4,84.32
X$1444 111 772 111 70 773 70 sky130_fd_sc_hd__inv_1
* cell instance $1449 r0 *1 43.7,84.32
X$1449 111 841 614 774 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1450 r0 *1 46.92,84.32
X$1450 111 773 746 774 744 876 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1451 r0 *1 49.68,84.32
X$1451 111 877 843 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1453 r0 *1 51.52,84.32
X$1453 111 564 804 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1454 r0 *1 52.9,84.32
X$1454 111 808 806 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1455 r0 *1 54.28,84.32
X$1455 111 682 797 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1456 r0 *1 55.66,84.32
X$1456 111 775 793 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1457 r0 *1 57.04,84.32
X$1457 70 125 792 658 794 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1459 r0 *1 67.16,84.32
X$1459 111 788 711 789 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1463 r0 *1 70.84,84.32
X$1463 111 717 711 111 817 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1464 r0 *1 74.06,84.32
X$1464 111 865 787 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1465 r0 *1 75.44,84.32
X$1465 111 784 788 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1466 r0 *1 76.82,84.32
X$1466 111 786 908 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1467 r0 *1 78.2,84.32
X$1467 111 783 730 111 813 70 70 sky130_fd_sc_hd__xor2_1
* cell instance $1468 r0 *1 81.42,84.32
X$1468 111 776 779 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1469 r0 *1 82.8,84.32
X$1469 111 781 782 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1470 r0 *1 84.18,84.32
X$1470 70 125 576 631 780 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1471 r0 *1 93.38,84.32
X$1471 111 576 682 641 807 70 778 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $1476 m0 *1 1.38,89.76
X$1476 111 617 811 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1477 m0 *1 2.76,89.76
X$1477 111 767 111 616 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1479 m0 *1 6.9,89.76
X$1479 111 769 799 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1480 m0 *1 8.28,89.76
X$1480 111 814 673 824 70 111 70 sky130_fd_sc_hd__nor2_1
* cell instance $1481 m0 *1 9.66,89.76
X$1481 70 125 826 630 814 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1482 m0 *1 18.86,89.76
X$1482 111 800 111 70 828 70 sky130_fd_sc_hd__inv_1
* cell instance $1483 m0 *1 20.24,89.76
X$1483 111 815 835 818 801 816 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $1485 m0 *1 23,89.76
X$1485 111 802 836 828 829 803 70 111 70 sky130_fd_sc_hd__o22ai_1
* cell instance $1486 m0 *1 25.3,89.76
X$1486 111 803 111 819 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1489 m0 *1 30.36,89.76
X$1489 70 125 709 638 838 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1490 m0 *1 39.56,89.76
X$1490 70 125 748 658 821 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1492 m0 *1 49.22,89.76
X$1492 111 845 577 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1493 m0 *1 50.6,89.76
X$1493 111 752 844 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1495 m0 *1 52.44,89.76
X$1495 111 636 822 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1496 m0 *1 53.82,89.76
X$1496 111 849 846 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1497 m0 *1 55.2,89.76
X$1497 111 521 847 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1500 m0 *1 57.5,89.76
X$1500 111 745 848 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1501 m0 *1 58.88,89.76
X$1501 111 745 805 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1502 m0 *1 60.26,89.76
X$1502 111 794 820 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1504 m0 *1 62.56,89.76
X$1504 111 807 842 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1505 m0 *1 63.94,89.76
X$1505 111 831 840 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1506 m0 *1 65.32,89.76
X$1506 70 125 807 631 839 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1507 m0 *1 74.52,89.76
X$1507 111 892 745 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1508 m0 *1 75.9,89.76
X$1508 111 809 817 789 782 909 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1509 m0 *1 78.66,89.76
X$1509 111 633 730 810 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1510 m0 *1 81.88,89.76
X$1510 111 806 111 70 832 70 sky130_fd_sc_hd__inv_1
* cell instance $1513 m0 *1 84.64,89.76
X$1513 111 574 813 810 694 834 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1514 m0 *1 87.4,89.76
X$1514 111 779 111 70 809 70 sky130_fd_sc_hd__inv_1
* cell instance $1516 m0 *1 89.24,89.76
X$1516 111 547 715 812 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1517 m0 *1 92.46,89.76
X$1517 111 732 111 571 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1518 r0 *1 1.38,89.76
X$1518 70 125 833 630 621 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1520 r0 *1 11.04,89.76
X$1520 111 823 863 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1521 r0 *1 12.42,89.76
X$1521 111 619 823 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1522 r0 *1 13.8,89.76
X$1522 111 800 850 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1527 r0 *1 15.64,89.76
X$1527 111 824 825 814 864 111 802 70 70 sky130_fd_sc_hd__a22oi_1
* cell instance $1528 r0 *1 18.4,89.76
X$1528 111 799 826 825 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $1529 r0 *1 20.7,89.76
X$1529 111 739 801 835 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $1530 r0 *1 23,89.76
X$1530 111 827 829 836 70 111 70 sky130_fd_sc_hd__nand2b_1
* cell instance $1531 r0 *1 25.3,89.76
X$1531 111 852 869 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1532 r0 *1 26.68,89.76
X$1532 111 747 748 709 800 70 510 111 70 sky130_fd_sc_hd__nor4_1
* cell instance $1533 r0 *1 28.98,89.76
X$1533 111 904 111 837 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1534 r0 *1 32.66,89.76
X$1534 111 853 111 838 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1535 r0 *1 36.34,89.76
X$1535 111 785 766 870 869 830 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1536 r0 *1 39.1,89.76
X$1536 111 851 720 830 70 111 853 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1538 r0 *1 41.4,89.76
X$1538 111 873 841 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1544 r0 *1 43.7,89.76
X$1544 111 854 111 821 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1545 r0 *1 47.38,89.76
X$1545 111 843 764 876 70 111 854 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1547 r0 *1 50.14,89.76
X$1547 111 855 111 901 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1548 r0 *1 53.82,89.76
X$1548 111 577 878 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1549 r0 *1 55.2,89.76
X$1549 111 577 849 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1550 r0 *1 56.58,89.76
X$1550 111 875 521 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1551 r0 *1 57.96,89.76
X$1551 111 848 856 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1552 r0 *1 59.34,89.76
X$1552 111 822 872 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1553 r0 *1 60.72,89.76
X$1553 111 871 794 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1554 r0 *1 62.1,89.76
X$1554 111 793 650 858 111 70 70 sky130_fd_sc_hd__xnor2_1
* cell instance $1555 r0 *1 65.32,89.76
X$1555 111 794 857 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1556 r0 *1 66.7,89.76
X$1556 111 868 111 839 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1561 r0 *1 70.84,89.76
X$1561 111 832 701 858 840 866 111 70 70 sky130_fd_sc_hd__o211ai_1
* cell instance $1562 r0 *1 73.6,89.76
X$1562 70 125 682 631 862 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1564 r0 *1 83.26,89.76
X$1564 111 545 719 834 70 111 861 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1565 r0 *1 85.1,89.76
X$1565 70 125 641 631 860 111 111 70 sky130_fd_sc_hd__dfrtp_1
* cell instance $1566 r0 *1 94.3,89.76
X$1566 111 807 111 70 859 70 sky130_fd_sc_hd__inv_1
* cell instance $1568 m0 *1 1.38,95.2
X$1568 111 647 639 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1569 m0 *1 2.76,95.2
X$1569 111 722 708 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1570 m0 *1 4.14,95.2
X$1570 111 867 801 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1571 m0 *1 5.52,95.2
X$1571 111 889 827 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1572 m0 *1 6.9,95.2
X$1572 111 879 829 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1573 m0 *1 8.28,95.2
X$1573 111 747 903 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1574 m0 *1 9.66,95.2
X$1574 111 619 905 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1575 m0 *1 11.04,95.2
X$1575 111 837 619 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1576 m0 *1 12.42,95.2
X$1576 111 673 799 826 70 111 864 70 sky130_fd_sc_hd__a21boi_0
* cell instance $1578 m0 *1 15.64,95.2
X$1578 111 880 851 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1579 m0 *1 17.02,95.2
X$1579 111 881 111 674 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1580 m0 *1 20.7,95.2
X$1580 111 891 111 867 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1581 m0 *1 24.38,95.2
X$1581 111 893 111 879 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1585 m0 *1 30.36,95.2
X$1585 111 896 772 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1586 m0 *1 31.74,95.2
X$1586 111 897 111 880 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1587 m0 *1 35.42,95.2
X$1587 111 898 111 762 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1588 m0 *1 39.1,95.2
X$1588 111 899 111 874 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1591 m0 *1 43.7,95.2
X$1591 111 844 900 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1592 m0 *1 45.08,95.2
X$1592 111 752 906 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1593 m0 *1 46.46,95.2
X$1593 111 882 111 877 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1594 m0 *1 50.14,95.2
X$1594 111 902 111 845 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1595 m0 *1 53.82,95.2
X$1595 111 901 636 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1596 m0 *1 55.2,95.2
X$1596 111 636 907 70 111 70 sky130_fd_sc_hd__clkbuf_1
* cell instance $1598 m0 *1 57.04,95.2
X$1598 111 883 111 875 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1599 m0 *1 60.72,95.2
X$1599 111 884 111 871 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1600 m0 *1 64.4,95.2
X$1600 111 885 111 892 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1602 m0 *1 68.54,95.2
X$1602 111 787 859 866 70 111 868 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1604 m0 *1 70.84,95.2
X$1604 111 895 111 865 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1605 m0 *1 74.52,95.2
X$1605 111 894 111 754 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1606 m0 *1 78.2,95.2
X$1606 111 890 111 862 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1607 m0 *1 81.88,95.2
X$1607 111 798 683 909 70 111 890 70 sky130_fd_sc_hd__a21oi_1
* cell instance $1610 m0 *1 84.64,95.2
X$1610 111 886 111 554 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1611 m0 *1 88.32,95.2
X$1611 111 861 111 860 70 70 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $1612 m0 *1 92,95.2
X$1612 111 888 111 527 70 70 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS gpio_controller

* cell sky130_fd_sc_hd__nor4_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nor4_2 1 2 3 4 5 6 8 11 12
* net 1 VGND
* net 2 Y
* net 3 A
* net 4 B
* net 5 C
* net 6 D
* net 8 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.73,1.985 pfet_01v8_hvt
M$1 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.57,1.985 pfet_01v8_hvt
M$3 2 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 8 3 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 9 4 7 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.57,0.56 nfet_01v8
M$11 2 6 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $13 r0 *1 0.49,0.56 nfet_01v8
M$13 2 3 1 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $15 r0 *1 1.33,0.56 nfet_01v8
M$15 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nor4_2

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__clkinv_4
* pin VPB
* pin A
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_4 1 2 3 5 6
* net 1 VPB
* net 2 A
* net 3 VGND
* net 4 Y
* net 5 VPWR
* device instance $1 r0 *1 0.515,1.985 pfet_01v8_hvt
M$1 4 2 5 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.005e+12P AD=1.045e+12P
+ PS=9010000U PD=9090000U
* device instance $7 r0 *1 0.945,0.445 nfet_01v8
M$7 4 2 3 6 nfet_01v8 L=150000U W=1680000U AS=315000000000P AD=342300000000P
+ PS=3600000U PD=3730000U
.ENDS sky130_fd_sc_hd__clkinv_4

* cell sky130_fd_sc_hd__a22oi_1
* pin VPB
* pin B2
* pin B1
* pin A1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a22oi_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 1.83,1.985 pfet_01v8_hvt
M$1 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 2.25,1.985 pfet_01v8_hvt
M$2 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=300000000000P PS=1270000U PD=2600000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $4 r0 *1 0.89,1.985 pfet_01v8_hvt
M$4 8 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 1.83,0.56 nfet_01v8
M$5 11 4 8 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 2.19,0.56 nfet_01v8
M$6 9 5 11 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=234000000000P
+ PS=860000U PD=2020000U
* device instance $7 r0 *1 0.47,0.56 nfet_01v8
M$7 12 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=74750000000P
+ PS=1820000U PD=880000U
* device instance $8 r0 *1 0.85,0.56 nfet_01v8
M$8 8 3 12 10 nfet_01v8 L=150000U W=650000U AS=74750000000P AD=169000000000P
+ PS=880000U PD=1820000U
.ENDS sky130_fd_sc_hd__a22oi_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__clkinvlp_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinvlp_4 1 2 3 4 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.525,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=250000U W=4000000U AS=685000000000P
+ AD=685000000000P PS=6370000U PD=6370000U
* device instance $5 r0 *1 0.475,0.51 nfet_01v8
M$5 8 2 4 6 nfet_01v8 L=150000U W=550000U AS=145750000000P AD=57750000000P
+ PS=1630000U PD=760000U
* device instance $6 r0 *1 0.835,0.51 nfet_01v8
M$6 5 2 8 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=77000000000P
+ PS=760000U PD=830000U
* device instance $7 r0 *1 1.265,0.51 nfet_01v8
M$7 7 2 5 6 nfet_01v8 L=150000U W=550000U AS=77000000000P AD=57750000000P
+ PS=830000U PD=760000U
* device instance $8 r0 *1 1.625,0.51 nfet_01v8
M$8 4 2 7 6 nfet_01v8 L=150000U W=550000U AS=57750000000P AD=145750000000P
+ PS=760000U PD=1630000U
.ENDS sky130_fd_sc_hd__clkinvlp_4

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__a21boi_0
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21boi_0 1 2 3 4 6 8 9 10
* net 1 VPB
* net 2 B1_N
* net 3 A1
* net 4 A2
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 1.425,2.165 pfet_01v8_hvt
M$1 5 7 9 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=89600000000P
+ PS=1810000U PD=920000U
* device instance $2 r0 *1 1.855,2.165 pfet_01v8_hvt
M$2 8 3 5 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=89600000000P
+ PS=920000U PD=920000U
* device instance $3 r0 *1 2.285,2.165 pfet_01v8_hvt
M$3 5 4 8 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=169600000000P
+ PS=920000U PD=1810000U
* device instance $4 r0 *1 0.475,2.275 pfet_01v8_hvt
M$4 8 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=111300000000P
+ PS=1370000U PD=1370000U
* device instance $5 r0 *1 0.475,0.445 nfet_01v8
M$5 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=130200000000P
+ PS=1370000U PD=1040000U
* device instance $6 r0 *1 1.245,0.445 nfet_01v8
M$6 9 7 6 10 nfet_01v8 L=150000U W=420000U AS=130200000000P AD=111300000000P
+ PS=1040000U PD=950000U
* device instance $7 r0 *1 1.925,0.445 nfet_01v8
M$7 11 3 9 10 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=950000U PD=630000U
* device instance $8 r0 *1 2.285,0.445 nfet_01v8
M$8 6 4 11 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=111300000000P
+ PS=630000U PD=1370000U
.ENDS sky130_fd_sc_hd__a21boi_0

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1
