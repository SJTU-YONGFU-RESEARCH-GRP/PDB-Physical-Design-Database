* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT pipelined_fifo almost_empty almost_full clk data_count[0]
+ data_count[1] data_count[2] data_count[3] data_count[4] empty
+ full rd_data[0] rd_data[10] rd_data[11] rd_data[12] rd_data[13]
+ rd_data[14] rd_data[15] rd_data[16] rd_data[17] rd_data[18]
+ rd_data[19] rd_data[1] rd_data[20] rd_data[21] rd_data[22]
+ rd_data[23] rd_data[24] rd_data[25] rd_data[26] rd_data[27]
+ rd_data[28] rd_data[29] rd_data[2] rd_data[30] rd_data[31]
+ rd_data[3] rd_data[4] rd_data[5] rd_data[6] rd_data[7] rd_data[8]
+ rd_data[9] rd_en rst_n wr_data[0] wr_data[10] wr_data[11]
+ wr_data[12] wr_data[13] wr_data[14] wr_data[15] wr_data[16]
+ wr_data[17] wr_data[18] wr_data[19] wr_data[1] wr_data[20]
+ wr_data[21] wr_data[22] wr_data[23] wr_data[24] wr_data[25]
+ wr_data[26] wr_data[27] wr_data[28] wr_data[29] wr_data[2]
+ wr_data[30] wr_data[31] wr_data[3] wr_data[4] wr_data[5] wr_data[6]
+ wr_data[7] wr_data[8] wr_data[9] wr_en
X_115_ _077_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__inv_1
X_116_ _109_ _112_ _076_ VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nand3_1
X_117_ _112_ _108_ _111_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__a21oi_1
X_118_ wr_ptr\[4\] rd_ptr\[4\] VSS VSS VDD VDD _064_ sky130_fd_sc_hd__xnor2_1
X_119_ _062_ _063_ _064_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__a21oi_1
X_120_ _062_ _063_ _064_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__and3_1
X_121_ _065_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__or2_0
X_122_ _067_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__buf_2
X_123_ pipeline_count\[1\] pipeline_count\[3\] pipeline_count\[2\]
+ pipeline_count\[4\] VSS VSS VDD VDD _069_ sky130_fd_sc_hd__or4_1
X_124_ _103_ _106_ _109_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__nand3b_1
X_125_ _109_ _105_ _108_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__a21oi_1
X_126_ _112_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__inv_1
X_127_ _070_ _020_ _021_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_128_ _103_ _106_ _109_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__and3b_1
X_129_ _109_ _105_ _108_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__a21o_1
X_130_ _112_ _023_ _024_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor3_1
X_131_ _022_ _025_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__nor2_1
X_132_ _109_ _076_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__xor2_2
X_133_ _104_ _079_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nand2_1
X_134_ pipeline_count\[0\] _089_ _026_ VSS VSS VDD VDD _027_
+ sky130_fd_sc_hd__nor3_2
X_135_ _068_ _069_ _092_ _027_ VSS VSS VDD VDD net11 sky130_fd_sc_hd__nor4b_1
X_136_ _070_ _020_ _021_ _069_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__a211o_1
X_137_ _112_ _069_ _023_ _024_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__or4_1
X_138_ _028_ _029_ _065_ _066_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__a211oi_2
X_139_ net2 VSS VSS VDD VDD _031_ sky130_fd_sc_hd__inv_1
X_140_ _027_ _030_ _031_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__a21o_1
X_141_ _032_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__inv_1
X_142_ _079_ _022_ _025_ _089_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nor4b_4
X_143_ _068_ _033_ VSS VSS VDD VDD net12 sky130_fd_sc_hd__or2_0
X_144_ _033_ _068_ net3 VSS VSS VDD VDD _001_ sky130_fd_sc_hd__nor3b_2
X_145_ pipeline_count\[1\] VSS VSS VDD VDD _078_ sky130_fd_sc_hd__inv_1
X_146_ _083_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__inv_1
X_147_ _082_ VSS VSS VDD VDD net7 sky130_fd_sc_hd__inv_1
X_148_ rd_en_pipe VSS VSS VDD VDD _084_ sky130_fd_sc_hd__inv_1
X_149_ rd_ptr\[1\] VSS VSS VDD VDD _074_ sky130_fd_sc_hd__inv_1
X_150_ _103_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__inv_1
X_151_ rd_ptr\[2\] VSS VSS VDD VDD _107_ sky130_fd_sc_hd__inv_1
X_152_ rd_ptr\[3\] VSS VSS VDD VDD _110_ sky130_fd_sc_hd__inv_1
X_153_ _085_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__inv_1
X_154_ wr_ptr\[0\] VSS VSS VDD VDD _003_ sky130_fd_sc_hd__inv_1
X_155_ _104_ VSS VSS VDD VDD _113_ sky130_fd_sc_hd__inv_1
X_156_ rd_ptr\[0\] _032_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__xnor2_1
X_157_ _002_ rd_ptr\[1\] _032_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__mux2_1
X_158_ net2 _096_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nand2_1
X_159_ _027_ _030_ _034_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__a21oi_1
X_160_ _107_ _035_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__xnor2_1
X_161_ rd_ptr\[2\] rd_ptr\[1\] rd_ptr\[0\] VSS VSS VDD VDD
+ _036_ sky130_fd_sc_hd__nand3_1
X_162_ _027_ _030_ _036_ _031_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__a211oi_1
X_163_ _110_ _037_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__xnor2_1
X_164_ _027_ _030_ _034_ _110_ _107_ VSS VSS VDD VDD _038_
+ sky130_fd_sc_hd__a2111oi_1
X_165_ rd_ptr\[4\] _038_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__xor2_1
X_166_ _003_ _001_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__xnor2_1
X_167_ wr_ptr\[1\] _004_ _001_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__mux2_1
X_168_ net3 _095_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand2_1
X_169_ _068_ _033_ _039_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor3_1
X_170_ wr_ptr\[2\] _040_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__xor2_1
X_171_ net3 wr_ptr\[2\] wr_ptr\[1\] wr_ptr\[0\] VSS VSS VDD
+ VDD _041_ sky130_fd_sc_hd__nand4_1
X_172_ _068_ _033_ _041_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor3_1
X_173_ wr_ptr\[3\] _042_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__xor2_1
X_174_ wr_ptr\[2\] wr_ptr\[3\] VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand2_1
X_175_ _068_ _033_ _039_ _043_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nor4_1
X_176_ wr_ptr\[4\] _044_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__xor2_1
X_177_ _086_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__clkbuf_2
X_178_ pipeline_count\[0\] _045_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__xnor2_1
X_179_ _073_ _078_ _045_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__mux2i_1
X_180_ _072_ _100_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__xnor2_1
X_181_ pipeline_count\[2\] _045_ VSS VSS VDD VDD _047_ sky130_fd_sc_hd__nand2_1
X_182_ _045_ _046_ _047_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_183_ pipeline_count\[0\] _098_ _097_ VSS VSS VDD VDD _048_
+ sky130_fd_sc_hd__a21o_1
X_184_ _100_ _048_ _099_ VSS VSS VDD VDD _049_ sky130_fd_sc_hd__a21oi_1
X_185_ _102_ _049_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__xor2_1
X_186_ pipeline_count\[3\] _045_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand2_1
X_187_ _045_ _050_ _051_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__o21ai_0
X_188_ _072_ _100_ _099_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__a21o_1
X_189_ _102_ _052_ _101_ VSS VSS VDD VDD _053_ sky130_fd_sc_hd__a21oi_1
X_190_ _085_ _053_ VSS VSS VDD VDD _054_ sky130_fd_sc_hd__xnor2_1
X_191_ _045_ _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__nor2_1
X_192_ pipeline_count\[4\] _055_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__xor2_1
X_193_ _089_ _026_ _030_ VSS VSS VDD VDD net4 sky130_fd_sc_hd__a21boi_0
X_194_ _092_ _089_ _068_ VSS VSS VDD VDD net5 sky130_fd_sc_hd__a21o_1
X_195_ _091_ _081_ VSS VSS VDD VDD net8 sky130_fd_sc_hd__xnor2_1
X_196_ _088_ _083_ _087_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__a21o_1
X_197_ _091_ _056_ _090_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__a21oi_1
X_198_ _094_ _057_ VSS VSS VDD VDD net9 sky130_fd_sc_hd__xnor2_1
X_199_ _081_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__inv_1
X_200_ _091_ _058_ _090_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__a21o_1
X_201_ _094_ _059_ _093_ VSS VSS VDD VDD _060_ sky130_fd_sc_hd__a21oi_1
X_202_ pipeline_count\[4\] _060_ VSS VSS VDD VDD _061_ sky130_fd_sc_hd__xor2_1
X_203_ _068_ _061_ VSS VSS VDD VDD net10 sky130_fd_sc_hd__xnor2_1
X_204_ pipeline_count\[0\] pipeline_count\[1\] _071_ VSS VSS
+ VDD VDD _072_ _073_ sky130_fd_sc_hd__fa_1
X_205_ _074_ wr_ptr\[1\] _075_ VSS VSS VDD VDD _076_ _077_
+ sky130_fd_sc_hd__fa_1
X_206_ _078_ _079_ _080_ VSS VSS VDD VDD _081_ _082_ sky130_fd_sc_hd__fa_1
X_207_ _084_ wr_en_pipe\[1\] VSS VSS VDD VDD _085_ _086_ sky130_fd_sc_hd__ha_1
X_208_ pipeline_count\[1\] _077_ VSS VSS VDD VDD _087_ _088_
+ sky130_fd_sc_hd__ha_1
X_209_ pipeline_count\[2\] _089_ VSS VSS VDD VDD _090_ _091_
+ sky130_fd_sc_hd__ha_1
X_210_ pipeline_count\[3\] _092_ VSS VSS VDD VDD _093_ _094_
+ sky130_fd_sc_hd__ha_1
X_211_ wr_ptr\[0\] wr_ptr\[1\] VSS VSS VDD VDD _095_ _004_
+ sky130_fd_sc_hd__ha_1
X_212_ rd_ptr\[0\] rd_ptr\[1\] VSS VSS VDD VDD _096_ _002_
+ sky130_fd_sc_hd__ha_1
X_213_ pipeline_count\[1\] _071_ VSS VSS VDD VDD _097_ _098_
+ sky130_fd_sc_hd__ha_1
X_214_ pipeline_count\[2\] _071_ VSS VSS VDD VDD _099_ _100_
+ sky130_fd_sc_hd__ha_1
X_215_ pipeline_count\[3\] _071_ VSS VSS VDD VDD _101_ _102_
+ sky130_fd_sc_hd__ha_1
X_216_ rd_ptr\[0\] _003_ VSS VSS VDD VDD _103_ _104_ sky130_fd_sc_hd__ha_1
X_217_ _074_ wr_ptr\[1\] VSS VSS VDD VDD _105_ _106_ sky130_fd_sc_hd__ha_1
X_218_ _107_ wr_ptr\[2\] VSS VSS VDD VDD _108_ _109_ sky130_fd_sc_hd__ha_2
X_219_ _110_ wr_ptr\[3\] VSS VSS VDD VDD _111_ _112_ sky130_fd_sc_hd__ha_1
X_220_ pipeline_count\[0\] _113_ VSS VSS VDD VDD _083_ net6
+ sky130_fd_sc_hd__ha_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
X_222_ net13 VSS VSS VDD VDD rd_data[0] sky130_fd_sc_hd__buf_4
X_223_ net14 VSS VSS VDD VDD rd_data[1] sky130_fd_sc_hd__buf_4
X_224_ net15 VSS VSS VDD VDD rd_data[2] sky130_fd_sc_hd__buf_4
X_225_ net16 VSS VSS VDD VDD rd_data[3] sky130_fd_sc_hd__buf_4
X_226_ net17 VSS VSS VDD VDD rd_data[4] sky130_fd_sc_hd__buf_4
X_227_ net18 VSS VSS VDD VDD rd_data[5] sky130_fd_sc_hd__buf_4
X_228_ net19 VSS VSS VDD VDD rd_data[6] sky130_fd_sc_hd__buf_4
X_229_ net20 VSS VSS VDD VDD rd_data[7] sky130_fd_sc_hd__buf_4
X_230_ net21 VSS VSS VDD VDD rd_data[8] sky130_fd_sc_hd__buf_4
X_231_ net22 VSS VSS VDD VDD rd_data[9] sky130_fd_sc_hd__buf_4
X_232_ net23 VSS VSS VDD VDD rd_data[10] sky130_fd_sc_hd__buf_4
X_233_ net24 VSS VSS VDD VDD rd_data[11] sky130_fd_sc_hd__buf_4
X_234_ net25 VSS VSS VDD VDD rd_data[12] sky130_fd_sc_hd__buf_4
X_235_ net26 VSS VSS VDD VDD rd_data[13] sky130_fd_sc_hd__buf_4
X_236_ net27 VSS VSS VDD VDD rd_data[14] sky130_fd_sc_hd__buf_4
X_237_ net28 VSS VSS VDD VDD rd_data[15] sky130_fd_sc_hd__buf_4
X_238_ net29 VSS VSS VDD VDD rd_data[16] sky130_fd_sc_hd__buf_4
X_239_ net30 VSS VSS VDD VDD rd_data[17] sky130_fd_sc_hd__buf_4
X_240_ net31 VSS VSS VDD VDD rd_data[18] sky130_fd_sc_hd__buf_4
X_241_ net32 VSS VSS VDD VDD rd_data[19] sky130_fd_sc_hd__buf_4
X_242_ net33 VSS VSS VDD VDD rd_data[20] sky130_fd_sc_hd__buf_4
X_243_ net34 VSS VSS VDD VDD rd_data[21] sky130_fd_sc_hd__buf_4
X_244_ net35 VSS VSS VDD VDD rd_data[22] sky130_fd_sc_hd__buf_4
X_245_ net36 VSS VSS VDD VDD rd_data[23] sky130_fd_sc_hd__buf_4
X_246_ net37 VSS VSS VDD VDD rd_data[24] sky130_fd_sc_hd__buf_4
X_247_ net38 VSS VSS VDD VDD rd_data[25] sky130_fd_sc_hd__buf_4
X_248_ net39 VSS VSS VDD VDD rd_data[26] sky130_fd_sc_hd__buf_4
X_249_ net40 VSS VSS VDD VDD rd_data[27] sky130_fd_sc_hd__buf_4
X_250_ net41 VSS VSS VDD VDD rd_data[28] sky130_fd_sc_hd__buf_4
X_251_ net42 VSS VSS VDD VDD rd_data[29] sky130_fd_sc_hd__buf_4
X_252_ net43 VSS VSS VDD VDD rd_data[30] sky130_fd_sc_hd__buf_4
X_253_ net44 VSS VSS VDD VDD rd_data[31] sky130_fd_sc_hd__buf_4
Xpipeline_count\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _005_
+ net1 VSS VSS VDD VDD pipeline_count\[0\] sky130_fd_sc_hd__dfrtp_4
Xpipeline_count\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_
+ net1 VSS VSS VDD VDD pipeline_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _007_
+ net1 VSS VSS VDD VDD pipeline_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _008_
+ net1 VSS VSS VDD VDD pipeline_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xpipeline_count\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _009_
+ net1 VSS VSS VDD VDD pipeline_count\[4\] sky130_fd_sc_hd__dfrtp_1
Xrd_en_pipe$_DFF_PN0_ clknet_1_1__leaf_clk _000_ net1 VSS
+ VSS VDD VDD rd_en_pipe sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _010_ net1 VSS
+ VSS VDD VDD rd_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _011_ net1 VSS
+ VSS VDD VDD rd_ptr\[1\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _012_ net1 VSS
+ VSS VDD VDD rd_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _013_ net1 VSS
+ VSS VDD VDD rd_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xrd_ptr\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _014_ net1 VSS
+ VSS VDD VDD rd_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xwr_en_pipe\[0\]$_DFF_PN0_ clknet_1_0__leaf_clk _001_ net1
+ VSS VSS VDD VDD wr_en_pipe\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_en_pipe\[1\]$_DFF_PN0_ clknet_1_0__leaf_clk wr_en_pipe\[0\]
+ net1 VSS VSS VDD VDD wr_en_pipe\[1\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _015_ net1 VSS
+ VSS VDD VDD wr_ptr\[0\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _016_ net1 VSS
+ VSS VDD VDD wr_ptr\[1\] sky130_fd_sc_hd__dfrtp_2
Xwr_ptr\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _017_ net1 VSS
+ VSS VDD VDD wr_ptr\[2\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _018_ net1 VSS
+ VSS VDD VDD wr_ptr\[3\] sky130_fd_sc_hd__dfrtp_1
Xwr_ptr\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _019_ net1 VSS
+ VSS VDD VDD wr_ptr\[4\] sky130_fd_sc_hd__dfrtp_1
Xhold1 net45 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 rd_en VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 wr_en VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD almost_empty sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD almost_full sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD data_count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD data_count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net8 VSS VSS VDD VDD data_count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD data_count[3] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD data_count[4] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD empty sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD full sky130_fd_sc_hd__clkbuf_1
X_222__12 VSS VSS VDD VDD _unconnected_0 net13 sky130_fd_sc_hd__conb_1
X_223__13 VSS VSS VDD VDD _unconnected_1 net14 sky130_fd_sc_hd__conb_1
X_224__14 VSS VSS VDD VDD _unconnected_2 net15 sky130_fd_sc_hd__conb_1
X_225__15 VSS VSS VDD VDD _unconnected_3 net16 sky130_fd_sc_hd__conb_1
X_226__16 VSS VSS VDD VDD _unconnected_4 net17 sky130_fd_sc_hd__conb_1
X_227__17 VSS VSS VDD VDD _unconnected_5 net18 sky130_fd_sc_hd__conb_1
X_228__18 VSS VSS VDD VDD _unconnected_6 net19 sky130_fd_sc_hd__conb_1
X_229__19 VSS VSS VDD VDD _unconnected_7 net20 sky130_fd_sc_hd__conb_1
X_230__20 VSS VSS VDD VDD _unconnected_8 net21 sky130_fd_sc_hd__conb_1
X_231__21 VSS VSS VDD VDD _unconnected_9 net22 sky130_fd_sc_hd__conb_1
X_232__22 VSS VSS VDD VDD _unconnected_10 net23 sky130_fd_sc_hd__conb_1
X_233__23 VSS VSS VDD VDD _unconnected_11 net24 sky130_fd_sc_hd__conb_1
X_234__24 VSS VSS VDD VDD _unconnected_12 net25 sky130_fd_sc_hd__conb_1
X_235__25 VSS VSS VDD VDD _unconnected_13 net26 sky130_fd_sc_hd__conb_1
X_236__26 VSS VSS VDD VDD _unconnected_14 net27 sky130_fd_sc_hd__conb_1
X_237__27 VSS VSS VDD VDD _unconnected_15 net28 sky130_fd_sc_hd__conb_1
X_238__28 VSS VSS VDD VDD _unconnected_16 net29 sky130_fd_sc_hd__conb_1
X_239__29 VSS VSS VDD VDD _unconnected_17 net30 sky130_fd_sc_hd__conb_1
X_240__30 VSS VSS VDD VDD _unconnected_18 net31 sky130_fd_sc_hd__conb_1
X_241__31 VSS VSS VDD VDD _unconnected_19 net32 sky130_fd_sc_hd__conb_1
X_242__32 VSS VSS VDD VDD _unconnected_20 net33 sky130_fd_sc_hd__conb_1
X_243__33 VSS VSS VDD VDD _unconnected_21 net34 sky130_fd_sc_hd__conb_1
X_244__34 VSS VSS VDD VDD _unconnected_22 net35 sky130_fd_sc_hd__conb_1
X_245__35 VSS VSS VDD VDD _unconnected_23 net36 sky130_fd_sc_hd__conb_1
X_246__36 VSS VSS VDD VDD _unconnected_24 net37 sky130_fd_sc_hd__conb_1
X_247__37 VSS VSS VDD VDD _unconnected_25 net38 sky130_fd_sc_hd__conb_1
X_248__38 VSS VSS VDD VDD _unconnected_26 net39 sky130_fd_sc_hd__conb_1
X_249__39 VSS VSS VDD VDD _unconnected_27 net40 sky130_fd_sc_hd__conb_1
X_250__40 VSS VSS VDD VDD _unconnected_28 net41 sky130_fd_sc_hd__conb_1
X_251__41 VSS VSS VDD VDD _unconnected_29 net42 sky130_fd_sc_hd__conb_1
X_252__42 VSS VSS VDD VDD _unconnected_30 net43 sky130_fd_sc_hd__conb_1
X_253__43 VSS VSS VDD VDD _unconnected_31 net44 sky130_fd_sc_hd__conb_1
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net45 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS pipelined_fifo
