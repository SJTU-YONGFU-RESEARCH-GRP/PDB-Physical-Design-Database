* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_self_correcting_counter clk count[0]
+ count[1] count[2] count[3] enable rst_n
X_13_ net4 net5 net6 VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21a_1
X_14_ net3 net2 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand2b_1
X_15_ net2 net3 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__nand2b_1
X_16_ _04_ _05_ _06_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_17_ net3 net6 net2 VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21ai_0
X_18_ net4 net6 net2 net3 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__and4bb_1
X_19_ net4 _07_ _08_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a21o_1
X_20_ net6 net2 net3 net4 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__and4b_1
X_21_ net3 net4 net6 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__a21oi_1
X_22_ net5 net2 VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nand2_1
X_23_ net5 _09_ _10_ _11_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o22a_1
X_24_ net3 net4 net5 net2 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__o31ai_1
X_25_ net5 _09_ _12_ net6 VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a22o_1
Xcounter_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net3 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _01_ net1
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfrtp_2
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xhold1 net7 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput2 net3 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net7 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_self_correcting_counter
