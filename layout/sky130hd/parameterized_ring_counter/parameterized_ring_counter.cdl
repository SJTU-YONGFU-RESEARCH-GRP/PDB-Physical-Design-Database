* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_ring_counter clk count[0] count[1] count[2]
+ count[3] enable rst_n
X_4_ net4 net7 net2 VSS VSS VDD VDD _0_ sky130_fd_sc_hd__mux2_1
X_5_ net5 net4 net2 VSS VSS VDD VDD _1_ sky130_fd_sc_hd__mux2_1
X_6_ net6 net5 net2 VSS VSS VDD VDD _2_ sky130_fd_sc_hd__mux2_1
X_7_ net7 net6 net2 VSS VSS VDD VDD _3_ sky130_fd_sc_hd__mux2_1
Xcounter_reg\[0\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _0_ net3
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfstp_1
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _1_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _2_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _3_ net1
+ VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xhold1 net3 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkdlybuf4s50_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 net8 VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xoutput3 net4 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_ring_counter
