* cell performance_counter
* pin all_counts[72]
* pin all_counts[68]
* pin all_counts[67]
* pin all_counts[73]
* pin all_counts[75]
* pin all_counts[66]
* pin event_inc[2]
* pin all_counts[76]
* pin all_counts[65]
* pin all_counts[77]
* pin all_counts[64]
* pin all_counts[78]
* pin all_counts[79]
* pin all_counts[13]
* pin all_counts[14]
* pin all_counts[84]
* pin all_counts[94]
* pin all_counts[80]
* pin all_counts[95]
* pin all_counts[90]
* pin all_counts[81]
* pin all_counts[83]
* pin all_counts[82]
* pin all_counts[93]
* pin all_counts[85]
* pin all_counts[89]
* pin all_counts[87]
* pin all_counts[88]
* pin all_counts[86]
* pin all_counts[97]
* pin event_inc[4]
* pin all_counts[130]
* pin event_inc[3]
* pin all_counts[98]
* pin all_counts[96]
* pin counter_sel[4]
* pin all_counts[137]
* pin all_counts[104]
* pin all_counts[105]
* pin all_counts[136]
* pin all_counts[135]
* pin all_counts[99]
* pin counter_sel[3]
* pin all_counts[103]
* pin all_counts[100]
* pin all_counts[106]
* pin all_counts[128]
* pin all_counts[101]
* pin all_counts[102]
* pin all_counts[129]
* pin all_counts[107]
* pin all_counts[110]
* pin all_counts[109]
* pin all_counts[111]
* pin all_counts[112]
* pin all_counts[113]
* pin all_counts[114]
* pin all_counts[115]
* pin all_counts[116]
* pin all_counts[74]
* pin all_counts[91]
* pin all_counts[92]
* pin all_counts[108]
* pin rst_n
* pin all_counts[119]
* pin all_counts[117]
* pin all_counts[118]
* pin all_counts[71]
* pin all_counts[69]
* pin all_counts[120]
* pin all_counts[121]
* pin all_counts[126]
* pin all_counts[70]
* pin all_counts[123]
* pin all_counts[122]
* pin all_counts[124]
* pin all_counts[125]
* pin all_counts[127]
* pin all_counts[8]
* pin all_counts[11]
* pin all_counts[6]
* pin all_counts[4]
* pin all_counts[158]
* pin all_counts[7]
* pin all_counts[153]
* pin all_counts[133]
* pin all_counts[3]
* pin all_counts[5]
* pin all_counts[159]
* pin all_counts[151]
* pin all_counts[1]
* pin all_counts[157]
* pin all_counts[132]
* pin all_counts[155]
* pin all_counts[0]
* pin all_counts[9]
* pin all_counts[131]
* pin all_counts[31]
* pin all_counts[2]
* pin all_counts[156]
* pin all_counts[134]
* pin event_inc[0]
* pin all_counts[10]
* pin all_counts[154]
* pin all_counts[152]
* pin all_counts[26]
* pin counter_sel[0]
* pin counter_sel[1]
* pin all_counts[146]
* pin all_counts[29]
* pin all_counts[140]
* pin all_counts[12]
* pin counter_sel[2]
* pin all_counts[141]
* pin all_counts[139]
* pin all_counts[55]
* pin all_counts[25]
* pin all_counts[138]
* pin all_counts[54]
* pin all_counts[56]
* pin all_counts[147]
* pin all_counts[61]
* pin all_counts[15]
* pin all_counts[150]
* pin all_counts[53]
* pin all_counts[60]
* pin all_counts[149]
* pin all_counts[148]
* pin all_counts[59]
* pin all_counts[145]
* pin all_counts[62]
* pin all_counts[143]
* pin all_counts[22]
* pin all_counts[30]
* pin all_counts[142]
* pin all_counts[23]
* pin counter_sel[5]
* pin clk
* pin all_counts[63]
* pin all_counts[58]
* pin all_counts[144]
* pin clear
* pin all_counts[24]
* pin all_counts[253]
* pin all_counts[21]
* pin all_counts[51]
* pin all_counts[20]
* pin all_counts[250]
* pin all_counts[249]
* pin all_counts[57]
* pin all_counts[251]
* pin all_counts[50]
* pin all_counts[238]
* pin all_counts[52]
* pin all_counts[16]
* pin all_counts[237]
* pin all_counts[252]
* pin all_counts[49]
* pin all_counts[18]
* pin all_counts[255]
* pin all_counts[239]
* pin all_counts[48]
* pin all_counts[27]
* pin all_counts[240]
* pin all_counts[234]
* pin all_counts[28]
* pin all_counts[248]
* pin all_counts[17]
* pin all_counts[243]
* pin all_counts[254]
* pin all_counts[47]
* pin all_counts[244]
* pin all_counts[46]
* pin all_counts[45]
* pin count_value[23]
* pin all_counts[247]
* pin all_counts[44]
* pin count_value[26]
* pin count_value[25]
* pin all_counts[43]
* pin count_value[24]
* pin all_counts[236]
* pin all_counts[246]
* pin all_counts[245]
* pin all_counts[41]
* pin all_counts[39]
* pin all_counts[42]
* pin count_value[28]
* pin count_value[29]
* pin all_counts[37]
* pin all_counts[38]
* pin count_value[21]
* pin count_value[22]
* pin all_counts[241]
* pin count_value[20]
* pin all_counts[40]
* pin count_value[30]
* pin all_counts[242]
* pin all_counts[35]
* pin all_counts[235]
* pin count_value[31]
* pin all_counts[36]
* pin all_counts[218]
* pin all_counts[223]
* pin all_counts[219]
* pin all_counts[216]
* pin all_counts[34]
* pin all_counts[33]
* pin all_counts[220]
* pin all_counts[217]
* pin all_counts[213]
* pin all_counts[222]
* pin all_counts[32]
* pin all_counts[215]
* pin all_counts[221]
* pin event_inc[1]
* pin enable
* pin all_counts[183]
* pin all_counts[164]
* pin count_value[11]
* pin count_value[2]
* pin all_counts[165]
* pin count_value[10]
* pin all_counts[231]
* pin all_counts[209]
* pin all_counts[188]
* pin count_value[17]
* pin count_value[12]
* pin count_value[27]
* pin all_counts[171]
* pin all_counts[173]
* pin all_counts[229]
* pin count_value[6]
* pin all_counts[197]
* pin all_counts[192]
* pin all_counts[201]
* pin counter_sel[7]
* pin all_counts[205]
* pin all_counts[174]
* pin all_counts[193]
* pin count_value[3]
* pin counter_sel[6]
* pin count_value[5]
* pin all_counts[162]
* pin all_counts[181]
* pin all_counts[172]
* pin all_counts[175]
* pin all_counts[167]
* pin all_counts[230]
* pin count_value[13]
* pin all_counts[198]
* pin all_counts[208]
* pin all_counts[211]
* pin all_counts[210]
* pin all_counts[160]
* pin all_counts[184]
* pin count_value[15]
* pin all_counts[196]
* pin all_counts[170]
* pin all_counts[187]
* pin all_counts[227]
* pin all_counts[180]
* pin all_counts[189]
* pin all_counts[194]
* pin all_counts[224]
* pin all_counts[178]
* pin all_counts[169]
* pin all_counts[182]
* pin all_counts[191]
* pin all_counts[199]
* pin all_counts[204]
* pin count_value[19]
* pin event_inc[5]
* pin all_counts[161]
* pin all_counts[163]
* pin all_counts[168]
* pin all_counts[214]
* pin all_counts[212]
* pin all_counts[177]
* pin all_counts[176]
* pin all_counts[179]
* pin all_counts[206]
* pin count_value[16]
* pin all_counts[203]
* pin all_counts[19]
* pin all_counts[195]
* pin count_value[18]
* pin all_counts[225]
* pin event_inc[7]
* pin count_value[8]
* pin count_value[7]
* pin all_counts[200]
* pin all_counts[202]
* pin count_value[0]
* pin count_value[1]
* pin all_counts[185]
* pin all_counts[166]
* pin all_counts[190]
* pin all_counts[186]
* pin event_inc[6]
* pin count_value[9]
* pin all_counts[226]
* pin count_value[4]
* pin all_counts[228]
* pin all_counts[232]
* pin count_value[14]
* pin all_counts[233]
* pin all_counts[207]
.SUBCKT performance_counter 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20
+ 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46
+ 47 48 49 50 51 52 53 54 55 56 57 58 59 61 62 63 64 115 235 236 267 283 331
+ 341 369 389 403 446 447 469 470 494 503 504 536 550 560 561 563 565 584 585
+ 606 607 631 645 646 649 669 670 685 702 723 734 735 748 749 772 775 778 796
+ 797 816 834 877 879 885 903 904 905 927 947 966 967 982 1007 1008 1025 1044
+ 1045 1053 1054 1071 1083 1104 1112 1121 1122 1131 1132 1137 1148 1150 1151
+ 1160 1178 1179 1193 1194 1204 1205 1214 1215 1228 1242 1256 1264 1265 1279
+ 1289 1290 1310 1311 1323 1324 1337 1338 1343 1344 1361 1372 1393 1401 1402
+ 1414 1430 1440 1441 1454 1457 1469 1479 1480 1495 1504 1528 1529 1530 1554
+ 1577 1578 1590 1591 1599 1600 1614 1615 1648 1649 1661 1679 1680 1700 1718
+ 1719 1741 1749 1779 1801 1802 1823 1824 1832 1833 1861 1883 1888 1901 1902
+ 1923 1949 2049 2050 2053 2054 2062 2066 2067 2075 2079 2080 2081 2083 2084
+ 2085 2089 2097 2100 2110 2113 2121 2122 2128 2129 2131 2132 2137 2138 2139
+ 2140 2141 2142 2145 2146 2147 2148 2149 2152 2153 2154 2155 2156 2159 2160
+ 2161 2163 2164 2165 2166 2167 2168 2169 2170 2171 2172 2173 2175 2176 2177
+ 2178 2179 2180 2181 2182 2183 2184 2185 2186 2187 2188 2189 2191 2192 2194
+ 2195 2196 2197 2198 2199 2200 2201 2202 2203 2204 2205 2206 2207 2208 2209
+ 2210 2211 2212
* net 1 all_counts[72]
* net 2 all_counts[68]
* net 3 all_counts[67]
* net 4 all_counts[73]
* net 5 all_counts[75]
* net 6 all_counts[66]
* net 7 event_inc[2]
* net 8 all_counts[76]
* net 9 all_counts[65]
* net 10 all_counts[77]
* net 11 all_counts[64]
* net 12 all_counts[78]
* net 13 all_counts[79]
* net 14 all_counts[13]
* net 15 all_counts[14]
* net 16 all_counts[84]
* net 17 all_counts[94]
* net 18 all_counts[80]
* net 19 all_counts[95]
* net 20 all_counts[90]
* net 21 all_counts[81]
* net 22 all_counts[83]
* net 23 all_counts[82]
* net 24 all_counts[93]
* net 25 all_counts[85]
* net 26 all_counts[89]
* net 27 all_counts[87]
* net 28 all_counts[88]
* net 29 all_counts[86]
* net 30 all_counts[97]
* net 31 event_inc[4]
* net 32 all_counts[130]
* net 33 event_inc[3]
* net 34 all_counts[98]
* net 35 all_counts[96]
* net 36 counter_sel[4]
* net 37 all_counts[137]
* net 38 all_counts[104]
* net 39 all_counts[105]
* net 40 all_counts[136]
* net 41 all_counts[135]
* net 42 all_counts[99]
* net 43 counter_sel[3]
* net 44 all_counts[103]
* net 45 all_counts[100]
* net 46 all_counts[106]
* net 47 all_counts[128]
* net 48 all_counts[101]
* net 49 all_counts[102]
* net 50 all_counts[129]
* net 51 all_counts[107]
* net 52 all_counts[110]
* net 53 all_counts[109]
* net 54 all_counts[111]
* net 55 all_counts[112]
* net 56 all_counts[113]
* net 57 all_counts[114]
* net 58 all_counts[115]
* net 59 all_counts[116]
* net 61 all_counts[74]
* net 62 all_counts[91]
* net 63 all_counts[92]
* net 64 all_counts[108]
* net 115 rst_n
* net 235 all_counts[119]
* net 236 all_counts[117]
* net 267 all_counts[118]
* net 283 all_counts[71]
* net 331 all_counts[69]
* net 341 all_counts[120]
* net 369 all_counts[121]
* net 389 all_counts[126]
* net 403 all_counts[70]
* net 446 all_counts[123]
* net 447 all_counts[122]
* net 469 all_counts[124]
* net 470 all_counts[125]
* net 494 all_counts[127]
* net 503 all_counts[8]
* net 504 all_counts[11]
* net 536 all_counts[6]
* net 550 all_counts[4]
* net 560 all_counts[158]
* net 561 all_counts[7]
* net 563 all_counts[153]
* net 565 all_counts[133]
* net 584 all_counts[3]
* net 585 all_counts[5]
* net 606 all_counts[159]
* net 607 all_counts[151]
* net 631 all_counts[1]
* net 645 all_counts[157]
* net 646 all_counts[132]
* net 649 all_counts[155]
* net 669 all_counts[0]
* net 670 all_counts[9]
* net 685 all_counts[131]
* net 702 all_counts[31]
* net 723 all_counts[2]
* net 734 all_counts[156]
* net 735 all_counts[134]
* net 748 event_inc[0]
* net 749 all_counts[10]
* net 772 all_counts[154]
* net 775 all_counts[152]
* net 778 all_counts[26]
* net 796 counter_sel[0]
* net 797 counter_sel[1]
* net 816 all_counts[146]
* net 834 all_counts[29]
* net 877 all_counts[140]
* net 879 all_counts[12]
* net 885 counter_sel[2]
* net 903 all_counts[141]
* net 904 all_counts[139]
* net 905 all_counts[55]
* net 927 all_counts[25]
* net 947 all_counts[138]
* net 966 all_counts[54]
* net 967 all_counts[56]
* net 982 all_counts[147]
* net 1007 all_counts[61]
* net 1008 all_counts[15]
* net 1025 all_counts[150]
* net 1044 all_counts[53]
* net 1045 all_counts[60]
* net 1053 all_counts[149]
* net 1054 all_counts[148]
* net 1071 all_counts[59]
* net 1083 all_counts[145]
* net 1104 all_counts[62]
* net 1112 all_counts[143]
* net 1121 all_counts[22]
* net 1122 all_counts[30]
* net 1131 all_counts[142]
* net 1132 all_counts[23]
* net 1137 counter_sel[5]
* net 1148 clk
* net 1150 all_counts[63]
* net 1151 all_counts[58]
* net 1160 all_counts[144]
* net 1178 clear
* net 1179 all_counts[24]
* net 1193 all_counts[253]
* net 1194 all_counts[21]
* net 1204 all_counts[51]
* net 1205 all_counts[20]
* net 1214 all_counts[250]
* net 1215 all_counts[249]
* net 1228 all_counts[57]
* net 1242 all_counts[251]
* net 1256 all_counts[50]
* net 1264 all_counts[238]
* net 1265 all_counts[52]
* net 1279 all_counts[16]
* net 1289 all_counts[237]
* net 1290 all_counts[252]
* net 1310 all_counts[49]
* net 1311 all_counts[18]
* net 1323 all_counts[255]
* net 1324 all_counts[239]
* net 1337 all_counts[48]
* net 1338 all_counts[27]
* net 1343 all_counts[240]
* net 1344 all_counts[234]
* net 1361 all_counts[28]
* net 1372 all_counts[248]
* net 1393 all_counts[17]
* net 1401 all_counts[243]
* net 1402 all_counts[254]
* net 1414 all_counts[47]
* net 1430 all_counts[244]
* net 1440 all_counts[46]
* net 1441 all_counts[45]
* net 1454 count_value[23]
* net 1457 all_counts[247]
* net 1469 all_counts[44]
* net 1479 count_value[26]
* net 1480 count_value[25]
* net 1495 all_counts[43]
* net 1504 count_value[24]
* net 1528 all_counts[236]
* net 1529 all_counts[246]
* net 1530 all_counts[245]
* net 1554 all_counts[41]
* net 1577 all_counts[39]
* net 1578 all_counts[42]
* net 1590 count_value[28]
* net 1591 count_value[29]
* net 1599 all_counts[37]
* net 1600 all_counts[38]
* net 1614 count_value[21]
* net 1615 count_value[22]
* net 1648 all_counts[241]
* net 1649 count_value[20]
* net 1661 all_counts[40]
* net 1679 count_value[30]
* net 1680 all_counts[242]
* net 1700 all_counts[35]
* net 1718 all_counts[235]
* net 1719 count_value[31]
* net 1741 all_counts[36]
* net 1749 all_counts[218]
* net 1779 all_counts[223]
* net 1801 all_counts[219]
* net 1802 all_counts[216]
* net 1823 all_counts[34]
* net 1824 all_counts[33]
* net 1832 all_counts[220]
* net 1833 all_counts[217]
* net 1861 all_counts[213]
* net 1883 all_counts[222]
* net 1888 all_counts[32]
* net 1901 all_counts[215]
* net 1902 all_counts[221]
* net 1923 event_inc[1]
* net 1949 enable
* net 2049 all_counts[183]
* net 2050 all_counts[164]
* net 2053 count_value[11]
* net 2054 count_value[2]
* net 2062 all_counts[165]
* net 2066 count_value[10]
* net 2067 all_counts[231]
* net 2075 all_counts[209]
* net 2079 all_counts[188]
* net 2080 count_value[17]
* net 2081 count_value[12]
* net 2083 count_value[27]
* net 2084 all_counts[171]
* net 2085 all_counts[173]
* net 2089 all_counts[229]
* net 2097 count_value[6]
* net 2100 all_counts[197]
* net 2110 all_counts[192]
* net 2113 all_counts[201]
* net 2121 counter_sel[7]
* net 2122 all_counts[205]
* net 2128 all_counts[174]
* net 2129 all_counts[193]
* net 2131 count_value[3]
* net 2132 counter_sel[6]
* net 2137 count_value[5]
* net 2138 all_counts[162]
* net 2139 all_counts[181]
* net 2140 all_counts[172]
* net 2141 all_counts[175]
* net 2142 all_counts[167]
* net 2145 all_counts[230]
* net 2146 count_value[13]
* net 2147 all_counts[198]
* net 2148 all_counts[208]
* net 2149 all_counts[211]
* net 2152 all_counts[210]
* net 2153 all_counts[160]
* net 2154 all_counts[184]
* net 2155 count_value[15]
* net 2156 all_counts[196]
* net 2159 all_counts[170]
* net 2160 all_counts[187]
* net 2161 all_counts[227]
* net 2163 all_counts[180]
* net 2164 all_counts[189]
* net 2165 all_counts[194]
* net 2166 all_counts[224]
* net 2167 all_counts[178]
* net 2168 all_counts[169]
* net 2169 all_counts[182]
* net 2170 all_counts[191]
* net 2171 all_counts[199]
* net 2172 all_counts[204]
* net 2173 count_value[19]
* net 2175 event_inc[5]
* net 2176 all_counts[161]
* net 2177 all_counts[163]
* net 2178 all_counts[168]
* net 2179 all_counts[214]
* net 2180 all_counts[212]
* net 2181 all_counts[177]
* net 2182 all_counts[176]
* net 2183 all_counts[179]
* net 2184 all_counts[206]
* net 2185 count_value[16]
* net 2186 all_counts[203]
* net 2187 all_counts[19]
* net 2188 all_counts[195]
* net 2189 count_value[18]
* net 2191 all_counts[225]
* net 2192 event_inc[7]
* net 2194 count_value[8]
* net 2195 count_value[7]
* net 2196 all_counts[200]
* net 2197 all_counts[202]
* net 2198 count_value[0]
* net 2199 count_value[1]
* net 2200 all_counts[185]
* net 2201 all_counts[166]
* net 2202 all_counts[190]
* net 2203 all_counts[186]
* net 2204 event_inc[6]
* net 2205 count_value[9]
* net 2206 all_counts[226]
* net 2207 count_value[4]
* net 2208 all_counts[228]
* net 2209 all_counts[232]
* net 2210 count_value[14]
* net 2211 all_counts[233]
* net 2212 all_counts[207]
* cell instance $3 r0 *1 21.16,2.72
X$3 94 138 1 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 r0 *1 19.78,2.72
X$6 94 81 2 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $9 m0 *1 29.9,8.16
X$9 94 118 3 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $12 r0 *1 24.38,2.72
X$12 94 82 4 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $15 r0 *1 22.54,2.72
X$15 94 66 5 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $18 m0 *1 31.74,8.16
X$18 94 111 6 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $21 r0 *1 38.64,2.72
X$21 94 7 94 99 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $24 r0 *1 39.56,8.16
X$24 94 101 8 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $27 m0 *1 49.22,13.6
X$27 94 183 9 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $32 r0 *1 38.18,8.16
X$32 94 84 10 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $34 m0 *1 47.84,13.6
X$34 94 197 11 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $38 r0 *1 49.22,8.16
X$38 94 158 12 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $41 r0 *1 50.6,8.16
X$41 94 112 13 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $44 r0 *1 49.68,2.72
X$44 94 104 14 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $47 r0 *1 55.2,2.72
X$47 94 106 15 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $51 r0 *1 48.3,2.72
X$51 94 70 16 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $55 r0 *1 57.96,2.72
X$55 94 71 17 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $60 r0 *1 51.06,2.72
X$60 94 146 18 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $63 r0 *1 52.44,2.72
X$63 94 242 19 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $65 r0 *1 64.4,8.16
X$65 94 147 20 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $69 m0 *1 67.62,8.16
X$69 94 113 21 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $72 r0 *1 65.78,8.16
X$72 94 148 22 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $75 r0 *1 68.54,2.72
X$75 94 72 23 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $78 m0 *1 69,8.16
X$78 94 127 24 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $81 r0 *1 72.22,2.72
X$81 94 110 25 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $84 r0 *1 73.6,2.72
X$84 94 73 26 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $87 m0 *1 80.04,13.6
X$87 94 109 27 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $90 r0 *1 81.88,8.16
X$90 94 149 28 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $93 m0 *1 81.42,8.16
X$93 94 126 29 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $96 m0 *1 89.24,8.16
X$96 94 124 30 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $99 r0 *1 98.44,2.72
X$99 94 31 94 107 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $102 r0 *1 96.14,8.16
X$102 94 162 32 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $104 r0 *1 92.46,8.16
X$104 94 33 94 133 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $108 r0 *1 98.44,8.16
X$108 94 134 34 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $111 m0 *1 94.3,13.6
X$111 94 186 35 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $116 r0 *1 94.76,35.36
X$116 94 36 77 480 94 77 sky130_fd_sc_hd__buf_2
* cell instance $120 r0 *1 86.94,2.72
X$120 94 185 37 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $124 m0 *1 100.28,8.16
X$124 94 79 38 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $127 r0 *1 101.2,8.16
X$127 94 121 39 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $131 r0 *1 112.24,2.72
X$131 94 74 40 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $135 r0 *1 107.18,8.16
X$135 94 201 41 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $140 r0 *1 120.52,2.72
X$140 94 89 42 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $142 r0 *1 101.66,35.36
X$142 94 43 77 463 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $148 r0 *1 113.62,2.72
X$148 94 143 44 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $152 r0 *1 126.04,2.72
X$152 94 75 45 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $157 r0 *1 115,2.72
X$157 94 87 46 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $162 r0 *1 119.14,2.72
X$162 94 60 47 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $168 r0 *1 116.38,2.72
X$168 94 88 48 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $172 r0 *1 121.9,2.72
X$172 94 102 49 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $176 r0 *1 117.76,2.72
X$176 94 216 50 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $181 r0 *1 123.28,2.72
X$181 94 90 51 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $185 r0 *1 127.42,2.72
X$185 94 65 52 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $190 r0 *1 130.18,2.72
X$190 94 92 53 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $195 r0 *1 132.94,2.72
X$195 94 76 54 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $199 r0 *1 121.44,8.16
X$199 94 190 55 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $202 r0 *1 131.56,2.72
X$202 94 91 56 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $205 r0 *1 134.32,2.72
X$205 94 93 57 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $208 m0 *1 133.4,8.16
X$208 94 116 58 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $211 r0 *1 135.7,2.72
X$211 94 95 59 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $227 m0 *1 105.8,57.12
X$227 94 60 216 713 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $229 r0 *1 114.54,51.68
X$229 94 60 216 639 94 77 77 sky130_fd_sc_hd__and2_1
* cell instance $232 m0 *1 102.12,51.68
X$232 77 665 509 216 60 94 94 77 sky130_fd_sc_hd__ha_2
* cell instance $235 r0 *1 103.04,51.68
X$235 94 60 94 77 638 77 sky130_fd_sc_hd__inv_1
* cell instance $237 m0 *1 97.06,46.24
X$237 77 68 60 492 575 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $240 r0 *1 27.6,2.72
X$240 94 67 61 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $243 r0 *1 53.82,2.72
X$243 94 105 62 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $246 r0 *1 67.16,8.16
X$246 94 159 63 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $249 r0 *1 128.8,2.72
X$249 94 98 64 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $260 m0 *1 113.16,24.48
X$260 77 88 102 319 75 65 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $262 r0 *1 113.16,40.8
X$262 94 464 462 65 77 94 528 77 sky130_fd_sc_hd__a21oi_1
* cell instance $264 m0 *1 115,40.8
X$264 94 440 353 364 65 94 77 502 77 sky130_fd_sc_hd__o31ai_1
* cell instance $266 m0 *1 114.54,35.36
X$266 94 440 65 353 364 410 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $268 r0 *1 112.7,35.36
X$268 77 68 65 114 427 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $280 r0 *1 28.06,8.16
X$280 94 66 69 96 154 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $283 r0 *1 30.36,8.16
X$283 94 66 67 82 128 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $285 m0 *1 34.5,8.16
X$285 94 67 101 66 82 94 83 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $287 m0 *1 17.48,8.16
X$287 77 68 66 100 117 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $291 r0 *1 25.76,2.72
X$291 94 69 96 66 94 97 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $294 m0 *1 34.5,13.6
X$294 94 82 67 66 101 77 94 173 77 sky130_fd_sc_hd__and4_1
* cell instance $297 m0 *1 50.6,13.6
X$297 94 66 94 77 198 77 sky130_fd_sc_hd__inv_1
* cell instance $307 r0 *1 26.22,19.04
X$307 77 68 67 100 301 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $314 m0 *1 26.68,8.16
X$314 94 67 82 96 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $317 m0 *1 29.44,19.04
X$317 94 67 209 155 287 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $319 r0 *1 31.74,13.6
X$319 94 209 155 67 94 238 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $322 m0 *1 34.96,24.48
X$322 94 67 94 77 302 77 sky130_fd_sc_hd__inv_1
* cell instance $324 m0 *1 41.4,40.8
X$324 77 68 183 100 422 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $325 m0 *1 12.88,127.84
X$325 77 68 820 1635 1620 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $326 m0 *1 120.52,19.04
X$326 77 68 76 114 232 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $327 m0 *1 84.64,95.2
X$327 77 68 1124 1254 1253 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $328 m0 *1 63.94,144.16
X$328 77 68 1793 1421 1855 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $329 m0 *1 90.16,111.52
X$329 77 68 1448 1254 1510 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $330 m0 *1 91.54,100.64
X$330 77 68 1078 1254 1226 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $331 m0 *1 46,100.64
X$331 77 68 917 1154 1302 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $332 m0 *1 119.14,122.4
X$332 77 68 1494 1517 1571 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $333 m0 *1 37.26,138.72
X$333 77 68 1792 1890 1805 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $334 m0 *1 87.86,84.32
X$334 77 68 868 730 1110 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $335 r0 *1 43.24,165.92
X$335 77 68 2004 1890 2151 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $336 r0 *1 28.06,40.8
X$336 77 68 505 170 506 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $337 r0 *1 54.74,24.48
X$337 77 68 70 348 350 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $338 r0 *1 106.26,95.2
X$338 77 68 1262 1251 1308 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $339 r0 *1 50.6,111.52
X$339 77 68 1445 1154 1488 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $340 r0 *1 15.64,133.28
X$340 77 68 909 1635 1752 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $341 r0 *1 3.22,116.96
X$341 77 68 836 1403 1562 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $342 r0 *1 32.2,127.84
X$342 77 68 1602 1403 1687 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $343 r0 *1 79.58,111.52
X$343 77 68 1473 1254 1511 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $344 r0 *1 32.2,106.08
X$344 77 68 1092 1181 1378 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $345 r0 *1 109.48,106.08
X$345 77 68 1411 1251 1425 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $346 r0 *1 107.64,84.32
X$346 77 68 994 730 1128 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $364 m0 *1 58.88,122.4
X$364 77 68 1556 1421 1573 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $365 m0 *1 150.42,100.64
X$365 77 68 1286 1159 1351 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $366 m0 *1 117.3,160.48
X$366 77 68 1995 1894 1988 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $367 m0 *1 149.5,89.76
X$367 77 68 1192 1159 1190 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $368 m0 *1 12.42,51.68
X$368 77 68 547 549 652 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $369 m0 *1 89.7,122.4
X$369 77 68 1584 1254 1576 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $370 m0 *1 86.02,62.56
X$370 77 68 185 544 794 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $371 m0 *1 129.72,89.76
X$371 77 68 1129 1159 1168 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $372 m0 *1 102.12,100.64
X$372 77 68 1320 1251 1309 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $373 m0 *1 57.04,35.36
X$373 77 68 105 348 425 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $374 m0 *1 123.74,8.16
X$374 77 68 93 114 172 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $375 m0 *1 16.56,165.92
X$375 77 68 2028 1890 2106 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $376 m0 *1 129.72,122.4
X$376 77 68 1452 1251 1435 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $377 m0 *1 96.6,29.92
X$377 77 68 143 86 374 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $378 m0 *1 85.56,133.28
X$378 77 68 1668 1421 1734 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $379 m0 *1 44.62,35.36
X$379 77 68 197 100 424 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $380 m0 *1 46,8.16
X$380 77 68 112 85 123 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $381 m0 *1 142.6,111.52
X$381 77 68 1432 1159 1428 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $382 m0 *1 157.32,73.44
X$382 77 68 733 847 949 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $383 m0 *1 112.24,149.6
X$383 77 68 1828 1894 1947 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $384 m0 *1 86.48,19.04
X$384 77 68 124 85 281 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $385 m0 *1 17.48,122.4
X$385 77 68 800 1403 1592 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $386 m0 *1 40.94,89.76
X$386 77 68 708 1181 1169 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $387 m0 *1 122.82,40.8
X$387 77 68 190 492 465 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $388 m0 *1 149.04,19.04
X$388 77 68 233 262 263 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $389 m0 *1 120.98,35.36
X$389 77 68 91 114 426 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $390 m0 *1 121.9,51.68
X$390 77 68 602 492 617 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $391 m0 *1 57.96,51.68
X$391 77 68 71 348 627 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $392 m0 *1 58.88,116.96
X$392 77 68 1446 1421 1515 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $393 m0 *1 63.02,149.6
X$393 77 68 1879 1706 1892 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $394 r0 *1 5.52,106.08
X$394 77 68 907 1403 1431 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $395 r0 *1 52.44,8.16
X$395 77 68 146 85 180 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $396 r0 *1 105.8,46.24
X$396 77 68 216 492 573 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $397 r0 *1 157.32,149.6
X$397 77 68 1647 1867 1962 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $398 r0 *1 44.16,106.08
X$398 77 68 972 1154 1434 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $399 r0 *1 162.84,51.68
X$399 77 68 644 603 608 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $400 r0 *1 115.46,68
X$400 77 68 861 730 959 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $401 r0 *1 22.08,106.08
X$401 77 68 1116 1181 1406 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $402 r0 *1 158.7,40.8
X$402 77 68 418 262 476 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $403 r0 *1 135.7,100.64
X$403 77 68 1326 1159 1329 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $404 r0 *1 46.92,138.72
X$404 77 68 1807 1706 1908 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $405 r0 *1 138,149.6
X$405 77 68 1798 1867 1917 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $406 r0 *1 129.26,165.92
X$406 77 68 1768 1894 2078 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $407 r0 *1 104.88,149.6
X$407 77 68 1956 1894 1966 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $408 r0 *1 134.78,144.16
X$408 77 68 1796 1867 1919 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $409 r0 *1 132.02,73.44
X$409 77 68 981 847 1033 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $410 r0 *1 18.4,40.8
X$410 77 68 537 170 496 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $411 r0 *1 158.7,13.6
X$411 77 68 234 262 237 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $412 r0 *1 27.6,165.92
X$412 77 68 2020 1890 2124 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $413 m0 *1 9.66,73.44
X$413 77 68 928 549 985 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $414 m0 *1 1.38,62.56
X$414 77 68 704 549 773 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $415 m0 *1 144.44,35.36
X$415 77 68 387 262 415 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $416 m0 *1 157.78,78.88
X$416 77 68 952 847 950 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $417 m0 *1 11.96,62.56
X$417 77 68 703 549 750 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $418 m0 *1 139.84,29.92
X$418 77 68 339 114 385 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $419 m0 *1 19.78,149.6
X$419 77 68 1925 1635 1889 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $420 m0 *1 157.78,51.68
X$420 77 68 650 603 605 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $421 m0 *1 3.22,29.92
X$421 77 68 332 170 370 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $422 m0 *1 7.82,19.04
X$422 77 68 252 100 268 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $423 m0 *1 144.44,51.68
X$423 77 68 604 603 643 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $424 m0 *1 157.78,155.04
X$424 77 68 1646 1867 1960 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $425 m0 *1 74.98,155.04
X$425 77 68 1990 1706 1986 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $426 m0 *1 66.7,13.6
X$426 77 68 148 85 202 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $427 m0 *1 144.44,165.92
X$427 77 68 1748 1867 2105 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $428 m0 *1 36.8,8.16
X$428 77 68 84 100 120 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $429 m0 *1 157.78,127.84
X$429 77 68 1618 1294 1651 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $430 r0 *1 57.96,165.92
X$430 77 68 1913 1706 2114 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $431 r0 *1 98.44,144.16
X$431 77 68 1770 1517 1918 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $432 r0 *1 88.78,149.6
X$432 77 68 1954 1894 1987 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $433 r0 *1 163.3,62.56
X$433 77 68 647 603 851 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $434 r0 *1 133.4,51.68
X$434 77 68 510 847 640 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $435 r0 *1 130.64,35.36
X$435 77 68 412 262 482 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $436 r0 *1 80.5,51.68
X$436 77 68 555 544 666 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $437 r0 *1 82.8,29.92
X$437 77 68 357 348 434 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $438 r0 *1 85.56,35.36
X$438 77 68 134 348 479 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $439 r0 *1 1.38,68
X$439 77 68 837 549 948 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $440 r0 *1 43.7,13.6
X$440 77 68 158 100 224 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $441 r0 *1 74.98,2.72
X$441 77 68 109 85 182 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $442 r0 *1 154.1,46.24
X$442 77 68 557 603 611 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $443 r0 *1 72.22,35.36
X$443 77 68 73 348 501 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $445 r0 *1 26.22,133.28
X$445 77 68 1755 1403 1753 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $447 r0 *1 18.4,138.72
X$447 77 68 930 1635 1834 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $450 m0 *1 117.3,29.92
X$450 77 68 98 114 372 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $455 r0 *1 21.16,144.16
X$455 77 68 887 1635 1884 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $459 m0 *1 140.3,144.16
X$459 77 68 1762 1867 1866 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $464 r0 *1 28.52,111.52
X$464 77 68 990 1403 1486 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $467 r0 *1 29.44,116.96
X$467 77 68 991 1403 1568 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $470 r0 *1 2.3,127.84
X$470 77 68 913 1635 1681 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $474 m0 *1 33.12,122.4
X$474 77 68 915 1403 1569 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $478 r0 *1 19.78,127.84
X$478 77 68 931 1635 1685 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $480 r0 *1 24.84,122.4
X$480 77 68 1443 1403 1624 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $482 r0 *1 106.26,29.92
X$482 77 68 92 86 429 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $485 r0 *1 137.54,160.48
X$485 77 68 1859 1867 2048 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $488 r0 *1 70.84,149.6
X$488 77 68 1873 1706 1965 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $491 m0 *1 74.98,149.6
X$491 77 68 1881 1706 1914 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $493 m0 *1 57.04,133.28
X$493 77 68 1606 1421 1758 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $495 r0 *1 70.84,138.72
X$495 77 68 1761 1421 1788 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $498 m0 *1 37.72,149.6
X$498 77 68 1912 1890 1906 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $501 r0 *1 161.92,144.16
X$501 77 68 1865 1294 1909 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $509 m0 *1 92.92,35.36
X$509 77 68 89 86 430 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $513 m0 *1 5.52,149.6
X$513 77 68 1075 1635 1935 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $517 m0 *1 1.38,144.16
X$517 77 68 1803 1635 1825 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $522 m0 *1 73.14,133.28
X$522 77 68 1665 1421 1760 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $526 r0 *1 20.7,160.48
X$526 77 68 2037 1890 2046 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $528 r0 *1 24.84,155.04
X$528 77 68 1991 1890 1998 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $534 r0 *1 139.38,19.04
X$534 77 68 239 114 303 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $536 r0 *1 47.84,122.4
X$536 77 68 1447 1421 1627 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $539 r0 *1 43.24,116.96
X$539 77 68 916 1154 1570 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $543 m0 *1 42.78,127.84
X$543 77 68 1603 1403 1688 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $547 r0 *1 54.74,100.64
X$547 77 68 806 1154 1332 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $561 m0 *1 62.56,100.64
X$561 77 68 1108 1254 1282 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $563 m0 *1 62.56,106.08
X$563 77 68 1077 1154 1386 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $565 r0 *1 162.84,19.04
X$565 77 68 297 262 298 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $568 r0 *1 80.96,95.2
X$568 77 68 1107 1254 1307 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $573 m0 *1 61.64,89.76
X$573 77 68 777 1154 1097 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $575 r0 *1 59.8,95.2
X$575 77 68 974 1154 1304 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $581 r0 *1 49.22,89.76
X$581 77 68 710 1154 1182 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $585 r0 *1 71.3,106.08
X$585 77 68 1184 1254 1408 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $587 r0 *1 128.34,8.16
X$587 77 68 116 114 241 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $590 r0 *1 80.96,100.64
X$590 77 68 1356 1254 1335 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $594 r0 *1 111.32,57.12
X$594 77 68 546 492 790 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $596 r0 *1 131.56,13.6
X$596 77 68 95 114 218 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $599 r0 *1 1.38,100.64
X$599 77 68 1266 1181 1312 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $602 r0 *1 138.92,165.92
X$602 77 68 1868 1867 2070 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $604 r0 *1 1.84,89.76
X$604 77 68 912 1181 1217 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $610 m0 *1 11.04,100.64
X$610 77 68 929 1181 1347 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $615 r0 *1 153.64,165.92
X$615 77 68 2014 1867 2150 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $620 m0 *1 157.32,160.48
X$620 77 68 1730 1867 2034 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $622 m0 *1 17.02,89.76
X$622 77 68 935 1181 1223 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $624 m0 *1 30.36,95.2
X$624 77 68 1060 1181 1231 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $626 r0 *1 74.52,127.84
X$626 77 68 1632 1421 1664 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $628 m0 *1 69,111.52
X$628 77 68 1516 1421 1439 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $630 m0 *1 72.22,122.4
X$630 77 68 1557 1421 1582 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $634 m0 *1 35.88,100.64
X$634 77 68 1062 1181 1350 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $636 r0 *1 162.84,155.04
X$636 77 68 1714 1867 1999 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $641 r0 *1 23.46,100.64
X$641 77 68 1094 1181 1299 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $647 m0 *1 95.68,106.08
X$647 77 68 1391 1254 1390 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $649 m0 *1 95.22,89.76
X$649 77 68 977 730 1189 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $654 m0 *1 94.76,127.84
X$654 77 68 1585 1517 1631 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $657 m0 *1 101.2,116.96
X$657 77 68 1423 1517 1547 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $663 r0 *1 85.56,122.4
X$663 77 68 1583 1254 1634 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $666 m0 *1 113.16,8.16
X$666 77 68 75 114 119 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $669 r0 *1 108.56,160.48
X$669 77 68 1946 1894 2032 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $671 r0 *1 162.84,127.84
X$671 77 68 1676 1294 1650 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $676 r0 *1 111.32,13.6
X$676 77 68 90 86 223 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $683 r0 *1 109.94,8.16
X$683 77 68 102 86 175 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $685 m0 *1 112.24,95.2
X$685 77 68 1234 1251 1306 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $688 m0 *1 119.14,89.76
X$688 77 68 1038 1251 1197 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $692 r0 *1 116.38,144.16
X$692 77 68 1895 1894 1921 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $705 m0 *1 90.62,144.16
X$705 77 68 1794 1517 1844 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $708 m0 *1 94.3,138.72
X$708 77 68 1766 1517 1811 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $710 m0 *1 157.32,29.92
X$710 77 68 367 262 368 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $713 r0 *1 106.26,116.96
X$713 77 68 1422 1517 1572 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $716 r0 *1 115.92,122.4
X$716 77 68 1475 1517 1611 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $718 m0 *1 84.64,165.92
X$718 77 68 1975 1894 2088 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $720 r0 *1 84.18,165.92
X$720 77 68 1973 1706 2086 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $723 r0 *1 161.92,35.36
X$723 77 68 443 262 451 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $727 m0 *1 70.38,165.92
X$727 77 68 1886 1706 2109 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $729 r0 *1 70.84,165.92
X$729 77 68 1774 1706 2162 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $734 r0 *1 70.84,155.04
X$734 77 68 1670 1706 2023 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $737 m0 *1 39.56,133.28
X$737 77 68 1608 1706 1725 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $740 r0 *1 102.58,2.72
X$740 77 68 87 86 78 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $742 m0 *1 102.12,8.16
X$742 77 68 88 86 177 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $744 r0 *1 163.3,95.2
X$744 77 68 1267 1294 1293 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $746 r0 *1 163.3,133.28
X$746 77 68 1747 1294 1751 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $748 r0 *1 162.84,138.72
X$748 77 68 1746 1294 1804 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $750 r0 *1 88.32,2.72
X$750 77 68 79 86 108 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $752 m0 *1 90.62,8.16
X$752 77 68 121 86 122 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $755 m0 *1 84.64,13.6
X$755 77 68 186 85 205 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $758 r0 *1 57.5,160.48
X$758 77 68 1840 1706 2076 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $760 m0 *1 37.72,155.04
X$760 77 68 1967 1890 1981 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $766 m0 *1 38.64,165.92
X$766 77 68 2036 1890 2125 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $771 r0 *1 127.42,116.96
X$771 77 68 1456 1251 1551 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $775 r0 *1 137.54,116.96
X$775 77 68 1453 1159 1520 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $778 r0 *1 116.38,165.92
X$778 77 68 1737 1894 2158 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $780 r0 *1 162.38,116.96
X$780 77 68 1429 1294 1526 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $784 r0 *1 126.04,127.84
X$784 77 68 1693 1517 1735 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $786 r0 *1 161.92,111.52
X$786 77 68 1455 1294 1481 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $788 r0 *1 163.3,89.76
X$788 77 68 1216 1159 1213 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $795 r0 *1 126.04,95.2
X$795 77 68 1263 1251 1250 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $798 m0 *1 139.84,100.64
X$798 77 68 1322 1159 1300 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $800 r0 *1 126.04,100.64
X$800 77 68 1340 1251 1330 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $802 r0 *1 163.3,106.08
X$802 77 68 1398 1294 1400 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $804 r0 *1 163.3,100.64
X$804 77 68 1345 1294 1346 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $806 r0 *1 138.92,89.76
X$806 77 68 1210 1159 1222 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $808 r0 *1 162.84,24.48
X$808 77 68 342 262 343 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $811 r0 *1 31.28,73.44
X$811 77 68 562 549 1034 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $814 m0 *1 57.5,8.16
X$814 77 68 113 85 243 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $816 r0 *1 59.34,2.72
X$816 77 68 72 85 80 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $820 m0 *1 6.44,68
X$820 77 68 878 549 1073 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $826 r0 *1 16.1,73.44
X$826 77 68 968 549 1030 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $834 m0 *1 67.62,51.68
X$834 77 68 159 544 593 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $839 r0 *1 162.84,78.88
X$839 77 68 1024 847 1027 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $841 r0 *1 162.38,84.32
X$841 77 68 1162 603 1134 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $843 m0 *1 73.14,57.12
X$843 77 68 104 544 747 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $846 m0 *1 70.38,62.56
X$846 77 68 833 544 860 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $848 r0 *1 78.66,62.56
X$848 77 68 106 492 962 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $852 r0 *1 29.44,84.32
X$852 77 68 969 620 1167 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $855 r0 *1 28.98,78.88
X$855 77 68 906 620 1035 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $858 r0 *1 17.02,78.88
X$858 77 68 971 549 1074 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $860 m0 *1 74.52,19.04
X$860 77 68 126 85 308 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $872 m0 *1 71.76,8.16
X$872 77 68 110 85 152 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $875 m0 *1 93.84,78.88
X$875 77 68 201 544 1070 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $877 r0 *1 29.44,2.72
X$877 77 68 101 100 171 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $883 r0 *1 31.28,35.36
X$883 77 68 111 100 448 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $886 r0 *1 16.56,8.16
X$886 77 68 138 170 219 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $890 m0 *1 34.96,46.24
X$890 77 68 540 549 572 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $895 r0 *1 83.72,73.44
X$895 77 68 938 544 978 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $898 r0 *1 3.68,40.8
X$898 77 68 539 170 511 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $904 m0 *1 11.96,24.48
X$904 77 68 81 170 285 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $906 r0 *1 5.98,29.92
X$906 77 68 323 170 390 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $910 r0 *1 1.38,35.36
X$910 77 68 471 170 458 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $913 m0 *1 19.78,13.6
X$913 77 68 82 100 192 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $917 r0 *1 15.64,35.36
X$917 77 68 460 170 474 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $920 r0 *1 23,29.92
X$920 77 68 118 170 419 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $923 r0 *1 27.14,24.48
X$923 77 68 334 100 345 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $927 m0 *1 13.34,40.8
X$927 77 68 538 170 475 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $932 r0 *1 50.6,40.8
X$932 77 68 242 348 488 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $941 r0 *1 75.9,24.48
X$941 77 68 149 348 375 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $943 r0 *1 75.9,40.8
X$943 77 68 127 348 630 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $947 m0 *1 65.32,29.92
X$947 77 68 147 348 373 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $950 r0 *1 103.5,73.44
X$950 77 68 921 730 1002 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $952 m0 *1 91.54,73.44
X$952 77 68 74 492 1006 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $955 r0 *1 162.84,73.44
X$955 77 68 545 603 983 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $960 r0 *1 133.86,62.56
X$960 77 68 846 847 857 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $962 r0 *1 126.04,57.12
X$962 77 68 765 730 767 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $970 r0 *1 129.26,68
X$970 77 68 899 730 958 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $973 r0 *1 141.68,84.32
X$973 77 68 1051 847 1158 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $975 m0 *1 139.84,84.32
X$975 77 68 721 847 1111 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $977 r0 *1 77.74,78.88
X$977 77 68 976 544 1173 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $980 m0 *1 84.64,46.24
X$980 77 68 162 544 629 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $982 r0 *1 51.52,84.32
X$982 77 68 805 1154 1126 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $985 m0 *1 154.1,84.32
X$985 77 68 1023 847 1091 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $991 r0 *1 161,57.12
X$991 77 68 718 603 774 94 94 77 sky130_fd_sc_hd__dfrtp_1
* cell instance $994 r0 *1 126.04,46.24
X$994 77 68 564 492 569 94 94 77 sky130_fd_sc_hd__dfrtp_2
* cell instance $997 r0 *1 43.24,46.24
X$997 77 68 554 620 621 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $1000 r0 *1 46.46,51.68
X$1000 77 68 592 348 664 94 94 77 sky130_fd_sc_hd__dfrtp_4
* cell instance $1002 r0 *1 162.38,8.16
X$1002 77 115 68 94 94 77 sky130_fd_sc_hd__buf_16
* cell instance $1011 r0 *1 24.84,13.6
X$1011 94 69 209 208 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1017 m0 *1 41.4,19.04
X$1017 94 274 94 77 69 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1019 r0 *1 43.24,2.72
X$1019 94 84 69 83 103 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1021 r0 *1 45.08,8.16
X$1021 94 112 69 144 131 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1023 r0 *1 45.54,2.72
X$1023 94 69 83 84 94 145 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1025 r0 *1 43.24,8.16
X$1025 94 69 144 112 94 130 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1037 m0 *1 58.42,24.48
X$1037 77 290 70 315 289 94 255 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $1040 m0 *1 61.64,29.92
X$1040 94 70 184 229 307 361 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1042 r0 *1 63.94,29.92
X$1042 94 70 94 77 428 77 sky130_fd_sc_hd__inv_1
* cell instance $1044 m0 *1 57.04,29.92
X$1044 94 184 160 307 70 94 77 395 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1048 r0 *1 46.92,24.48
X$1048 94 118 70 112 111 94 347 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1050 r0 *1 52.44,19.04
X$1050 94 70 112 305 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1059 m0 *1 63.94,40.8
X$1059 94 408 439 71 489 94 461 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1062 r0 *1 60.72,40.8
X$1062 94 71 240 255 507 578 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1064 r0 *1 60.26,51.68
X$1064 94 71 94 77 694 77 sky130_fd_sc_hd__inv_1
* cell instance $1066 m0 *1 60.72,46.24
X$1066 94 210 255 507 71 94 77 523 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1076 m0 *1 66.24,24.48
X$1076 94 72 94 77 328 77 sky130_fd_sc_hd__inv_1
* cell instance $1078 m0 *1 65.32,19.04
X$1078 94 72 113 146 247 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1080 r0 *1 64.4,19.04
X$1080 94 146 113 72 148 77 94 290 77 sky130_fd_sc_hd__and4_1
* cell instance $1086 r0 *1 61.18,13.6
X$1086 94 184 160 245 72 94 77 227 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1088 r0 *1 61.18,19.04
X$1088 94 113 148 72 146 94 307 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1090 m0 *1 62.56,19.04
X$1090 94 72 184 229 245 244 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1094 m0 *1 70.38,35.36
X$1094 94 73 94 77 439 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1108 r0 *1 101.66,57.12
X$1108 94 201 74 744 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1111 m0 *1 105.34,68
X$1111 77 74 185 873 201 921 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $1113 r0 *1 99.82,68
X$1113 94 74 94 77 893 77 sky130_fd_sc_hd__inv_1
* cell instance $1115 m0 *1 100.74,68
X$1115 77 74 871 201 185 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $1129 m0 *1 112.24,13.6
X$1129 94 165 75 88 187 94 164 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1132 m0 *1 117.3,13.6
X$1132 94 137 75 94 174 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1137 m0 *1 106.72,46.24
X$1137 94 490 484 75 77 94 637 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1141 m0 *1 112.24,19.04
X$1141 77 88 277 75 102 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $1143 r0 *1 101.66,13.6
X$1143 94 75 165 188 225 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1159 m0 *1 129.72,13.6
X$1159 94 91 76 190 93 94 169 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1162 r0 *1 117.3,40.8
X$1162 94 464 462 76 77 94 525 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1164 m0 *1 126.96,29.92
X$1164 94 76 190 365 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1167 r0 *1 126.04,35.36
X$1167 94 76 94 77 466 77 sky130_fd_sc_hd__inv_1
* cell instance $1169 r0 *1 127.88,19.04
X$1169 94 93 91 190 76 77 94 260 77 sky130_fd_sc_hd__and4_1
* cell instance $1171 m0 *1 118.68,19.04
X$1171 94 189 168 76 94 259 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1173 m0 *1 122.36,13.6
X$1173 94 76 190 91 167 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1175 r0 *1 121.9,13.6
X$1175 94 76 189 168 231 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1285 m0 *1 33.12,8.16
X$1285 94 99 142 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1297 m0 *1 87.4,8.16
X$1297 94 107 94 77 125 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1328 r0 *1 26.22,8.16
X$1328 94 129 97 154 77 94 117 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1329 r0 *1 32.2,8.16
X$1329 94 101 155 128 194 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1332 r0 *1 36.8,8.16
X$1332 94 84 173 156 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1333 r0 *1 40.94,8.16
X$1333 94 129 145 103 77 94 120 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1338 r0 *1 47.38,8.16
X$1338 94 129 130 131 77 94 123 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1342 r0 *1 68.54,8.16
X$1342 94 132 150 151 77 94 152 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1347 r0 *1 70.84,8.16
X$1347 77 181 85 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $1348 r0 *1 80.04,8.16
X$1348 94 132 153 251 77 94 182 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1352 r0 *1 91.08,8.16
X$1352 94 133 316 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1358 r0 *1 99.82,8.16
X$1358 94 135 179 108 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1359 r0 *1 102.58,8.16
X$1359 94 135 178 122 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1360 r0 *1 103.96,8.16
X$1360 94 176 87 94 136 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1361 r0 *1 108.56,8.16
X$1361 94 135 136 78 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1363 r0 *1 122.82,8.16
X$1363 94 137 168 167 93 94 77 141 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1368 r0 *1 126.04,8.16
X$1368 94 140 141 139 77 94 172 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1390 m0 *1 30.36,13.6
X$1390 94 129 193 194 77 94 171 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1391 m0 *1 32.2,13.6
X$1391 94 155 128 101 94 193 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1394 m0 *1 38.64,13.6
X$1394 94 158 84 195 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $1395 m0 *1 40.94,13.6
X$1395 94 158 155 156 157 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1396 m0 *1 43.24,13.6
X$1396 94 129 196 157 77 94 224 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1397 m0 *1 45.08,13.6
X$1397 94 155 156 158 94 196 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1401 m0 *1 54.74,13.6
X$1401 94 129 200 199 77 94 180 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1404 m0 *1 57.5,13.6
X$1404 94 184 160 146 94 200 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1407 m0 *1 62.1,13.6
X$1407 94 132 227 244 77 94 80 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1410 m0 *1 75.9,13.6
X$1410 94 160 204 161 109 94 77 153 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1411 m0 *1 78.66,13.6
X$1411 94 126 110 161 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1416 m0 *1 96.6,13.6
X$1416 94 203 79 94 179 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1418 m0 *1 100.28,13.6
X$1418 94 250 121 178 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1419 m0 *1 103.5,13.6
X$1419 94 135 163 177 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1421 m0 *1 105.34,13.6
X$1421 94 225 88 94 163 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1422 m0 *1 108.56,13.6
X$1422 94 164 102 94 166 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1424 m0 *1 114.54,13.6
X$1424 94 135 166 175 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1425 m0 *1 115.92,13.6
X$1425 94 135 174 119 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1426 m0 *1 120.52,13.6
X$1426 94 165 188 189 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1428 m0 *1 124.2,13.6
X$1428 94 93 137 168 167 139 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1429 m0 *1 126.96,13.6
X$1429 94 189 168 169 116 94 77 191 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1457 r0 *1 17.02,13.6
X$1457 94 207 206 219 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1458 r0 *1 18.4,13.6
X$1458 94 220 138 206 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1460 r0 *1 22.54,13.6
X$1460 94 207 208 192 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1464 r0 *1 30.36,13.6
X$1464 94 82 94 77 209 77 sky130_fd_sc_hd__inv_1
* cell instance $1466 r0 *1 34.5,13.6
X$1466 94 138 94 77 221 77 sky130_fd_sc_hd__inv_1
* cell instance $1468 r0 *1 36.8,13.6
X$1468 77 195 173 222 138 94 240 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $1469 r0 *1 41.4,13.6
X$1469 94 173 195 144 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1478 r0 *1 56.12,13.6
X$1478 94 146 184 210 199 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1479 r0 *1 58.42,13.6
X$1479 94 113 211 210 212 228 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1480 r0 *1 63.94,13.6
X$1480 94 113 146 245 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1482 r0 *1 65.78,13.6
X$1482 94 160 212 247 148 94 77 249 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1483 r0 *1 68.54,13.6
X$1483 94 160 213 110 94 150 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1488 r0 *1 70.84,13.6
X$1488 77 85 2223 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $1490 r0 *1 76.36,13.6
X$1490 94 109 229 204 161 251 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1491 r0 *1 79.12,13.6
X$1491 94 110 210 213 151 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1494 r0 *1 86.02,13.6
X$1494 94 207 214 205 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1496 r0 *1 89.24,13.6
X$1496 94 215 186 94 214 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1504 r0 *1 99.36,13.6
X$1504 94 187 143 165 226 94 203 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1505 r0 *1 103.5,13.6
X$1505 77 86 2219 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $1506 r0 *1 108.56,13.6
X$1506 77 79 248 143 121 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $1516 r0 *1 126.96,13.6
X$1516 94 116 189 168 169 217 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1517 r0 *1 129.72,13.6
X$1517 94 140 191 217 77 94 241 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1541 m0 *1 32.2,19.04
X$1541 77 181 100 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $1544 m0 *1 44.62,19.04
X$1544 94 101 94 77 275 77 sky130_fd_sc_hd__inv_1
* cell instance $1547 m0 *1 50.14,19.04
X$1547 94 84 94 77 276 77 sky130_fd_sc_hd__inv_1
* cell instance $1549 m0 *1 55.2,19.04
X$1549 94 158 94 77 278 77 sky130_fd_sc_hd__inv_1
* cell instance $1551 m0 *1 57.04,19.04
X$1551 94 211 160 212 113 94 77 279 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1552 m0 *1 59.8,19.04
X$1552 94 132 279 228 77 94 243 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1554 m0 *1 67.16,19.04
X$1554 94 148 229 212 247 230 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1555 m0 *1 69.92,19.04
X$1555 94 132 249 230 77 94 202 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1561 m0 *1 97.06,19.04
X$1561 94 143 79 280 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $1562 m0 *1 99.36,19.04
X$1562 94 280 226 188 165 77 94 250 77 sky130_fd_sc_hd__and4_1
* cell instance $1563 m0 *1 102.58,19.04
X$1563 77 258 86 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $1565 m0 *1 114.54,19.04
X$1565 94 135 246 223 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1574 m0 *1 142.14,19.04
X$1574 94 239 294 265 271 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1578 m0 *1 159.62,19.04
X$1578 94 140 300 269 77 94 237 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1581 m0 *1 162.84,19.04
X$1581 94 233 235 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1584 m0 *1 165.6,19.04
X$1584 94 239 236 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1587 m0 *1 171.12,19.04
X$1587 94 234 267 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1588 r0 *1 1.38,19.04
X$1588 94 252 283 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1593 r0 *1 12.42,19.04
X$1593 94 207 299 268 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1601 r0 *1 18.86,19.04
X$1601 94 252 94 77 253 77 sky130_fd_sc_hd__inv_1
* cell instance $1602 r0 *1 20.24,19.04
X$1602 94 270 254 253 286 77 220 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $1605 r0 *1 23.92,19.04
X$1605 94 81 254 286 272 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1606 r0 *1 35.88,19.04
X$1606 94 221 286 254 222 77 94 155 77 sky130_fd_sc_hd__or4b_2
* cell instance $1613 r0 *1 46.92,19.04
X$1613 77 118 315 112 111 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $1619 r0 *1 56.12,19.04
X$1619 94 240 77 210 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1620 r0 *1 57.96,19.04
X$1620 94 146 94 77 211 77 sky130_fd_sc_hd__inv_1
* cell instance $1622 r0 *1 59.8,19.04
X$1622 94 113 94 77 306 77 sky130_fd_sc_hd__inv_1
* cell instance $1625 r0 *1 68.08,19.04
X$1625 94 210 77 160 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1631 r0 *1 73.14,19.04
X$1631 94 291 160 255 126 94 77 282 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1632 r0 *1 75.9,19.04
X$1632 94 132 282 310 77 94 308 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1637 r0 *1 87.4,19.04
X$1637 94 273 256 281 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1638 r0 *1 88.78,19.04
X$1638 77 256 311 124 215 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $1645 r0 *1 101.2,19.04
X$1645 94 257 94 77 188 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1646 r0 *1 103.04,19.04
X$1646 77 124 257 186 89 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $1647 r0 *1 105.34,19.04
X$1647 94 226 165 187 248 94 176 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1650 r0 *1 109.02,19.04
X$1650 77 226 277 94 94 77 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $1651 r0 *1 113.62,19.04
X$1651 94 309 90 94 246 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1652 r0 *1 116.84,19.04
X$1652 77 77 187 137 318 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $1654 r0 *1 120.06,19.04
X$1654 94 90 98 320 94 77 77 sky130_fd_sc_hd__and2_1
* cell instance $1655 r0 *1 122.36,19.04
X$1655 94 273 259 231 77 94 232 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1657 r0 *1 124.2,19.04
X$1657 94 116 260 261 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1660 r0 *1 126.5,19.04
X$1660 94 114 2231 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1661 r0 *1 131.1,19.04
X$1661 94 137 168 261 95 94 77 326 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1662 r0 *1 133.86,19.04
X$1662 94 95 137 168 261 293 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1667 r0 *1 150.88,19.04
X$1667 94 140 321 264 77 94 263 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1670 r0 *1 153.64,19.04
X$1670 94 233 294 265 296 264 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1672 r0 *1 156.86,19.04
X$1672 94 239 94 77 266 77 sky130_fd_sc_hd__inv_1
* cell instance $1673 r0 *1 158.24,19.04
X$1673 94 266 234 322 265 269 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1690 m0 *1 8.74,24.48
X$1690 94 284 252 299 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1691 m0 *1 21.16,24.48
X$1691 94 254 304 270 284 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $1693 m0 *1 24.84,24.48
X$1693 94 254 286 81 94 324 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1694 m0 *1 26.68,24.48
X$1694 94 129 324 272 77 94 285 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1699 m0 *1 30.82,24.48
X$1699 94 129 238 287 77 94 301 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1700 m0 *1 32.66,24.48
X$1700 94 100 2227 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1704 m0 *1 38.64,24.48
X$1704 77 222 274 304 221 94 94 288 77 sky130_fd_sc_hd__or4b_1
* cell instance $1705 m0 *1 42.32,24.48
X$1705 94 288 77 254 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1706 m0 *1 44.16,24.48
X$1706 77 197 183 111 118 94 304 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $1707 m0 *1 48.76,24.48
X$1707 77 315 360 197 183 94 212 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $1708 m0 *1 53.36,24.48
X$1708 94 305 307 304 288 77 94 213 77 sky130_fd_sc_hd__or4_2
* cell instance $1710 m0 *1 57.04,24.48
X$1710 94 289 315 184 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1712 m0 *1 71.3,24.48
X$1712 94 148 94 77 329 77 sky130_fd_sc_hd__inv_1
* cell instance $1714 m0 *1 73.6,24.48
X$1714 94 110 94 77 291 77 sky130_fd_sc_hd__inv_1
* cell instance $1715 m0 *1 74.98,24.48
X$1715 94 126 291 229 255 310 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1723 m0 *1 89.7,24.48
X$1723 77 311 317 186 124 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $1724 m0 *1 94.3,24.48
X$1724 94 89 317 330 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $1726 m0 *1 97.06,24.48
X$1726 94 330 94 77 187 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1728 m0 *1 99.82,24.48
X$1728 94 318 77 165 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1731 m0 *1 103.96,24.48
X$1731 77 79 121 292 143 87 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $1733 m0 *1 109.48,24.48
X$1733 94 226 165 188 292 94 309 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1736 m0 *1 116.84,24.48
X$1736 94 90 292 337 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1738 m0 *1 119.14,24.48
X$1738 77 319 92 320 292 94 168 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $1739 m0 *1 126.96,24.48
X$1739 77 258 114 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $1740 m0 *1 136.16,24.48
X$1740 94 116 95 327 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $1744 m0 *1 141.68,24.48
X$1744 94 140 325 271 77 94 303 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1745 m0 *1 143.52,24.48
X$1745 94 294 295 239 94 325 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1748 m0 *1 149.5,24.48
X$1748 94 294 295 296 233 94 77 321 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1749 m0 *1 152.26,24.48
X$1749 94 239 234 296 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1750 m0 *1 153.64,24.48
X$1750 94 265 77 295 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1752 m0 *1 157.32,24.48
X$1752 94 266 322 295 234 94 77 300 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1765 r0 *1 10.12,24.48
X$1765 94 332 331 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1766 r0 *1 11.5,24.48
X$1766 94 333 332 358 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1773 r0 *1 16.56,24.48
X$1773 94 81 332 323 252 77 94 222 77 sky130_fd_sc_hd__and4_1
* cell instance $1774 r0 *1 19.78,24.48
X$1774 94 323 332 81 270 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1775 r0 *1 21.62,24.48
X$1775 94 312 254 304 333 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $1776 r0 *1 23.46,24.48
X$1776 94 81 94 77 312 77 sky130_fd_sc_hd__inv_1
* cell instance $1779 r0 *1 36.34,24.48
X$1779 77 286 118 111 313 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $1780 r0 *1 40.02,24.48
X$1780 94 334 142 314 288 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $1789 r0 *1 67.16,24.48
X$1789 94 160 255 351 147 94 77 352 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1797 r0 *1 73.14,24.48
X$1797 94 160 255 354 149 94 77 355 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1802 r0 *1 92,24.48
X$1802 77 134 314 318 357 316 94 94 77 sky130_fd_sc_hd__and4b_2
* cell instance $1808 r0 *1 98.44,24.48
X$1808 94 335 89 94 382 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1810 r0 *1 102.12,24.48
X$1810 94 186 124 165 335 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1812 r0 *1 104.42,24.48
X$1812 94 336 143 94 356 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1814 r0 *1 108.1,24.48
X$1814 94 165 188 226 336 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1816 r0 *1 110.86,24.48
X$1816 94 165 187 226 353 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1817 r0 *1 112.7,24.48
X$1817 77 319 92 188 318 94 340 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $1818 r0 *1 120.52,24.48
X$1818 77 319 187 318 92 94 349 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $1826 r0 *1 127.42,24.48
X$1826 77 77 320 364 292 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $1828 r0 *1 130.18,24.48
X$1828 77 327 260 320 292 94 338 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $1829 r0 *1 134.78,24.48
X$1829 94 140 326 293 77 94 218 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1833 r0 *1 142.6,24.48
X$1833 94 338 94 77 265 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $1840 r0 *1 150.88,24.48
X$1840 94 233 239 234 297 94 366 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $1844 r0 *1 156.4,24.48
X$1844 94 239 234 233 346 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1846 r0 *1 159.16,24.48
X$1846 94 322 295 346 297 94 77 344 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1850 m0 *1 12.42,29.92
X$1850 94 207 358 370 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1855 m0 *1 20.7,29.92
X$1855 94 332 94 77 377 77 sky130_fd_sc_hd__inv_1
* cell instance $1863 m0 *1 31.74,29.92
X$1863 77 345 334 142 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $1866 m0 *1 38.64,29.92
X$1866 94 142 314 334 360 77 94 77 sky130_fd_sc_hd__and3b_1
* cell instance $1869 m0 *1 43.24,29.92
X$1869 77 392 313 197 183 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $1871 m0 *1 48.3,29.92
X$1871 94 183 197 371 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1872 m0 *1 49.68,29.92
X$1872 77 347 204 307 371 288 94 94 77 sky130_fd_sc_hd__or4_4
* cell instance $1876 m0 *1 59.8,29.92
X$1876 94 132 395 361 77 94 350 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1878 m0 *1 75.9,29.92
X$1878 94 149 229 255 354 362 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1879 m0 *1 78.66,29.92
X$1879 94 132 355 362 77 94 375 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1883 m0 *1 85.1,29.92
X$1883 77 434 357 316 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $1885 m0 *1 89.7,29.92
X$1885 94 357 363 316 215 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $1887 m0 *1 92.92,29.92
X$1887 94 357 317 363 316 94 402 77 77 sky130_fd_sc_hd__nand4b_1
* cell instance $1889 m0 *1 106.26,29.92
X$1889 94 135 356 374 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1892 m0 *1 109.94,29.92
X$1892 94 336 364 92 94 409 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1894 m0 *1 112.24,29.92
X$1894 94 92 336 364 401 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1896 m0 *1 115,29.92
X$1896 94 353 337 98 94 400 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $1899 m0 *1 128.34,29.92
X$1899 94 91 364 294 365 398 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1900 m0 *1 131.1,29.92
X$1900 94 340 77 294 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1903 m0 *1 137.54,29.92
X$1903 94 349 77 322 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1906 m0 *1 150.88,29.92
X$1906 94 294 295 366 367 94 77 393 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1907 m0 *1 153.64,29.92
X$1907 94 367 340 265 366 391 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1910 m0 *1 167.44,29.92
X$1910 94 367 369 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1911 m0 *1 168.82,29.92
X$1911 94 339 389 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1913 m0 *1 171.12,29.92
X$1913 94 297 341 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1917 r0 *1 4.6,29.92
X$1917 94 323 403 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $1920 r0 *1 15.64,29.92
X$1920 94 207 376 390 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1922 r0 *1 17.48,29.92
X$1922 94 404 323 376 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $1923 r0 *1 20.7,29.92
X$1923 94 286 312 377 254 77 404 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $1924 r0 *1 32.66,29.92
X$1924 94 118 94 77 407 77 sky130_fd_sc_hd__inv_1
* cell instance $1928 r0 *1 37.26,29.92
X$1928 77 314 313 289 334 142 94 94 77 sky130_fd_sc_hd__and4b_2
* cell instance $1929 r0 *1 41.4,29.92
X$1929 94 392 360 423 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1933 r0 *1 43.7,29.92
X$1933 94 183 254 452 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1935 r0 *1 45.54,29.92
X$1935 94 129 453 378 77 94 424 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1936 r0 *1 47.38,29.92
X$1936 94 379 360 378 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $1938 r0 *1 52.44,29.92
X$1938 94 380 77 129 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $1941 r0 *1 59.34,29.92
X$1941 94 210 204 438 105 94 77 396 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1942 r0 *1 62.1,29.92
X$1942 94 132 396 455 77 94 425 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1943 r0 *1 65.32,29.92
X$1943 94 147 229 255 351 381 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1944 r0 *1 68.08,29.92
X$1944 94 132 352 381 77 94 373 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1948 r0 *1 70.84,29.92
X$1948 94 380 77 132 94 77 sky130_fd_sc_hd__buf_2
* cell instance $1950 r0 *1 73.6,29.92
X$1950 94 149 94 77 431 77 sky130_fd_sc_hd__inv_1
* cell instance $1952 r0 *1 75.9,29.92
X$1952 94 109 126 110 354 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $1954 r0 *1 78.66,29.92
X$1954 94 149 110 126 109 77 94 433 77 sky130_fd_sc_hd__and4_1
* cell instance $1957 r0 *1 92.92,29.92
X$1957 94 402 134 94 432 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $1960 r0 *1 96.6,29.92
X$1960 94 273 382 430 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $1965 r0 *1 116.84,29.92
X$1965 94 98 353 337 383 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $1966 r0 *1 119.14,29.92
X$1966 94 273 400 383 77 94 372 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1971 r0 *1 126.04,29.92
X$1971 94 364 294 365 91 94 77 399 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1972 r0 *1 128.8,29.92
X$1972 94 140 399 398 77 94 426 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1975 r0 *1 138,29.92
X$1975 94 339 349 338 397 384 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1976 r0 *1 140.76,29.92
X$1976 94 413 394 384 77 94 385 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1977 r0 *1 142.6,29.92
X$1977 94 387 340 338 386 414 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1978 r0 *1 145.36,29.92
X$1978 94 322 295 397 339 94 77 394 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1979 r0 *1 148.12,29.92
X$1979 94 294 295 386 387 94 77 421 77 sky130_fd_sc_hd__o31ai_1
* cell instance $1984 r0 *1 153.64,29.92
X$1984 94 140 393 391 77 94 368 77 sky130_fd_sc_hd__a21oi_1
* cell instance $1985 r0 *1 155.48,29.92
X$1985 77 258 262 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $1986 r0 *1 164.68,29.92
X$1986 94 297 322 265 346 388 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $1987 r0 *1 167.44,29.92
X$1987 94 140 344 388 77 94 298 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2007 m0 *1 13.34,35.36
X$2007 94 170 2228 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2008 m0 *1 14.72,35.36
X$2008 77 181 170 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $2010 m0 *1 24.84,35.36
X$2010 94 207 405 419 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2011 m0 *1 26.22,35.36
X$2011 94 323 94 77 420 77 sky130_fd_sc_hd__inv_1
* cell instance $2015 m0 *1 29.44,35.36
X$2015 94 406 407 405 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2016 m0 *1 32.66,35.36
X$2016 94 437 254 371 406 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $2020 m0 *1 38.18,35.36
X$2020 94 289 111 450 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2023 m0 *1 42.78,35.36
X$2023 94 129 423 452 77 94 422 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2024 m0 *1 54.28,35.36
X$2024 94 112 94 77 454 77 sky130_fd_sc_hd__inv_1
* cell instance $2028 m0 *1 67.62,35.36
X$2028 94 439 408 351 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2032 m0 *1 73.14,35.36
X$2032 94 354 210 431 213 77 456 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $2035 m0 *1 76.82,35.36
X$2035 94 433 94 77 408 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2036 m0 *1 78.66,35.36
X$2036 94 126 94 77 436 77 sky130_fd_sc_hd__inv_1
* cell instance $2037 m0 *1 80.04,35.36
X$2037 94 109 94 77 435 77 sky130_fd_sc_hd__inv_1
* cell instance $2043 m0 *1 90.16,35.36
X$2043 94 273 432 479 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2049 m0 *1 108.56,35.36
X$2049 94 273 409 401 77 94 429 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2054 m0 *1 113.16,35.36
X$2054 94 92 94 77 440 77 sky130_fd_sc_hd__inv_1
* cell instance $2055 m0 *1 117.3,35.36
X$2055 94 273 502 410 77 94 427 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2060 m0 *1 136.62,35.36
X$2060 94 412 340 338 411 481 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2062 m0 *1 139.84,35.36
X$2062 94 294 265 411 412 94 77 457 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2063 m0 *1 142.6,35.36
X$2063 94 413 421 414 77 94 415 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2065 m0 *1 155.48,35.36
X$2065 77 262 2216 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $2066 m0 *1 160.54,35.36
X$2066 94 322 295 416 342 94 77 417 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2067 m0 *1 163.3,35.36
X$2067 94 322 295 449 443 94 77 495 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2070 m0 *1 167.44,35.36
X$2070 94 413 417 445 77 94 343 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2071 m0 *1 169.28,35.36
X$2071 94 418 446 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2073 m0 *1 171.12,35.36
X$2073 94 443 447 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2075 r0 *1 13.8,35.36
X$2075 94 207 473 474 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2089 r0 *1 45.08,35.36
X$2089 94 197 254 453 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2091 r0 *1 47.38,35.36
X$2091 94 197 94 77 379 77 sky130_fd_sc_hd__inv_1
* cell instance $2096 r0 *1 60.26,35.36
X$2096 94 105 229 204 438 455 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2099 r0 *1 64.4,35.36
X$2099 94 439 147 408 438 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2106 r0 *1 70.84,35.36
X$2106 94 359 439 478 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2122 r0 *1 122.82,35.36
X$2122 94 466 190 364 322 485 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2127 r0 *1 127.42,35.36
X$2127 94 466 364 322 190 94 77 500 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2130 r0 *1 140.3,35.36
X$2130 94 413 457 481 77 94 482 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2132 r0 *1 142.6,35.36
X$2132 94 442 387 339 441 94 411 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2133 r0 *1 144.9,35.36
X$2133 94 387 442 441 397 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2135 r0 *1 147.66,35.36
X$2135 94 342 418 443 367 77 94 441 77 sky130_fd_sc_hd__and4_1
* cell instance $2139 r0 *1 150.88,35.36
X$2139 94 418 367 443 442 94 416 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2141 r0 *1 153.64,35.36
X$2141 94 294 295 444 418 94 77 497 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2142 r0 *1 156.4,35.36
X$2142 94 342 349 265 416 445 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2143 r0 *1 159.16,35.36
X$2143 94 418 340 265 444 468 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2147 m0 *1 3.68,40.8
X$2147 94 552 471 94 459 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $2148 m0 *1 6.9,40.8
X$2148 94 486 459 458 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2150 m0 *1 10.12,40.8
X$2150 94 472 460 94 473 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $2158 m0 *1 32.66,40.8
X$2158 94 111 94 77 437 77 sky130_fd_sc_hd__inv_1
* cell instance $2162 m0 *1 40.02,40.8
X$2162 94 486 450 448 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2165 m0 *1 54.74,40.8
X$2165 94 487 498 499 77 94 488 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2167 m0 *1 57.04,40.8
X$2167 94 242 240 213 461 499 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2168 m0 *1 59.8,40.8
X$2168 94 240 77 229 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2172 m0 *1 66.7,40.8
X$2172 94 127 159 105 147 77 94 489 77 sky130_fd_sc_hd__and4_1
* cell instance $2174 m0 *1 70.84,40.8
X$2174 94 348 2225 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2175 m0 *1 72.22,40.8
X$2175 77 181 348 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $2185 m0 *1 100.74,40.8
X$2185 94 464 186 462 77 94 483 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2187 m0 *1 104.42,40.8
X$2187 94 463 77 462 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2188 m0 *1 106.26,40.8
X$2188 94 463 77 484 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2192 m0 *1 112.7,40.8
X$2192 94 464 462 90 77 94 729 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2197 m0 *1 120.98,40.8
X$2197 94 273 500 485 77 94 465 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2205 m0 *1 144.44,40.8
X$2205 94 442 441 386 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2208 m0 *1 149.96,40.8
X$2208 94 297 233 234 239 77 94 477 77 sky130_fd_sc_hd__and4_1
* cell instance $2209 m0 *1 153.18,40.8
X$2209 77 442 477 94 94 77 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $2210 m0 *1 157.78,40.8
X$2210 94 367 442 449 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2211 m0 *1 159.16,40.8
X$2211 94 443 322 265 449 467 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2212 m0 *1 161.92,40.8
X$2212 94 413 497 468 77 94 476 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2213 m0 *1 163.76,40.8
X$2213 94 413 495 467 77 94 451 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2214 m0 *1 165.6,40.8
X$2214 94 412 494 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2216 m0 *1 167.44,40.8
X$2216 94 387 470 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2219 m0 *1 171.12,40.8
X$2219 94 342 469 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2220 r0 *1 1.38,40.8
X$2220 94 460 503 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2223 r0 *1 13.8,40.8
X$2223 94 207 512 475 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2230 r0 *1 17.02,40.8
X$2230 94 486 513 496 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2239 r0 *1 47.84,40.8
X$2239 94 487 77 135 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2242 r0 *1 63.94,40.8
X$2242 94 439 408 489 507 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2245 r0 *1 67.16,40.8
X$2245 94 159 105 147 439 77 94 526 77 sky130_fd_sc_hd__and4_1
* cell instance $2251 r0 *1 71.76,40.8
X$2251 77 501 478 581 456 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $2256 r0 *1 94.3,40.8
X$2256 94 490 484 134 77 94 531 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2260 r0 *1 96.14,40.8
X$2260 94 480 77 490 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2262 r0 *1 98.44,40.8
X$2262 94 480 484 143 77 94 533 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2263 r0 *1 100.28,40.8
X$2263 94 480 77 464 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2265 r0 *1 103.96,40.8
X$2265 94 464 462 87 77 94 535 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2266 r0 *1 105.8,40.8
X$2266 94 490 484 88 77 94 534 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2267 r0 *1 107.64,40.8
X$2267 94 480 484 102 77 94 677 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2268 r0 *1 109.48,40.8
X$2268 94 463 77 493 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2269 r0 *1 111.32,40.8
X$2269 94 480 77 491 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2270 r0 *1 115,40.8
X$2270 94 464 462 98 77 94 527 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2273 r0 *1 119.6,40.8
X$2273 94 491 462 91 77 94 1040 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2274 r0 *1 121.44,40.8
X$2274 94 491 462 190 77 94 810 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2284 r0 *1 135.24,40.8
X$2284 94 490 484 412 77 94 641 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2286 r0 *1 138.92,40.8
X$2286 94 490 484 339 77 94 521 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2288 r0 *1 142.6,40.8
X$2288 94 490 484 387 77 94 519 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2289 r0 *1 144.44,40.8
X$2289 94 491 493 239 77 94 518 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2290 r0 *1 146.28,40.8
X$2290 94 490 493 367 77 94 811 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2291 r0 *1 148.12,40.8
X$2291 94 491 493 234 77 94 516 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2292 r0 *1 149.96,40.8
X$2292 94 491 493 233 77 94 514 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2301 r0 *1 155.02,40.8
X$2301 94 367 443 442 444 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2305 r0 *1 171.12,40.8
X$2305 94 510 606 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2306 m0 *1 1.38,46.24
X$2306 94 547 550 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2307 m0 *1 2.76,46.24
X$2307 94 505 561 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2308 m0 *1 4.14,46.24
X$2308 94 537 585 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2309 m0 *1 5.52,46.24
X$2309 94 538 536 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2310 m0 *1 6.9,46.24
X$2310 94 539 504 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2311 m0 *1 8.28,46.24
X$2311 94 140 566 567 77 94 511 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2313 m0 *1 11.04,46.24
X$2313 94 651 538 94 512 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $2318 m0 *1 23,46.24
X$2318 94 548 537 513 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2322 m0 *1 29.44,46.24
X$2322 94 207 570 506 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2327 m0 *1 46.92,46.24
X$2327 94 380 77 273 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2330 m0 *1 52.44,46.24
X$2330 94 183 94 77 574 77 sky130_fd_sc_hd__inv_1
* cell instance $2334 m0 *1 57.04,46.24
X$2334 94 210 213 461 242 94 77 498 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2337 m0 *1 65.32,46.24
X$2337 94 439 94 77 508 77 sky130_fd_sc_hd__inv_1
* cell instance $2338 m0 *1 66.7,46.24
X$2338 94 105 439 147 408 94 541 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2340 m0 *1 69.92,46.24
X$2340 94 159 229 255 541 580 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2342 m0 *1 73.14,46.24
X$2342 94 408 526 542 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2343 m0 *1 74.52,46.24
X$2343 94 127 229 204 542 582 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2344 m0 *1 77.28,46.24
X$2344 94 543 94 77 207 77 sky130_fd_sc_hd__buf_4
* cell instance $2347 m0 *1 81.42,46.24
X$2347 94 543 94 77 140 77 sky130_fd_sc_hd__buf_4
* cell instance $2351 m0 *1 95.22,46.24
X$2351 94 490 484 89 77 94 530 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2352 m0 *1 108.56,46.24
X$2352 94 491 493 124 77 94 532 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2358 m0 *1 113.62,46.24
X$2358 94 464 462 92 77 94 529 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2361 m0 *1 117.76,46.24
X$2361 94 462 464 418 94 571 77 77 sky130_fd_sc_hd__a21oi_2
* cell instance $2364 m0 *1 123.28,46.24
X$2364 94 491 493 116 77 94 524 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2367 m0 *1 126.5,46.24
X$2367 94 491 493 93 77 94 522 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2373 m0 *1 140.3,46.24
X$2373 94 491 493 95 77 94 1061 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2375 m0 *1 142.6,46.24
X$2375 94 490 484 342 77 94 520 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2377 m0 *1 146.28,46.24
X$2377 94 490 493 443 77 94 517 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2380 m0 *1 149.5,46.24
X$2380 94 491 493 297 77 94 515 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2389 m0 *1 168.82,46.24
X$2389 94 546 685 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2391 m0 *1 171.12,46.24
X$2391 94 718 563 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2392 r0 *1 1.38,46.24
X$2392 94 471 584 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2393 r0 *1 2.76,46.24
X$2393 94 562 631 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2394 r0 *1 4.14,46.24
X$2394 94 551 553 552 539 94 77 566 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2395 r0 *1 6.9,46.24
X$2395 94 539 551 553 552 567 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2396 r0 *1 9.66,46.24
X$2396 94 609 547 94 610 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $2404 r0 *1 21.16,46.24
X$2404 77 538 537 547 471 94 587 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $2405 r0 *1 25.76,46.24
X$2405 94 471 547 614 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2408 r0 *1 29.44,46.24
X$2408 94 616 505 570 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2412 r0 *1 35.88,46.24
X$2412 94 135 618 572 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2418 r0 *1 53.82,46.24
X$2418 94 624 592 576 626 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $2420 r0 *1 56.58,46.24
X$2420 94 242 94 77 577 77 sky130_fd_sc_hd__inv_1
* cell instance $2421 r0 *1 57.96,46.24
X$2421 94 105 94 77 628 77 sky130_fd_sc_hd__inv_1
* cell instance $2423 r0 *1 61.18,46.24
X$2423 94 487 523 578 77 94 627 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2426 r0 *1 67.62,46.24
X$2426 94 210 255 541 159 94 77 579 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2430 r0 *1 70.84,46.24
X$2430 94 487 579 580 77 94 593 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2432 r0 *1 73.14,46.24
X$2432 94 601 508 581 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2434 r0 *1 74.98,46.24
X$2434 94 210 204 542 127 94 77 583 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2435 r0 *1 77.74,46.24
X$2435 94 487 583 582 77 94 630 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2438 r0 *1 82.34,46.24
X$2438 94 543 77 413 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2441 r0 *1 86.48,46.24
X$2441 94 487 77 556 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2443 r0 *1 89.7,46.24
X$2443 94 555 509 363 125 94 668 77 77 sky130_fd_sc_hd__nand4b_1
* cell instance $2444 r0 *1 92.92,46.24
X$2444 94 555 363 125 598 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2445 r0 *1 95.68,46.24
X$2445 94 162 94 77 623 77 sky130_fd_sc_hd__inv_1
* cell instance $2452 r0 *1 100.74,46.24
X$2452 94 135 622 575 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2457 r0 *1 121.9,46.24
X$2457 94 556 663 617 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2461 r0 *1 123.74,46.24
X$2461 94 556 599 569 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2465 r0 *1 137.54,46.24
X$2465 94 510 94 77 568 77 sky130_fd_sc_hd__inv_1
* cell instance $2466 r0 *1 138.92,46.24
X$2466 94 380 568 615 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2468 r0 *1 141.22,46.24
X$2468 94 601 510 613 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2479 r0 *1 163.76,46.24
X$2479 94 558 559 719 77 94 608 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2480 r0 *1 165.6,46.24
X$2480 94 564 565 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2482 r0 *1 167.44,46.24
X$2482 94 557 560 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2484 r0 *1 169.28,46.24
X$2484 94 604 645 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2486 r0 *1 171.12,46.24
X$2486 94 545 607 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2494 m0 *1 2.3,51.68
X$2494 94 554 592 553 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2495 m0 *1 3.68,51.68
X$2495 94 538 537 547 471 77 94 648 77 sky130_fd_sc_hd__and4_1
* cell instance $2496 m0 *1 6.9,51.68
X$2496 94 586 632 505 648 94 472 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2497 m0 *1 9.2,51.68
X$2497 94 632 471 586 609 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2498 m0 *1 11.04,51.68
X$2498 94 486 610 652 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2501 m0 *1 23.46,51.68
X$2501 94 654 547 634 656 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2503 m0 *1 27.14,51.68
X$2503 94 659 614 635 548 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $2506 m0 *1 29.9,51.68
X$2506 94 659 587 635 616 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $2508 m0 *1 32.2,51.68
X$2508 94 540 562 635 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2509 m0 *1 33.58,51.68
X$2509 94 706 540 618 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2511 m0 *1 37.26,51.68
X$2511 94 635 587 659 588 77 589 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $2513 m0 *1 40.48,51.68
X$2513 94 589 554 590 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2515 m0 *1 44.62,51.68
X$2515 94 273 590 621 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2518 m0 *1 51.52,51.68
X$2518 94 554 94 77 624 77 sky130_fd_sc_hd__inv_1
* cell instance $2519 m0 *1 52.9,51.68
X$2519 94 624 576 592 94 625 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $2520 m0 *1 54.74,51.68
X$2520 94 273 625 626 77 94 664 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2528 m0 *1 84.64,51.68
X$2528 77 666 555 125 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $2529 m0 *1 88.78,51.68
X$2529 94 556 594 629 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2530 m0 *1 90.16,51.68
X$2530 94 668 623 594 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2532 m0 *1 94.3,51.68
X$2532 77 597 600 667 595 531 623 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2534 m0 *1 98.9,51.68
X$2534 94 598 638 622 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2535 m0 *1 107.64,51.68
X$2535 77 700 665 216 598 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $2540 m0 *1 119.6,51.68
X$2540 94 602 94 77 619 77 sky130_fd_sc_hd__inv_1
* cell instance $2545 m0 *1 134.78,51.68
X$2545 77 596 600 612 595 641 568 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2548 m0 *1 139.84,51.68
X$2548 77 640 613 615 661 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $2551 m0 *1 154.1,51.68
X$2551 94 557 94 77 658 77 sky130_fd_sc_hd__inv_1
* cell instance $2552 m0 *1 155.48,51.68
X$2552 94 558 657 655 77 94 611 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2555 m0 *1 167.44,51.68
X$2555 94 602 646 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2557 m0 *1 169.74,51.68
X$2557 94 644 649 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2558 m0 *1 171.12,51.68
X$2558 94 647 772 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2559 r0 *1 1.38,51.68
X$2559 94 554 670 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2560 r0 *1 2.76,51.68
X$2560 77 547 671 471 537 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $2561 r0 *1 5.06,51.68
X$2561 94 540 562 586 552 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2562 r0 *1 6.9,51.68
X$2562 94 505 460 648 551 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2564 r0 *1 9.66,51.68
X$2564 94 632 586 671 651 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2570 r0 *1 17.48,51.68
X$2570 94 654 537 634 687 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2571 r0 *1 20.24,51.68
X$2571 77 687 377 636 673 686 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2572 r0 *1 23.92,51.68
X$2572 77 656 312 591 673 689 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2573 r0 *1 27.6,51.68
X$2573 94 654 471 634 692 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2574 r0 *1 30.36,51.68
X$2574 77 692 407 662 673 691 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2577 r0 *1 35.42,51.68
X$2577 94 505 460 588 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2579 r0 *1 37.26,51.68
X$2579 94 632 94 77 693 77 sky130_fd_sc_hd__inv_1
* cell instance $2592 r0 *1 65.32,51.68
X$2592 94 159 94 77 695 77 sky130_fd_sc_hd__inv_1
* cell instance $2593 r0 *1 66.7,51.68
X$2593 94 127 94 77 696 77 sky130_fd_sc_hd__inv_1
* cell instance $2603 r0 *1 89.7,51.68
X$2603 77 162 699 701 555 125 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $2604 r0 *1 93.38,51.68
X$2604 94 555 162 363 125 94 674 77 77 sky130_fd_sc_hd__nand4b_1
* cell instance $2611 r0 *1 98.9,51.68
X$2611 77 591 600 675 595 637 619 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2612 r0 *1 104.42,51.68
X$2612 77 636 600 676 595 534 678 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2613 r0 *1 108.56,51.68
X$2613 94 556 700 573 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2616 r0 *1 112.24,51.68
X$2616 94 697 639 698 829 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2620 r0 *1 118.22,51.68
X$2620 94 679 619 663 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2621 r0 *1 121.44,51.68
X$2621 94 722 678 599 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2630 r0 *1 145.36,51.68
X$2630 94 558 660 680 77 94 643 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2631 r0 *1 147.2,51.68
X$2631 94 642 681 682 604 94 77 660 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2632 r0 *1 149.96,51.68
X$2632 94 683 642 658 681 77 661 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $2637 r0 *1 153.64,51.68
X$2637 94 684 681 683 557 94 77 657 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2638 r0 *1 156.4,51.68
X$2638 94 557 716 690 683 655 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2639 r0 *1 159.16,51.68
X$2639 94 684 681 688 650 94 77 653 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2647 m0 *1 1.38,57.12
X$2647 94 703 723 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2648 m0 *1 2.76,57.12
X$2648 94 708 702 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2650 m0 *1 5.06,57.12
X$2650 94 540 669 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2652 m0 *1 6.9,57.12
X$2652 77 703 314 586 704 672 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $2654 m0 *1 11.5,57.12
X$2654 94 363 672 704 706 77 94 77 sky130_fd_sc_hd__and3b_1
* cell instance $2656 m0 *1 15.64,57.12
X$2656 94 632 706 776 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2659 m0 *1 19.78,57.12
X$2659 94 705 538 634 737 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2660 m0 *1 22.54,57.12
X$2660 94 654 703 634 738 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2661 m0 *1 25.3,57.12
X$2661 77 738 437 597 673 707 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2665 m0 *1 32.2,57.12
X$2665 77 725 632 540 562 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $2667 m0 *1 37.72,57.12
X$2667 94 693 659 587 588 720 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2672 m0 *1 50.14,57.12
X$2672 94 654 708 634 742 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2673 m0 *1 52.9,57.12
X$2673 77 742 577 596 673 709 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2677 m0 *1 59.8,57.12
X$2677 94 654 710 634 743 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2678 m0 *1 62.56,57.12
X$2678 77 743 696 712 673 711 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2689 m0 *1 94.76,57.12
X$2689 77 662 600 746 595 530 697 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2690 m0 *1 98.9,57.12
X$2690 94 701 77 698 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2695 m0 *1 108.56,57.12
X$2695 94 492 94 77 77 sky130_fd_sc_hd__clkinv_2
* cell instance $2696 m0 *1 110.4,57.12
X$2696 94 546 94 77 697 77 sky130_fd_sc_hd__inv_1
* cell instance $2698 m0 *1 112.24,57.12
X$2698 77 258 492 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $2699 m0 *1 121.44,57.12
X$2699 94 639 546 602 698 94 722 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2700 m0 *1 123.74,57.12
X$2700 94 546 509 698 679 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2701 m0 *1 125.58,57.12
X$2701 94 564 94 77 678 77 sky130_fd_sc_hd__inv_1
* cell instance $2702 m0 *1 126.96,57.12
X$2702 77 768 698 509 721 94 716 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $2709 m0 *1 141.22,57.12
X$2709 77 712 600 740 595 519 714 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2711 m0 *1 145.36,57.12
X$2711 94 604 94 77 714 77 sky130_fd_sc_hd__inv_1
* cell instance $2712 m0 *1 146.74,57.12
X$2712 94 604 732 690 682 680 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2713 m0 *1 149.5,57.12
X$2713 94 644 650 715 682 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2715 m0 *1 152.26,57.12
X$2715 94 604 644 650 715 94 683 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2716 m0 *1 154.56,57.12
X$2716 94 716 94 77 684 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2717 m0 *1 156.4,57.12
X$2717 94 644 715 688 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2718 m0 *1 157.78,57.12
X$2718 94 650 716 690 688 736 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2719 m0 *1 160.54,57.12
X$2719 94 644 642 690 717 719 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2720 m0 *1 163.3,57.12
X$2720 94 642 681 717 644 94 77 559 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2723 m0 *1 167.44,57.12
X$2723 94 650 734 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2724 m0 *1 168.82,57.12
X$2724 94 721 816 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2726 m0 *1 170.66,57.12
X$2726 94 765 735 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2728 r0 *1 1.38,57.12
X$2728 94 592 749 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2729 r0 *1 2.76,57.12
X$2729 94 817 672 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2731 r0 *1 4.6,57.12
X$2731 77 773 704 672 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $2732 r0 *1 8.74,57.12
X$2732 77 659 704 703 699 672 94 94 77 sky130_fd_sc_hd__nand4b_2
* cell instance $2736 r0 *1 15.64,57.12
X$2736 94 776 703 94 835 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $2738 r0 *1 19.32,57.12
X$2738 94 777 778 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2741 r0 *1 22.08,57.12
X$2741 77 737 420 739 463 724 752 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2744 r0 *1 27.14,57.12
X$2744 94 705 505 634 779 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2746 r0 *1 31.74,57.12
X$2746 77 780 562 725 706 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $2748 r0 *1 36.34,57.12
X$2748 94 505 540 562 460 94 726 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2750 r0 *1 39.1,57.12
X$2750 94 659 587 782 726 781 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2754 r0 *1 43.24,57.12
X$2754 77 539 592 554 94 782 94 77 sky130_fd_sc_hd__nand3_4
* cell instance $2757 r0 *1 51.98,57.12
X$2757 94 720 77 576 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2760 r0 *1 57.04,57.12
X$2760 94 463 77 673 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2762 r0 *1 59.34,57.12
X$2762 77 786 694 741 673 785 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2764 r0 *1 63.48,57.12
X$2764 77 787 695 727 673 760 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2765 r0 *1 67.16,57.12
X$2765 94 147 94 77 789 77 sky130_fd_sc_hd__inv_1
* cell instance $2770 r0 *1 74.52,57.12
X$2770 94 863 104 761 762 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $2771 r0 *1 76.82,57.12
X$2771 94 413 792 762 77 94 747 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2775 r0 *1 85.1,57.12
X$2775 94 543 77 558 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2778 r0 *1 93.38,57.12
X$2778 94 556 745 794 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2779 r0 *1 94.76,57.12
X$2779 94 480 77 600 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2784 r0 *1 98.44,57.12
X$2784 94 764 185 745 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2785 r0 *1 103.04,57.12
X$2785 94 744 674 713 728 77 764 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $2786 r0 *1 105.34,57.12
X$2786 94 713 674 728 795 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $2789 r0 *1 108.56,57.12
X$2789 94 713 674 546 94 791 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $2791 r0 *1 121.9,57.12
X$2791 94 765 94 77 788 77 sky130_fd_sc_hd__inv_1
* cell instance $2797 r0 *1 136.16,57.12
X$2797 94 546 602 564 77 94 769 77 sky130_fd_sc_hd__and3_2
* cell instance $2798 r0 *1 138.92,57.12
X$2798 77 741 600 784 595 521 658 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2799 r0 *1 142.6,57.12
X$2799 77 727 600 783 595 520 731 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2801 r0 *1 146.74,57.12
X$2801 94 732 77 642 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2802 r0 *1 148.58,57.12
X$2802 94 650 94 77 731 77 sky130_fd_sc_hd__inv_1
* cell instance $2803 r0 *1 149.96,57.12
X$2803 94 644 94 77 770 77 sky130_fd_sc_hd__inv_1
* cell instance $2805 r0 *1 151.34,57.12
X$2805 94 558 653 736 77 94 605 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2808 r0 *1 154.56,57.12
X$2808 94 647 718 733 545 77 94 715 77 sky130_fd_sc_hd__and4_1
* cell instance $2809 r0 *1 157.78,57.12
X$2809 94 545 733 771 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $2810 r0 *1 159.16,57.12
X$2810 94 603 94 77 77 sky130_fd_sc_hd__clkinv_2
* cell instance $2811 r0 *1 170.2,57.12
X$2811 94 733 775 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2828 m0 *1 22.08,62.56
X$2828 77 779 253 757 463 751 752 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2833 m0 *1 29.44,62.56
X$2833 94 705 554 753 821 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2835 m0 *1 33.12,62.56
X$2835 94 705 460 753 822 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2837 m0 *1 36.34,62.56
X$2837 94 705 94 77 654 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2840 m0 *1 39.56,62.56
X$2840 94 754 539 801 825 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2841 m0 *1 42.32,62.56
X$2841 94 755 540 801 826 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2842 m0 *1 45.08,62.56
X$2842 77 826 379 759 802 756 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2843 m0 *1 48.76,62.56
X$2843 94 753 77 634 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2844 m0 *1 50.6,62.56
X$2844 94 798 77 633 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2847 m0 *1 53.82,62.56
X$2847 94 720 77 804 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2849 m0 *1 57.04,62.56
X$2849 94 654 805 634 786 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2851 m0 *1 60.72,62.56
X$2851 94 654 806 634 787 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2854 m0 *1 64.86,62.56
X$2854 77 883 508 793 673 803 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2862 m0 *1 95.68,62.56
X$2862 77 757 600 832 808 533 763 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2863 m0 *1 99.82,62.56
X$2863 94 201 94 77 763 77 sky130_fd_sc_hd__inv_1
* cell instance $2865 m0 *1 102.12,62.56
X$2865 94 808 77 595 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2869 m0 *1 107.18,62.56
X$2869 77 739 600 830 808 677 788 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2872 m0 *1 112.24,62.56
X$2872 94 413 791 829 77 94 790 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2875 m0 *1 119.6,62.56
X$2875 94 765 564 602 546 77 94 828 77 sky130_fd_sc_hd__and4_1
* cell instance $2876 m0 *1 122.82,62.56
X$2876 94 827 788 766 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $2877 m0 *1 126.04,62.56
X$2877 94 556 766 767 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2879 m0 *1 127.88,62.56
X$2879 94 698 721 639 768 94 732 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2881 m0 *1 130.64,62.56
X$2881 77 765 564 602 546 94 728 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $2882 m0 *1 135.24,62.56
X$2882 94 413 824 823 77 94 857 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2891 m0 *1 155.48,62.56
X$2891 94 718 545 733 647 94 717 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $2892 m0 *1 157.78,62.56
X$2892 77 258 603 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $2894 m0 *1 167.44,62.56
X$2894 94 642 681 771 718 94 77 819 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2895 m0 *1 170.2,62.56
X$2895 94 558 819 818 77 94 774 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2897 r0 *1 1.38,62.56
X$2897 94 748 94 817 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $2898 r0 *1 5.06,62.56
X$2898 77 753 796 94 94 77 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $2899 r0 *1 9.66,62.56
X$2899 94 710 834 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2901 r0 *1 11.96,62.56
X$2901 94 852 835 750 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $2902 r0 *1 13.34,62.56
X$2902 94 798 836 754 77 94 724 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2907 r0 *1 15.64,62.56
X$2907 77 549 2224 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $2908 r0 *1 20.7,62.56
X$2908 94 799 820 754 77 94 686 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2909 r0 *1 22.54,62.56
X$2909 94 799 837 838 77 94 709 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2910 r0 *1 24.38,62.56
X$2910 94 799 878 838 77 94 760 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2912 r0 *1 27.14,62.56
X$2912 94 798 800 754 77 94 839 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2913 r0 *1 28.98,62.56
X$2913 77 821 209 807 463 839 752 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2915 r0 *1 36.34,62.56
X$2915 94 705 94 77 754 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2916 r0 *1 38.18,62.56
X$2916 94 752 1443 755 77 94 853 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2917 r0 *1 40.02,62.56
X$2917 94 754 592 801 914 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2922 r0 *1 43.24,62.56
X$2922 77 825 198 872 802 840 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2923 r0 *1 46.92,62.56
X$2923 94 753 77 801 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2924 r0 *1 48.76,62.56
X$2924 94 753 77 889 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2925 r0 *1 50.6,62.56
X$2925 94 754 104 801 856 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2929 r0 *1 56.58,62.56
X$2929 77 882 628 842 802 841 758 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $2932 r0 *1 62.1,62.56
X$2932 94 654 777 889 858 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $2933 r0 *1 64.86,62.56
X$2933 77 858 789 855 673 859 633 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2939 r0 *1 70.84,62.56
X$2939 94 576 869 833 94 831 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $2940 r0 *1 72.68,62.56
X$2940 94 413 831 881 77 94 860 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2941 r0 *1 74.52,62.56
X$2941 94 833 94 77 863 77 sky130_fd_sc_hd__inv_1
* cell instance $2942 r0 *1 75.9,62.56
X$2942 94 863 761 104 94 792 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $2944 r0 *1 89.24,62.56
X$2944 94 463 77 802 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2945 r0 *1 91.08,62.56
X$2945 94 544 94 77 77 sky130_fd_sc_hd__clkinv_2
* cell instance $2946 r0 *1 92.92,62.56
X$2946 94 480 802 79 77 94 892 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2947 r0 *1 94.76,62.56
X$2947 94 480 802 121 77 94 925 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2951 r0 *1 96.6,62.56
X$2951 94 185 94 77 843 77 sky130_fd_sc_hd__inv_1
* cell instance $2954 r0 *1 100.28,62.56
X$2954 77 759 638 844 809 483 845 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2956 r0 *1 104.88,62.56
X$2956 94 480 77 845 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $2957 r0 *1 107.64,62.56
X$2957 94 480 77 812 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2961 r0 *1 114.54,62.56
X$2961 77 842 809 1355 571 770 845 94 94 77 sky130_fd_sc_hd__a221oi_4
* cell instance $2965 r0 *1 124.2,62.56
X$2965 94 861 94 77 862 77 sky130_fd_sc_hd__inv_1
* cell instance $2968 r0 *1 126.5,62.56
X$2968 94 509 698 769 827 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $2971 r0 *1 131.1,62.56
X$2971 94 875 728 880 846 94 77 824 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2972 r0 *1 143.52,62.56
X$2972 77 793 812 813 595 811 848 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2973 r0 *1 147.2,62.56
X$2973 77 855 812 854 595 517 814 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2978 r0 *1 151.8,62.56
X$2978 94 647 94 77 814 77 sky130_fd_sc_hd__inv_1
* cell instance $2980 r0 *1 153.64,62.56
X$2980 94 718 94 77 848 77 sky130_fd_sc_hd__inv_1
* cell instance $2981 r0 *1 155.02,62.56
X$2981 94 684 681 849 647 94 77 850 77 sky130_fd_sc_hd__o31ai_1
* cell instance $2982 r0 *1 157.78,62.56
X$2982 94 647 684 690 849 815 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2983 r0 *1 160.54,62.56
X$2983 94 718 642 690 771 818 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $2984 m0 *1 1.38,68
X$2984 94 797 77 705 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2985 m0 *1 3.22,68
X$2985 94 906 905 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2986 m0 *1 4.6,68
X$2986 94 885 77 798 94 77 sky130_fd_sc_hd__buf_2
* cell instance $2987 m0 *1 15.64,68
X$2987 77 181 549 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $2988 m0 *1 24.84,68
X$2988 94 833 879 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $2989 m0 *1 26.22,68
X$2989 94 798 94 77 799 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2994 m0 *1 33.58,68
X$2994 77 822 221 865 463 864 752 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2995 m0 *1 37.26,68
X$2995 94 798 94 77 886 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $2996 m0 *1 39.1,68
X$2996 94 752 887 755 77 94 756 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2997 m0 *1 40.94,68
X$2997 77 914 302 866 802 853 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $2998 m0 *1 44.62,68
X$2998 94 752 916 755 77 94 867 77 sky130_fd_sc_hd__a21oi_1
* cell instance $2999 m0 *1 46.46,68
X$2999 94 754 833 801 888 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3000 m0 *1 49.22,68
X$3000 77 856 276 884 802 867 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3002 m0 *1 53.82,68
X$3002 94 755 917 801 882 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3006 m0 *1 59.8,68
X$3006 94 463 77 922 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3008 m0 *1 63.48,68
X$3008 94 654 868 889 883 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3011 m0 *1 71.76,68
X$3011 94 833 804 869 881 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3013 m0 *1 74.98,68
X$3013 94 833 104 891 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3014 m0 *1 76.36,68
X$3014 94 576 869 891 106 94 77 870 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3015 m0 *1 79.12,68
X$3015 94 106 804 782 891 923 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3019 m0 *1 84.64,68
X$3019 77 181 544 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3020 m0 *1 93.84,68
X$3020 77 807 464 924 808 925 843 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $3021 m0 *1 97.98,68
X$3021 94 698 201 509 828 94 944 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3023 m0 *1 103.04,68
X$3023 94 828 509 698 871 94 961 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3027 m0 *1 112.24,68
X$3027 77 872 845 920 809 729 862 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3028 m0 *1 115.92,68
X$3028 94 874 862 896 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $3029 m0 *1 119.14,68
X$3029 94 846 94 77 918 77 sky130_fd_sc_hd__inv_1
* cell instance $3030 m0 *1 120.52,68
X$3030 77 873 639 828 698 94 874 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $3031 m0 *1 128.34,68
X$3031 77 77 698 875 509 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $3033 m0 *1 131.56,68
X$3033 94 861 873 880 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3034 m0 *1 132.94,68
X$3034 94 846 875 728 880 823 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3038 m0 *1 140.76,68
X$3038 94 899 846 861 765 77 94 898 77 sky130_fd_sc_hd__and4_1
* cell instance $3043 m0 *1 150.88,68
X$3043 94 690 77 681 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3044 m0 *1 152.72,68
X$3044 94 545 94 77 876 77 sky130_fd_sc_hd__inv_1
* cell instance $3045 m0 *1 154.1,68
X$3045 94 545 733 718 849 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3046 m0 *1 155.94,68
X$3046 94 876 684 681 733 94 77 911 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3047 m0 *1 158.7,68
X$3047 94 733 94 77 910 77 sky130_fd_sc_hd__inv_1
* cell instance $3049 m0 *1 161,68
X$3049 94 545 642 681 908 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3050 m0 *1 163.3,68
X$3050 94 558 850 815 77 94 851 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3051 m0 *1 165.14,68
X$3051 94 861 904 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3054 m0 *1 167.44,68
X$3054 94 899 903 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3055 m0 *1 168.82,68
X$3055 94 846 877 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3058 r0 *1 10.58,68
X$3058 94 868 927 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3065 r0 *1 19.32,68
X$3065 94 798 907 754 77 94 751 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3066 r0 *1 21.16,68
X$3066 94 799 929 838 77 94 859 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3067 r0 *1 23,68
X$3067 94 799 909 838 77 94 689 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3068 r0 *1 24.84,68
X$3068 94 799 912 838 77 94 785 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3069 r0 *1 26.68,68
X$3069 94 799 931 838 77 94 691 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3070 r0 *1 28.52,68
X$3070 94 798 913 754 77 94 864 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3071 r0 *1 30.36,68
X$3071 94 705 94 77 838 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3072 r0 *1 32.2,68
X$3072 94 798 77 752 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3073 r0 *1 34.04,68
X$3073 77 620 94 94 77 sky130_fd_sc_hd__inv_8
* cell instance $3074 r0 *1 38.18,68
X$3074 94 705 94 77 755 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3075 r0 *1 40.02,68
X$3075 94 886 906 956 77 94 937 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3079 r0 *1 43.24,68
X$3079 94 752 915 755 77 94 840 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3081 r0 *1 46,68
X$3081 77 888 275 890 802 933 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3083 r0 *1 50.14,68
X$3083 94 758 935 755 77 94 841 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3084 r0 *1 51.98,68
X$3084 94 798 77 758 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3085 r0 *1 53.82,68
X$3085 94 798 77 940 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3087 r0 *1 56.12,68
X$3087 94 754 106 801 993 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3097 r0 *1 79.12,68
X$3097 94 833 104 106 963 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3099 r0 *1 81.42,68
X$3099 94 942 870 923 77 94 962 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3100 r0 *1 83.26,68
X$3100 94 543 94 77 852 77 sky130_fd_sc_hd__buf_4
* cell instance $3103 r0 *1 90.16,68
X$3103 77 865 464 926 808 892 893 94 94 77 sky130_fd_sc_hd__a221o_2
* cell instance $3104 r0 *1 94.3,68
X$3104 94 944 893 965 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $3112 r0 *1 102.58,68
X$3112 77 866 845 895 809 535 894 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3113 r0 *1 106.26,68
X$3113 94 921 94 77 894 77 sky130_fd_sc_hd__inv_1
* cell instance $3116 r0 *1 111.78,68
X$3116 77 884 845 919 809 529 945 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3120 r0 *1 126.04,68
X$3120 94 861 846 897 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3121 r0 *1 127.42,68
X$3121 94 874 897 899 94 989 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3123 r0 *1 139.84,68
X$3123 77 957 769 873 898 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $3125 r0 *1 144.44,68
X$3125 77 900 769 898 873 94 690 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $3129 r0 *1 153.64,68
X$3129 94 954 953 642 952 94 77 951 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3130 r0 *1 156.4,68
X$3130 94 876 733 684 690 901 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3131 r0 *1 159.16,68
X$3131 94 558 911 901 77 94 949 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3132 r0 *1 161,68
X$3132 94 642 681 545 94 902 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3133 r0 *1 162.84,68
X$3133 94 558 902 908 77 94 983 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3137 r0 *1 167.9,68
X$3137 94 921 947 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3155 m0 *1 2.76,73.44
X$3155 94 968 966 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3156 m0 *1 4.14,73.44
X$3156 94 928 967 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3161 m0 *1 23.46,73.44
X$3161 94 799 1086 838 77 94 803 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3162 m0 *1 25.3,73.44
X$3162 94 799 930 838 77 94 707 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3163 m0 *1 27.14,73.44
X$3163 94 799 971 838 77 94 711 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3167 m0 *1 32.2,73.44
X$3167 94 886 928 838 77 94 932 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3168 m0 *1 34.04,73.44
X$3168 77 181 620 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3170 m0 *1 43.7,73.44
X$3170 94 752 990 956 77 94 934 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3171 m0 *1 45.54,73.44
X$3171 94 752 991 755 77 94 933 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3172 m0 *1 47.38,73.44
X$3172 94 755 938 801 992 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3173 m0 *1 50.14,73.44
X$3173 94 758 972 755 77 94 936 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3175 m0 *1 52.9,73.44
X$3175 77 992 454 941 802 936 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3177 m0 *1 57.04,73.44
X$3177 77 993 278 939 802 934 758 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3179 m0 *1 61.18,73.44
X$3179 94 106 833 104 938 94 1183 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3183 m0 *1 69.92,73.44
X$3183 94 782 77 869 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3184 m0 *1 72.68,73.44
X$3184 77 999 431 964 922 932 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3185 m0 *1 76.36,73.44
X$3185 77 1000 435 955 922 937 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3186 m0 *1 80.04,73.44
X$3186 94 938 106 104 833 77 94 1004 77 sky130_fd_sc_hd__and4_1
* cell instance $3189 m0 *1 84.64,73.44
X$3189 94 938 761 963 943 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3190 m0 *1 86.94,73.44
X$3190 94 558 1005 943 77 94 978 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3193 m0 *1 90.16,73.44
X$3193 94 556 965 1006 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3196 m0 *1 103.5,73.44
X$3196 94 961 894 1003 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $3199 m0 *1 108.1,73.44
X$3199 94 216 94 77 1001 77 sky130_fd_sc_hd__inv_1
* cell instance $3203 m0 *1 112.24,73.44
X$3203 77 939 845 997 809 528 998 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3204 m0 *1 115.92,73.44
X$3204 77 890 845 960 809 527 918 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3205 m0 *1 119.6,73.44
X$3205 94 994 94 77 996 77 sky130_fd_sc_hd__inv_1
* cell instance $3206 m0 *1 120.98,73.44
X$3206 94 556 896 959 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3207 m0 *1 122.36,73.44
X$3207 94 899 94 77 945 77 sky130_fd_sc_hd__inv_1
* cell instance $3208 m0 *1 123.74,73.44
X$3208 77 846 980 861 899 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $3211 m0 *1 127.42,73.44
X$3211 94 899 874 897 946 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3212 m0 *1 129.72,73.44
X$3212 94 942 989 946 77 94 958 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3218 m0 *1 141.68,73.44
X$3218 77 898 873 769 981 94 953 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $3219 m0 *1 146.28,73.44
X$3219 77 847 2214 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $3220 m0 *1 151.34,73.44
X$3220 77 955 812 987 988 514 876 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3221 m0 *1 155.02,73.44
X$3221 94 942 951 986 77 94 950 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3225 m0 *1 169.28,73.44
X$3225 94 981 982 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3227 m0 *1 171.12,73.44
X$3227 94 1024 1025 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3228 r0 *1 1.38,73.44
X$3228 94 971 1007 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3229 r0 *1 2.76,73.44
X$3229 94 969 1044 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3231 r0 *1 4.6,73.44
X$3231 94 969 968 906 970 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3232 r0 *1 6.44,73.44
X$3232 94 1009 1028 970 928 94 77 1029 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3235 r0 *1 11.5,73.44
X$3235 94 938 1008 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3237 r0 *1 13.8,73.44
X$3237 94 969 94 77 1012 77 sky130_fd_sc_hd__inv_1
* cell instance $3250 r0 *1 43.24,73.44
X$3250 94 705 94 77 956 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3253 r0 *1 49.22,73.44
X$3253 94 705 94 77 973 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3254 r0 *1 51.06,73.44
X$3254 94 973 562 889 1039 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3257 r0 *1 55.2,73.44
X$3257 94 973 974 801 1041 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3258 r0 *1 57.96,73.44
X$3258 77 1096 306 995 922 975 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3267 r0 *1 70.84,73.44
X$3267 94 973 976 889 999 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3268 r0 *1 73.6,73.44
X$3268 94 973 977 889 1000 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3271 r0 *1 80.96,73.44
X$3271 94 543 77 942 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3273 r0 *1 95.22,73.44
X$3273 94 556 1019 1070 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3281 r0 *1 98.9,73.44
X$3281 94 795 201 1019 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $3282 r0 *1 102.12,73.44
X$3282 94 556 1003 1002 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3283 r0 *1 112.7,73.44
X$3283 77 809 1208 525 941 996 845 94 94 77 sky130_fd_sc_hd__a221oi_2
* cell instance $3285 r0 *1 118.68,73.44
X$3285 77 995 845 1209 988 1040 979 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3286 r0 *1 122.36,73.44
X$3286 94 1038 94 77 979 77 sky130_fd_sc_hd__inv_1
* cell instance $3294 r0 *1 127.42,73.44
X$3294 94 721 980 768 1021 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3296 r0 *1 130.18,73.44
X$3296 94 874 1021 981 94 1036 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3299 r0 *1 143.98,73.44
X$3299 77 258 847 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3304 r0 *1 153.64,73.44
X$3304 94 954 952 953 642 986 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3305 r0 *1 156.4,73.44
X$3305 94 1023 94 77 954 77 sky130_fd_sc_hd__inv_1
* cell instance $3306 r0 *1 157.78,73.44
X$3306 94 684 953 1088 1024 94 77 984 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3307 r0 *1 160.54,73.44
X$3307 94 558 984 1087 77 94 1027 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3309 m0 *1 1.38,78.88
X$3309 94 878 1045 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3311 m0 *1 3.68,78.88
X$3311 94 928 906 968 969 77 94 1026 77 sky130_fd_sc_hd__and4_1
* cell instance $3312 m0 *1 6.9,78.88
X$3312 94 928 1010 1028 970 1046 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3313 m0 *1 9.66,78.88
X$3313 94 1011 1029 1046 77 94 985 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3317 m0 *1 14.72,78.88
X$3317 94 1012 968 1010 1028 1013 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3318 m0 *1 17.48,78.88
X$3318 94 1012 1009 1028 968 94 77 1047 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3319 m0 *1 20.24,78.88
X$3319 94 1011 1047 1013 77 94 1030 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3321 m0 *1 23.92,78.88
X$3321 94 1009 1032 1056 906 94 77 1057 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3322 m0 *1 26.68,78.88
X$3322 94 969 968 1056 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3325 m0 *1 29.44,78.88
X$3325 94 1011 1057 1089 77 94 1035 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3327 m0 *1 33.12,78.88
X$3327 94 1079 780 1034 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3330 m0 *1 39.1,78.88
X$3330 94 886 1060 956 77 94 1014 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3331 m0 *1 40.94,78.88
X$3331 94 886 968 956 77 94 1037 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3332 m0 *1 42.78,78.88
X$3332 94 886 969 956 77 94 1015 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3333 m0 *1 44.62,78.88
X$3333 94 886 1062 956 77 94 1049 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3337 m0 *1 51.52,78.88
X$3337 77 1039 574 1076 922 1048 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3342 m0 *1 57.5,78.88
X$3342 77 1041 211 1042 922 1050 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3343 m0 *1 61.18,78.88
X$3343 77 1065 428 1043 922 1014 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3344 m0 *1 64.86,78.88
X$3344 77 1119 328 1016 922 1066 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3347 m0 *1 69.92,78.88
X$3347 77 1068 329 1017 922 1049 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3348 m0 *1 73.6,78.88
X$3348 77 1100 291 1018 922 1015 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3349 m0 *1 77.28,78.88
X$3349 77 1117 436 1058 922 1037 940 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3350 m0 *1 80.96,78.88
X$3350 94 1004 77 1069 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3355 m0 *1 85.56,78.88
X$3355 94 761 963 938 94 1005 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3361 m0 *1 105.8,78.88
X$3361 77 1076 812 1067 988 532 1001 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3362 m0 *1 109.48,78.88
X$3362 94 808 77 988 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3365 m0 *1 112.24,78.88
X$3365 77 730 94 94 77 sky130_fd_sc_hd__bufinv_16
* cell instance $3366 m0 *1 123.28,78.88
X$3366 77 1017 812 1871 988 524 1020 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3367 m0 *1 126.96,78.88
X$3367 94 980 94 77 1064 77 sky130_fd_sc_hd__inv_1
* cell instance $3368 m0 *1 128.34,78.88
X$3368 94 721 94 77 1063 77 sky130_fd_sc_hd__inv_1
* cell instance $3370 m0 *1 130.18,78.88
X$3370 94 981 874 1021 1022 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3371 m0 *1 132.48,78.88
X$3371 94 942 1036 1022 77 94 1033 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3372 m0 *1 134.32,78.88
X$3372 94 981 94 77 1020 77 sky130_fd_sc_hd__inv_1
* cell instance $3375 m0 *1 139.84,78.88
X$3375 77 1043 812 1059 988 1061 954 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3377 m0 *1 143.98,78.88
X$3377 77 1018 812 1652 988 518 1052 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3378 m0 *1 147.66,78.88
X$3378 77 964 812 1031 988 515 910 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3379 m0 *1 151.34,78.88
X$3379 94 1024 952 1023 981 77 94 900 77 sky130_fd_sc_hd__and4_1
* cell instance $3380 m0 *1 154.56,78.88
X$3380 94 1023 684 953 1055 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3383 m0 *1 167.44,78.88
X$3383 94 1023 1054 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3384 m0 *1 168.82,78.88
X$3384 94 952 1053 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3386 m0 *1 171.12,78.88
X$3386 94 1038 1083 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3387 r0 *1 1.38,78.88
X$3387 94 912 1104 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3388 r0 *1 2.76,78.88
X$3388 94 935 1071 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3390 r0 *1 5.06,78.88
X$3390 94 1026 94 77 1072 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3391 r0 *1 6.9,78.88
X$3391 94 1009 1028 1085 878 94 77 1084 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3392 r0 *1 9.66,78.88
X$3392 94 1011 1084 1113 77 94 1073 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3393 r0 *1 11.5,78.88
X$3393 94 935 1086 929 1072 94 1085 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3400 r0 *1 26.22,78.88
X$3400 94 906 1010 1032 1056 1089 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3402 r0 *1 39.1,78.88
X$3402 94 886 1075 956 77 94 1048 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3403 r0 *1 40.94,78.88
X$3403 94 886 1116 956 77 94 1050 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3406 r0 *1 43.24,78.88
X$3406 94 886 1092 956 77 94 975 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3407 r0 *1 45.08,78.88
X$3407 94 886 1094 956 77 94 1066 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3411 r0 *1 53.36,78.88
X$3411 94 601 805 1120 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3415 r0 *1 57.96,78.88
X$3415 94 973 1077 801 1096 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3418 r0 *1 66.24,78.88
X$3418 94 1098 1199 1118 77 94 1097 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3425 r0 *1 73.14,78.88
X$3425 94 973 1078 889 1100 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3428 r0 *1 89.24,78.88
X$3428 94 487 94 77 1079 77 sky130_fd_sc_hd__buf_4
* cell instance $3439 r0 *1 110.86,78.88
X$3439 77 258 730 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3441 r0 *1 120.52,78.88
X$3441 77 1042 845 1103 988 810 1080 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3443 r0 *1 124.2,78.88
X$3443 94 1051 94 77 998 77 sky130_fd_sc_hd__inv_1
* cell instance $3446 r0 *1 126.5,78.88
X$3446 77 1016 812 1102 988 522 1063 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3447 r0 *1 130.18,78.88
X$3447 94 1051 994 1101 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3449 r0 *1 132.48,78.88
X$3449 94 875 957 1081 721 94 77 1099 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3451 r0 *1 135.7,78.88
X$3451 94 721 875 957 1081 1138 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3452 r0 *1 138.46,78.88
X$3452 94 875 957 1051 94 1095 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3456 r0 *1 145.36,78.88
X$3456 77 1058 812 1093 988 516 1082 94 94 77 sky130_fd_sc_hd__a221o_1
* cell instance $3457 r0 *1 149.04,78.88
X$3457 94 1024 94 77 1082 77 sky130_fd_sc_hd__inv_1
* cell instance $3459 r0 *1 150.42,78.88
X$3459 94 952 94 77 1052 77 sky130_fd_sc_hd__inv_1
* cell instance $3464 r0 *1 154.1,78.88
X$3464 94 942 1090 1055 77 94 1091 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3465 r0 *1 155.94,78.88
X$3465 94 684 953 1023 94 1090 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3466 r0 *1 157.78,78.88
X$3466 94 1023 952 1088 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3467 r0 *1 159.16,78.88
X$3467 94 1024 684 953 1088 1087 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3484 m0 *1 2.76,84.32
X$3484 94 805 1122 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3486 m0 *1 4.6,84.32
X$3486 94 359 837 1133 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3488 m0 *1 6.44,84.32
X$3488 77 935 1163 929 878 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $3490 m0 *1 9.66,84.32
X$3490 94 878 1105 1028 1085 1113 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3491 m0 *1 12.42,84.32
X$3491 94 935 878 1135 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $3492 m0 *1 14.72,84.32
X$3492 94 1072 1086 929 1135 94 1114 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3493 m0 *1 17.02,84.32
X$3493 94 1009 1032 1114 971 94 77 1136 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3498 m0 *1 26.68,84.32
X$3498 94 969 1010 1032 1166 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3505 m0 *1 42.78,84.32
X$3505 94 781 77 1142 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3507 m0 *1 46.46,84.32
X$3507 94 601 708 1143 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3510 m0 *1 49.22,84.32
X$3510 94 806 777 917 710 94 1125 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3512 m0 *1 52.44,84.32
X$3512 77 1126 1120 1144 1106 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3515 m0 *1 60.72,84.32
X$3515 94 973 1107 889 1065 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3516 m0 *1 63.48,84.32
X$3516 94 777 804 782 1145 1118 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3517 m0 *1 66.24,84.32
X$3517 94 973 1108 889 1119 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3519 m0 *1 69.46,84.32
X$3519 94 973 1184 889 1068 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3522 m0 *1 74.98,84.32
X$3522 94 973 1124 889 1117 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $3524 m0 *1 79.58,84.32
X$3524 94 576 869 1127 976 94 77 1149 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3527 m0 *1 84.64,84.32
X$3527 94 976 94 77 1109 77 sky130_fd_sc_hd__inv_1
* cell instance $3528 m0 *1 86.02,84.32
X$3528 94 1098 1147 1146 77 94 1110 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3536 m0 *1 112.7,84.32
X$3536 94 1137 77 808 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3538 m0 *1 115.92,84.32
X$3538 77 1157 258 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3540 m0 *1 125.58,84.32
X$3540 94 1038 1129 994 1051 77 94 768 77 sky130_fd_sc_hd__and4_1
* cell instance $3541 m0 *1 128.8,84.32
X$3541 94 874 1064 1115 1038 94 77 1141 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3543 m0 *1 132.02,84.32
X$3543 94 875 957 1101 1129 94 77 1140 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3544 m0 *1 134.78,84.32
X$3544 94 942 1140 1165 77 94 1168 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3545 m0 *1 136.62,84.32
X$3545 94 942 1099 1138 77 94 1111 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3549 m0 *1 163.3,84.32
X$3549 94 994 1112 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3551 m0 *1 165.14,84.32
X$3551 94 977 1132 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3555 m0 *1 171.12,84.32
X$3555 94 1051 1131 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3556 r0 *1 1.38,84.32
X$3556 94 837 1150 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3558 r0 *1 3.22,84.32
X$3558 77 948 1133 1161 1152 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3559 r0 *1 7.36,84.32
X$3559 94 1072 1086 971 1163 94 1180 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3560 r0 *1 9.66,84.32
X$3560 94 1124 1121 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3565 r0 *1 15.64,84.32
X$3565 94 971 1105 1032 1114 1123 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3567 r0 *1 18.86,84.32
X$3567 94 1011 1136 1123 77 94 1074 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3570 r0 *1 25.3,84.32
X$3570 94 1009 1032 969 94 1139 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3571 r0 *1 27.14,84.32
X$3571 94 1011 1139 1166 77 94 1167 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3577 r0 *1 45.08,84.32
X$3577 77 1169 1143 1170 1153 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3578 r0 *1 49.22,84.32
X$3578 94 1125 1142 1171 1145 77 1153 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $3579 r0 *1 61.18,84.32
X$3579 77 1157 181 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3583 r0 *1 71.3,84.32
X$3583 94 976 868 1203 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $3584 r0 *1 73.6,84.32
X$3584 94 977 1124 1078 1107 77 94 1155 77 sky130_fd_sc_hd__and4_1
* cell instance $3587 r0 *1 78.2,84.32
X$3587 94 976 804 782 1127 1174 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3588 r0 *1 80.96,84.32
X$3588 94 1098 1149 1174 77 94 1173 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3590 r0 *1 83.26,84.32
X$3590 94 1109 761 1127 868 94 77 1147 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3591 r0 *1 86.02,84.32
X$3591 94 1109 868 1142 1127 1146 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3592 r0 *1 88.78,84.32
X$3592 77 1148 1157 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3595 r0 *1 98.44,84.32
X$3595 94 1207 977 1175 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $3600 r0 *1 118.22,84.32
X$3600 94 258 94 77 77 sky130_fd_sc_hd__inv_6
* cell instance $3601 r0 *1 121.44,84.32
X$3601 94 998 994 874 1064 1172 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3603 r0 *1 124.2,84.32
X$3603 94 1129 94 77 1080 77 sky130_fd_sc_hd__inv_1
* cell instance $3605 r0 *1 126.04,84.32
X$3605 94 1038 874 1064 1115 1225 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3607 r0 *1 129.72,84.32
X$3607 94 1129 1051 994 1038 94 1081 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3608 r0 *1 132.02,84.32
X$3608 94 1051 994 1129 1115 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3609 r0 *1 133.86,84.32
X$3609 94 1129 875 957 1101 1165 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3611 r0 *1 137.08,84.32
X$3611 94 1051 875 957 1130 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3612 r0 *1 139.38,84.32
X$3612 94 942 1095 1130 77 94 1158 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3619 r0 *1 161,84.32
X$3619 94 1129 1160 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3633 m0 *1 1.38,89.76
X$3633 94 929 1151 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3634 m0 *1 2.76,89.76
X$3634 94 1206 837 1161 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $3636 m0 *1 5.52,89.76
X$3636 94 976 1179 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3638 m0 *1 7.36,89.76
X$3638 94 1010 1028 1180 912 94 77 1195 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3640 m0 *1 10.58,89.76
X$3640 94 1180 1010 1164 1032 77 1152 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $3641 m0 *1 12.88,89.76
X$3641 94 912 94 77 1164 77 sky130_fd_sc_hd__inv_1
* cell instance $3652 m0 *1 51.52,89.76
X$3652 94 805 94 77 1171 77 sky130_fd_sc_hd__inv_1
* cell instance $3653 m0 *1 52.9,89.76
X$3653 94 601 1171 1144 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3654 m0 *1 54.28,89.76
X$3654 94 1125 782 804 1145 77 1106 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $3659 m0 *1 73.14,89.76
X$3659 77 1203 1069 1155 1185 94 1145 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $3660 m0 *1 80.96,89.76
X$3660 94 1124 804 782 1186 1202 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3664 m0 *1 86.48,89.76
X$3664 94 1176 1142 1186 1156 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $3665 m0 *1 88.32,89.76
X$3665 94 1124 94 77 1176 77 sky130_fd_sc_hd__inv_1
* cell instance $3666 m0 *1 89.7,89.76
X$3666 94 601 977 1177 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3667 m0 *1 91.08,89.76
X$3667 77 1189 1177 1175 1156 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3670 m0 *1 106.26,89.76
X$3670 94 380 77 1098 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3677 m0 *1 115.46,89.76
X$3677 94 998 874 1064 994 94 77 1198 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3686 m0 *1 160.08,89.76
X$3686 94 1192 1193 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3694 r0 *1 11.04,89.76
X$3694 94 912 1105 1028 1180 1220 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3699 r0 *1 15.64,89.76
X$3699 94 1009 1032 1229 935 94 77 1196 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3700 r0 *1 18.4,89.76
X$3700 94 1011 1196 1224 77 94 1223 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3703 r0 *1 27.6,89.76
X$3703 77 1206 359 94 94 77 sky130_fd_sc_hd__buf_6
* cell instance $3706 r0 *1 37.26,89.76
X$3706 94 1206 94 77 380 77 sky130_fd_sc_hd__buf_4
* cell instance $3707 r0 *1 40.02,89.76
X$3707 94 1206 94 77 601 77 sky130_fd_sc_hd__buf_4
* cell instance $3712 r0 *1 46,89.76
X$3712 94 1207 708 1170 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $3715 r0 *1 60.26,89.76
X$3715 94 974 804 782 1183 1227 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3718 r0 *1 65.78,89.76
X$3718 94 576 869 1145 777 94 77 1199 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3722 r0 *1 70.84,89.76
X$3722 94 1184 1108 1077 974 77 94 1185 77 sky130_fd_sc_hd__and4_1
* cell instance $3725 r0 *1 76.36,89.76
X$3725 94 1069 1185 1155 1127 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3727 r0 *1 78.66,89.76
X$3727 94 1069 1107 1078 1185 94 1186 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3728 r0 *1 80.96,89.76
X$3728 94 1107 1069 1185 1187 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3730 r0 *1 83.26,89.76
X$3730 94 576 869 1186 1124 94 77 1201 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3731 r0 *1 86.02,89.76
X$3731 94 1188 1201 1202 77 94 1253 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3732 r0 *1 87.86,89.76
X$3732 94 1078 1142 1187 1200 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3733 r0 *1 90.16,89.76
X$3733 94 1188 1252 1200 77 94 1226 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3741 r0 *1 103.96,89.76
X$3741 94 808 77 809 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3746 r0 *1 116.38,89.76
X$3746 94 942 1198 1172 77 94 1128 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3749 r0 *1 120.98,89.76
X$3749 94 942 1141 1225 77 94 1197 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3758 r0 *1 148.58,89.76
X$3758 94 1244 77 1212 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3761 r0 *1 151.34,89.76
X$3761 94 1098 1221 1246 77 94 1190 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3764 r0 *1 155.48,89.76
X$3764 94 1210 1162 1191 1240 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3766 r0 *1 158.24,89.76
X$3766 94 1098 1219 1245 77 94 1213 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3768 r0 *1 161.92,89.76
X$3768 94 1210 1191 1218 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3781 m0 *1 1.38,95.2
X$3781 94 1178 94 77 1206 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $3782 m0 *1 3.22,95.2
X$3782 94 1094 1256 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3784 m0 *1 6.44,95.2
X$3784 94 1062 1204 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3787 m0 *1 10.12,95.2
X$3787 94 1011 1195 1220 77 94 1217 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3788 m0 *1 11.96,95.2
X$3788 94 1105 77 1010 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3789 m0 *1 13.8,95.2
X$3789 94 1107 1205 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3791 m0 *1 15.64,95.2
X$3791 94 1086 929 1072 1229 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3792 m0 *1 17.48,95.2
X$3792 94 935 1105 1032 1229 1224 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3796 m0 *1 23.46,95.2
X$3796 94 1010 77 1009 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3798 m0 *1 25.76,95.2
X$3798 94 1296 1009 1230 1060 94 77 1269 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3802 m0 *1 39.56,95.2
X$3802 77 1206 1207 94 94 77 sky130_fd_sc_hd__buf_6
* cell instance $3805 m0 *1 45.08,95.2
X$3805 94 777 917 806 1232 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3806 m0 *1 46.92,95.2
X$3806 94 710 1142 1145 1232 1233 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3807 m0 *1 49.68,95.2
X$3807 94 1258 1273 1233 77 94 1182 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3808 m0 *1 51.52,95.2
X$3808 94 761 1145 1232 710 94 77 1273 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3813 m0 *1 60.72,95.2
X$3813 94 576 869 1183 974 94 77 1281 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3816 m0 *1 67.62,95.2
X$3816 94 974 1069 1276 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3818 m0 *1 69.46,95.2
X$3818 94 974 1077 1069 1261 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3819 m0 *1 71.3,95.2
X$3819 94 576 869 1261 1108 94 77 1278 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3821 m0 *1 77.74,95.2
X$3821 94 1069 1185 1255 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3822 m0 *1 79.12,95.2
X$3822 94 576 869 1255 1107 94 77 1336 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3824 m0 *1 82.34,95.2
X$3824 94 761 1187 1078 94 1252 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $3830 m0 *1 106.72,95.2
X$3830 94 380 77 1188 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $3834 m0 *1 122.82,95.2
X$3834 94 1235 1271 1249 77 94 1250 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3842 m0 *1 141.22,95.2
X$3842 77 1222 1248 1268 1247 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3845 m0 *1 146.74,95.2
X$3845 94 1236 1237 1191 1247 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $3846 m0 *1 149.5,95.2
X$3846 94 1237 1239 1238 1192 94 77 1221 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3847 m0 *1 152.26,95.2
X$3847 94 1192 1211 1236 1238 1246 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3848 m0 *1 155.02,95.2
X$3848 94 1237 1239 1240 1216 94 77 1219 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3849 m0 *1 157.78,95.2
X$3849 94 1216 1211 1236 1240 1245 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3851 m0 *1 161.46,95.2
X$3851 94 1212 1239 1218 1162 94 77 1243 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3852 m0 *1 164.22,95.2
X$3852 94 1162 1244 1236 1218 1241 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3854 m0 *1 167.44,95.2
X$3854 94 1098 1243 1241 77 94 1134 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3856 m0 *1 171.12,95.2
X$3856 94 1078 1194 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3857 r0 *1 1.38,95.2
X$3857 94 1060 1265 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3858 r0 *1 2.76,95.2
X$3858 94 974 1279 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3859 r0 *1 4.14,95.2
X$3859 94 1266 1228 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3861 r0 *1 5.98,95.2
X$3861 94 1266 77 1086 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3863 r0 *1 8.28,95.2
X$3863 94 1032 1010 1072 1292 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $3864 r0 *1 11.04,95.2
X$3864 94 1086 1072 1280 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3865 r0 *1 12.42,95.2
X$3865 94 1009 1028 1280 929 94 77 1295 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3872 r0 *1 20.24,95.2
X$3872 94 1092 94 77 1257 77 sky130_fd_sc_hd__inv_1
* cell instance $3873 r0 *1 21.62,95.2
X$3873 94 1257 1094 1296 1010 1270 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3874 r0 *1 24.38,95.2
X$3874 77 181 1181 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3875 r0 *1 33.58,95.2
X$3875 94 1060 1296 1010 1230 1314 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3876 r0 *1 36.34,95.2
X$3876 94 380 77 1011 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3878 r0 *1 38.64,95.2
X$3878 94 380 77 1258 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3888 r0 *1 49.22,95.2
X$3888 94 777 94 77 1259 77 sky130_fd_sc_hd__inv_1
* cell instance $3889 r0 *1 50.6,95.2
X$3889 94 1259 761 1145 917 94 77 1381 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3892 r0 *1 56.12,95.2
X$3892 94 777 917 1260 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3893 r0 *1 57.5,95.2
X$3893 94 1260 869 804 1145 77 1384 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $3898 r0 *1 70.84,95.2
X$3898 94 1108 804 782 1261 1305 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3901 r0 *1 78.2,95.2
X$3901 94 1107 804 782 1255 1277 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3903 r0 *1 95.22,95.2
X$3903 94 380 94 77 1275 77 sky130_fd_sc_hd__buf_4
* cell instance $3911 r0 *1 104.88,95.2
X$3911 94 852 1359 1309 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3915 r0 *1 120.06,95.2
X$3915 94 1274 1285 1272 1263 94 77 1271 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3920 r0 *1 123.28,95.2
X$3920 77 1234 1331 1262 1263 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $3922 r0 *1 135.7,95.2
X$3922 94 1211 77 1237 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3924 r0 *1 138,95.2
X$3924 94 380 77 1235 94 77 sky130_fd_sc_hd__buf_2
* cell instance $3925 r0 *1 139.84,95.2
X$3925 94 601 1210 1248 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3926 r0 *1 141.22,95.2
X$3926 94 1207 1210 1268 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $3927 r0 *1 143.52,95.2
X$3927 77 258 1159 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $3934 r0 *1 154.1,95.2
X$3934 94 1267 1216 1162 1210 77 94 1298 77 sky130_fd_sc_hd__and4_1
* cell instance $3936 r0 *1 157.78,95.2
X$3936 94 1216 1210 1162 1191 94 1287 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $3937 r0 *1 160.08,95.2
X$3937 94 1212 1239 1287 1267 94 77 1325 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3940 m0 *1 5.06,100.64
X$3940 94 359 1086 1291 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $3942 m0 *1 6.9,100.64
X$3942 77 1312 1291 1313 1292 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $3944 m0 *1 21.16,100.64
X$3944 94 1257 1296 1009 1094 94 77 1297 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3945 m0 *1 23.92,100.64
X$3945 77 1181 2217 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $3947 m0 *1 29.44,100.64
X$3947 94 1092 1094 1062 1230 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $3948 m0 *1 31.28,100.64
X$3948 94 1011 1269 1314 77 94 1231 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3949 m0 *1 33.12,100.64
X$3949 94 1258 1297 1270 77 94 1299 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3954 m0 *1 60.72,100.64
X$3954 94 1364 1281 1227 77 94 1304 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3955 m0 *1 73.14,100.64
X$3955 94 1334 1278 1305 77 94 1282 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3956 m0 *1 74.98,100.64
X$3956 94 1108 94 77 1317 77 sky130_fd_sc_hd__inv_1
* cell instance $3960 m0 *1 81.42,100.64
X$3960 94 1275 1336 1277 77 94 1307 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3970 m0 *1 114.54,100.64
X$3970 94 1234 1321 1272 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3971 m0 *1 115.92,100.64
X$3971 94 1188 1333 1283 77 94 1306 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3972 m0 *1 117.76,100.64
X$3972 94 1284 1274 1285 1234 94 77 1333 77 sky130_fd_sc_hd__o31ai_1
* cell instance $3973 m0 *1 120.52,100.64
X$3973 94 1263 1274 1285 1272 1249 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3975 m0 *1 123.74,100.64
X$3975 77 1331 1321 1340 94 1244 94 77 sky130_fd_sc_hd__nand3_4
* cell instance $3979 m0 *1 133.4,100.64
X$3979 94 1326 1303 1212 1301 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $3982 m0 *1 138,100.64
X$3982 94 1216 94 77 1328 77 sky130_fd_sc_hd__inv_1
* cell instance $3984 m0 *1 149.04,100.64
X$3984 94 1191 1298 1238 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $3986 m0 *1 160.54,100.64
X$3986 94 1267 1244 1236 1287 1288 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3987 m0 *1 163.3,100.64
X$3987 94 1098 1325 1288 77 94 1293 77 sky130_fd_sc_hd__a21oi_1
* cell instance $3989 m0 *1 165.6,100.64
X$3989 94 1210 1215 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3992 m0 *1 168.36,100.64
X$3992 94 1162 1214 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3993 m0 *1 169.74,100.64
X$3993 94 1216 1242 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3994 m0 *1 171.12,100.64
X$3994 94 1267 1290 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $3995 r0 *1 10.58,100.64
X$3995 94 929 1105 1028 1280 1348 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $3996 r0 *1 13.34,100.64
X$3996 94 1011 1295 1348 77 94 1347 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4000 r0 *1 16.1,100.64
X$4000 94 1108 1311 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4004 r0 *1 20.7,100.64
X$4004 94 1207 1086 1313 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $4006 r0 *1 33.12,100.64
X$4006 94 1315 1339 1316 1062 94 77 1327 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4007 r0 *1 35.88,100.64
X$4007 94 1062 1315 1339 1316 1352 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4008 r0 *1 38.64,100.64
X$4008 94 1092 1094 1316 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4014 r0 *1 44.16,100.64
X$4014 94 543 94 77 486 77 sky130_fd_sc_hd__buf_4
* cell instance $4015 r0 *1 46.92,100.64
X$4015 94 1259 917 1142 1145 1353 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4016 r0 *1 49.68,100.64
X$4016 77 1154 2218 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $4017 r0 *1 65.32,100.64
X$4017 94 761 1276 1077 94 1407 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4019 r0 *1 67.62,100.64
X$4019 94 1077 1142 1276 1354 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4025 r0 *1 72.22,100.64
X$4025 94 1317 761 1261 1184 94 77 1387 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4026 r0 *1 74.98,100.64
X$4026 94 1317 1184 1142 1261 1388 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4028 r0 *1 78.2,100.64
X$4028 94 1207 77 543 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4029 r0 *1 90.16,100.64
X$4029 77 1357 699 1319 1356 1318 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $4030 r0 *1 93.84,100.64
X$4030 94 1319 77 1321 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4038 r0 *1 104.42,100.64
X$4038 94 1360 1320 94 1359 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4041 r0 *1 109.02,100.64
X$4041 94 852 1358 1308 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4044 r0 *1 117.76,100.64
X$4044 77 1251 2221 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $4045 r0 *1 122.82,100.64
X$4045 94 1234 1284 1274 1285 1283 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4048 r0 *1 145.36,100.64
X$4048 77 1159 2220 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $4050 r0 *1 150.42,100.64
X$4050 94 1237 1239 1341 1322 94 77 1382 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4052 r0 *1 153.64,100.64
X$4052 94 1191 1192 1286 1298 94 1341 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4053 r0 *1 155.94,100.64
X$4053 94 1192 1191 1298 1369 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4054 r0 *1 157.78,100.64
X$4054 94 1322 1323 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4055 r0 *1 159.16,100.64
X$4055 94 1326 1343 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4056 r0 *1 160.54,100.64
X$4056 94 1234 1289 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4057 r0 *1 161.92,100.64
X$4057 94 1263 1264 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4071 m0 *1 3.22,106.08
X$4071 94 1077 1393 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4073 m0 *1 5.06,106.08
X$4073 94 1092 1310 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4076 m0 *1 7.82,106.08
X$4076 77 1094 1062 1373 1092 1060 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $4077 m0 *1 11.5,106.08
X$4077 94 1116 1337 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4078 m0 *1 12.88,106.08
X$4078 94 917 1338 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4080 m0 *1 16.1,106.08
X$4080 94 972 1116 1374 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $4082 m0 *1 18.86,106.08
X$4082 94 1362 1374 1339 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4084 m0 *1 22.08,106.08
X$4084 94 972 1362 1363 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4085 m0 *1 23.46,106.08
X$4085 94 1296 1375 1363 1116 94 77 1376 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4090 m0 *1 31.28,106.08
X$4090 94 1315 1339 1092 94 1377 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4091 m0 *1 33.12,106.08
X$4091 94 1258 1377 1349 77 94 1378 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4092 m0 *1 34.96,106.08
X$4092 94 1092 1315 1339 1349 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4093 m0 *1 37.26,106.08
X$4093 94 1258 1327 1352 77 94 1350 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4098 m0 *1 47.84,106.08
X$4098 94 543 77 1364 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4099 m0 *1 50.6,106.08
X$4099 94 1258 1381 1353 77 94 1302 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4101 m0 *1 52.9,106.08
X$4101 94 1142 77 761 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4102 m0 *1 54.74,106.08
X$4102 94 543 77 1383 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4104 m0 *1 57.04,106.08
X$4104 77 1332 1385 1438 1384 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $4105 m0 *1 61.18,106.08
X$4105 94 601 806 1385 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4106 m0 *1 73.14,106.08
X$4106 94 1334 1387 1388 77 94 1408 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4109 m0 *1 77.28,106.08
X$4109 94 543 77 1334 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4110 m0 *1 80.04,106.08
X$4110 77 1335 1356 1318 1207 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $4113 m0 *1 88.32,106.08
X$4113 77 1318 1356 1426 699 94 94 77 sky130_fd_sc_hd__nand3b_4
* cell instance $4115 m0 *1 107.18,106.08
X$4115 94 1410 1262 94 1358 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4121 m0 *1 117.76,106.08
X$4121 77 258 1251 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4122 m0 *1 126.96,106.08
X$4122 94 1340 1284 1303 1392 1366 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4123 m0 *1 129.72,106.08
X$4123 94 1235 1365 1366 77 94 1330 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4125 m0 *1 135.24,106.08
X$4125 94 1303 1212 1326 94 1389 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4126 m0 *1 137.08,106.08
X$4126 94 1235 1389 1301 77 94 1329 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4131 m0 *1 144.44,106.08
X$4131 94 1322 1211 1368 1341 1367 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4132 m0 *1 147.2,106.08
X$4132 94 1098 1382 1367 77 94 1300 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4133 m0 *1 149.04,106.08
X$4133 94 1236 77 1239 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4134 m0 *1 150.88,106.08
X$4134 94 1286 1244 1368 1369 1380 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4135 m0 *1 153.64,106.08
X$4135 94 1098 1379 1380 77 94 1351 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4136 m0 *1 155.48,106.08
X$4136 94 1212 1239 1369 1286 94 77 1379 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4137 m0 *1 158.24,106.08
X$4137 94 1397 94 77 1191 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4138 m0 *1 160.08,106.08
X$4138 94 1212 1239 1370 1345 94 77 1342 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4139 m0 *1 162.84,106.08
X$4139 94 1345 1244 1236 1370 1371 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4143 m0 *1 167.44,106.08
X$4143 94 1098 1342 1371 77 94 1346 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4149 r0 *1 3.68,106.08
X$4149 94 806 1361 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4156 r0 *1 16.56,106.08
X$4156 94 990 916 991 915 77 94 1362 77 sky130_fd_sc_hd__and4_1
* cell instance $4157 r0 *1 19.78,106.08
X$4157 94 1405 1416 1375 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4165 r0 *1 53.82,106.08
X$4165 77 181 1154 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4168 r0 *1 65.32,106.08
X$4168 94 1383 1407 1354 77 94 1386 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4179 r0 *1 85.56,106.08
X$4179 94 1254 2230 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4180 r0 *1 86.94,106.08
X$4180 77 181 1254 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4186 r0 *1 98.44,106.08
X$4186 94 852 1394 1390 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4188 r0 *1 100.74,106.08
X$4188 94 1412 1391 1394 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4189 r0 *1 103.96,106.08
X$4189 77 1422 1413 1423 1391 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4191 r0 *1 107.18,106.08
X$4191 94 1395 1411 1321 1409 94 1410 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4192 r0 *1 120.06,106.08
X$4192 94 1395 1465 1285 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4194 r0 *1 121.9,106.08
X$4194 94 1284 1303 1392 1340 94 77 1365 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4200 r0 *1 126.04,106.08
X$4200 94 1262 1234 1263 1392 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4203 r0 *1 135.24,106.08
X$4203 94 1326 94 77 1433 77 sky130_fd_sc_hd__inv_1
* cell instance $4216 r0 *1 156.86,106.08
X$4216 94 1237 1239 1396 1398 94 77 1399 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4217 r0 *1 159.62,106.08
X$4217 94 1398 1211 1236 1396 1404 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4221 m0 *1 4.14,111.52
X$4221 94 972 1414 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4222 m0 *1 5.52,111.52
X$4222 94 1506 907 94 1415 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4223 m0 *1 8.74,111.52
X$4223 94 486 1415 1431 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4226 m0 *1 12.88,111.52
X$4226 94 800 1443 1416 94 77 77 sky130_fd_sc_hd__and2_1
* cell instance $4227 m0 *1 15.18,111.52
X$4227 77 1374 1405 1362 1416 94 1105 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $4229 m0 *1 23.92,111.52
X$4229 94 1116 1296 1375 1363 1417 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4230 m0 *1 26.68,111.52
X$4230 94 1258 1376 1417 77 94 1406 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4236 m0 *1 35.88,111.52
X$4236 94 916 915 991 990 94 1418 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4237 m0 *1 38.18,111.52
X$4237 94 1315 1418 972 94 1419 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4238 m0 *1 40.02,111.52
X$4238 94 972 1315 1418 1420 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4239 m0 *1 42.32,111.52
X$4239 94 1258 1419 1420 77 94 1434 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4246 m0 *1 57.04,111.52
X$4246 94 1207 806 1438 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $4256 m0 *1 100.74,111.52
X$4256 94 1467 1437 1426 1468 77 1412 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $4257 m0 *1 103.04,111.52
X$4257 94 1423 1422 1467 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4258 m0 *1 104.42,111.52
X$4258 94 1321 1395 1413 1360 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4259 m0 *1 106.26,111.52
X$4259 94 1320 1391 1422 1423 77 94 1409 77 sky130_fd_sc_hd__and4_1
* cell instance $4261 m0 *1 110.4,111.52
X$4261 94 852 1424 1425 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4263 m0 *1 112.24,111.52
X$4263 94 1466 1411 1424 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4265 m0 *1 115.92,111.52
X$4265 77 1274 1411 1262 1409 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $4266 m0 *1 119.6,111.52
X$4266 77 1392 1211 1437 1426 1436 94 94 77 sky130_fd_sc_hd__or4_4
* cell instance $4267 m0 *1 123.74,111.52
X$4267 94 1340 94 77 1436 77 sky130_fd_sc_hd__inv_1
* cell instance $4271 m0 *1 128.34,111.52
X$4271 94 1452 1450 1211 1462 1427 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4272 m0 *1 131.1,111.52
X$4272 94 1235 1461 1427 77 94 1435 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4273 m0 *1 132.94,111.52
X$4273 94 1303 1237 1462 1452 94 77 1461 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4275 m0 *1 136.62,111.52
X$4275 94 1303 1212 1460 1432 94 77 1459 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4278 m0 *1 140.76,111.52
X$4278 94 1235 1459 1458 77 94 1428 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4281 m0 *1 156.86,111.52
X$4281 94 1345 1398 1429 1455 77 94 1397 77 sky130_fd_sc_hd__and4_1
* cell instance $4282 m0 *1 160.08,111.52
X$4282 94 1455 1429 1396 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4283 m0 *1 161.46,111.52
X$4283 94 1262 1344 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4284 m0 *1 162.84,111.52
X$4284 94 1235 1399 1404 77 94 1400 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4285 m0 *1 164.68,111.52
X$4285 94 1455 1429 1398 1370 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4288 m0 *1 167.44,111.52
X$4288 94 1340 1324 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4290 m0 *1 169.28,111.52
X$4290 94 1456 1430 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4292 m0 *1 171.12,111.52
X$4292 94 1345 1372 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4295 r0 *1 2.76,111.52
X$4295 94 916 1441 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4298 r0 *1 5.52,111.52
X$4298 94 909 931 1075 887 77 94 1444 77 sky130_fd_sc_hd__and4_1
* cell instance $4299 r0 *1 8.74,111.52
X$4299 77 1373 1442 1496 94 1028 94 77 sky130_fd_sc_hd__nand3_4
* cell instance $4302 r0 *1 15.64,111.52
X$4302 77 1416 1496 1405 1444 94 1315 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $4303 r0 *1 23.46,111.52
X$4303 94 915 991 916 1482 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4305 r0 *1 25.76,111.52
X$4305 94 1296 1375 1482 990 94 77 1485 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4308 r0 *1 40.48,111.52
X$4308 94 916 1315 1501 1487 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4313 r0 *1 61.18,111.52
X$4313 94 1470 1471 1489 1446 94 77 1463 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4314 r0 *1 63.94,111.52
X$4314 94 1383 1463 1542 77 94 1515 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4315 r0 *1 65.78,111.52
X$4315 94 1447 1445 1446 1472 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4316 r0 *1 67.62,111.52
X$4316 94 1470 1490 1472 1516 94 77 1464 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4319 r0 *1 70.84,111.52
X$4319 94 1383 1464 1512 77 94 1439 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4322 r0 *1 78.2,111.52
X$4322 94 1491 1447 1483 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4323 r0 *1 90.16,111.52
X$4323 77 1545 1357 1448 1473 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $4324 r0 *1 94.76,111.52
X$4324 94 1426 1448 94 1492 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4329 r0 *1 99.82,111.52
X$4329 77 77 1473 1437 1448 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $4331 r0 *1 102.58,111.52
X$4331 94 1474 1423 1493 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4332 r0 *1 105.8,111.52
X$4332 94 1426 1437 1468 1474 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $4335 r0 *1 109.94,111.52
X$4335 94 1391 1423 1422 1320 94 1449 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4337 r0 *1 113.16,111.52
X$4337 94 1449 1437 1426 1468 77 1466 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $4338 r0 *1 115.46,111.52
X$4338 94 1437 1426 1284 77 94 77 sky130_fd_sc_hd__or2_1
* cell instance $4340 r0 *1 118.22,111.52
X$4340 94 1494 1475 1465 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $4342 r0 *1 120.98,111.52
X$4342 94 1409 1411 1395 1465 94 1450 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4345 r0 *1 123.74,111.52
X$4345 94 1450 94 77 1303 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4347 r0 *1 126.04,111.52
X$4347 94 1468 1449 1451 1508 1368 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4348 r0 *1 128.8,111.52
X$4348 94 1456 1450 1244 1451 1553 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4350 r0 *1 132.02,111.52
X$4350 94 1432 1326 1453 1452 94 1451 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4352 r0 *1 134.78,111.52
X$4352 94 1326 1453 1432 1462 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4354 r0 *1 137.08,111.52
X$4354 94 1326 1453 1460 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4356 r0 *1 138.92,111.52
X$4356 94 1432 1303 1212 1460 1458 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4359 r0 *1 149.04,111.52
X$4359 94 1368 94 77 1236 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4361 r0 *1 150.88,111.52
X$4361 94 1483 987 1484 1476 77 94 1477 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4363 r0 *1 153.64,111.52
X$4363 77 1476 1524 1398 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4365 r0 *1 157.78,111.52
X$4365 94 1477 1454 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4366 r0 *1 159.16,111.52
X$4366 94 1478 1429 1244 1236 1536 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4367 r0 *1 171.12,111.52
X$4367 94 1286 1402 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4382 m0 *1 3.68,116.96
X$4382 94 1563 836 94 1505 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4383 m0 *1 6.9,116.96
X$4383 94 1496 820 836 1444 94 1506 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4384 m0 *1 9.2,116.96
X$4384 77 1373 1497 1498 94 1032 94 77 sky130_fd_sc_hd__nand3_4
* cell instance $4385 m0 *1 15.64,116.96
X$4385 94 1498 1497 1405 1533 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4389 m0 *1 20.7,116.96
X$4389 77 77 1442 1296 1496 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $4391 m0 *1 23.92,116.96
X$4391 94 990 1296 1375 1482 1499 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4392 m0 *1 26.68,116.96
X$4392 94 1258 1485 1499 77 94 1486 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4395 m0 *1 29.44,116.96
X$4395 94 1500 1296 1375 991 94 77 1535 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4396 m0 *1 32.2,116.96
X$4396 94 1500 991 1296 1375 1580 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4399 m0 *1 39.56,116.96
X$4399 94 915 991 1501 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4400 m0 *1 40.94,116.96
X$4400 94 1315 1501 916 94 1538 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4405 m0 *1 49.68,116.96
X$4405 94 1447 94 77 1513 77 sky130_fd_sc_hd__inv_1
* cell instance $4406 m0 *1 51.06,116.96
X$4406 94 1513 1470 1490 1445 94 77 1539 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4407 m0 *1 53.82,116.96
X$4407 94 1383 1539 1540 77 94 1488 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4411 m0 *1 68.54,116.96
X$4411 94 1516 1514 1490 1472 1512 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4416 m0 *1 78.2,116.96
X$4416 94 1491 1446 1544 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4417 m0 *1 79.58,116.96
X$4417 94 1491 1445 1507 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4424 m0 *1 86.94,116.96
X$4424 94 1518 1502 1511 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4427 m0 *1 89.7,116.96
X$4427 77 1502 1545 1473 1426 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4430 m0 *1 95.68,116.96
X$4430 94 1518 1492 1510 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4432 m0 *1 98.9,116.96
X$4432 94 1509 1426 1437 1546 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $4437 m0 *1 116.84,116.96
X$4437 94 1284 1468 1274 1494 94 77 1549 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4438 m0 *1 119.6,116.96
X$4438 94 1494 1284 1468 1274 1550 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4441 m0 *1 126.5,116.96
X$4441 94 1475 1411 1494 1456 94 1508 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4442 m0 *1 128.8,116.96
X$4442 94 1235 1552 1553 77 94 1551 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4445 m0 *1 132.02,116.96
X$4445 94 1303 1212 1451 1456 94 77 1552 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4447 m0 *1 136.62,116.96
X$4447 94 1433 1453 1303 1237 1519 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4449 m0 *1 139.84,116.96
X$4449 94 1235 1548 1519 77 94 1520 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4450 m0 *1 141.68,116.96
X$4450 94 1433 1303 1237 1453 94 77 1548 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4452 m0 *1 145.36,116.96
X$4452 94 1544 813 1484 1521 77 94 1522 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4453 m0 *1 147.66,116.96
X$4453 94 1507 1031 1484 1503 77 94 1531 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4454 m0 *1 149.96,116.96
X$4454 77 1521 1541 1210 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4455 m0 *1 153.64,116.96
X$4455 77 1503 1537 1345 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4457 m0 *1 157.78,116.96
X$4457 94 1478 1212 1239 1429 94 77 1534 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4460 m0 *1 161.92,116.96
X$4460 94 1237 1239 1455 94 1532 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4462 m0 *1 164.22,116.96
X$4462 94 1235 1532 1527 77 94 1481 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4465 m0 *1 167.44,116.96
X$4465 94 1455 1237 1236 1527 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4466 m0 *1 169.74,116.96
X$4466 94 1452 1401 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4470 r0 *1 1.84,116.96
X$4470 94 991 1469 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4471 r0 *1 13.8,116.96
X$4471 94 990 1440 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4476 r0 *1 15.64,116.96
X$4476 94 1533 800 1555 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4479 r0 *1 21.16,116.96
X$4479 94 1442 800 1496 1405 94 1565 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4482 r0 *1 24.84,116.96
X$4482 94 915 94 77 1500 77 sky130_fd_sc_hd__inv_1
* cell instance $4483 r0 *1 26.22,116.96
X$4483 94 1315 1500 1567 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4485 r0 *1 40.94,116.96
X$4485 94 1258 1538 1487 77 94 1570 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4490 r0 *1 53.82,116.96
X$4490 94 1513 1445 1514 1490 1540 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4494 r0 *1 61.64,116.96
X$4494 94 1447 1445 1489 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4495 r0 *1 63.02,116.96
X$4495 94 1446 1514 1471 1489 1542 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4498 r0 *1 68.08,116.96
X$4498 94 1446 1447 1445 1516 94 1575 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $4506 r0 *1 78.66,116.96
X$4506 94 1491 1516 1543 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4518 r0 *1 98.44,116.96
X$4518 94 1546 1584 1598 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4521 r0 *1 103.96,116.96
X$4521 94 1518 1493 1547 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4524 r0 *1 118.68,116.96
X$4524 94 1188 1549 1550 77 94 1571 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4537 r0 *1 149.5,116.96
X$4537 94 1475 1528 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4541 r0 *1 150.88,116.96
X$4541 94 1543 854 1484 1523 77 94 1564 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4543 r0 *1 153.64,116.96
X$4543 77 1523 1625 1162 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4544 r0 *1 157.32,116.96
X$4544 94 1522 1480 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4547 r0 *1 160.08,116.96
X$4547 94 1235 1534 1536 77 94 1526 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4550 m0 *1 1.38,122.4
X$4550 94 915 1495 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4551 m0 *1 2.76,122.4
X$4551 94 800 1554 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4553 m0 *1 4.6,122.4
X$4553 94 486 1505 1562 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4555 m0 *1 6.44,122.4
X$4555 94 820 1496 1442 1563 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4556 m0 *1 8.28,122.4
X$4556 94 1443 1578 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4558 m0 *1 10.58,122.4
X$4558 94 931 1075 930 887 77 94 1497 77 sky130_fd_sc_hd__and4_1
* cell instance $4559 m0 *1 13.8,122.4
X$4559 77 836 907 1405 820 913 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $4562 m0 *1 29.44,122.4
X$4562 94 486 1567 1569 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4564 m0 *1 31.28,122.4
X$4564 94 1258 1535 1580 77 94 1568 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4569 m0 *1 52.44,122.4
X$4569 94 1447 1514 1471 1594 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4573 m0 *1 68.54,122.4
X$4573 94 1470 1471 1575 1557 94 77 1596 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4575 m0 *1 82.8,122.4
X$4575 94 1491 1556 1566 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4579 m0 *1 86.94,122.4
X$4579 94 487 77 1518 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4582 m0 *1 100.74,122.4
X$4582 94 1518 1598 1576 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4584 m0 *1 103.96,122.4
X$4584 94 1597 94 77 1395 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4585 m0 *1 105.8,122.4
X$4585 94 1558 1422 94 1574 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4587 m0 *1 109.94,122.4
X$4587 94 1423 1321 1395 1558 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4590 m0 *1 113.16,122.4
X$4590 94 1494 1321 1395 1559 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4591 m0 *1 115,122.4
X$4591 94 1274 1559 1475 94 1595 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4592 m0 *1 116.84,122.4
X$4592 94 1475 1274 1559 1586 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $4597 m0 *1 145.82,122.4
X$4597 94 1566 783 1484 1561 77 94 1593 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4602 m0 *1 155.02,122.4
X$4602 77 1561 1622 1267 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4603 m0 *1 158.7,122.4
X$4603 94 1455 94 77 1478 77 sky130_fd_sc_hd__inv_1
* cell instance $4606 m0 *1 162.84,122.4
X$4606 94 1564 1479 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4607 m0 *1 164.22,122.4
X$4607 94 1294 2226 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4612 m0 *1 168.36,122.4
X$4612 94 1429 1529 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4613 m0 *1 169.74,122.4
X$4613 94 1455 1530 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4614 m0 *1 171.12,122.4
X$4614 94 1398 1457 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4615 r0 *1 1.38,122.4
X$4615 94 907 1577 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4616 r0 *1 2.76,122.4
X$4616 94 820 1599 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4617 r0 *1 4.14,122.4
X$4617 77 836 1579 820 907 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4618 r0 *1 6.44,122.4
X$4618 94 1496 1442 1579 1617 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4621 r0 *1 12.88,122.4
X$4621 94 487 1555 1592 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $4627 r0 *1 16.56,122.4
X$4627 94 1565 1443 94 1621 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4628 r0 *1 19.78,122.4
X$4628 77 1403 2222 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $4639 r0 *1 61.18,122.4
X$4639 94 1514 77 1470 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4643 r0 *1 66.24,122.4
X$4643 94 1557 1605 1604 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4644 r0 *1 67.62,122.4
X$4644 94 1557 1607 1471 1575 1581 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4649 r0 *1 70.84,122.4
X$4649 94 1632 1607 1471 1629 1630 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4650 r0 *1 73.6,122.4
X$4650 94 1383 1596 1581 77 94 1582 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4653 r0 *1 82.8,122.4
X$4653 94 808 94 77 1491 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4662 r0 *1 100.28,122.4
X$4662 77 1468 1583 1584 1585 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $4663 r0 *1 103.96,122.4
X$4663 77 1584 1597 1583 1585 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4665 r0 *1 107.18,122.4
X$4665 94 1610 1585 94 1633 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4666 r0 *1 110.4,122.4
X$4666 94 1583 1584 1321 1610 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4667 r0 *1 112.24,122.4
X$4667 94 1518 1574 1572 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4669 r0 *1 114.08,122.4
X$4669 94 1188 1595 1586 77 94 1611 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4679 r0 *1 142.6,122.4
X$4679 77 1654 1628 1456 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4680 r0 *1 146.28,122.4
X$4680 94 1612 740 1484 1588 77 94 1587 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4682 r0 *1 149.5,122.4
X$4682 94 1560 1093 1484 1623 77 94 1626 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4689 r0 *1 153.64,122.4
X$4689 77 1588 1589 1192 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4690 r0 *1 157.32,122.4
X$4690 77 1623 1726 1429 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4691 r0 *1 161,122.4
X$4691 94 1587 1591 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4693 r0 *1 163.3,122.4
X$4693 77 258 1294 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4696 m0 *1 3.68,127.84
X$4696 94 1617 913 94 1616 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4699 m0 *1 8.28,127.84
X$4699 94 1682 820 94 1601 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4700 m0 *1 11.5,127.84
X$4700 94 486 1601 1620 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4702 m0 *1 23.92,127.84
X$4702 94 486 1621 1624 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4705 m0 *1 29.44,127.84
X$4705 77 181 1403 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4708 m0 *1 40.02,127.84
X$4708 94 1207 94 77 487 77 sky130_fd_sc_hd__buf_4
* cell instance $4709 m0 *1 52.44,127.84
X$4709 94 1383 1656 1594 77 94 1627 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4710 m0 *1 54.28,127.84
X$4710 94 1470 1471 1447 94 1656 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $4716 m0 *1 60.26,127.84
X$4716 94 1470 1490 1604 1556 94 77 1658 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4717 m0 *1 63.02,127.84
X$4717 94 1383 1658 1659 77 94 1573 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4719 m0 *1 65.78,127.84
X$4719 94 1557 1556 1605 1629 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4720 m0 *1 67.62,127.84
X$4720 77 181 1421 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4724 m0 *1 80.04,127.84
X$4724 94 1491 1606 1560 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4725 m0 *1 81.42,127.84
X$4725 94 1491 1608 1609 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4726 m0 *1 82.8,127.84
X$4726 94 1491 1603 1642 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4728 m0 *1 84.64,127.84
X$4728 94 1491 1632 1612 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4731 m0 *1 88.78,127.84
X$4731 94 1518 1637 1634 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4734 m0 *1 91.54,127.84
X$4734 94 1321 1583 1637 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $4736 m0 *1 105.34,127.84
X$4736 77 1517 2215 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $4737 m0 *1 110.4,127.84
X$4737 94 1583 94 77 1509 77 sky130_fd_sc_hd__inv_1
* cell instance $4739 m0 *1 112.24,127.84
X$4739 94 1638 77 1484 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4740 m0 *1 114.08,127.84
X$4740 94 1518 1633 1631 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4741 m0 *1 115.46,127.84
X$4741 94 1638 1639 1657 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4752 m0 *1 141.22,127.84
X$4752 94 1609 1059 1484 1654 77 94 1643 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4754 m0 *1 145.36,127.84
X$4754 94 1642 1652 1484 1653 77 94 1619 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4755 m0 *1 147.66,127.84
X$4755 94 1478 1641 1686 77 94 1653 77 sky130_fd_sc_hd__a21o_1
* cell instance $4758 m0 *1 151.8,127.84
X$4758 94 1613 1618 1625 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4759 m0 *1 154.1,127.84
X$4759 94 1613 1647 1622 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4763 m0 *1 167.44,127.84
X$4763 94 1593 1590 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4764 m0 *1 168.82,127.84
X$4764 94 1531 1504 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4765 m0 *1 170.2,127.84
X$4765 94 1626 1615 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4776 r0 *1 16.1,127.84
X$4776 94 1684 94 77 1442 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4778 r0 *1 30.36,127.84
X$4778 94 487 77 1705 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4785 r0 *1 47.84,127.84
X$4785 94 1383 1690 1636 77 94 1688 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4786 r0 *1 49.68,127.84
X$4786 94 1603 1514 1663 1692 1636 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4787 r0 *1 52.44,127.84
X$4787 94 1772 1470 1663 1608 94 77 1695 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4792 r0 *1 62.1,127.84
X$4792 94 1556 1607 1490 1604 1659 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4795 r0 *1 67.62,127.84
X$4795 94 1470 1471 1629 1632 94 77 1660 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4800 r0 *1 70.84,127.84
X$4800 94 1421 2229 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4801 r0 *1 72.22,127.84
X$4801 94 1334 1660 1630 77 94 1664 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4803 r0 *1 84.18,127.84
X$4803 94 1491 1602 1699 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4813 r0 *1 98.44,127.84
X$4813 77 1667 1699 667 1484 1698 94 94 77 sky130_fd_sc_hd__a31oi_2
* cell instance $4815 r0 *1 103.96,127.84
X$4815 94 809 1557 1639 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4816 r0 *1 105.34,127.84
X$4816 77 258 1517 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $4818 r0 *1 115.46,127.84
X$4818 94 1671 1697 1208 94 1694 77 77 sky130_fd_sc_hd__o21a_1
* cell instance $4819 r0 *1 118.22,127.84
X$4819 94 1640 1657 1355 94 1696 77 77 sky130_fd_sc_hd__o21a_1
* cell instance $4820 r0 *1 120.98,127.84
X$4820 94 1738 1436 1672 77 94 1671 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4821 r0 *1 122.82,127.84
X$4821 94 1641 94 77 1525 77 sky130_fd_sc_hd__buf_4
* cell instance $4828 r0 *1 137.08,127.84
X$4828 94 1655 1328 1672 77 94 1640 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4832 r0 *1 142.14,127.84
X$4832 77 1691 1731 1322 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4835 r0 *1 148.12,127.84
X$4835 94 1644 1675 1628 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4841 r0 *1 151.8,127.84
X$4841 94 1644 1645 1524 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4843 r0 *1 153.64,127.84
X$4843 94 1613 1646 1589 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4845 r0 *1 157.78,127.84
X$4845 94 1643 1649 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4846 r0 *1 159.16,127.84
X$4846 94 1645 1678 1683 1676 94 77 1716 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4848 m0 *1 1.38,133.28
X$4848 94 913 1661 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4849 m0 *1 2.76,133.28
X$4849 94 836 1600 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4850 m0 *1 4.14,133.28
X$4850 94 486 1616 1681 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4852 m0 *1 6.44,133.28
X$4852 77 1075 1701 887 909 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4853 m0 *1 8.74,133.28
X$4853 94 931 1496 1701 1682 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4855 m0 *1 11.04,133.28
X$4855 94 1721 909 94 1722 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4856 m0 *1 14.26,133.28
X$4856 77 931 1684 1702 909 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4859 m0 *1 17.94,133.28
X$4859 94 887 1075 1496 1662 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4860 m0 *1 19.78,133.28
X$4860 94 1662 931 94 1703 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4861 m0 *1 23,133.28
X$4861 94 852 1703 1685 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4867 m0 *1 33.58,133.28
X$4867 94 1724 1602 94 1704 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $4868 m0 *1 36.8,133.28
X$4868 94 1705 1704 1687 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4871 m0 *1 50.14,133.28
X$4871 94 1470 1663 1692 1603 94 77 1690 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4872 m0 *1 52.9,133.28
X$4872 94 1606 1514 1663 1728 1757 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4875 m0 *1 66.7,133.28
X$4875 94 1516 1446 1445 1447 77 94 1605 77 sky130_fd_sc_hd__and4_1
* cell instance $4876 m0 *1 69.92,133.28
X$4876 77 1556 1707 1557 1632 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $4879 m0 *1 82.8,133.28
X$4879 94 1710 1665 1666 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4885 m0 *1 103.04,133.28
X$4885 94 1509 1641 1711 77 94 1698 77 sky130_fd_sc_hd__a21o_1
* cell instance $4886 m0 *1 105.8,133.28
X$4886 94 1641 1668 1644 1711 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $4888 m0 *1 109.02,133.28
X$4888 94 1641 94 77 1672 77 sky130_fd_sc_hd__buf_4
* cell instance $4890 m0 *1 112.24,133.28
X$4890 94 1638 77 1669 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4891 m0 *1 115,133.28
X$4891 94 809 1670 1740 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4894 m0 *1 119.14,133.28
X$4894 77 1778 1712 1234 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4895 m0 *1 122.82,133.28
X$4895 94 1727 1737 1712 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4899 m0 *1 128.34,133.28
X$4899 94 1207 1693 1736 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $4900 m0 *1 130.64,133.28
X$4900 94 601 1693 1733 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4902 m0 *1 132.48,133.28
X$4902 94 1641 94 77 1713 77 sky130_fd_sc_hd__buf_4
* cell instance $4906 m0 *1 139.84,133.28
X$4906 94 1666 612 1669 1691 77 94 1689 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4908 m0 *1 142.6,133.28
X$4908 94 1673 784 1669 1674 77 94 1720 77 sky130_fd_sc_hd__a31oi_1
* cell instance $4909 m0 *1 144.9,133.28
X$4909 77 1674 1784 1286 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $4910 m0 *1 148.58,133.28
X$4910 94 1641 1730 1644 1686 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $4914 m0 *1 154.56,133.28
X$4914 94 1727 1676 1537 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4915 m0 *1 156.86,133.28
X$4915 94 1645 1676 1678 1677 1754 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4916 m0 *1 159.62,133.28
X$4916 94 1618 1678 1677 1715 1717 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4917 m0 *1 162.38,133.28
X$4917 94 1188 1723 1717 77 94 1651 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4919 m0 *1 164.68,133.28
X$4919 94 1619 1614 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4922 m0 *1 167.44,133.28
X$4922 94 1720 1679 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4925 m0 *1 170.2,133.28
X$4925 94 1453 1648 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4927 r0 *1 1.38,133.28
X$4927 94 931 1700 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4928 r0 *1 2.76,133.28
X$4928 94 909 1741 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $4931 r0 *1 8.28,133.28
X$4931 94 1750 77 1496 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $4933 r0 *1 11.5,133.28
X$4933 94 1702 931 1496 1721 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4934 r0 *1 13.34,133.28
X$4934 94 852 1722 1752 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4940 r0 *1 36.8,133.28
X$4940 94 1756 1742 1724 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4949 r0 *1 47.38,133.28
X$4949 94 1383 1695 1743 77 94 1725 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4950 r0 *1 49.22,133.28
X$4950 94 1608 1772 1514 1663 1743 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4951 r0 *1 51.98,133.28
X$4951 94 1470 1663 1728 1606 94 77 1729 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4952 r0 *1 54.74,133.28
X$4952 94 1383 1729 1757 77 94 1758 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4954 r0 *1 60.26,133.28
X$4954 94 1607 77 1514 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4957 r0 *1 64.4,133.28
X$4957 94 1514 1490 1759 1761 94 77 1806 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4958 r0 *1 67.16,133.28
X$4958 94 1605 1707 1759 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4959 r0 *1 68.54,133.28
X$4959 94 1761 1605 1707 1708 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $4964 r0 *1 70.84,133.28
X$4964 94 1514 1471 1708 1665 94 77 1709 77 sky130_fd_sc_hd__o31ai_1
* cell instance $4965 r0 *1 73.6,133.28
X$4965 94 1665 1607 1471 1708 1744 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $4966 r0 *1 76.36,133.28
X$4966 94 1334 1709 1744 77 94 1760 77 sky130_fd_sc_hd__a21oi_1
* cell instance $4968 r0 *1 80.04,133.28
X$4968 94 1710 1761 1673 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4970 r0 *1 81.88,133.28
X$4970 94 808 94 77 1732 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $4972 r0 *1 84.18,133.28
X$4972 94 808 77 1710 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4974 r0 *1 87.86,133.28
X$4974 94 1079 1790 1734 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4985 r0 *1 102.58,133.28
X$4985 94 1644 1766 1767 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4987 r0 *1 105.8,133.28
X$4987 94 1739 77 1644 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4988 r0 *1 107.64,133.28
X$4988 94 1644 1770 1817 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $4989 r0 *1 109.94,133.28
X$4989 94 1638 77 1777 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4990 r0 *1 111.78,133.28
X$4990 94 1638 1740 1697 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $4991 r0 *1 113.16,133.28
X$4991 94 1739 1745 1638 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $4994 r0 *1 115.92,133.28
X$4994 94 1745 77 1641 94 77 sky130_fd_sc_hd__buf_2
* cell instance $4998 r0 *1 120.98,133.28
X$4998 94 1641 1768 1644 1738 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $5006 r0 *1 128.34,133.28
X$5006 77 1735 1733 1736 1765 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $5007 r0 *1 132.48,133.28
X$5007 94 1727 1693 1763 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5008 r0 *1 134.78,133.28
X$5008 77 1764 1763 1432 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5010 r0 *1 142.14,133.28
X$5010 94 1613 1762 1731 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5012 r0 *1 146.28,133.28
X$5012 94 1641 1746 1644 1655 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $5017 r0 *1 150.88,133.28
X$5017 94 1613 1747 1541 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5019 r0 *1 153.64,133.28
X$5019 94 1714 94 77 1645 77 sky130_fd_sc_hd__inv_1
* cell instance $5020 r0 *1 155.02,133.28
X$5020 94 1727 1748 1726 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5021 r0 *1 157.32,133.28
X$5021 94 1494 1718 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5022 r0 *1 158.7,133.28
X$5022 94 1275 1716 1754 77 94 1650 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5023 r0 *1 160.54,133.28
X$5023 94 1678 1683 1715 1618 94 77 1723 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5026 m0 *1 5.98,138.72
X$5026 77 930 314 1750 1803 1780 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $5027 m0 *1 9.66,138.72
X$5027 77 909 314 1498 1803 1780 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $5028 m0 *1 13.34,138.72
X$5028 77 181 1635 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $5035 m0 *1 31.74,138.72
X$5035 94 1705 1771 1753 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5036 m0 *1 33.12,138.72
X$5036 77 1771 1755 1785 1742 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5038 m0 *1 47.84,138.72
X$5038 94 1756 94 77 1772 77 sky130_fd_sc_hd__inv_1
* cell instance $5039 m0 *1 49.22,138.72
X$5039 94 1792 1755 1608 1692 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5041 m0 *1 51.98,138.72
X$5041 94 1608 1603 1756 1728 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5042 m0 *1 53.82,138.72
X$5042 94 1938 77 1471 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5048 m0 *1 68.08,138.72
X$5048 94 1761 1607 1490 1759 1773 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5049 m0 *1 70.84,138.72
X$5049 94 1334 1806 1773 77 94 1788 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5054 m0 *1 79.58,138.72
X$5054 94 1732 1807 1769 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5055 m0 *1 80.96,138.72
X$5055 94 1732 1774 1775 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5059 m0 *1 85.56,138.72
X$5059 94 1916 1668 94 1790 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5060 m0 *1 88.78,138.72
X$5060 94 1791 1766 94 1776 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5061 m0 *1 92,138.72
X$5061 94 1079 1776 1811 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5063 m0 *1 103.96,138.72
X$5063 77 1814 1767 1448 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5065 m0 *1 108.1,138.72
X$5065 77 1789 1817 1262 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5068 m0 *1 115.92,138.72
X$5068 94 1775 919 1777 1778 77 94 1931 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5069 m0 *1 118.22,138.72
X$5069 77 1821 1822 1494 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5070 m0 *1 121.9,138.72
X$5070 77 1819 1847 1475 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5071 m0 *1 125.58,138.72
X$5071 77 1787 1816 1263 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5072 m0 *1 129.26,138.72
X$5072 94 1769 1102 1777 1764 77 94 1920 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5074 m0 *1 132.02,138.72
X$5074 77 1813 1841 1453 1672 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5075 m0 *1 135.7,138.72
X$5075 94 1641 1798 1644 1812 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $5079 m0 *1 140.76,138.72
X$5079 94 1207 1762 1809 77 94 77 sky130_fd_sc_hd__nor2b_1
* cell instance $5080 m0 *1 143.06,138.72
X$5080 94 601 1762 1786 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5082 m0 *1 146.28,138.72
X$5082 94 1644 1799 1784 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5086 m0 *1 153.64,138.72
X$5086 94 1746 1783 1677 1782 1800 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5087 m0 *1 156.4,138.72
X$5087 94 1783 1683 1782 1746 94 77 1781 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5088 m0 *1 159.16,138.72
X$5088 94 1747 1714 1676 1618 94 1782 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5089 m0 *1 161.46,138.72
X$5089 94 1714 1676 1747 1715 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5092 m0 *1 167.44,138.72
X$5092 94 1689 1719 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5093 m0 *1 168.82,138.72
X$5093 94 1762 1779 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5095 m0 *1 171.12,138.72
X$5095 94 1432 1680 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5097 r0 *1 1.84,138.72
X$5097 94 930 1823 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5099 r0 *1 3.68,138.72
X$5099 77 1825 1803 1780 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $5102 r0 *1 10.58,138.72
X$5102 77 1903 1702 887 1075 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $5107 r0 *1 15.64,138.72
X$5107 94 1635 94 77 77 sky130_fd_sc_hd__clkinv_2
* cell instance $5111 r0 *1 34.5,138.72
X$5111 77 1785 1863 1792 1755 94 94 77 sky130_fd_sc_hd__ha_1
* cell instance $5112 r0 *1 39.1,138.72
X$5112 94 1705 1836 1805 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5129 r0 *1 80.04,138.72
X$5129 94 1732 1793 1818 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5131 r0 *1 81.88,138.72
X$5131 94 1792 1710 1795 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5134 r0 *1 87.4,138.72
X$5134 77 1810 1842 1794 1791 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5135 r0 *1 91.08,138.72
X$5135 94 1079 1810 1844 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5144 r0 *1 102.58,138.72
X$5144 94 1669 1795 844 1814 77 94 1851 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5145 r0 *1 104.88,138.72
X$5145 94 1727 1794 1815 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5146 r0 *1 107.18,138.72
X$5146 77 1827 1815 1473 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5147 r0 *1 110.86,138.72
X$5147 94 1739 77 1727 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5150 r0 *1 114.08,138.72
X$5150 94 1818 997 1777 1787 77 94 1849 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5151 r0 *1 116.38,138.72
X$5151 94 1826 920 1777 1821 77 94 1848 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5153 r0 *1 120.52,138.72
X$5153 94 1820 1209 1777 1813 77 94 1845 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5160 r0 *1 126.04,138.72
X$5160 94 1727 1796 1816 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5164 r0 *1 133.4,138.72
X$5164 94 1433 1713 1812 77 94 1843 77 sky130_fd_sc_hd__a21o_1
* cell instance $5165 r0 *1 136.16,138.72
X$5165 77 1830 1797 1452 1525 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5167 r0 *1 141.68,138.72
X$5167 77 1866 1786 1809 1831 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $5173 r0 *1 150.42,138.72
X$5173 94 1808 1783 1799 1683 77 1831 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $5176 r0 *1 153.64,138.72
X$5176 94 1618 1747 1676 1714 77 94 1839 77 sky130_fd_sc_hd__and4_1
* cell instance $5177 r0 *1 156.86,138.72
X$5177 94 1188 1781 1800 77 94 1804 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5178 r0 *1 158.7,138.72
X$5178 94 1714 1676 1837 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5179 r0 *1 160.08,138.72
X$5179 94 1783 1683 1837 1747 94 77 1835 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5180 m0 *1 10.58,144.16
X$5180 94 363 1780 1803 1852 77 94 77 sky130_fd_sc_hd__and3b_1
* cell instance $5181 m0 *1 13.8,144.16
X$5181 94 1702 1852 1862 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5182 m0 *1 15.18,144.16
X$5182 94 1862 930 94 1853 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5183 m0 *1 18.4,144.16
X$5183 94 852 1853 1834 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5190 m0 *1 32.2,144.16
X$5190 77 314 363 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $5191 m0 *1 37.26,144.16
X$5191 94 1742 1792 1836 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5192 m0 *1 40.48,144.16
X$5192 94 1863 77 1756 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $5197 m0 *1 52.9,144.16
X$5197 94 1854 1838 1877 1807 94 77 1864 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5202 m0 *1 59.8,144.16
X$5202 94 1854 1838 1793 94 1870 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5203 m0 *1 61.64,144.16
X$5203 94 1793 1854 1838 1880 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5205 m0 *1 76.36,144.16
X$5205 94 1732 1840 1820 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5206 m0 *1 77.74,144.16
X$5206 94 1732 1755 1846 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5207 m0 *1 79.12,144.16
X$5207 94 1732 1886 1826 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5208 m0 *1 80.5,144.16
X$5208 94 1732 1879 1856 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5209 m0 *1 81.88,144.16
X$5209 94 1732 1873 1858 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5213 m0 *1 85.1,144.16
X$5213 77 1842 1874 1794 1766 94 94 77 sky130_fd_sc_hd__ha_2
* cell instance $5214 m0 *1 100.28,144.16
X$5214 94 1739 77 1613 94 77 sky130_fd_sc_hd__clkbuf_4
* cell instance $5217 m0 *1 105.8,144.16
X$5217 94 1857 895 1777 1789 77 94 1850 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5218 m0 *1 108.1,144.16
X$5218 94 1846 1067 1777 1827 77 94 1885 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5224 m0 *1 116.84,144.16
X$5224 94 1922 960 1777 1819 77 94 1872 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5225 m0 *1 119.14,144.16
X$5225 94 1727 1828 1822 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5227 m0 *1 121.9,144.16
X$5227 94 1727 1895 1847 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5228 m0 *1 124.2,144.16
X$5228 94 1856 1103 1777 1843 77 94 1829 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5229 m0 *1 126.5,144.16
X$5229 94 1858 1871 1777 1830 77 94 1869 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5233 m0 *1 133.86,144.16
X$5233 94 1727 1868 1841 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5234 m0 *1 136.16,144.16
X$5234 94 1727 1859 1797 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5240 m0 *1 151.8,144.16
X$5240 94 1865 94 77 1799 77 sky130_fd_sc_hd__inv_1
* cell instance $5243 m0 *1 154.56,144.16
X$5243 94 1646 1746 1647 1839 94 1808 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5246 m0 *1 159.16,144.16
X$5246 94 1747 1783 1677 1837 1860 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5247 m0 *1 161.92,144.16
X$5247 94 1275 1835 1860 77 94 1751 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5249 m0 *1 165.6,144.16
X$5249 94 1746 1801 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5252 m0 *1 168.36,144.16
X$5252 94 1618 1749 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5253 m0 *1 169.74,144.16
X$5253 94 1676 1802 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5254 m0 *1 171.12,144.16
X$5254 94 1747 1833 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5255 r0 *1 1.38,144.16
X$5255 94 887 1888 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5256 r0 *1 2.76,144.16
X$5256 94 1075 1824 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5259 r0 *1 9.66,144.16
X$5259 77 1961 1075 1903 1852 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5263 r0 *1 15.64,144.16
X$5263 94 1852 887 1875 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5264 r0 *1 18.86,144.16
X$5264 94 852 1875 1884 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5266 r0 *1 31.74,144.16
X$5266 94 363 1904 1925 1742 77 94 77 sky130_fd_sc_hd__and3b_1
* cell instance $5268 r0 *1 35.88,144.16
X$5268 94 1905 77 1876 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5271 r0 *1 39.1,144.16
X$5271 94 1705 1907 1906 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5278 r0 *1 47.84,144.16
X$5278 94 1756 1876 1854 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5279 r0 *1 49.22,144.16
X$5279 77 1663 1807 1876 1926 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $5280 r0 *1 52.9,144.16
X$5280 94 1364 1864 1891 77 94 1908 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5281 r0 *1 54.74,144.16
X$5281 94 1807 1854 1838 1877 1891 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5283 r0 *1 57.96,144.16
X$5283 94 1854 1838 1878 1879 94 77 1887 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5284 r0 *1 60.72,144.16
X$5284 94 1879 1854 1838 1878 1911 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5285 r0 *1 63.48,144.16
X$5285 94 1793 1670 1878 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5286 r0 *1 64.86,144.16
X$5286 94 1364 1870 1880 77 94 1855 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5293 r0 *1 75.9,144.16
X$5293 94 1732 1912 1857 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5294 r0 *1 77.28,144.16
X$5294 94 1732 1913 1922 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5296 r0 *1 79.12,144.16
X$5296 77 1914 1881 1882 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $5297 r0 *1 83.26,144.16
X$5297 94 1881 1874 363 1882 94 1916 77 77 sky130_fd_sc_hd__nand4b_1
* cell instance $5298 r0 *1 86.48,144.16
X$5298 94 1881 363 1882 1791 77 94 77 sky130_fd_sc_hd__nand3b_1
* cell instance $5317 r0 *1 149.96,144.16
X$5317 94 1678 1683 1808 1865 94 77 1937 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5322 r0 *1 154.1,144.16
X$5322 94 1746 1647 1839 1900 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5323 r0 *1 155.94,144.16
X$5323 94 1746 1839 1899 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5325 r0 *1 159.16,144.16
X$5325 94 1678 1683 1899 1647 94 77 1910 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5326 r0 *1 171.12,144.16
X$5326 94 1714 1901 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5341 m0 *1 4.14,149.6
X$5341 94 1924 1780 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5343 m0 *1 17.02,149.6
X$5343 94 699 94 77 314 77 sky130_fd_sc_hd__buf_4
* cell instance $5345 m0 *1 29.44,149.6
X$5345 77 1889 1925 1904 359 94 94 77 sky130_fd_sc_hd__mux2_1
* cell instance $5346 m0 *1 33.58,149.6
X$5346 77 1602 314 1905 1925 1904 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $5350 m0 *1 48.76,149.6
X$5350 77 1952 1756 1926 1876 94 1490 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $5353 m0 *1 58.88,149.6
X$5353 94 1879 1793 1670 1840 94 1877 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5354 m0 *1 61.18,149.6
X$5354 94 1364 1887 1911 77 94 1892 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5359 m0 *1 86.48,149.6
X$5359 77 1668 699 1928 1881 1882 94 94 77 sky130_fd_sc_hd__and4b_1
* cell instance $5363 m0 *1 95.22,149.6
X$5363 94 1928 77 1929 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5365 m0 *1 98.9,149.6
X$5365 94 1948 1770 94 1930 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5366 m0 *1 102.12,149.6
X$5366 94 1518 1930 1918 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5371 m0 *1 110.4,149.6
X$5371 94 1518 1893 1947 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5374 m0 *1 123.74,149.6
X$5374 94 1334 1944 1933 77 94 1921 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5377 m0 *1 129.72,149.6
X$5377 94 1943 1896 1934 1765 77 94 77 sky130_fd_sc_hd__nor3b_1
* cell instance $5379 m0 *1 132.94,149.6
X$5379 94 1896 1943 1796 94 1942 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5380 m0 *1 134.78,149.6
X$5380 94 1796 1768 1941 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5382 m0 *1 136.62,149.6
X$5382 94 1275 1939 1940 77 94 1917 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5389 m0 *1 148.58,149.6
X$5389 94 1188 1937 1897 77 94 1909 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5390 m0 *1 150.42,149.6
X$5390 94 1865 1915 1677 1808 1897 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5391 m0 *1 153.18,149.6
X$5391 94 1647 1915 1677 1899 1898 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5392 m0 *1 155.94,149.6
X$5392 94 1783 1683 1900 1646 94 77 1936 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5393 m0 *1 158.7,149.6
X$5393 94 1188 1910 1898 77 94 1962 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5397 m0 *1 165.6,149.6
X$5397 94 1647 1832 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5399 m0 *1 167.44,149.6
X$5399 94 1646 1902 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5401 m0 *1 169.74,149.6
X$5401 94 1730 1861 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5402 m0 *1 171.12,149.6
X$5402 94 1865 1883 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5406 r0 *1 4.6,149.6
X$5406 77 1949 699 94 94 77 sky130_fd_sc_hd__buf_6
* cell instance $5408 r0 *1 9.66,149.6
X$5408 94 852 1961 1935 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5421 r0 *1 31.74,149.6
X$5421 77 1904 1951 1925 1602 699 94 94 77 sky130_fd_sc_hd__nand4b_4
* cell instance $5428 r0 *1 43.24,149.6
X$5428 94 1950 1912 1907 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5429 r0 *1 46.46,149.6
X$5429 94 2021 1951 1772 1963 77 1950 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $5431 r0 *1 49.68,149.6
X$5431 77 1952 1938 1877 1951 94 94 1980 77 sky130_fd_sc_hd__or4b_1
* cell instance $5432 r0 *1 53.36,149.6
X$5432 94 1606 1603 1608 1807 77 94 1952 77 sky130_fd_sc_hd__and4_1
* cell instance $5435 r0 *1 58.88,149.6
X$5435 94 1840 1879 1670 1793 77 94 1926 77 sky130_fd_sc_hd__and4_1
* cell instance $5436 r0 *1 62.1,149.6
X$5436 94 1807 1927 1926 1964 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5438 r0 *1 67.62,149.6
X$5438 94 1886 1913 1774 77 94 1927 77 sky130_fd_sc_hd__and3_2
* cell instance $5445 r0 *1 85.56,149.6
X$5445 94 1881 1668 314 1882 94 2010 77 77 sky130_fd_sc_hd__nand4b_1
* cell instance $5450 r0 *1 98.44,149.6
X$5450 94 1932 1874 1929 1989 94 1948 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5453 r0 *1 103.5,149.6
X$5453 94 1079 1955 1966 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5455 r0 *1 115,149.6
X$5455 94 1957 1828 94 1893 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5456 r0 *1 118.22,149.6
X$5456 94 1975 1956 1946 77 94 1945 77 sky130_fd_sc_hd__and3_2
* cell instance $5457 r0 *1 120.98,149.6
X$5457 94 1895 1959 1958 1933 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5461 r0 *1 123.28,149.6
X$5461 94 1874 1929 1932 1959 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5464 r0 *1 126.04,149.6
X$5464 94 1959 1958 1895 94 1944 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5466 r0 *1 128.34,149.6
X$5466 94 1929 1693 1874 1934 94 1915 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5469 r0 *1 132.02,149.6
X$5469 94 1334 1942 1982 77 94 1919 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5471 r0 *1 134.78,149.6
X$5471 94 1896 1943 1941 1798 94 77 1939 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5478 r0 *1 150.42,149.6
X$5478 94 1915 77 1678 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5481 r0 *1 153.64,149.6
X$5481 94 1677 77 1683 94 77 sky130_fd_sc_hd__buf_2
* cell instance $5482 r0 *1 155.48,149.6
X$5482 94 1188 1936 2000 77 94 1960 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5487 m0 *1 2.76,155.04
X$5487 94 1923 94 1924 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $5499 m0 *1 35.88,155.04
X$5499 94 1951 1980 1963 2018 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $5500 m0 *1 48.3,155.04
X$5500 77 77 1755 1980 1792 94 94 sky130_fd_sc_hd__nand2_2
* cell instance $5506 m0 *1 57.96,155.04
X$5506 77 1927 1968 1969 1967 94 1838 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $5507 m0 *1 62.56,155.04
X$5507 94 1953 1964 1873 94 1983 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5508 m0 *1 64.4,155.04
X$5508 94 1873 1953 1964 1970 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5509 m0 *1 66.7,155.04
X$5509 94 1364 1983 1970 77 94 1965 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5510 m0 *1 68.54,155.04
X$5510 94 1953 1985 1670 94 1984 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5515 m0 *1 85.56,155.04
X$5515 94 1518 2002 1986 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5517 m0 *1 90.62,155.04
X$5517 94 1079 1971 1987 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5518 m0 *1 92,155.04
X$5518 94 1972 1954 94 1971 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5521 m0 *1 96.6,155.04
X$5521 77 1954 1989 1973 1990 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $5523 m0 *1 99.36,155.04
X$5523 94 1929 1973 1874 1932 94 1972 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5525 m0 *1 102.12,155.04
X$5525 94 1766 1794 1976 94 77 77 sky130_fd_sc_hd__and2_1
* cell instance $5526 m0 *1 104.42,155.04
X$5526 94 1974 1956 94 1955 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5527 m0 *1 107.64,155.04
X$5527 94 1975 1874 1929 1974 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5532 m0 *1 114.08,155.04
X$5532 77 1978 1976 1932 1929 94 1957 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $5533 m0 *1 121.9,155.04
X$5533 94 1079 1977 1988 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5534 m0 *1 123.28,155.04
X$5534 94 1828 1978 1958 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5536 m0 *1 125.12,155.04
X$5536 77 1896 1874 1929 1945 94 94 77 sky130_fd_sc_hd__nand3_2
* cell instance $5539 m0 *1 130.18,155.04
X$5539 94 1796 1896 1943 1982 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5541 m0 *1 134.32,155.04
X$5541 94 1978 1979 1943 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5542 m0 *1 135.7,155.04
X$5542 94 1798 1896 1943 1941 1940 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5549 m0 *1 148.58,155.04
X$5549 77 258 1867 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $5566 r0 *1 34.5,155.04
X$5566 94 2018 1991 1992 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5567 r0 *1 37.72,155.04
X$5567 94 2004 1756 1876 2019 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5569 r0 *1 40.02,155.04
X$5569 94 1705 2005 1981 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5570 r0 *1 41.4,155.04
X$5570 94 1705 1992 1998 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5575 r0 *1 43.24,155.04
X$5575 94 2007 1967 94 2005 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5576 r0 *1 46.46,155.04
X$5576 94 1756 1876 1969 2007 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5579 r0 *1 49.68,155.04
X$5579 77 1968 1993 1963 1951 94 94 1980 77 sky130_fd_sc_hd__or4b_1
* cell instance $5582 r0 *1 54.74,155.04
X$5582 94 1993 94 77 1953 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $5583 r0 *1 56.58,155.04
X$5583 77 2008 1969 1927 1968 94 1607 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $5584 r0 *1 64.4,155.04
X$5584 94 1967 1873 2008 94 77 77 sky130_fd_sc_hd__and2_0
* cell instance $5586 r0 *1 67.16,155.04
X$5586 94 1793 1927 1985 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5587 r0 *1 68.54,155.04
X$5587 94 1364 1984 2001 77 94 2023 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5594 r0 *1 83.72,155.04
X$5594 94 2009 1990 2002 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5595 r0 *1 86.94,155.04
X$5595 94 1994 2010 2003 2026 77 2009 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $5597 r0 *1 89.7,155.04
X$5597 94 1766 1794 2003 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5599 r0 *1 91.54,155.04
X$5599 94 1973 1954 1994 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5608 r0 *1 102.12,155.04
X$5608 77 1954 1990 1978 1973 1770 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $5611 r0 *1 107.18,155.04
X$5611 77 1956 1946 1932 1975 1995 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $5612 r0 *1 110.86,155.04
X$5612 77 258 1894 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $5613 r0 *1 120.06,155.04
X$5613 94 1976 1975 1956 1929 94 2024 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5614 r0 *1 122.36,155.04
X$5614 94 1896 1995 94 1977 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5621 r0 *1 128.34,155.04
X$5621 94 1929 1693 1976 1934 94 2012 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5624 r0 *1 132.94,155.04
X$5624 94 1737 1895 1828 1995 77 94 1979 77 sky130_fd_sc_hd__and4_1
* cell instance $5627 r0 *1 137.54,155.04
X$5627 94 1957 1996 1859 94 2022 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5630 r0 *1 144.9,155.04
X$5630 77 1997 1945 1979 1978 94 1677 94 77 sky130_fd_sc_hd__nand4_4
* cell instance $5638 r0 *1 155.02,155.04
X$5638 94 1646 2012 1677 1900 2000 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5639 r0 *1 157.78,155.04
X$5639 94 1675 2017 1783 1730 94 77 2016 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5640 r0 *1 160.54,155.04
X$5640 94 1714 1783 1683 2015 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5649 m0 *1 27.6,160.48
X$5649 94 1705 2071 2046 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5652 m0 *1 29.9,160.48
X$5652 94 1890 94 77 77 sky130_fd_sc_hd__clkinv_2
* cell instance $5653 m0 *1 31.74,160.48
X$5653 77 181 1890 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $5654 m0 *1 40.94,160.48
X$5654 94 1991 2020 2047 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5655 m0 *1 42.32,160.48
X$5655 94 1876 1991 1756 2027 94 2006 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5658 m0 *1 46,160.48
X$5658 94 1991 2020 2036 2021 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5659 m0 *1 47.84,160.48
X$5659 94 1967 2028 2037 2004 77 94 2027 77 sky130_fd_sc_hd__and4_1
* cell instance $5660 m0 *1 51.06,160.48
X$5660 94 1756 1876 2027 2029 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5661 m0 *1 52.9,160.48
X$5661 94 1447 2049 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5662 m0 *1 54.28,160.48
X$5662 77 2037 1969 2004 2028 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $5666 m0 *1 58.42,160.48
X$5666 94 1953 2035 1840 94 2051 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5667 m0 *1 60.26,160.48
X$5667 94 1840 1953 2035 2038 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5668 m0 *1 62.56,160.48
X$5668 94 1446 2200 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5669 m0 *1 63.94,160.48
X$5669 94 1879 1793 1670 1927 94 2035 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5670 m0 *1 66.24,160.48
X$5670 77 181 1706 94 94 77 sky130_fd_sc_hd__clkbuf_16
* cell instance $5672 m0 *1 77.28,160.48
X$5672 94 1761 2202 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5678 m0 *1 87.4,160.48
X$5678 94 2003 2010 2026 2087 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $5679 m0 *1 89.24,160.48
X$5679 94 1975 2003 2010 2056 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5680 m0 *1 91.54,160.48
X$5680 94 2003 2010 1975 94 2057 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5683 m0 *1 95.68,160.48
X$5683 94 1613 1973 2030 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5685 m0 *1 98.44,160.48
X$5685 94 1583 2206 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5686 m0 *1 99.82,160.48
X$5686 77 2055 2030 1391 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5689 m0 *1 105.8,160.48
X$5689 94 1079 2031 2032 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5690 m0 *1 107.18,160.48
X$5690 94 1946 1975 1956 1995 94 2026 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5691 m0 *1 109.48,160.48
X$5691 94 1613 1956 2025 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5693 m0 *1 112.24,160.48
X$5693 77 1894 2213 94 94 77 sky130_fd_sc_hd__clkbuf_8
* cell instance $5696 m0 *1 129.72,160.48
X$5696 77 1895 2011 1828 1737 94 94 77 sky130_fd_sc_hd__and3_1
* cell instance $5698 m0 *1 132.94,160.48
X$5698 94 1868 1798 1768 1796 77 94 1934 77 sky130_fd_sc_hd__and4_1
* cell instance $5700 m0 *1 137.08,160.48
X$5700 94 1859 1957 1996 2013 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5702 m0 *1 139.84,160.48
X$5702 94 1275 2022 2013 77 94 2048 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5705 m0 *1 143.06,160.48
X$5705 94 2014 94 77 1675 77 sky130_fd_sc_hd__inv_1
* cell instance $5706 m0 *1 144.44,160.48
X$5706 77 1979 1978 1945 1859 94 2017 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $5707 m0 *1 149.04,160.48
X$5707 94 1748 1730 2014 1859 77 94 1997 77 sky130_fd_sc_hd__and4_1
* cell instance $5708 m0 *1 152.26,160.48
X$5708 94 1675 1730 2017 1783 2033 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5709 m0 *1 155.02,160.48
X$5709 94 1275 2016 2033 77 94 2034 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5726 r0 *1 32.2,160.48
X$5726 94 2019 2037 94 2071 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5727 r0 *1 35.42,160.48
X$5727 94 2006 2020 94 2073 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5728 r0 *1 38.64,160.48
X$5728 94 2060 2036 2074 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5734 r0 *1 45.54,160.48
X$5734 94 2004 1951 1980 2061 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5735 r0 *1 47.84,160.48
X$5735 77 1967 2028 2037 2004 94 1963 94 77 sky130_fd_sc_hd__nand4_2
* cell instance $5736 r0 *1 52.44,160.48
X$5736 94 2028 2062 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5738 r0 *1 54.28,160.48
X$5738 94 2037 2050 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5739 r0 *1 55.66,160.48
X$5739 94 1364 2051 2038 77 94 2076 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5740 r0 *1 67.16,160.48
X$5740 94 1556 2079 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5741 r0 *1 68.54,160.48
X$5741 94 1953 2064 1774 94 2082 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5744 r0 *1 70.84,160.48
X$5744 94 1670 1953 1985 2001 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5745 r0 *1 73.14,160.48
X$5745 94 1886 2084 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5746 r0 *1 74.52,160.48
X$5746 94 1079 2039 2109 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5747 r0 *1 75.9,160.48
X$5747 94 1774 2085 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5751 r0 *1 80.5,160.48
X$5751 94 1710 2037 2041 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5754 r0 *1 83.26,160.48
X$5754 94 1710 1991 2058 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5757 r0 *1 86.02,160.48
X$5757 94 1079 2040 2086 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5758 r0 *1 87.4,160.48
X$5758 94 2087 1973 2040 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5759 r0 *1 90.62,160.48
X$5759 94 1334 2057 2056 77 94 2088 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5763 r0 *1 95.68,160.48
X$5763 94 2058 832 1669 2055 77 94 2090 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5766 r0 *1 98.44,160.48
X$5766 94 2041 675 1669 2043 77 94 2042 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5767 r0 *1 100.74,160.48
X$5767 94 1667 2054 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5769 r0 *1 102.58,160.48
X$5769 77 2043 2025 1585 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5770 r0 *1 106.26,160.48
X$5770 94 1423 2089 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5772 r0 *1 117.76,160.48
X$5772 94 2024 1946 94 2031 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5773 r0 *1 120.98,160.48
X$5773 94 1696 2083 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5774 r0 *1 122.36,160.48
X$5774 94 1848 2053 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5776 r0 *1 123.74,160.48
X$5776 94 1872 2081 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5779 r0 *1 126.04,160.48
X$5779 94 1845 2080 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5781 r0 *1 129.26,160.48
X$5781 94 1957 2068 1768 94 2077 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5782 r0 *1 131.1,160.48
X$5782 94 1796 2011 2068 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5784 r0 *1 133.4,160.48
X$5784 94 1798 1796 1768 2011 94 2102 77 77 sky130_fd_sc_hd__nand4_1
* cell instance $5785 r0 *1 135.7,160.48
X$5785 94 1693 2011 1934 1996 94 77 77 sky130_fd_sc_hd__nand3_1
* cell instance $5787 r0 *1 148.12,160.48
X$5787 94 2017 1678 2014 94 2127 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5788 r0 *1 149.96,160.48
X$5788 94 2017 1678 2044 1748 94 77 2072 77 sky130_fd_sc_hd__o31ai_1
* cell instance $5792 r0 *1 153.64,160.48
X$5792 94 1748 2017 1678 2044 2107 94 77 77 sky130_fd_sc_hd__or4_1
* cell instance $5793 r0 *1 156.4,160.48
X$5793 94 2012 94 77 1783 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $5794 r0 *1 158.24,160.48
X$5794 94 1783 1683 1714 94 2045 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5795 r0 *1 160.08,160.48
X$5795 94 1275 2045 2015 77 94 1999 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5818 m0 *1 26.22,165.92
X$5818 94 1705 2091 2106 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5819 m0 *1 27.6,165.92
X$5819 94 1705 2073 2124 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5821 m0 *1 29.44,165.92
X$5821 94 2059 2028 2091 94 77 77 sky130_fd_sc_hd__xnor2_1
* cell instance $5823 m0 *1 33.12,165.92
X$5823 94 2004 2037 2092 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5824 m0 *1 34.5,165.92
X$5824 94 1951 1980 2092 2059 77 94 77 sky130_fd_sc_hd__nor3_1
* cell instance $5825 m0 *1 36.34,165.92
X$5825 94 2047 1980 1951 1963 77 2060 94 77 sky130_fd_sc_hd__nor4_1
* cell instance $5826 m0 *1 48.3,165.92
X$5826 94 1951 1980 2004 94 2126 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5828 m0 *1 50.6,165.92
X$5828 77 2020 2036 1968 1991 1912 94 94 77 sky130_fd_sc_hd__and4_2
* cell instance $5829 m0 *1 54.28,165.92
X$5829 94 1913 2029 2063 2093 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5831 m0 *1 57.04,165.92
X$5831 94 2029 2063 1913 94 2108 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5832 m0 *1 58.88,165.92
X$5832 94 1364 2108 2093 77 94 2114 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5833 m0 *1 60.72,165.92
X$5833 94 1886 1968 2063 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5834 m0 *1 62.1,165.92
X$5834 94 1953 1886 94 2039 77 77 sky130_fd_sc_hd__xor2_1
* cell instance $5835 m0 *1 65.32,165.92
X$5835 94 1793 2128 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5836 m0 *1 66.7,165.92
X$5836 94 1886 1913 2064 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5837 m0 *1 68.08,165.92
X$5837 94 1774 1953 2064 2115 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5838 m0 *1 80.04,165.92
X$5838 94 1766 2110 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5839 m0 *1 81.42,165.92
X$5839 94 1710 2036 2111 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5840 m0 *1 82.8,165.92
X$5840 94 1794 2129 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5842 m0 *1 94.3,165.92
X$5842 94 2094 2131 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5844 m0 *1 97.52,165.92
X$5844 94 2095 746 1669 2133 77 94 2094 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5846 m0 *1 100.28,165.92
X$5846 94 2042 2207 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5848 m0 *1 102.12,165.92
X$5848 94 1613 1975 2134 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5851 m0 *1 105.8,165.92
X$5851 77 2096 2052 1423 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5852 m0 *1 109.48,165.92
X$5852 94 2065 830 1669 2099 77 94 2098 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5854 m0 *1 112.24,165.92
X$5854 94 2098 2097 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5855 m0 *1 113.62,165.92
X$5855 94 1391 2067 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5856 m0 *1 115,165.92
X$5856 94 2112 2137 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5857 m0 *1 116.38,165.92
X$5857 94 1850 2066 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5858 m0 *1 117.76,165.92
X$5858 94 1613 1946 2052 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $5859 m0 *1 120.06,165.92
X$5859 94 1946 2100 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5861 m0 *1 122.36,165.92
X$5861 94 1737 1957 2101 2130 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5862 m0 *1 124.66,165.92
X$5862 94 1828 1895 2101 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5864 m0 *1 126.96,165.92
X$5864 94 1768 2212 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5866 m0 *1 128.8,165.92
X$5866 94 1334 2077 2069 77 94 2078 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5867 m0 *1 130.64,165.92
X$5867 94 1768 1957 2068 2069 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5870 m0 *1 134.32,165.92
X$5870 94 1957 2102 1868 94 2103 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5871 m0 *1 136.16,165.92
X$5871 94 1868 1957 2102 2104 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5874 m0 *1 139.84,165.92
X$5874 94 1275 2103 2104 77 94 2070 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5875 m0 *1 141.68,165.92
X$5875 94 1868 2075 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5878 m0 *1 153.64,165.92
X$5878 94 1275 2072 2107 77 94 2105 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5880 m0 *1 156.4,165.92
X$5880 94 2014 1730 2044 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5901 r0 *1 39.56,165.92
X$5901 94 1705 2074 2125 77 94 77 sky130_fd_sc_hd__nor2_1
* cell instance $5906 r0 *1 54.28,165.92
X$5906 94 1445 2154 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5908 r0 *1 56.58,165.92
X$5908 94 1912 2159 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5909 r0 *1 67.16,165.92
X$5909 94 1710 2004 2095 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5910 r0 *1 68.54,165.92
X$5910 94 1364 2082 2115 77 94 2162 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5913 r0 *1 80.04,165.92
X$5913 94 1710 2020 2143 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5914 r0 *1 81.42,165.92
X$5914 94 1710 2028 2118 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5915 r0 *1 82.8,165.92
X$5915 94 1668 2165 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5916 r0 *1 93.84,165.92
X$5916 94 2111 924 1669 2117 77 94 2116 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5918 r0 *1 96.14,165.92
X$5918 94 2132 94 77 1739 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $5920 r0 *1 98.44,165.92
X$5920 77 2133 2134 1584 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5922 r0 *1 102.58,165.92
X$5922 77 2135 2136 1320 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5923 r0 *1 106.26,165.92
X$5923 94 2118 676 1669 2096 77 94 2112 77 sky130_fd_sc_hd__a31oi_1
* cell instance $5924 r0 *1 108.56,165.92
X$5924 77 2117 2119 1411 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5926 r0 *1 112.7,165.92
X$5926 77 2099 2120 1422 1713 94 94 77 sky130_fd_sc_hd__mux2i_1
* cell instance $5929 r0 *1 126.04,165.92
X$5929 94 2121 1745 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5930 r0 *1 127.42,165.92
X$5930 94 1957 2101 1737 94 2157 77 77 sky130_fd_sc_hd__o21ai_0
* cell instance $5931 r0 *1 148.12,165.92
X$5931 94 2014 2017 1678 2123 94 77 77 sky130_fd_sc_hd__or3_1
* cell instance $5933 r0 *1 150.42,165.92
X$5933 94 1275 2127 2123 77 94 2150 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5967 m0 *1 32.66,171.36
X$5967 94 2175 94 2174 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $5968 m0 *1 36.34,171.36
X$5968 94 2174 94 77 1904 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $5970 m0 *1 40.02,171.36
X$5970 94 1755 2176 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5971 m0 *1 41.4,171.36
X$5971 94 2004 2177 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5974 m0 *1 44.16,171.36
X$5974 94 2020 2178 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5975 m0 *1 45.54,171.36
X$5975 94 1364 2126 2061 77 94 2151 77 sky130_fd_sc_hd__a21oi_1
* cell instance $5977 m0 *1 48.3,171.36
X$5977 94 1967 2201 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5978 m0 *1 49.68,171.36
X$5978 94 1602 2138 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5979 m0 *1 51.06,171.36
X$5979 94 1792 2153 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5980 m0 *1 52.44,171.36
X$5980 94 1807 2167 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5981 m0 *1 53.82,171.36
X$5981 94 2036 2168 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5982 m0 *1 55.2,171.36
X$5982 94 1603 2139 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5985 m0 *1 57.96,171.36
X$5985 94 1840 2181 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5986 m0 *1 59.34,171.36
X$5986 94 1913 2140 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5987 m0 *1 60.72,171.36
X$5987 94 1879 2182 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5988 m0 *1 62.1,171.36
X$5988 94 1873 2183 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5989 m0 *1 63.48,171.36
X$5989 94 1710 1967 2065 94 77 77 sky130_fd_sc_hd__nand2_1
* cell instance $5990 m0 *1 64.86,171.36
X$5990 94 1670 2141 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5991 m0 *1 66.24,171.36
X$5991 94 1557 2160 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5992 m0 *1 67.62,171.36
X$5992 94 1606 2169 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5993 m0 *1 69,171.36
X$5993 94 1608 2163 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5995 m0 *1 70.84,171.36
X$5995 94 1665 2170 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5996 m0 *1 72.22,171.36
X$5996 94 1516 2203 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5997 m0 *1 73.6,171.36
X$5997 94 1184 2187 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5998 m0 *1 74.98,171.36
X$5998 94 1991 2142 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $5999 m0 *1 76.36,171.36
X$5999 94 1632 2164 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6000 m0 *1 77.74,171.36
X$6000 94 1975 2188 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6001 m0 *1 79.12,171.36
X$6001 94 1473 2191 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6002 m0 *1 80.5,171.36
X$6002 94 2204 94 2190 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $6004 m0 *1 84.64,171.36
X$6004 77 1882 2190 94 94 77 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $6005 m0 *1 89.24,171.36
X$6005 94 2192 94 2193 77 77 sky130_fd_sc_hd__dlygate4sd3_1
* cell instance $6007 m0 *1 93.38,171.36
X$6007 94 2143 926 1669 2135 77 94 2144 77 sky130_fd_sc_hd__a31oi_1
* cell instance $6008 m0 *1 95.68,171.36
X$6008 94 2193 94 77 1318 77 sky130_fd_sc_hd__clkbuf_2
* cell instance $6011 m0 *1 98.44,171.36
X$6011 94 1448 2166 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6012 m0 *1 99.82,171.36
X$6012 94 2144 2194 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6013 m0 *1 101.2,171.36
X$6013 94 2090 2195 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6014 m0 *1 102.58,171.36
X$6014 94 2116 2205 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6015 m0 *1 103.96,171.36
X$6015 94 1739 1954 2136 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $6016 m0 *1 106.26,171.36
X$6016 94 1973 2171 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6017 m0 *1 107.64,171.36
X$6017 94 1954 2196 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6019 m0 *1 109.48,171.36
X$6019 94 1739 1990 2119 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $6021 m0 *1 112.24,171.36
X$6021 94 1584 2161 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6022 m0 *1 113.62,171.36
X$6022 94 1770 2197 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6023 m0 *1 115,171.36
X$6023 94 1585 2208 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6024 m0 *1 116.38,171.36
X$6024 94 1990 2113 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6025 m0 *1 117.76,171.36
X$6025 94 1885 2199 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6026 m0 *1 119.14,171.36
X$6026 94 1851 2198 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6028 m0 *1 120.98,171.36
X$6028 94 1613 1995 2120 77 94 77 sky130_fd_sc_hd__nand2b_1
* cell instance $6029 m0 *1 123.28,171.36
X$6029 94 1334 2157 2130 77 94 2158 77 sky130_fd_sc_hd__a21oi_1
* cell instance $6032 m0 *1 126.04,171.36
X$6032 94 1956 2156 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6033 m0 *1 127.42,171.36
X$6033 94 1320 2209 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6034 m0 *1 128.8,171.36
X$6034 94 1931 2146 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6035 m0 *1 130.18,171.36
X$6035 94 1422 2145 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6036 m0 *1 131.56,171.36
X$6036 94 1694 2155 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6037 m0 *1 132.94,171.36
X$6037 94 1920 2189 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6038 m0 *1 134.32,171.36
X$6038 94 1849 2210 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6039 m0 *1 135.7,171.36
X$6039 94 1869 2173 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6040 m0 *1 137.08,171.36
X$6040 94 1828 2186 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6043 m0 *1 139.84,171.36
X$6043 94 1995 2147 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6044 m0 *1 141.22,171.36
X$6044 94 1693 2152 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6045 m0 *1 142.6,171.36
X$6045 94 1829 2185 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6046 m0 *1 143.98,171.36
X$6046 94 1895 2172 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6047 m0 *1 145.36,171.36
X$6047 94 1411 2211 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6048 m0 *1 146.74,171.36
X$6048 94 1796 2184 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6049 m0 *1 148.12,171.36
X$6049 94 1737 2122 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6050 m0 *1 149.5,171.36
X$6050 94 1798 2148 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6051 m0 *1 150.88,171.36
X$6051 94 1859 2149 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6054 m0 *1 153.64,171.36
X$6054 94 2014 2180 77 94 77 sky130_fd_sc_hd__clkbuf_1
* cell instance $6055 m0 *1 155.02,171.36
X$6055 94 1748 2179 77 94 77 sky130_fd_sc_hd__clkbuf_1
.ENDS performance_counter

* cell sky130_fd_sc_hd__buf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_16 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=935000000000P
+ AD=810000000000P PS=8870000U PD=7620000U
* device instance $7 r0 *1 2.99,1.985 pfet_01v8_hvt
M$7 4 3 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $23 r0 *1 0.47,0.56 nfet_01v8
M$23 3 2 1 7 nfet_01v8 L=150000U W=3900000U AS=607750000000P AD=526500000000P
+ PS=6420000U PD=5520000U
* device instance $29 r0 *1 2.99,0.56 nfet_01v8
M$29 4 3 1 7 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__buf_16

* cell sky130_fd_sc_hd__a221oi_4
* pin VGND
* pin B1
* pin C1
* pin Y
* pin B2
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_4 1 2 3 4 6 7 9 11 12 14
* net 1 VGND
* net 2 B1
* net 3 C1
* net 4 Y
* net 6 B2
* net 7 A2
* net 9 A1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 2.69,1.985 pfet_01v8_hvt
M$1 10 6 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=580000000000P PS=6330000U PD=5160000U
* device instance $4 r0 *1 3.95,1.985 pfet_01v8_hvt
M$4 13 2 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $9 r0 *1 6.13,1.985 pfet_01v8_hvt
M$9 11 7 13 12 pfet_01v8_hvt L=150000U W=4000000U AS=580000000000P
+ AD=700000000000P PS=5160000U PD=6400000U
* device instance $10 r0 *1 6.55,1.985 pfet_01v8_hvt
M$10 13 9 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=540000000000P PS=5080000U PD=5080000U
* device instance $17 r0 *1 0.49,1.985 pfet_01v8_hvt
M$17 4 3 10 12 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=665000000000P PS=6370000U PD=6330000U
* device instance $21 r0 *1 0.49,0.56 nfet_01v8
M$21 4 3 1 14 nfet_01v8 L=150000U W=2600000U AS=445250000000P AD=357500000000P
+ PS=4620000U PD=3700000U
* device instance $25 r0 *1 2.19,0.56 nfet_01v8
M$25 5 6 1 14 nfet_01v8 L=150000U W=2600000U AS=357500000000P AD=539500000000P
+ PS=3700000U PD=4260000U
* device instance $28 r0 *1 3.95,0.56 nfet_01v8
M$28 4 2 5 14 nfet_01v8 L=150000U W=2600000U AS=513500000000P AD=351000000000P
+ PS=4180000U PD=3680000U
* device instance $33 r0 *1 6.13,0.56 nfet_01v8
M$33 8 7 1 14 nfet_01v8 L=150000U W=2600000U AS=377000000000P AD=432250000000P
+ PS=3760000U PD=4580000U
* device instance $34 r0 *1 6.55,0.56 nfet_01v8
M$34 4 9 8 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
.ENDS sky130_fd_sc_hd__a221oi_4

* cell sky130_fd_sc_hd__a221oi_2
* pin VGND
* pin C1
* pin Y
* pin B2
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221oi_2 1 2 3 4 6 7 9 10 11 14
* net 1 VGND
* net 2 C1
* net 3 Y
* net 4 B2
* net 6 B1
* net 7 A2
* net 9 A1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.84,1.985 pfet_01v8_hvt
M$1 12 4 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=310000000000P PS=3790000U PD=2620000U
* device instance $2 r0 *1 2.26,1.985 pfet_01v8_hvt
M$2 13 6 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 3.6,1.985 pfet_01v8_hvt
M$5 10 7 13 11 pfet_01v8_hvt L=150000U W=2000000U AS=310000000000P
+ AD=420000000000P PS=2620000U PD=3840000U
* device instance $6 r0 *1 4.02,1.985 pfet_01v8_hvt
M$6 13 9 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 0.48,1.985 pfet_01v8_hvt
M$9 3 2 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=395000000000P PS=3810000U PD=3790000U
* device instance $11 r0 *1 0.48,0.56 nfet_01v8
M$11 3 2 1 14 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=344500000000P
+ PS=2760000U PD=2360000U
* device instance $13 r0 *1 1.84,0.56 nfet_01v8
M$13 5 4 1 14 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=201500000000P
+ PS=2360000U PD=1920000U
* device instance $14 r0 *1 2.26,0.56 nfet_01v8
M$14 3 6 5 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 3.6,0.56 nfet_01v8
M$17 8 7 1 14 nfet_01v8 L=150000U W=1300000U AS=201500000000P AD=256750000000P
+ PS=1920000U PD=2740000U
* device instance $18 r0 *1 4.02,0.56 nfet_01v8
M$18 3 9 8 14 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
.ENDS sky130_fd_sc_hd__a221oi_2

* cell sky130_fd_sc_hd__bufinv_16
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__bufinv_16 1 5 6 7 8
* net 1 VGND
* net 4 Y
* net 5 A
* net 6 VPWR
* net 7 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 6 5 2 7 pfet_01v8_hvt L=150000U W=3000000U AS=530000000000P
+ AD=405000000000P PS=5060000U PD=3810000U
* device instance $4 r0 *1 1.73,1.985 pfet_01v8_hvt
M$4 3 2 6 7 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=810000000000P PS=7620000U PD=7620000U
* device instance $10 r0 *1 4.25,1.985 pfet_01v8_hvt
M$10 4 3 6 7 pfet_01v8_hvt L=150000U W=16000000U AS=2.16e+12P AD=2.285e+12P
+ PS=20320000U PD=21570000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 5 2 8 nfet_01v8 L=150000U W=1950000U AS=344500000000P AD=263250000000P
+ PS=3660000U PD=2760000U
* device instance $29 r0 *1 1.73,0.56 nfet_01v8
M$29 3 2 1 8 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=526500000000P
+ PS=5520000U PD=5520000U
* device instance $35 r0 *1 4.25,0.56 nfet_01v8
M$35 4 3 1 8 nfet_01v8 L=150000U W=10400000U AS=1.404e+12P AD=1.48525e+12P
+ PS=14720000U PD=15620000U
.ENDS sky130_fd_sc_hd__bufinv_16

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__or4_2
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or4_2 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 D
* net 3 C
* net 4 B
* net 5 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 3 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 4 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 5 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 9 6 8 1 pfet_01v8_hvt L=150000U W=2000000U AS=283250000000P
+ AD=440000000000P PS=2610000U PD=3880000U
* device instance $7 r0 *1 0.47,0.475 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $8 r0 *1 0.95,0.475 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $9 r0 *1 1.37,0.475 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 1.79,0.475 nfet_01v8
M$10 6 5 7 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 2.28,0.56 nfet_01v8
M$11 9 6 7 10 nfet_01v8 L=150000U W=1300000U AS=189625000000P AD=286000000000P
+ PS=1910000U PD=2830000U
.ENDS sky130_fd_sc_hd__or4_2

* cell sky130_fd_sc_hd__or4b_2
* pin VPB
* pin A
* pin C
* pin B
* pin D_N
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__or4b_2 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 A
* net 3 C
* net 4 B
* net 5 D_N
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 8 5 10 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=169300000000P PS=1360000U PD=1500000U
* device instance $2 r0 *1 1.86,1.695 pfet_01v8_hvt
M$2 14 2 8 1 pfet_01v8_hvt L=150000U W=420000U AS=168350000000P AD=69300000000P
+ PS=1495000U PD=750000U
* device instance $3 r0 *1 2.34,1.695 pfet_01v8_hvt
M$3 13 4 14 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $4 r0 *1 2.7,1.695 pfet_01v8_hvt
M$4 12 3 13 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $5 r0 *1 3.18,1.695 pfet_01v8_hvt
M$5 6 10 12 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=109200000000P PS=750000U PD=1360000U
* device instance $6 r0 *1 0.955,1.985 pfet_01v8_hvt
M$6 9 6 8 1 pfet_01v8_hvt L=150000U W=2000000U AS=304300000000P
+ AD=303350000000P PS=2770000U PD=2765000U
* device instance $8 r0 *1 0.47,0.475 nfet_01v8
M$8 10 5 7 11 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $9 r0 *1 1.86,0.475 nfet_01v8
M$9 6 2 7 11 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=69300000000P
+ PS=985000U PD=750000U
* device instance $10 r0 *1 2.34,0.475 nfet_01v8
M$10 7 4 6 11 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $11 r0 *1 2.76,0.475 nfet_01v8
M$11 6 3 7 11 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $12 r0 *1 3.18,0.475 nfet_01v8
M$12 7 10 6 11 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $13 r0 *1 0.955,0.56 nfet_01v8
M$13 9 6 7 11 nfet_01v8 L=150000U W=1300000U AS=188000000000P AD=188000000000P
+ PS=1905000U PD=1905000U
.ENDS sky130_fd_sc_hd__or4b_2

* cell sky130_fd_sc_hd__and4b_2
* pin VGND
* pin B
* pin C
* pin X
* pin A_N
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4b_2 1 4 5 6 7 8 12 13 14
* net 1 VGND
* net 4 B
* net 5 C
* net 6 X
* net 7 A_N
* net 8 D
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 12 7 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,2.275 pfet_01v8_hvt
M$2 3 2 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=98700000000P
+ PS=690000U PD=890000U
* device instance $3 r0 *1 1.51,2.275 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=420000U AS=98700000000P
+ AD=128100000000P PS=890000U PD=1030000U
* device instance $4 r0 *1 2.27,2.275 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=420000U AS=128100000000P
+ AD=66150000000P PS=1030000U PD=735000U
* device instance $5 r0 *1 2.735,2.275 pfet_01v8_hvt
M$5 3 8 12 13 pfet_01v8_hvt L=150000U W=420000U AS=143250000000P
+ AD=66150000000P PS=1330000U PD=735000U
* device instance $6 r0 *1 3.215,1.985 pfet_01v8_hvt
M$6 6 3 12 13 pfet_01v8_hvt L=150000U W=2000000U AS=295750000000P
+ AD=412500000000P PS=2635000U PD=3825000U
* device instance $8 r0 *1 1.41,0.445 nfet_01v8
M$8 10 2 3 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 1.77,0.445 nfet_01v8
M$9 11 4 10 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $10 r0 *1 2.27,0.445 nfet_01v8
M$10 9 5 11 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=61950000000P
+ PS=770000U PD=715000U
* device instance $11 r0 *1 2.715,0.445 nfet_01v8
M$11 1 8 9 14 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=103975000000P
+ PS=715000U PD=1000000U
* device instance $12 r0 *1 3.215,0.56 nfet_01v8
M$12 6 3 1 14 nfet_01v8 L=150000U W=1300000U AS=203100000000P AD=268125000000P
+ PS=1955000U PD=2775000U
* device instance $14 r0 *1 0.47,0.445 nfet_01v8
M$14 2 7 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4b_2

* cell sky130_fd_sc_hd__nand4b_2
* pin VGND
* pin Y
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_2 1 4 7 8 9 10 11 12 13
* net 1 VGND
* net 4 Y
* net 7 A_N
* net 8 B
* net 9 C
* net 10 D
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 4 2 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 2.25,1.985 pfet_01v8_hvt
M$3 4 8 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=505000000000P PS=2540000U PD=3010000U
* device instance $5 r0 *1 3.56,1.985 pfet_01v8_hvt
M$5 4 9 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=505000000000P
+ AD=315000000000P PS=3010000U PD=2630000U
* device instance $7 r0 *1 4.49,1.985 pfet_01v8_hvt
M$7 4 10 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=315000000000P
+ AD=535000000000P PS=2630000U PD=4070000U
* device instance $9 r0 *1 0.47,2.275 pfet_01v8_hvt
M$9 11 7 2 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=109200000000P PS=1360000U PD=1360000U
* device instance $10 r0 *1 3.61,0.56 nfet_01v8
M$10 5 9 6 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=204750000000P
+ PS=2740000U PD=1930000U
* device instance $12 r0 *1 4.54,0.56 nfet_01v8
M$12 1 10 6 13 nfet_01v8 L=150000U W=1300000U AS=204750000000P AD=256750000000P
+ PS=1930000U PD=2740000U
* device instance $14 r0 *1 1.41,0.56 nfet_01v8
M$14 4 2 3 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $16 r0 *1 2.25,0.56 nfet_01v8
M$16 5 8 3 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
* device instance $18 r0 *1 0.47,0.445 nfet_01v8
M$18 1 7 2 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__nand4b_2

* cell sky130_fd_sc_hd__inv_8
* pin VGND
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__inv_8 1 2 4 5 6
* net 1 VGND
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VPB
* device instance $1 r0 *1 0.635,1.985 pfet_01v8_hvt
M$1 3 2 4 5 pfet_01v8_hvt L=150000U W=8000000U AS=1.205e+12P AD=1.205e+12P
+ PS=11410000U PD=11410000U
* device instance $9 r0 *1 0.635,0.56 nfet_01v8
M$9 3 2 1 6 nfet_01v8 L=150000U W=5200000U AS=783250000000P AD=783250000000P
+ PS=8260000U PD=8260000U
.ENDS sky130_fd_sc_hd__inv_8

* cell sky130_fd_sc_hd__a221o_2
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_2 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=420000000000P PS=2585000U PD=3840000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $7 r0 *1 1.31,1.985 pfet_01v8_hvt
M$7 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $8 r0 *1 2.25,0.56 nfet_01v8
M$8 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $9 r0 *1 2.73,0.56 nfet_01v8
M$9 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $10 r0 *1 3.195,0.56 nfet_01v8
M$10 5 2 1 15 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=273000000000P
+ PS=1885000U PD=2790000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $13 r0 *1 0.95,0.56 nfet_01v8
M$13 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $14 r0 *1 1.31,0.56 nfet_01v8
M$14 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_2

* cell sky130_fd_sc_hd__a221o_1
* pin VGND
* pin B1
* pin A1
* pin X
* pin C1
* pin B2
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a221o_1 1 3 4 5 8 9 10 13 14 15
* net 1 VGND
* net 3 B1
* net 4 A1
* net 5 X
* net 8 C1
* net 9 B2
* net 10 A2
* net 13 VPWR
* net 14 VPB
* device instance $1 r0 *1 2.25,1.985 pfet_01v8_hvt
M$1 12 4 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=165000000000P PS=2520000U PD=1330000U
* device instance $2 r0 *1 2.73,1.985 pfet_01v8_hvt
M$2 13 10 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=157500000000P PS=1330000U PD=1315000U
* device instance $3 r0 *1 3.195,1.985 pfet_01v8_hvt
M$3 5 2 13 14 pfet_01v8_hvt L=150000U W=1000000U AS=157500000000P
+ AD=260000000000P PS=1315000U PD=2520000U
* device instance $4 r0 *1 0.47,1.985 pfet_01v8_hvt
M$4 11 8 2 14 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $5 r0 *1 0.89,1.985 pfet_01v8_hvt
M$5 12 9 11 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $6 r0 *1 1.31,1.985 pfet_01v8_hvt
M$6 11 3 12 14 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $7 r0 *1 2.25,0.56 nfet_01v8
M$7 7 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $8 r0 *1 2.73,0.56 nfet_01v8
M$8 1 10 7 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=102375000000P
+ PS=980000U PD=965000U
* device instance $9 r0 *1 3.195,0.56 nfet_01v8
M$9 5 2 1 15 nfet_01v8 L=150000U W=650000U AS=102375000000P AD=169000000000P
+ PS=965000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 1 8 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $11 r0 *1 0.95,0.56 nfet_01v8
M$11 6 9 1 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=68250000000P
+ PS=980000U PD=860000U
* device instance $12 r0 *1 1.31,0.56 nfet_01v8
M$12 2 3 6 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__a221o_1

* cell sky130_fd_sc_hd__and3b_1
* pin VPB
* pin C
* pin B
* pin A_N
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__and3b_1 1 2 3 5 7 8 9 10
* net 1 VPB
* net 2 C
* net 3 B
* net 5 A_N
* net 7 X
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 2.275,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=142225000000P
+ PS=815000U PD=1335000U
* device instance $2 r0 *1 1.38,1.765 pfet_01v8_hvt
M$2 9 4 6 1 pfet_01v8_hvt L=150000U W=420000U AS=108500000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 1.8,1.765 pfet_01v8_hvt
M$3 9 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 2.75,1.985 pfet_01v8_hvt
M$4 7 6 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,2.275 pfet_01v8_hvt
M$5 4 5 9 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=108700000000P
+ PS=1360000U PD=1360000U
* device instance $6 r0 *1 1.405,0.475 nfet_01v8
M$6 12 4 6 10 nfet_01v8 L=150000U W=420000U AS=107825000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 1.765,0.475 nfet_01v8
M$7 11 3 12 10 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 2.17,0.475 nfet_01v8
M$8 11 2 8 10 nfet_01v8 L=150000U W=420000U AS=122275000000P AD=53550000000P
+ PS=1080000U PD=675000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 7 6 8 10 nfet_01v8 L=150000U W=650000U AS=122275000000P AD=169000000000P
+ PS=1080000U PD=1820000U
* device instance $10 r0 *1 0.47,0.675 nfet_01v8
M$10 4 5 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=107850000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and3b_1

* cell sky130_fd_sc_hd__clkinv_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__clkinv_2 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 4 2 3 1 pfet_01v8_hvt L=150000U W=3000000U AS=545000000000P
+ AD=545000000000P PS=5090000U PD=5090000U
* device instance $4 r0 *1 0.94,0.445 nfet_01v8
M$4 3 2 5 6 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=168000000000P
+ PS=2070000U PD=2060000U
.ENDS sky130_fd_sc_hd__clkinv_2

* cell sky130_fd_sc_hd__nand4b_4
* pin VGND
* pin D
* pin Y
* pin A_N
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_4 1 2 5 8 9 10 11 12 13
* net 1 VGND
* net 2 D
* net 5 Y
* net 8 A_N
* net 9 B
* net 10 C
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 1.41,1.985 pfet_01v8_hvt
M$1 5 3 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 3.09,1.985 pfet_01v8_hvt
M$5 5 9 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 5.29,1.985 pfet_01v8_hvt
M$9 5 10 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=540000000000P PS=5600000U PD=5080000U
* device instance $13 r0 *1 6.97,1.985 pfet_01v8_hvt
M$13 5 2 11 12 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $17 r0 *1 0.47,1.985 pfet_01v8_hvt
M$17 11 8 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $18 r0 *1 5.29,0.56 nfet_01v8
M$18 6 10 7 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $22 r0 *1 6.97,0.56 nfet_01v8
M$22 1 2 7 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $26 r0 *1 0.47,0.56 nfet_01v8
M$26 1 8 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $27 r0 *1 1.41,0.56 nfet_01v8
M$27 5 3 4 13 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $31 r0 *1 3.09,0.56 nfet_01v8
M$31 6 9 4 13 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4b_4

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__or4b_1
* pin VGND
* pin D_N
* pin X
* pin C
* pin A
* pin VPWR
* pin VPB
* pin B
* pin
.SUBCKT sky130_fd_sc_hd__or4b_1 1 2 5 6 7 8 9 10 14
* net 1 VGND
* net 2 D_N
* net 5 X
* net 6 C
* net 7 A
* net 8 VPWR
* net 9 VPB
* net 10 B
* device instance $1 r0 *1 1.41,1.695 pfet_01v8_hvt
M$1 11 3 4 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=68250000000P
+ PS=1360000U PD=745000U
* device instance $2 r0 *1 1.885,1.695 pfet_01v8_hvt
M$2 13 6 11 9 pfet_01v8_hvt L=150000U W=420000U AS=68250000000P AD=45150000000P
+ PS=745000U PD=635000U
* device instance $3 r0 *1 2.25,1.695 pfet_01v8_hvt
M$3 12 10 13 9 pfet_01v8_hvt L=150000U W=420000U AS=45150000000P
+ AD=64050000000P PS=635000U PD=725000U
* device instance $4 r0 *1 2.705,1.695 pfet_01v8_hvt
M$4 8 7 12 9 pfet_01v8_hvt L=150000U W=420000U AS=64050000000P AD=148250000000P
+ PS=725000U PD=1340000U
* device instance $5 r0 *1 3.195,1.985 pfet_01v8_hvt
M$5 5 4 8 9 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=275000000000P PS=1340000U PD=2550000U
* device instance $6 r0 *1 0.47,1.695 pfet_01v8_hvt
M$6 3 2 8 9 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
* device instance $7 r0 *1 1.41,0.475 nfet_01v8
M$7 4 3 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=64050000000P
+ PS=1360000U PD=725000U
* device instance $8 r0 *1 1.865,0.475 nfet_01v8
M$8 1 6 4 14 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=56700000000P
+ PS=725000U PD=690000U
* device instance $9 r0 *1 2.285,0.475 nfet_01v8
M$9 4 10 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $10 r0 *1 2.705,0.475 nfet_01v8
M$10 4 7 1 14 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $11 r0 *1 3.195,0.56 nfet_01v8
M$11 5 4 1 14 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=178750000000P
+ PS=990000U PD=1850000U
* device instance $12 r0 *1 0.47,0.475 nfet_01v8
M$12 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__or4b_1

* cell sky130_fd_sc_hd__nand3b_4
* pin VGND
* pin B
* pin A_N
* pin Y
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_4 1 2 4 6 8 9 10 11
* net 1 VGND
* net 2 B
* net 4 A_N
* net 6 Y
* net 8 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 5.29,1.985 pfet_01v8_hvt
M$1 6 8 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=765000000000P PS=6330000U PD=6530000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 4 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $6 r0 *1 1.41,1.985 pfet_01v8_hvt
M$6 6 3 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $10 r0 *1 3.09,1.985 pfet_01v8_hvt
M$10 6 2 9 10 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $14 r0 *1 5.29,0.56 nfet_01v8
M$14 7 8 1 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=497250000000P
+ PS=4580000U PD=4780000U
* device instance $18 r0 *1 0.47,0.56 nfet_01v8
M$18 1 4 3 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $19 r0 *1 1.41,0.56 nfet_01v8
M$19 6 3 5 11 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $23 r0 *1 3.09,0.56 nfet_01v8
M$23 7 2 5 11 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand3b_4

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__or4_4
* pin VGND
* pin D
* pin X
* pin C
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__or4_4 1 2 4 5 6 7 8 9 13
* net 1 VGND
* net 2 D
* net 4 X
* net 5 C
* net 6 B
* net 7 A
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 0.495,1.985 pfet_01v8_hvt
M$1 10 2 3 9 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=190000000000P PS=2520000U PD=1380000U
* device instance $2 r0 *1 1.025,1.985 pfet_01v8_hvt
M$2 12 5 10 9 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $3 r0 *1 1.445,1.985 pfet_01v8_hvt
M$3 11 6 12 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.865,1.985 pfet_01v8_hvt
M$4 8 7 11 9 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=190000000000P PS=1270000U PD=1380000U
* device instance $5 r0 *1 2.395,1.985 pfet_01v8_hvt
M$5 4 3 8 9 pfet_01v8_hvt L=150000U W=4000000U AS=595000000000P
+ AD=675000000000P PS=5190000U PD=6350000U
* device instance $9 r0 *1 0.495,0.56 nfet_01v8
M$9 3 2 1 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=123500000000P
+ PS=1820000U PD=1030000U
* device instance $10 r0 *1 1.025,0.56 nfet_01v8
M$10 1 5 3 13 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=87750000000P
+ PS=1030000U PD=920000U
* device instance $11 r0 *1 1.445,0.56 nfet_01v8
M$11 3 6 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $12 r0 *1 1.865,0.56 nfet_01v8
M$12 1 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $13 r0 *1 2.395,0.56 nfet_01v8
M$13 4 3 1 13 nfet_01v8 L=150000U W=2600000U AS=386750000000P AD=442000000000P
+ PS=3790000U PD=4610000U
.ENDS sky130_fd_sc_hd__or4_4

* cell sky130_fd_sc_hd__or2_1
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 5 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.695 pfet_01v8_hvt
M$1 9 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.695 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=145750000000P
+ PS=630000U PD=1335000U
* device instance $3 r0 *1 1.52,1.985 pfet_01v8_hvt
M$3 4 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=340000000000P PS=1335000U PD=2680000U
* device instance $4 r0 *1 0.615,0.445 nfet_01v8
M$4 6 2 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.445 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=100250000000P
+ PS=690000U PD=985000U
* device instance $6 r0 *1 1.52,0.56 nfet_01v8
M$6 4 6 5 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=169000000000P
+ PS=985000U PD=1820000U
.ENDS sky130_fd_sc_hd__or2_1

* cell sky130_fd_sc_hd__dlygate4sd3_1
* pin VPB
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 1 3 5 7 8 9
* net 1 VPB
* net 3 A
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.465,2.275 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=500000U W=420000U AS=140750000000P AD=109200000000P
+ PS=1325000U PD=1360000U
* device instance $2 r0 *1 3.115,1.985 pfet_01v8_hvt
M$2 7 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 0.58,2.275 pfet_01v8_hvt
M$3 5 3 4 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $4 r0 *1 1.175,2.275 pfet_01v8_hvt
M$4 2 4 5 1 pfet_01v8_hvt L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $5 r0 *1 2.465,0.445 nfet_01v8
M$5 8 2 6 9 nfet_01v8 L=500000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $6 r0 *1 3.115,0.56 nfet_01v8
M$6 7 6 8 9 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $7 r0 *1 0.58,0.445 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $8 r0 *1 1.175,0.445 nfet_01v8
M$8 2 4 8 9 nfet_01v8 L=500000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__dlygate4sd3_1

* cell sky130_fd_sc_hd__and2_1
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_1 1 2 3 4 5 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 X
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.65,2.065 pfet_01v8_hvt
M$1 6 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $2 r0 *1 1.07,2.065 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=166550000000P AD=56700000000P
+ PS=1390000U PD=690000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 6 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=166550000000P
+ AD=475000000000P PS=1390000U PD=2950000U
* device instance $4 r0 *1 0.65,0.585 nfet_01v8
M$4 9 2 6 8 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $5 r0 *1 1.07,0.585 nfet_01v8
M$5 9 3 7 8 nfet_01v8 L=150000U W=420000U AS=111800000000P AD=56700000000P
+ PS=1040000U PD=690000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 4 6 7 8 nfet_01v8 L=150000U W=650000U AS=111800000000P AD=182000000000P
+ PS=1040000U PD=1860000U
.ENDS sky130_fd_sc_hd__and2_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__clkbuf_8
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_8 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 1.335,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=8000000U AS=1.12e+12P AD=1.245e+12P
+ PS=10240000U PD=11490000U
* device instance $11 r0 *1 0.475,0.445 nfet_01v8
M$11 3 2 1 7 nfet_01v8 L=150000U W=840000U AS=170100000000P AD=117600000000P
+ PS=2070000U PD=1400000U
* device instance $13 r0 *1 1.335,0.445 nfet_01v8
M$13 4 3 1 7 nfet_01v8 L=150000U W=3360000U AS=470400000000P AD=525000000000P
+ PS=5600000U PD=6280000U
.ENDS sky130_fd_sc_hd__clkbuf_8

* cell sky130_fd_sc_hd__and4_2
* pin VGND
* pin B
* pin C
* pin X
* pin A
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4_2 1 3 4 5 6 7 11 12 13
* net 1 VGND
* net 3 B
* net 4 C
* net 5 X
* net 6 A
* net 7 D
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 11 12 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=74550000000P PS=1360000U PD=775000U
* device instance $2 r0 *1 0.975,2.275 pfet_01v8_hvt
M$2 11 3 2 12 pfet_01v8_hvt L=150000U W=420000U AS=74550000000P AD=77700000000P
+ PS=775000U PD=790000U
* device instance $3 r0 *1 1.495,2.275 pfet_01v8_hvt
M$3 2 4 11 12 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.925,2.275 pfet_01v8_hvt
M$4 2 7 11 12 pfet_01v8_hvt L=150000U W=420000U AS=279950000000P
+ AD=58800000000P PS=1615000U PD=700000U
* device instance $5 r0 *1 2.69,1.985 pfet_01v8_hvt
M$5 5 2 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=444950000000P
+ AD=465000000000P PS=2945000U PD=3930000U
* device instance $7 r0 *1 0.47,0.445 nfet_01v8
M$7 8 6 2 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=61950000000P
+ PS=1360000U PD=715000U
* device instance $8 r0 *1 0.915,0.445 nfet_01v8
M$8 9 3 8 13 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=79800000000P
+ PS=715000U PD=800000U
* device instance $9 r0 *1 1.445,0.445 nfet_01v8
M$9 10 4 9 13 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $10 r0 *1 1.925,0.445 nfet_01v8
M$10 1 7 10 13 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=175150000000P
+ PS=750000U PD=1265000U
* device instance $11 r0 *1 2.69,0.56 nfet_01v8
M$11 5 2 1 13 nfet_01v8 L=150000U W=1300000U AS=282400000000P AD=302250000000P
+ PS=2245000U PD=2880000U
.ENDS sky130_fd_sc_hd__and4_2

* cell sky130_fd_sc_hd__and3_2
* pin VPB
* pin A
* pin B
* pin C
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and3_2 1 2 3 4 6 7 8 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 1.375,1.695 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=150750000000P
+ PS=815000U PD=1345000U
* device instance $2 r0 *1 0.48,1.765 pfet_01v8_hvt
M$2 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $3 r0 *1 0.9,1.765 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=74375000000P AD=56700000000P
+ PS=815000U PD=690000U
* device instance $4 r0 *1 1.87,1.985 pfet_01v8_hvt
M$4 8 5 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=285750000000P
+ AD=395000000000P PS=2615000U PD=3790000U
* device instance $6 r0 *1 0.485,0.475 nfet_01v8
M$6 11 2 5 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $7 r0 *1 0.845,0.475 nfet_01v8
M$7 10 3 11 9 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=53550000000P
+ PS=630000U PD=675000U
* device instance $8 r0 *1 1.25,0.475 nfet_01v8
M$8 10 4 6 9 nfet_01v8 L=150000U W=420000U AS=130400000000P AD=53550000000P
+ PS=1105000U PD=675000U
* device instance $9 r0 *1 1.855,0.56 nfet_01v8
M$9 8 5 6 9 nfet_01v8 L=150000U W=1300000U AS=218150000000P AD=266500000000P
+ PS=2025000U PD=2770000U
.ENDS sky130_fd_sc_hd__and3_2

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__buf_2
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__buf_2 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.125 pfet_01v8_hvt
M$1 2 3 6 1 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P AD=166400000000P
+ PS=1325000U PD=1800000U
* device instance $2 r0 *1 0.945,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=284000000000P
+ AD=400000000000P PS=2595000U PD=3800000U
* device instance $4 r0 *1 0.47,0.445 nfet_01v8
M$4 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $5 r0 *1 0.945,0.56 nfet_01v8
M$5 5 2 4 7 nfet_01v8 L=150000U W=1300000U AS=184750000000P AD=260000000000P
+ PS=1895000U PD=2750000U
.ENDS sky130_fd_sc_hd__buf_2

* cell sky130_fd_sc_hd__a31oi_2
* pin VGND
* pin Y
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_2 1 4 5 6 7 8 10 11 12
* net 1 VGND
* net 4 Y
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=545000000000P
+ AD=590000000000P PS=3090000U PD=3180000U
* device instance $7 r0 *1 3.63,1.985 pfet_01v8_hvt
M$7 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=355000000000P
+ AD=435000000000P PS=2710000U PD=3870000U
* device instance $9 r0 *1 2.67,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=266500000000P AD=214500000000P
+ PS=2770000U PD=1960000U
* device instance $11 r0 *1 3.63,0.56 nfet_01v8
M$11 1 8 4 12 nfet_01v8 L=150000U W=1300000U AS=230750000000P AD=282750000000P
+ PS=2010000U PD=2820000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__a31oi_2

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__nor3b_1
* pin VPB
* pin B
* pin A
* pin C_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3b_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 C_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 2.055,1.86 pfet_01v8_hvt
M$1 8 4 7 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 11 8 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=320000000000P
+ AD=135000000000P PS=2640000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 10 2 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.57,1.985 pfet_01v8_hvt
M$4 7 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $5 r0 *1 0.73,0.56 nfet_01v8
M$5 6 8 5 9 nfet_01v8 L=150000U W=650000U AS=221000000000P AD=87750000000P
+ PS=1980000U PD=920000U
* device instance $6 r0 *1 1.15,0.56 nfet_01v8
M$6 5 2 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.57,0.56 nfet_01v8
M$7 6 3 5 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $8 r0 *1 2.055,0.675 nfet_01v8
M$8 8 4 6 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor3b_1

* cell sky130_fd_sc_hd__nand3_4
* pin VGND
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_4 1 2 5 6 7 8 9 10
* net 1 VGND
* net 2 C
* net 5 B
* net 6 A
* net 7 VPWR
* net 8 Y
* net 9 VPB
* device instance $1 r0 *1 4.35,1.985 pfet_01v8_hvt
M$1 8 6 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=675000000000P PS=6330000U PD=6350000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $9 r0 *1 2.15,1.985 pfet_01v8_hvt
M$9 8 5 7 9 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 2 3 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $17 r0 *1 2.15,0.56 nfet_01v8
M$17 4 5 3 10 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 8 6 4 10 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=438750000000P
+ PS=4580000U PD=4600000U
.ENDS sky130_fd_sc_hd__nand3_4

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__buf_4
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__buf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VPWR
* net 5 VGND
* net 6 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 4 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 4 1 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $6 r0 *1 0.47,0.56 nfet_01v8
M$6 5 3 2 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.89,0.56 nfet_01v8
M$7 6 2 5 7 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__buf_4

* cell sky130_fd_sc_hd__dfrtp_1
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_1 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=1000000U AS=301200000000P
+ AD=260000000000P PS=2660000U PD=2520000U
* device instance $2 r0 *1 5.35,2.065 pfet_01v8_hvt
M$2 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $3 r0 *1 5.845,2.275 pfet_01v8_hvt
M$3 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $4 r0 *1 6.275,2.275 pfet_01v8_hvt
M$4 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $5 r0 *1 6.695,2.275 pfet_01v8_hvt
M$5 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $6 r0 *1 7.235,2.275 pfet_01v8_hvt
M$6 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $7 r0 *1 7.655,2.275 pfet_01v8_hvt
M$7 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $8 r0 *1 2.225,2.275 pfet_01v8_hvt
M$8 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $9 r0 *1 2.685,2.275 pfet_01v8_hvt
M$9 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $10 r0 *1 3.18,2.275 pfet_01v8_hvt
M$10 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $11 r0 *1 3.88,2.275 pfet_01v8_hvt
M$11 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $12 r0 *1 4.365,2.275 pfet_01v8_hvt
M$12 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $13 r0 *1 0.47,2.135 pfet_01v8_hvt
M$13 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $14 r0 *1 0.89,2.135 pfet_01v8_hvt
M$14 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $15 r0 *1 8.73,0.56 nfet_01v8
M$15 9 8 1 21 nfet_01v8 L=150000U W=650000U AS=208700000000P AD=169000000000P
+ PS=2020000U PD=1820000U
* device instance $16 r0 *1 0.47,0.445 nfet_01v8
M$16 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 0.89,0.445 nfet_01v8
M$17 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $18 r0 *1 2.64,0.415 nfet_01v8
M$18 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $19 r0 *1 3.12,0.415 nfet_01v8
M$19 12 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $20 r0 *1 5.465,0.415 nfet_01v8
M$20 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $21 r0 *1 6.01,0.415 nfet_01v8
M$21 11 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $22 r0 *1 2.165,0.445 nfet_01v8
M$22 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $23 r0 *1 3.95,0.445 nfet_01v8
M$23 13 16 12 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $24 r0 *1 4.31,0.445 nfet_01v8
M$24 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $25 r0 *1 6.49,0.445 nfet_01v8
M$25 1 8 11 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $26 r0 *1 7.235,0.445 nfet_01v8
M$26 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $27 r0 *1 7.69,0.445 nfet_01v8
M$27 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $28 r0 *1 4.97,0.555 nfet_01v8
M$28 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_1

* cell sky130_fd_sc_hd__dfrtp_2
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_2 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPWR
* net 18 VPB
* device instance $1 r0 *1 8.73,1.985 pfet_01v8_hvt
M$1 9 8 17 18 pfet_01v8_hvt L=150000U W=2000000U AS=436200000000P
+ AD=395000000000P PS=3930000U PD=3790000U
* device instance $3 r0 *1 5.35,2.065 pfet_01v8_hvt
M$3 16 5 17 18 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $4 r0 *1 5.845,2.275 pfet_01v8_hvt
M$4 7 2 16 18 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $5 r0 *1 6.275,2.275 pfet_01v8_hvt
M$5 20 3 7 18 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $6 r0 *1 6.695,2.275 pfet_01v8_hvt
M$6 17 8 20 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $7 r0 *1 7.235,2.275 pfet_01v8_hvt
M$7 8 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $8 r0 *1 7.655,2.275 pfet_01v8_hvt
M$8 17 7 8 18 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $9 r0 *1 2.225,2.275 pfet_01v8_hvt
M$9 4 15 17 18 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $10 r0 *1 2.685,2.275 pfet_01v8_hvt
M$10 5 3 4 18 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $11 r0 *1 3.18,2.275 pfet_01v8_hvt
M$11 19 2 5 18 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $12 r0 *1 3.88,2.275 pfet_01v8_hvt
M$12 17 16 19 18 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $13 r0 *1 4.365,2.275 pfet_01v8_hvt
M$13 19 6 17 18 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $14 r0 *1 0.47,2.135 pfet_01v8_hvt
M$14 17 14 2 18 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $15 r0 *1 0.89,2.135 pfet_01v8_hvt
M$15 3 2 17 18 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $16 r0 *1 8.73,0.56 nfet_01v8
M$16 9 8 1 21 nfet_01v8 L=150000U W=1300000U AS=296450000000P AD=256750000000P
+ PS=2940000U PD=2740000U
* device instance $18 r0 *1 0.47,0.445 nfet_01v8
M$18 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $19 r0 *1 0.89,0.445 nfet_01v8
M$19 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 2.64,0.415 nfet_01v8
M$20 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $21 r0 *1 3.12,0.415 nfet_01v8
M$21 11 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $22 r0 *1 5.465,0.415 nfet_01v8
M$22 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $23 r0 *1 6.01,0.415 nfet_01v8
M$23 12 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $24 r0 *1 2.165,0.445 nfet_01v8
M$24 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $25 r0 *1 3.95,0.445 nfet_01v8
M$25 13 16 11 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $26 r0 *1 4.31,0.445 nfet_01v8
M$26 1 6 13 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $27 r0 *1 6.49,0.445 nfet_01v8
M$27 1 8 12 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $28 r0 *1 7.235,0.445 nfet_01v8
M$28 10 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $29 r0 *1 7.69,0.445 nfet_01v8
M$29 8 7 10 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $30 r0 *1 4.97,0.555 nfet_01v8
M$30 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_2

* cell sky130_fd_sc_hd__dfrtp_4
* pin VGND
* pin RESET_B
* pin Q
* pin CLK
* pin D
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__dfrtp_4 1 6 9 14 15 17 18 21
* net 1 VGND
* net 6 RESET_B
* net 9 Q
* net 14 CLK
* net 15 D
* net 17 VPB
* net 18 VPWR
* device instance $1 r0 *1 8.63,1.985 pfet_01v8_hvt
M$1 9 8 18 17 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=710000000000P PS=6330000U PD=6420000U
* device instance $5 r0 *1 5.35,2.065 pfet_01v8_hvt
M$5 16 5 18 17 pfet_01v8_hvt L=150000U W=840000U AS=218400000000P
+ AD=129150000000P PS=2200000U PD=1185000U
* device instance $6 r0 *1 5.845,2.275 pfet_01v8_hvt
M$6 7 2 16 17 pfet_01v8_hvt L=150000U W=420000U AS=129150000000P
+ AD=58800000000P PS=1185000U PD=700000U
* device instance $7 r0 *1 6.275,2.275 pfet_01v8_hvt
M$7 20 3 7 17 pfet_01v8_hvt L=150000U W=420000U AS=58800000000P AD=56700000000P
+ PS=700000U PD=690000U
* device instance $8 r0 *1 6.695,2.275 pfet_01v8_hvt
M$8 18 8 20 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=81900000000P PS=690000U PD=810000U
* device instance $9 r0 *1 7.235,2.275 pfet_01v8_hvt
M$9 8 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=81900000000P AD=56700000000P
+ PS=810000U PD=690000U
* device instance $10 r0 *1 7.655,2.275 pfet_01v8_hvt
M$10 18 7 8 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=113400000000P PS=690000U PD=1380000U
* device instance $11 r0 *1 2.225,2.275 pfet_01v8_hvt
M$11 4 15 18 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=65100000000P PS=1360000U PD=730000U
* device instance $12 r0 *1 2.685,2.275 pfet_01v8_hvt
M$12 5 3 4 17 pfet_01v8_hvt L=150000U W=420000U AS=65100000000P AD=72450000000P
+ PS=730000U PD=765000U
* device instance $13 r0 *1 3.18,2.275 pfet_01v8_hvt
M$13 19 2 5 17 pfet_01v8_hvt L=150000U W=420000U AS=72450000000P
+ AD=115500000000P PS=765000U PD=970000U
* device instance $14 r0 *1 3.88,2.275 pfet_01v8_hvt
M$14 18 16 19 17 pfet_01v8_hvt L=150000U W=420000U AS=115500000000P
+ AD=70350000000P PS=970000U PD=755000U
* device instance $15 r0 *1 4.365,2.275 pfet_01v8_hvt
M$15 19 6 18 17 pfet_01v8_hvt L=150000U W=420000U AS=70350000000P
+ AD=109200000000P PS=755000U PD=1360000U
* device instance $16 r0 *1 0.47,2.135 pfet_01v8_hvt
M$16 18 14 2 17 pfet_01v8_hvt L=150000U W=640000U AS=166400000000P
+ AD=86400000000P PS=1800000U PD=910000U
* device instance $17 r0 *1 0.89,2.135 pfet_01v8_hvt
M$17 3 2 18 17 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=166400000000P PS=910000U PD=1800000U
* device instance $18 r0 *1 8.63,0.56 nfet_01v8
M$18 9 8 1 21 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=445250000000P
+ PS=4580000U PD=4620000U
* device instance $22 r0 *1 0.47,0.445 nfet_01v8
M$22 1 14 2 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $23 r0 *1 0.89,0.445 nfet_01v8
M$23 3 2 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $24 r0 *1 2.64,0.415 nfet_01v8
M$24 5 2 4 21 nfet_01v8 L=150000U W=360000U AS=66000000000P AD=59400000000P
+ PS=745000U PD=690000U
* device instance $25 r0 *1 3.12,0.415 nfet_01v8
M$25 10 3 5 21 nfet_01v8 L=150000U W=360000U AS=59400000000P AD=140100000000P
+ PS=690000U PD=1100000U
* device instance $26 r0 *1 5.465,0.415 nfet_01v8
M$26 7 3 16 21 nfet_01v8 L=150000U W=360000U AS=99900000000P AD=71100000000P
+ PS=985000U PD=755000U
* device instance $27 r0 *1 6.01,0.415 nfet_01v8
M$27 13 2 7 21 nfet_01v8 L=150000U W=360000U AS=71100000000P AD=66900000000P
+ PS=755000U PD=750000U
* device instance $28 r0 *1 2.165,0.445 nfet_01v8
M$28 4 15 1 21 nfet_01v8 L=150000U W=420000U AS=220500000000P AD=66000000000P
+ PS=1890000U PD=745000U
* device instance $29 r0 *1 3.95,0.445 nfet_01v8
M$29 11 16 10 21 nfet_01v8 L=150000U W=420000U AS=140100000000P AD=44100000000P
+ PS=1100000U PD=630000U
* device instance $30 r0 *1 4.31,0.445 nfet_01v8
M$30 1 6 11 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=134600000000P
+ PS=630000U PD=1150000U
* device instance $31 r0 *1 6.49,0.445 nfet_01v8
M$31 1 8 13 21 nfet_01v8 L=150000U W=420000U AS=66900000000P AD=124950000000P
+ PS=750000U PD=1015000U
* device instance $32 r0 *1 7.235,0.445 nfet_01v8
M$32 12 6 1 21 nfet_01v8 L=150000U W=420000U AS=124950000000P AD=64050000000P
+ PS=1015000U PD=725000U
* device instance $33 r0 *1 7.69,0.445 nfet_01v8
M$33 8 7 12 21 nfet_01v8 L=150000U W=420000U AS=64050000000P AD=109200000000P
+ PS=725000U PD=1360000U
* device instance $34 r0 *1 4.97,0.555 nfet_01v8
M$34 16 5 1 21 nfet_01v8 L=150000U W=640000U AS=134600000000P AD=99900000000P
+ PS=1150000U PD=985000U
.ENDS sky130_fd_sc_hd__dfrtp_4

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__inv_6
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__inv_6 1 2 4 5 6
* net 1 VPB
* net 2 A
* net 3 Y
* net 4 VPWR
* net 5 VGND
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 3 2 4 1 pfet_01v8_hvt L=150000U W=6000000U AS=1.105e+12P AD=945000000000P
+ PS=9210000U PD=8890000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 3 2 5 6 nfet_01v8 L=150000U W=3900000U AS=685750000000P AD=614250000000P
+ PS=6660000U PD=6440000U
.ENDS sky130_fd_sc_hd__inv_6

* cell sky130_fd_sc_hd__clkbuf_16
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_16 1 3 4 5 6 7
* net 1 VGND
* net 3 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 2 3 5 6 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=560000000000P PS=6370000U PD=5120000U
* device instance $5 r0 *1 2.195,1.985 pfet_01v8_hvt
M$5 4 2 5 6 pfet_01v8_hvt L=150000U W=16000000U AS=2.2375e+12P AD=2.3625e+12P
+ PS=20475000U PD=21725000U
* device instance $21 r0 *1 0.475,0.445 nfet_01v8
M$21 2 3 1 7 nfet_01v8 L=150000U W=1680000U AS=287700000000P AD=235200000000P
+ PS=3470000U PD=2800000U
* device instance $25 r0 *1 2.195,0.445 nfet_01v8
M$25 4 2 1 7 nfet_01v8 L=150000U W=6720000U AS=939750000000P AD=992250000000P
+ PS=11195000U PD=11865000U
.ENDS sky130_fd_sc_hd__clkbuf_16

* cell sky130_fd_sc_hd__ha_2
* pin VGND
* pin SUM
* pin COUT
* pin B
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_2 1 2 6 7 8 10 11 13
* net 1 VGND
* net 2 SUM
* net 6 COUT
* net 7 B
* net 8 A
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 2 3 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=446600000000P PS=3830000U PD=3075000U
* device instance $3 r0 *1 1.845,2.165 pfet_01v8_hvt
M$3 3 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=291600000000P
+ AD=86400000000P PS=1765000U PD=910000U
* device instance $4 r0 *1 2.265,2.165 pfet_01v8_hvt
M$4 12 7 3 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=128000000000P PS=910000U PD=1040000U
* device instance $5 r0 *1 2.815,2.165 pfet_01v8_hvt
M$5 10 8 12 11 pfet_01v8_hvt L=150000U W=640000U AS=128000000000P
+ AD=227200000000P PS=1040000U PD=1350000U
* device instance $6 r0 *1 3.675,2.165 pfet_01v8_hvt
M$6 5 7 10 11 pfet_01v8_hvt L=150000U W=640000U AS=227200000000P
+ AD=92800000000P PS=1350000U PD=930000U
* device instance $7 r0 *1 4.115,2.165 pfet_01v8_hvt
M$7 5 8 10 11 pfet_01v8_hvt L=150000U W=640000U AS=149000000000P
+ AD=92800000000P PS=1325000U PD=930000U
* device instance $8 r0 *1 4.59,1.985 pfet_01v8_hvt
M$8 6 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=304000000000P
+ AD=415000000000P PS=2635000U PD=3830000U
* device instance $10 r0 *1 3.755,0.445 nfet_01v8
M$10 9 7 5 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $11 r0 *1 4.115,0.445 nfet_01v8
M$11 1 8 9 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $12 r0 *1 4.59,0.56 nfet_01v8
M$12 6 5 1 13 nfet_01v8 L=150000U W=1300000U AS=197750000000P AD=269750000000P
+ PS=1935000U PD=2780000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 2 3 1 13 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=269750000000P
+ PS=2780000U PD=2780000U
* device instance $16 r0 *1 1.87,0.445 nfet_01v8
M$16 4 5 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $17 r0 *1 2.29,0.445 nfet_01v8
M$17 1 7 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.71,0.445 nfet_01v8
M$18 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
.ENDS sky130_fd_sc_hd__ha_2

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__nand4b_1
* pin VPB
* pin A_N
* pin B
* pin C
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4b_1 1 2 3 4 6 7 8 9 10
* net 1 VPB
* net 2 A_N
* net 3 B
* net 4 C
* net 6 D
* net 7 VPWR
* net 8 Y
* net 9 VGND
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 7 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 8 6 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=195000000000P PS=1385000U PD=1390000U
* device instance $5 r0 *1 2.58,1.985 pfet_01v8_hvt
M$5 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $6 r0 *1 0.545,0.675 nfet_01v8
M$6 5 2 9 10 nfet_01v8 L=150000U W=420000U AS=118125000000P AD=111300000000P
+ PS=1040000U PD=1370000U
* device instance $7 r0 *1 1.085,0.56 nfet_01v8
M$7 11 6 9 10 nfet_01v8 L=150000U W=650000U AS=118125000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.505,0.56 nfet_01v8
M$8 13 4 11 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $9 r0 *1 2.04,0.56 nfet_01v8
M$9 12 3 13 10 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=126750000000P
+ PS=1035000U PD=1040000U
* device instance $10 r0 *1 2.58,0.56 nfet_01v8
M$10 8 5 12 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=227500000000P
+ PS=1040000U PD=2000000U
.ENDS sky130_fd_sc_hd__nand4b_1

* cell sky130_fd_sc_hd__nand3b_1
* pin VPB
* pin A_N
* pin C
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand3b_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A_N
* net 3 C
* net 4 B
* net 5 Y
* net 7 VGND
* net 8 VPWR
* device instance $1 r0 *1 0.6,1.695 pfet_01v8_hvt
M$1 8 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 1.085,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.505,1.985 pfet_01v8_hvt
M$3 8 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=192500000000P PS=1270000U PD=1385000U
* device instance $4 r0 *1 2.04,1.985 pfet_01v8_hvt
M$4 5 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=192500000000P
+ AD=280000000000P PS=1385000U PD=2560000U
* device instance $5 r0 *1 0.6,0.675 nfet_01v8
M$5 6 2 7 9 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $6 r0 *1 1.085,0.56 nfet_01v8
M$6 11 3 7 9 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $7 r0 *1 1.505,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=125125000000P
+ PS=920000U PD=1035000U
* device instance $8 r0 *1 2.04,0.56 nfet_01v8
M$8 5 6 10 9 nfet_01v8 L=150000U W=650000U AS=125125000000P AD=182000000000P
+ PS=1035000U PD=1860000U
.ENDS sky130_fd_sc_hd__nand3b_1

* cell sky130_fd_sc_hd__and4b_1
* pin VGND
* pin B
* pin C
* pin X
* pin A_N
* pin D
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and4b_1 1 4 5 6 7 8 12 13 14
* net 1 VGND
* net 4 B
* net 5 C
* net 6 X
* net 7 A_N
* net 8 D
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 12 7 2 13 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,2.275 pfet_01v8_hvt
M$2 3 2 12 13 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=98700000000P
+ PS=690000U PD=890000U
* device instance $3 r0 *1 1.51,2.275 pfet_01v8_hvt
M$3 12 4 3 13 pfet_01v8_hvt L=150000U W=420000U AS=98700000000P
+ AD=128100000000P PS=890000U PD=1030000U
* device instance $4 r0 *1 2.27,2.275 pfet_01v8_hvt
M$4 3 5 12 13 pfet_01v8_hvt L=150000U W=420000U AS=128100000000P
+ AD=66150000000P PS=1030000U PD=735000U
* device instance $5 r0 *1 2.735,2.275 pfet_01v8_hvt
M$5 3 8 12 13 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=66150000000P PS=1325000U PD=735000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 6 3 12 13 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 1.41,0.445 nfet_01v8
M$7 11 2 3 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $8 r0 *1 1.77,0.445 nfet_01v8
M$8 10 4 11 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=73500000000P
+ PS=630000U PD=770000U
* device instance $9 r0 *1 2.27,0.445 nfet_01v8
M$9 9 5 10 14 nfet_01v8 L=150000U W=420000U AS=73500000000P AD=60900000000P
+ PS=770000U PD=710000U
* device instance $10 r0 *1 2.71,0.445 nfet_01v8
M$10 1 8 9 14 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=103400000000P
+ PS=710000U PD=1000000U
* device instance $11 r0 *1 3.21,0.56 nfet_01v8
M$11 6 3 1 14 nfet_01v8 L=150000U W=650000U AS=103400000000P AD=169000000000P
+ PS=1000000U PD=1820000U
* device instance $12 r0 *1 0.47,0.445 nfet_01v8
M$12 1 7 2 14 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__and4b_1

* cell sky130_fd_sc_hd__nand4_4
* pin VGND
* pin D
* pin A
* pin C
* pin B
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_4 1 2 3 5 7 9 10 11 12
* net 1 VGND
* net 2 D
* net 3 A
* net 5 C
* net 7 B
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 10 5 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=800000000000P PS=5080000U PD=5600000U
* device instance $9 r0 *1 4.35,1.985 pfet_01v8_hvt
M$9 10 7 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=800000000000P
+ AD=570000000000P PS=5600000U PD=5140000U
* device instance $13 r0 *1 6.09,1.985 pfet_01v8_hvt
M$13 10 3 9 11 pfet_01v8_hvt L=150000U W=4000000U AS=570000000000P
+ AD=665000000000P PS=5140000U PD=6330000U
* device instance $17 r0 *1 4.35,0.56 nfet_01v8
M$17 6 7 8 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=370500000000P
+ PS=4580000U PD=3740000U
* device instance $21 r0 *1 6.09,0.56 nfet_01v8
M$21 10 3 8 12 nfet_01v8 L=150000U W=2600000U AS=370500000000P AD=432250000000P
+ PS=3740000U PD=4580000U
* device instance $25 r0 *1 0.47,0.56 nfet_01v8
M$25 1 2 4 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $29 r0 *1 2.15,0.56 nfet_01v8
M$29 6 5 4 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__nand4_4

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__or4_1
* pin VPB
* pin A
* pin B
* pin C
* pin D
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or4_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 D
* net 7 X
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 13 5 6 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $2 r0 *1 0.95,1.695 pfet_01v8_hvt
M$2 12 4 13 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $3 r0 *1 1.31,1.695 pfet_01v8_hvt
M$3 11 3 12 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $4 r0 *1 1.79,1.695 pfet_01v8_hvt
M$4 8 2 11 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $5 r0 *1 2.28,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=270000000000P PS=1340000U PD=2540000U
* device instance $6 r0 *1 0.47,0.475 nfet_01v8
M$6 6 5 9 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=69300000000P
+ PS=1360000U PD=750000U
* device instance $7 r0 *1 0.95,0.475 nfet_01v8
M$7 9 4 6 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=56700000000P
+ PS=750000U PD=690000U
* device instance $8 r0 *1 1.37,0.475 nfet_01v8
M$8 6 3 9 10 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $9 r0 *1 1.79,0.475 nfet_01v8
M$9 6 2 9 10 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $10 r0 *1 2.28,0.56 nfet_01v8
M$10 7 6 9 10 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=175500000000P
+ PS=990000U PD=1840000U
.ENDS sky130_fd_sc_hd__or4_1

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__and4_1
* pin VPB
* pin D
* pin C
* pin B
* pin A
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__and4_1 1 3 4 5 6 7 8 9 10
* net 1 VPB
* net 3 D
* net 4 C
* net 5 B
* net 6 A
* net 7 VGND
* net 8 VPWR
* net 9 X
* device instance $1 r0 *1 0.47,2.275 pfet_01v8_hvt
M$1 2 6 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=73500000000P
+ PS=1360000U PD=770000U
* device instance $2 r0 *1 0.97,2.275 pfet_01v8_hvt
M$2 8 5 2 1 pfet_01v8_hvt L=150000U W=420000U AS=73500000000P AD=77700000000P
+ PS=770000U PD=790000U
* device instance $3 r0 *1 1.49,2.275 pfet_01v8_hvt
M$3 2 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=77700000000P AD=58800000000P
+ PS=790000U PD=700000U
* device instance $4 r0 *1 1.92,2.275 pfet_01v8_hvt
M$4 2 3 8 1 pfet_01v8_hvt L=150000U W=420000U AS=312450000000P AD=58800000000P
+ PS=1680000U PD=700000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=312450000000P
+ AD=260000000000P PS=1680000U PD=2520000U
* device instance $6 r0 *1 0.47,0.445 nfet_01v8
M$6 13 6 2 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=60900000000P
+ PS=1360000U PD=710000U
* device instance $7 r0 *1 0.91,0.445 nfet_01v8
M$7 11 5 13 10 nfet_01v8 L=150000U W=420000U AS=60900000000P AD=79800000000P
+ PS=710000U PD=800000U
* device instance $8 r0 *1 1.44,0.445 nfet_01v8
M$8 12 4 11 10 nfet_01v8 L=150000U W=420000U AS=79800000000P AD=69300000000P
+ PS=800000U PD=750000U
* device instance $9 r0 *1 1.92,0.445 nfet_01v8
M$9 7 3 12 10 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=196275000000P
+ PS=750000U PD=1330000U
* device instance $10 r0 *1 2.75,0.56 nfet_01v8
M$10 9 2 7 10 nfet_01v8 L=150000U W=650000U AS=196275000000P AD=169000000000P
+ PS=1330000U PD=1820000U
.ENDS sky130_fd_sc_hd__and4_1

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__clkbuf_4
* pin VPB
* pin A
* pin VGND
* pin X
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_4 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 VGND
* net 5 X
* net 6 VPWR
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 6 3 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=165000000000P PS=2530000U PD=1330000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 6 1 pfet_01v8_hvt L=150000U W=4000000U AS=585000000000P
+ AD=720000000000P PS=5170000U PD=6440000U
* device instance $6 r0 *1 0.475,0.445 nfet_01v8
M$6 4 3 2 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=70350000000P
+ PS=1370000U PD=755000U
* device instance $7 r0 *1 0.96,0.445 nfet_01v8
M$7 5 2 4 7 nfet_01v8 L=150000U W=1680000U AS=246750000000P AD=298200000000P
+ PS=2855000U PD=3520000U
.ENDS sky130_fd_sc_hd__clkbuf_4
