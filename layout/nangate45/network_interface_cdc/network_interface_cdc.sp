* cell network_interface_cdc
* pin dst_clk
* pin dst_rst_n
* pin router_in_data[11]
* pin mem_addr[15]
* pin mem_wdata[15]
* pin mem_addr[12]
* pin router_in_data[15]
* pin mem_wdata[12]
* pin router_in_data[12]
* pin mem_ready
* pin router_in_ready
* pin router_out_valid
* pin router_in_valid
* pin router_out_ready
* pin router_out_data[29]
* pin router_out_data[2]
* pin mem_rdata[29]
* pin mem_rdata[2]
* pin router_out_data[28]
* pin router_out_data[7]
* pin mem_rdata[28]
* pin router_out_data[5]
* pin PWELL
* pin NWELL
* pin src_rst_n
* pin mem_rdata[5]
* pin mem_wdata[11]
* pin mem_addr[11]
* pin mem_rdata[30]
* pin mem_wdata[14]
* pin mem_rdata[7]
* pin router_out_data[30]
* pin mem_addr[14]
* pin router_in_data[14]
* pin mem_addr[13]
* pin mem_wdata[13]
* pin router_out_data[31]
* pin mem_rdata[31]
* pin router_in_data[13]
* pin mem_rdata[4]
* pin router_out_data[4]
* pin router_in_data[16]
* pin router_out_data[6]
* pin mem_wdata[16]
* pin mem_addr[16]
* pin mem_rdata[6]
* pin router_out_data[3]
* pin mem_wdata[10]
* pin mem_addr[10]
* pin mem_rdata[3]
* pin router_in_data[10]
* pin router_out_data[15]
* pin router_in_data[0]
* pin mem_write
* pin mem_read
* pin mem_wdata[0]
* pin mem_rdata[10]
* pin mem_rdata[9]
* pin mem_rdata[18]
* pin router_in_data[17]
* pin mem_rdata[15]
* pin router_out_data[9]
* pin mem_addr[0]
* pin mem_wdata[17]
* pin mem_addr[20]
* pin router_out_data[18]
* pin mem_addr[18]
* pin mem_wdata[20]
* pin router_out_data[10]
* pin mem_rdata[8]
* pin router_out_data[12]
* pin mem_addr[17]
* pin mem_wdata[18]
* pin router_in_data[18]
* pin mem_rdata[12]
* pin router_out_data[8]
* pin mem_rdata[13]
* pin router_in_data[20]
* pin router_out_data[13]
* pin mem_wdata[19]
* pin router_in_data[19]
* pin mem_addr[19]
* pin router_in_data[8]
* pin router_in_data[7]
* pin router_out_data[16]
* pin mem_rdata[16]
* pin mem_addr[9]
* pin router_out_data[0]
* pin mem_wdata[1]
* pin router_in_data[1]
* pin mem_addr[1]
* pin mem_rdata[11]
* pin mem_rdata[0]
* pin mem_wdata[9]
* pin router_out_data[17]
* pin mem_wdata[24]
* pin router_out_data[11]
* pin router_in_data[24]
* pin mem_rdata[17]
* pin dest_id[0]
* pin mem_rdata[26]
* pin router_out_data[14]
* pin router_in_data[22]
* pin mem_wdata[22]
* pin mem_rdata[14]
* pin msg_type[1]
* pin dest_id[2]
* pin router_in_data[26]
* pin mem_wdata[26]
* pin router_out_data[21]
* pin mem_rdata[21]
* pin router_out_data[22]
* pin mem_wdata[25]
* pin router_in_data[25]
* pin mem_rdata[22]
* pin mem_wdata[21]
* pin msg_type[0]
* pin dest_id[1]
* pin router_out_data[20]
* pin msg_type[2]
* pin mem_wdata[23]
* pin mem_rdata[20]
* pin router_in_data[23]
* pin src_clk
* pin mem_wdata[2]
* pin router_out_data[26]
* pin router_in_data[21]
* pin router_in_data[27]
* pin dest_id[6]
* pin mem_rdata[19]
* pin router_in_data[30]
* pin router_in_data[3]
* pin mem_rdata[24]
* pin router_out_data[19]
* pin router_in_data[4]
* pin router_in_data[6]
* pin router_out_data[25]
* pin mem_rdata[27]
* pin mem_addr[5]
* pin router_out_data[27]
* pin mem_rdata[25]
* pin router_out_data[24]
* pin router_in_data[5]
* pin mem_rdata[1]
* pin mem_rdata[23]
* pin router_in_data[2]
* pin router_in_data[29]
* pin router_in_data[31]
* pin router_in_data[9]
* pin mem_wdata[6]
* pin mem_addr[6]
* pin dest_id[3]
* pin dest_id[4]
* pin mem_wdata[27]
* pin mem_wdata[28]
* pin router_in_data[28]
* pin mem_wdata[29]
* pin dest_id[5]
* pin mem_addr[3]
* pin mem_wdata[3]
* pin mem_wdata[30]
* pin dest_id[7]
* pin mem_wdata[31]
* pin mem_addr[4]
* pin mem_addr[8]
* pin mem_addr[7]
* pin mem_wdata[4]
* pin mem_wdata[7]
* pin mem_wdata[5]
* pin mem_wdata[8]
* pin mem_addr[2]
* pin router_out_data[23]
* pin router_out_data[1]
.SUBCKT network_interface_cdc 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19
+ 20 21 22 35 48 88 89 109 110 114 133 141 142 146 156 164 165 173 175 181 187
+ 188 195 197 200 211 217 218 225 226 234 240 244 246 262 263 264 272 273 274
+ 278 285 286 300 310 318 326 331 332 345 346 348 357 358 359 365 366 377 382
+ 386 390 391 392 396 397 398 399 408 414 416 417 418 423 424 431 433 439 444
+ 448 458 466 470 471 476 477 485 494 507 508 516 518 519 531 541 542 550 552
+ 553 573 585 597 598 607 617 641 663 666 696 697 700 702 704 706 708 709 712
+ 714 715 716 717 719 721 722 723 724 725 726 727 728 729 730 731 732 733 734
+ 735 736 737 738 739 740 741 742 743 744 745 746 747 748 749 750 751 752 753
* net 1 dst_clk
* net 2 dst_rst_n
* net 3 router_in_data[11]
* net 4 mem_addr[15]
* net 5 mem_wdata[15]
* net 6 mem_addr[12]
* net 7 router_in_data[15]
* net 8 mem_wdata[12]
* net 9 router_in_data[12]
* net 10 mem_ready
* net 11 router_in_ready
* net 12 router_out_valid
* net 13 router_in_valid
* net 14 router_out_ready
* net 15 router_out_data[29]
* net 16 router_out_data[2]
* net 17 mem_rdata[29]
* net 18 mem_rdata[2]
* net 19 router_out_data[28]
* net 20 router_out_data[7]
* net 21 mem_rdata[28]
* net 22 router_out_data[5]
* net 35 PWELL
* net 48 NWELL
* net 88 src_rst_n
* net 89 mem_rdata[5]
* net 109 mem_wdata[11]
* net 110 mem_addr[11]
* net 114 mem_rdata[30]
* net 133 mem_wdata[14]
* net 141 mem_rdata[7]
* net 142 router_out_data[30]
* net 146 mem_addr[14]
* net 156 router_in_data[14]
* net 164 mem_addr[13]
* net 165 mem_wdata[13]
* net 173 router_out_data[31]
* net 175 mem_rdata[31]
* net 181 router_in_data[13]
* net 187 mem_rdata[4]
* net 188 router_out_data[4]
* net 195 router_in_data[16]
* net 197 router_out_data[6]
* net 200 mem_wdata[16]
* net 211 mem_addr[16]
* net 217 mem_rdata[6]
* net 218 router_out_data[3]
* net 225 mem_wdata[10]
* net 226 mem_addr[10]
* net 234 mem_rdata[3]
* net 240 router_in_data[10]
* net 244 router_out_data[15]
* net 246 router_in_data[0]
* net 262 mem_write
* net 263 mem_read
* net 264 mem_wdata[0]
* net 272 mem_rdata[10]
* net 273 mem_rdata[9]
* net 274 mem_rdata[18]
* net 278 router_in_data[17]
* net 285 mem_rdata[15]
* net 286 router_out_data[9]
* net 300 mem_addr[0]
* net 310 mem_wdata[17]
* net 318 mem_addr[20]
* net 326 router_out_data[18]
* net 331 mem_addr[18]
* net 332 mem_wdata[20]
* net 345 router_out_data[10]
* net 346 mem_rdata[8]
* net 348 router_out_data[12]
* net 357 mem_addr[17]
* net 358 mem_wdata[18]
* net 359 router_in_data[18]
* net 365 mem_rdata[12]
* net 366 router_out_data[8]
* net 377 mem_rdata[13]
* net 382 router_in_data[20]
* net 386 router_out_data[13]
* net 390 mem_wdata[19]
* net 391 router_in_data[19]
* net 392 mem_addr[19]
* net 396 router_in_data[8]
* net 397 router_in_data[7]
* net 398 router_out_data[16]
* net 399 mem_rdata[16]
* net 408 mem_addr[9]
* net 414 router_out_data[0]
* net 416 mem_wdata[1]
* net 417 router_in_data[1]
* net 418 mem_addr[1]
* net 423 mem_rdata[11]
* net 424 mem_rdata[0]
* net 431 mem_wdata[9]
* net 433 router_out_data[17]
* net 439 mem_wdata[24]
* net 444 router_out_data[11]
* net 448 router_in_data[24]
* net 458 mem_rdata[17]
* net 466 dest_id[0]
* net 470 mem_rdata[26]
* net 471 router_out_data[14]
* net 476 router_in_data[22]
* net 477 mem_wdata[22]
* net 485 mem_rdata[14]
* net 494 msg_type[1]
* net 507 dest_id[2]
* net 508 router_in_data[26]
* net 516 mem_wdata[26]
* net 518 router_out_data[21]
* net 519 mem_rdata[21]
* net 531 router_out_data[22]
* net 541 mem_wdata[25]
* net 542 router_in_data[25]
* net 550 mem_rdata[22]
* net 552 mem_wdata[21]
* net 553 msg_type[0]
* net 573 dest_id[1]
* net 585 router_out_data[20]
* net 597 msg_type[2]
* net 598 mem_wdata[23]
* net 607 mem_rdata[20]
* net 617 router_in_data[23]
* net 641 src_clk
* net 663 mem_wdata[2]
* net 666 router_out_data[26]
* net 696 router_in_data[21]
* net 697 router_in_data[27]
* net 700 dest_id[6]
* net 702 mem_rdata[19]
* net 704 router_in_data[30]
* net 706 router_in_data[3]
* net 708 mem_rdata[24]
* net 709 router_out_data[19]
* net 712 router_in_data[4]
* net 714 router_in_data[6]
* net 715 router_out_data[25]
* net 716 mem_rdata[27]
* net 717 mem_addr[5]
* net 719 router_out_data[27]
* net 721 mem_rdata[25]
* net 722 router_out_data[24]
* net 723 router_in_data[5]
* net 724 mem_rdata[1]
* net 725 mem_rdata[23]
* net 726 router_in_data[2]
* net 727 router_in_data[29]
* net 728 router_in_data[31]
* net 729 router_in_data[9]
* net 730 mem_wdata[6]
* net 731 mem_addr[6]
* net 732 dest_id[3]
* net 733 dest_id[4]
* net 734 mem_wdata[27]
* net 735 mem_wdata[28]
* net 736 router_in_data[28]
* net 737 mem_wdata[29]
* net 738 dest_id[5]
* net 739 mem_addr[3]
* net 740 mem_wdata[3]
* net 741 mem_wdata[30]
* net 742 dest_id[7]
* net 743 mem_wdata[31]
* net 744 mem_addr[4]
* net 745 mem_addr[8]
* net 746 mem_addr[7]
* net 747 mem_wdata[4]
* net 748 mem_wdata[7]
* net 749 mem_wdata[5]
* net 750 mem_wdata[8]
* net 751 mem_addr[2]
* net 752 router_out_data[23]
* net 753 router_out_data[1]
* cell instance $2 m0 *1 4.56,4.2
X$2 35 1 26 48 BUF_X16
* cell instance $8 r0 *1 5.7,1.4
X$8 35 2 38 48 BUF_X16
* cell instance $14 r0 *1 5.13,1.4
X$14 61 35 48 3 BUF_X1
* cell instance $20 r0 *1 10.45,1.4
X$20 4 35 48 62 BUF_X1
* cell instance $26 r0 *1 10.83,4.2
X$26 5 35 48 80 BUF_X1
* cell instance $32 r0 *1 13.87,1.4
X$32 6 35 48 63 BUF_X1
* cell instance $38 r0 *1 12.35,1.4
X$38 24 35 48 7 BUF_X1
* cell instance $48 r0 *1 12.92,1.4
X$48 8 35 48 36 BUF_X1
* cell instance $50 r0 *1 15.77,1.4
X$50 25 35 48 9 BUF_X1
* cell instance $56 r0 *1 27.17,1.4
X$56 147 35 48 10 BUF_X1
* cell instance $62 m0 *1 30.02,4.2
X$62 11 35 48 65 BUF_X1
* cell instance $68 r0 *1 32.11,4.2
X$68 12 35 48 72 BUF_X1
* cell instance $74 r0 *1 31.54,1.4
X$74 41 35 48 13 BUF_X1
* cell instance $80 r0 *1 32.11,1.4
X$80 27 35 48 14 BUF_X1
* cell instance $86 r0 *1 34.77,1.4
X$86 15 35 48 37 BUF_X1
* cell instance $92 r0 *1 36.86,1.4
X$92 16 35 48 79 BUF_X1
* cell instance $98 r0 *1 37.81,1.4
X$98 42 35 48 17 BUF_X1
* cell instance $104 r0 *1 38.76,1.4
X$104 28 35 48 18 BUF_X1
* cell instance $110 r0 *1 39.33,1.4
X$110 19 35 48 43 BUF_X1
* cell instance $116 r0 *1 41.61,1.4
X$116 20 35 48 30 BUF_X1
* cell instance $122 r0 *1 42.18,1.4
X$122 29 35 48 21 BUF_X1
* cell instance $128 r0 *1 44.46,1.4
X$128 22 35 48 32 BUF_X1
* cell instance $134 r0 *1 7.03,4.2
X$134 35 33 864 23 90 66 48 DFFR_X1
* cell instance $137 m0 *1 10.26,7
X$137 23 35 48 92 INV_X1
* cell instance $139 r0 *1 11.02,1.4
X$139 23 51 24 35 48 50 MUX2_X1
* cell instance $141 m0 *1 9.69,4.2
X$141 35 26 833 24 50 38 48 DFFR_X1
* cell instance $148 m0 *1 14.25,4.2
X$148 35 26 830 25 57 38 48 DFFR_X1
* cell instance $150 r0 *1 14.44,1.4
X$150 56 51 25 35 48 57 MUX2_X1
* cell instance $156 m0 *1 32.11,12.6
X$156 35 754 158 180 26 38 48 DFFS_X1
* cell instance $158 m0 *1 7.41,46.2
X$158 35 26 780 622 623 38 48 DFFR_X1
* cell instance $160 m0 *1 20.33,40.6
X$160 35 26 781 543 572 38 48 DFFR_X1
* cell instance $163 m0 *1 42.94,40.6
X$163 35 26 827 548 567 38 48 DFFR_X1
* cell instance $166 r0 *1 15.01,46.2
X$166 35 26 892 698 675 38 48 DFFR_X1
* cell instance $168 m0 *1 35.15,7
X$168 35 26 777 97 73 38 48 DFFR_X1
* cell instance $170 m0 *1 37.24,26.6
X$170 35 26 795 374 404 38 48 DFFR_X1
* cell instance $172 r0 *1 32.68,23.8
X$172 35 26 874 340 330 38 48 DFFR_X1
* cell instance $174 m0 *1 15.2,40.6
X$174 35 26 784 558 571 38 48 DFFR_X1
* cell instance $177 r0 *1 43.13,4.2
X$177 35 26 845 93 76 38 48 DFFR_X1
* cell instance $179 m0 *1 10.64,43.4
X$179 35 26 766 599 575 38 48 DFFR_X1
* cell instance $182 m0 *1 43.13,15.4
X$182 35 26 793 191 192 38 48 DFFR_X1
* cell instance $185 m0 *1 43.89,4.2
X$185 35 26 809 46 45 38 48 DFFR_X1
* cell instance $188 m0 *1 7.98,40.6
X$188 35 26 779 557 568 38 48 DFFR_X1
* cell instance $191 m0 *1 41.8,26.6
X$191 35 26 794 375 379 38 48 DFFR_X1
* cell instance $194 r0 *1 43.51,15.4
X$194 35 26 896 237 207 38 48 DFFR_X1
* cell instance $196 r0 *1 9.31,32.2
X$196 35 26 876 449 450 38 48 DFFR_X1
* cell instance $198 m0 *1 10.07,37.8
X$198 35 26 767 510 523 38 48 DFFR_X1
* cell instance $200 r0 *1 9.31,35
X$200 35 26 880 497 498 38 48 DFFR_X1
* cell instance $203 m0 *1 45.79,49
X$203 35 26 774 691 699 38 48 DFFR_X1
* cell instance $205 m0 *1 42.56,9.8
X$205 35 26 810 104 126 38 48 DFFR_X1
* cell instance $207 r0 *1 40.66,46.2
X$207 35 26 849 670 669 38 48 DFFR_X1
* cell instance $210 m0 *1 45.41,46.2
X$210 35 26 775 605 635 38 48 DFFR_X1
* cell instance $212 r0 *1 41.8,9.8
X$212 35 26 898 151 161 38 48 DFFR_X1
* cell instance $214 m0 *1 40.09,4.2
X$214 35 26 820 49 44 38 48 DFFR_X1
* cell instance $217 r0 *1 27.93,12.6
X$217 35 26 136 183 171 38 48 DFFR_X1
* cell instance $219 r0 *1 30.02,40.6
X$219 35 26 854 591 561 38 48 DFFR_X1
* cell instance $222 r0 *1 42.18,32.2
X$222 35 26 850 456 464 38 48 DFFR_X1
* cell instance $224 m0 *1 41.8,35
X$224 35 26 817 489 473 38 48 DFFR_X1
* cell instance $226 r0 *1 43.89,26.6
X$226 35 26 851 406 407 38 48 DFFR_X1
* cell instance $228 m0 *1 44.08,32.2
X$228 35 26 824 421 437 38 48 DFFR_X1
* cell instance $231 m0 *1 44.08,37.8
X$231 35 26 825 535 524 38 48 DFFR_X1
* cell instance $234 m0 *1 32.87,35
X$234 35 26 804 499 483 38 48 DFFR_X1
* cell instance $236 r0 *1 29.45,37.8
X$236 35 26 878 529 538 38 48 DFFR_X1
* cell instance $239 r0 *1 32.87,43.4
X$239 35 26 839 631 636 38 48 DFFR_X1
* cell instance $241 r0 *1 32.11,32.2
X$241 35 26 855 443 455 38 48 DFFR_X1
* cell instance $243 m0 *1 34.2,40.6
X$243 35 26 762 563 570 38 48 DFFR_X1
* cell instance $245 r0 *1 27.74,1.4
X$245 35 26 853 41 40 38 48 DFFR_X1
* cell instance $247 r0 *1 30.4,29.4
X$247 35 26 863 412 411 38 48 DFFR_X1
* cell instance $249 m0 *1 31.16,9.8
X$249 35 26 772 102 129 38 48 DFFR_X1
* cell instance $251 r0 *1 36.29,29.4
X$251 35 26 882 413 430 38 48 DFFR_X1
* cell instance $253 r0 *1 36.29,40.6
X$253 35 26 883 582 590 38 48 DFFR_X1
* cell instance $256 r0 *1 36.86,46.2
X$256 35 26 866 668 674 38 48 DFFR_X1
* cell instance $259 r0 *1 33.06,46.2
X$259 35 26 862 667 676 38 48 DFFR_X1
* cell instance $262 m0 *1 37.81,15.4
X$262 35 26 813 206 209 38 48 DFFR_X1
* cell instance $265 m0 *1 22.42,46.2
X$265 35 26 764 602 628 38 48 DFFR_X1
* cell instance $268 m0 *1 14.25,46.2
X$268 35 26 818 695 657 38 48 DFFR_X1
* cell instance $271 r0 *1 26.79,15.4
X$271 35 26 886 205 224 38 48 DFFR_X1
* cell instance $273 m0 *1 33.44,4.2
X$273 35 26 808 58 52 38 48 DFFR_X1
* cell instance $276 r0 *1 23.75,46.2
X$276 35 26 865 660 681 38 48 DFFR_X1
* cell instance $278 m0 *1 38.19,23.8
X$278 35 26 812 343 328 38 48 DFFR_X1
* cell instance $281 m0 *1 30.02,49
X$281 35 26 815 665 711 38 48 DFFR_X1
* cell instance $284 r0 *1 28.31,4.2
X$284 35 26 857 71 82 38 48 DFFR_X1
* cell instance $286 m0 *1 26.22,4.2
X$286 35 26 796 94 108 38 48 DFFR_X1
* cell instance $289 r0 *1 34.77,18.2
X$289 35 26 843 277 260 38 48 DFFR_X1
* cell instance $291 m0 *1 21.85,9.8
X$291 35 26 789 132 124 38 48 DFFR_X1
* cell instance $294 r0 *1 24.13,12.6
X$294 35 26 903 170 182 38 48 DFFR_X1
* cell instance $297 m0 *1 21.85,12.6
X$297 35 26 790 163 169 38 48 DFFR_X1
* cell instance $299 m0 *1 6.46,18.2
X$299 35 26 769 213 236 38 48 DFFR_X1
* cell instance $301 r0 *1 23.94,9.8
X$301 35 26 904 135 163 38 48 DFFR_X1
* cell instance $304 r0 *1 3.23,4.2
X$304 35 26 861 61 60 38 48 DFFR_X1
* cell instance $307 r0 *1 17.29,35
X$307 35 26 873 479 492 38 48 DFFR_X1
* cell instance $310 m0 *1 5.89,21
X$310 35 26 770 266 290 38 48 DFFR_X1
* cell instance $316 m0 *1 7.03,29.4
X$316 35 26 826 402 394 38 48 DFFR_X1
* cell instance $318 m0 *1 7.22,26.6
X$318 35 26 799 371 360 38 48 DFFR_X1
* cell instance $321 r0 *1 9.31,29.4
X$321 35 26 877 409 410 38 48 DFFR_X1
* cell instance $327 m0 *1 18.05,9.8
X$327 35 26 785 124 123 38 48 DFFR_X1
* cell instance $330 m0 *1 14.25,9.8
X$330 35 26 831 123 122 38 48 DFFR_X1
* cell instance $333 r0 *1 12.35,18.2
X$333 35 26 895 247 256 38 48 DFFR_X1
* cell instance $335 m0 *1 43.7,21
X$335 35 26 803 253 291 38 48 DFFR_X1
* cell instance $337 r0 *1 43.51,21
X$337 35 26 901 350 327 38 48 DFFR_X1
* cell instance $339 m0 *1 20.52,15.4
X$339 35 26 773 182 242 38 48 DFFR_X1
* cell instance $342 r0 *1 7.03,12.6
X$342 35 26 190 167 189 38 48 DFFR_X1
* cell instance $344 m0 *1 7.03,12.6
X$344 35 26 787 154 179 38 48 DFFR_X1
* cell instance $346 m0 *1 6.46,9.8
X$346 35 26 834 130 145 38 48 DFFR_X1
* cell instance $348 m0 *1 9.12,15.4
X$348 35 26 807 203 194 38 48 DFFR_X1
* cell instance $350 m0 *1 13.68,26.6
X$350 35 26 798 373 361 38 48 DFFR_X1
* cell instance $409 r0 *1 31.92,7
X$409 102 103 35 48 27 OR2_X1
* cell instance $412 r0 *1 36.48,7
X$412 35 33 888 28 96 66 48 DFFR_X1
* cell instance $414 m0 *1 38.95,7
X$414 97 78 28 35 48 96 MUX2_X1
* cell instance $417 r0 *1 39.33,4.2
X$417 35 33 890 29 77 66 48 DFFR_X1
* cell instance $419 m0 *1 41.23,7
X$419 49 78 29 35 48 77 MUX2_X1
* cell instance $423 r0 *1 43.13,1.4
X$423 30 31 46 35 48 45 MUX2_X1
* cell instance $425 r0 *1 35.53,1.4
X$425 37 31 58 35 48 52 MUX2_X1
* cell instance $427 r0 *1 45.22,12.6
X$427 176 31 191 35 48 192 MUX2_X1
* cell instance $429 r0 *1 44.84,7
X$429 144 31 104 35 48 126 MUX2_X1
* cell instance $431 m0 *1 45.22,18.2
X$431 235 31 237 35 48 207 MUX2_X1
* cell instance $433 r0 *1 41.23,15.4
X$433 220 31 206 35 48 209 MUX2_X1
* cell instance $435 r0 *1 45.03,1.4
X$435 32 31 93 35 48 76 MUX2_X1
* cell instance $440 m0 *1 44.27,12.6
X$440 177 31 151 35 48 161 MUX2_X1
* cell instance $442 r0 *1 39.9,1.4
X$442 43 31 49 35 48 44 MUX2_X1
* cell instance $445 r0 *1 38,4.2
X$445 79 31 97 35 48 73 MUX2_X1
* cell instance $447 r0 *1 37.81,12.6
X$447 162 35 48 31 CLKBUF_X3
* cell instance $460 r0 *1 12.73,21
X$460 35 267 316 315 33 66 48 DFFS_X1
* cell instance $462 r0 *1 1.33,46.2
X$462 35 641 33 48 BUF_X16
* cell instance $466 m0 *1 2.28,46.2
X$466 35 33 782 621 620 66 48 DFFR_X1
* cell instance $469 m0 *1 47.31,9.8
X$469 35 33 806 113 112 66 48 DFFR_X1
* cell instance $471 r0 *1 47.12,9.8
X$471 35 33 856 159 152 66 48 DFFR_X1
* cell instance $473 r0 *1 23.75,40.6
X$473 35 33 899 593 580 66 48 DFFR_X1
* cell instance $476 m0 *1 41.04,43.4
X$476 35 33 756 583 612 66 48 DFFR_X1
* cell instance $478 r0 *1 47.31,15.4
X$478 35 33 871 216 233 66 48 DFFR_X1
* cell instance $480 m0 *1 47.31,15.4
X$480 35 33 776 185 184 66 48 DFFR_X1
* cell instance $482 m0 *1 47.5,40.6
X$482 35 33 788 533 549 66 48 DFFR_X1
* cell instance $484 r0 *1 47.5,40.6
X$484 35 33 847 530 586 66 48 DFFR_X1
* cell instance $486 m0 *1 47.31,43.4
X$486 35 33 802 606 634 66 48 DFFR_X1
* cell instance $488 m0 *1 34.58,46.2
X$488 35 33 814 720 649 66 48 DFFR_X1
* cell instance $491 r0 *1 41.04,18.2
X$491 35 33 872 243 251 66 48 DFFR_X1
* cell instance $494 m0 *1 40.47,18.2
X$494 35 33 758 232 238 66 48 DFFR_X1
* cell instance $496 r0 *1 2.66,40.6
X$496 35 33 870 556 555 66 48 DFFR_X1
* cell instance $499 r0 *1 12.73,43.4
X$499 35 33 838 626 624 66 48 DFFR_X1
* cell instance $502 m0 *1 39.33,21
X$502 35 33 811 271 294 66 48 DFFR_X1
* cell instance $504 r0 *1 47.31,4.2
X$504 35 33 868 74 59 66 48 DFFR_X1
* cell instance $506 m0 *1 3.99,37.8
X$506 35 33 759 521 509 66 48 DFFR_X1
* cell instance $508 r0 *1 47.31,1.4
X$508 35 33 869 47 34 66 48 DFFR_X1
* cell instance $510 r0 *1 47.31,46.2
X$510 35 33 893 672 646 66 48 DFFR_X1
* cell instance $512 m0 *1 5.13,43.4
X$512 35 33 783 574 614 66 48 DFFR_X1
* cell instance $514 m0 *1 38.38,46.2
X$514 35 33 821 689 648 66 48 DFFR_X1
* cell instance $517 m0 *1 41.99,49
X$517 35 33 786 703 671 66 48 DFFR_X1
* cell instance $519 r0 *1 9.88,46.2
X$519 35 33 841 653 692 66 48 DFFR_X1
* cell instance $524 r0 *1 26.6,43.4
X$524 35 33 858 637 639 66 48 DFFR_X1
* cell instance $527 r0 *1 47.31,35
X$527 35 33 852 501 500 66 48 DFFR_X1
* cell instance $530 m0 *1 47.31,35
X$530 35 33 822 457 472 66 48 DFFR_X1
* cell instance $532 m0 *1 27.17,35
X$532 35 33 801 454 481 66 48 DFFR_X1
* cell instance $535 r0 *1 37.62,35
X$535 35 33 867 502 503 66 48 DFFR_X1
* cell instance $538 r0 *1 38,37.8
X$538 35 33 884 569 547 66 48 DFFR_X1
* cell instance $540 r0 *1 34.2,4.2
X$540 35 33 859 42 64 66 48 DFFR_X1
* cell instance $543 r0 *1 30.59,15.4
X$543 35 33 902 223 205 66 48 DFFR_X1
* cell instance $546 r0 *1 38.38,23.8
X$546 35 33 889 341 369 66 48 DFFR_X1
* cell instance $549 m0 *1 20.9,49
X$549 35 33 765 659 658 66 48 DFFR_X1
* cell instance $551 m0 *1 40.47,29.4
X$551 35 33 819 395 405 66 48 DFFR_X1
* cell instance $554 m0 *1 40.28,32.2
X$554 35 33 828 432 438 66 48 DFFR_X1
* cell instance $558 m0 *1 32.87,18.2
X$558 35 33 791 239 223 66 48 DFFR_X1
* cell instance $561 m0 *1 18.05,46.2
X$561 35 33 763 627 650 66 48 DFFR_X1
* cell instance $564 r0 *1 47.31,29.4
X$564 35 33 837 422 427 66 48 DFFR_X1
* cell instance $566 r0 *1 27.55,46.2
X$566 35 33 860 664 679 66 48 DFFR_X1
* cell instance $568 m0 *1 47.31,26.6
X$568 35 33 797 385 376 66 48 DFFR_X1
* cell instance $570 m0 *1 24.13,21
X$570 35 33 816 306 299 66 48 DFFR_X1
* cell instance $573 r0 *1 22.04,37.8
X$573 35 33 844 539 526 66 48 DFFR_X1
* cell instance $576 m0 *1 2.47,7
X$576 35 33 757 54 85 66 48 DFFR_X1
* cell instance $579 r0 *1 46.74,23.8
X$579 35 33 879 364 389 66 48 DFFR_X1
* cell instance $581 r0 *1 9.88,23.8
X$581 35 33 891 337 336 66 48 DFFR_X1
* cell instance $584 m0 *1 47.5,21
X$584 35 33 792 254 288 66 48 DFFR_X1
* cell instance $586 r0 *1 47.31,21
X$586 35 33 885 255 311 66 48 DFFR_X1
* cell instance $589 m0 *1 2.47,18.2
X$589 35 33 836 222 229 66 48 DFFR_X1
* cell instance $591 r0 *1 25.27,32.2
X$591 35 33 897 453 475 66 48 DFFR_X1
* cell instance $593 m0 *1 17.86,26.6
X$593 35 33 800 381 380 66 48 DFFR_X1
* cell instance $595 m0 *1 12.16,7
X$595 35 33 829 56 67 66 48 DFFR_X1
* cell instance $597 m0 *1 22.99,23.8
X$597 35 33 805 314 356 66 48 DFFR_X1
* cell instance $601 r0 *1 4.18,23.8
X$601 35 33 900 321 351 66 48 DFFR_X1
* cell instance $604 r0 *1 18.24,12.6
X$604 35 33 894 169 168 66 48 DFFR_X1
* cell instance $606 r0 *1 18.24,37.8
X$606 35 33 846 560 528 66 48 DFFR_X1
* cell instance $609 r0 *1 2.28,21
X$609 35 33 842 265 319 66 48 DFFR_X1
* cell instance $611 m0 *1 15.01,35
X$611 35 33 832 452 451 66 48 DFFR_X1
* cell instance $614 r0 *1 13.49,37.8
X$614 35 33 848 592 537 66 48 DFFR_X1
* cell instance $617 m0 *1 10.07,21
X$617 35 33 835 275 292 66 48 DFFR_X1
* cell instance $620 m0 *1 4.56,35
X$620 35 33 761 460 491 66 48 DFFR_X1
* cell instance $622 r0 *1 3.23,35
X$622 35 33 875 496 478 66 48 DFFR_X1
* cell instance $625 r0 *1 12.16,12.6
X$625 35 33 887 199 167 66 48 DFFR_X1
* cell instance $627 m0 *1 3.99,32.2
X$627 35 33 760 428 436 66 48 DFFR_X1
* cell instance $629 m0 *1 22.42,18.2
X$629 35 33 778 147 259 66 48 DFFR_X1
* cell instance $632 m0 *1 16.34,15.4
X$632 35 33 199 66 755 214 48 DFFR_X2
* cell instance $634 m0 *1 2.85,12.6
X$634 35 33 768 157 160 66 48 DFFR_X1
* cell instance $637 r0 *1 18.24,15.4
X$637 35 33 881 204 214 66 48 DFFR_X1
* cell instance $640 r0 *1 16.53,18.2
X$640 35 33 257 66 258 242 48 DFFR_X2
* cell instance $642 r0 *1 12.35,7
X$642 35 33 116 122 98 66 48 DFFR_X1
* cell instance $645 m0 *1 3.8,15.4
X$645 35 33 771 193 198 66 48 DFFR_X1
* cell instance $647 r0 *1 2.47,7
X$647 35 33 840 121 115 66 48 DFFR_X1
* cell instance $649 m0 *1 2.47,29.4
X$649 35 33 823 384 401 66 48 DFFR_X1
* cell instance $719 m0 *1 45.22,7
X$719 93 78 47 35 48 34 MUX2_X1
* cell instance $723 m0 *1 11.97,49
X$723 693 512 655 445 673 35 48 692 AOI221_X1
* cell instance $724 m0 *1 11.59,49
X$724 653 35 48 693 INV_X1
* cell instance $725 m0 *1 13.11,49
X$725 434 654 35 48 642 NOR2_X1
* cell instance $726 m0 *1 13.68,49
X$726 434 656 35 48 655 NOR2_X1
* cell instance $727 m0 *1 14.25,49
X$727 694 35 48 673 INV_X1
* cell instance $728 m0 *1 14.63,49
X$728 653 559 695 35 48 657 MUX2_X1
* cell instance $729 m0 *1 15.96,49
X$729 626 559 698 35 48 675 MUX2_X1
* cell instance $731 m0 *1 18.05,49
X$731 558 35 48 727 BUF_X1
* cell instance $733 m0 *1 18.81,49
X$733 465 682 35 48 677 NOR2_X1
* cell instance $734 m0 *1 19.38,49
X$734 700 35 48 579 BUF_X1
* cell instance $735 m0 *1 19.95,49
X$735 479 35 48 729 BUF_X1
* cell instance $751 r0 *1 12.92,49
X$751 732 35 48 654 BUF_X1
* cell instance $752 r0 *1 13.49,49
X$752 733 35 48 656 BUF_X1
* cell instance $753 r0 *1 14.06,49
X$753 734 35 48 643 BUF_X1
* cell instance $754 r0 *1 14.63,49
X$754 735 35 48 694 BUF_X1
* cell instance $755 r0 *1 15.2,49
X$755 599 35 48 696 BUF_X1
* cell instance $757 r0 *1 16.15,49
X$757 695 35 48 736 BUF_X1
* cell instance $758 r0 *1 16.72,49
X$758 698 35 48 697 BUF_X1
* cell instance $759 r0 *1 17.29,49
X$759 737 35 48 600 BUF_X1
* cell instance $760 r0 *1 17.86,49
X$760 738 35 48 601 BUF_X1
* cell instance $763 r0 *1 19,49
X$763 739 35 48 682 BUF_X1
* cell instance $764 r0 *1 19.57,49
X$764 701 35 48 644 INV_X1
* cell instance $766 r0 *1 20.14,49
X$766 740 35 48 701 BUF_X1
* cell instance $767 r0 *1 20.71,49
X$767 741 35 48 616 BUF_X1
* cell instance $768 m0 *1 24.7,49
X$768 659 559 660 35 48 681 MUX2_X1
* cell instance $769 m0 *1 26.03,49
X$769 731 35 48 680 BUF_X1
* cell instance $771 m0 *1 26.79,49
X$771 730 35 48 545 BUF_X1
* cell instance $772 m0 *1 27.36,49
X$772 661 512 705 446 710 35 48 679 AOI221_X1
* cell instance $773 m0 *1 28.5,49
X$773 663 35 48 662 BUF_X1
* cell instance $775 r0 *1 21.28,49
X$775 465 684 35 48 683 NOR2_X1
* cell instance $776 r0 *1 21.85,49
X$776 742 35 48 684 BUF_X1
* cell instance $777 r0 *1 22.42,49
X$777 743 35 48 685 BUF_X1
* cell instance $778 r0 *1 22.99,49
X$778 543 35 48 704 BUF_X1
* cell instance $779 r0 *1 23.56,49
X$779 744 35 48 686 BUF_X1
* cell instance $780 r0 *1 24.13,49
X$780 745 35 48 527 BUF_X1
* cell instance $781 r0 *1 24.7,49
X$781 746 35 48 525 BUF_X1
* cell instance $782 r0 *1 25.27,49
X$782 747 35 48 640 BUF_X1
* cell instance $783 r0 *1 25.84,49
X$783 748 35 48 505 BUF_X1
* cell instance $785 r0 *1 27.17,49
X$785 602 35 48 706 BUF_X1
* cell instance $786 r0 *1 27.74,49
X$786 660 35 48 728 BUF_X1
* cell instance $788 r0 *1 28.5,49
X$788 749 35 48 707 BUF_X1
* cell instance $789 r0 *1 29.07,49
X$789 707 35 48 710 INV_X1
* cell instance $791 m0 *1 29.45,49
X$791 750 35 48 506 BUF_X1
* cell instance $792 m0 *1 33.82,49
X$792 666 35 48 504 BUF_X1
* cell instance $794 m0 *1 34.58,49
X$794 687 513 667 35 48 676 MUX2_X1
* cell instance $796 m0 *1 36.1,49
X$796 667 484 720 35 48 649 MUX2_X1
* cell instance $798 m0 *1 37.62,49
X$798 718 513 668 35 48 674 MUX2_X1
* cell instance $800 m0 *1 39.14,49
X$800 668 484 689 35 48 648 MUX2_X1
* cell instance $801 m0 *1 40.47,49
X$801 688 513 670 35 48 669 MUX2_X1
* cell instance $806 r0 *1 29.83,49
X$806 751 35 48 630 BUF_X1
* cell instance $809 r0 *1 30.97,49
X$809 664 559 665 35 48 711 MUX2_X1
* cell instance $810 r0 *1 32.3,49
X$810 591 35 48 712 BUF_X1
* cell instance $811 r0 *1 32.87,49
X$811 529 35 48 714 BUF_X1
* cell instance $812 r0 *1 33.44,49
X$812 665 35 48 723 BUF_X1
* cell instance $813 r0 *1 34.01,49
X$813 465 713 35 48 705 NOR2_X1
* cell instance $814 r0 *1 34.58,49
X$814 715 35 48 687 BUF_X1
* cell instance $815 r0 *1 35.15,49
X$815 752 35 48 562 BUF_X1
* cell instance $816 r0 *1 35.72,49
X$816 717 35 48 713 BUF_X1
* cell instance $817 r0 *1 36.29,49
X$817 631 35 48 726 BUF_X1
* cell instance $818 r0 *1 36.86,49
X$818 719 35 48 581 BUF_X1
* cell instance $819 r0 *1 37.43,49
X$819 753 35 48 718 BUF_X1
* cell instance $820 r0 *1 38,49
X$820 720 35 48 721 BUF_X1
* cell instance $821 r0 *1 38.57,49
X$821 569 35 48 725 BUF_X1
* cell instance $823 r0 *1 39.52,49
X$823 583 35 48 716 BUF_X1
* cell instance $824 r0 *1 40.09,49
X$824 722 35 48 688 BUF_X1
* cell instance $825 r0 *1 40.66,49
X$825 689 35 48 724 BUF_X1
* cell instance $828 r0 *1 43.51,49
X$828 703 35 48 708 BUF_X1
* cell instance $829 r0 *1 44.08,49
X$829 709 35 48 690 BUF_X1
* cell instance $830 r0 *1 44.65,49
X$830 690 513 691 35 48 699 MUX2_X1
* cell instance $833 r0 *1 46.55,49
X$833 672 35 48 702 BUF_X1
* cell instance $834 r0 *1 47.12,49
X$834 691 484 672 35 48 646 MUX2_X1
* cell instance $840 m0 *1 1.33,40.6
X$840 434 564 35 48 565 NOR2_X1
* cell instance $842 m0 *1 1.9,40.6
X$842 541 35 48 566 BUF_X1
* cell instance $843 m0 *1 2.47,40.6
X$843 566 35 48 554 INV_X1
* cell instance $845 m0 *1 5.89,40.6
X$845 557 35 48 542 BUF_X1
* cell instance $847 m0 *1 6.65,40.6
X$847 556 372 557 35 48 568 MUX2_X1
* cell instance $852 r0 *1 1.52,40.6
X$852 588 335 565 445 554 35 48 555 AOI221_X1
* cell instance $856 r0 *1 6.46,40.6
X$856 556 35 48 588 INV_X1
* cell instance $861 r0 *1 15.96,40.6
X$861 592 35 48 576 INV_X1
* cell instance $864 r0 *1 17.48,40.6
X$864 592 559 558 35 48 571 MUX2_X1
* cell instance $866 r0 *1 19,40.6
X$866 596 512 595 446 578 35 48 528 AOI221_X1
* cell instance $871 r0 *1 20.33,40.6
X$871 560 35 48 596 INV_X1
* cell instance $873 r0 *1 20.9,40.6
X$873 560 559 543 35 48 572 MUX2_X1
* cell instance $876 m0 *1 26.03,40.6
X$876 465 680 35 48 544 NOR2_X1
* cell instance $877 m0 *1 27.17,40.6
X$877 545 35 48 546 INV_X1
* cell instance $881 r0 *1 27.55,40.6
X$881 593 35 48 594 INV_X1
* cell instance $883 r0 *1 28.69,40.6
X$883 593 559 591 35 48 561 MUX2_X1
* cell instance $886 m0 *1 38,40.6
X$886 563 484 569 35 48 547 MUX2_X1
* cell instance $889 r0 *1 34.58,40.6
X$889 562 513 563 35 48 570 MUX2_X1
* cell instance $893 m0 *1 46.74,40.6
X$893 531 35 48 584 BUF_X1
* cell instance $896 r0 *1 46.17,40.6
X$896 584 513 548 35 48 567 MUX2_X1
* cell instance $898 m0 *1 1.33,32.2
X$898 434 419 35 48 393 NOR2_X1
* cell instance $900 m0 *1 1.9,32.2
X$900 440 35 48 426 INV_X1
* cell instance $901 m0 *1 2.28,32.2
X$901 434 441 35 48 420 NOR2_X1
* cell instance $902 m0 *1 2.85,32.2
X$902 435 335 420 445 426 35 48 436 AOI221_X1
* cell instance $903 m0 *1 7.79,32.2
X$903 428 35 48 435 INV_X1
* cell instance $907 m0 *1 15.2,32.2
X$907 362 415 35 48 442 NOR2_X1
* cell instance $908 m0 *1 15.77,32.2
X$908 302 48 445 35 BUF_X4
* cell instance $909 m0 *1 17.1,32.2
X$909 302 48 446 35 BUF_X4
* cell instance $917 r0 *1 1.33,32.2
X$917 416 35 48 440 BUF_X1
* cell instance $918 r0 *1 1.9,32.2
X$918 418 35 48 441 BUF_X1
* cell instance $919 r0 *1 2.47,32.2
X$919 439 35 48 459 BUF_X1
* cell instance $923 r0 *1 3.04,32.2
X$923 449 35 48 448 BUF_X1
* cell instance $925 r0 *1 3.99,32.2
X$925 459 35 48 468 INV_X1
* cell instance $928 r0 *1 6.27,32.2
X$928 460 35 48 474 INV_X1
* cell instance $930 r0 *1 7.41,32.2
X$930 431 35 48 462 BUF_X1
* cell instance $931 r0 *1 7.98,32.2
X$931 460 372 449 35 48 450 MUX2_X1
* cell instance $934 r0 *1 13.68,32.2
X$934 462 35 48 463 INV_X1
* cell instance $936 r0 *1 14.44,32.2
X$936 362 35 48 434 CLKBUF_X3
* cell instance $937 r0 *1 15.39,32.2
X$937 447 324 442 446 463 35 48 451 AOI221_X1
* cell instance $940 r0 *1 17.1,32.2
X$940 452 35 48 447 INV_X1
* cell instance $941 r0 *1 17.48,32.2
X$941 362 35 48 465 CLKBUF_X3
* cell instance $944 r0 *1 24.89,32.2
X$944 453 35 48 493 INV_X1
* cell instance $947 r0 *1 30.78,32.2
X$947 454 210 443 35 48 455 MUX2_X1
* cell instance $951 r0 *1 37.24,32.2
X$951 231 35 48 484 CLKBUF_X3
* cell instance $954 r0 *1 39.14,32.2
X$954 162 35 48 344 CLKBUF_X3
* cell instance $955 m0 *1 39.33,32.2
X$955 231 35 48 308 CLKBUF_X3
* cell instance $956 m0 *1 47.88,32.2
X$956 421 308 422 35 48 427 MUX2_X1
* cell instance $957 m0 *1 49.21,32.2
X$957 432 35 48 424 BUF_X1
* cell instance $958 m0 *1 49.78,32.2
X$958 444 35 48 425 BUF_X1
* cell instance $961 r0 *1 40.47,32.2
X$961 413 308 432 35 48 438 MUX2_X1
* cell instance $963 r0 *1 45.98,32.2
X$963 461 344 456 35 48 464 MUX2_X1
* cell instance $964 r0 *1 47.31,32.2
X$964 456 308 457 35 48 472 MUX2_X1
* cell instance $965 r0 *1 48.64,32.2
X$965 433 35 48 461 BUF_X1
* cell instance $968 r0 *1 50.16,32.2
X$968 443 35 48 396 BUF_X1
* cell instance $970 m0 *1 50.73,32.2
X$970 422 35 48 423 BUF_X1
* cell instance $971 r0 *1 50.73,32.2
X$971 457 35 48 458 BUF_X1
* cell instance $973 m0 *1 1.9,7
X$973 55 106 35 48 84 NOR2_X1
* cell instance $977 m0 *1 8.55,7
X$977 55 62 35 48 86 NOR2_X1
* cell instance $978 m0 *1 9.12,7
X$978 92 83 86 68 91 35 48 90 AOI221_X1
* cell instance $983 m0 *1 28.88,7
X$983 70 94 35 48 99 NAND2_X1
* cell instance $988 r0 *1 1.33,7
X$988 109 35 48 105 BUF_X1
* cell instance $989 r0 *1 1.9,7
X$989 110 35 48 106 BUF_X1
* cell instance $1000 r0 *1 28.12,7
X$1000 99 100 35 48 108 NAND2_X1
* cell instance $1001 r0 *1 28.69,7
X$1001 107 111 99 100 35 48 40 NAND4_X1
* cell instance $1002 r0 *1 29.64,7
X$1002 117 35 48 118 INV_X1
* cell instance $1003 m0 *1 29.83,7
X$1003 94 35 48 95 INV_X1
* cell instance $1004 m0 *1 30.21,7
X$1004 95 70 87 48 82 35 OAI21_X1
* cell instance $1006 m0 *1 31.73,7
X$1006 71 35 48 103 BUF_X2
* cell instance $1010 r0 *1 30.02,7
X$1010 119 101 103 48 87 35 OAI21_X1
* cell instance $1011 r0 *1 30.78,7
X$1011 72 117 35 48 101 NOR2_X1
* cell instance $1012 r0 *1 31.35,7
X$1012 117 102 35 48 107 NAND2_X1
* cell instance $1022 m0 *1 46.55,7
X$1022 35 88 66 48 BUF_X16
* cell instance $1025 r0 *1 46.93,7
X$1025 104 78 113 35 48 112 MUX2_X1
* cell instance $1028 r0 *1 50.16,7
X$1028 47 35 48 89 BUF_X1
* cell instance $1029 r0 *1 50.73,7
X$1029 113 35 48 114 BUF_X1
* cell instance $1032 m0 *1 1.71,12.6
X$1032 178 83 174 68 166 35 48 160 AOI221_X1
* cell instance $1033 m0 *1 6.65,12.6
X$1033 157 35 48 178 INV_X1
* cell instance $1041 r0 *1 1.33,12.6
X$1041 164 35 48 153 BUF_X1
* cell instance $1042 r0 *1 1.9,12.6
X$1042 165 35 48 186 BUF_X1
* cell instance $1044 r0 *1 2.66,12.6
X$1044 186 35 48 166 INV_X1
* cell instance $1050 r0 *1 4.75,12.6
X$1050 154 35 48 181 BUF_X1
* cell instance $1053 r0 *1 10.83,12.6
X$1053 190 51 167 35 48 189 MUX2_X1
* cell instance $1059 m0 *1 28.12,12.6
X$1059 170 100 117 35 48 171 MUX2_X1
* cell instance $1060 m0 *1 29.45,12.6
X$1060 148 117 103 35 48 111 NAND3_X1
* cell instance $1061 m0 *1 30.21,12.6
X$1061 148 158 35 48 100 NAND2_X1
* cell instance $1062 m0 *1 30.78,12.6
X$1062 158 103 117 35 48 172 MUX2_X1
* cell instance $1071 r0 *1 31.73,12.6
X$1071 172 148 35 210 48 NAND2_X4
* cell instance $1072 r0 *1 33.44,12.6
X$1072 158 35 48 150 INV_X1
* cell instance $1080 m0 *1 46.74,12.6
X$1080 151 78 159 35 48 152 MUX2_X1
* cell instance $1082 m0 *1 49.02,12.6
X$1082 173 35 48 177 BUF_X1
* cell instance $1084 r0 *1 46.93,12.6
X$1084 191 78 185 35 48 184 MUX2_X1
* cell instance $1087 r0 *1 49.21,12.6
X$1087 188 35 48 176 BUF_X1
* cell instance $1089 m0 *1 50.16,12.6
X$1089 159 35 48 175 BUF_X1
* cell instance $1091 m0 *1 50.73,12.6
X$1091 74 35 48 141 BUF_X1
* cell instance $1093 r0 *1 50.16,12.6
X$1093 197 35 48 235 BUF_X1
* cell instance $1094 r0 *1 50.73,12.6
X$1094 185 35 48 187 BUF_X1
* cell instance $1098 m0 *1 1.52,18.2
X$1098 225 35 48 227 BUF_X1
* cell instance $1099 m0 *1 2.09,18.2
X$1099 227 35 48 228 INV_X1
* cell instance $1104 m0 *1 19.57,18.2
X$1104 204 214 35 48 269 XNOR2_X2
* cell instance $1107 m0 *1 26.22,18.2
X$1107 147 35 48 230 INV_X1
* cell instance $1115 r0 *1 1.71,18.2
X$1115 226 35 48 202 BUF_X1
* cell instance $1118 r0 *1 2.85,18.2
X$1118 241 83 212 68 228 35 48 229 AOI221_X1
* cell instance $1125 r0 *1 5.32,18.2
X$1125 213 35 48 240 BUF_X1
* cell instance $1128 r0 *1 7.03,18.2
X$1128 247 35 48 246 BUF_X1
* cell instance $1131 r0 *1 11.02,18.2
X$1131 275 51 247 35 48 256 MUX2_X1
* cell instance $1133 r0 *1 20.71,18.2
X$1133 258 35 48 248 BUF_X2
* cell instance $1136 r0 *1 23.37,18.2
X$1136 249 242 215 35 48 261 MUX2_X1
* cell instance $1137 r0 *1 24.7,18.2
X$1137 270 245 230 250 48 35 259 OAI22_X1
* cell instance $1138 r0 *1 25.65,18.2
X$1138 230 261 250 35 48 245 MUX2_X1
* cell instance $1139 r0 *1 26.98,18.2
X$1139 239 35 48 249 BUF_X1
* cell instance $1145 m0 *1 39.52,18.2
X$1145 231 35 48 78 CLKBUF_X3
* cell instance $1150 r0 *1 39.71,18.2
X$1150 277 231 243 35 48 251 MUX2_X1
* cell instance $1153 r0 *1 45.41,18.2
X$1153 244 35 48 252 BUF_X1
* cell instance $1157 m0 *1 46.93,18.2
X$1157 237 78 216 35 48 233 MUX2_X1
* cell instance $1158 m0 *1 49.02,18.2
X$1158 218 35 48 220 BUF_X1
* cell instance $1159 m0 *1 49.59,18.2
X$1159 232 35 48 234 BUF_X1
* cell instance $1161 r0 *1 46.93,18.2
X$1161 253 308 254 35 48 288 MUX2_X1
* cell instance $1163 r0 *1 48.45,18.2
X$1163 326 35 48 287 BUF_X1
* cell instance $1166 r0 *1 49.59,18.2
X$1166 243 35 48 273 BUF_X1
* cell instance $1167 r0 *1 50.16,18.2
X$1167 271 35 48 272 BUF_X1
* cell instance $1168 m0 *1 50.73,18.2
X$1168 216 35 48 217 BUF_X1
* cell instance $1171 r0 *1 50.73,18.2
X$1171 255 35 48 274 BUF_X1
* cell instance $1173 m0 *1 6.08,46.2
X$1173 621 372 622 35 48 623 MUX2_X1
* cell instance $1176 m0 *1 1.33,46.2
X$1176 622 35 48 617 BUF_X1
* cell instance $1185 m0 *1 13.11,46.2
X$1185 647 512 642 445 625 35 48 624 AOI221_X1
* cell instance $1186 m0 *1 21.85,46.2
X$1186 627 35 48 652 INV_X1
* cell instance $1190 r0 *1 13.68,46.2
X$1190 626 35 48 647 INV_X1
* cell instance $1191 r0 *1 14.06,46.2
X$1191 643 35 48 625 INV_X1
* cell instance $1194 r0 *1 18.81,46.2
X$1194 652 512 677 446 644 35 48 650 AOI221_X1
* cell instance $1197 r0 *1 20.9,46.2
X$1197 678 512 683 446 645 35 48 658 AOI221_X1
* cell instance $1199 r0 *1 22.42,46.2
X$1199 685 35 48 645 INV_X1
* cell instance $1201 r0 *1 22.99,46.2
X$1201 659 35 48 678 INV_X1
* cell instance $1203 m0 *1 28.5,46.2
X$1203 662 35 48 629 INV_X1
* cell instance $1204 m0 *1 27.36,46.2
X$1204 638 512 651 446 629 35 48 639 AOI221_X1
* cell instance $1206 m0 *1 29.07,46.2
X$1206 465 630 35 48 651 NOR2_X1
* cell instance $1210 r0 *1 31.35,46.2
X$1210 664 35 48 661 INV_X1
* cell instance $1218 r0 *1 44.46,46.2
X$1218 670 484 703 35 48 671 MUX2_X1
* cell instance $1224 m0 *1 1.33,43.4
X$1224 573 35 48 564 BUF_X1
* cell instance $1226 m0 *1 1.9,43.4
X$1226 552 35 48 608 BUF_X1
* cell instance $1227 m0 *1 2.47,43.4
X$1227 608 35 48 613 INV_X1
* cell instance $1228 m0 *1 2.85,43.4
X$1228 553 35 48 587 BUF_X1
* cell instance $1229 m0 *1 3.42,43.4
X$1229 434 587 35 48 611 NOR2_X1
* cell instance $1230 m0 *1 3.99,43.4
X$1230 589 335 611 445 613 35 48 614 AOI221_X1
* cell instance $1231 m0 *1 8.93,43.4
X$1231 574 35 48 589 INV_X1
* cell instance $1232 m0 *1 9.31,43.4
X$1232 574 372 599 35 48 575 MUX2_X1
* cell instance $1236 r0 *1 1.33,43.4
X$1236 597 35 48 632 BUF_X1
* cell instance $1237 r0 *1 1.9,43.4
X$1237 598 35 48 618 BUF_X1
* cell instance $1238 r0 *1 2.47,43.4
X$1238 434 632 35 48 610 NOR2_X1
* cell instance $1242 r0 *1 3.04,43.4
X$1242 618 35 48 633 INV_X1
* cell instance $1243 r0 *1 3.42,43.4
X$1243 619 335 610 445 633 35 48 620 AOI221_X1
* cell instance $1245 r0 *1 4.75,43.4
X$1245 621 35 48 619 INV_X1
* cell instance $1249 m0 *1 16.34,43.4
X$1249 576 512 615 445 577 35 48 537 AOI221_X1
* cell instance $1251 m0 *1 19.19,43.4
X$1251 465 579 35 48 595 NOR2_X1
* cell instance $1254 r0 *1 17.29,43.4
X$1254 600 35 48 577 INV_X1
* cell instance $1256 r0 *1 17.86,43.4
X$1256 465 601 35 48 615 NOR2_X1
* cell instance $1259 m0 *1 20.14,43.4
X$1259 616 35 48 578 INV_X1
* cell instance $1262 r0 *1 22.23,43.4
X$1262 627 559 602 35 48 628 MUX2_X1
* cell instance $1264 r0 *1 23.75,43.4
X$1264 465 686 35 48 603 NOR2_X1
* cell instance $1266 m0 *1 23.94,43.4
X$1266 594 512 603 446 604 35 48 580 AOI221_X1
* cell instance $1272 r0 *1 25.08,43.4
X$1272 640 35 48 604 INV_X1
* cell instance $1275 r0 *1 30.4,43.4
X$1275 637 35 48 638 INV_X1
* cell instance $1278 r0 *1 31.35,43.4
X$1278 637 559 631 35 48 636 MUX2_X1
* cell instance $1282 m0 *1 36.86,43.4
X$1282 581 513 582 35 48 590 MUX2_X1
* cell instance $1283 m0 *1 38.95,43.4
X$1283 582 484 583 35 48 612 MUX2_X1
* cell instance $1288 r0 *1 45.79,43.4
X$1288 609 513 605 35 48 635 MUX2_X1
* cell instance $1289 m0 *1 46.17,43.4
X$1289 585 35 48 609 BUF_X1
* cell instance $1296 r0 *1 48.64,43.4
X$1296 605 484 606 35 48 634 MUX2_X1
* cell instance $1298 r0 *1 50.73,43.4
X$1298 606 35 48 607 BUF_X1
* cell instance $1300 m0 *1 1.33,23.8
X$1300 318 35 48 329 BUF_X1
* cell instance $1302 m0 *1 1.9,23.8
X$1302 347 335 333 68 320 35 48 319 AOI221_X1
* cell instance $1303 m0 *1 3.04,23.8
X$1303 321 35 48 334 INV_X1
* cell instance $1305 m0 *1 3.61,23.8
X$1305 265 35 48 347 INV_X1
* cell instance $1306 m0 *1 3.99,23.8
X$1306 332 35 48 322 BUF_X1
* cell instance $1310 r0 *1 1.33,23.8
X$1310 367 35 48 349 INV_X1
* cell instance $1311 r0 *1 1.71,23.8
X$1311 358 35 48 367 BUF_X1
* cell instance $1312 r0 *1 2.28,23.8
X$1312 331 35 48 370 BUF_X1
* cell instance $1313 r0 *1 2.85,23.8
X$1313 334 335 368 68 349 35 48 351 AOI221_X1
* cell instance $1318 m0 *1 5.89,23.8
X$1318 322 35 48 323 INV_X1
* cell instance $1320 m0 *1 6.27,23.8
X$1320 329 281 279 35 48 352 NOR3_X1
* cell instance $1322 m0 *1 7.22,23.8
X$1322 352 281 323 35 353 48 AOI21_X1
* cell instance $1326 m0 *1 9.12,23.8
X$1326 353 83 337 35 48 336 MUX2_X1
* cell instance $1327 m0 *1 10.45,23.8
X$1327 35 83 48 324 BUF_X8
* cell instance $1331 m0 *1 17.67,23.8
X$1331 304 35 48 338 INV_X1
* cell instance $1334 m0 *1 19.76,23.8
X$1334 268 304 35 48 355 NAND2_X1
* cell instance $1335 m0 *1 20.33,23.8
X$1335 281 304 35 48 325 NOR2_X1
* cell instance $1336 m0 *1 20.9,23.8
X$1336 325 248 281 35 339 48 AOI21_X2
* cell instance $1340 m0 *1 35.91,23.8
X$1340 342 162 340 35 48 330 MUX2_X1
* cell instance $1343 m0 *1 41.99,23.8
X$1343 354 344 343 35 48 328 MUX2_X1
* cell instance $1347 r0 *1 14.44,23.8
X$1347 362 35 48 55 CLKBUF_X3
* cell instance $1349 r0 *1 16.91,23.8
X$1349 338 281 268 35 48 362 OR3_X2
* cell instance $1350 r0 *1 18.05,23.8
X$1350 338 268 283 48 380 35 OAI21_X1
* cell instance $1352 r0 *1 19.57,23.8
X$1352 281 305 355 48 35 302 AND3_X2
* cell instance $1353 r0 *1 20.71,23.8
X$1353 283 355 339 35 324 48 NAND3_X4
* cell instance $1357 r0 *1 36.48,23.8
X$1357 340 231 341 35 48 369 MUX2_X1
* cell instance $1361 m0 *1 43.89,23.8
X$1361 345 35 48 354 BUF_X1
* cell instance $1364 m0 *1 45.03,23.8
X$1364 252 344 253 35 48 291 MUX2_X1
* cell instance $1366 m0 *1 46.36,23.8
X$1366 287 344 350 35 48 327 MUX2_X1
* cell instance $1367 m0 *1 47.69,23.8
X$1367 350 308 255 35 48 311 MUX2_X1
* cell instance $1368 m0 *1 49.02,23.8
X$1368 348 35 48 363 BUF_X1
* cell instance $1372 r0 *1 46.17,23.8
X$1372 341 35 48 346 BUF_X1
* cell instance $1373 m0 *1 50.16,23.8
X$1373 366 35 48 342 BUF_X1
* cell instance $1375 m0 *1 50.73,23.8
X$1375 254 35 48 285 BUF_X1
* cell instance $1378 r0 *1 50.73,23.8
X$1378 364 35 48 365 BUF_X1
* cell instance $1380 m0 *1 1.33,37.8
X$1380 477 35 48 520 BUF_X1
* cell instance $1382 m0 *1 1.9,37.8
X$1382 520 35 48 514 INV_X1
* cell instance $1383 m0 *1 2.28,37.8
X$1383 507 35 48 532 BUF_X1
* cell instance $1384 m0 *1 2.85,37.8
X$1384 510 35 48 508 BUF_X1
* cell instance $1385 m0 *1 3.42,37.8
X$1385 497 35 48 476 BUF_X1
* cell instance $1386 m0 *1 7.79,37.8
X$1386 521 35 48 522 INV_X1
* cell instance $1391 r0 *1 2.28,37.8
X$1391 516 35 48 534 BUF_X1
* cell instance $1392 r0 *1 2.85,37.8
X$1392 434 532 35 48 551 NOR2_X1
* cell instance $1397 r0 *1 3.61,37.8
X$1397 534 35 48 536 INV_X1
* cell instance $1398 r0 *1 3.99,37.8
X$1398 522 335 551 445 536 35 48 509 AOI221_X1
* cell instance $1400 m0 *1 8.74,37.8
X$1400 521 372 510 35 48 523 MUX2_X1
* cell instance $1409 m0 *1 18.24,37.8
X$1409 210 48 559 35 BUF_X4
* cell instance $1414 m0 *1 24.7,37.8
X$1414 465 525 35 48 511 NOR2_X1
* cell instance $1416 m0 *1 25.27,37.8
X$1416 465 527 35 48 515 NOR2_X1
* cell instance $1422 m0 *1 48.83,37.8
X$1422 471 35 48 488 BUF_X1
* cell instance $1423 m0 *1 49.4,37.8
X$1423 518 35 48 517 BUF_X1
* cell instance $1425 m0 *1 50.16,37.8
X$1425 502 35 48 470 BUF_X1
* cell instance $1426 m0 *1 50.73,37.8
X$1426 501 35 48 485 BUF_X1
* cell instance $1428 r0 *1 25.84,37.8
X$1428 539 35 48 540 INV_X1
* cell instance $1429 r0 *1 26.22,37.8
X$1429 540 512 544 446 546 35 48 526 AOI221_X1
* cell instance $1431 r0 *1 28.12,37.8
X$1431 539 559 529 35 48 538 MUX2_X1
* cell instance $1438 r0 *1 45.98,37.8
X$1438 517 513 535 35 48 524 MUX2_X1
* cell instance $1439 r0 *1 47.31,37.8
X$1439 548 484 533 35 48 549 MUX2_X1
* cell instance $1440 r0 *1 48.64,37.8
X$1440 535 484 530 35 48 586 MUX2_X1
* cell instance $1442 r0 *1 50.16,37.8
X$1442 530 35 48 519 BUF_X1
* cell instance $1443 r0 *1 50.73,37.8
X$1443 533 35 48 550 BUF_X1
* cell instance $1445 m0 *1 6.27,29.4
X$1445 402 35 48 391 BUF_X1
* cell instance $1459 r0 *1 1.33,29.4
X$1459 392 35 48 419 BUF_X1
* cell instance $1467 r0 *1 4.75,29.4
X$1467 409 35 48 417 BUF_X1
* cell instance $1470 r0 *1 7.22,29.4
X$1470 408 35 48 415 BUF_X1
* cell instance $1472 r0 *1 7.98,29.4
X$1472 428 372 409 35 48 410 MUX2_X1
* cell instance $1477 r0 *1 29.07,29.4
X$1477 453 210 412 35 48 411 MUX2_X1
* cell instance $1481 r0 *1 40.09,29.4
X$1481 429 344 413 35 48 430 MUX2_X1
* cell instance $1484 m0 *1 44.84,29.4
X$1484 412 35 48 397 BUF_X1
* cell instance $1488 m0 *1 47.12,29.4
X$1488 403 344 406 35 48 407 MUX2_X1
* cell instance $1489 m0 *1 48.45,29.4
X$1489 395 35 48 399 BUF_X1
* cell instance $1492 r0 *1 45.41,29.4
X$1492 414 35 48 429 BUF_X1
* cell instance $1493 r0 *1 45.98,29.4
X$1493 425 344 421 35 48 437 MUX2_X1
* cell instance $1494 m0 *1 49.59,29.4
X$1494 386 35 48 403 BUF_X1
* cell instance $1497 m0 *1 50.73,29.4
X$1497 398 35 48 388 BUF_X1
* cell instance $1502 m0 *1 1.33,35
X$1502 466 35 48 467 BUF_X1
* cell instance $1504 m0 *1 1.9,35
X$1504 434 486 35 48 487 NOR2_X1
* cell instance $1505 m0 *1 2.47,35
X$1505 434 467 35 48 490 NOR2_X1
* cell instance $1506 m0 *1 3.04,35
X$1506 474 335 490 445 468 35 48 491 AOI221_X1
* cell instance $1509 r0 *1 1.33,35
X$1509 494 35 48 486 BUF_X1
* cell instance $1511 r0 *1 2.09,35
X$1511 495 335 487 445 514 35 48 478 AOI221_X1
* cell instance $1517 m0 *1 12.16,35
X$1517 210 48 372 35 BUF_X4
* cell instance $1519 m0 *1 18.81,35
X$1519 452 210 479 35 48 492 MUX2_X1
* cell instance $1523 r0 *1 7.03,35
X$1523 496 35 48 495 INV_X1
* cell instance $1526 r0 *1 7.98,35
X$1526 496 372 497 35 48 498 MUX2_X1
* cell instance $1533 r0 *1 23.56,35
X$1533 35 512 48 324 BUF_X8
* cell instance $1535 m0 *1 25.08,35
X$1535 493 324 511 446 469 35 48 475 AOI221_X1
* cell instance $1536 r0 *1 26.03,35
X$1536 505 35 48 469 INV_X1
* cell instance $1538 m0 *1 26.79,35
X$1538 454 35 48 480 INV_X1
* cell instance $1542 r0 *1 26.6,35
X$1542 480 324 515 446 482 35 48 481 AOI221_X1
* cell instance $1543 r0 *1 27.74,35
X$1543 506 35 48 482 INV_X1
* cell instance $1551 r0 *1 33.25,35
X$1551 504 513 499 35 48 483 MUX2_X1
* cell instance $1553 r0 *1 35.34,35
X$1553 162 35 48 513 CLKBUF_X3
* cell instance $1554 r0 *1 36.29,35
X$1554 499 484 502 35 48 503 MUX2_X1
* cell instance $1557 m0 *1 45.6,35
X$1557 488 344 489 35 48 473 MUX2_X1
* cell instance $1560 r0 *1 45.98,35
X$1560 489 308 501 35 48 500 MUX2_X1
* cell instance $1565 m0 *1 1.33,9.8
X$1565 133 35 48 125 BUF_X1
* cell instance $1568 m0 *1 2.09,9.8
X$1568 125 35 48 128 INV_X1
* cell instance $1570 m0 *1 2.66,9.8
X$1570 55 134 35 48 127 NOR2_X1
* cell instance $1571 m0 *1 3.23,9.8
X$1571 143 83 127 68 128 35 48 115 AOI221_X1
* cell instance $1573 m0 *1 4.56,9.8
X$1573 121 35 48 143 INV_X1
* cell instance $1575 m0 *1 5.13,9.8
X$1575 121 51 130 35 48 145 MUX2_X1
* cell instance $1582 r0 *1 1.9,9.8
X$1582 55 153 35 48 174 NOR2_X1
* cell instance $1583 r0 *1 2.47,9.8
X$1583 146 35 48 134 BUF_X1
* cell instance $1587 r0 *1 3.04,9.8
X$1587 130 35 48 156 BUF_X1
* cell instance $1592 r0 *1 6.46,9.8
X$1592 157 51 154 35 48 179 MUX2_X1
* cell instance $1594 m0 *1 12.92,9.8
X$1594 116 83 122 35 48 98 MUX2_X1
* cell instance $1595 m0 *1 25.65,9.8
X$1595 132 124 35 48 131 XOR2_X1
* cell instance $1597 m0 *1 28.31,9.8
X$1597 136 135 131 35 119 48 AOI21_X1
* cell instance $1598 m0 *1 29.07,9.8
X$1598 118 103 35 48 139 NAND2_X1
* cell instance $1599 m0 *1 29.64,9.8
X$1599 120 139 111 140 138 48 35 129 OAI221_X1
* cell instance $1600 m0 *1 30.78,9.8
X$1600 72 35 48 120 INV_X1
* cell instance $1611 r0 *1 27.74,9.8
X$1611 135 131 48 35 148 AND2_X1
* cell instance $1612 r0 *1 28.5,9.8
X$1612 136 35 48 137 INV_X1
* cell instance $1613 r0 *1 28.88,9.8
X$1613 70 137 135 118 35 48 138 AOI22_X1
* cell instance $1615 r0 *1 30.02,9.8
X$1615 135 117 70 35 48 155 MUX2_X1
* cell instance $1616 r0 *1 31.35,9.8
X$1616 102 72 103 35 149 48 AOI21_X1
* cell instance $1617 r0 *1 32.11,9.8
X$1617 140 155 150 148 48 35 180 OAI22_X1
* cell instance $1618 r0 *1 33.06,9.8
X$1618 72 136 103 35 48 162 NAND3_X2
* cell instance $1620 r0 *1 34.58,9.8
X$1620 102 35 48 140 INV_X1
* cell instance $1625 r0 *1 46.55,9.8
X$1625 142 35 48 144 BUF_X1
* cell instance $1628 m0 *1 1.33,26.6
X$1628 357 35 48 378 BUF_X1
* cell instance $1630 m0 *1 1.9,26.6
X$1630 55 378 35 48 333 NOR2_X1
* cell instance $1631 m0 *1 2.47,26.6
X$1631 55 370 35 48 368 NOR2_X1
* cell instance $1634 r0 *1 1.33,26.6
X$1634 390 35 48 400 BUF_X1
* cell instance $1635 r0 *1 1.9,26.6
X$1635 400 35 48 383 INV_X1
* cell instance $1636 r0 *1 2.28,26.6
X$1636 387 335 393 68 383 35 48 401 AOI221_X1
* cell instance $1642 m0 *1 3.42,26.6
X$1642 373 35 48 382 BUF_X1
* cell instance $1643 m0 *1 4.75,26.6
X$1643 371 35 48 359 BUF_X1
* cell instance $1646 r0 *1 4.56,26.6
X$1646 384 35 48 387 INV_X1
* cell instance $1648 m0 *1 5.89,26.6
X$1648 321 372 371 35 48 360 MUX2_X1
* cell instance $1650 m0 *1 11.02,26.6
X$1650 302 48 68 35 BUF_X4
* cell instance $1651 m0 *1 12.35,26.6
X$1651 337 372 373 35 48 361 MUX2_X1
* cell instance $1655 r0 *1 6.27,26.6
X$1655 384 372 402 35 48 394 MUX2_X1
* cell instance $1658 r0 *1 8.74,26.6
X$1658 35 335 48 324 BUF_X8
* cell instance $1661 m0 *1 21.66,26.6
X$1661 35 281 48 381 BUF_X8
* cell instance $1667 m0 *1 45.6,26.6
X$1667 363 344 375 35 48 379 MUX2_X1
* cell instance $1674 r0 *1 39.71,26.6
X$1674 388 344 374 35 48 404 MUX2_X1
* cell instance $1675 r0 *1 41.04,26.6
X$1675 374 308 395 35 48 405 MUX2_X1
* cell instance $1679 r0 *1 47.69,26.6
X$1679 375 308 364 35 48 389 MUX2_X1
* cell instance $1680 r0 *1 49.02,26.6
X$1680 406 308 385 35 48 376 MUX2_X1
* cell instance $1682 r0 *1 50.73,26.6
X$1682 385 35 48 377 BUF_X1
* cell instance $1684 m0 *1 1.33,21
X$1684 263 35 48 276 BUF_X1
* cell instance $1686 m0 *1 1.9,21
X$1686 262 35 48 279 BUF_X1
* cell instance $1687 m0 *1 2.47,21
X$1687 266 35 48 278 BUF_X1
* cell instance $1688 m0 *1 3.04,21
X$1688 264 35 48 289 BUF_X1
* cell instance $1691 m0 *1 4.56,21
X$1691 265 51 266 35 48 290 MUX2_X1
* cell instance $1694 r0 *1 1.33,21
X$1694 310 35 48 309 BUF_X1
* cell instance $1695 r0 *1 1.9,21
X$1695 309 35 48 320 INV_X1
* cell instance $1700 r0 *1 6.46,21
X$1700 289 35 48 313 INV_X1
* cell instance $1701 r0 *1 6.84,21
X$1701 300 35 48 312 BUF_X1
* cell instance $1704 r0 *1 9.12,21
X$1704 55 312 35 48 301 NOR2_X1
* cell instance $1705 r0 *1 9.69,21
X$1705 313 302 301 83 303 35 48 292 AOI221_X1
* cell instance $1706 m0 *1 13.87,21
X$1706 276 279 35 48 268 NOR2_X2
* cell instance $1707 m0 *1 14.82,21
X$1707 276 35 48 296 INV_X1
* cell instance $1709 r0 *1 10.83,21
X$1709 275 35 48 303 INV_X1
* cell instance $1711 m0 *1 15.96,21
X$1711 295 267 280 48 257 35 OAI21_X1
* cell instance $1712 m0 *1 15.58,21
X$1712 279 35 48 295 INV_X1
* cell instance $1713 m0 *1 16.72,21
X$1713 267 296 242 48 280 35 OAI21_X1
* cell instance $1715 m0 *1 18.24,21
X$1715 248 297 283 268 267 48 35 168 OAI221_X1
* cell instance $1716 m0 *1 19.38,21
X$1716 281 282 269 35 297 48 AOI21_X1
* cell instance $1718 m0 *1 20.33,21
X$1718 269 248 35 48 305 NOR2_X1
* cell instance $1719 m0 *1 20.9,21
X$1719 269 281 35 48 283 NAND2_X2
* cell instance $1720 m0 *1 21.85,21
X$1720 282 298 281 215 35 48 284 AOI22_X1
* cell instance $1721 m0 *1 22.8,21
X$1721 248 215 249 242 48 35 298 OAI22_X1
* cell instance $1722 m0 *1 23.75,21
X$1722 282 35 48 270 INV_X1
* cell instance $1726 r0 *1 16.53,21
X$1726 316 35 48 304 BUF_X2
* cell instance $1729 r0 *1 18.24,21
X$1729 317 35 48 315 INV_X1
* cell instance $1731 r0 *1 19,21
X$1731 304 268 306 282 305 317 48 35 AOI221_X2
* cell instance $1732 r0 *1 21.09,21
X$1732 306 304 35 48 250 OR2_X1
* cell instance $1734 r0 *1 22.04,21
X$1734 284 35 48 356 INV_X1
* cell instance $1735 r0 *1 22.42,21
X$1735 248 249 282 35 48 231 NAND3_X2
* cell instance $1736 r0 *1 23.75,21
X$1736 249 35 48 307 INV_X1
* cell instance $1737 r0 *1 24.13,21
X$1737 242 307 270 35 48 299 NOR3_X1
* cell instance $1738 r0 *1 24.89,21
X$1738 314 35 48 282 BUF_X2
* cell instance $1741 m0 *1 37.62,21
X$1741 293 162 277 35 48 260 MUX2_X1
* cell instance $1745 m0 *1 43.13,21
X$1745 286 35 48 293 BUF_X1
* cell instance $1748 r0 *1 41.04,21
X$1748 343 308 271 35 48 294 MUX2_X1
* cell instance $1753 m0 *1 1.33,15.4
X$1753 203 35 48 195 BUF_X1
* cell instance $1755 m0 *1 1.9,15.4
X$1755 193 35 48 196 INV_X1
* cell instance $1757 m0 *1 2.47,15.4
X$1757 196 83 201 68 208 35 48 198 AOI221_X1
* cell instance $1760 m0 *1 7.79,15.4
X$1760 193 51 203 35 48 194 MUX2_X1
* cell instance $1764 r0 *1 1.33,15.4
X$1764 211 35 48 219 BUF_X1
* cell instance $1767 r0 *1 2.47,15.4
X$1767 55 219 35 48 201 NOR2_X1
* cell instance $1771 r0 *1 3.04,15.4
X$1771 55 202 35 48 212 NOR2_X1
* cell instance $1772 r0 *1 3.61,15.4
X$1772 200 35 48 221 BUF_X1
* cell instance $1773 r0 *1 4.18,15.4
X$1773 221 35 48 208 INV_X1
* cell instance $1774 r0 *1 4.56,15.4
X$1774 222 35 48 241 INV_X1
* cell instance $1777 r0 *1 5.89,15.4
X$1777 222 51 213 35 48 236 MUX2_X1
* cell instance $1783 r0 *1 13.11,15.4
X$1783 210 48 51 35 BUF_X4
* cell instance $1790 r0 *1 22.04,15.4
X$1790 214 204 48 215 35 XOR2_X2
* cell instance $1793 m0 *1 30.02,15.4
X$1793 149 117 35 48 224 NOR2_X1
* cell instance $1794 m0 *1 31.16,15.4
X$1794 183 35 48 117 BUF_X2
* cell instance $1807 r0 *1 39.9,15.4
X$1807 206 78 232 35 48 238 MUX2_X1
* cell instance $1828 r0 *1 1.71,4.2
X$1828 105 35 48 75 INV_X1
* cell instance $1829 r0 *1 2.09,4.2
X$1829 53 83 84 68 75 35 48 85 AOI221_X1
* cell instance $1831 m0 *1 2.47,4.2
X$1831 54 35 48 53 INV_X1
* cell instance $1835 m0 *1 3.23,4.2
X$1835 54 51 61 35 48 60 MUX2_X1
* cell instance $1837 m0 *1 13.49,4.2
X$1837 55 63 35 48 39 NOR2_X1
* cell instance $1842 r0 *1 11.4,4.2
X$1842 80 35 48 91 INV_X1
* cell instance $1845 r0 *1 12.92,4.2
X$1845 81 83 39 68 69 35 48 67 AOI221_X1
* cell instance $1847 r0 *1 14.44,4.2
X$1847 56 35 48 81 INV_X1
* cell instance $1851 m0 *1 30.59,4.2
X$1851 65 41 35 48 70 NAND2_X1
* cell instance $1859 m0 *1 37.81,4.2
X$1859 58 78 42 35 48 64 MUX2_X1
* cell instance $1864 m0 *1 48.45,4.2
X$1864 46 78 74 35 48 59 MUX2_X1
* cell instance $1873 r0 *1 13.49,1.4
X$1873 36 35 48 69 INV_X1
.ENDS network_interface_cdc

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell DFFR_X2
* pin PWELL,VSS
* pin CK
* pin D
* pin RN
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFFR_X2 1 3 5 9 11 12 19
* net 1 PWELL,VSS
* net 3 CK
* net 5 D
* net 9 RN
* net 11 QN
* net 12 Q
* net 19 NWELL,VDD
* device instance $1 r0 *1 2.51,1.025 PMOS_VTL
M$1 23 4 8 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $2 r0 *1 2.7,1.025 PMOS_VTL
M$2 23 10 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $3 r0 *1 1.875,1.0125 PMOS_VTL
M$3 19 6 7 19 PMOS_VTL L=0.05U W=0.315U AS=0.04725P AD=0.0322875P PS=0.93U
+ PD=0.52U
* device instance $4 r0 *1 2.13,1.0125 PMOS_VTL
M$4 22 6 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.0322875P AD=0.02205P PS=0.52U
+ PD=0.455U
* device instance $5 r0 *1 2.32,1.0125 PMOS_VTL
M$5 8 2 22 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $6 r0 *1 2.89,0.995 PMOS_VTL
M$6 10 9 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.048825P PS=0.77U
+ PD=0.785U
* device instance $7 r0 *1 3.095,0.995 PMOS_VTL
M$7 19 8 10 19 PMOS_VTL L=0.05U W=0.63U AS=0.048825P AD=0.06615P PS=0.785U
+ PD=0.84U
* device instance $8 r0 *1 3.355,0.995 PMOS_VTL
M$8 11 8 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.1323P AD=0.11025P PS=1.68U PD=1.61U
* device instance $10 r0 *1 3.805,0.995 PMOS_VTL
M$10 12 10 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U
+ PD=2.24U
* device instance $12 r0 *1 1.1,1.065 PMOS_VTL
M$12 20 2 6 19 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $13 r0 *1 1.29,1.065 PMOS_VTL
M$13 19 7 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $14 r0 *1 1.48,1.065 PMOS_VTL
M$14 20 9 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.01035P PS=0.23U
+ PD=0.41U
* device instance $15 r0 *1 0.72,1.05 PMOS_VTL
M$15 21 5 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.0441P AD=0.0294P PS=1.05U PD=0.56U
* device instance $16 r0 *1 0.91,1.05 PMOS_VTL
M$16 6 4 21 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.01785P PS=0.56U PD=0.56U
* device instance $17 r0 *1 0.19,1.0325 PMOS_VTL
M$17 19 3 2 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $18 r0 *1 0.38,1.0325 PMOS_VTL
M$18 4 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $19 r0 *1 3.425,0.2975 NMOS_VTL
M$19 11 8 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $21 r0 *1 3.805,0.2975 NMOS_VTL
M$21 12 10 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $23 r0 *1 2.445,0.26 NMOS_VTL
M$23 18 2 8 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $24 r0 *1 2.635,0.26 NMOS_VTL
M$24 18 10 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $25 r0 *1 1.875,0.32 NMOS_VTL
M$25 1 6 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $26 r0 *1 2.065,0.32 NMOS_VTL
M$26 16 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 2.255,0.32 NMOS_VTL
M$27 8 4 16 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $28 r0 *1 2.825,0.2975 NMOS_VTL
M$28 17 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 3.015,0.2975 NMOS_VTL
M$29 10 8 17 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $30 r0 *1 0.19,0.245 NMOS_VTL
M$30 1 3 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $31 r0 *1 0.38,0.245 NMOS_VTL
M$31 4 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $32 r0 *1 1.1,0.35 NMOS_VTL
M$32 15 4 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $33 r0 *1 1.29,0.35 NMOS_VTL
M$33 14 7 15 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $34 r0 *1 1.48,0.35 NMOS_VTL
M$34 1 9 14 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $35 r0 *1 0.72,0.3525 NMOS_VTL
M$35 13 5 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.028875P AD=0.01925P PS=0.76U
+ PD=0.415U
* device instance $36 r0 *1 0.91,0.3525 NMOS_VTL
M$36 6 2 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.012775P PS=0.415U
+ PD=0.415U
.ENDS DFFR_X2

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell DFFS_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin SN
* pin NWELL,VDD
.SUBCKT DFFS_X1 1 7 8 13 15 16 19
* net 1 PWELL,VSS
* net 7 QN
* net 8 Q
* net 13 D
* net 15 CK
* net 16 SN
* net 19 NWELL,VDD
* device instance $1 r0 *1 3.325,0.995 PMOS_VTL
M$1 19 5 7 19 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.515,0.995 PMOS_VTL
M$2 8 6 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.75,1.015 PMOS_VTL
M$3 22 2 4 19 PMOS_VTL L=0.05U W=0.09U AS=0.0183P AD=0.0072P PS=0.57U PD=0.25U
* device instance $4 r0 *1 0.96,1.015 PMOS_VTL
M$4 22 14 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.01485P AD=0.0072P PS=0.47U
+ PD=0.25U
* device instance $5 r0 *1 1.165,0.9025 PMOS_VTL
M$5 14 16 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.01485P AD=0.02205P PS=0.47U
+ PD=0.455U
* device instance $6 r0 *1 1.355,0.9025 PMOS_VTL
M$6 19 4 14 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $7 r0 *1 1.545,0.9025 PMOS_VTL
M$7 2 15 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $8 r0 *1 0.17,1.0725 PMOS_VTL
M$8 3 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.033075P PS=0.56U
+ PD=0.84U
* device instance $9 r0 *1 0.36,1.1 PMOS_VTL
M$9 21 13 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.025725P AD=0.0294P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 0.55,1.1 PMOS_VTL
M$10 4 3 21 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.0183P PS=0.56U PD=0.57U
* device instance $11 r0 *1 1.885,0.9775 PMOS_VTL
M$11 23 4 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $12 r0 *1 2.075,0.9775 PMOS_VTL
M$12 5 2 23 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $13 r0 *1 2.265,1.09 PMOS_VTL
M$13 20 3 5 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $14 r0 *1 2.455,1.09 PMOS_VTL
M$14 19 6 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $15 r0 *1 2.645,1.09 PMOS_VTL
M$15 20 16 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U
+ PD=0.39U
* device instance $16 r0 *1 2.985,0.9775 PMOS_VTL
M$16 6 5 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.84U
+ PD=0.84U
* device instance $17 r0 *1 3.325,0.2975 NMOS_VTL
M$17 1 5 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 3.515,0.2975 NMOS_VTL
M$18 8 6 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $19 r0 *1 2.265,0.315 NMOS_VTL
M$19 11 2 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $20 r0 *1 2.455,0.315 NMOS_VTL
M$20 10 6 11 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $21 r0 *1 2.645,0.315 NMOS_VTL
M$21 10 16 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.01095P AD=0.0063P PS=0.36U PD=0.23U
* device instance $22 r0 *1 2.845,0.255 NMOS_VTL
M$22 6 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.01095P AD=0.02205P PS=0.36U PD=0.63U
* device instance $23 r0 *1 1.695,0.375 NMOS_VTL
M$23 1 15 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $24 r0 *1 1.885,0.375 NMOS_VTL
M$24 18 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $25 r0 *1 2.075,0.375 NMOS_VTL
M$25 5 3 18 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $26 r0 *1 0.17,0.26 NMOS_VTL
M$26 3 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.36,0.2275 NMOS_VTL
M$27 9 13 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.016975P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $28 r0 *1 0.55,0.2275 NMOS_VTL
M$28 4 2 9 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.013225P PS=0.415U
+ PD=0.425U
* device instance $29 r0 *1 0.75,0.32 NMOS_VTL
M$29 12 3 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013225P AD=0.0072P PS=0.425U
+ PD=0.25U
* device instance $30 r0 *1 0.96,0.32 NMOS_VTL
M$30 12 14 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.012225P AD=0.0072P PS=0.365U
+ PD=0.25U
* device instance $31 r0 *1 1.165,0.32 NMOS_VTL
M$31 17 16 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.012225P AD=0.0147P PS=0.365U
+ PD=0.35U
* device instance $32 r0 *1 1.355,0.32 NMOS_VTL
M$32 14 4 17 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
.ENDS DFFS_X1

* cell BUF_X16
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X16 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.3528P PS=6.86U PD=6.16U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 4 3 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.7056P AD=0.72765P PS=12.32U PD=13.02U
* device instance $25 r0 *1 0.185,0.2975 NMOS_VTL
M$25 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.2324P PS=4.925U PD=4.44U
* device instance $33 r0 *1 1.705,0.2975 NMOS_VTL
M$33 4 3 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4648P AD=0.479325P PS=8.88U PD=9.365U
.ENDS BUF_X16

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell DFFR_X1
* pin PWELL,VSS
* pin CK
* pin QN
* pin Q
* pin D
* pin RN
* pin NWELL,VDD
.SUBCKT DFFR_X1 1 3 8 9 16 18 19
* net 1 PWELL,VSS
* net 3 CK
* net 8 QN
* net 9 Q
* net 16 D
* net 18 RN
* net 19 NWELL,VDD
* device instance $1 r0 *1 3.41,0.995 PMOS_VTL
M$1 19 6 8 19 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.6,0.995 PMOS_VTL
M$2 9 7 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 2.455,1.04 PMOS_VTL
M$3 21 4 6 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $4 r0 *1 2.645,1.04 PMOS_VTL
M$4 19 7 21 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.014175P PS=0.23U
+ PD=0.455U
* device instance $5 r0 *1 1.815,1.0125 PMOS_VTL
M$5 19 5 17 19 PMOS_VTL L=0.05U W=0.315U AS=0.03465P AD=0.033075P PS=0.85U
+ PD=0.525U
* device instance $6 r0 *1 2.075,1.0125 PMOS_VTL
M$6 23 5 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.525U
+ PD=0.455U
* device instance $7 r0 *1 2.265,1.0125 PMOS_VTL
M$7 6 2 23 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $8 r0 *1 2.835,1.1525 PMOS_VTL
M$8 7 18 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 3.025,1.1525 PMOS_VTL
M$9 19 6 7 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $10 r0 *1 1.08,1.065 PMOS_VTL
M$10 20 2 5 19 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $11 r0 *1 1.27,1.065 PMOS_VTL
M$11 19 17 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U
+ PD=0.23U
* device instance $12 r0 *1 1.46,1.065 PMOS_VTL
M$12 20 18 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.01035P PS=0.23U
+ PD=0.41U
* device instance $13 r0 *1 0.7,1.05 PMOS_VTL
M$13 22 16 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.0441P AD=0.0294P PS=1.05U
+ PD=0.56U
* device instance $14 r0 *1 0.89,1.05 PMOS_VTL
M$14 5 4 22 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.01785P PS=0.56U PD=0.56U
* device instance $15 r0 *1 0.17,1.1525 PMOS_VTL
M$15 19 3 2 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $16 r0 *1 0.36,1.1525 PMOS_VTL
M$16 4 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $17 r0 *1 1.08,0.35 NMOS_VTL
M$17 12 4 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $18 r0 *1 1.27,0.35 NMOS_VTL
M$18 11 17 12 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $19 r0 *1 1.46,0.35 NMOS_VTL
M$19 1 18 11 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $20 r0 *1 0.7,0.3525 NMOS_VTL
M$20 10 16 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.028875P AD=0.01925P PS=0.76U
+ PD=0.415U
* device instance $21 r0 *1 0.89,0.3525 NMOS_VTL
M$21 5 2 10 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.012775P PS=0.415U
+ PD=0.415U
* device instance $22 r0 *1 0.17,0.245 NMOS_VTL
M$22 1 3 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $23 r0 *1 0.36,0.245 NMOS_VTL
M$23 4 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $24 r0 *1 2.455,0.26 NMOS_VTL
M$24 15 2 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 2.645,0.26 NMOS_VTL
M$25 1 7 15 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0105P PS=0.23U PD=0.35U
* device instance $26 r0 *1 1.815,0.32 NMOS_VTL
M$26 1 5 17 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.02205P PS=0.63U PD=0.42U
* device instance $27 r0 *1 2.075,0.32 NMOS_VTL
M$27 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.42U PD=0.35U
* device instance $28 r0 *1 2.265,0.32 NMOS_VTL
M$28 6 4 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $29 r0 *1 2.835,0.32 NMOS_VTL
M$29 13 18 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.0147P PS=0.35U PD=0.35U
* device instance $30 r0 *1 3.025,0.32 NMOS_VTL
M$30 7 6 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $31 r0 *1 3.41,0.2975 NMOS_VTL
M$31 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $32 r0 *1 3.6,0.2975 NMOS_VTL
M$32 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFFR_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1
