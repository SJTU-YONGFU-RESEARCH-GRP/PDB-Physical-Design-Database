* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT bidirectional_shift_register clk direction enable
+ load_en parallel_in[0] parallel_in[1] parallel_in[2] parallel_in[3]
+ parallel_in[4] parallel_in[5] parallel_in[6] parallel_in[7]
+ parallel_out[0] parallel_out[1] parallel_out[2] parallel_out[3]
+ parallel_out[4] parallel_out[5] parallel_out[6] parallel_out[7]
+ rst_n serial_in shift_en
X_36_ load_en VSS VSS VDD VDD _08_ sky130_fd_sc_hd__buf_6
X_37_ net12 _08_ net2 VSS VSS VDD VDD _09_ sky130_fd_sc_hd__o21ai_4
X_38_ _09_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__buf_6
X_39_ direction VSS VSS VDD VDD _11_ sky130_fd_sc_hd__buf_6
X_40_ net14 net11 _11_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__mux2_1
X_41_ _12_ net3 _08_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__mux2i_1
X_42_ net13 _10_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nand2_1
X_43_ _10_ _13_ _14_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__o21ai_0
X_44_ net15 net13 _11_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__mux2_1
X_45_ _15_ net4 _08_ VSS VSS VDD VDD _16_ sky130_fd_sc_hd__mux2i_1
X_46_ net14 _10_ VSS VSS VDD VDD _17_ sky130_fd_sc_hd__nand2_1
X_47_ _10_ _16_ _17_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__o21ai_0
X_48_ net16 net14 _11_ VSS VSS VDD VDD _18_ sky130_fd_sc_hd__mux2_1
X_49_ _18_ net5 _08_ VSS VSS VDD VDD _19_ sky130_fd_sc_hd__mux2i_1
X_50_ net15 _10_ VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nand2_1
X_51_ _09_ _19_ _20_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__o21ai_0
X_52_ net17 net15 _11_ VSS VSS VDD VDD _21_ sky130_fd_sc_hd__mux2_1
X_53_ _21_ net6 _08_ VSS VSS VDD VDD _22_ sky130_fd_sc_hd__mux2i_1
X_54_ net16 _10_ VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nand2_1
X_55_ _09_ _22_ _23_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__o21ai_0
X_56_ net18 net16 _11_ VSS VSS VDD VDD _24_ sky130_fd_sc_hd__mux2_1
X_57_ _24_ net7 _08_ VSS VSS VDD VDD _25_ sky130_fd_sc_hd__mux2i_1
X_58_ net17 _10_ VSS VSS VDD VDD _26_ sky130_fd_sc_hd__nand2_1
X_59_ _09_ _25_ _26_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__o21ai_0
X_60_ net19 net17 _11_ VSS VSS VDD VDD _27_ sky130_fd_sc_hd__mux2_1
X_61_ _27_ net8 _08_ VSS VSS VDD VDD _28_ sky130_fd_sc_hd__mux2i_1
X_62_ net18 _10_ VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nand2_1
X_63_ _09_ _28_ _29_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__o21ai_0
X_64_ net20 net18 _11_ VSS VSS VDD VDD _30_ sky130_fd_sc_hd__mux2_1
X_65_ _30_ net9 _08_ VSS VSS VDD VDD _31_ sky130_fd_sc_hd__mux2i_1
X_66_ net19 _10_ VSS VSS VDD VDD _32_ sky130_fd_sc_hd__nand2_1
X_67_ _09_ _31_ _32_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__o21ai_0
X_68_ net11 net19 _11_ VSS VSS VDD VDD _33_ sky130_fd_sc_hd__mux2_1
X_69_ _33_ net10 _08_ VSS VSS VDD VDD _34_ sky130_fd_sc_hd__mux2i_1
X_70_ net20 _10_ VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nand2_1
X_71_ _09_ _34_ _35_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__o21ai_0
Xparallel_out\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _00_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _04_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _05_ net1
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xparallel_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xhold1 net21 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 enable VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 parallel_in[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 parallel_in[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 parallel_in[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 parallel_in[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 parallel_in[4] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 parallel_in[5] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 parallel_in[6] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 parallel_in[7] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 serial_in VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 shift_en VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD parallel_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD parallel_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD parallel_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD parallel_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD parallel_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD parallel_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD parallel_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD parallel_out[7] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net21 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS bidirectional_shift_register
