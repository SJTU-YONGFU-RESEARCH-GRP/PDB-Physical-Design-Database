* cell dynamic_node_top_wrap
* pin dataOut_S[52]
* pin dataIn_S[42]
* pin dataIn_P[20]
* pin dataIn_P[19]
* pin dataIn_P[24]
* pin dataIn_P[27]
* pin dataIn_P[23]
* pin dataIn_P[22]
* pin dataIn_S[55]
* pin dataIn_S[59]
* pin dataOut_P[54]
* pin dataIn_S[60]
* pin dataOut_S[50]
* pin dataOut_E[54]
* pin dataIn_S[61]
* pin dataOut_E[55]
* pin dataIn_S[11]
* pin dataIn_S[15]
* pin dataIn_S[17]
* pin dataOut_S[54]
* pin dataIn_S[58]
* pin dataIn_N[18]
* pin dataIn_S[5]
* pin dataOut_P[55]
* pin dataOut_P[58]
* pin dataIn_S[10]
* pin dataIn_N[10]
* pin dataIn_S[18]
* pin dataIn_N[8]
* pin dataIn_N[56]
* pin dataIn_N[61]
* pin dataIn_N[14]
* pin dataIn_S[63]
* pin dataIn_S[14]
* pin dataIn_S[56]
* pin dataIn_S[12]
* pin dataIn_S[62]
* pin dataIn_N[63]
* pin dataIn_S[16]
* pin dataIn_S[8]
* pin dataIn_N[15]
* pin dataIn_N[0]
* pin dataIn_S[54]
* pin dataIn_N[12]
* pin dataOut_N[54]
* pin dataIn_S[52]
* pin dataIn_S[0]
* pin dataIn_S[13]
* pin dataOut_S[55]
* pin dataOut_N[55]
* pin dataOut_S[58]
* pin dataOut_N[58]
* pin dataIn_S[49]
* pin dataIn_S[41]
* pin dataIn_S[44]
* pin dataIn_S[4]
* pin dataIn_S[43]
* pin dataIn_E[59]
* pin dataIn_S[53]
* pin dataIn_E[55]
* pin dataIn_S[50]
* pin dataIn_S[40]
* pin dataOut_N[13]
* pin dataIn_E[60]
* pin dataOut_E[58]
* pin dataOut_N[10]
* pin dataOut_P[13]
* pin dataOut_E[13]
* pin dataOut_E[57]
* pin dataOut_W[13]
* pin dataOut_P[10]
* pin dataOut_E[59]
* pin dataOut_S[57]
* pin dataOut_N[57]
* pin dataOut_S[53]
* pin dataOut_P[57]
* pin dataIn_S[46]
* pin dataOut_E[10]
* pin dataOut_N[59]
* pin dataOut_S[10]
* pin dataIn_E[63]
* pin dataOut_S[13]
* pin dataOut_P[16]
* pin dataIn_S[48]
* pin dataOut_S[20]
* pin dataIn_S[39]
* pin dataIn_E[5]
* pin dataOut_P[59]
* pin dataOut_N[8]
* pin dataOut_E[16]
* pin dataOut_P[63]
* pin dataOut_N[61]
* pin dataIn_S[3]
* pin dataIn_S[6]
* pin dataOut_S[8]
* pin dataOut_W[10]
* pin dataIn_S[38]
* pin dataOut_S[5]
* pin dataOut_P[61]
* pin dataOut_S[62]
* pin dataOut_E[61]
* pin dataOut_S[11]
* pin dataIn_S[51]
* pin dataOut_S[51]
* pin dataOut_E[5]
* pin dataOut_N[16]
* pin dataOut_E[3]
* pin dataOut_S[56]
* pin dataIn_E[56]
* pin dataOut_P[11]
* pin dataOut_E[20]
* pin dataOut_E[56]
* pin dataOut_E[9]
* pin dataIn_S[34]
* pin dataIn_S[19]
* pin dataOut_P[20]
* pin dataIn_E[9]
* pin dataOut_S[4]
* pin dataOut_N[12]
* pin dataOut_S[16]
* pin dataOut_P[3]
* pin dataIn_E[53]
* pin dataIn_S[33]
* pin dataIn_E[61]
* pin dataIn_E[62]
* pin dataOut_N[19]
* pin dataOut_S[6]
* pin dataOut_W[14]
* pin dataIn_S[20]
* pin dataOut_E[0]
* pin dataOut_N[3]
* pin dataIn_E[8]
* pin dataIn_S[32]
* pin dataOut_W[11]
* pin dataOut_P[8]
* pin dataOut_N[63]
* pin dataIn_S[28]
* pin dataOut_P[7]
* pin dataOut_S[14]
* pin dataIn_S[26]
* pin dataIn_S[1]
* pin dataOut_S[17]
* pin dataOut_P[5]
* pin dataOut_S[0]
* pin dataOut_P[0]
* pin dataIn_E[54]
* pin dataOut_E[12]
* pin dataOut_S[19]
* pin dataOut_N[0]
* pin dataOut_W[12]
* pin dataOut_S[7]
* pin dataIn_S[24]
* pin dataIn_E[14]
* pin dataOut_P[6]
* pin dataIn_S[23]
* pin dataOut_E[7]
* pin dataOut_W[15]
* pin dataOut_S[61]
* pin dataIn_E[11]
* pin dataIn_S[47]
* pin dataOut_S[15]
* pin dataIn_S[9]
* pin dataOut_P[14]
* pin dataOut_E[19]
* pin dataIn_S[7]
* pin dataOut_N[11]
* pin dataOut_P[9]
* pin dataIn_E[58]
* pin dataOut_S[12]
* pin dataOut_E[6]
* pin dataOut_E[17]
* pin dataOut_N[17]
* pin dataIn_S[29]
* pin dataIn_S[37]
* pin dataIn_S[2]
* pin dataIn_S[25]
* pin dataIn_S[21]
* pin dataIn_E[7]
* pin dataOut_W[0]
* pin dataIn_E[50]
* pin dataOut_N[14]
* pin dataOut_P[17]
* pin dataOut_N[5]
* pin dataOut_E[14]
* pin dataOut_E[63]
* pin dataOut_N[9]
* pin dataIn_S[22]
* pin dataIn_S[30]
* pin dataOut_N[7]
* pin dataIn_S[35]
* pin dataOut_S[9]
* pin dataIn_E[57]
* pin dataIn_S[45]
* pin dataOut_N[20]
* pin dataOut_N[6]
* pin dataIn_E[52]
* pin dataOut_S[60]
* pin dataOut_E[8]
* pin dataOut_E[11]
* pin dataIn_S[36]
* pin dataIn_E[51]
* pin dataOut_P[15]
* pin dataIn_S[31]
* pin dataOut_S[59]
* pin dataOut_S[63]
* pin dataOut_P[19]
* pin dataIn_S[27]
* pin dataOut_P[12]
* pin PWELL
* pin NWELL
* pin dataIn_P[13]
* pin dataIn_P[11]
* pin dataIn_E[15]
* pin dataIn_E[0]
* pin dataIn_E[18]
* pin dataIn_E[17]
* pin dataIn_E[13]
* pin dataIn_P[16]
* pin dataIn_E[12]
* pin dataIn_E[27]
* pin dataIn_E[22]
* pin dataIn_E[16]
* pin dataIn_P[17]
* pin dataIn_E[10]
* pin dataIn_E[24]
* pin dataIn_E[1]
* pin dataIn_E[20]
* pin dataIn_E[26]
* pin dataIn_P[10]
* pin dataIn_E[6]
* pin dataIn_E[4]
* pin dataIn_E[19]
* pin dataIn_E[21]
* pin dataIn_E[25]
* pin dataIn_E[23]
* pin dataIn_S[57]
* pin dataIn_P[14]
* pin dataIn_E[41]
* pin myChipID[4]
* pin myChipID[2]
* pin myChipID[12]
* pin dataIn_E[49]
* pin dataIn_E[3]
* pin dataIn_E[2]
* pin dataIn_E[33]
* pin myChipID[11]
* pin dataIn_P[25]
* pin dataIn_P[15]
* pin dataIn_E[29]
* pin dataIn_E[28]
* pin myChipID[0]
* pin myChipID[13]
* pin myChipID[10]
* pin myChipID[3]
* pin dataOut_W[61]
* pin dataIn_E[47]
* pin myChipID[1]
* pin dataIn_P[1]
* pin myChipID[5]
* pin dataOut_W[57]
* pin dataOut_W[5]
* pin dataIn_E[36]
* pin dataIn_P[18]
* pin dataIn_E[38]
* pin dataOut_W[56]
* pin dataIn_W[13]
* pin dataIn_E[30]
* pin dataOut_W[55]
* pin dataIn_E[48]
* pin dataIn_W[11]
* pin dataIn_P[26]
* pin dataOut_W[54]
* pin dataIn_E[43]
* pin dataIn_N[17]
* pin dataIn_E[46]
* pin dataOut_W[19]
* pin dataIn_N[16]
* pin dataIn_W[10]
* pin dataIn_E[35]
* pin dataIn_P[12]
* pin dataOut_W[59]
* pin dataIn_W[55]
* pin dataIn_E[42]
* pin dataOut_S[18]
* pin dataIn_W[16]
* pin dataIn_E[39]
* pin dataIn_P[21]
* pin dataIn_E[34]
* pin dataIn_E[44]
* pin dataOut_W[16]
* pin dataIn_E[40]
* pin dataIn_N[13]
* pin dataIn_P[56]
* pin dataOut_W[17]
* pin dataIn_W[15]
* pin dataIn_P[0]
* pin dataIn_E[32]
* pin dataIn_W[0]
* pin dataOut_W[18]
* pin dataIn_W[17]
* pin dataOut_W[20]
* pin dataOut_E[15]
* pin dataIn_P[60]
* pin dataIn_W[14]
* pin dataIn_E[31]
* pin dataIn_E[37]
* pin dataIn_N[11]
* pin dataIn_E[45]
* pin dataIn_W[12]
* pin dataOut_N[15]
* pin dataIn_P[8]
* pin dataIn_P[9]
* pin dataOut_N[18]
* pin dataOut_E[18]
* pin dataIn_W[18]
* pin dataIn_P[62]
* pin dataIn_P[61]
* pin dataOut_P[18]
* pin dataOut_W[9]
* pin dataOut_S[1]
* pin dataIn_W[9]
* pin dataOut_W[8]
* pin dataIn_N[59]
* pin dataIn_P[63]
* pin dataOut_W[1]
* pin dataOut_W[63]
* pin dataOut_E[1]
* pin dataOut_W[58]
* pin dataIn_P[6]
* pin dataOut_W[6]
* pin dataOut_P[1]
* pin dataOut_N[1]
* pin myChipID[9]
* pin dataIn_W[7]
* pin dataOut_W[7]
* pin dataIn_P[5]
* pin dataIn_W[6]
* pin dataIn_W[58]
* pin dataOut_W[3]
* pin myChipID[8]
* pin dataIn_N[58]
* pin dataOut_W[33]
* pin dataOut_W[21]
* pin dataIn_W[63]
* pin myChipID[7]
* pin myChipID[6]
* pin dataIn_P[7]
* pin dataOut_S[21]
* pin dataOut_E[21]
* pin dataOut_P[21]
* pin dataOut_N[21]
* pin dataIn_W[8]
* pin dataIn_W[1]
* pin dataIn_W[59]
* pin dataIn_W[62]
* pin dataIn_N[57]
* pin dataIn_W[21]
* pin dataIn_W[5]
* pin dataIn_P[59]
* pin dataOut_E[33]
* pin dataOut_N[33]
* pin dataIn_W[56]
* pin dataOut_S[33]
* pin dataOut_P[33]
* pin dataIn_P[55]
* pin dataIn_P[28]
* pin dataIn_P[2]
* pin dataOut_S[2]
* pin dataOut_E[2]
* pin clk
* pin dataOut_E[62]
* pin dataIn_W[61]
* pin dataOut_N[56]
* pin dataIn_W[60]
* pin dataIn_W[57]
* pin dataIn_P[57]
* pin dataOut_P[56]
* pin dataOut_N[2]
* pin dataOut_S[3]
* pin dataOut_N[4]
* pin dataOut_P[62]
* pin dataIn_P[33]
* pin dataOut_P[4]
* pin dataOut_P[52]
* pin dataOut_E[22]
* pin dataOut_N[23]
* pin dataOut_N[53]
* pin dataIn_P[29]
* pin dataIn_N[62]
* pin dataOut_E[53]
* pin dataOut_P[2]
* pin dataIn_W[53]
* pin dataOut_P[60]
* pin dataOut_P[50]
* pin dataOut_P[22]
* pin dataIn_P[30]
* pin dataOut_N[51]
* pin dataOut_N[50]
* pin dataOut_E[52]
* pin dataIn_P[31]
* pin dataOut_S[24]
* pin dataIn_W[33]
* pin dataIn_N[54]
* pin dataOut_E[47]
* pin dataOut_E[29]
* pin dataOut_P[41]
* pin dataOut_E[49]
* pin dataOut_P[49]
* pin dataIn_P[58]
* pin dataOut_S[23]
* pin dataOut_N[52]
* pin dataIn_N[9]
* pin dataOut_N[41]
* pin dataOut_N[43]
* pin dataOut_S[38]
* pin dataIn_W[50]
* pin dataIn_W[19]
* pin dataIn_P[32]
* pin dataOut_N[48]
* pin dataOut_E[45]
* pin dataIn_N[50]
* pin dataIn_P[3]
* pin dataIn_P[4]
* pin dataOut_E[51]
* pin dataOut_E[30]
* pin dataOut_N[46]
* pin dataOut_P[23]
* pin dataOut_S[22]
* pin dataOut_E[37]
* pin dataOut_P[51]
* pin dataOut_N[29]
* pin dataOut_E[50]
* pin dataIn_P[34]
* pin dataOut_E[23]
* pin dataIn_W[52]
* pin dataIn_N[49]
* pin dataOut_N[28]
* pin dataOut_P[48]
* pin dataOut_E[46]
* pin dataIn_W[48]
* pin dataOut_N[47]
* pin dataIn_W[42]
* pin dataOut_E[60]
* pin dataOut_N[45]
* pin dataOut_S[36]
* pin dataIn_N[1]
* pin dataIn_W[49]
* pin dataOut_P[53]
* pin dataIn_P[52]
* pin dataOut_N[38]
* pin dataOut_P[36]
* pin dataOut_E[35]
* pin dataOut_S[39]
* pin dataOut_N[22]
* pin dataIn_N[20]
* pin dataIn_W[20]
* pin dataIn_P[51]
* pin dataOut_S[43]
* pin dataOut_N[26]
* pin dataIn_P[50]
* pin dataIn_P[42]
* pin dataIn_N[21]
* pin dataOut_P[27]
* pin dataIn_W[51]
* pin dataIn_P[36]
* pin dataOut_N[42]
* pin dataOut_E[40]
* pin dataOut_S[42]
* pin dataIn_N[19]
* pin dataOut_P[30]
* pin dataOut_P[46]
* pin dataIn_P[44]
* pin dataIn_P[54]
* pin dataOut_N[39]
* pin dataIn_W[34]
* pin dataIn_W[45]
* pin dataIn_P[35]
* pin dataOut_N[40]
* pin dataOut_E[39]
* pin dataOut_S[28]
* pin dataIn_P[39]
* pin dataOut_P[35]
* pin dataOut_N[37]
* pin dataIn_W[44]
* pin dataIn_P[46]
* pin dataOut_N[34]
* pin dataIn_N[5]
* pin dataIn_W[40]
* pin dataOut_E[28]
* pin dataOut_P[40]
* pin dataOut_E[27]
* pin dataIn_W[32]
* pin dataOut_E[4]
* pin dataIn_W[2]
* pin dataIn_P[53]
* pin dataOut_S[32]
* pin dataOut_S[44]
* pin dataIn_W[28]
* pin dataOut_P[39]
* pin dataIn_P[43]
* pin dataOut_S[26]
* pin dataIn_W[46]
* pin dataIn_W[26]
* pin dataIn_W[35]
* pin dataOut_N[30]
* pin dataOut_N[36]
* pin dataIn_W[29]
* pin dataOut_N[60]
* pin dataOut_N[24]
* pin dataOut_P[25]
* pin dataIn_W[30]
* pin dataIn_W[23]
* pin dataOut_E[25]
* pin dataOut_P[26]
* pin dataOut_E[48]
* pin dataIn_W[27]
* pin dataOut_P[43]
* pin dataOut_N[62]
* pin dataOut_S[37]
* pin dataOut_S[35]
* pin dataOut_P[32]
* pin dataOut_E[31]
* pin dataIn_W[47]
* pin dataOut_E[26]
* pin dataOut_N[31]
* pin dataOut_N[25]
* pin dataOut_N[32]
* pin dataIn_P[48]
* pin dataIn_P[47]
* pin dataIn_P[49]
* pin dataOut_P[28]
* pin dataOut_P[42]
* pin dataOut_E[32]
* pin dataOut_S[31]
* pin dataOut_E[44]
* pin dataIn_W[3]
* pin dataIn_P[45]
* pin dataOut_P[29]
* pin dataOut_S[45]
* pin dataOut_P[44]
* pin dataIn_W[4]
* pin dataOut_P[38]
* pin dataOut_E[24]
* pin dataOut_S[46]
* pin dataOut_N[27]
* pin dataIn_W[37]
* pin dataIn_P[37]
* pin dataIn_W[39]
* pin dataIn_W[25]
* pin dataOut_P[47]
* pin dataIn_P[38]
* pin dataIn_P[40]
* pin dataOut_S[25]
* pin dataOut_N[49]
* pin dataOut_E[34]
* pin dataOut_S[40]
* pin dataOut_E[42]
* pin dataOut_N[35]
* pin dataOut_S[30]
* pin dataIn_P[41]
* pin dataIn_W[38]
* pin dataIn_W[22]
* pin dataOut_E[43]
* pin dataOut_E[36]
* pin dataOut_S[34]
* pin dataIn_W[54]
* pin dataOut_P[24]
* pin dataIn_W[41]
* pin dataOut_E[41]
* pin dataOut_P[37]
* pin dataIn_W[31]
* pin dataIn_W[24]
* pin dataOut_E[38]
* pin dataOut_S[41]
* pin dataOut_S[27]
* pin dataOut_P[34]
* pin dataOut_P[31]
* pin dataOut_S[29]
* pin dataOut_N[44]
* pin dataIn_W[43]
* pin dataIn_W[36]
* pin dataOut_P[45]
* pin dataIn_N[41]
* pin dataOut_W[45]
* pin dataOut_W[35]
* pin dataOut_W[32]
* pin yummyIn_S
* pin myLocY[4]
* pin myLocY[3]
* pin myLocY[2]
* pin dataIn_N[45]
* pin dataIn_N[3]
* pin dataIn_N[27]
* pin dataIn_N[32]
* pin dataIn_N[36]
* pin dataIn_N[24]
* pin dataOut_W[37]
* pin myLocX[3]
* pin validIn_N
* pin dataOut_W[50]
* pin yummyOut_E
* pin validIn_E
* pin yummyOut_W
* pin myLocY[6]
* pin reset_in
* pin validIn_P
* pin thanksIn_P
* pin myLocY[7]
* pin yummyOut_P
* pin dataIn_N[38]
* pin dataOut_W[25]
* pin dataIn_N[44]
* pin dataIn_N[42]
* pin dataIn_N[39]
* pin dataOut_W[24]
* pin dataOut_W[28]
* pin dataIn_N[40]
* pin dataIn_N[46]
* pin dataOut_W[26]
* pin dataOut_W[27]
* pin dataIn_N[53]
* pin dataIn_N[60]
* pin dataIn_N[47]
* pin dataOut_W[2]
* pin dataIn_N[35]
* pin dataIn_N[4]
* pin dataIn_N[34]
* pin validOut_W
* pin dataOut_W[23]
* pin dataIn_N[29]
* pin dataIn_N[23]
* pin dataOut_W[22]
* pin validOut_E
* pin myLocX[2]
* pin yummyIn_E
* pin dataIn_N[28]
* pin dataOut_W[30]
* pin dataIn_N[33]
* pin myLocX[1]
* pin dataIn_N[30]
* pin dataIn_N[31]
* pin dataOut_W[29]
* pin dataIn_N[26]
* pin dataOut_W[31]
* pin dataIn_N[25]
* pin dataOut_W[52]
* pin dataOut_W[34]
* pin validOut_S
* pin dataOut_W[39]
* pin dataOut_W[41]
* pin yummyOut_N
* pin dataOut_W[36]
* pin dataOut_S[49]
* pin dataOut_W[53]
* pin validOut_P
* pin dataOut_W[40]
* pin dataOut_W[4]
* pin dataOut_W[49]
* pin validIn_S
* pin dataOut_W[47]
* pin dataOut_S[47]
* pin dataOut_W[42]
* pin dataOut_W[60]
* pin dataOut_W[43]
* pin dataOut_W[38]
* pin dataOut_W[44]
* pin dataOut_W[46]
* pin validOut_N
* pin dataOut_W[51]
* pin dataOut_W[62]
* pin dataIn_N[37]
* pin dataIn_N[48]
* pin dataIn_N[51]
* pin dataIn_N[43]
* pin dataIn_N[52]
* pin dataIn_N[6]
* pin dataIn_N[55]
* pin dataIn_N[2]
* pin dataIn_N[7]
* pin myLocX[5]
* pin myLocX[4]
* pin myLocX[0]
* pin dataIn_N[22]
* pin dataOut_S[48]
* pin dataOut_W[48]
* pin yummyIn_N
* pin yummyIn_P
* pin yummyOut_S
* pin yummyIn_W
* pin myLocY[0]
* pin myLocX[7]
* pin myLocX[6]
* pin myLocY[5]
* pin myLocY[1]
* pin validIn_W
.SUBCKT dynamic_node_top_wrap 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19
+ 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45
+ 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71
+ 72 73 74 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95 96 97
+ 98 99 100 101 102 103 104 105 106 107 108 109 110 111 112 113 114 115 116 117
+ 118 119 120 121 122 123 124 125 126 127 128 129 130 131 132 133 134 135 136
+ 137 138 139 140 141 142 143 144 145 146 147 148 149 150 151 152 153 154 155
+ 156 157 158 159 160 161 162 163 164 165 166 167 168 169 170 171 172 173 174
+ 175 176 177 178 179 180 181 182 183 184 185 186 187 188 189 190 191 192 193
+ 194 195 196 197 198 199 200 201 202 203 204 205 206 207 208 219 320 664 665
+ 1195 1196 1260 1504 1506 1546 1598 1682 1683 1785 1828 1872 1962 1963 1964
+ 2074 2140 2173 2270 2271 2272 2378 2379 2455 2456 2500 2554 2555 2556 2597
+ 2598 2695 2696 2764 2765 2766 2834 2836 2877 2878 2879 2880 2947 2948 3027
+ 3028 3029 3073 3074 3075 3123 3174 3175 3176 3183 3295 3299 3300 3352 3410
+ 3411 3471 3525 3527 3568 3626 3627 3672 3709 3710 3713 3800 3801 3802 3845
+ 3883 3884 3885 3890 3941 3942 4096 4097 4142 4206 4207 4208 4209 4212 4213
+ 4274 4324 4426 4427 4473 4536 4537 4540 4598 4599 4646 4647 4648 4695 4696
+ 4748 4749 4843 4844 4845 4897 4898 4943 4944 4945 4946 4984 5044 5045 5046
+ 5167 5168 5172 5185 5285 5286 5289 5343 5344 5377 5378 5380 5412 5413 5414
+ 5457 5458 5550 5551 5554 5649 5650 5651 5707 5761 5762 5800 5854 5855 5856
+ 5858 5859 5920 5921 5922 5983 5984 6021 6088 6089 6093 6205 6206 6262 6312
+ 6313 6402 6403 6404 6452 6482 6483 6557 6558 6560 6605 6645 6646 6747 6748
+ 6749 6847 6848 6896 6965 6966 6967 7013 7073 7074 7075 7076 7168 7169 7170
+ 7173 7211 7297 7298 7421 7422 7423 7533 7534 7535 7576 7643 7644 7645 7646
+ 7703 7754 7755 7756 7854 7855 7856 7964 7965 7966 8011 8079 8080 8081 8201
+ 8202 8203 8302 8303 8399 8400 8401 8402 8505 8506 8507 8522 8613 8614 8615
+ 8617 8618 8723 8724 8738 8845 8846 8880 8906 8963 8964 8965 9030 9080 9081
+ 9082 9192 9193 9194 9195 9222 9341 9342 9343 9344 9449 9450 9451 9524 9585
+ 9586 9587 9635 9688 9689 9690 9691 9804 9805 9806 9892 9893 9915 9981 9982
+ 10073 10074 10125 10163 10164 10165 10273 10274 10275 10381 10510 10511 10512
+ 10513 10610 10611 10612 10718 10719 10817 10823 10824 10825 10914 10991 10992
+ 10994 11086 11087 11088 11098 11099 11100 11176 11177 11178 11261 11262 11263
+ 11302 11347 11348 11426 11427 11428 11429 11514 11515 11516 11519 11583 11584
+ 11585 11586 11623 11666 11667 11668 11720 11721 11722 11723 11724 11776 11777
+ 11778 11824 11825 11884 11885 11928 11929 11930 11931 11932 11994 12030 12031
+ 12032 12033 12100 12101 12102 12156 12157 12369 12370 12371 12372 12377 12380
+ 12383 12384 12385 12386 12387 12388 12390 12391 12392 12393 12394 12395 12396
+ 12397 12398 12399 12400 12401 12402 12403 12404 12405 12406 12407 12408 12409
+ 12410 12411 12412 12413 12414 12415 12416 12417 12418 12419 12420 12421 12422
+ 12423 12424 12425 12426 12427 12428 12429 12430 12431 12432 12433 12434 12435
+ 12436 12437 12438 12439 12440 12441 12442 12443 12444 12445 12446 12447 12448
+ 12449 12450 12451 12452 12453 12454 12455 12456 12457 12458 12459 12460 12461
+ 12462 12463 12464 12465 12466 12467 12468 12469 12470 12471 12472 12473 12474
+ 12475 12476 12477 12478 12479 12480 12481 12482 12483 12484 12485 12486 12487
+ 12488 12489 12490
* net 1 dataOut_S[52]
* net 2 dataIn_S[42]
* net 3 dataIn_P[20]
* net 4 dataIn_P[19]
* net 5 dataIn_P[24]
* net 6 dataIn_P[27]
* net 7 dataIn_P[23]
* net 8 dataIn_P[22]
* net 9 dataIn_S[55]
* net 10 dataIn_S[59]
* net 11 dataOut_P[54]
* net 12 dataIn_S[60]
* net 13 dataOut_S[50]
* net 14 dataOut_E[54]
* net 15 dataIn_S[61]
* net 16 dataOut_E[55]
* net 17 dataIn_S[11]
* net 18 dataIn_S[15]
* net 19 dataIn_S[17]
* net 20 dataOut_S[54]
* net 21 dataIn_S[58]
* net 22 dataIn_N[18]
* net 23 dataIn_S[5]
* net 24 dataOut_P[55]
* net 25 dataOut_P[58]
* net 26 dataIn_S[10]
* net 27 dataIn_N[10]
* net 28 dataIn_S[18]
* net 29 dataIn_N[8]
* net 30 dataIn_N[56]
* net 31 dataIn_N[61]
* net 32 dataIn_N[14]
* net 33 dataIn_S[63]
* net 34 dataIn_S[14]
* net 35 dataIn_S[56]
* net 36 dataIn_S[12]
* net 37 dataIn_S[62]
* net 38 dataIn_N[63]
* net 39 dataIn_S[16]
* net 40 dataIn_S[8]
* net 41 dataIn_N[15]
* net 42 dataIn_N[0]
* net 43 dataIn_S[54]
* net 44 dataIn_N[12]
* net 45 dataOut_N[54]
* net 46 dataIn_S[52]
* net 47 dataIn_S[0]
* net 48 dataIn_S[13]
* net 49 dataOut_S[55]
* net 50 dataOut_N[55]
* net 51 dataOut_S[58]
* net 52 dataOut_N[58]
* net 53 dataIn_S[49]
* net 54 dataIn_S[41]
* net 55 dataIn_S[44]
* net 56 dataIn_S[4]
* net 57 dataIn_S[43]
* net 58 dataIn_E[59]
* net 59 dataIn_S[53]
* net 60 dataIn_E[55]
* net 61 dataIn_S[50]
* net 62 dataIn_S[40]
* net 63 dataOut_N[13]
* net 64 dataIn_E[60]
* net 65 dataOut_E[58]
* net 66 dataOut_N[10]
* net 67 dataOut_P[13]
* net 68 dataOut_E[13]
* net 69 dataOut_E[57]
* net 70 dataOut_W[13]
* net 71 dataOut_P[10]
* net 72 dataOut_E[59]
* net 73 dataOut_S[57]
* net 74 dataOut_N[57]
* net 75 dataOut_S[53]
* net 76 dataOut_P[57]
* net 77 dataIn_S[46]
* net 78 dataOut_E[10]
* net 79 dataOut_N[59]
* net 80 dataOut_S[10]
* net 81 dataIn_E[63]
* net 82 dataOut_S[13]
* net 83 dataOut_P[16]
* net 84 dataIn_S[48]
* net 85 dataOut_S[20]
* net 86 dataIn_S[39]
* net 87 dataIn_E[5]
* net 88 dataOut_P[59]
* net 89 dataOut_N[8]
* net 90 dataOut_E[16]
* net 91 dataOut_P[63]
* net 92 dataOut_N[61]
* net 93 dataIn_S[3]
* net 94 dataIn_S[6]
* net 95 dataOut_S[8]
* net 96 dataOut_W[10]
* net 97 dataIn_S[38]
* net 98 dataOut_S[5]
* net 99 dataOut_P[61]
* net 100 dataOut_S[62]
* net 101 dataOut_E[61]
* net 102 dataOut_S[11]
* net 103 dataIn_S[51]
* net 104 dataOut_S[51]
* net 105 dataOut_E[5]
* net 106 dataOut_N[16]
* net 107 dataOut_E[3]
* net 108 dataOut_S[56]
* net 109 dataIn_E[56]
* net 110 dataOut_P[11]
* net 111 dataOut_E[20]
* net 112 dataOut_E[56]
* net 113 dataOut_E[9]
* net 114 dataIn_S[34]
* net 115 dataIn_S[19]
* net 116 dataOut_P[20]
* net 117 dataIn_E[9]
* net 118 dataOut_S[4]
* net 119 dataOut_N[12]
* net 120 dataOut_S[16]
* net 121 dataOut_P[3]
* net 122 dataIn_E[53]
* net 123 dataIn_S[33]
* net 124 dataIn_E[61]
* net 125 dataIn_E[62]
* net 126 dataOut_N[19]
* net 127 dataOut_S[6]
* net 128 dataOut_W[14]
* net 129 dataIn_S[20]
* net 130 dataOut_E[0]
* net 131 dataOut_N[3]
* net 132 dataIn_E[8]
* net 133 dataIn_S[32]
* net 134 dataOut_W[11]
* net 135 dataOut_P[8]
* net 136 dataOut_N[63]
* net 137 dataIn_S[28]
* net 138 dataOut_P[7]
* net 139 dataOut_S[14]
* net 140 dataIn_S[26]
* net 141 dataIn_S[1]
* net 142 dataOut_S[17]
* net 143 dataOut_P[5]
* net 144 dataOut_S[0]
* net 145 dataOut_P[0]
* net 146 dataIn_E[54]
* net 147 dataOut_E[12]
* net 148 dataOut_S[19]
* net 149 dataOut_N[0]
* net 150 dataOut_W[12]
* net 151 dataOut_S[7]
* net 152 dataIn_S[24]
* net 153 dataIn_E[14]
* net 154 dataOut_P[6]
* net 155 dataIn_S[23]
* net 156 dataOut_E[7]
* net 157 dataOut_W[15]
* net 158 dataOut_S[61]
* net 159 dataIn_E[11]
* net 160 dataIn_S[47]
* net 161 dataOut_S[15]
* net 162 dataIn_S[9]
* net 163 dataOut_P[14]
* net 164 dataOut_E[19]
* net 165 dataIn_S[7]
* net 166 dataOut_N[11]
* net 167 dataOut_P[9]
* net 168 dataIn_E[58]
* net 169 dataOut_S[12]
* net 170 dataOut_E[6]
* net 171 dataOut_E[17]
* net 172 dataOut_N[17]
* net 173 dataIn_S[29]
* net 174 dataIn_S[37]
* net 175 dataIn_S[2]
* net 176 dataIn_S[25]
* net 177 dataIn_S[21]
* net 178 dataIn_E[7]
* net 179 dataOut_W[0]
* net 180 dataIn_E[50]
* net 181 dataOut_N[14]
* net 182 dataOut_P[17]
* net 183 dataOut_N[5]
* net 184 dataOut_E[14]
* net 185 dataOut_E[63]
* net 186 dataOut_N[9]
* net 187 dataIn_S[22]
* net 188 dataIn_S[30]
* net 189 dataOut_N[7]
* net 190 dataIn_S[35]
* net 191 dataOut_S[9]
* net 192 dataIn_E[57]
* net 193 dataIn_S[45]
* net 194 dataOut_N[20]
* net 195 dataOut_N[6]
* net 196 dataIn_E[52]
* net 197 dataOut_S[60]
* net 198 dataOut_E[8]
* net 199 dataOut_E[11]
* net 200 dataIn_S[36]
* net 201 dataIn_E[51]
* net 202 dataOut_P[15]
* net 203 dataIn_S[31]
* net 204 dataOut_S[59]
* net 205 dataOut_S[63]
* net 206 dataOut_P[19]
* net 207 dataIn_S[27]
* net 208 dataOut_P[12]
* net 219 PWELL
* net 320 NWELL
* net 664 dataIn_P[13]
* net 665 dataIn_P[11]
* net 1195 dataIn_E[15]
* net 1196 dataIn_E[0]
* net 1260 dataIn_E[18]
* net 1504 dataIn_E[17]
* net 1506 dataIn_E[13]
* net 1546 dataIn_P[16]
* net 1598 dataIn_E[12]
* net 1682 dataIn_E[27]
* net 1683 dataIn_E[22]
* net 1785 dataIn_E[16]
* net 1828 dataIn_P[17]
* net 1872 dataIn_E[10]
* net 1962 dataIn_E[24]
* net 1963 dataIn_E[1]
* net 1964 dataIn_E[20]
* net 2074 dataIn_E[26]
* net 2140 dataIn_P[10]
* net 2173 dataIn_E[6]
* net 2270 dataIn_E[4]
* net 2271 dataIn_E[19]
* net 2272 dataIn_E[21]
* net 2378 dataIn_E[25]
* net 2379 dataIn_E[23]
* net 2455 dataIn_S[57]
* net 2456 dataIn_P[14]
* net 2500 dataIn_E[41]
* net 2554 myChipID[4]
* net 2555 myChipID[2]
* net 2556 myChipID[12]
* net 2597 dataIn_E[49]
* net 2598 dataIn_E[3]
* net 2695 dataIn_E[2]
* net 2696 dataIn_E[33]
* net 2764 myChipID[11]
* net 2765 dataIn_P[25]
* net 2766 dataIn_P[15]
* net 2834 dataIn_E[29]
* net 2836 dataIn_E[28]
* net 2877 myChipID[0]
* net 2878 myChipID[13]
* net 2879 myChipID[10]
* net 2880 myChipID[3]
* net 2947 dataOut_W[61]
* net 2948 dataIn_E[47]
* net 3027 myChipID[1]
* net 3028 dataIn_P[1]
* net 3029 myChipID[5]
* net 3073 dataOut_W[57]
* net 3074 dataOut_W[5]
* net 3075 dataIn_E[36]
* net 3123 dataIn_P[18]
* net 3174 dataIn_E[38]
* net 3175 dataOut_W[56]
* net 3176 dataIn_W[13]
* net 3183 dataIn_E[30]
* net 3295 dataOut_W[55]
* net 3299 dataIn_E[48]
* net 3300 dataIn_W[11]
* net 3352 dataIn_P[26]
* net 3410 dataOut_W[54]
* net 3411 dataIn_E[43]
* net 3471 dataIn_N[17]
* net 3525 dataIn_E[46]
* net 3527 dataOut_W[19]
* net 3568 dataIn_N[16]
* net 3626 dataIn_W[10]
* net 3627 dataIn_E[35]
* net 3672 dataIn_P[12]
* net 3709 dataOut_W[59]
* net 3710 dataIn_W[55]
* net 3713 dataIn_E[42]
* net 3800 dataOut_S[18]
* net 3801 dataIn_W[16]
* net 3802 dataIn_E[39]
* net 3845 dataIn_P[21]
* net 3883 dataIn_E[34]
* net 3884 dataIn_E[44]
* net 3885 dataOut_W[16]
* net 3890 dataIn_E[40]
* net 3941 dataIn_N[13]
* net 3942 dataIn_P[56]
* net 4096 dataOut_W[17]
* net 4097 dataIn_W[15]
* net 4142 dataIn_P[0]
* net 4206 dataIn_E[32]
* net 4207 dataIn_W[0]
* net 4208 dataOut_W[18]
* net 4209 dataIn_W[17]
* net 4212 dataOut_W[20]
* net 4213 dataOut_E[15]
* net 4274 dataIn_P[60]
* net 4324 dataIn_W[14]
* net 4426 dataIn_E[31]
* net 4427 dataIn_E[37]
* net 4473 dataIn_N[11]
* net 4536 dataIn_E[45]
* net 4537 dataIn_W[12]
* net 4540 dataOut_N[15]
* net 4598 dataIn_P[8]
* net 4599 dataIn_P[9]
* net 4646 dataOut_N[18]
* net 4647 dataOut_E[18]
* net 4648 dataIn_W[18]
* net 4695 dataIn_P[62]
* net 4696 dataIn_P[61]
* net 4748 dataOut_P[18]
* net 4749 dataOut_W[9]
* net 4843 dataOut_S[1]
* net 4844 dataIn_W[9]
* net 4845 dataOut_W[8]
* net 4897 dataIn_N[59]
* net 4898 dataIn_P[63]
* net 4943 dataOut_W[1]
* net 4944 dataOut_W[63]
* net 4945 dataOut_E[1]
* net 4946 dataOut_W[58]
* net 4984 dataIn_P[6]
* net 5044 dataOut_W[6]
* net 5045 dataOut_P[1]
* net 5046 dataOut_N[1]
* net 5167 myChipID[9]
* net 5168 dataIn_W[7]
* net 5172 dataOut_W[7]
* net 5185 dataIn_P[5]
* net 5285 dataIn_W[6]
* net 5286 dataIn_W[58]
* net 5289 dataOut_W[3]
* net 5343 myChipID[8]
* net 5344 dataIn_N[58]
* net 5377 dataOut_W[33]
* net 5378 dataOut_W[21]
* net 5380 dataIn_W[63]
* net 5412 myChipID[7]
* net 5413 myChipID[6]
* net 5414 dataIn_P[7]
* net 5457 dataOut_S[21]
* net 5458 dataOut_E[21]
* net 5550 dataOut_P[21]
* net 5551 dataOut_N[21]
* net 5554 dataIn_W[8]
* net 5649 dataIn_W[1]
* net 5650 dataIn_W[59]
* net 5651 dataIn_W[62]
* net 5707 dataIn_N[57]
* net 5761 dataIn_W[21]
* net 5762 dataIn_W[5]
* net 5800 dataIn_P[59]
* net 5854 dataOut_E[33]
* net 5855 dataOut_N[33]
* net 5856 dataIn_W[56]
* net 5858 dataOut_S[33]
* net 5859 dataOut_P[33]
* net 5920 dataIn_P[55]
* net 5921 dataIn_P[28]
* net 5922 dataIn_P[2]
* net 5983 dataOut_S[2]
* net 5984 dataOut_E[2]
* net 6021 clk
* net 6088 dataOut_E[62]
* net 6089 dataIn_W[61]
* net 6093 dataOut_N[56]
* net 6205 dataIn_W[60]
* net 6206 dataIn_W[57]
* net 6262 dataIn_P[57]
* net 6312 dataOut_P[56]
* net 6313 dataOut_N[2]
* net 6402 dataOut_S[3]
* net 6403 dataOut_N[4]
* net 6404 dataOut_P[62]
* net 6452 dataIn_P[33]
* net 6482 dataOut_P[4]
* net 6483 dataOut_P[52]
* net 6557 dataOut_E[22]
* net 6558 dataOut_N[23]
* net 6560 dataOut_N[53]
* net 6605 dataIn_P[29]
* net 6645 dataIn_N[62]
* net 6646 dataOut_E[53]
* net 6747 dataOut_P[2]
* net 6748 dataIn_W[53]
* net 6749 dataOut_P[60]
* net 6847 dataOut_P[50]
* net 6848 dataOut_P[22]
* net 6896 dataIn_P[30]
* net 6965 dataOut_N[51]
* net 6966 dataOut_N[50]
* net 6967 dataOut_E[52]
* net 7013 dataIn_P[31]
* net 7073 dataOut_S[24]
* net 7074 dataIn_W[33]
* net 7075 dataIn_N[54]
* net 7076 dataOut_E[47]
* net 7168 dataOut_E[29]
* net 7169 dataOut_P[41]
* net 7170 dataOut_E[49]
* net 7173 dataOut_P[49]
* net 7211 dataIn_P[58]
* net 7297 dataOut_S[23]
* net 7298 dataOut_N[52]
* net 7421 dataIn_N[9]
* net 7422 dataOut_N[41]
* net 7423 dataOut_N[43]
* net 7533 dataOut_S[38]
* net 7534 dataIn_W[50]
* net 7535 dataIn_W[19]
* net 7576 dataIn_P[32]
* net 7643 dataOut_N[48]
* net 7644 dataOut_E[45]
* net 7645 dataIn_N[50]
* net 7646 dataIn_P[3]
* net 7703 dataIn_P[4]
* net 7754 dataOut_E[51]
* net 7755 dataOut_E[30]
* net 7756 dataOut_N[46]
* net 7854 dataOut_P[23]
* net 7855 dataOut_S[22]
* net 7856 dataOut_E[37]
* net 7964 dataOut_P[51]
* net 7965 dataOut_N[29]
* net 7966 dataOut_E[50]
* net 8011 dataIn_P[34]
* net 8079 dataOut_E[23]
* net 8080 dataIn_W[52]
* net 8081 dataIn_N[49]
* net 8201 dataOut_N[28]
* net 8202 dataOut_P[48]
* net 8203 dataOut_E[46]
* net 8302 dataIn_W[48]
* net 8303 dataOut_N[47]
* net 8399 dataIn_W[42]
* net 8400 dataOut_E[60]
* net 8401 dataOut_N[45]
* net 8402 dataOut_S[36]
* net 8505 dataIn_N[1]
* net 8506 dataIn_W[49]
* net 8507 dataOut_P[53]
* net 8522 dataIn_P[52]
* net 8613 dataOut_N[38]
* net 8614 dataOut_P[36]
* net 8615 dataOut_E[35]
* net 8617 dataOut_S[39]
* net 8618 dataOut_N[22]
* net 8723 dataIn_N[20]
* net 8724 dataIn_W[20]
* net 8738 dataIn_P[51]
* net 8845 dataOut_S[43]
* net 8846 dataOut_N[26]
* net 8880 dataIn_P[50]
* net 8906 dataIn_P[42]
* net 8963 dataIn_N[21]
* net 8964 dataOut_P[27]
* net 8965 dataIn_W[51]
* net 9030 dataIn_P[36]
* net 9080 dataOut_N[42]
* net 9081 dataOut_E[40]
* net 9082 dataOut_S[42]
* net 9192 dataIn_N[19]
* net 9193 dataOut_P[30]
* net 9194 dataOut_P[46]
* net 9195 dataIn_P[44]
* net 9222 dataIn_P[54]
* net 9341 dataOut_N[39]
* net 9342 dataIn_W[34]
* net 9343 dataIn_W[45]
* net 9344 dataIn_P[35]
* net 9449 dataOut_N[40]
* net 9450 dataOut_E[39]
* net 9451 dataOut_S[28]
* net 9524 dataIn_P[39]
* net 9585 dataOut_P[35]
* net 9586 dataOut_N[37]
* net 9587 dataIn_W[44]
* net 9635 dataIn_P[46]
* net 9688 dataOut_N[34]
* net 9689 dataIn_N[5]
* net 9690 dataIn_W[40]
* net 9691 dataOut_E[28]
* net 9804 dataOut_P[40]
* net 9805 dataOut_E[27]
* net 9806 dataIn_W[32]
* net 9892 dataOut_E[4]
* net 9893 dataIn_W[2]
* net 9915 dataIn_P[53]
* net 9981 dataOut_S[32]
* net 9982 dataOut_S[44]
* net 10073 dataIn_W[28]
* net 10074 dataOut_P[39]
* net 10125 dataIn_P[43]
* net 10163 dataOut_S[26]
* net 10164 dataIn_W[46]
* net 10165 dataIn_W[26]
* net 10273 dataIn_W[35]
* net 10274 dataOut_N[30]
* net 10275 dataOut_N[36]
* net 10381 dataIn_W[29]
* net 10510 dataOut_N[60]
* net 10511 dataOut_N[24]
* net 10512 dataOut_P[25]
* net 10513 dataIn_W[30]
* net 10610 dataIn_W[23]
* net 10611 dataOut_E[25]
* net 10612 dataOut_P[26]
* net 10718 dataOut_E[48]
* net 10719 dataIn_W[27]
* net 10817 dataOut_P[43]
* net 10823 dataOut_N[62]
* net 10824 dataOut_S[37]
* net 10825 dataOut_S[35]
* net 10914 dataOut_P[32]
* net 10991 dataOut_E[31]
* net 10992 dataIn_W[47]
* net 10994 dataOut_E[26]
* net 11086 dataOut_N[31]
* net 11087 dataOut_N[25]
* net 11088 dataOut_N[32]
* net 11098 dataIn_P[48]
* net 11099 dataIn_P[47]
* net 11100 dataIn_P[49]
* net 11176 dataOut_P[28]
* net 11177 dataOut_P[42]
* net 11178 dataOut_E[32]
* net 11261 dataOut_S[31]
* net 11262 dataOut_E[44]
* net 11263 dataIn_W[3]
* net 11302 dataIn_P[45]
* net 11347 dataOut_P[29]
* net 11348 dataOut_S[45]
* net 11426 dataOut_P[44]
* net 11427 dataIn_W[4]
* net 11428 dataOut_P[38]
* net 11429 dataOut_E[24]
* net 11514 dataOut_S[46]
* net 11515 dataOut_N[27]
* net 11516 dataIn_W[37]
* net 11519 dataIn_P[37]
* net 11583 dataIn_W[39]
* net 11584 dataIn_W[25]
* net 11585 dataOut_P[47]
* net 11586 dataIn_P[38]
* net 11623 dataIn_P[40]
* net 11666 dataOut_S[25]
* net 11667 dataOut_N[49]
* net 11668 dataOut_E[34]
* net 11720 dataOut_S[40]
* net 11721 dataOut_E[42]
* net 11722 dataOut_N[35]
* net 11723 dataOut_S[30]
* net 11724 dataIn_P[41]
* net 11776 dataIn_W[38]
* net 11777 dataIn_W[22]
* net 11778 dataOut_E[43]
* net 11824 dataOut_E[36]
* net 11825 dataOut_S[34]
* net 11884 dataIn_W[54]
* net 11885 dataOut_P[24]
* net 11928 dataIn_W[41]
* net 11929 dataOut_E[41]
* net 11930 dataOut_P[37]
* net 11931 dataIn_W[31]
* net 11932 dataIn_W[24]
* net 11994 dataOut_E[38]
* net 12030 dataOut_S[41]
* net 12031 dataOut_S[27]
* net 12032 dataOut_P[34]
* net 12033 dataOut_P[31]
* net 12100 dataOut_S[29]
* net 12101 dataOut_N[44]
* net 12102 dataIn_W[43]
* net 12156 dataIn_W[36]
* net 12157 dataOut_P[45]
* net 12369 dataIn_N[41]
* net 12370 dataOut_W[45]
* net 12371 dataOut_W[35]
* net 12372 dataOut_W[32]
* net 12377 yummyIn_S
* net 12380 myLocY[4]
* net 12383 myLocY[3]
* net 12384 myLocY[2]
* net 12385 dataIn_N[45]
* net 12386 dataIn_N[3]
* net 12387 dataIn_N[27]
* net 12388 dataIn_N[32]
* net 12390 dataIn_N[36]
* net 12391 dataIn_N[24]
* net 12392 dataOut_W[37]
* net 12393 myLocX[3]
* net 12394 validIn_N
* net 12395 dataOut_W[50]
* net 12396 yummyOut_E
* net 12397 validIn_E
* net 12398 yummyOut_W
* net 12399 myLocY[6]
* net 12400 reset_in
* net 12401 validIn_P
* net 12402 thanksIn_P
* net 12403 myLocY[7]
* net 12404 yummyOut_P
* net 12405 dataIn_N[38]
* net 12406 dataOut_W[25]
* net 12407 dataIn_N[44]
* net 12408 dataIn_N[42]
* net 12409 dataIn_N[39]
* net 12410 dataOut_W[24]
* net 12411 dataOut_W[28]
* net 12412 dataIn_N[40]
* net 12413 dataIn_N[46]
* net 12414 dataOut_W[26]
* net 12415 dataOut_W[27]
* net 12416 dataIn_N[53]
* net 12417 dataIn_N[60]
* net 12418 dataIn_N[47]
* net 12419 dataOut_W[2]
* net 12420 dataIn_N[35]
* net 12421 dataIn_N[4]
* net 12422 dataIn_N[34]
* net 12423 validOut_W
* net 12424 dataOut_W[23]
* net 12425 dataIn_N[29]
* net 12426 dataIn_N[23]
* net 12427 dataOut_W[22]
* net 12428 validOut_E
* net 12429 myLocX[2]
* net 12430 yummyIn_E
* net 12431 dataIn_N[28]
* net 12432 dataOut_W[30]
* net 12433 dataIn_N[33]
* net 12434 myLocX[1]
* net 12435 dataIn_N[30]
* net 12436 dataIn_N[31]
* net 12437 dataOut_W[29]
* net 12438 dataIn_N[26]
* net 12439 dataOut_W[31]
* net 12440 dataIn_N[25]
* net 12441 dataOut_W[52]
* net 12442 dataOut_W[34]
* net 12443 validOut_S
* net 12444 dataOut_W[39]
* net 12445 dataOut_W[41]
* net 12446 yummyOut_N
* net 12447 dataOut_W[36]
* net 12448 dataOut_S[49]
* net 12449 dataOut_W[53]
* net 12450 validOut_P
* net 12451 dataOut_W[40]
* net 12452 dataOut_W[4]
* net 12453 dataOut_W[49]
* net 12454 validIn_S
* net 12455 dataOut_W[47]
* net 12456 dataOut_S[47]
* net 12457 dataOut_W[42]
* net 12458 dataOut_W[60]
* net 12459 dataOut_W[43]
* net 12460 dataOut_W[38]
* net 12461 dataOut_W[44]
* net 12462 dataOut_W[46]
* net 12463 validOut_N
* net 12464 dataOut_W[51]
* net 12465 dataOut_W[62]
* net 12466 dataIn_N[37]
* net 12467 dataIn_N[48]
* net 12468 dataIn_N[51]
* net 12469 dataIn_N[43]
* net 12470 dataIn_N[52]
* net 12471 dataIn_N[6]
* net 12472 dataIn_N[55]
* net 12473 dataIn_N[2]
* net 12474 dataIn_N[7]
* net 12475 myLocX[5]
* net 12476 myLocX[4]
* net 12477 myLocX[0]
* net 12478 dataIn_N[22]
* net 12479 dataOut_S[48]
* net 12480 dataOut_W[48]
* net 12481 yummyIn_N
* net 12482 yummyIn_P
* net 12483 yummyOut_S
* net 12484 yummyIn_W
* net 12485 myLocY[0]
* net 12486 myLocX[7]
* net 12487 myLocX[6]
* net 12488 myLocY[5]
* net 12489 myLocY[1]
* net 12490 validIn_W
* cell instance $2 r0 *1 117.23,5.6
X$2 4074 219 320 1 BUF_X1
* cell instance $8 r0 *1 163.02,5.6
X$8 2 219 320 300 BUF_X1
* cell instance $17 r0 *1 58.9,47.6
X$17 3 219 320 1388 BUF_X1
* cell instance $20 m0 *1 64.98,64.4
X$20 4 219 320 2221 BUF_X1
* cell instance $26 r0 *1 73.15,44.8
X$26 5 219 320 1390 BUF_X1
* cell instance $32 m0 *1 81.32,47.6
X$32 6 219 320 1479 BUF_X1
* cell instance $38 r0 *1 83.22,36.4
X$38 7 219 320 1159 CLKBUF_X2
* cell instance $48 r0 *1 83.41,67.2
X$48 8 219 320 2465 BUF_X1
* cell instance $50 r0 *1 111.72,5.6
X$50 9 219 320 1441 BUF_X1
* cell instance $56 r0 *1 114.76,5.6
X$56 10 219 320 527 CLKBUF_X2
* cell instance $62 r0 *1 113.43,5.6
X$62 3556 219 320 11 BUF_X1
* cell instance $68 r0 *1 119.51,5.6
X$68 12 219 320 981 BUF_X1
* cell instance $74 r0 *1 114.19,5.6
X$74 439 219 320 13 BUF_X1
* cell instance $80 m0 *1 115.71,8.4
X$80 3221 219 320 14 BUF_X1
* cell instance $86 r0 *1 116.09,5.6
X$86 15 219 320 471 BUF_X1
* cell instance $92 r0 *1 116.66,5.6
X$92 938 219 320 16 BUF_X1
* cell instance $98 r0 *1 117.8,5.6
X$98 17 219 320 691 BUF_X1
* cell instance $104 r0 *1 118.37,5.6
X$104 18 219 320 284 BUF_X1
* cell instance $110 r0 *1 120.27,5.6
X$110 19 219 320 285 BUF_X1
* cell instance $116 r0 *1 118.94,5.6
X$116 220 219 320 20 BUF_X1
* cell instance $122 m0 *1 120.84,8.4
X$122 21 219 320 387 BUF_X1
* cell instance $128 m0 *1 125.02,8.4
X$128 22 219 320 337 BUF_X2
* cell instance $134 m0 *1 121.98,8.4
X$134 23 219 320 895 BUF_X1
* cell instance $140 r0 *1 120.27,8.4
X$140 2576 219 320 24 BUF_X1
* cell instance $146 r0 *1 121.79,5.6
X$146 2577 219 320 25 BUF_X1
* cell instance $152 r0 *1 123.12,5.6
X$152 26 219 320 697 BUF_X1
* cell instance $158 r0 *1 122.36,5.6
X$158 27 219 320 222 BUF_X2
* cell instance $164 r0 *1 123.69,5.6
X$164 28 219 320 347 BUF_X1
* cell instance $170 r0 *1 124.26,5.6
X$170 29 219 320 440 BUF_X2
* cell instance $176 m0 *1 125.78,8.4
X$176 30 219 320 1160 BUF_X2
* cell instance $182 r0 *1 128.25,5.6
X$182 31 219 320 223 BUF_X2
* cell instance $188 r0 *1 125.21,5.6
X$188 32 219 320 324 CLKBUF_X2
* cell instance $194 r0 *1 129.77,8.4
X$194 33 219 320 472 BUF_X1
* cell instance $200 r0 *1 125.97,5.6
X$200 34 219 320 442 BUF_X1
* cell instance $206 r0 *1 126.73,5.6
X$206 35 219 320 286 BUF_X1
* cell instance $212 m0 *1 130.53,8.4
X$212 36 219 320 338 BUF_X1
* cell instance $218 r0 *1 127.68,5.6
X$218 37 219 320 441 BUF_X1
* cell instance $224 r0 *1 129.01,5.6
X$224 38 219 320 1161 BUF_X2
* cell instance $230 r0 *1 131.48,5.6
X$230 39 219 320 567 BUF_X1
* cell instance $236 m0 *1 132.62,8.4
X$236 40 219 320 793 BUF_X1
* cell instance $242 r0 *1 129.96,5.6
X$242 41 219 320 1396 CLKBUF_X2
* cell instance $248 r0 *1 130.72,5.6
X$248 42 219 320 287 CLKBUF_X2
* cell instance $254 r0 *1 133.38,5.6
X$254 43 219 320 288 BUF_X1
* cell instance $260 r0 *1 132.05,5.6
X$260 44 219 320 760 CLKBUF_X2
* cell instance $266 m0 *1 133.19,8.4
X$266 390 219 320 45 BUF_X1
* cell instance $272 r0 *1 134.9,5.6
X$272 46 219 320 209 BUF_X1
* cell instance $278 r0 *1 134.14,5.6
X$278 47 219 320 340 BUF_X1
* cell instance $284 m0 *1 133.76,8.4
X$284 48 219 320 615 BUF_X1
* cell instance $290 m0 *1 134.9,8.4
X$290 391 219 320 49 BUF_X1
* cell instance $296 m0 *1 135.66,8.4
X$296 289 219 320 50 BUF_X1
* cell instance $302 r0 *1 135.66,8.4
X$302 393 219 320 51 BUF_X1
* cell instance $308 r0 *1 140.6,8.4
X$308 345 219 320 52 BUF_X1
* cell instance $314 m0 *1 140.03,8.4
X$314 53 219 320 399 BUF_X1
* cell instance $320 m0 *1 145.54,8.4
X$320 54 219 320 477 BUF_X1
* cell instance $326 r0 *1 139.84,5.6
X$326 55 219 320 344 CLKBUF_X2
* cell instance $332 m0 *1 139.46,8.4
X$332 56 219 320 342 BUF_X1
* cell instance $338 r0 *1 138.89,5.6
X$338 57 219 320 291 CLKBUF_X2
* cell instance $344 m0 *1 148.39,8.4
X$344 58 219 320 354 BUF_X1
* cell instance $350 m0 *1 140.6,8.4
X$350 59 219 320 346 BUF_X1
* cell instance $360 r0 *1 140.6,5.6
X$360 60 219 320 326 CLKBUF_X2
* cell instance $362 m0 *1 144.4,8.4
X$362 61 219 320 351 BUF_X1
* cell instance $368 r0 *1 141.74,5.6
X$368 62 219 320 327 CLKBUF_X2
* cell instance $374 r0 *1 149.72,5.6
X$374 233 219 320 63 BUF_X1
* cell instance $380 r0 *1 149.15,5.6
X$380 64 219 320 294 BUF_X1
* cell instance $386 m0 *1 144.97,8.4
X$386 402 219 320 65 BUF_X1
* cell instance $392 r0 *1 146.3,5.6
X$392 228 219 320 66 BUF_X1
* cell instance $398 r0 *1 145.73,5.6
X$398 226 219 320 67 BUF_X1
* cell instance $404 m0 *1 146.11,8.4
X$404 403 219 320 68 BUF_X1
* cell instance $410 r0 *1 146.87,5.6
X$410 229 219 320 69 BUF_X1
* cell instance $416 r0 *1 150.86,5.6
X$416 235 219 320 70 BUF_X1
* cell instance $422 r0 *1 147.44,5.6
X$422 232 219 320 71 BUF_X1
* cell instance $428 r0 *1 148.01,5.6
X$428 449 219 320 72 BUF_X1
* cell instance $434 r0 *1 150.29,5.6
X$434 234 219 320 73 BUF_X1
* cell instance $440 m0 *1 153.9,11.2
X$440 485 219 320 74 BUF_X1
* cell instance $446 r0 *1 148.58,5.6
X$446 231 219 320 75 BUF_X1
* cell instance $452 m0 *1 152.38,8.4
X$452 406 219 320 76 BUF_X1
* cell instance $458 r0 *1 154.85,5.6
X$458 77 219 320 332 BUF_X1
* cell instance $464 r0 *1 157.13,5.6
X$464 238 219 320 78 BUF_X1
* cell instance $470 r0 *1 157.7,5.6
X$470 239 219 320 79 BUF_X1
* cell instance $476 r0 *1 155.42,5.6
X$476 237 219 320 80 BUF_X1
* cell instance $482 m0 *1 154.28,8.4
X$482 81 219 320 408 BUF_X1
* cell instance $488 r0 *1 153.14,8.4
X$488 407 219 320 82 BUF_X1
* cell instance $494 m0 *1 155.42,8.4
X$494 412 219 320 83 BUF_X1
* cell instance $500 m0 *1 154.85,8.4
X$500 84 219 320 413 BUF_X1
* cell instance $506 r0 *1 154.47,8.4
X$506 411 219 320 85 BUF_X1
* cell instance $512 m0 *1 155.99,8.4
X$512 86 219 320 358 BUF_X1
* cell instance $518 r0 *1 156.37,5.6
X$518 87 219 320 297 CLKBUF_X2
* cell instance $524 r0 *1 162.45,5.6
X$524 242 219 320 88 BUF_X1
* cell instance $530 r0 *1 158.27,5.6
X$530 240 219 320 89 BUF_X1
* cell instance $536 r0 *1 164.73,5.6
X$536 246 219 320 90 BUF_X1
* cell instance $542 m0 *1 161.31,8.4
X$542 418 219 320 91 BUF_X1
* cell instance $548 m0 *1 161.88,8.4
X$548 419 219 320 92 BUF_X1
* cell instance $554 r0 *1 162.26,8.4
X$554 93 219 320 731 BUF_X1
* cell instance $560 m0 *1 162.45,8.4
X$560 94 219 320 506 BUF_X1
* cell instance $566 m0 *1 163.59,8.4
X$566 422 219 320 95 BUF_X1
* cell instance $572 r0 *1 163.59,5.6
X$572 245 219 320 96 BUF_X1
* cell instance $578 r0 *1 165.3,8.4
X$578 97 219 320 435 BUF_X1
* cell instance $584 m0 *1 163.02,8.4
X$584 423 219 320 98 BUF_X1
* cell instance $590 r0 *1 163.4,8.4
X$590 426 219 320 99 BUF_X1
* cell instance $596 r0 *1 164.16,5.6
X$596 244 219 320 100 BUF_X1
* cell instance $602 m0 *1 164.16,8.4
X$602 425 219 320 101 BUF_X1
* cell instance $608 r0 *1 164.73,8.4
X$608 491 219 320 102 BUF_X1
* cell instance $614 m0 *1 162.07,11.2
X$614 103 219 320 489 BUF_X1
* cell instance $620 r0 *1 167.39,8.4
X$620 494 219 320 104 BUF_X1
* cell instance $626 r0 *1 171.57,5.6
X$626 251 219 320 105 BUF_X1
* cell instance $632 m0 *1 167.39,11.2
X$632 495 219 320 106 BUF_X1
* cell instance $638 r0 *1 169.29,8.4
X$638 496 219 320 107 BUF_X1
* cell instance $644 m0 *1 170.05,8.4
X$644 433 219 320 108 BUF_X1
* cell instance $650 r0 *1 168.53,5.6
X$650 109 219 320 336 BUF_X1
* cell instance $656 m0 *1 169.48,8.4
X$656 432 219 320 110 BUF_X1
* cell instance $662 r0 *1 170.43,5.6
X$662 248 219 320 111 BUF_X1
* cell instance $668 r0 *1 179.55,5.6
X$668 259 219 320 112 BUF_X1
* cell instance $674 m0 *1 170.62,8.4
X$674 436 219 320 113 BUF_X1
* cell instance $680 r0 *1 173.28,5.6
X$680 114 219 320 453 BUF_X1
* cell instance $686 r0 *1 172.14,5.6
X$686 115 219 320 301 BUF_X1
* cell instance $692 r0 *1 172.71,5.6
X$692 252 219 320 116 BUF_X1
* cell instance $698 r0 *1 181.26,5.6
X$698 117 219 320 329 BUF_X1
* cell instance $704 r0 *1 173.85,5.6
X$704 253 219 320 118 BUF_X1
* cell instance $710 r0 *1 176.32,5.6
X$710 255 219 320 119 BUF_X1
* cell instance $716 r0 *1 171,5.6
X$716 250 219 320 120 BUF_X1
* cell instance $722 r0 *1 175.18,5.6
X$722 254 219 320 121 BUF_X1
* cell instance $728 r0 *1 175.75,5.6
X$728 122 219 320 334 BUF_X1
* cell instance $734 m0 *1 181.26,8.4
X$734 123 219 320 367 BUF_X1
* cell instance $740 m0 *1 176.13,8.4
X$740 124 219 320 437 BUF_X1
* cell instance $746 r0 *1 177.27,5.6
X$746 125 219 320 304 BUF_X1
* cell instance $752 r0 *1 177.84,5.6
X$752 257 219 320 126 BUF_X1
* cell instance $758 r0 *1 178.98,5.6
X$758 258 219 320 127 BUF_X1
* cell instance $764 r0 *1 184.68,5.6
X$764 269 219 320 128 BUF_X1
* cell instance $770 r0 *1 178.41,5.6
X$770 129 219 320 333 BUF_X1
* cell instance $776 r0 *1 182.97,5.6
X$776 265 219 320 130 BUF_X1
* cell instance $782 r0 *1 180.69,5.6
X$782 260 219 320 131 BUF_X1
* cell instance $788 m0 *1 189.81,8.4
X$788 132 219 320 416 BUF_X1
* cell instance $794 r0 *1 188.48,5.6
X$794 133 219 320 211 BUF_X1
* cell instance $800 r0 *1 180.12,5.6
X$800 261 219 320 134 BUF_X1
* cell instance $806 r0 *1 181.83,5.6
X$806 262 219 320 135 BUF_X1
* cell instance $812 r0 *1 182.4,5.6
X$812 264 219 320 136 BUF_X1
* cell instance $818 m0 *1 191.14,8.4
X$818 137 219 320 369 BUF_X1
* cell instance $824 r0 *1 184.11,5.6
X$824 268 219 320 138 BUF_X1
* cell instance $830 r0 *1 187.91,5.6
X$830 271 219 320 139 BUF_X1
* cell instance $836 r0 *1 183.54,5.6
X$836 140 219 320 366 BUF_X1
* cell instance $842 r0 *1 186.58,5.6
X$842 141 219 320 330 BUF_X1
* cell instance $848 m0 *1 184.3,8.4
X$848 456 219 320 142 BUF_X1
* cell instance $858 r0 *1 187.34,5.6
X$858 270 219 320 143 BUF_X1
* cell instance $860 m0 *1 188.1,8.4
X$860 428 219 320 144 BUF_X1
* cell instance $866 r0 *1 188.29,8.4
X$866 424 219 320 145 BUF_X1
* cell instance $872 r0 *1 189.05,5.6
X$872 146 219 320 810 CLKBUF_X2
* cell instance $880 m0 *1 189.24,8.4
X$880 420 219 320 147 BUF_X1
* cell instance $884 r0 *1 189.81,5.6
X$884 272 219 320 148 BUF_X1
* cell instance $890 m0 *1 190.38,8.4
X$890 417 219 320 149 BUF_X1
* cell instance $896 r0 *1 191.14,5.6
X$896 274 219 320 150 BUF_X1
* cell instance $902 r0 *1 191.71,5.6
X$902 275 219 320 151 BUF_X1
* cell instance $908 r0 *1 199.31,5.6
X$908 152 219 320 313 BUF_X1
* cell instance $914 m0 *1 198.74,8.4
X$914 153 219 320 530 BUF_X1
* cell instance $920 m0 *1 188.67,8.4
X$920 421 219 320 154 BUF_X1
* cell instance $926 r0 *1 194.37,5.6
X$926 155 219 320 310 BUF_X1
* cell instance $932 r0 *1 190.38,5.6
X$932 273 219 320 156 BUF_X1
* cell instance $938 m0 *1 194.94,8.4
X$938 409 219 320 157 BUF_X1
* cell instance $944 r0 *1 192.85,5.6
X$944 276 219 320 158 BUF_X1
* cell instance $950 m0 *1 203.3,8.4
X$950 159 219 320 404 BUF_X1
* cell instance $956 r0 *1 193.42,5.6
X$956 160 219 320 328 CLKBUF_X2
* cell instance $962 r0 *1 197.03,5.6
X$962 278 219 320 161 BUF_X1
* cell instance $968 r0 *1 197.6,5.6
X$968 162 219 320 312 BUF_X1
* cell instance $974 r0 *1 196.46,5.6
X$974 277 219 320 163 BUF_X1
* cell instance $980 r0 *1 198.74,5.6
X$980 213 219 320 164 BUF_X1
* cell instance $986 m0 *1 199.88,8.4
X$986 165 219 320 372 BUF_X1
* cell instance $992 r0 *1 199.88,5.6
X$992 281 219 320 166 BUF_X1
* cell instance $998 r0 *1 198.17,5.6
X$998 279 219 320 167 BUF_X1
* cell instance $1004 m0 *1 201.4,8.4
X$1004 168 219 320 587 BUF_X1
* cell instance $1010 r0 *1 201.02,5.6
X$1010 282 219 320 169 BUF_X1
* cell instance $1016 r0 *1 201.59,5.6
X$1016 283 219 320 170 BUF_X1
* cell instance $1022 r0 *1 202.73,5.6
X$1022 280 219 320 171 BUF_X1
* cell instance $1028 r0 *1 202.16,5.6
X$1028 214 219 320 172 BUF_X1
* cell instance $1034 r0 *1 204.25,5.6
X$1034 173 219 320 315 BUF_X1
* cell instance $1040 r0 *1 200.45,5.6
X$1040 174 219 320 373 BUF_X1
* cell instance $1046 r0 *1 203.49,5.6
X$1046 175 219 320 635 BUF_X1
* cell instance $1052 r0 *1 206.15,5.6
X$1052 176 219 320 316 BUF_X1
* cell instance $1058 r0 *1 205.58,5.6
X$1058 177 219 320 212 BUF_X1
* cell instance $1064 r0 *1 204.82,5.6
X$1064 178 219 320 682 BUF_X1
* cell instance $1070 r0 *1 207.67,5.6
X$1070 266 219 320 179 BUF_X1
* cell instance $1076 r0 *1 206.91,5.6
X$1076 180 219 320 317 BUF_X2
* cell instance $1082 m0 *1 208.43,8.4
X$1082 396 219 320 181 BUF_X1
* cell instance $1090 m0 *1 209.19,8.4
X$1090 397 219 320 182 BUF_X1
* cell instance $1094 r0 *1 208.43,5.6
X$1094 267 219 320 183 BUF_X1
* cell instance $1100 r0 *1 209.57,5.6
X$1100 215 219 320 184 BUF_X1
* cell instance $1106 r0 *1 209,5.6
X$1106 263 219 320 185 BUF_X1
* cell instance $1112 r0 *1 210.14,5.6
X$1112 256 219 320 186 BUF_X1
* cell instance $1118 r0 *1 217.74,5.6
X$1118 187 219 320 523 BUF_X1
* cell instance $1124 r0 *1 213.94,5.6
X$1124 188 219 320 323 BUF_X1
* cell instance $1130 m0 *1 216.98,8.4
X$1130 385 219 320 189 BUF_X1
* cell instance $1136 r0 *1 214.51,5.6
X$1136 190 219 320 386 BUF_X1
* cell instance $1142 r0 *1 215.84,5.6
X$1142 243 219 320 191 BUF_X1
* cell instance $1148 r0 *1 215.08,5.6
X$1148 192 219 320 322 CLKBUF_X2
* cell instance $1154 r0 *1 216.41,5.6
X$1154 193 219 320 217 BUF_X1
* cell instance $1160 m0 *1 216.41,8.4
X$1160 384 219 320 194 BUF_X1
* cell instance $1166 m0 *1 215.84,8.4
X$1166 388 219 320 195 BUF_X1
* cell instance $1172 r0 *1 216.98,5.6
X$1172 196 219 320 236 BUF_X2
* cell instance $1178 r0 *1 218.31,5.6
X$1178 230 219 320 197 BUF_X1
* cell instance $1184 r0 *1 218.88,5.6
X$1184 227 219 320 198 BUF_X1
* cell instance $1190 r0 *1 219.26,8.4
X$1190 468 219 320 199 BUF_X1
* cell instance $1196 r0 *1 220.97,5.6
X$1196 200 219 320 321 BUF_X1
* cell instance $1202 r0 *1 220.21,5.6
X$1202 201 219 320 224 BUF_X2
* cell instance $1208 r0 *1 219.45,5.6
X$1208 225 219 320 202 BUF_X1
* cell instance $1214 r0 *1 222.11,5.6
X$1214 203 219 320 750 BUF_X1
* cell instance $1220 r0 *1 221.54,5.6
X$1220 221 219 320 204 BUF_X1
* cell instance $1226 m0 *1 222.3,8.4
X$1226 381 219 320 205 BUF_X1
* cell instance $1232 r0 *1 222.68,5.6
X$1232 218 219 320 206 BUF_X1
* cell instance $1238 r0 *1 223.82,5.6
X$1238 207 219 320 319 BUF_X1
* cell instance $1244 r0 *1 223.25,5.6
X$1244 467 219 320 208 BUF_X1
* cell instance $1250 m0 *1 142.5,44.8
X$1250 209 903 1229 219 320 1270 MUX2_X1
* cell instance $1252 r0 *1 143.83,42
X$1252 209 902 1231 219 320 1275 MUX2_X1
* cell instance $1254 m0 *1 143.45,36.4
X$1254 209 851 984 219 320 1074 MUX2_X1
* cell instance $1257 r0 *1 141.36,39.2
X$1257 209 900 1089 219 320 1135 MUX2_X1
* cell instance $1271 r0 *1 142.69,8.4
X$1271 347 349 292 219 320 210 MUX2_X1
* cell instance $1273 r0 *1 142.5,5.6
X$1273 219 14239 292 210 295 320 DFF_X1
* cell instance $1276 r0 *1 192.28,16.8
X$1276 211 631 645 219 320 644 MUX2_X1
* cell instance $1278 r0 *1 195.13,19.6
X$1278 211 680 681 219 320 702 MUX2_X1
* cell instance $1281 m0 *1 190.95,19.6
X$1281 211 632 633 219 320 647 MUX2_X1
* cell instance $1284 m0 *1 191.52,22.4
X$1284 211 684 708 219 320 712 MUX2_X1
* cell instance $1291 r0 *1 191.71,8.4
X$1291 212 305 370 219 320 309 MUX2_X1
* cell instance $1294 m0 *1 188.48,11.2
X$1294 212 378 483 219 320 484 MUX2_X1
* cell instance $1296 r0 *1 190.19,8.4
X$1296 212 462 517 219 320 368 MUX2_X1
* cell instance $1301 r0 *1 195.13,5.6
X$1301 212 302 311 219 320 410 MUX2_X1
* cell instance $1307 m0 *1 196.84,92.4
X$1307 4111 3702 219 320 213 NOR2_X2
* cell instance $1311 m0 *1 176.7,78.4
X$1311 219 214 3058 2930 3453 320 AOI21_X4
* cell instance $1320 r0 *1 195.89,86.8
X$1320 3814 3702 219 320 215 NOR2_X2
* cell instance $1326 m0 *1 210.52,8.4
X$1326 316 302 247 219 320 216 MUX2_X1
* cell instance $1328 r0 *1 210.71,5.6
X$1328 219 14126 247 216 318 320 DFF_X1
* cell instance $1331 m0 *1 188.29,42
X$1331 217 803 1180 219 320 1179 MUX2_X1
* cell instance $1334 m0 *1 184.3,42
X$1334 217 802 1177 219 320 1240 MUX2_X1
* cell instance $1337 m0 *1 187.72,39.2
X$1337 217 801 1106 219 320 1151 MUX2_X1
* cell instance $1340 m0 *1 189.05,39.2
X$1340 217 808 1107 219 320 1150 MUX2_X1
* cell instance $1347 r0 *1 196.65,92.4
X$1347 4309 3725 219 320 218 NOR2_X2
* cell instance $1355 m0 *1 154.85,193.2
X$1355 10851 10787 10887 320 10788 219 OAI21_X1
* cell instance $1357 m0 *1 155.61,193.2
X$1357 10788 10789 219 320 10852 NAND2_X1
* cell instance $1358 m0 *1 156.18,193.2
X$1358 10789 10684 219 320 10790 NAND2_X1
* cell instance $1359 m0 *1 156.75,193.2
X$1359 10762 10891 10794 219 10682 320 AOI21_X1
* cell instance $1360 m0 *1 157.51,193.2
X$1360 10683 10787 10684 219 320 10791 NOR3_X1
* cell instance $1361 m0 *1 158.27,193.2
X$1361 9318 10762 219 320 10893 NAND2_X1
* cell instance $1362 m0 *1 158.84,193.2
X$1362 10787 10789 219 320 10792 NAND2_X1
* cell instance $1363 m0 *1 159.41,193.2
X$1363 10792 10793 10693 10896 320 219 10855 OAI22_X1
* cell instance $1364 m0 *1 160.36,193.2
X$1364 10757 9318 10762 219 10851 320 AOI21_X1
* cell instance $1366 m0 *1 161.31,193.2
X$1366 219 10763 10795 10855 10115 320 DFF_X1
* cell instance $1370 m0 *1 167.01,193.2
X$1370 10856 219 320 10689 BUF_X2
* cell instance $1371 m0 *1 167.77,193.2
X$1371 10689 11036 10470 10413 10766 219 320 OAI211_X2
* cell instance $1372 m0 *1 169.48,193.2
X$1372 10796 10797 10799 320 10798 219 OAI21_X1
* cell instance $1373 m0 *1 170.24,193.2
X$1373 10854 10767 10471 10580 10898 320 219 AOI211_X2
* cell instance $1374 m0 *1 171.95,193.2
X$1374 10853 10800 219 320 10854 NAND2_X1
* cell instance $1376 m0 *1 172.71,193.2
X$1376 10801 10316 10665 10220 219 320 10800 AOI22_X1
* cell instance $1377 m0 *1 173.66,193.2
X$1377 10664 10802 10850 320 10692 219 OAI21_X1
* cell instance $1378 m0 *1 174.42,193.2
X$1378 10803 10220 10802 219 320 10804 OR3_X1
* cell instance $1379 m0 *1 175.37,193.2
X$1379 10582 10764 10804 219 10805 320 AOI21_X1
* cell instance $1380 m0 *1 176.13,193.2
X$1380 10477 10849 10151 219 320 10850 NAND3_X1
* cell instance $1383 m0 *1 140.79,193.2
X$1383 219 13059 10786 10847 10112 320 DFF_X1
* cell instance $1387 r0 *1 140.6,193.2
X$1387 10884 3238 219 320 10847 NOR2_X1
* cell instance $1388 r0 *1 141.17,193.2
X$1388 10968 10941 219 320 10884 XOR2_X1
* cell instance $1390 m0 *1 145.35,193.2
X$1390 219 13060 10942 7112 10112 320 DFF_X1
* cell instance $1394 r0 *1 145.54,193.2
X$1394 10885 10942 320 10943 219 XOR2_X2
* cell instance $1395 r0 *1 147.25,193.2
X$1395 10946 219 320 9425 CLKBUF_X3
* cell instance $1396 r0 *1 148.2,193.2
X$1396 10943 10064 219 320 7112 NOR2_X2
* cell instance $1397 m0 *1 149.15,193.2
X$1397 10043 10466 219 320 10848 OR2_X1
* cell instance $1401 m0 *1 150.48,193.2
X$1401 10681 6341 10848 219 320 10945 MUX2_X1
* cell instance $1406 r0 *1 150.86,193.2
X$1406 10886 7251 2676 219 320 NOR2_X4
* cell instance $1409 m0 *1 152.95,193.2
X$1409 10752 320 10787 219 BUF_X4
* cell instance $1411 r0 *1 154.85,193.2
X$1411 10888 10889 219 320 10887 NOR2_X1
* cell instance $1412 r0 *1 155.42,193.2
X$1412 10889 9930 10888 219 10890 320 AOI21_X1
* cell instance $1413 r0 *1 156.18,193.2
X$1413 10890 10897 3233 320 10891 219 OAI21_X1
* cell instance $1414 r0 *1 156.94,193.2
X$1414 10894 10892 219 320 10789 NOR2_X2
* cell instance $1415 r0 *1 157.89,193.2
X$1415 10888 10791 10789 320 10947 219 OAI21_X1
* cell instance $1416 r0 *1 158.65,193.2
X$1416 10945 10893 10894 219 320 10949 NOR3_X1
* cell instance $1417 r0 *1 159.41,193.2
X$1417 10757 10948 10973 219 10793 320 AOI21_X1
* cell instance $1418 r0 *1 160.17,193.2
X$1418 10949 10888 10894 219 10896 320 AOI21_X1
* cell instance $1419 r0 *1 160.93,193.2
X$1419 9479 219 320 10794 BUF_X2
* cell instance $1420 r0 *1 161.69,193.2
X$1420 10894 10472 10757 219 320 10754 NAND3_X1
* cell instance $1421 r0 *1 162.45,193.2
X$1421 11219 10897 4631 320 10948 219 OAI21_X1
* cell instance $1423 r0 *1 163.59,193.2
X$1423 219 10856 10951 10950 10975 320 DFF_X1
* cell instance $1424 r0 *1 166.82,193.2
X$1424 10951 219 320 10579 BUF_X1
* cell instance $1425 r0 *1 167.39,193.2
X$1425 219 10324 10976 10690 10686 320 AOI21_X4
* cell instance $1426 r0 *1 169.86,193.2
X$1426 10688 10798 10898 219 10950 320 AOI21_X1
* cell instance $1427 r0 *1 170.62,193.2
X$1427 219 10977 11035 10123 10689 320 AOI21_X4
* cell instance $1428 r0 *1 173.09,193.2
X$1428 10579 10260 219 320 10801 NAND2_X1
* cell instance $1429 r0 *1 173.66,193.2
X$1429 10803 219 320 10693 CLKBUF_X3
* cell instance $1430 r0 *1 174.61,193.2
X$1430 10151 219 320 10694 INV_X1
* cell instance $1431 r0 *1 174.99,193.2
X$1431 10805 10324 10944 219 320 10900 MUX2_X1
* cell instance $1435 r0 *1 176.32,193.2
X$1435 10474 10314 320 219 10944 AND2_X1
* cell instance $1437 m0 *1 178.22,193.2
X$1437 9672 219 320 4307 INV_X4
* cell instance $1440 m0 *1 179.93,193.2
X$1440 10806 4135 10755 219 10807 320 AOI21_X1
* cell instance $1441 m0 *1 180.69,193.2
X$1441 10807 10808 10658 10846 10588 320 219 AOI211_X2
* cell instance $1442 m0 *1 182.4,193.2
X$1442 10809 10693 219 320 10697 NOR2_X1
* cell instance $1444 m0 *1 183.16,193.2
X$1444 10585 219 320 10809 INV_X1
* cell instance $1446 m0 *1 183.73,193.2
X$1446 10482 10806 7740 219 10811 320 AOI21_X2
* cell instance $1449 r0 *1 178.98,193.2
X$1449 10015 219 320 10901 INV_X1
* cell instance $1450 r0 *1 179.36,193.2
X$1450 10483 219 320 CLKBUF_X1
* cell instance $1451 r0 *1 179.93,193.2
X$1451 9383 219 320 10483 CLKBUF_X3
* cell instance $1452 r0 *1 180.88,193.2
X$1452 10591 10585 10696 10015 219 320 10939 AOI22_X1
* cell instance $1453 r0 *1 181.83,193.2
X$1453 10901 10809 10938 10892 10981 10939 219 320 10846 OAI33_X1
* cell instance $1454 r0 *1 183.16,193.2
X$1454 10596 10806 219 320 10981 NAND2_X1
* cell instance $1455 r0 *1 183.73,193.2
X$1455 10482 10596 10153 10806 219 320 10938 AOI22_X1
* cell instance $1457 r0 *1 185.06,193.2
X$1457 10809 11075 3222 219 320 10902 NAND3_X1
* cell instance $1459 m0 *1 185.44,193.2
X$1459 10587 10811 10843 219 10701 320 AOI21_X1
* cell instance $1460 r0 *1 185.82,193.2
X$1460 219 10015 10591 10596 7740 10482 10806 10984 320 OAI222_X2
* cell instance $1462 m0 *1 186.58,193.2
X$1462 10596 10806 10696 219 320 10843 NAND3_X1
* cell instance $1464 m0 *1 187.72,193.2
X$1464 10651 219 320 10696 CLKBUF_X3
* cell instance $1466 r0 *1 188.67,193.2
X$1466 219 11024 10707 10934 10935 320 AOI21_X4
* cell instance $1468 m0 *1 189.05,193.2
X$1468 9522 10702 6582 320 219 11078 MUX2_X2
* cell instance $1470 m0 *1 191.33,193.2
X$1470 10705 10813 10812 219 320 NOR2_X4
* cell instance $1472 m0 *1 193.04,193.2
X$1472 9560 6582 10705 320 10903 219 NOR3_X2
* cell instance $1473 m0 *1 194.37,193.2
X$1473 6498 8259 11020 219 10933 320 AOI21_X2
* cell instance $1474 m0 *1 195.7,193.2
X$1474 10813 6498 9560 219 320 10814 MUX2_X1
* cell instance $1475 m0 *1 197.03,193.2
X$1475 219 10376 10814 10646 10316 320 NOR3_X4
* cell instance $1477 r0 *1 191.33,193.2
X$1477 10705 6582 9560 219 320 10934 OR3_X2
* cell instance $1479 r0 *1 192.66,193.2
X$1479 10986 10903 10933 320 219 10806 OAI21_X4
* cell instance $1481 r0 *1 195.51,193.2
X$1481 10987 10906 6582 320 219 10904 MUX2_X2
* cell instance $1482 r0 *1 197.22,193.2
X$1482 10905 10376 10813 219 320 10906 NOR3_X1
* cell instance $1484 r0 *1 198.36,193.2
X$1484 219 10929 11014 8659 10840 320 DFF_X2
* cell instance $1485 m0 *1 201.02,193.2
X$1485 219 8470 8518 8709 10840 10841 320 NOR4_X4
* cell instance $1486 m0 *1 200.07,193.2
X$1486 10841 10742 320 219 9474 AND2_X2
* cell instance $1488 m0 *1 207.48,193.2
X$1488 10709 10633 219 320 10815 NOR2_X1
* cell instance $1489 m0 *1 208.05,193.2
X$1489 10710 10633 10815 10712 10711 10538 320 219 AOI221_X2
* cell instance $1490 m0 *1 210.14,193.2
X$1490 10633 10709 10601 219 320 10734 OR3_X1
* cell instance $1491 m0 *1 211.09,193.2
X$1491 10816 10601 320 219 10602 XNOR2_X1
* cell instance $1492 m0 *1 212.23,193.2
X$1492 10816 10633 219 320 10731 NAND2_X1
* cell instance $1498 r0 *1 206.15,193.2
X$1498 9976 219 320 9818 CLKBUF_X3
* cell instance $1499 r0 *1 207.1,193.2
X$1499 9818 219 320 14721 INV_X2
* cell instance $1502 r0 *1 208.62,193.2
X$1502 10634 10907 219 320 10908 NOR2_X1
* cell instance $1505 r0 *1 210.14,193.2
X$1505 10633 219 320 10909 INV_X1
* cell instance $1507 m0 *1 217.17,193.2
X$1507 10837 219 320 10601 BUF_X1
* cell instance $1508 m0 *1 213.94,193.2
X$1508 219 13449 10837 10713 9978 320 DFF_X1
* cell instance $1509 m0 *1 217.74,193.2
X$1509 11006 219 320 6477 CLKBUF_X3
* cell instance $1511 m0 *1 218.88,193.2
X$1511 6477 320 10377 219 BUF_X4
* cell instance $1515 m0 *1 222.68,193.2
X$1515 10716 10069 10910 219 320 10504 MUX2_X1
* cell instance $1518 m0 *1 226.29,193.2
X$1518 219 13549 10716 10834 10717 320 DFF_X1
* cell instance $1520 m0 *1 229.71,193.2
X$1520 9228 219 320 10825 BUF_X1
* cell instance $1525 r0 *1 221.92,193.2
X$1525 219 14270 10910 10925 11004 320 DFF_X1
* cell instance $1526 r0 *1 225.15,193.2
X$1526 10607 7291 10910 219 320 10925 MUX2_X1
* cell instance $1529 r0 *1 228.38,193.2
X$1529 219 14690 11001 11003 10717 320 DFF_X1
* cell instance $1530 m0 *1 231.23,193.2
X$1530 10620 9801 10818 219 320 10728 MUX2_X1
* cell instance $1531 m0 *1 230.66,193.2
X$1531 8255 219 320 10817 BUF_X1
* cell instance $1532 m0 *1 232.56,193.2
X$1532 219 12593 10818 10819 10616 320 DFF_X1
* cell instance $1533 m0 *1 235.79,193.2
X$1533 10515 7291 10721 219 320 10724 MUX2_X1
* cell instance $1534 m0 *1 237.12,193.2
X$1534 10609 10820 10721 219 320 10822 MUX2_X1
* cell instance $1535 m0 *1 238.45,193.2
X$1535 10719 219 320 10821 BUF_X1
* cell instance $1536 m0 *1 239.02,193.2
X$1536 10610 219 320 10828 BUF_X1
* cell instance $1537 m0 *1 239.59,193.2
X$1537 10384 219 320 10512 BUF_X1
* cell instance $1538 m0 *1 240.16,193.2
X$1538 10388 219 320 10611 BUF_X1
* cell instance $1544 r0 *1 231.99,193.2
X$1544 9447 219 320 10717 CLKBUF_X3
* cell instance $1545 r0 *1 232.94,193.2
X$1545 10608 7291 10818 219 320 10819 MUX2_X1
* cell instance $1546 r0 *1 234.27,193.2
X$1546 10821 5995 10990 219 320 10912 MUX2_X1
* cell instance $1547 r0 *1 235.6,193.2
X$1547 6308 219 320 10823 BUF_X1
* cell instance $1549 r0 *1 236.36,193.2
X$1549 8515 219 320 10824 BUF_X1
* cell instance $1552 r0 *1 237.5,193.2
X$1552 219 13730 10913 10916 10717 320 DFF_X1
* cell instance $1554 m0 *1 201.78,226.8
X$1554 12159 12152 12154 219 320 12201 NAND3_X1
* cell instance $1556 m0 *1 202.54,226.8
X$1556 219 12200 12094 12201 12302 320 DFF_X1
* cell instance $1566 r0 *1 201.78,226.8
X$1566 12151 12249 12160 12090 219 320 12155 NAND4_X1
* cell instance $1568 r0 *1 203.49,226.8
X$1568 12200 219 320 12160 BUF_X2
* cell instance $1579 m0 *1 182.02,112
X$1579 4523 5274 1444 3468 320 219 5332 OAI22_X2
* cell instance $1580 m0 *1 180.31,112
X$1580 4883 5275 1030 3280 320 219 5272 OAI22_X2
* cell instance $1582 m0 *1 184.49,112
X$1582 4828 5275 4631 5274 320 219 5478 OAI22_X1
* cell instance $1584 m0 *1 185.63,112
X$1584 5403 2922 219 320 5051 NOR2_X1
* cell instance $1587 m0 *1 188.48,112
X$1587 4241 5398 3869 2088 320 219 5401 OAI22_X1
* cell instance $1588 m0 *1 189.43,112
X$1588 4245 3162 219 320 5365 NOR2_X1
* cell instance $1589 m0 *1 190,112
X$1589 3512 5366 3516 5398 320 219 5367 OAI22_X1
* cell instance $1592 r0 *1 180.5,112
X$1592 5213 4725 219 320 5480 NOR2_X1
* cell instance $1593 r0 *1 181.07,112
X$1593 5213 4307 219 320 5484 NOR2_X1
* cell instance $1595 r0 *1 182.02,112
X$1595 5484 5273 5481 219 320 5404 NOR3_X1
* cell instance $1596 r0 *1 182.78,112
X$1596 4308 1030 3978 1444 320 219 5481 OAI22_X1
* cell instance $1597 r0 *1 183.73,112
X$1597 4346 1030 3666 1444 320 219 5364 OAI22_X1
* cell instance $1598 r0 *1 184.68,112
X$1598 5480 5478 5364 219 320 5403 NOR3_X1
* cell instance $1602 r0 *1 187.91,112
X$1602 4245 3703 219 320 5475 NOR2_X1
* cell instance $1603 r0 *1 188.48,112
X$1603 3782 5366 3393 2853 320 219 5441 OAI22_X1
* cell instance $1604 r0 *1 189.43,112
X$1604 3217 2853 3666 2088 320 219 5442 OAI22_X1
* cell instance $1605 r0 *1 190.38,112
X$1605 4740 5366 4254 2853 320 219 5443 OAI22_X1
* cell instance $1606 m0 *1 192.28,112
X$1606 5397 5367 5368 219 320 5395 NOR3_X1
* cell instance $1607 m0 *1 191.33,112
X$1607 3650 2853 3468 2088 320 219 5368 OAI22_X1
* cell instance $1608 m0 *1 193.04,112
X$1608 5395 3282 219 320 5383 NOR2_X1
* cell instance $1610 r0 *1 191.33,112
X$1610 4245 3398 219 320 5397 NOR2_X1
* cell instance $1611 r0 *1 191.9,112
X$1611 3871 2853 3979 2088 320 219 5473 OAI22_X1
* cell instance $1612 r0 *1 192.85,112
X$1612 4736 5366 3785 5398 320 219 5471 OAI22_X1
* cell instance $1614 m0 *1 194.18,112
X$1614 2477 5394 320 219 5538 XNOR2_X1
* cell instance $1618 m0 *1 198.55,112
X$1618 5155 5448 5276 219 320 5320 MUX2_X1
* cell instance $1621 r0 *1 194.18,112
X$1621 5472 5471 5473 219 320 5470 NOR3_X1
* cell instance $1625 r0 *1 197.41,112
X$1625 2243 5469 219 320 5444 XNOR2_X2
* cell instance $1626 r0 *1 199.31,112
X$1626 5470 3702 219 320 5372 NOR2_X1
* cell instance $1629 m0 *1 201.02,112
X$1629 5319 5369 5370 219 320 5394 MUX2_X1
* cell instance $1630 m0 *1 202.54,112
X$1630 5278 5161 5370 320 219 4128 OAI21_X4
* cell instance $1633 m0 *1 205.39,112
X$1633 219 12971 5371 5391 5314 320 DFF_X1
* cell instance $1637 r0 *1 208.43,112
X$1637 5446 5369 5312 219 320 5469 MUX2_X1
* cell instance $1639 m0 *1 209,112
X$1639 5034 5447 5371 219 320 5391 MUX2_X1
* cell instance $1640 r0 *1 209.76,112
X$1640 5445 5446 219 320 5313 OR2_X1
* cell instance $1642 m0 *1 212.04,112
X$1642 5034 5448 5373 219 320 5311 MUX2_X1
* cell instance $1643 m0 *1 210.71,112
X$1643 5371 5277 5373 219 320 5446 MUX2_X1
* cell instance $1647 r0 *1 212.8,112
X$1647 219 4273 5449 3624 5450 320 AOI21_X4
* cell instance $1649 m0 *1 214.51,112
X$1649 5281 5277 5037 219 320 5450 MUX2_X1
* cell instance $1650 m0 *1 216.03,112
X$1650 2362 219 320 5158 CLKBUF_X3
* cell instance $1651 m0 *1 216.98,112
X$1651 219 12945 5374 5387 5158 320 DFF_X1
* cell instance $1652 m0 *1 220.21,112
X$1652 4941 320 5448 219 BUF_X4
* cell instance $1657 r0 *1 216.22,112
X$1657 3987 5447 5452 219 320 5467 MUX2_X1
* cell instance $1660 r0 *1 218.5,112
X$1660 3987 5448 5374 219 320 5387 MUX2_X1
* cell instance $1662 r0 *1 220.21,112
X$1662 219 3624 320 5445 BUF_X8
* cell instance $1665 m0 *1 225.15,112
X$1665 5162 320 5198 219 BUF_X4
* cell instance $1670 r0 *1 224.96,112
X$1670 5462 4532 5463 320 219 4676 OAI21_X4
* cell instance $1673 r0 *1 230.85,112
X$1673 219 14553 5454 5453 5043 320 DFF_X1
* cell instance $1677 m0 *1 234.65,112
X$1677 5284 4941 5375 219 320 5384 MUX2_X1
* cell instance $1678 m0 *1 231.42,112
X$1678 219 13086 5375 5384 5043 320 DFF_X1
* cell instance $1679 m0 *1 235.98,112
X$1679 4322 5381 219 320 5560 OR2_X1
* cell instance $1680 m0 *1 236.74,112
X$1680 5383 219 320 5457 BUF_X1
* cell instance $1682 m0 *1 237.5,112
X$1682 219 13121 5376 5459 5165 320 DFF_X1
* cell instance $1684 r0 *1 234.08,112
X$1684 5454 3880 5375 219 320 5455 MUX2_X1
* cell instance $1685 r0 *1 235.41,112
X$1685 5372 219 320 5458 BUF_X1
* cell instance $1686 r0 *1 235.98,112
X$1686 219 13857 5456 5460 5165 320 DFF_X1
* cell instance $1687 r0 *1 239.21,112
X$1687 5456 4531 5376 219 320 5381 MUX2_X1
* cell instance $1690 m0 *1 173.09,100.8
X$1690 4346 883 4631 4592 320 219 4683 OAI22_X1
* cell instance $1691 m0 *1 172.14,100.8
X$1691 4522 950 3666 1628 320 219 4685 OAI22_X1
* cell instance $1692 m0 *1 174.04,100.8
X$1692 4791 4683 4594 219 320 4680 NOR3_X1
* cell instance $1694 m0 *1 175.56,100.8
X$1694 4740 4729 4254 950 320 219 4681 OAI22_X1
* cell instance $1697 m0 *1 177.46,100.8
X$1697 4788 4173 219 320 267 NOR2_X2
* cell instance $1698 m0 *1 178.41,100.8
X$1698 4679 4681 4677 219 320 4668 NOR3_X1
* cell instance $1700 r0 *1 172.14,100.8
X$1700 4523 4676 1628 3468 320 219 4792 OAI22_X2
* cell instance $1701 r0 *1 173.85,100.8
X$1701 4187 4725 219 320 4791 NOR2_X1
* cell instance $1703 r0 *1 174.8,100.8
X$1703 3871 950 3979 1628 320 219 4730 OAI22_X1
* cell instance $1707 r0 *1 175.75,100.8
X$1707 4735 4729 3393 950 320 219 4789 OAI22_X1
* cell instance $1708 r0 *1 176.7,100.8
X$1708 4731 4789 4732 219 320 4788 NOR3_X1
* cell instance $1709 r0 *1 177.46,100.8
X$1709 4241 4676 3869 1628 320 219 4732 OAI22_X1
* cell instance $1710 r0 *1 178.41,100.8
X$1710 4680 2922 219 320 4752 NOR2_X1
* cell instance $1712 r0 *1 179.36,100.8
X$1712 4636 4733 4734 320 2860 219 NOR3_X2
* cell instance $1713 m0 *1 179.74,100.8
X$1713 4402 4304 219 320 4636 NOR2_X1
* cell instance $1716 r0 *1 180.69,100.8
X$1716 4087 656 1815 3468 320 219 4734 OAI22_X2
* cell instance $1718 m0 *1 180.69,100.8
X$1718 4586 4676 3978 1628 320 219 4677 OAI22_X1
* cell instance $1719 m0 *1 181.83,100.8
X$1719 4402 4307 219 320 4783 NOR2_X1
* cell instance $1721 m0 *1 182.59,100.8
X$1721 4402 4464 219 320 4673 NOR2_X1
* cell instance $1722 m0 *1 183.16,100.8
X$1722 4522 656 3666 1815 320 219 4739 OAI22_X1
* cell instance $1723 m0 *1 184.11,100.8
X$1723 4179 656 3869 1815 320 219 4670 OAI22_X1
* cell instance $1724 m0 *1 185.06,100.8
X$1724 4673 4785 4670 219 320 4669 NOR3_X1
* cell instance $1725 m0 *1 185.82,100.8
X$1725 4668 3966 219 320 270 NOR2_X2
* cell instance $1727 m0 *1 186.96,100.8
X$1727 4669 3054 219 320 388 NOR2_X2
* cell instance $1731 r0 *1 182.59,100.8
X$1731 4736 4737 4239 4738 320 219 4637 OAI22_X1
* cell instance $1732 r0 *1 183.54,100.8
X$1732 4740 4737 4254 656 320 219 4784 OAI22_X1
* cell instance $1734 r0 *1 184.87,100.8
X$1734 4735 4737 4241 4738 320 219 4785 OAI22_X1
* cell instance $1736 r0 *1 186.2,100.8
X$1736 4783 4784 4781 219 320 4779 NOR3_X1
* cell instance $1737 r0 *1 186.96,100.8
X$1737 4586 4738 3978 1815 320 219 4781 OAI22_X1
* cell instance $1739 m0 *1 189.24,100.8
X$1739 4740 4248 4254 550 320 219 4741 OAI22_X1
* cell instance $1741 m0 *1 190.19,100.8
X$1741 4665 4741 4664 219 320 4663 NOR3_X1
* cell instance $1743 m0 *1 191.14,100.8
X$1743 3925 4406 3978 1198 320 219 4664 OAI22_X1
* cell instance $1744 m0 *1 192.09,100.8
X$1744 4663 3725 219 320 4649 NOR2_X1
* cell instance $1751 r0 *1 195.32,100.8
X$1751 219 13709 4638 4776 3874 320 DFF_X1
* cell instance $1752 m0 *1 197.79,100.8
X$1752 4639 2165 4638 219 320 4776 MUX2_X1
* cell instance $1759 r0 *1 198.55,100.8
X$1759 4639 2256 4775 219 320 4774 MUX2_X1
* cell instance $1763 r0 *1 203.87,100.8
X$1763 4645 2256 4742 219 320 4772 MUX2_X1
* cell instance $1764 r0 *1 205.2,100.8
X$1764 4645 2165 4838 219 320 4771 MUX2_X1
* cell instance $1768 r0 *1 209,100.8
X$1768 4764 2072 219 320 4770 NOR2_X2
* cell instance $1770 m0 *1 211.09,100.8
X$1770 4658 4438 2259 320 219 4767 MUX2_X2
* cell instance $1772 m0 *1 212.8,100.8
X$1772 219 13037 4528 4659 4415 320 DFF_X1
* cell instance $1775 m0 *1 218.31,100.8
X$1775 219 12898 4529 4656 4226 320 DFF_X1
* cell instance $1780 r0 *1 212.04,100.8
X$1780 219 13800 4555 4768 4415 320 DFF_X1
* cell instance $1781 r0 *1 215.27,100.8
X$1781 2362 219 320 4415 CLKBUF_X3
* cell instance $1784 r0 *1 217.36,100.8
X$1784 219 14426 4743 4766 4415 320 DFF_X1
* cell instance $1785 r0 *1 220.59,100.8
X$1785 4529 1868 4743 219 320 4764 MUX2_X1
* cell instance $1789 m0 *1 223.44,100.8
X$1789 219 12955 4640 4760 4317 320 DFF_X1
* cell instance $1790 m0 *1 226.86,100.8
X$1790 219 12899 4641 4755 4317 320 DFF_X1
* cell instance $1794 r0 *1 224.01,100.8
X$1794 4219 3070 4640 219 320 4760 MUX2_X1
* cell instance $1796 r0 *1 225.72,100.8
X$1796 219 14496 4744 4756 4317 320 DFF_X1
* cell instance $1797 r0 *1 228.95,100.8
X$1797 4219 3081 4641 219 320 4755 MUX2_X1
* cell instance $1803 m0 *1 235.22,100.8
X$1803 4745 4532 4642 320 219 4406 OAI21_X4
* cell instance $1804 m0 *1 231.99,100.8
X$1804 219 12991 4841 4851 4323 320 DFF_X1
* cell instance $1805 m0 *1 237.69,100.8
X$1805 4534 4531 4535 219 320 4746 MUX2_X1
* cell instance $1806 m0 *1 239.02,100.8
X$1806 4649 219 320 4748 BUF_X1
* cell instance $1808 m0 *1 239.78,100.8
X$1808 4648 219 320 4533 BUF_X1
* cell instance $1811 r0 *1 232.37,100.8
X$1811 219 14504 4842 4754 4323 320 DFF_X1
* cell instance $1812 r0 *1 235.6,100.8
X$1812 4322 4746 219 320 4745 OR2_X1
* cell instance $1815 r0 *1 236.93,100.8
X$1815 219 14409 4534 4643 4323 320 DFF_X1
* cell instance $1816 r0 *1 240.16,100.8
X$1816 4844 219 320 4747 BUF_X1
* cell instance $1819 m0 *1 200.45,190.4
X$1819 219 11015 10495 10267 9067 320 AOI21_X4
* cell instance $1820 m0 *1 199.5,190.4
X$1820 8871 10492 219 320 10596 OR2_X2
* cell instance $1821 m0 *1 202.92,190.4
X$1821 10267 10494 10597 320 10641 219 OAI21_X1
* cell instance $1822 m0 *1 203.68,190.4
X$1822 9067 10267 219 320 10597 NAND2_X1
* cell instance $1824 m0 *1 205.77,190.4
X$1824 10540 10064 219 320 10598 NOR2_X1
* cell instance $1825 m0 *1 206.34,190.4
X$1825 219 10599 10600 10636 8102 320 DFF_X1
* cell instance $1826 m0 *1 209.57,190.4
X$1826 10633 10600 219 320 10499 XOR2_X1
* cell instance $1827 m0 *1 210.71,190.4
X$1827 10909 10600 10709 10601 219 320 10604 OR4_X1
* cell instance $1828 m0 *1 211.85,190.4
X$1828 10602 10710 10633 219 320 10631 NAND3_X1
* cell instance $1829 m0 *1 212.61,190.4
X$1829 10605 10631 10734 219 10603 320 AOI21_X1
* cell instance $1830 m0 *1 213.37,190.4
X$1830 10501 10604 320 219 10605 XNOR2_X1
* cell instance $1831 m0 *1 214.51,190.4
X$1831 10605 10374 219 320 10606 NOR2_X1
* cell instance $1832 m0 *1 215.08,190.4
X$1832 10606 10502 9745 219 320 10630 NOR3_X1
* cell instance $1834 r0 *1 199.5,190.4
X$1834 10742 10841 219 9388 320 NAND2_X4
* cell instance $1835 r0 *1 201.21,190.4
X$1835 219 8523 8832 8318 8491 10742 320 NOR4_X4
* cell instance $1837 r0 *1 205.39,190.4
X$1837 219 10741 10709 10598 8102 320 DFF_X1
* cell instance $1838 r0 *1 208.62,190.4
X$1838 10599 10741 10710 320 219 10816 HA_X1
* cell instance $1839 r0 *1 210.52,190.4
X$1839 10712 10711 219 8489 320 NAND2_X4
* cell instance $1840 r0 *1 212.23,190.4
X$1840 10711 10712 320 219 10374 AND2_X2
* cell instance $1842 r0 *1 213.56,190.4
X$1842 10601 10731 320 219 10714 XNOR2_X1
* cell instance $1844 r0 *1 214.89,190.4
X$1844 10714 10374 219 320 10732 NOR2_X1
* cell instance $1846 r0 *1 215.84,190.4
X$1846 10732 10715 9745 219 320 10713 NOR3_X1
* cell instance $1848 m0 *1 216.22,190.4
X$1848 219 13552 10501 10630 9978 320 DFF_X1
* cell instance $1851 r0 *1 216.98,190.4
X$1851 10601 10501 10731 219 320 10270 OR3_X1
* cell instance $1853 m0 *1 220.78,190.4
X$1853 219 13545 10505 10627 9888 320 DFF_X1
* cell instance $1855 m0 *1 224.01,190.4
X$1855 10607 7176 10505 219 320 10627 MUX2_X1
* cell instance $1859 r0 *1 220.97,190.4
X$1859 219 14008 10506 10730 9978 320 DFF_X1
* cell instance $1860 r0 *1 224.2,190.4
X$1860 10607 7165 10506 219 320 10730 MUX2_X1
* cell instance $1862 r0 *1 225.91,190.4
X$1862 10607 7166 10716 219 320 10834 MUX2_X1
* cell instance $1865 m0 *1 228.19,190.4
X$1865 10619 10728 10377 320 219 10595 MUX2_X2
* cell instance $1867 m0 *1 229.9,190.4
X$1867 10608 7166 10620 219 320 10622 MUX2_X1
* cell instance $1868 m0 *1 231.23,190.4
X$1868 10608 7165 10523 219 320 10524 MUX2_X1
* cell instance $1869 m0 *1 232.56,190.4
X$1869 219 12612 10609 10617 10616 320 DFF_X1
* cell instance $1870 m0 *1 235.79,190.4
X$1870 10515 7166 10609 219 320 10617 MUX2_X1
* cell instance $1871 m0 *1 237.12,190.4
X$1871 9447 219 320 10616 CLKBUF_X3
* cell instance $1873 m0 *1 238.26,190.4
X$1873 10613 10822 10377 320 219 10614 MUX2_X2
* cell instance $1874 m0 *1 239.97,190.4
X$1874 10381 219 320 10515 BUF_X1
* cell instance $1877 r0 *1 228.38,190.4
X$1877 219 14531 10620 10622 10717 320 DFF_X1
* cell instance $1881 r0 *1 231.61,190.4
X$1881 10618 9801 10523 219 320 10619 MUX2_X1
* cell instance $1882 r0 *1 232.94,190.4
X$1882 10608 7176 10618 219 320 10522 MUX2_X1
* cell instance $1883 r0 *1 234.27,190.4
X$1883 10268 219 320 10511 BUF_X1
* cell instance $1885 r0 *1 235.03,190.4
X$1885 10616 219 320 14777 INV_X1
* cell instance $1886 r0 *1 235.41,190.4
X$1886 219 13752 10721 10724 10616 320 DFF_X1
* cell instance $1887 r0 *1 238.64,190.4
X$1887 10513 219 320 10608 BUF_X1
* cell instance $1888 r0 *1 239.21,190.4
X$1888 10269 219 320 10612 BUF_X1
* cell instance $1890 r0 *1 239.97,190.4
X$1890 6764 219 320 10510 BUF_X1
* cell instance $1893 m0 *1 167.01,182
X$1893 9934 9966 9879 219 320 10053 NOR3_X1
* cell instance $1894 m0 *1 163.78,182
X$1894 219 12729 9879 10023 9965 320 DFF_X1
* cell instance $1895 m0 *1 167.77,182
X$1895 9966 9880 320 219 9967 XNOR2_X1
* cell instance $1900 r0 *1 163.97,182
X$1900 9935 10002 219 320 10023 NOR2_X1
* cell instance $1901 r0 *1 164.54,182
X$1901 693 7838 10118 219 320 10222 MUX2_X1
* cell instance $1902 r0 *1 165.87,182
X$1902 10255 10053 219 320 10118 XOR2_X1
* cell instance $1905 r0 *1 167.58,182
X$1905 9574 7838 9967 219 320 10150 MUX2_X1
* cell instance $1907 r0 *1 169.67,182
X$1907 9383 219 320 9965 CLKBUF_X3
* cell instance $1908 r0 *1 170.62,182
X$1908 9965 219 320 CLKBUF_X1
* cell instance $1910 m0 *1 174.8,182
X$1910 10025 320 8052 219 BUF_X4
* cell instance $1911 m0 *1 171.57,182
X$1911 219 10025 9968 10024 9965 320 DFF_X1
* cell instance $1913 m0 *1 176.89,182
X$1913 9969 219 320 6987 CLKBUF_X3
* cell instance $1916 r0 *1 172.71,182
X$1916 9881 219 320 10152 CLKBUF_X3
* cell instance $1918 r0 *1 174.04,182
X$1918 219 9969 10124 10216 9965 320 DFF_X1
* cell instance $1923 r0 *1 178.79,182
X$1923 9672 320 6394 219 BUF_X4
* cell instance $1924 m0 *1 179.17,182
X$1924 10026 219 320 7044 CLKBUF_X3
* cell instance $1928 m0 *1 181.07,182
X$1928 4725 219 320 10026 INV_X1
* cell instance $1931 m0 *1 182.4,182
X$1931 8001 219 320 7737 INV_X2
* cell instance $1932 m0 *1 182.97,182
X$1932 4828 9668 9882 9066 6728 320 219 10154 OAI221_X1
* cell instance $1935 m0 *1 185.06,182
X$1935 6538 9668 9970 9066 4511 320 219 9971 OAI221_X1
* cell instance $1937 m0 *1 186.96,182
X$1937 10022 8115 9546 219 10121 320 AOI21_X1
* cell instance $1940 r0 *1 180.12,182
X$1940 8674 320 4135 219 BUF_X4
* cell instance $1941 r0 *1 181.45,182
X$1941 10026 219 320 10056 BUF_X2
* cell instance $1943 r0 *1 182.97,182
X$1943 10055 320 8001 219 BUF_X4
* cell instance $1947 r0 *1 186.77,182
X$1947 9971 5902 9546 219 10122 320 AOI21_X1
* cell instance $1948 r0 *1 187.53,182
X$1948 9926 10056 2197 219 10120 320 AOI21_X1
* cell instance $1951 r0 *1 188.86,182
X$1951 10020 10056 6138 219 10119 320 AOI21_X1
* cell instance $1952 r0 *1 189.62,182
X$1952 10013 10056 9233 219 10116 320 AOI21_X1
* cell instance $1955 m0 *1 191.33,182
X$1955 6634 9574 10009 9573 6728 320 219 10020 OAI221_X1
* cell instance $1957 m0 *1 192.47,182
X$1957 8049 693 7679 2967 219 320 10018 AOI22_X1
* cell instance $1959 r0 *1 191.52,182
X$1959 4828 7782 10018 7952 4631 320 219 10211 OAI221_X1
* cell instance $1960 r0 *1 192.66,182
X$1960 8049 689 7679 1970 219 320 10210 AOI22_X1
* cell instance $1962 m0 *1 194.94,182
X$1962 8381 9677 8060 9571 219 320 10009 AOI22_X1
* cell instance $1963 m0 *1 193.8,182
X$1963 6634 9789 9885 9725 3940 320 219 10013 OAI221_X1
* cell instance $1967 r0 *1 196.08,182
X$1967 9330 8115 8119 219 10190 320 AOI21_X1
* cell instance $1968 m0 *1 197.41,182
X$1968 4346 9739 9975 9683 3940 320 219 9972 OAI221_X1
* cell instance $1969 m0 *1 196.27,182
X$1969 7058 9789 9974 9725 4511 320 219 9973 OAI221_X1
* cell instance $1971 m0 *1 198.74,182
X$1971 7737 9825 7102 9998 219 320 10005 AOI22_X1
* cell instance $1972 m0 *1 199.69,182
X$1972 7058 9738 10005 9886 4511 320 219 10057 OAI221_X1
* cell instance $1973 m0 *1 200.83,182
X$1973 4301 9683 10058 9739 8324 320 219 9997 OAI221_X1
* cell instance $1974 m0 *1 201.97,182
X$1974 6732 9825 8380 9998 219 320 9996 AOI22_X1
* cell instance $1975 m0 *1 202.92,182
X$1975 9794 9825 8220 9998 219 320 10059 AOI22_X1
* cell instance $1976 m0 *1 203.87,182
X$1976 4301 9886 9996 9738 8324 320 219 10060 OAI221_X1
* cell instance $1977 m0 *1 205.01,182
X$1977 9794 9793 8220 9678 219 320 9991 AOI22_X1
* cell instance $1978 m0 *1 205.96,182
X$1978 9794 9677 8220 9571 219 320 10061 AOI22_X1
* cell instance $1981 r0 *1 197.22,182
X$1981 4346 9738 10207 9886 3940 320 219 10155 OAI221_X1
* cell instance $1982 r0 *1 198.36,182
X$1982 8381 9825 8060 9998 219 320 10207 AOI22_X1
* cell instance $1983 r0 *1 199.31,182
X$1983 9973 5902 9233 219 10110 320 AOI21_X1
* cell instance $1985 r0 *1 200.45,182
X$1985 6732 9826 8380 9828 219 320 10058 AOI22_X1
* cell instance $1987 r0 *1 201.78,182
X$1987 9997 6184 2293 219 10201 320 AOI21_X1
* cell instance $1990 r0 *1 203.11,182
X$1990 4180 9886 10059 9738 3787 320 219 10197 OAI221_X1
* cell instance $1992 r0 *1 204.44,182
X$1992 10060 8115 9797 219 10156 320 AOI21_X1
* cell instance $1993 r0 *1 205.2,182
X$1993 9675 6836 219 320 10199 NOR2_X1
* cell instance $1994 r0 *1 205.77,182
X$1994 4180 9573 10061 9574 3787 320 219 10062 OAI221_X1
* cell instance $1995 r0 *1 206.91,182
X$1995 10062 6394 6138 219 10100 320 AOI21_X1
* cell instance $1996 m0 *1 207.48,182
X$1996 4180 9725 9991 9789 3787 320 219 10098 OAI221_X1
* cell instance $1998 m0 *1 208.62,182
X$1998 9883 6836 219 320 9985 NOR2_X2
* cell instance $2000 m0 *1 209.76,182
X$2000 9332 6328 219 320 9984 NOR2_X1
* cell instance $2003 r0 *1 207.67,182
X$2003 10098 6394 9233 219 10157 320 AOI21_X1
* cell instance $2004 r0 *1 208.43,182
X$2004 9905 8115 2197 219 10094 320 AOI21_X1
* cell instance $2008 r0 *1 211.28,182
X$2008 2967 8871 10092 219 320 10188 MUX2_X1
* cell instance $2010 m0 *1 211.47,182
X$2010 1954 10188 320 219 9887 AND2_X1
* cell instance $2011 m0 *1 213.94,182
X$2011 2702 219 320 9886 INV_X1
* cell instance $2012 m0 *1 212.61,182
X$2012 9681 8871 9987 219 320 10063 MUX2_X1
* cell instance $2013 m0 *1 214.32,182
X$2013 9573 8871 9986 219 320 9977 MUX2_X1
* cell instance $2014 m0 *1 215.65,182
X$2014 219 12706 10088 10066 9978 320 DFF_X1
* cell instance $2020 r0 *1 213.37,182
X$2020 10063 9977 219 320 10158 NAND2_X1
* cell instance $2021 r0 *1 213.94,182
X$2021 10063 10064 219 320 10066 NOR2_X1
* cell instance $2022 r0 *1 214.51,182
X$2022 10091 10087 219 320 10092 XOR2_X1
* cell instance $2024 r0 *1 216.03,182
X$2024 10065 10159 10088 219 320 10087 NOR3_X1
* cell instance $2026 r0 *1 216.98,182
X$2026 9977 10064 219 320 10161 NOR2_X1
* cell instance $2029 r0 *1 221.35,182
X$2029 219 14234 10067 10085 9888 320 DFF_X1
* cell instance $2031 m0 *1 224.58,182
X$2031 9447 219 320 9888 CLKBUF_X3
* cell instance $2034 r0 *1 224.58,182
X$2034 10067 10069 10179 219 320 10272 MUX2_X1
* cell instance $2035 r0 *1 225.91,182
X$2035 10068 7166 10067 219 320 10085 MUX2_X1
* cell instance $2036 r0 *1 227.24,182
X$2036 10068 7165 10070 219 320 10083 MUX2_X1
* cell instance $2037 r0 *1 228.57,182
X$2037 219 13981 10070 10083 9979 320 DFF_X1
* cell instance $2043 m0 *1 233.32,182
X$2043 9447 219 320 9979 CLKBUF_X3
* cell instance $2044 m0 *1 232.75,182
X$2044 9979 219 320 CLKBUF_X1
* cell instance $2045 m0 *1 234.27,182
X$2045 219 12876 9980 10077 9979 320 DFF_X1
* cell instance $2046 m0 *1 237.5,182
X$2046 219 12788 10072 9983 9979 320 DFF_X1
* cell instance $2048 r0 *1 232.75,182
X$2048 219 14122 10071 10174 9979 320 DFF_X1
* cell instance $2049 r0 *1 235.98,182
X$2049 9891 7166 10071 219 320 10174 MUX2_X1
* cell instance $2050 r0 *1 237.31,182
X$2050 9891 7291 9980 219 320 10077 MUX2_X1
* cell instance $2051 r0 *1 238.64,182
X$2051 9890 10069 10072 219 320 10167 MUX2_X1
* cell instance $2052 r0 *1 239.97,182
X$2052 9118 219 320 9982 BUF_X1
* cell instance $2055 m0 *1 101.84,114.8
X$2055 2674 5252 320 219 5817 XNOR2_X1
* cell instance $2058 m0 *1 103.74,114.8
X$2058 5122 2468 219 320 5582 NAND2_X2
* cell instance $2060 r0 *1 101.65,114.8
X$2060 5117 5721 320 219 5688 AND2_X1
* cell instance $2061 r0 *1 102.41,114.8
X$2061 219 4919 5688 3044 5518 320 AOI21_X4
* cell instance $2062 r0 *1 104.88,114.8
X$2062 5518 3491 5517 5689 5724 320 219 AOI211_X2
* cell instance $2063 m0 *1 105.26,114.8
X$2063 2674 5328 219 320 5689 XOR2_X1
* cell instance $2065 m0 *1 106.4,114.8
X$2065 2674 5328 320 219 5690 XNOR2_X1
* cell instance $2068 r0 *1 106.78,114.8
X$2068 5479 5690 5518 320 5609 219 OAI21_X1
* cell instance $2070 m0 *1 108.11,114.8
X$2070 4291 5482 2776 320 219 5584 MUX2_X2
* cell instance $2073 r0 *1 108.3,114.8
X$2073 5350 2468 219 320 5585 NAND2_X1
* cell instance $2075 m0 *1 110.39,114.8
X$2075 219 12864 5405 5583 5519 320 DFF_X1
* cell instance $2080 r0 *1 112.29,114.8
X$2080 219 5585 5521 5586 5611 5582 320 OAI22_X4
* cell instance $2081 m0 *1 116.09,114.8
X$2081 5427 5353 5257 219 320 5587 MUX2_X1
* cell instance $2082 m0 *1 114.76,114.8
X$2082 5354 5515 5587 219 320 5586 MUX2_X1
* cell instance $2086 m0 *1 117.8,114.8
X$2086 5588 5520 5589 219 320 5521 MUX2_X1
* cell instance $2087 m0 *1 119.89,114.8
X$2087 4167 5258 2536 320 5522 219 OAI21_X1
* cell instance $2088 m0 *1 120.65,114.8
X$2088 2536 5258 4167 219 320 5590 OR3_X1
* cell instance $2091 r0 *1 118.75,114.8
X$2091 2534 5611 5216 219 320 5694 OR3_X1
* cell instance $2095 r0 *1 119.7,114.8
X$2095 5590 5522 5694 5692 320 219 5610 AND4_X1
* cell instance $2096 r0 *1 120.84,114.8
X$2096 4167 5258 5696 219 320 NOR2_X4
* cell instance $2097 m0 *1 122.17,114.8
X$2097 5356 5353 5591 219 320 5588 MUX2_X1
* cell instance $2107 m0 *1 125.4,114.8
X$2107 219 12972 5591 5430 5259 320 DFF_X1
* cell instance $2109 m0 *1 130.34,114.8
X$2109 5592 4351 5524 219 320 5523 MUX2_X1
* cell instance $2111 m0 *1 132.43,114.8
X$2111 5592 4377 5431 219 320 5490 MUX2_X1
* cell instance $2115 r0 *1 130.15,114.8
X$2115 219 14495 5524 5523 5729 320 DFF_X1
* cell instance $2117 m0 *1 134.9,114.8
X$2117 5524 4584 5431 219 320 5491 MUX2_X1
* cell instance $2118 m0 *1 134.14,114.8
X$2118 5359 5612 219 320 5432 OR2_X1
* cell instance $2120 m0 *1 136.99,114.8
X$2120 219 13271 5526 5699 5358 320 DFF_X1
* cell instance $2121 m0 *1 140.22,114.8
X$2121 5525 4718 5526 219 320 5528 MUX2_X1
* cell instance $2122 m0 *1 141.55,114.8
X$2122 5613 4890 5527 219 320 5595 MUX2_X1
* cell instance $2124 m0 *1 143.07,114.8
X$2124 4382 5528 219 320 5614 OR2_X1
* cell instance $2127 m0 *1 146.11,114.8
X$2127 219 13633 5529 5596 5531 320 DFF_X1
* cell instance $2131 r0 *1 135.28,114.8
X$2131 5613 4819 5525 219 320 5700 MUX2_X1
* cell instance $2132 r0 *1 136.61,114.8
X$2132 219 14596 5525 5700 5358 320 DFF_X1
* cell instance $2134 r0 *1 140.03,114.8
X$2134 219 14578 5527 5595 5358 320 DFF_X1
* cell instance $2136 r0 *1 143.64,114.8
X$2136 5614 4383 5615 320 219 4926 OAI21_X4
* cell instance $2138 r0 *1 146.49,114.8
X$2138 219 14573 5433 5616 5531 320 DFF_X1
* cell instance $2139 r0 *1 149.72,114.8
X$2139 219 14590 5797 5618 5531 320 DFF_X1
* cell instance $2141 m0 *1 150.48,114.8
X$2141 219 13475 5733 5530 5531 320 DFF_X1
* cell instance $2144 r0 *1 153.14,114.8
X$2144 223 4890 5703 219 320 5702 MUX2_X1
* cell instance $2146 r0 *1 154.66,114.8
X$2146 219 14277 5703 5702 5619 320 DFF_X1
* cell instance $2147 m0 *1 158.08,114.8
X$2147 5498 5496 5497 320 5598 219 NOR3_X2
* cell instance $2148 m0 *1 154.85,114.8
X$2148 219 13367 5435 5436 5619 320 DFF_X1
* cell instance $2149 m0 *1 159.41,114.8
X$2149 5411 5597 5361 219 320 5532 NOR3_X1
* cell instance $2151 m0 *1 160.36,114.8
X$2151 3977 2440 5362 3565 320 219 5497 OAI22_X2
* cell instance $2152 m0 *1 162.07,114.8
X$2152 5706 5533 3221 219 320 NOR2_X4
* cell instance $2156 r0 *1 158.46,114.8
X$2156 5410 4355 219 320 5620 NOR2_X1
* cell instance $2157 r0 *1 159.03,114.8
X$2157 5620 5621 5704 320 3937 219 NOR3_X2
* cell instance $2158 r0 *1 160.36,114.8
X$2158 4083 3019 5437 4396 320 219 5621 OAI22_X2
* cell instance $2159 r0 *1 162.07,114.8
X$2159 4135 3019 5437 3278 320 219 5622 OAI22_X2
* cell instance $2160 r0 *1 163.78,114.8
X$2160 3871 2440 5362 3384 320 219 5705 OAI22_X2
* cell instance $2162 m0 *1 164.16,114.8
X$2162 3650 2440 5362 3508 320 219 5704 OAI22_X2
* cell instance $2166 r0 *1 166.44,114.8
X$2166 5623 320 2922 219 BUF_X4
* cell instance $2168 m0 *1 167.01,114.8
X$2168 4306 219 320 4358 CLKBUF_X3
* cell instance $2169 m0 *1 168.72,114.8
X$2169 4307 219 320 4081 CLKBUF_X3
* cell instance $2170 m0 *1 169.67,114.8
X$2170 5594 5533 219 320 496 NOR2_X2
* cell instance $2171 m0 *1 170.62,114.8
X$2171 5737 4721 219 320 5493 NOR2_X1
* cell instance $2172 m0 *1 171.19,114.8
X$2172 4736 5534 3347 2415 320 219 5593 OAI22_X1
* cell instance $2173 m0 *1 172.14,114.8
X$2173 4828 5534 3940 2415 320 219 5439 OAI22_X1
* cell instance $2175 m0 *1 173.28,114.8
X$2175 4458 5440 3698 846 320 219 5536 OAI22_X1
* cell instance $2176 m0 *1 174.23,114.8
X$2176 4596 320 3393 219 BUF_X4
* cell instance $2177 m0 *1 175.56,114.8
X$2177 4586 5440 3383 846 320 219 5535 OAI22_X1
* cell instance $2182 m0 *1 187.91,114.8
X$2182 3443 5366 3513 5398 320 219 5577 OAI22_X1
* cell instance $2183 m0 *1 188.86,114.8
X$2183 5475 5441 5401 219 320 5571 NOR3_X1
* cell instance $2184 m0 *1 189.62,114.8
X$2184 5365 5577 5442 219 320 5321 NOR3_X1
* cell instance $2186 m0 *1 190.57,114.8
X$2186 4245 3705 219 320 5472 NOR2_X1
* cell instance $2188 r0 *1 167.77,114.8
X$2188 5736 219 320 3391 CLKBUF_X3
* cell instance $2190 r0 *1 168.91,114.8
X$2190 4304 219 320 4355 CLKBUF_X3
* cell instance $2191 r0 *1 169.86,114.8
X$2191 5624 5593 5536 219 320 5594 NOR3_X1
* cell instance $2193 r0 *1 171,114.8
X$2193 5626 5701 5535 219 320 5695 NOR3_X1
* cell instance $2194 r0 *1 171.76,114.8
X$2194 3660 2415 3470 846 320 219 5627 OAI22_X1
* cell instance $2195 r0 *1 172.71,114.8
X$2195 4740 5534 3609 2415 320 219 5701 OAI22_X1
* cell instance $2196 r0 *1 173.66,114.8
X$2196 4735 5534 4193 2415 320 219 5628 OAI22_X1
* cell instance $2197 r0 *1 174.61,114.8
X$2197 4241 5440 3393 846 320 219 5698 OAI22_X1
* cell instance $2202 r0 *1 175.94,114.8
X$2202 5695 5537 219 320 254 NOR2_X2
* cell instance $2203 r0 *1 176.89,114.8
X$2203 3217 2762 3158 1998 320 219 5697 OAI22_X1
* cell instance $2204 r0 *1 177.84,114.8
X$2204 3698 2762 3507 1998 320 219 5742 OAI22_X1
* cell instance $2205 r0 *1 178.79,114.8
X$2205 4254 2762 3390 1998 320 219 5631 OAI22_X1
* cell instance $2207 r0 *1 180.12,114.8
X$2207 5629 5570 219 320 260 NOR2_X2
* cell instance $2208 r0 *1 181.07,114.8
X$2208 5632 320 4080 219 BUF_X4
* cell instance $2211 r0 *1 182.97,114.8
X$2211 4458 320 3785 219 BUF_X4
* cell instance $2213 r0 *1 184.68,114.8
X$2213 5632 320 5533 219 BUF_X4
* cell instance $2216 r0 *1 186.96,114.8
X$2216 5634 5488 219 320 5559 NOR2_X1
* cell instance $2218 r0 *1 189.05,114.8
X$2218 3868 717 3869 2609 320 219 5635 OAI22_X1
* cell instance $2220 m0 *1 191.71,114.8
X$2220 4586 5398 3978 2088 320 219 5573 OAI22_X1
* cell instance $2222 m0 *1 192.66,114.8
X$2222 5396 5443 5573 219 320 5572 NOR3_X1
* cell instance $2225 m0 *1 194.37,114.8
X$2225 5571 3792 219 320 5556 NOR2_X1
* cell instance $2227 m0 *1 195.13,114.8
X$2227 5572 3725 219 320 5451 NOR2_X1
* cell instance $2228 m0 *1 195.7,114.8
X$2228 2536 5568 219 320 5683 XNOR2_X2
* cell instance $2230 m0 *1 197.79,114.8
X$2230 2239 5566 219 320 5569 XNOR2_X2
* cell instance $2234 r0 *1 192.28,114.8
X$2234 4458 320 4239 219 BUF_X4
* cell instance $2237 r0 *1 195.51,114.8
X$2237 219 5569 5444 5636 5683 5747 320 NAND4_X4
* cell instance $2238 r0 *1 198.93,114.8
X$2238 5539 5448 5637 219 320 5682 MUX2_X1
* cell instance $2239 r0 *1 200.26,114.8
X$2239 5748 5277 5637 219 320 5681 MUX2_X1
* cell instance $2242 m0 *1 201.59,114.8
X$2242 5640 5681 320 219 5680 AND2_X1
* cell instance $2244 m0 *1 203.3,114.8
X$2244 219 12981 5540 5675 5314 320 DFF_X1
* cell instance $2245 m0 *1 206.53,114.8
X$2245 5567 219 320 5314 CLKBUF_X3
* cell instance $2249 m0 *1 212.8,114.8
X$2249 5640 5542 320 219 5449 AND2_X1
* cell instance $2250 m0 *1 213.56,114.8
X$2250 5542 5369 5450 219 320 5566 MUX2_X1
* cell instance $2252 r0 *1 201.78,114.8
X$2252 219 4512 5680 3624 5638 320 AOI21_X4
* cell instance $2254 r0 *1 205.01,114.8
X$2254 5539 5036 5540 219 320 5675 MUX2_X1
* cell instance $2255 r0 *1 206.34,114.8
X$2255 5750 5369 5674 219 320 5568 MUX2_X1
* cell instance $2257 r0 *1 207.86,114.8
X$2257 219 14366 5671 5541 5314 320 DFF_X1
* cell instance $2259 m0 *1 218.5,114.8
X$2259 5452 5639 5374 219 320 5542 MUX2_X1
* cell instance $2260 m0 *1 215.27,114.8
X$2260 219 13026 5452 5467 5158 320 DFF_X1
* cell instance $2262 m0 *1 220.59,114.8
X$2262 4942 320 5447 219 BUF_X4
* cell instance $2263 m0 *1 221.92,114.8
X$2263 5543 5448 5546 219 320 5565 MUX2_X1
* cell instance $2264 m0 *1 223.25,114.8
X$2264 219 12953 5546 5565 5544 320 DFF_X1
* cell instance $2265 m0 *1 226.48,114.8
X$2265 5545 3880 5546 219 320 5463 MUX2_X1
* cell instance $2266 m0 *1 227.81,114.8
X$2266 219 13113 5548 5547 5544 320 DFF_X1
* cell instance $2267 m0 *1 231.04,114.8
X$2267 3173 5549 219 320 5462 OR2_X1
* cell instance $2269 m0 *1 231.99,114.8
X$2269 5284 4942 5454 219 320 5453 MUX2_X1
* cell instance $2271 m0 *1 233.51,114.8
X$2271 5560 4532 5455 320 219 4738 OAI21_X4
* cell instance $2275 r0 *1 218.12,114.8
X$2275 5642 5036 5641 219 320 5668 MUX2_X1
* cell instance $2276 r0 *1 219.45,114.8
X$2276 5642 5447 5643 219 320 5644 MUX2_X1
* cell instance $2279 r0 *1 221.92,114.8
X$2279 5543 5447 5545 219 320 5767 MUX2_X1
* cell instance $2283 r0 *1 225.91,114.8
X$2283 5543 5198 5660 219 320 5646 MUX2_X1
* cell instance $2284 r0 *1 227.24,114.8
X$2284 5543 5036 5548 219 320 5547 MUX2_X1
* cell instance $2287 r0 *1 229.71,114.8
X$2287 5660 3071 5548 219 320 5549 MUX2_X1
* cell instance $2292 r0 *1 231.23,114.8
X$2292 219 14675 5648 5655 5544 320 DFF_X1
* cell instance $2293 r0 *1 234.46,114.8
X$2293 5651 219 320 5642 BUF_X1
* cell instance $2295 m0 *1 237.69,114.8
X$2295 5559 219 320 5377 BUF_X1
* cell instance $2296 m0 *1 236.36,114.8
X$2296 5284 5162 5456 219 320 5460 MUX2_X1
* cell instance $2297 m0 *1 238.26,114.8
X$2297 5284 5160 5376 219 320 5459 MUX2_X1
* cell instance $2298 m0 *1 239.59,114.8
X$2298 5451 219 320 5550 BUF_X1
* cell instance $2299 m0 *1 240.16,114.8
X$2299 5556 219 320 5551 BUF_X1
* cell instance $2301 r0 *1 236.55,114.8
X$2301 5649 219 320 5647 BUF_X1
* cell instance $2303 r0 *1 240.16,114.8
X$2303 5554 219 320 5758 BUF_X1
* cell instance $2305 m0 *1 115.14,196
X$2305 11016 10961 320 219 10962 XNOR2_X1
* cell instance $2307 m0 *1 116.28,196
X$2307 10962 10877 219 320 11018 NAND2_X1
* cell instance $2308 m0 *1 116.85,196
X$2308 10880 11018 219 320 10937 XOR2_X1
* cell instance $2311 m0 *1 121.22,196
X$2311 219 10963 10143 12499 10676 320 DFF_X2
* cell instance $2314 m0 *1 127.11,196
X$2314 10964 9157 11022 219 320 11021 MUX2_X1
* cell instance $2315 m0 *1 128.44,196
X$2315 10964 8699 11058 219 320 10965 MUX2_X1
* cell instance $2317 r0 *1 114.95,196
X$2317 11013 11055 11135 10880 320 11056 219 OR4_X2
* cell instance $2318 r0 *1 116.28,196
X$2318 10676 11053 11056 320 219 9147 OAI21_X4
* cell instance $2319 r0 *1 118.75,196
X$2319 11056 11053 219 10451 320 OR2_X4
* cell instance $2324 r0 *1 120.84,196
X$2324 10569 11050 11109 219 320 10963 MUX2_X1
* cell instance $2325 r0 *1 122.17,196
X$2325 10676 10892 219 320 11109 OR2_X1
* cell instance $2332 r0 *1 125.78,196
X$2332 219 13818 11022 11021 11057 320 DFF_X1
* cell instance $2333 r0 *1 129.01,196
X$2333 219 13798 11058 10965 11057 320 DFF_X1
* cell instance $2334 m0 *1 133.38,196
X$2334 11114 8821 10883 219 320 11025 MUX2_X1
* cell instance $2335 m0 *1 130.15,196
X$2335 219 13033 10966 11023 11057 320 DFF_X1
* cell instance $2336 m0 *1 134.71,196
X$2336 219 13025 10883 11025 10967 320 DFF_X1
* cell instance $2337 m0 *1 137.94,196
X$2337 11114 8699 10882 219 320 11026 MUX2_X1
* cell instance $2341 r0 *1 134.14,196
X$2341 219 13832 11060 11059 10967 320 DFF_X1
* cell instance $2343 m0 *1 142.88,196
X$2343 10969 10941 10968 219 320 11061 MUX2_X1
* cell instance $2344 m0 *1 139.65,196
X$2344 219 10968 10969 11028 10975 320 DFF_X1
* cell instance $2345 m0 *1 144.21,196
X$2345 10539 11061 320 219 11028 AND2_X1
* cell instance $2346 m0 *1 144.97,196
X$2346 10941 10969 219 320 10885 NAND2_X1
* cell instance $2351 r0 *1 146.49,196
X$2351 11062 219 320 11291 INV_X1
* cell instance $2356 m0 *1 151.62,196
X$2356 11031 11117 3121 219 320 NOR2_X4
* cell instance $2357 m0 *1 149.72,196
X$2357 10886 10756 12531 320 219 11031 HA_X1
* cell instance $2361 m0 *1 155.8,196
X$2361 9930 10888 219 320 10970 NAND2_X1
* cell instance $2362 m0 *1 156.37,196
X$2362 10970 10897 3233 320 11032 219 OAI21_X1
* cell instance $2363 m0 *1 157.13,196
X$2363 10971 10972 11032 10895 219 320 11119 NAND4_X1
* cell instance $2365 m0 *1 158.27,196
X$2365 9479 9318 320 219 10973 AND2_X1
* cell instance $2366 m0 *1 159.03,196
X$2366 10894 219 320 10895 INV_X1
* cell instance $2367 m0 *1 159.41,196
X$2367 9930 10947 10693 11065 320 219 11034 OAI22_X1
* cell instance $2368 m0 *1 160.36,196
X$2368 10852 11121 10974 3693 10693 10895 219 320 11066 OAI33_X1
* cell instance $2370 r0 *1 149.72,196
X$2370 11117 11062 3265 219 320 NOR2_X4
* cell instance $2371 r0 *1 151.43,196
X$2371 11063 219 320 10886 INV_X2
* cell instance $2373 r0 *1 152.19,196
X$2373 11116 320 3238 219 BUF_X4
* cell instance $2377 r0 *1 154.85,196
X$2377 10888 219 320 11118 INV_X1
* cell instance $2378 r0 *1 155.23,196
X$2378 10794 10787 11118 10897 10972 219 320 OAI211_X2
* cell instance $2380 r0 *1 157.13,196
X$2380 11148 10895 10762 219 320 11120 NAND3_X1
* cell instance $2382 r0 *1 158.08,196
X$2382 10945 9930 10974 10973 219 11064 320 NAND4_X2
* cell instance $2384 r0 *1 160.17,196
X$2384 10946 219 320 9383 CLKBUF_X3
* cell instance $2385 r0 *1 161.12,196
X$2385 11220 11120 11119 11221 219 320 10758 NAND4_X1
* cell instance $2386 r0 *1 162.07,196
X$2386 9383 219 320 14709 INV_X2
* cell instance $2388 m0 *1 162.07,196
X$2388 219 11037 11067 11034 10975 320 DFF_X1
* cell instance $2391 m0 *1 167.77,196
X$2391 10690 10579 219 320 10976 NOR2_X1
* cell instance $2393 r0 *1 162.64,196
X$2393 9930 10889 219 320 11121 NOR2_X1
* cell instance $2394 r0 *1 163.21,196
X$2394 10897 10894 219 320 11218 NOR2_X1
* cell instance $2397 r0 *1 164.35,196
X$2397 10795 219 320 10888 CLKBUF_X3
* cell instance $2398 r0 *1 165.3,196
X$2398 11067 219 320 10889 CLKBUF_X3
* cell instance $2401 m0 *1 168.72,196
X$2401 10768 10686 10690 219 320 10797 NAND3_X1
* cell instance $2402 m0 *1 169.67,196
X$2402 11068 10978 219 320 10686 NOR2_X2
* cell instance $2404 m0 *1 170.81,196
X$2404 11068 10978 11035 10691 320 11036 219 NOR4_X2
* cell instance $2406 m0 *1 172.71,196
X$2406 9561 10799 219 320 11033 NOR2_X1
* cell instance $2408 m0 *1 173.47,196
X$2408 10849 219 320 10803 INV_X1
* cell instance $2409 m0 *1 173.85,196
X$2409 11071 10899 320 219 10802 AND2_X1
* cell instance $2410 m0 *1 174.61,196
X$2410 219 10900 10483 8890 11072 320 DFF_X2
* cell instance $2415 r0 *1 171.57,196
X$2415 4307 10694 11071 10977 219 11069 320 NAND4_X2
* cell instance $2416 r0 *1 173.28,196
X$2416 10152 219 320 10665 INV_X1
* cell instance $2417 r0 *1 173.66,196
X$2417 11070 6977 219 320 7330 NOR2_X2
* cell instance $2418 r0 *1 174.61,196
X$2418 10260 219 320 11071 INV_X1
* cell instance $2423 r0 *1 175.37,196
X$2423 11072 320 10474 219 BUF_X4
* cell instance $2427 r0 *1 178.03,196
X$2427 219 10979 11162 11073 10483 320 DFF_X1
* cell instance $2428 m0 *1 180.31,196
X$2428 10979 320 4306 219 BUF_X4
* cell instance $2430 m0 *1 181.64,196
X$2430 11027 11074 219 320 10808 NOR2_X1
* cell instance $2432 r0 *1 181.26,196
X$2432 11116 11115 10658 11074 10693 11075 219 320 11073 OAI33_X1
* cell instance $2433 m0 *1 182.78,196
X$2433 10981 10982 10811 320 10980 219 OAI21_X1
* cell instance $2435 m0 *1 183.54,196
X$2435 10696 10585 10591 219 10982 320 AOI21_X1
* cell instance $2436 m0 *1 184.3,196
X$2436 10587 10811 11074 320 11030 219 OAI21_X1
* cell instance $2437 m0 *1 185.06,196
X$2437 10591 10015 11030 219 11029 320 AOI21_X1
* cell instance $2438 m0 *1 185.82,196
X$2438 10902 11029 11113 320 10748 219 OAI21_X1
* cell instance $2439 m0 *1 186.58,196
X$2439 10596 10585 10015 219 320 11027 NAND3_X1
* cell instance $2440 m0 *1 187.34,196
X$2440 11024 10015 10585 10983 320 219 11112 AND4_X1
* cell instance $2444 r0 *1 182.59,196
X$2444 10980 11075 219 320 11115 NAND2_X1
* cell instance $2448 r0 *1 185.82,196
X$2448 10590 10472 10696 219 320 11113 NAND3_X1
* cell instance $2449 r0 *1 186.58,196
X$2449 10696 10585 11163 320 11076 219 OAI21_X1
* cell instance $2451 r0 *1 188.1,196
X$2451 10700 10658 11110 320 11111 219 OAI21_X1
* cell instance $2452 r0 *1 188.86,196
X$2452 11024 10587 11111 320 11077 219 OAI21_X1
* cell instance $2454 r0 *1 190.38,196
X$2454 219 10897 11079 11019 11078 320 AOI21_X4
* cell instance $2455 m0 *1 191.33,196
X$2455 219 11108 10904 10974 10703 10986 320 AOI22_X4
* cell instance $2457 m0 *1 194.56,196
X$2457 10813 10705 219 320 11020 OR2_X1
* cell instance $2458 m0 *1 195.32,196
X$2458 9560 10905 10376 219 320 10987 NOR3_X1
* cell instance $2461 r0 *1 193.61,196
X$2461 219 11572 10490 10595 10904 320 AOI21_X4
* cell instance $2462 r0 *1 196.08,196
X$2462 10595 11079 219 320 11108 NOR2_X1
* cell instance $2464 m0 *1 196.46,196
X$2464 10595 10376 10905 10814 320 11019 219 OR4_X2
* cell instance $2465 m0 *1 199.31,196
X$2465 219 11017 11014 12501 8523 320 DFF_X2
* cell instance $2468 m0 *1 205.2,196
X$2468 219 13269 11011 10740 11014 320 DFF_X1
* cell instance $2469 m0 *1 208.43,196
X$2469 10908 10989 1954 320 10988 219 OAI21_X1
* cell instance $2470 m0 *1 209.19,196
X$2470 11080 10711 219 320 10989 NOR2_X1
* cell instance $2474 r0 *1 198.36,196
X$2474 219 11105 11014 12511 8318 320 DFF_X2
* cell instance $2477 r0 *1 203.87,196
X$2477 9818 219 320 11014 CLKBUF_X3
* cell instance $2480 r0 *1 206.53,196
X$2480 11200 10633 11011 219 320 11160 MUX2_X1
* cell instance $2481 r0 *1 207.86,196
X$2481 11102 11080 12555 320 219 11101 HA_X1
* cell instance $2482 r0 *1 209.76,196
X$2482 11081 11101 1859 219 320 NOR2_X4
* cell instance $2484 m0 *1 210.14,196
X$2484 11102 7251 1956 219 320 NOR2_X4
* cell instance $2488 r0 *1 211.66,196
X$2488 11169 11081 3501 219 320 NOR2_X4
* cell instance $2490 r0 *1 213.56,196
X$2490 11191 3238 219 320 7309 NOR2_X2
* cell instance $2491 m0 *1 214.7,196
X$2491 219 13450 11006 11082 11004 320 DFF_X1
* cell instance $2495 m0 *1 227.05,196
X$2495 10379 6311 11001 219 320 11003 MUX2_X1
* cell instance $2497 m0 *1 229.14,196
X$2497 219 10507 10069 320 BUF_X16
* cell instance $2498 m0 *1 233.89,196
X$2498 10717 219 320 CLKBUF_X1
* cell instance $2501 r0 *1 214.7,196
X$2501 11192 3238 219 320 11082 NOR2_X1
* cell instance $2506 r0 *1 220.97,196
X$2506 219 14240 11083 11097 11171 320 DFF_X1
* cell instance $2507 r0 *1 224.2,196
X$2507 10828 6101 11083 219 320 11097 MUX2_X1
* cell instance $2512 r0 *1 228.38,196
X$2512 219 14559 11173 11095 10717 320 DFF_X1
* cell instance $2517 r0 *1 233.13,196
X$2517 10821 6101 11085 219 320 11092 MUX2_X1
* cell instance $2518 r0 *1 234.46,196
X$2518 219 14104 11085 11092 11084 320 DFF_X1
* cell instance $2519 m0 *1 235.03,196
X$2519 219 12563 10990 10912 10717 320 DFF_X1
* cell instance $2521 m0 *1 238.26,196
X$2521 10821 6311 10913 219 320 10916 MUX2_X1
* cell instance $2522 m0 *1 239.59,196
X$2522 10390 219 320 10994 BUF_X1
* cell instance $2523 m0 *1 240.16,196
X$2523 7892 219 320 10718 BUF_X1
* cell instance $2525 r0 *1 237.69,196
X$2525 10990 10507 11085 219 320 11090 MUX2_X1
* cell instance $2526 r0 *1 239.02,196
X$2526 11089 11090 10377 320 219 9732 MUX2_X2
* cell instance $2528 m0 *1 185.06,128.8
X$2528 2674 6474 320 219 6501 XNOR2_X1
* cell instance $2530 m0 *1 186.2,128.8
X$2530 2439 6731 320 219 6502 XNOR2_X1
* cell instance $2531 m0 *1 187.34,128.8
X$2531 6501 6502 219 320 6396 NAND2_X2
* cell instance $2532 m0 *1 188.29,128.8
X$2532 4735 219 320 3782 CLKBUF_X3
* cell instance $2534 m0 *1 190,128.8
X$2534 6540 219 320 3978 CLKBUF_X3
* cell instance $2535 m0 *1 190.95,128.8
X$2535 6395 320 3871 219 BUF_X4
* cell instance $2538 m0 *1 193.23,128.8
X$2538 6239 219 320 6328 CLKBUF_X3
* cell instance $2539 m0 *1 194.18,128.8
X$2539 6396 5747 5978 6497 320 6498 219 OR4_X2
* cell instance $2540 m0 *1 195.51,128.8
X$2540 2342 6493 320 219 6475 XNOR2_X1
* cell instance $2541 m0 *1 196.65,128.8
X$2541 2338 6543 320 219 6542 XNOR2_X1
* cell instance $2544 r0 *1 184.87,128.8
X$2544 6640 6636 5584 219 4027 320 AOI21_X2
* cell instance $2545 r0 *1 186.2,128.8
X$2545 6305 320 3966 219 BUF_X4
* cell instance $2546 r0 *1 187.53,128.8
X$2546 6239 320 3054 219 BUF_X4
* cell instance $2547 r0 *1 188.86,128.8
X$2547 6540 320 4180 219 BUF_X4
* cell instance $2551 r0 *1 191.52,128.8
X$2551 6538 219 320 4736 CLKBUF_X3
* cell instance $2553 r0 *1 192.66,128.8
X$2553 219 6396 5747 5978 6497 6582 320 NOR4_X4
* cell instance $2554 r0 *1 196.08,128.8
X$2554 6666 6665 6475 6542 219 6497 320 NAND4_X2
* cell instance $2557 r0 *1 198.36,128.8
X$2557 219 14501 6545 6663 6190 320 DFF_X1
* cell instance $2558 m0 *1 200.26,128.8
X$2558 6496 5161 6476 320 219 5362 OAI21_X4
* cell instance $2559 m0 *1 199.69,128.8
X$2559 6544 3792 219 320 6411 NOR2_X1
* cell instance $2560 m0 *1 202.73,128.8
X$2560 5445 6577 219 320 6496 OR2_X1
* cell instance $2566 r0 *1 201.97,128.8
X$2566 6577 6116 6476 219 320 6546 MUX2_X1
* cell instance $2570 r0 *1 205.96,128.8
X$2570 6863 6397 6660 219 320 6577 MUX2_X1
* cell instance $2571 r0 *1 207.29,128.8
X$2571 6116 320 5369 219 BUF_X4
* cell instance $2572 r0 *1 208.62,128.8
X$2572 219 6257 6547 3419 6548 320 AOI21_X4
* cell instance $2574 m0 *1 209.19,128.8
X$2574 6477 219 320 6116 INV_X2
* cell instance $2578 r0 *1 211.66,128.8
X$2578 219 5960 6478 3419 6549 320 AOI21_X4
* cell instance $2579 m0 *1 212.42,128.8
X$2579 6479 5369 6549 219 320 6493 MUX2_X1
* cell instance $2580 m0 *1 211.66,128.8
X$2580 5640 6479 320 219 6478 AND2_X1
* cell instance $2584 m0 *1 217.74,128.8
X$2584 6400 6414 6477 320 219 6474 MUX2_X2
* cell instance $2590 r0 *1 217.36,128.8
X$2590 6655 3419 6572 320 219 6030 OAI21_X4
* cell instance $2591 r0 *1 219.83,128.8
X$2591 6550 3171 6654 219 320 6572 MUX2_X1
* cell instance $2594 r0 *1 223.06,128.8
X$2594 6553 6087 6570 219 320 6551 MUX2_X1
* cell instance $2595 m0 *1 226.86,128.8
X$2595 6553 6311 6480 219 320 6492 MUX2_X1
* cell instance $2596 m0 *1 223.63,128.8
X$2596 219 13091 6480 6492 6310 320 DFF_X1
* cell instance $2597 m0 *1 228.19,128.8
X$2597 5757 219 320 6310 CLKBUF_X3
* cell instance $2599 m0 *1 230.66,128.8
X$2599 6488 3624 6481 320 219 5440 OAI21_X4
* cell instance $2600 m0 *1 233.13,128.8
X$2600 6410 219 320 3173 BUF_X2
* cell instance $2602 m0 *1 234.08,128.8
X$2602 6486 3624 6554 320 219 4398 OAI21_X4
* cell instance $2603 m0 *1 236.55,128.8
X$2603 3173 6556 219 320 6486 OR2_X1
* cell instance $2604 m0 *1 237.31,128.8
X$2604 6408 219 320 6482 BUF_X1
* cell instance $2605 m0 *1 237.88,128.8
X$2605 6332 219 320 6312 BUF_X1
* cell instance $2606 m0 *1 238.45,128.8
X$2606 6336 219 320 6402 BUF_X1
* cell instance $2607 m0 *1 239.02,128.8
X$2607 6484 219 320 6403 BUF_X1
* cell instance $2610 r0 *1 224.58,128.8
X$2610 6310 219 320 CLKBUF_X1
* cell instance $2611 r0 *1 225.15,128.8
X$2611 6570 4530 6480 219 320 6552 MUX2_X1
* cell instance $2612 r0 *1 226.48,128.8
X$2612 5161 6552 219 320 6568 OR2_X1
* cell instance $2613 r0 *1 227.24,128.8
X$2613 6568 3419 6762 320 219 3778 OAI21_X4
* cell instance $2620 r0 *1 233.32,128.8
X$2620 6411 219 320 6558 BUF_X1
* cell instance $2621 r0 *1 233.89,128.8
X$2621 6401 219 320 CLKBUF_X1
* cell instance $2622 r0 *1 234.46,128.8
X$2622 6758 3171 6644 219 320 6554 MUX2_X1
* cell instance $2623 r0 *1 235.79,128.8
X$2623 3173 6555 219 320 6488 OR2_X1
* cell instance $2625 r0 *1 236.74,128.8
X$2625 3173 6754 219 320 6564 OR2_X1
* cell instance $2627 r0 *1 239.02,128.8
X$2627 6473 219 320 6560 BUF_X1
* cell instance $2629 m0 *1 240.16,128.8
X$2629 6421 219 320 6483 BUF_X1
* cell instance $2634 m0 *1 194.75,131.6
X$2634 2438 6778 320 219 6665 XNOR2_X1
* cell instance $2636 m0 *1 195.89,131.6
X$2636 2471 6546 320 219 6666 XNOR2_X1
* cell instance $2637 m0 *1 197.03,131.6
X$2637 6667 3702 219 320 6648 NOR2_X1
* cell instance $2640 r0 *1 194.75,131.6
X$2640 7205 5902 6586 219 6667 320 AOI21_X1
* cell instance $2642 m0 *1 201.21,131.6
X$2642 6661 5161 6735 320 219 6297 OAI21_X4
* cell instance $2643 m0 *1 197.98,131.6
X$2643 219 13323 6641 6779 6190 320 DFF_X1
* cell instance $2644 m0 *1 203.68,131.6
X$2644 5445 6776 219 320 6661 OR2_X1
* cell instance $2648 r0 *1 199.69,131.6
X$2648 6837 6860 6641 219 320 6779 MUX2_X1
* cell instance $2649 r0 *1 201.02,131.6
X$2649 6641 6080 6545 219 320 6476 MUX2_X1
* cell instance $2651 r0 *1 202.54,131.6
X$2651 6776 6116 6735 219 320 6778 MUX2_X1
* cell instance $2653 r0 *1 204.06,131.6
X$2653 219 14083 6863 6774 6191 320 DFF_X1
* cell instance $2655 m0 *1 204.82,131.6
X$2655 219 13410 6660 6773 6191 320 DFF_X1
* cell instance $2656 m0 *1 208.24,131.6
X$2656 5640 6659 320 219 6547 AND2_X1
* cell instance $2658 m0 *1 209.76,131.6
X$2658 219 13408 6658 6737 6642 320 DFF_X1
* cell instance $2660 r0 *1 207.29,131.6
X$2660 6837 6740 6660 219 320 6773 MUX2_X1
* cell instance $2662 r0 *1 208.81,131.6
X$2662 6659 6116 6548 219 320 6543 MUX2_X1
* cell instance $2664 r0 *1 210.52,131.6
X$2664 6736 6860 6658 219 320 6737 MUX2_X1
* cell instance $2665 r0 *1 211.85,131.6
X$2665 6658 5277 6656 219 320 6549 MUX2_X1
* cell instance $2666 r0 *1 213.18,131.6
X$2666 6736 6843 6656 219 320 6738 MUX2_X1
* cell instance $2668 m0 *1 213.37,131.6
X$2668 219 12819 6656 6738 6642 320 DFF_X1
* cell instance $2670 m0 *1 217.55,131.6
X$2670 219 12660 6654 6768 6642 320 DFF_X1
* cell instance $2673 r0 *1 214.51,131.6
X$2673 6739 5277 6840 219 320 6479 MUX2_X1
* cell instance $2674 r0 *1 215.84,131.6
X$2674 219 14331 6550 6769 6642 320 DFF_X1
* cell instance $2676 r0 *1 219.26,131.6
X$2676 6741 6740 6654 219 320 6768 MUX2_X1
* cell instance $2678 r0 *1 220.97,131.6
X$2678 5161 6742 219 320 6655 OR2_X1
* cell instance $2679 r0 *1 221.73,131.6
X$2679 219 13859 6844 6743 6310 320 DFF_X1
* cell instance $2680 m0 *1 225.91,131.6
X$2680 219 12646 6650 6643 6310 320 DFF_X1
* cell instance $2681 m0 *1 222.68,131.6
X$2681 219 12643 6570 6551 6310 320 DFF_X1
* cell instance $2682 m0 *1 229.14,131.6
X$2682 6553 6101 6650 219 320 6643 MUX2_X1
* cell instance $2686 r0 *1 225.34,131.6
X$2686 6553 5995 6744 219 320 6845 MUX2_X1
* cell instance $2689 r0 *1 228.57,131.6
X$2689 6744 3171 6650 219 320 6762 MUX2_X1
* cell instance $2696 r0 *1 232.37,131.6
X$2696 219 13642 6758 6760 6401 320 DFF_X1
* cell instance $2697 m0 *1 235.6,131.6
X$2697 6648 219 320 6557 BUF_X1
* cell instance $2698 m0 *1 232.37,131.6
X$2698 219 13071 6644 6647 6401 320 DFF_X1
* cell instance $2700 m0 *1 236.36,131.6
X$2700 219 13070 6753 6757 6401 320 DFF_X1
* cell instance $2701 m0 *1 239.59,131.6
X$2701 6645 219 320 5831 BUF_X2
* cell instance $2703 r0 *1 235.6,131.6
X$2703 5757 219 320 6401 CLKBUF_X3
* cell instance $2705 r0 *1 236.74,131.6
X$2705 219 13926 6752 6746 6401 320 DFF_X1
* cell instance $2706 r0 *1 239.97,131.6
X$2706 6503 219 320 6646 BUF_X1
* cell instance $2710 m0 *1 187.15,184.8
X$2710 10487 320 7945 219 BUF_X4
* cell instance $2711 m0 *1 186.39,184.8
X$2711 9790 10056 8114 219 10264 320 AOI21_X1
* cell instance $2712 m0 *1 188.48,184.8
X$2712 10155 10056 9797 219 10306 320 AOI21_X1
* cell instance $2713 m0 *1 189.24,184.8
X$2713 10211 10056 6713 219 10265 320 AOI21_X1
* cell instance $2715 m0 *1 190.19,184.8
X$2715 8426 10056 6680 219 10302 320 AOI21_X1
* cell instance $2717 m0 *1 191.71,184.8
X$2717 4828 7201 10210 7315 4631 320 219 10300 OAI221_X1
* cell instance $2721 r0 *1 186.39,184.8
X$2721 10116 10263 219 320 10401 NOR2_X1
* cell instance $2724 r0 *1 187.53,184.8
X$2724 10303 3163 219 320 10396 NOR2_X2
* cell instance $2725 r0 *1 188.48,184.8
X$2725 10306 10263 219 320 10395 NOR2_X1
* cell instance $2726 r0 *1 189.05,184.8
X$2726 9972 10056 2293 219 10559 320 AOI21_X1
* cell instance $2728 r0 *1 190.19,184.8
X$2728 10300 10056 6586 219 10303 320 AOI21_X1
* cell instance $2732 r0 *1 194.94,184.8
X$2732 10266 10147 219 320 10556 NAND2_X1
* cell instance $2734 m0 *1 195.51,184.8
X$2734 2619 219 320 10267 CLKBUF_X3
* cell instance $2735 m0 *1 197.22,184.8
X$2735 8876 6394 6713 219 10290 320 AOI21_X1
* cell instance $2737 r0 *1 195.51,184.8
X$2737 10266 8719 219 320 10555 NAND2_X1
* cell instance $2739 r0 *1 196.27,184.8
X$2739 10147 10267 8719 219 320 10261 MUX2_X1
* cell instance $2740 r0 *1 197.6,184.8
X$2740 10122 5979 219 320 10392 NOR2_X1
* cell instance $2743 m0 *1 198.36,184.8
X$2743 9611 8951 8489 320 10266 219 NOR3_X2
* cell instance $2744 m0 *1 199.88,184.8
X$2744 10003 5902 2293 219 10292 320 AOI21_X1
* cell instance $2745 m0 *1 200.64,184.8
X$2745 10057 5902 9797 219 10294 320 AOI21_X1
* cell instance $2748 m0 *1 202.35,184.8
X$2748 9913 6394 2293 219 10291 320 AOI21_X1
* cell instance $2750 m0 *1 203.3,184.8
X$2750 10201 6328 219 320 10268 NOR2_X1
* cell instance $2752 m0 *1 204.63,184.8
X$2752 10197 6394 9797 219 10287 320 AOI21_X1
* cell instance $2756 r0 *1 201.4,184.8
X$2756 10110 5979 219 320 10390 NOR2_X1
* cell instance $2757 r0 *1 201.97,184.8
X$2757 10294 5979 219 320 10388 NOR2_X1
* cell instance $2759 r0 *1 202.92,184.8
X$2759 10292 5979 219 320 10389 NOR2_X1
* cell instance $2761 r0 *1 203.87,184.8
X$2761 10291 6836 219 320 10370 NOR2_X1
* cell instance $2763 r0 *1 205.2,184.8
X$2763 10290 6836 219 320 10911 NOR2_X1
* cell instance $2765 r0 *1 205.96,184.8
X$2765 10156 6328 219 320 10371 NOR2_X1
* cell instance $2767 m0 *1 207.48,184.8
X$2767 10100 6836 219 320 10192 NOR2_X1
* cell instance $2769 m0 *1 208.05,184.8
X$2769 10190 6328 219 320 10180 NOR2_X1
* cell instance $2770 m0 *1 208.62,184.8
X$2770 10121 6328 219 320 10182 NOR2_X1
* cell instance $2773 r0 *1 208.05,184.8
X$2773 10157 6836 219 320 10269 NOR2_X1
* cell instance $2774 r0 *1 208.62,184.8
X$2774 10287 6836 219 320 10384 NOR2_X1
* cell instance $2776 r0 *1 209.95,184.8
X$2776 10094 6328 219 320 10383 NOR2_X1
* cell instance $2779 m0 *1 212.61,184.8
X$2779 2371 8489 219 320 10285 NOR2_X1
* cell instance $2781 r0 *1 213.56,184.8
X$2781 10285 10500 10282 320 219 10386 AND3_X1
* cell instance $2782 r0 *1 214.51,184.8
X$2782 10385 10374 219 320 10372 NOR2_X1
* cell instance $2783 r0 *1 215.08,184.8
X$2783 10375 10270 320 219 10385 XNOR2_X1
* cell instance $2784 m0 *1 216.22,184.8
X$2784 10159 10160 320 219 9986 XNOR2_X1
* cell instance $2785 m0 *1 215.08,184.8
X$2785 10088 10065 219 320 9987 XOR2_X1
* cell instance $2786 m0 *1 217.36,184.8
X$2786 219 13493 10159 10161 9888 320 DFF_X1
* cell instance $2789 r0 *1 216.22,184.8
X$2789 10270 10088 10375 219 320 10160 NOR3_X1
* cell instance $2791 r0 *1 217.36,184.8
X$2791 10280 5369 10272 320 219 9183 OAI21_X4
* cell instance $2794 r0 *1 220.97,184.8
X$2794 8861 10271 219 320 10280 OR2_X1
* cell instance $2795 m0 *1 221.92,184.8
X$2795 219 13492 10179 10278 9888 320 DFF_X1
* cell instance $2799 m0 *1 226.1,184.8
X$2799 219 13494 10162 10177 9888 320 DFF_X1
* cell instance $2800 m0 *1 229.33,184.8
X$2800 10068 7291 10179 219 320 10278 MUX2_X1
* cell instance $2801 m0 *1 230.66,184.8
X$2801 10068 7176 10162 219 320 10177 MUX2_X1
* cell instance $2802 m0 *1 231.99,184.8
X$2802 10162 10069 10070 219 320 10271 MUX2_X1
* cell instance $2803 m0 *1 233.32,184.8
X$2803 8732 219 320 10275 BUF_X1
* cell instance $2805 m0 *1 234.65,184.8
X$2805 10167 10175 10377 320 219 9677 MUX2_X2
* cell instance $2806 m0 *1 236.36,184.8
X$2806 10071 10069 9980 219 320 10175 MUX2_X1
* cell instance $2807 m0 *1 237.69,184.8
X$2807 9898 219 320 10163 BUF_X1
* cell instance $2809 m0 *1 238.45,184.8
X$2809 9712 219 320 9981 BUF_X1
* cell instance $2810 m0 *1 239.02,184.8
X$2810 9893 219 320 7167 BUF_X1
* cell instance $2811 m0 *1 239.59,184.8
X$2811 9923 219 320 9805 BUF_X1
* cell instance $2812 m0 *1 240.16,184.8
X$2812 6789 219 320 9892 BUF_X1
* cell instance $2814 r0 *1 221.73,184.8
X$2814 10271 10272 8861 320 219 10376 MUX2_X2
* cell instance $2815 r0 *1 223.44,184.8
X$2815 9888 219 320 CLKBUF_X1
* cell instance $2817 r0 *1 224.2,184.8
X$2817 219 6398 10507 320 BUF_X32
* cell instance $2822 r0 *1 236.55,184.8
X$2822 10165 219 320 10379 BUF_X1
* cell instance $2824 r0 *1 237.88,184.8
X$2824 9984 219 320 10274 BUF_X1
* cell instance $2825 r0 *1 238.45,184.8
X$2825 10164 219 320 8498 BUF_X1
* cell instance $2826 r0 *1 239.02,184.8
X$2826 9567 219 320 10074 BUF_X1
* cell instance $2827 r0 *1 239.59,184.8
X$2827 10273 219 320 9686 BUF_X1
* cell instance $2828 r0 *1 240.16,184.8
X$2828 10073 219 320 9891 BUF_X1
* cell instance $2830 m0 *1 30.21,140
X$2830 4277 320 6121 219 BUF_X4
* cell instance $2833 m0 *1 31.73,140
X$2833 4278 320 7177 219 BUF_X4
* cell instance $2836 m0 *1 34.01,140
X$2836 7182 6154 7125 219 320 7178 MUX2_X1
* cell instance $2838 m0 *1 36.1,140
X$2838 219 13541 7126 7180 6908 320 DFF_X1
* cell instance $2839 m0 *1 39.33,140
X$2839 7238 6917 7126 219 320 7184 MUX2_X1
* cell instance $2841 m0 *1 40.85,140
X$2841 7182 5933 7127 219 320 7181 MUX2_X1
* cell instance $2843 m0 *1 42.94,140
X$2843 7182 6121 7185 219 320 7301 MUX2_X1
* cell instance $2845 m0 *1 47.31,140
X$2845 219 13471 7018 7186 7240 320 DFF_X1
* cell instance $2846 m0 *1 50.54,140
X$2846 219 13207 7020 7019 7240 320 DFF_X1
* cell instance $2849 r0 *1 30.02,140
X$2849 219 13966 7237 7235 7236 320 DFF_X1
* cell instance $2850 r0 *1 33.25,140
X$2850 7236 219 320 14788 INV_X1
* cell instance $2851 r0 *1 33.63,140
X$2851 219 14085 7238 7300 7236 320 DFF_X1
* cell instance $2854 r0 *1 37.43,140
X$2854 7182 6156 7126 219 320 7180 MUX2_X1
* cell instance $2857 r0 *1 39.71,140
X$2857 219 14229 7127 7181 6908 320 DFF_X1
* cell instance $2859 r0 *1 43.32,140
X$2859 219 14699 7185 7301 6908 320 DFF_X1
* cell instance $2862 r0 *1 47.5,140
X$2862 7017 6002 7241 219 320 7303 MUX2_X1
* cell instance $2863 r0 *1 48.83,140
X$2863 219 13703 7241 7303 7240 320 DFF_X1
* cell instance $2866 r0 *1 53.01,140
X$2866 219 13929 7242 7304 7240 320 DFF_X1
* cell instance $2867 m0 *1 56.24,140
X$2867 4278 320 5933 219 BUF_X4
* cell instance $2868 m0 *1 54.91,140
X$2868 7021 4997 7188 219 320 7189 MUX2_X1
* cell instance $2869 m0 *1 57.57,140
X$2869 7024 7129 7128 219 320 7191 MUX2_X1
* cell instance $2870 m0 *1 58.9,140
X$2870 7024 7243 7022 219 320 7190 MUX2_X1
* cell instance $2873 m0 *1 61.18,140
X$2873 6373 219 320 7023 CLKBUF_X3
* cell instance $2880 r0 *1 60.61,140
X$2880 219 14113 7244 7306 7023 320 DFF_X1
* cell instance $2884 m0 *1 63.46,140
X$2884 7244 1374 7357 219 320 6708 MUX2_X1
* cell instance $2886 m0 *1 64.79,140
X$2886 4238 320 7129 219 BUF_X4
* cell instance $2889 r0 *1 63.84,140
X$2889 6612 7192 7244 219 320 7306 MUX2_X1
* cell instance $2890 r0 *1 65.17,140
X$2890 4445 320 7243 219 BUF_X4
* cell instance $2893 m0 *1 68.59,140
X$2893 7195 320 3993 219 BUF_X4
* cell instance $2894 m0 *1 67.26,140
X$2894 3993 320 7091 219 BUF_X4
* cell instance $2895 m0 *1 69.92,140
X$2895 7246 7361 219 320 7093 NAND2_X1
* cell instance $2897 m0 *1 70.68,140
X$2897 4278 320 7136 219 BUF_X4
* cell instance $2899 r0 *1 67.45,140
X$2899 7245 320 4006 219 BUF_X4
* cell instance $2900 r0 *1 68.78,140
X$2900 7247 320 4238 219 BUF_X4
* cell instance $2901 r0 *1 70.11,140
X$2901 7246 7250 219 320 7195 NAND2_X1
* cell instance $2904 r0 *1 71.63,140
X$2904 7248 320 4445 219 BUF_X4
* cell instance $2905 m0 *1 75.62,140
X$2905 7131 320 4361 219 BUF_X4
* cell instance $2906 m0 *1 72.39,140
X$2906 219 12877 6913 7310 6914 320 DFF_X1
* cell instance $2910 m0 *1 82.27,140
X$2910 6915 6710 7028 219 320 7132 MUX2_X1
* cell instance $2913 m0 *1 84.55,140
X$2913 7255 3365 7028 219 320 7029 MUX2_X1
* cell instance $2915 m0 *1 86.64,140
X$2915 7199 7134 7098 7135 219 320 7100 NOR4_X1
* cell instance $2918 r0 *1 72.96,140
X$2918 7249 320 4282 219 BUF_X4
* cell instance $2919 r0 *1 74.29,140
X$2919 6913 7312 6612 219 320 7310 MUX2_X1
* cell instance $2920 r0 *1 75.62,140
X$2920 3948 320 7312 219 BUF_X4
* cell instance $2924 r0 *1 79.04,140
X$2924 219 13814 7255 7253 7254 320 DFF_X1
* cell instance $2925 r0 *1 82.27,140
X$2925 7496 3365 7256 219 320 7133 MUX2_X1
* cell instance $2929 r0 *1 85.69,140
X$2929 7318 3486 2792 219 320 7257 NOR3_X1
* cell instance $2930 r0 *1 86.45,140
X$2930 7319 3486 2792 219 320 7134 NOR3_X1
* cell instance $2932 m0 *1 90.06,140
X$2932 219 13348 7138 7320 6775 320 DFF_X1
* cell instance $2933 m0 *1 88.73,140
X$2933 7258 7136 7031 219 320 7137 MUX2_X1
* cell instance $2934 m0 *1 93.29,140
X$2934 7138 3766 7031 219 320 7203 MUX2_X1
* cell instance $2936 m0 *1 97.66,140
X$2936 7260 3365 7325 219 320 6997 MUX2_X1
* cell instance $2938 m0 *1 100.51,140
X$2938 219 12642 7140 7209 6919 320 DFF_X1
* cell instance $2942 r0 *1 91.2,140
X$2942 7139 7192 7138 219 320 7320 MUX2_X1
* cell instance $2943 r0 *1 92.53,140
X$2943 7258 7089 7260 219 320 7323 MUX2_X1
* cell instance $2944 r0 *1 93.86,140
X$2944 219 14326 7260 7323 6919 320 DFF_X1
* cell instance $2945 r0 *1 97.09,140
X$2945 7139 6710 7325 219 320 7261 MUX2_X1
* cell instance $2948 r0 *1 100.7,140
X$2948 7140 6856 7139 219 320 7209 MUX2_X1
* cell instance $2949 r0 *1 102.03,140
X$2949 7327 6662 7139 219 320 7326 MUX2_X1
* cell instance $2951 m0 *1 105.07,140
X$2951 5253 6057 219 320 6873 OR2_X2
* cell instance $2952 m0 *1 104.12,140
X$2952 3595 219 320 5122 INV_X4
* cell instance $2957 r0 *1 105.83,140
X$2957 5253 320 5077 219 BUF_X4
* cell instance $2958 r0 *1 107.16,140
X$2958 5253 320 6277 219 BUF_X4
* cell instance $2960 m0 *1 107.16,140
X$2960 7211 219 320 6285 CLKBUF_X2
* cell instance $2963 m0 *1 110.39,140
X$2963 219 13092 7035 7141 7262 320 DFF_X1
* cell instance $2965 m0 *1 116.66,140
X$2965 6285 4485 7142 219 320 7213 MUX2_X1
* cell instance $2967 m0 *1 118.18,140
X$2967 219 12916 7142 7213 7037 320 DFF_X1
* cell instance $2971 r0 *1 108.49,140
X$2971 7264 320 5253 219 BUF_X4
* cell instance $2975 r0 *1 113.43,140
X$2975 7263 320 2901 219 BUF_X4
* cell instance $2976 r0 *1 114.76,140
X$2976 5520 320 5515 219 BUF_X4
* cell instance $2978 r0 *1 117.61,140
X$2978 5520 320 2998 219 BUF_X4
* cell instance $2985 r0 *1 123.69,140
X$2985 7335 6691 7381 219 320 7334 MUX2_X1
* cell instance $2988 r0 *1 125.4,140
X$2988 7335 6724 7337 219 320 7336 MUX2_X1
* cell instance $2989 r0 *1 126.73,140
X$2989 219 13695 7337 7336 6925 320 DFF_X1
* cell instance $2993 r0 *1 132.62,140
X$2993 219 13794 7267 7340 7384 320 DFF_X1
* cell instance $2995 m0 *1 133.95,140
X$2995 4377 320 6691 219 BUF_X4
* cell instance $2997 m0 *1 139.08,140
X$2997 7143 6724 7144 219 320 7218 MUX2_X1
* cell instance $2998 m0 *1 140.41,140
X$2998 219 13213 7144 7218 7268 320 DFF_X1
* cell instance $2999 m0 *1 143.64,140
X$2999 7143 6719 7039 219 320 7217 MUX2_X1
* cell instance $3003 m0 *1 150.29,140
X$3003 7224 6724 7223 219 320 7222 MUX2_X1
* cell instance $3004 m0 *1 151.62,140
X$3004 7223 3775 7269 219 320 7225 MUX2_X1
* cell instance $3005 m0 *1 152.95,140
X$3005 7145 4584 7270 219 320 7476 MUX2_X1
* cell instance $3009 r0 *1 138.13,140
X$3009 7143 6622 7041 219 320 7342 MUX2_X1
* cell instance $3010 r0 *1 139.46,140
X$3010 219 14692 7041 7342 7384 320 DFF_X1
* cell instance $3011 r0 *1 142.69,140
X$3011 7143 6691 7040 219 320 7344 MUX2_X1
* cell instance $3012 r0 *1 144.02,140
X$3012 219 14401 7040 7344 7268 320 DFF_X1
* cell instance $3015 r0 *1 148.39,140
X$3015 219 13861 7223 7222 7268 320 DFF_X1
* cell instance $3016 r0 *1 151.62,140
X$3016 7224 6691 7269 219 320 7343 MUX2_X1
* cell instance $3019 r0 *1 153.52,140
X$3019 7224 6719 7270 219 320 7341 MUX2_X1
* cell instance $3021 m0 *1 154.66,140
X$3021 219 13142 7145 7227 6726 320 DFF_X1
* cell instance $3022 m0 *1 163.97,140
X$3022 7231 5488 219 320 7229 NOR2_X2
* cell instance $3025 m0 *1 168.15,140
X$3025 219 7230 3866 7228 7146 320 AOI21_X4
* cell instance $3026 m0 *1 170.62,140
X$3026 7045 5793 219 320 7228 NAND2_X1
* cell instance $3028 r0 *1 154.85,140
X$3028 219 14303 7270 7341 6726 320 DFF_X1
* cell instance $3031 r0 *1 164.92,140
X$3031 7274 7275 7273 320 219 7338 HA_X1
* cell instance $3036 r0 *1 171.19,140
X$3036 6948 219 320 6940 BUF_X1
* cell instance $3037 m0 *1 171.76,140
X$3037 6020 6939 3457 6948 320 219 7226 OAI22_X1
* cell instance $3039 m0 *1 172.71,140
X$3039 7147 2807 219 320 7332 NAND2_X1
* cell instance $3040 m0 *1 173.28,140
X$3040 7046 7220 219 320 7221 NOR2_X1
* cell instance $3042 r0 *1 171.76,140
X$3042 7226 7333 219 320 7331 NOR2_X1
* cell instance $3043 r0 *1 172.33,140
X$3043 4193 6938 3503 1025 320 219 7333 OAI22_X1
* cell instance $3044 r0 *1 173.28,140
X$3044 3058 7332 7221 219 7324 320 AOI21_X2
* cell instance $3045 m0 *1 174.8,140
X$3045 7051 7219 7048 219 7154 320 AOI21_X2
* cell instance $3046 m0 *1 174.23,140
X$3046 7147 6539 219 320 7219 NAND2_X1
* cell instance $3047 m0 *1 176.13,140
X$3047 7148 7215 7216 219 7150 320 AOI21_X2
* cell instance $3048 m0 *1 177.46,140
X$3048 7147 6833 219 320 7214 NAND2_X1
* cell instance $3049 m0 *1 178.03,140
X$3049 219 7193 7148 7214 7052 320 AOI21_X4
* cell instance $3050 m0 *1 180.5,140
X$3050 6987 219 320 6977 INV_X2
* cell instance $3052 m0 *1 184.11,140
X$3052 7212 5533 219 320 7208 NOR2_X1
* cell instance $3055 r0 *1 174.61,140
X$3055 7330 320 6305 219 BUF_X4
* cell instance $3060 r0 *1 176.7,140
X$3060 7207 219 320 6937 BUF_X1
* cell instance $3061 r0 *1 177.27,140
X$3061 7045 6184 219 320 7467 NAND2_X1
* cell instance $3063 r0 *1 178.6,140
X$3063 7329 6833 219 320 7149 NAND2_X1
* cell instance $3066 r0 *1 181.07,140
X$3066 219 7051 320 6305 BUF_X8
* cell instance $3067 r0 *1 183.54,140
X$3067 3103 219 320 7278 INV_X4
* cell instance $3068 r0 *1 184.49,140
X$3068 3103 219 320 7524 BUF_X1
* cell instance $3070 m0 *1 187.15,140
X$3070 219 7148 320 5632 BUF_X8
* cell instance $3071 m0 *1 185.82,140
X$3071 6395 320 7058 219 BUF_X4
* cell instance $3072 m0 *1 189.62,140
X$3072 7210 3545 7321 320 219 7206 HA_X1
* cell instance $3073 m0 *1 191.52,140
X$3073 3102 219 320 7207 BUF_X1
* cell instance $3074 m0 *1 192.09,140
X$3074 7060 7152 7153 219 7204 320 AOI21_X1
* cell instance $3075 m0 *1 192.85,140
X$3075 7206 219 320 7153 INV_X1
* cell instance $3079 r0 *1 187.72,140
X$3079 7322 5537 219 320 7285 NOR2_X2
* cell instance $3080 r0 *1 188.67,140
X$3080 7059 7281 7412 7321 219 7280 320 NAND4_X2
* cell instance $3081 r0 *1 190.38,140
X$3081 3102 7274 7281 320 219 7282 HA_X1
* cell instance $3082 r0 *1 192.28,140
X$3082 7059 219 320 7152 BUF_X1
* cell instance $3083 r0 *1 192.85,140
X$3083 7281 219 320 7316 BUF_X1
* cell instance $3085 m0 *1 194.56,140
X$3085 4736 7201 7202 7315 4239 320 219 7205 OAI221_X1
* cell instance $3086 m0 *1 193.61,140
X$3086 6951 689 7151 1970 219 320 7202 AOI22_X1
* cell instance $3092 r0 *1 195.51,140
X$3092 4586 7315 7286 7201 3788 320 219 7313 OAI221_X1
* cell instance $3097 r0 *1 199.5,140
X$3097 2426 219 320 6938 BUF_X1
* cell instance $3098 m0 *1 200.07,140
X$3098 7155 6860 7062 219 320 7200 MUX2_X1
* cell instance $3100 m0 *1 201.4,140
X$3100 7155 6843 7063 219 320 7198 MUX2_X1
* cell instance $3102 m0 *1 202.92,140
X$3102 7155 6861 7064 219 320 7095 MUX2_X1
* cell instance $3108 m0 *1 204.63,140
X$3108 7155 6740 7094 219 320 7092 MUX2_X1
* cell instance $3109 r0 *1 205.01,140
X$3109 5567 219 320 7061 CLKBUF_X3
* cell instance $3112 m0 *1 206.34,140
X$3112 219 13303 7156 7197 7061 320 DFF_X1
* cell instance $3114 r0 *1 207.67,140
X$3114 219 14456 6960 7309 7061 320 DFF_X1
* cell instance $3115 m0 *1 210.14,140
X$3115 219 13191 6959 7196 7157 320 DFF_X1
* cell instance $3118 m0 *1 214.13,140
X$3118 219 12797 7288 7308 7157 320 DFF_X1
* cell instance $3123 r0 *1 212.23,140
X$3123 219 3419 320 5445 BUF_X8
* cell instance $3126 r0 *1 215.65,140
X$3126 7289 6740 7288 219 320 7308 MUX2_X1
* cell instance $3127 r0 *1 216.98,140
X$3127 7289 6861 7307 219 320 7194 MUX2_X1
* cell instance $3128 m0 *1 217.93,140
X$3128 219 13579 7159 7305 7157 320 DFF_X1
* cell instance $3130 m0 *1 221.16,140
X$3130 219 13580 7161 7160 7162 320 DFF_X1
* cell instance $3131 m0 *1 224.39,140
X$3131 5640 320 5161 219 BUF_X4
* cell instance $3132 m0 *1 225.72,140
X$3132 7163 4530 7068 219 320 7187 MUX2_X1
* cell instance $3133 m0 *1 227.05,140
X$3133 7164 7166 7163 219 320 7066 MUX2_X1
* cell instance $3134 m0 *1 228.38,140
X$3134 7164 7291 7068 219 320 6962 MUX2_X1
* cell instance $3135 m0 *1 229.71,140
X$3135 7164 7176 6963 219 320 7183 MUX2_X1
* cell instance $3137 r0 *1 218.31,140
X$3137 7307 3171 7288 219 320 7158 MUX2_X1
* cell instance $3138 r0 *1 219.64,140
X$3138 7289 6860 7159 219 320 7305 MUX2_X1
* cell instance $3139 r0 *1 220.97,140
X$3139 7289 6843 7161 219 320 7160 MUX2_X1
* cell instance $3143 r0 *1 229.52,140
X$3143 219 13723 6963 7183 7067 320 DFF_X1
* cell instance $3148 m0 *1 231.42,140
X$3148 7164 7165 7069 219 320 7083 MUX2_X1
* cell instance $3149 r0 *1 232.75,140
X$3149 219 14455 6964 7179 7292 320 DFF_X1
* cell instance $3151 m0 *1 233.13,140
X$3151 5162 320 6087 219 BUF_X4
* cell instance $3152 m0 *1 234.65,140
X$3152 7167 7166 6964 219 320 7179 MUX2_X1
* cell instance $3153 m0 *1 235.98,140
X$3153 7075 219 320 6626 BUF_X2
* cell instance $3154 m0 *1 236.74,140
X$3154 219 13489 7072 7071 7067 320 DFF_X1
* cell instance $3155 m0 *1 239.97,140
X$3155 7154 219 320 7169 BUF_X1
* cell instance $3158 r0 *1 235.98,140
X$3158 7150 219 320 7170 BUF_X1
* cell instance $3160 r0 *1 236.74,140
X$3160 7080 219 320 7076 BUF_X1
* cell instance $3162 r0 *1 237.5,140
X$3162 219 13641 7294 7295 7067 320 DFF_X1
* cell instance $3164 m0 *1 155.8,198.8
X$3164 11147 10794 219 320 10971 NAND2_X1
* cell instance $3166 m0 *1 156.37,198.8
X$3166 11147 10787 10897 219 320 11148 NOR3_X1
* cell instance $3167 m0 *1 157.13,198.8
X$3167 9318 9930 219 320 11147 NAND2_X1
* cell instance $3168 m0 *1 157.7,198.8
X$3168 9930 10757 219 320 11149 NAND2_X1
* cell instance $3169 m0 *1 158.27,198.8
X$3169 10787 11149 11217 219 11222 320 AOI21_X1
* cell instance $3170 m0 *1 159.03,198.8
X$3170 11150 10889 10894 219 11065 320 AOI21_X1
* cell instance $3171 m0 *1 159.79,198.8
X$3171 9318 9479 10496 10889 219 320 11217 NAND4_X1
* cell instance $3172 m0 *1 160.74,198.8
X$3172 11116 11151 10894 219 11220 320 AOI21_X1
* cell instance $3173 m0 *1 161.5,198.8
X$3173 11152 11222 11218 320 11221 219 OAI21_X1
* cell instance $3175 m0 *1 162.45,198.8
X$3175 10762 10314 320 219 11151 AND2_X1
* cell instance $3178 m0 *1 164.16,198.8
X$3178 11297 7679 219 320 11153 NOR2_X2
* cell instance $3180 m0 *1 165.3,198.8
X$3180 219 5623 320 11153 BUF_X8
* cell instance $3183 r0 *1 155.61,198.8
X$3183 11295 11147 10787 10897 219 320 11239 NOR4_X1
* cell instance $3185 r0 *1 156.75,198.8
X$3185 219 10762 9479 9318 10757 10889 9930 11375 320 OAI222_X2
* cell instance $3187 r0 *1 159.79,198.8
X$3187 10787 9930 10894 11296 219 320 11150 NOR4_X1
* cell instance $3189 r0 *1 161.12,198.8
X$3189 10794 10693 11219 219 320 11152 NOR3_X1
* cell instance $3191 r0 *1 162.26,198.8
X$3191 10757 219 320 11296 INV_X1
* cell instance $3194 r0 *1 164.35,198.8
X$3194 10889 219 320 11219 INV_X1
* cell instance $3195 r0 *1 164.73,198.8
X$3195 219 11067 10795 10757 11240 11299 320 NOR4_X4
* cell instance $3196 r0 *1 168.15,198.8
X$3196 11240 320 8381 219 BUF_X4
* cell instance $3198 r0 *1 169.86,198.8
X$3198 10151 10152 10474 9672 320 11155 219 NOR4_X2
* cell instance $3200 m0 *1 171.19,198.8
X$3200 11216 11070 219 320 11068 NOR2_X2
* cell instance $3201 m0 *1 172.33,198.8
X$3201 11156 219 320 11070 INV_X1
* cell instance $3202 m0 *1 172.71,198.8
X$3202 11154 10665 11212 11071 11214 11157 219 320 OAI221_X2
* cell instance $3205 r0 *1 171.57,198.8
X$3205 11157 11156 11241 10430 10978 320 219 AOI211_X2
* cell instance $3206 r0 *1 173.28,198.8
X$3206 219 11072 10152 10260 11241 11156 320 NOR4_X4
* cell instance $3210 m0 *1 176.89,198.8
X$3210 11160 10386 10474 320 11214 219 OAI21_X1
* cell instance $3211 m0 *1 175.94,198.8
X$3211 10151 9787 10152 11158 219 320 11159 AOI22_X1
* cell instance $3213 m0 *1 177.84,198.8
X$3213 10386 11160 219 320 11161 OR2_X1
* cell instance $3216 r0 *1 176.7,198.8
X$3216 11300 11159 219 320 11301 NAND2_X1
* cell instance $3218 r0 *1 177.65,198.8
X$3218 11241 320 9672 219 BUF_X4
* cell instance $3219 r0 *1 178.98,198.8
X$3219 7105 10153 11161 219 11242 320 AOI21_X1
* cell instance $3223 m0 *1 180.5,198.8
X$3223 11162 219 320 10700 CLKBUF_X3
* cell instance $3226 r0 *1 181.07,198.8
X$3226 11243 7737 219 320 11244 NOR2_X1
* cell instance $3227 r0 *1 181.64,198.8
X$3227 219 5632 320 11244 BUF_X8
* cell instance $3228 m0 *1 183.54,198.8
X$3228 10700 219 320 11074 INV_X1
* cell instance $3232 r0 *1 184.11,198.8
X$3232 11478 219 320 10153 CLKBUF_X3
* cell instance $3233 r0 *1 185.06,198.8
X$3233 11479 11110 11365 320 219 10590 MUX2_X2
* cell instance $3234 m0 *1 186.01,198.8
X$3234 11027 11110 11076 219 320 11208 MUX2_X1
* cell instance $3236 m0 *1 187.34,198.8
X$3236 11208 11210 10984 11164 219 320 11207 NOR4_X1
* cell instance $3237 m0 *1 188.29,198.8
X$3237 11112 10658 11165 219 320 11166 NAND3_X1
* cell instance $3240 m0 *1 190.76,198.8
X$3240 10707 8381 11019 11078 11206 320 219 AOI211_X2
* cell instance $3242 m0 *1 193.23,198.8
X$3242 11160 10386 219 320 11167 NOR2_X1
* cell instance $3245 m0 *1 196.08,198.8
X$3245 11167 10064 219 320 11204 NOR2_X1
* cell instance $3249 r0 *1 186.77,198.8
X$3249 11110 219 320 11247 INV_X1
* cell instance $3250 r0 *1 187.15,198.8
X$3250 11163 11245 11248 320 219 11164 AND3_X1
* cell instance $3251 r0 *1 188.1,198.8
X$3251 3222 11364 11166 11249 11294 219 320 OAI211_X2
* cell instance $3252 r0 *1 189.81,198.8
X$3252 11294 11207 11077 219 11250 320 AOI21_X1
* cell instance $3257 r0 *1 196.27,198.8
X$3257 9793 10707 219 320 11293 NOR2_X1
* cell instance $3258 r0 *1 196.84,198.8
X$3258 11252 219 320 7315 INV_X2
* cell instance $3260 r0 *1 197.6,198.8
X$3260 11252 10614 9732 9677 219 320 11253 NOR4_X1
* cell instance $3261 r0 *1 198.55,198.8
X$3261 3243 11287 320 219 11359 AND2_X1
* cell instance $3263 m0 *1 199.31,198.8
X$3263 219 11205 11254 12491 8832 320 DFF_X2
* cell instance $3264 m0 *1 203.11,198.8
X$3264 11014 219 320 CLKBUF_X1
* cell instance $3265 m0 *1 203.68,198.8
X$3265 219 13270 11200 11204 11014 320 DFF_X1
* cell instance $3266 m0 *1 206.91,198.8
X$3266 10907 219 320 11080 INV_X1
* cell instance $3267 m0 *1 207.29,198.8
X$3267 219 13281 11197 10988 11014 320 DFF_X1
* cell instance $3268 m0 *1 210.52,198.8
X$3268 11197 219 320 10711 BUF_X2
* cell instance $3269 m0 *1 211.28,198.8
X$3269 11168 219 320 10633 BUF_X2
* cell instance $3273 r0 *1 199.88,198.8
X$3273 10614 11079 11286 219 320 11287 MUX2_X1
* cell instance $3277 r0 *1 206.53,198.8
X$3277 11255 219 320 11102 INV_X2
* cell instance $3278 r0 *1 207.1,198.8
X$3278 11255 10907 12539 320 219 11169 HA_X1
* cell instance $3279 r0 *1 209,198.8
X$3279 11102 10907 11170 320 219 11081 HA_X1
* cell instance $3281 r0 *1 211.28,198.8
X$3281 11169 11281 320 219 11256 XNOR2_X1
* cell instance $3282 r0 *1 212.42,198.8
X$3282 11256 11170 219 320 11340 NAND2_X1
* cell instance $3283 m0 *1 215.65,198.8
X$3283 11277 11193 320 11191 219 XOR2_X2
* cell instance $3284 m0 *1 212.42,198.8
X$3284 219 13463 11193 7309 11004 320 DFF_X1
* cell instance $3287 m0 *1 220.59,198.8
X$3287 219 13548 11172 11190 11171 320 DFF_X1
* cell instance $3288 m0 *1 223.82,198.8
X$3288 10828 5995 11172 219 320 11190 MUX2_X1
* cell instance $3292 m0 *1 229.14,198.8
X$3292 10379 6087 11173 219 320 11095 MUX2_X1
* cell instance $3293 m0 *1 230.47,198.8
X$3293 11173 10069 11001 219 320 11188 MUX2_X1
* cell instance $3294 m0 *1 231.8,198.8
X$3294 10180 219 320 11088 BUF_X1
* cell instance $3297 m0 *1 233.32,198.8
X$3297 10992 219 320 8196 BUF_X1
* cell instance $3299 r0 *1 212.99,198.8
X$3299 11169 219 320 11280 INV_X1
* cell instance $3300 r0 *1 213.37,198.8
X$3300 219 11341 11281 11257 11280 11339 320 FA_X1
* cell instance $3301 r0 *1 216.41,198.8
X$3301 9818 219 320 11004 CLKBUF_X3
* cell instance $3302 r0 *1 217.36,198.8
X$3302 11004 219 320 CLKBUF_X1
* cell instance $3303 r0 *1 217.93,198.8
X$3303 11170 11257 219 320 11343 NAND2_X1
* cell instance $3306 r0 *1 219.64,198.8
X$3306 219 14629 11258 11275 11171 320 DFF_X1
* cell instance $3307 r0 *1 222.87,198.8
X$3307 11172 10069 11083 219 320 11276 MUX2_X1
* cell instance $3308 r0 *1 224.2,198.8
X$3308 10828 6087 11258 219 320 11275 MUX2_X1
* cell instance $3312 r0 *1 228.19,198.8
X$3312 10379 5995 11270 219 320 11260 MUX2_X1
* cell instance $3313 r0 *1 229.52,198.8
X$3313 11188 11271 10377 320 219 9793 MUX2_X2
* cell instance $3317 r0 *1 231.23,198.8
X$3317 11270 10069 11345 219 320 11271 MUX2_X1
* cell instance $3321 m0 *1 234.27,198.8
X$3321 9735 219 320 11178 BUF_X1
* cell instance $3322 m0 *1 235.03,198.8
X$3322 10392 219 320 10991 BUF_X1
* cell instance $3323 m0 *1 235.6,198.8
X$3323 219 12588 11175 11174 11084 320 DFF_X1
* cell instance $3324 m0 *1 238.83,198.8
X$3324 11175 10507 10913 219 320 11089 MUX2_X1
* cell instance $3325 m0 *1 240.16,198.8
X$3325 10182 219 320 11086 BUF_X1
* cell instance $3328 r0 *1 234.65,198.8
X$3328 219 10378 10820 320 BUF_X16
* cell instance $3329 r0 *1 239.4,198.8
X$3329 10821 6087 11175 219 320 11174 MUX2_X1
* cell instance $3331 m0 *1 33.44,114.8
X$3331 5097 219 320 CLKBUF_X1
* cell instance $3337 m0 *1 30.78,114.8
X$3337 5499 4278 5503 219 320 5502 MUX2_X1
* cell instance $3340 r0 *1 30.97,114.8
X$3340 219 13939 5503 5502 5097 320 DFF_X1
* cell instance $3341 r0 *1 34.2,114.8
X$3341 4051 219 320 5097 CLKBUF_X3
* cell instance $3343 r0 *1 35.34,114.8
X$3343 5503 2657 5658 219 320 5657 MUX2_X1
* cell instance $3344 r0 *1 36.67,114.8
X$3344 5420 3993 5658 219 320 5659 MUX2_X1
* cell instance $3346 m0 *1 38.38,114.8
X$3346 219 13041 5562 5504 4990 320 DFF_X1
* cell instance $3349 r0 *1 38.19,114.8
X$3349 5562 4006 5420 219 320 5504 MUX2_X1
* cell instance $3350 r0 *1 39.52,114.8
X$3350 5562 3848 5603 219 320 5661 MUX2_X1
* cell instance $3353 r0 *1 41.42,114.8
X$3353 5420 3910 5603 219 320 5662 MUX2_X1
* cell instance $3354 m0 *1 42.18,114.8
X$3354 5561 4992 219 320 5418 NAND2_X1
* cell instance $3356 m0 *1 42.75,114.8
X$3356 5663 4906 219 320 5464 NAND2_X1
* cell instance $3357 m0 *1 43.32,114.8
X$3357 5419 4279 5563 320 219 5213 OAI21_X4
* cell instance $3362 r0 *1 43.32,114.8
X$3362 5664 3758 5602 219 320 5563 MUX2_X1
* cell instance $3366 r0 *1 47.12,114.8
X$3366 5665 4765 5564 219 320 5664 MUX2_X1
* cell instance $3367 m0 *1 47.88,114.8
X$3367 5465 3950 5505 219 320 5564 MUX2_X1
* cell instance $3372 r0 *1 49.02,114.8
X$3372 5389 4702 5604 219 320 5665 MUX2_X1
* cell instance $3373 m0 *1 50.92,114.8
X$3373 219 12792 5604 5506 5388 320 DFF_X1
* cell instance $3374 m0 *1 49.59,114.8
X$3374 5420 4282 5505 219 320 5468 MUX2_X1
* cell instance $3375 m0 *1 54.15,114.8
X$3375 3679 219 320 5388 CLKBUF_X3
* cell instance $3378 r0 *1 50.35,114.8
X$3378 5420 3947 5604 219 320 5506 MUX2_X1
* cell instance $3379 r0 *1 51.68,114.8
X$3379 5102 320 5810 219 BUF_X4
* cell instance $3383 r0 *1 55.48,114.8
X$3383 219 14244 5667 5666 5388 320 DFF_X1
* cell instance $3385 m0 *1 56.24,114.8
X$3385 219 12746 5605 5507 5388 320 DFF_X1
* cell instance $3392 r0 *1 62.32,114.8
X$3392 3723 219 320 5107 CLKBUF_X3
* cell instance $3396 r0 *1 63.27,114.8
X$3396 219 13746 5508 5670 5107 320 DFF_X1
* cell instance $3397 m0 *1 65.36,114.8
X$3397 5102 320 3950 219 BUF_X4
* cell instance $3399 m0 *1 66.69,114.8
X$3399 5102 320 2957 219 BUF_X4
* cell instance $3403 r0 *1 67.64,114.8
X$3403 5606 1844 5508 219 320 5673 MUX2_X1
* cell instance $3404 m0 *1 69.73,114.8
X$3404 219 4279 320 5421 BUF_X8
* cell instance $3405 m0 *1 68.4,114.8
X$3405 5421 320 4854 219 BUF_X4
* cell instance $3406 m0 *1 72.2,114.8
X$3406 4364 320 4497 219 BUF_X4
* cell instance $3409 m0 *1 74.48,114.8
X$3409 219 13189 5509 5677 5315 320 DFF_X1
* cell instance $3411 m0 *1 78.47,114.8
X$3411 219 13393 5574 5510 5315 320 DFF_X1
* cell instance $3412 m0 *1 81.7,114.8
X$3412 3723 219 320 5315 CLKBUF_X3
* cell instance $3414 m0 *1 84.17,114.8
X$3414 5511 4617 5575 219 320 5576 MUX2_X1
* cell instance $3415 m0 *1 85.5,114.8
X$3415 219 13411 5575 5576 5315 320 DFF_X1
* cell instance $3422 r0 *1 71.82,114.8
X$3422 4445 320 4617 219 BUF_X4
* cell instance $3423 r0 *1 73.15,114.8
X$3423 219 13790 5607 5676 5716 320 DFF_X1
* cell instance $3424 r0 *1 76.38,114.8
X$3424 5509 3496 5678 219 320 5677 MUX2_X1
* cell instance $3426 r0 *1 77.9,114.8
X$3426 5678 4163 5574 219 320 5510 MUX2_X1
* cell instance $3427 r0 *1 79.23,114.8
X$3427 219 14263 5718 5679 5315 320 DFF_X1
* cell instance $3430 r0 *1 83.6,114.8
X$3430 5517 5102 2031 219 320 NOR2_X4
* cell instance $3432 r0 *1 85.69,114.8
X$3432 5350 2672 2152 219 320 NOR2_X4
* cell instance $3435 r0 *1 87.97,114.8
X$3435 5575 5254 5422 219 320 5684 MUX2_X1
* cell instance $3437 r0 *1 89.68,114.8
X$3437 5112 219 320 CLKBUF_X1
* cell instance $3438 m0 *1 93.1,114.8
X$3438 5423 3496 5514 219 320 5476 MUX2_X1
* cell instance $3439 m0 *1 89.87,114.8
X$3439 219 13293 5513 5512 5112 320 DFF_X1
* cell instance $3441 r0 *1 90.25,114.8
X$3441 3856 219 320 5112 CLKBUF_X3
* cell instance $3443 r0 *1 91.39,114.8
X$3443 5514 3860 5513 219 320 5512 MUX2_X1
* cell instance $3444 r0 *1 92.72,114.8
X$3444 5423 5254 5513 219 320 5581 MUX2_X1
* cell instance $3446 r0 *1 94.43,114.8
X$3446 5684 3370 5515 320 5578 219 NOR3_X2
* cell instance $3447 m0 *1 95,114.8
X$3447 5514 4163 5516 219 320 5424 MUX2_X1
* cell instance $3449 m0 *1 96.33,114.8
X$3449 5425 5353 5516 219 320 5579 MUX2_X1
* cell instance $3450 m0 *1 97.66,114.8
X$3450 5579 4566 219 320 5580 NOR2_X1
* cell instance $3453 r0 *1 95.76,114.8
X$3453 219 5686 5578 5687 5580 5722 320 NOR4_X4
* cell instance $3454 r0 *1 99.18,114.8
X$3454 5581 5122 5253 320 5687 219 NOR3_X2
* cell instance $3457 m0 *1 8.93,170.8
X$3457 9526 219 320 8847 CLKBUF_X3
* cell instance $3461 m0 *1 16.15,170.8
X$3461 219 12985 9136 9196 9135 320 DFF_X1
* cell instance $3471 r0 *1 6.08,170.8
X$3471 219 14475 9392 9452 8847 320 DFF_X1
* cell instance $3475 r0 *1 9.31,170.8
X$3475 9453 8788 9392 219 320 9455 MUX2_X1
* cell instance $3477 r0 *1 11.02,170.8
X$3477 219 14701 9395 9394 8847 320 DFF_X1
* cell instance $3478 r0 *1 14.25,170.8
X$3478 9393 7177 9286 219 320 9347 MUX2_X1
* cell instance $3479 r0 *1 15.58,170.8
X$3479 219 14431 9286 9347 9135 320 DFF_X1
* cell instance $3482 r0 *1 19.76,170.8
X$3482 9286 8908 9461 219 320 9462 MUX2_X1
* cell instance $3484 m0 *1 25.27,170.8
X$3484 8914 6909 8548 219 320 9200 MUX2_X1
* cell instance $3486 m0 *1 26.6,170.8
X$3486 8548 7082 8916 219 320 9137 MUX2_X1
* cell instance $3487 m0 *1 27.93,170.8
X$3487 219 12887 8916 9137 8441 320 DFF_X1
* cell instance $3491 m0 *1 35.91,170.8
X$3491 219 12775 9139 9138 9202 320 DFF_X1
* cell instance $3492 m0 *1 39.14,170.8
X$3492 219 13062 9140 9203 9202 320 DFF_X1
* cell instance $3493 m0 *1 42.37,170.8
X$3493 9140 6110 8552 219 320 9203 MUX2_X1
* cell instance $3496 m0 *1 44.65,170.8
X$3496 219 12694 9038 9204 9205 320 DFF_X1
* cell instance $3499 m0 *1 51.68,170.8
X$3499 4997 320 6458 219 BUF_X4
* cell instance $3506 r0 *1 43.89,170.8
X$3506 6458 320 8860 219 BUF_X4
* cell instance $3511 r0 *1 48.07,170.8
X$3511 6458 320 8920 219 BUF_X4
* cell instance $3514 r0 *1 56.24,170.8
X$3514 219 13724 9289 9288 9205 320 DFF_X1
* cell instance $3516 m0 *1 56.43,170.8
X$3516 219 12756 9142 9209 8804 320 DFF_X1
* cell instance $3519 r0 *1 59.47,170.8
X$3519 9407 8791 9289 219 320 9290 MUX2_X1
* cell instance $3520 r0 *1 60.8,170.8
X$3520 219 14287 9291 9354 8804 320 DFF_X1
* cell instance $3521 m0 *1 62.51,170.8
X$3521 8804 219 320 CLKBUF_X1
* cell instance $3523 m0 *1 63.08,170.8
X$3523 8926 219 320 8804 CLKBUF_X3
* cell instance $3524 m0 *1 64.03,170.8
X$3524 9143 7192 9211 219 320 9210 MUX2_X1
* cell instance $3530 r0 *1 64.03,170.8
X$3530 9291 6856 9143 219 320 9354 MUX2_X1
* cell instance $3531 r0 *1 65.36,170.8
X$3531 9291 8908 9409 219 320 9357 MUX2_X1
* cell instance $3532 m0 *1 66.69,170.8
X$3532 9211 8795 9476 219 320 9358 MUX2_X1
* cell instance $3534 m0 *1 68.02,170.8
X$3534 9356 6662 9143 219 320 9212 MUX2_X1
* cell instance $3536 m0 *1 69.54,170.8
X$3536 9143 6710 9292 219 320 9293 MUX2_X1
* cell instance $3539 m0 *1 74.1,170.8
X$3539 219 13564 9144 9215 9295 320 DFF_X1
* cell instance $3540 m0 *1 77.33,170.8
X$3540 9143 7025 9219 219 320 9294 MUX2_X1
* cell instance $3541 m0 *1 78.66,170.8
X$3541 9143 7027 9217 219 320 9216 MUX2_X1
* cell instance $3542 m0 *1 79.99,170.8
X$3542 9219 8799 9296 219 320 9360 MUX2_X1
* cell instance $3543 m0 *1 81.32,170.8
X$3543 9144 8913 9217 219 320 9361 MUX2_X1
* cell instance $3546 r0 *1 67.07,170.8
X$3546 9357 8860 9358 219 320 9359 MUX2_X1
* cell instance $3547 r0 *1 68.4,170.8
X$3547 9356 8145 9292 219 320 9480 MUX2_X1
* cell instance $3548 r0 *1 69.73,170.8
X$3548 219 14337 9292 9293 8449 320 DFF_X1
* cell instance $3553 r0 *1 75.81,170.8
X$3553 9144 7312 9143 219 320 9215 MUX2_X1
* cell instance $3554 r0 *1 77.14,170.8
X$3554 219 13793 9219 9294 9295 320 DFF_X1
* cell instance $3555 r0 *1 80.37,170.8
X$3555 9361 8920 9360 219 320 9362 MUX2_X1
* cell instance $3557 m0 *1 83.22,170.8
X$3557 9222 219 320 8811 BUF_X1
* cell instance $3559 m0 *1 83.79,170.8
X$3559 9297 7136 9145 219 320 9225 MUX2_X1
* cell instance $3560 m0 *1 85.12,170.8
X$3560 219 12649 9145 9225 8809 320 DFF_X1
* cell instance $3561 m0 *1 88.35,170.8
X$3561 9146 6172 9145 219 320 9364 MUX2_X1
* cell instance $3563 m0 *1 89.87,170.8
X$3563 9298 6165 9299 219 320 9229 MUX2_X1
* cell instance $3564 m0 *1 91.2,170.8
X$3564 8809 219 320 CLKBUF_X1
* cell instance $3566 m0 *1 91.96,170.8
X$3566 9364 6165 9365 219 320 9230 MUX2_X1
* cell instance $3568 m0 *1 93.48,170.8
X$3568 9229 3486 9230 219 320 9238 MUX2_X1
* cell instance $3571 r0 *1 84.93,170.8
X$3571 219 13839 9146 9363 9295 320 DFF_X1
* cell instance $3572 r0 *1 88.16,170.8
X$3572 9415 7192 9146 219 320 9363 MUX2_X1
* cell instance $3575 r0 *1 91.2,170.8
X$3575 219 14267 9301 9300 8809 320 DFF_X1
* cell instance $3578 m0 *1 95.19,170.8
X$3578 9232 9207 3922 320 219 9233 OAI21_X4
* cell instance $3579 m0 *1 97.85,170.8
X$3579 219 13290 9149 9148 8992 320 DFF_X1
* cell instance $3582 r0 *1 97.66,170.8
X$3582 9149 7492 9415 219 320 9148 MUX2_X1
* cell instance $3585 r0 *1 100.89,170.8
X$3585 9149 5217 9304 219 320 9303 MUX2_X1
* cell instance $3586 m0 *1 102.79,170.8
X$3586 9237 9207 9151 320 219 5919 OAI21_X4
* cell instance $3587 m0 *1 101.46,170.8
X$3587 9239 3486 9150 219 320 9151 MUX2_X1
* cell instance $3590 m0 *1 112.86,170.8
X$3590 8999 8242 8931 219 320 9000 MUX2_X1
* cell instance $3593 r0 *1 102.22,170.8
X$3593 9303 2904 9490 219 320 9239 MUX2_X1
* cell instance $3595 r0 *1 103.93,170.8
X$3595 9304 7312 9415 219 320 9371 MUX2_X1
* cell instance $3597 r0 *1 105.45,170.8
X$3597 219 13822 9304 9371 9242 320 DFF_X1
* cell instance $3602 r0 *1 114.19,170.8
X$3602 8697 219 320 9421 CLKBUF_X3
* cell instance $3604 m0 *1 117.8,170.8
X$3604 8932 8278 9152 219 320 9245 MUX2_X1
* cell instance $3606 m0 *1 119.13,170.8
X$3606 219 13300 9152 9245 8819 320 DFF_X1
* cell instance $3607 m0 *1 122.36,170.8
X$3607 8932 8242 9153 219 320 9246 MUX2_X1
* cell instance $3617 r0 *1 120.84,170.8
X$3617 8697 219 320 8819 CLKBUF_X3
* cell instance $3619 r0 *1 123.31,170.8
X$3619 7607 9501 219 320 9305 OR2_X2
* cell instance $3623 m0 *1 129.58,170.8
X$3623 8820 9157 9156 219 320 9248 MUX2_X1
* cell instance $3624 m0 *1 126.35,170.8
X$3624 219 13599 9156 9248 9045 320 DFF_X1
* cell instance $3626 m0 *1 131.1,170.8
X$3626 9155 7723 9156 219 320 9250 MUX2_X1
* cell instance $3627 m0 *1 132.43,170.8
X$3627 219 13558 9158 9249 9046 320 DFF_X1
* cell instance $3629 m0 *1 135.85,170.8
X$3629 9010 9154 9123 219 320 9252 MUX2_X1
* cell instance $3631 m0 *1 137.37,170.8
X$3631 9010 9157 9254 219 320 9253 MUX2_X1
* cell instance $3635 m0 *1 141.17,170.8
X$3635 9159 219 320 9374 INV_X1
* cell instance $3636 m0 *1 141.55,170.8
X$3636 6956 9257 9161 320 219 9162 HA_X1
* cell instance $3637 m0 *1 143.45,170.8
X$3637 9162 9161 9259 219 9375 320 AOI21_X1
* cell instance $3638 m0 *1 144.21,170.8
X$3638 7210 8289 9163 320 219 9261 HA_X1
* cell instance $3639 m0 *1 146.11,170.8
X$3639 9261 219 320 9259 INV_X1
* cell instance $3641 m0 *1 146.68,170.8
X$3641 9167 219 320 9262 INV_X1
* cell instance $3642 m0 *1 147.06,170.8
X$3642 9165 219 320 9378 INV_X1
* cell instance $3643 m0 *1 147.44,170.8
X$3643 9262 9264 9378 320 9164 219 OAI21_X1
* cell instance $3644 m0 *1 148.2,170.8
X$3644 9264 219 320 9263 INV_X1
* cell instance $3645 m0 *1 148.58,170.8
X$3645 9165 9167 9263 219 9307 320 AOI21_X1
* cell instance $3646 m0 *1 149.34,170.8
X$3646 9166 9167 320 219 9168 AND2_X2
* cell instance $3647 m0 *1 150.29,170.8
X$3647 8709 9265 9167 320 219 9165 HA_X1
* cell instance $3648 m0 *1 152.19,170.8
X$3648 9309 9266 219 320 9312 NAND2_X1
* cell instance $3649 m0 *1 152.76,170.8
X$3649 9311 9625 9169 9314 9170 9627 320 219 AOI221_X2
* cell instance $3650 m0 *1 154.85,170.8
X$3650 8491 9005 9315 320 219 9269 HA_X1
* cell instance $3652 m0 *1 156.94,170.8
X$3652 9380 9269 9271 219 9519 320 AOI21_X1
* cell instance $3653 m0 *1 157.7,170.8
X$3653 9379 219 320 9270 BUF_X1
* cell instance $3654 m0 *1 158.27,170.8
X$3654 9379 219 320 9271 BUF_X1
* cell instance $3655 m0 *1 158.84,170.8
X$3655 219 12725 9172 9274 8758 320 DFF_X1
* cell instance $3658 m0 *1 163.02,170.8
X$3658 598 9051 219 320 9387 NAND2_X1
* cell instance $3661 m0 *1 164.54,170.8
X$3661 2761 219 320 9178 BUF_X1
* cell instance $3662 m0 *1 165.11,170.8
X$3662 9174 9052 2761 320 219 9390 MUX2_X2
* cell instance $3668 r0 *1 141.36,170.8
X$3668 7624 219 320 9257 INV_X1
* cell instance $3671 r0 *1 142.69,170.8
X$3671 9374 9375 9160 320 9376 219 OAI21_X1
* cell instance $3672 r0 *1 143.45,170.8
X$3672 7451 9377 9508 320 219 9306 HA_X1
* cell instance $3673 r0 *1 145.35,170.8
X$3673 7889 219 320 9377 INV_X1
* cell instance $3678 r0 *1 148.58,170.8
X$3678 9549 9309 320 219 9308 AND2_X2
* cell instance $3679 r0 *1 149.53,170.8
X$3679 8518 8480 9309 320 219 9310 HA_X1
* cell instance $3680 r0 *1 151.43,170.8
X$3680 9308 9311 9168 219 9427 320 NAND3_X4
* cell instance $3682 r0 *1 154.28,170.8
X$3682 9313 219 320 9314 BUF_X1
* cell instance $3683 r0 *1 154.85,170.8
X$3683 9315 9270 9317 9316 219 320 9512 NAND4_X1
* cell instance $3684 r0 *1 155.8,170.8
X$3684 219 9315 9313 9317 9379 9311 320 AND4_X4
* cell instance $3685 r0 *1 158.27,170.8
X$3685 8318 9171 9379 320 219 9380 HA_X1
* cell instance $3686 r0 *1 160.17,170.8
X$3686 9383 219 320 8758 CLKBUF_X3
* cell instance $3687 r0 *1 161.12,170.8
X$3687 9386 9434 9387 219 9274 320 AOI21_X1
* cell instance $3688 r0 *1 161.88,170.8
X$3688 8758 219 320 14711 INV_X2
* cell instance $3690 r0 *1 162.64,170.8
X$3690 219 9318 9173 2441 9435 320 AOI21_X4
* cell instance $3691 r0 *1 165.11,170.8
X$3691 9388 9132 9436 320 9174 219 OAI21_X1
* cell instance $3694 r0 *1 166.44,170.8
X$3694 2441 7908 9389 219 9381 320 AOI21_X2
* cell instance $3695 m0 *1 168.34,170.8
X$3695 9176 9055 9267 9177 219 320 9320 NAND4_X1
* cell instance $3696 m0 *1 167.2,170.8
X$3696 9267 9055 9176 9054 320 219 9175 AND4_X1
* cell instance $3697 m0 *1 169.29,170.8
X$3697 9267 769 219 320 9276 NOR2_X2
* cell instance $3700 r0 *1 167.96,170.8
X$3700 9319 9322 219 320 9389 OR2_X1
* cell instance $3701 r0 *1 168.72,170.8
X$3701 9320 9278 9178 320 219 9384 MUX2_X2
* cell instance $3703 m0 *1 171.57,170.8
X$3703 9055 8948 9180 219 320 9132 NOR3_X1
* cell instance $3704 m0 *1 170.62,170.8
X$3704 9280 5488 219 320 9385 NOR2_X2
* cell instance $3707 m0 *1 173.28,170.8
X$3707 9179 7044 8363 219 9515 320 AOI21_X1
* cell instance $3709 m0 *1 174.23,170.8
X$3709 3730 320 3693 219 BUF_X4
* cell instance $3710 m0 *1 175.56,170.8
X$3710 769 219 320 9180 INV_X2
* cell instance $3712 r0 *1 170.62,170.8
X$3712 818 9382 219 320 9321 NOR2_X1
* cell instance $3714 r0 *1 171.38,170.8
X$3714 9321 8948 769 219 320 9322 NAND3_X1
* cell instance $3716 r0 *1 172.9,170.8
X$3716 3730 320 3233 219 BUF_X4
* cell instance $3722 m0 *1 176.51,170.8
X$3722 818 219 320 9055 CLKBUF_X3
* cell instance $3723 m0 *1 178.98,170.8
X$3723 9283 6870 8363 219 9323 320 AOI21_X1
* cell instance $3727 r0 *1 178.41,170.8
X$3727 7944 9438 6732 8947 219 320 9324 AOI22_X1
* cell instance $3728 r0 *1 179.36,170.8
X$3728 6237 4442 9324 1449 8324 320 219 9325 OAI221_X1
* cell instance $3730 m0 *1 180.12,170.8
X$3730 7148 9282 9181 219 9348 320 AOI21_X2
* cell instance $3732 r0 *1 181.26,170.8
X$3732 9325 6635 9060 219 9373 320 AOI21_X1
* cell instance $3734 m0 *1 181.83,170.8
X$3734 9011 8115 8363 219 9366 320 AOI21_X1
* cell instance $3736 m0 *1 184.3,170.8
X$3736 9326 6635 9050 219 9355 320 AOI21_X1
* cell instance $3737 m0 *1 185.06,170.8
X$3737 6395 1290 9327 8001 320 219 9277 OAI22_X2
* cell instance $3738 m0 *1 186.77,170.8
X$3738 9369 7102 9277 9275 7151 9368 320 219 AOI221_X2
* cell instance $3739 m0 *1 188.86,170.8
X$3739 7148 9273 9368 219 9367 320 AOI21_X2
* cell instance $3744 r0 *1 182.59,170.8
X$3744 9373 5570 219 320 9213 NOR2_X1
* cell instance $3747 r0 *1 183.73,170.8
X$3747 6237 4007 9507 1290 8324 320 219 9326 OAI221_X1
* cell instance $3748 r0 *1 184.87,170.8
X$3748 6073 1290 9327 5898 320 219 9372 OAI22_X2
* cell instance $3749 r0 *1 186.58,170.8
X$3749 6987 1290 9327 5901 320 219 9328 OAI22_X2
* cell instance $3750 r0 *1 188.29,170.8
X$3750 9275 7628 9372 9369 8421 9370 320 219 AOI221_X2
* cell instance $3751 r0 *1 190.38,170.8
X$3751 9366 5570 219 320 9439 NOR2_X1
* cell instance $3753 m0 *1 191.52,170.8
X$3753 6395 9180 9183 4458 320 219 9184 OAI22_X2
* cell instance $3756 m0 *1 194.75,170.8
X$3756 9267 219 320 8948 INV_X2
* cell instance $3757 m0 *1 195.32,170.8
X$3757 4014 4193 9183 7522 9256 9330 219 320 OAI221_X2
* cell instance $3758 m0 *1 197.41,170.8
X$3758 7522 8991 9255 8948 8324 320 219 9251 OAI221_X1
* cell instance $3759 m0 *1 198.55,170.8
X$3759 9355 5570 219 320 9214 NOR2_X1
* cell instance $3762 r0 *1 192.66,170.8
X$3762 9329 7102 9184 4015 7151 9750 320 219 AOI221_X2
* cell instance $3763 r0 *1 194.75,170.8
X$3763 6982 769 9329 7944 219 320 9256 AOI22_X2
* cell instance $3764 r0 *1 196.46,170.8
X$3764 7628 3812 8421 9064 219 320 9331 AOI22_X1
* cell instance $3765 r0 *1 197.41,170.8
X$3765 4523 8991 9331 8948 6075 320 219 9481 OAI221_X1
* cell instance $3767 r0 *1 198.93,170.8
X$3767 9251 8115 8114 219 9332 320 AOI21_X1
* cell instance $3768 m0 *1 199.69,170.8
X$3768 4015 9066 4016 219 320 9185 NAND3_X1
* cell instance $3770 m0 *1 200.45,170.8
X$3770 9247 6836 219 320 9223 NOR2_X1
* cell instance $3772 m0 *1 204.06,170.8
X$3772 9244 9106 320 219 9335 AND2_X2
* cell instance $3773 m0 *1 205.01,170.8
X$3773 8318 9327 9351 320 219 9186 HA_X1
* cell instance $3775 m0 *1 207.1,170.8
X$3775 9186 9351 219 320 9333 NOR2_X1
* cell instance $3777 m0 *1 207.86,170.8
X$3777 9236 9188 9104 9335 219 9231 320 NAND4_X2
* cell instance $3780 r0 *1 201.21,170.8
X$3780 9353 219 320 9327 INV_X4
* cell instance $3784 r0 *1 206.34,170.8
X$3784 9105 9333 219 320 9334 NOR2_X1
* cell instance $3785 r0 *1 206.91,170.8
X$3785 9334 9187 9335 219 320 9352 NAND3_X2
* cell instance $3786 r0 *1 208.24,170.8
X$3786 219 9335 9236 9188 9104 9336 320 AND4_X4
* cell instance $3787 m0 *1 211.85,170.8
X$3787 1282 219 320 9976 CLKBUF_X3
* cell instance $3788 m0 *1 209.95,170.8
X$3788 8659 9227 9350 320 219 9224 HA_X1
* cell instance $3789 m0 *1 212.8,170.8
X$3789 9098 9224 9220 320 9221 219 OAI21_X1
* cell instance $3792 m0 *1 216.79,170.8
X$3792 8979 7750 9096 219 320 9218 MUX2_X1
* cell instance $3796 r0 *1 210.71,170.8
X$3796 9073 9351 9350 9102 320 219 9236 AND4_X2
* cell instance $3797 r0 *1 212.04,170.8
X$3797 9227 219 320 8944 INV_X2
* cell instance $3800 r0 *1 218.88,170.8
X$3800 219 14139 9446 9468 8953 320 DFF_X1
* cell instance $3804 r0 *1 224.77,170.8
X$3804 9337 8212 9349 219 320 9338 MUX2_X1
* cell instance $3805 r0 *1 226.1,170.8
X$3805 219 13719 9349 9339 9077 320 DFF_X1
* cell instance $3806 m0 *1 227.81,170.8
X$3806 219 12811 8957 9190 9077 320 DFF_X1
* cell instance $3810 m0 *1 231.99,170.8
X$3810 8410 219 320 9082 BUF_X1
* cell instance $3811 m0 *1 232.56,170.8
X$3811 6410 9201 219 320 8960 OR2_X1
* cell instance $3812 m0 *1 233.32,170.8
X$3812 8510 219 320 9080 BUF_X1
* cell instance $3813 m0 *1 233.89,170.8
X$3813 6410 9345 219 320 9191 OR2_X1
* cell instance $3814 m0 *1 234.65,170.8
X$3814 9348 219 320 9081 BUF_X1
* cell instance $3815 m0 *1 235.22,170.8
X$3815 9346 219 320 8964 BUF_X1
* cell instance $3816 m0 *1 235.79,170.8
X$3816 8844 219 320 CLKBUF_X1
* cell instance $3817 m0 *1 236.36,170.8
X$3817 8965 219 320 7852 BUF_X1
* cell instance $3818 m0 *1 236.93,170.8
X$3818 219 12796 8962 9085 8844 320 DFF_X1
* cell instance $3819 m0 *1 240.16,170.8
X$3819 7632 219 320 9194 BUF_X1
* cell instance $3821 r0 *1 229.33,170.8
X$3821 9447 219 320 9077 CLKBUF_X3
* cell instance $3822 r0 *1 230.28,170.8
X$3822 9077 219 320 CLKBUF_X1
* cell instance $3827 r0 *1 231.04,170.8
X$3827 219 9340 8212 320 BUF_X32
* cell instance $3830 m0 *1 35.15,98
X$3830 1282 219 320 4904 CLKBUF_X3
* cell instance $3831 m0 *1 33.82,98
X$3831 4601 4278 4480 219 320 4478 MUX2_X1
* cell instance $3834 m0 *1 37.81,98
X$3834 4475 3993 4481 219 320 4544 MUX2_X1
* cell instance $3836 m0 *1 40.66,98
X$3836 219 13141 4482 4545 3946 320 DFF_X1
* cell instance $3839 r0 *1 34.01,98
X$3839 219 14415 4480 4478 4479 320 DFF_X1
* cell instance $3840 r0 *1 37.24,98
X$3840 219 14613 4481 4544 4479 320 DFF_X1
* cell instance $3841 r0 *1 40.47,98
X$3841 4480 2888 4481 219 320 4655 MUX2_X1
* cell instance $3844 r0 *1 42.37,98
X$3844 4475 3910 4482 219 320 4545 MUX2_X1
* cell instance $3845 r0 *1 43.7,98
X$3845 4483 3848 4482 219 320 4657 MUX2_X1
* cell instance $3847 m0 *1 44.27,98
X$3847 219 12780 4483 4546 4281 320 DFF_X1
* cell instance $3852 r0 *1 45.6,98
X$3852 4483 4006 4475 219 320 4546 MUX2_X1
* cell instance $3856 r0 *1 51.11,98
X$3856 3679 219 320 4281 CLKBUF_X3
* cell instance $3857 m0 *1 53.01,98
X$3857 4475 4282 4484 219 320 4549 MUX2_X1
* cell instance $3858 m0 *1 51.68,98
X$3858 4475 4364 4547 219 320 4365 MUX2_X1
* cell instance $3860 r0 *1 52.06,98
X$3860 4281 219 320 CLKBUF_X1
* cell instance $3862 r0 *1 52.82,98
X$3862 219 13663 4484 4549 4281 320 DFF_X1
* cell instance $3863 m0 *1 54.91,98
X$3863 4547 3950 4484 219 320 4609 MUX2_X1
* cell instance $3866 m0 *1 57,98
X$3866 3952 1480 4439 219 320 4435 MUX2_X1
* cell instance $3868 m0 *1 58.52,98
X$3868 4335 4058 4439 219 320 4366 MUX2_X1
* cell instance $3869 m0 *1 59.85,98
X$3869 219 13498 4284 4440 4436 320 DFF_X1
* cell instance $3870 m0 *1 63.08,98
X$3870 4359 320 4255 219 BUF_X4
* cell instance $3872 m0 *1 67.45,98
X$3872 4006 320 3592 219 BUF_X4
* cell instance $3874 m0 *1 68.97,98
X$3874 3993 320 4161 219 BUF_X4
* cell instance $3881 m0 *1 87.97,98
X$3881 4274 219 320 4488 CLKBUF_X2
* cell instance $3886 m0 *1 94.24,98
X$3886 4160 4490 4368 219 320 4560 MUX2_X1
* cell instance $3887 m0 *1 95.57,98
X$3887 219 13003 4368 4560 4489 320 DFF_X1
* cell instance $3888 m0 *1 98.8,98
X$3888 4368 1576 4491 219 320 4562 MUX2_X1
* cell instance $3899 r0 *1 65.36,98
X$3899 4277 320 4490 219 BUF_X4
* cell instance $3902 r0 *1 67.26,98
X$3902 4278 320 4485 219 BUF_X4
* cell instance $3903 r0 *1 68.59,98
X$3903 4237 320 4492 219 BUF_X4
* cell instance $3905 r0 *1 70.3,98
X$3905 4361 320 3735 219 BUF_X4
* cell instance $3908 r0 *1 72.2,98
X$3908 219 13883 4486 4554 4612 320 DFF_X1
* cell instance $3909 r0 *1 75.43,98
X$3909 4611 3860 4486 219 320 4554 MUX2_X1
* cell instance $3912 r0 *1 77.71,98
X$3912 3723 219 320 4612 CLKBUF_X3
* cell instance $3916 r0 *1 85.31,98
X$3916 219 14385 4709 4487 4121 320 DFF_X1
* cell instance $3920 r0 *1 89.87,98
X$3920 219 14522 4615 4675 4489 320 DFF_X1
* cell instance $3924 r0 *1 95.76,98
X$3924 4160 4559 4491 219 320 4678 MUX2_X1
* cell instance $3928 r0 *1 99.56,98
X$3928 219 13836 4493 4561 4453 320 DFF_X1
* cell instance $3930 m0 *1 100.51,98
X$3930 3684 4492 4370 219 320 4369 MUX2_X1
* cell instance $3931 m0 *1 102.03,98
X$3931 4370 1576 4493 219 320 4564 MUX2_X1
* cell instance $3932 m0 *1 103.36,98
X$3932 4564 2792 219 320 4563 NOR2_X1
* cell instance $3933 m0 *1 103.93,98
X$3933 3856 219 320 4453 CLKBUF_X3
* cell instance $3935 m0 *1 105.07,98
X$3935 4348 2672 219 320 4496 NOR2_X1
* cell instance $3936 m0 *1 105.64,98
X$3936 4453 219 320 14738 INV_X1
* cell instance $3937 m0 *1 106.02,98
X$3937 3684 4497 4568 219 320 4498 MUX2_X1
* cell instance $3942 r0 *1 103.36,98
X$3942 4562 2665 219 320 4494 NOR2_X1
* cell instance $3943 r0 *1 103.93,98
X$3943 4494 4563 4618 4566 4495 4496 219 320 4371 OAI33_X1
* cell instance $3944 r0 *1 105.26,98
X$3944 4682 2792 219 320 4495 NOR2_X1
* cell instance $3946 r0 *1 106.21,98
X$3946 219 14293 4568 4498 4453 320 DFF_X1
* cell instance $3947 m0 *1 109.44,98
X$3947 219 13621 4500 4499 4372 320 DFF_X1
* cell instance $3950 m0 *1 112.86,98
X$3950 4131 4490 4373 219 320 4572 MUX2_X1
* cell instance $3951 m0 *1 114.19,98
X$3951 219 12620 4373 4572 4372 320 DFF_X1
* cell instance $3953 m0 *1 117.61,98
X$3953 4373 3595 4292 219 320 4501 MUX2_X1
* cell instance $3954 m0 *1 118.94,98
X$3954 219 13310 4503 4575 4620 320 DFF_X1
* cell instance $3955 m0 *1 122.17,98
X$3955 4375 4076 4374 219 320 4578 MUX2_X1
* cell instance $3956 m0 *1 123.5,98
X$3956 4131 4559 4375 219 320 4580 MUX2_X1
* cell instance $3958 m0 *1 125.02,98
X$3958 219 13101 4375 4580 4376 320 DFF_X1
* cell instance $3960 m0 *1 129.77,98
X$3960 440 4294 4507 219 320 4581 MUX2_X1
* cell instance $3961 m0 *1 131.1,98
X$3961 219 13130 4507 4581 4506 320 DFF_X1
* cell instance $3962 m0 *1 134.33,98
X$3962 440 4377 4378 219 320 4583 MUX2_X1
* cell instance $3963 m0 *1 135.66,98
X$3963 440 4505 4380 219 320 4460 MUX2_X1
* cell instance $3965 r0 *1 109.44,98
X$3965 4488 4485 4500 219 320 4499 MUX2_X1
* cell instance $3966 r0 *1 110.77,98
X$3966 4500 3491 4569 219 320 4571 MUX2_X1
* cell instance $3967 r0 *1 112.1,98
X$3967 3859 4497 4569 219 320 4684 MUX2_X1
* cell instance $3970 r0 *1 115.71,98
X$3970 4131 4485 4502 219 320 4619 MUX2_X1
* cell instance $3973 r0 *1 118.18,98
X$3973 3456 4492 4503 219 320 4575 MUX2_X1
* cell instance $3980 r0 *1 119.51,98
X$3980 4503 3595 4502 219 320 4621 MUX2_X1
* cell instance $3984 r0 *1 122.17,98
X$3984 4577 4076 4504 219 320 4686 MUX2_X1
* cell instance $3986 r0 *1 123.69,98
X$3986 3456 4497 4504 219 320 4579 MUX2_X1
* cell instance $3989 r0 *1 125.59,98
X$3989 219 14399 4504 4579 4376 320 DFF_X1
* cell instance $3993 r0 *1 132.43,98
X$3993 219 14570 4378 4583 4506 320 DFF_X1
* cell instance $3994 r0 *1 135.66,98
X$3994 4507 4584 4380 219 320 4508 MUX2_X1
* cell instance $3996 r0 *1 137.18,98
X$3996 4382 4508 219 320 4509 OR2_X1
* cell instance $3997 m0 *1 137.56,98
X$3997 4509 4383 4462 320 219 4391 OAI21_X4
* cell instance $4006 r0 *1 140.03,98
X$4006 219 13736 4626 4624 4506 320 DFF_X1
* cell instance $4009 r0 *1 143.83,98
X$4009 219 3746 320 4383 BUF_X8
* cell instance $4014 m0 *1 155.61,98
X$4014 4390 4268 219 320 4587 NOR2_X1
* cell instance $4015 r0 *1 155.8,98
X$4015 4587 4510 4588 219 320 4299 NOR3_X1
* cell instance $4016 r0 *1 156.56,98
X$4016 4390 4358 219 320 4590 NOR2_X1
* cell instance $4017 m0 *1 156.75,98
X$4017 4590 4589 4591 219 320 4469 NOR3_X1
* cell instance $4021 r0 *1 157.51,98
X$4021 4179 2125 3784 4512 320 219 4510 OAI22_X1
* cell instance $4022 m0 *1 158.84,98
X$4022 4511 2870 4387 4388 320 219 4385 OAI22_X1
* cell instance $4023 m0 *1 157.89,98
X$4023 4511 2296 4387 4518 320 219 4591 OAI22_X1
* cell instance $4024 m0 *1 159.79,98
X$4024 4182 2125 3785 4512 320 219 4589 OAI22_X1
* cell instance $4027 r0 *1 158.84,98
X$4027 4390 4081 219 320 4513 NOR2_X1
* cell instance $4028 r0 *1 159.41,98
X$4028 4513 4595 4514 219 320 4039 NOR3_X1
* cell instance $4030 r0 *1 160.36,98
X$4030 4389 2296 4400 4518 320 219 4514 OAI22_X1
* cell instance $4031 m0 *1 161.31,98
X$4031 4472 2870 3391 4388 320 219 4515 OAI22_X1
* cell instance $4034 m0 *1 162.45,98
X$4034 4522 1727 3233 4273 320 219 4516 OAI22_X1
* cell instance $4035 m0 *1 163.4,98
X$4035 4390 4355 219 320 4519 NOR2_X1
* cell instance $4037 r0 *1 161.31,98
X$4037 4593 4515 4516 219 320 4517 NOR3_X1
* cell instance $4039 r0 *1 162.26,98
X$4039 4308 2125 3925 4512 320 219 4595 OAI22_X1
* cell instance $4040 r0 *1 163.21,98
X$4040 3660 2296 4396 4518 320 219 4597 OAI22_X1
* cell instance $4041 r0 *1 164.16,98
X$4041 4519 4520 4597 219 320 4046 NOR3_X1
* cell instance $4043 m0 *1 164.35,98
X$4043 4087 2125 3516 4512 320 219 4520 OAI22_X1
* cell instance $4045 m0 *1 171.57,98
X$4045 4472 1453 4521 4391 320 219 4594 OAI22_X1
* cell instance $4046 m0 *1 172.52,98
X$4046 4470 1453 4391 4459 320 219 4395 OAI22_X2
* cell instance $4047 m0 *1 174.23,98
X$4047 4523 4592 4391 4396 320 219 4461 OAI22_X2
* cell instance $4048 m0 *1 175.94,98
X$4048 4586 4592 4400 4391 320 219 4397 OAI22_X1
* cell instance $4051 r0 *1 167.96,98
X$4051 4522 1228 3233 4128 320 219 4632 OAI22_X1
* cell instance $4052 r0 *1 168.91,98
X$4052 4517 4687 219 320 3292 NOR2_X2
* cell instance $4055 r0 *1 173.09,98
X$4055 4596 883 4592 4241 320 219 4394 OAI22_X2
* cell instance $4063 m0 *1 177.46,98
X$4063 4523 4398 4396 4399 320 219 4457 OAI22_X1
* cell instance $4065 m0 *1 178.41,98
X$4065 3730 4398 4521 4399 320 219 4251 OAI22_X1
* cell instance $4066 m0 *1 179.36,98
X$4066 3925 4398 4399 4400 320 219 4401 OAI22_X2
* cell instance $4069 m0 *1 182.02,98
X$4069 4402 4306 219 320 4403 NOR2_X1
* cell instance $4070 m0 *1 182.59,98
X$4070 4403 4637 4404 219 320 4405 NOR3_X1
* cell instance $4075 m0 *1 186.77,98
X$4075 4779 3966 219 320 421 NOR2_X2
* cell instance $4080 r0 *1 188.29,98
X$4080 3720 3703 219 320 4582 NOR2_X1
* cell instance $4081 r0 *1 188.86,98
X$4081 3782 4248 3784 4406 320 219 4585 OAI22_X1
* cell instance $4082 m0 *1 189.81,98
X$4082 3781 4248 3785 4406 320 219 4576 OAI22_X1
* cell instance $4084 m0 *1 190.76,98
X$4084 3868 550 3869 1198 320 219 4524 OAI22_X1
* cell instance $4087 m0 *1 193.42,98
X$4087 219 12616 4408 4449 4834 320 DFF_X1
* cell instance $4088 m0 *1 196.65,98
X$4088 4408 2589 4447 219 320 4525 MUX2_X1
* cell instance $4090 m0 *1 198.17,98
X$4090 219 12960 4409 4410 3874 320 DFF_X1
* cell instance $4091 m0 *1 201.4,98
X$4091 219 13640 4412 4411 3874 320 DFF_X1
* cell instance $4093 m0 *1 204.82,98
X$4093 3798 2256 4413 219 320 4444 MUX2_X1
* cell instance $4095 m0 *1 206.34,98
X$4095 2259 4558 219 320 4414 OR2_X2
* cell instance $4097 r0 *1 189.81,98
X$4097 3720 3816 219 320 4665 NOR2_X1
* cell instance $4098 r0 *1 190.38,98
X$4098 4582 4585 4524 219 320 4570 NOR3_X1
* cell instance $4099 r0 *1 191.14,98
X$4099 3720 3705 219 320 4661 NOR2_X1
* cell instance $4100 r0 *1 191.71,98
X$4100 3871 550 3979 1198 320 219 4574 OAI22_X1
* cell instance $4101 r0 *1 192.66,98
X$4101 4661 4576 4574 219 320 4573 NOR3_X1
* cell instance $4103 r0 *1 193.8,98
X$4103 4573 3702 219 320 4550 NOR2_X1
* cell instance $4105 r0 *1 195.89,98
X$4105 4570 3792 219 320 4654 NOR2_X1
* cell instance $4106 r0 *1 196.46,98
X$4106 4565 2933 4525 320 219 4567 OAI21_X4
* cell instance $4107 r0 *1 198.93,98
X$4107 2259 4446 219 320 4565 OR2_X1
* cell instance $4109 r0 *1 201.21,98
X$4109 2362 219 320 3874 CLKBUF_X3
* cell instance $4110 r0 *1 202.16,98
X$4110 3874 219 320 CLKBUF_X1
* cell instance $4112 r0 *1 203.11,98
X$4112 3798 2165 4412 219 320 4411 MUX2_X1
* cell instance $4113 r0 *1 204.44,98
X$4113 219 13707 4314 4333 4557 320 DFF_X1
* cell instance $4114 m0 *1 207.86,98
X$4114 3798 2490 4556 219 320 4526 MUX2_X1
* cell instance $4118 m0 *1 210.9,98
X$4118 219 13569 4527 4437 4415 320 DFF_X1
* cell instance $4119 m0 *1 214.13,98
X$4119 4527 2589 4416 219 320 4438 MUX2_X1
* cell instance $4120 m0 *1 215.46,98
X$4120 3986 2368 4527 219 320 4437 MUX2_X1
* cell instance $4122 m0 *1 218.31,98
X$4122 4316 2368 4417 219 320 4434 MUX2_X1
* cell instance $4125 r0 *1 207.67,98
X$4125 219 14128 4556 4526 4557 320 DFF_X1
* cell instance $4127 r0 *1 211.66,98
X$4127 3986 2261 4555 219 320 4768 MUX2_X1
* cell instance $4128 r0 *1 212.99,98
X$4128 4555 2589 4528 219 320 4658 MUX2_X1
* cell instance $4129 r0 *1 214.32,98
X$4129 3986 2169 4528 219 320 4659 MUX2_X1
* cell instance $4133 r0 *1 218.12,98
X$4133 4316 2169 4743 219 320 4766 MUX2_X1
* cell instance $4134 r0 *1 219.45,98
X$4134 4316 2261 4529 219 320 4656 MUX2_X1
* cell instance $4136 m0 *1 220.97,98
X$4136 2362 219 320 4226 CLKBUF_X3
* cell instance $4138 m0 *1 221.92,98
X$4138 4226 219 320 14743 INV_X1
* cell instance $4141 m0 *1 223.25,98
X$4141 4320 3293 4418 219 320 4433 MUX2_X1
* cell instance $4142 m0 *1 224.58,98
X$4142 4320 3070 4419 219 320 4432 MUX2_X1
* cell instance $4143 m0 *1 225.91,98
X$4143 4418 4530 4419 219 320 4420 MUX2_X1
* cell instance $4145 m0 *1 227.43,98
X$4145 4322 4430 219 320 4431 OR2_X1
* cell instance $4150 r0 *1 225.53,98
X$4150 4553 4532 4859 320 219 3515 OAI21_X4
* cell instance $4151 r0 *1 228,98
X$4151 4322 4552 219 320 4553 OR2_X1
* cell instance $4153 m0 *1 229.52,98
X$4153 219 13119 4421 4551 4323 320 DFF_X1
* cell instance $4155 m0 *1 232.75,98
X$4155 4203 3293 4421 219 320 4551 MUX2_X1
* cell instance $4156 m0 *1 234.08,98
X$4156 4548 4532 4423 320 219 3557 OAI21_X4
* cell instance $4157 m0 *1 236.55,98
X$4157 4203 2831 4425 219 320 4424 MUX2_X1
* cell instance $4158 m0 *1 237.88,98
X$4158 4425 4531 4205 219 320 4326 MUX2_X1
* cell instance $4159 m0 *1 239.21,98
X$4159 4321 219 320 4540 BUF_X1
* cell instance $4170 r0 *1 233.89,98
X$4170 4550 219 320 4647 BUF_X1
* cell instance $4172 r0 *1 234.65,98
X$4172 4654 219 320 4646 BUF_X1
* cell instance $4173 r0 *1 235.22,98
X$4173 4536 219 320 4639 BUF_X1
* cell instance $4174 r0 *1 235.79,98
X$4174 1869 219 320 4323 CLKBUF_X3
* cell instance $4176 r0 *1 236.93,98
X$4176 4533 2831 4534 219 320 4643 MUX2_X1
* cell instance $4177 r0 *1 238.26,98
X$4177 4533 3081 4535 219 320 4644 MUX2_X1
* cell instance $4178 r0 *1 239.59,98
X$4178 4427 219 320 4645 BUF_X1
* cell instance $4180 m0 *1 240.16,98
X$4180 4537 219 320 4203 BUF_X1
* cell instance $4185 m0 *1 18.24,176.4
X$4185 9696 9527 9637 219 320 9591 MUX2_X1
* cell instance $4186 m0 *1 21.09,176.4
X$4186 9396 7081 9638 219 320 9697 MUX2_X1
* cell instance $4187 m0 *1 22.42,176.4
X$4187 219 12925 9638 9697 9401 320 DFF_X1
* cell instance $4191 m0 *1 28.12,176.4
X$4191 9396 7082 9594 219 320 9528 MUX2_X1
* cell instance $4192 m0 *1 29.45,176.4
X$4192 9402 8913 9594 219 320 9639 MUX2_X1
* cell instance $4194 m0 *1 30.97,176.4
X$4194 9639 8920 9698 219 320 9466 MUX2_X1
* cell instance $4199 m0 *1 37.81,176.4
X$4199 219 12776 9642 9530 9202 320 DFF_X1
* cell instance $4202 m0 *1 43.32,176.4
X$4202 9533 6909 9531 219 320 9702 MUX2_X1
* cell instance $4203 m0 *1 44.65,176.4
X$4203 219 12695 9533 9702 9202 320 DFF_X1
* cell instance $4204 m0 *1 47.88,176.4
X$4204 9533 8799 9532 219 320 9703 MUX2_X1
* cell instance $4205 m0 *1 49.21,176.4
X$4205 9531 6974 9603 219 320 9600 MUX2_X1
* cell instance $4206 m0 *1 50.54,176.4
X$4206 9703 8792 9406 219 320 9643 MUX2_X1
* cell instance $4207 m0 *1 51.87,176.4
X$4207 9643 4992 9813 219 320 9704 MUX2_X1
* cell instance $4208 m0 *1 53.2,176.4
X$4208 10034 9704 1643 320 219 8293 MUX2_X2
* cell instance $4211 m0 *1 55.86,176.4
X$4211 219 12755 9534 9604 9205 320 DFF_X1
* cell instance $4212 m0 *1 59.09,176.4
X$4212 9534 8788 9644 219 320 9535 MUX2_X1
* cell instance $4214 m0 *1 60.61,176.4
X$4214 219 12816 9644 9706 9865 320 DFF_X1
* cell instance $4219 m0 *1 6.27,176.4
X$4219 219 13008 9525 9692 8847 320 DFF_X1
* cell instance $4227 r0 *1 8.55,176.4
X$4227 9393 7232 9693 219 320 9694 MUX2_X1
* cell instance $4228 m0 *1 10.07,176.4
X$4228 9525 6902 9396 219 320 9692 MUX2_X1
* cell instance $4231 m0 *1 11.59,176.4
X$4231 9525 9287 9693 219 320 9696 MUX2_X1
* cell instance $4233 m0 *1 13.11,176.4
X$4233 9393 7348 9589 219 320 9695 MUX2_X1
* cell instance $4235 m0 *1 14.63,176.4
X$4235 219 12903 9589 9695 9135 320 DFF_X1
* cell instance $4237 r0 *1 9.88,176.4
X$4237 219 14486 9693 9694 9135 320 DFF_X1
* cell instance $4241 r0 *1 14.44,176.4
X$4241 219 14498 9636 9807 9135 320 DFF_X1
* cell instance $4242 r0 *1 17.67,176.4
X$4242 9636 8795 9589 219 320 9637 MUX2_X1
* cell instance $4249 r0 *1 36.86,176.4
X$4249 9640 7016 9642 219 320 9530 MUX2_X1
* cell instance $4250 r0 *1 38.19,176.4
X$4250 9640 6974 9641 219 320 9701 MUX2_X1
* cell instance $4253 r0 *1 40.09,176.4
X$4253 219 13757 9641 9701 9202 320 DFF_X1
* cell instance $4254 r0 *1 43.32,176.4
X$4254 5810 320 8908 219 BUF_X4
* cell instance $4257 r0 *1 45.6,176.4
X$4257 5810 320 8145 219 BUF_X4
* cell instance $4259 r0 *1 47.69,176.4
X$4259 5810 320 8795 219 BUF_X4
* cell instance $4262 r0 *1 50.16,176.4
X$4262 9635 219 320 9408 BUF_X1
* cell instance $4267 r0 *1 60.8,176.4
X$4267 9408 7129 9644 219 320 9706 MUX2_X1
* cell instance $4273 m0 *1 64.41,176.4
X$4273 9408 7136 9606 219 320 9708 MUX2_X1
* cell instance $4275 m0 *1 65.74,176.4
X$4275 219 12968 9606 9708 8804 320 DFF_X1
* cell instance $4280 r0 *1 64.41,176.4
X$4280 9764 6662 9537 219 320 9645 MUX2_X1
* cell instance $4283 r0 *1 69.54,176.4
X$4283 9537 6710 9765 219 320 9646 MUX2_X1
* cell instance $4287 r0 *1 72.96,176.4
X$4287 9413 219 320 CLKBUF_X1
* cell instance $4288 r0 *1 73.53,176.4
X$4288 8926 219 320 9413 CLKBUF_X3
* cell instance $4290 r0 *1 74.67,176.4
X$4290 219 13964 9817 9766 9413 320 DFF_X1
* cell instance $4291 m0 *1 77.9,176.4
X$4291 9648 7312 9537 219 320 9647 MUX2_X1
* cell instance $4296 m0 *1 87.59,176.4
X$4296 9297 7129 9650 219 320 9649 MUX2_X1
* cell instance $4298 r0 *1 77.9,176.4
X$4298 219 14092 9648 9647 9413 320 DFF_X1
* cell instance $4301 r0 *1 87.4,176.4
X$4301 219 14281 9650 9649 9295 320 DFF_X1
* cell instance $4302 m0 *1 89.49,176.4
X$4302 9650 6172 9538 219 320 9299 MUX2_X1
* cell instance $4306 m0 *1 91.77,176.4
X$4306 9415 7026 9538 219 320 9715 MUX2_X1
* cell instance $4309 m0 *1 95.38,176.4
X$4309 9297 7089 9652 219 320 9651 MUX2_X1
* cell instance $4313 r0 *1 91.2,176.4
X$4313 219 14189 9538 9715 8809 320 DFF_X1
* cell instance $4314 r0 *1 94.43,176.4
X$4314 9297 219 320 9415 BUF_X2
* cell instance $4316 r0 *1 95.38,176.4
X$4316 219 14437 9652 9651 9242 320 DFF_X1
* cell instance $4318 m0 *1 97.09,176.4
X$4318 9415 6710 9539 219 320 9771 MUX2_X1
* cell instance $4320 m0 *1 99.37,176.4
X$4320 9652 6172 9539 219 320 9610 MUX2_X1
* cell instance $4322 m0 *1 100.89,176.4
X$4322 9918 6172 9653 219 320 9540 MUX2_X1
* cell instance $4326 m0 *1 106.21,176.4
X$4326 3654 219 320 9797 CLKBUF_X3
* cell instance $4329 m0 *1 108.87,176.4
X$4329 219 13307 9654 9719 9421 320 DFF_X1
* cell instance $4333 r0 *1 99.75,176.4
X$4333 219 14461 9653 9717 9242 320 DFF_X1
* cell instance $4334 r0 *1 102.98,176.4
X$4334 9653 6662 9415 219 320 9717 MUX2_X1
* cell instance $4337 r0 *1 111.91,176.4
X$4337 9494 8121 9654 219 320 9719 MUX2_X1
* cell instance $4339 m0 *1 112.48,176.4
X$4339 9494 8166 9541 219 320 9495 MUX2_X1
* cell instance $4342 m0 *1 114.19,176.4
X$4342 9654 8458 9541 219 320 9616 MUX2_X1
* cell instance $4343 m0 *1 116.28,176.4
X$4343 219 13309 9499 9498 9421 320 DFF_X1
* cell instance $4346 r0 *1 117.04,176.4
X$4346 9422 8242 9655 219 320 9720 MUX2_X1
* cell instance $4347 r0 *1 118.37,176.4
X$4347 219 14609 9655 9720 9421 320 DFF_X1
* cell instance $4352 m0 *1 119.89,176.4
X$4352 219 13425 9423 9721 8819 320 DFF_X1
* cell instance $4353 m0 *1 123.31,176.4
X$4353 219 13587 9656 9723 9045 320 DFF_X1
* cell instance $4355 r0 *1 121.6,176.4
X$4355 9422 8278 9542 219 320 9617 MUX2_X1
* cell instance $4361 r0 *1 125.59,176.4
X$4361 9505 9154 9656 219 320 9723 MUX2_X1
* cell instance $4364 m0 *1 126.92,176.4
X$4364 9656 8458 9657 219 320 9621 MUX2_X1
* cell instance $4366 r0 *1 127.49,176.4
X$4366 9505 9157 9657 219 320 9724 MUX2_X1
* cell instance $4368 m0 *1 128.63,176.4
X$4368 219 13543 9657 9724 9045 320 DFF_X1
* cell instance $4369 r0 *1 128.82,176.4
X$4369 219 14268 9659 9658 9045 320 DFF_X1
* cell instance $4370 r0 *1 132.05,176.4
X$4370 219 14286 9661 9660 9046 320 DFF_X1
* cell instance $4371 m0 *1 132.43,176.4
X$4371 9543 8821 9661 219 320 9660 MUX2_X1
* cell instance $4373 m0 *1 133.76,176.4
X$4373 219 13563 9545 9544 9046 320 DFF_X1
* cell instance $4374 m0 *1 136.99,176.4
X$4374 219 9727 9046 12497 6956 320 DFF_X2
* cell instance $4379 m0 *1 146.11,176.4
X$4379 9547 9548 219 9551 320 NAND2_X4
* cell instance $4380 m0 *1 147.82,176.4
X$4380 9548 9547 320 219 9522 AND2_X2
* cell instance $4383 r0 *1 135.28,176.4
X$4383 5131 9726 320 219 9727 AND2_X1
* cell instance $4384 r0 *1 136.04,176.4
X$4384 9661 7723 9545 219 320 9662 MUX2_X1
* cell instance $4388 r0 *1 138.7,176.4
X$4388 5131 9728 320 219 9730 AND2_X1
* cell instance $4390 r0 *1 139.84,176.4
X$4390 7329 219 320 9729 INV_X1
* cell instance $4391 r0 *1 140.22,176.4
X$4391 7274 9729 9731 320 219 9829 HA_X1
* cell instance $4393 r0 *1 142.5,176.4
X$4393 7676 219 320 9830 INV_X1
* cell instance $4394 r0 *1 142.88,176.4
X$4394 9731 9831 9872 9733 219 9734 320 NAND4_X2
* cell instance $4395 r0 *1 144.59,176.4
X$4395 9733 219 320 9664 INV_X1
* cell instance $4400 r0 *1 149.34,176.4
X$4400 9665 9429 7901 219 320 9874 MUX2_X1
* cell instance $4401 r0 *1 150.67,176.4
X$4401 219 9427 9329 9668 9777 9737 320 NOR4_X4
* cell instance $4402 m0 *1 152.38,176.4
X$4402 9428 9666 9552 219 320 9667 NAND3_X1
* cell instance $4407 m0 *1 157.89,176.4
X$4407 9388 9551 219 320 9177 NOR2_X2
* cell instance $4410 r0 *1 154.09,176.4
X$4410 9929 9429 219 320 9552 NOR2_X2
* cell instance $4411 r0 *1 155.04,176.4
X$4411 9627 9737 9552 320 9838 219 OAI21_X1
* cell instance $4414 r0 *1 156.94,176.4
X$4414 219 13649 9669 9740 8758 320 DFF_X1
* cell instance $4415 m0 *1 160.55,176.4
X$4415 9556 219 320 9841 INV_X1
* cell instance $4416 m0 *1 159.98,176.4
X$4416 9553 9556 219 320 9554 NAND2_X1
* cell instance $4417 m0 *1 160.93,176.4
X$4417 9742 9051 532 219 9741 320 AOI21_X1
* cell instance $4419 m0 *1 161.88,176.4
X$4419 9670 9051 219 320 9743 NOR2_X1
* cell instance $4421 m0 *1 163.21,176.4
X$4421 9557 9746 9386 219 320 9747 NOR3_X1
* cell instance $4422 m0 *1 163.97,176.4
X$4422 9559 219 320 9746 INV_X1
* cell instance $4423 m0 *1 164.35,176.4
X$4423 528 7838 219 320 9671 NOR2_X1
* cell instance $4426 r0 *1 160.17,176.4
X$4426 9555 9669 9554 219 320 9785 OR3_X1
* cell instance $4427 r0 *1 161.12,176.4
X$4427 9556 9779 9555 219 320 9782 OR3_X1
* cell instance $4428 r0 *1 162.07,176.4
X$4428 9743 9671 9745 219 320 9740 NOR3_X1
* cell instance $4429 r0 *1 162.83,176.4
X$4429 9842 9051 219 320 9557 NOR2_X1
* cell instance $4431 r0 *1 163.59,176.4
X$4431 219 13669 9784 9747 8758 320 DFF_X1
* cell instance $4433 m0 *1 166.06,176.4
X$4433 9607 9558 9559 320 9749 219 NOR3_X2
* cell instance $4434 m0 *1 167.58,176.4
X$4434 9382 556 219 320 9559 OR2_X1
* cell instance $4437 r0 *1 166.82,176.4
X$4437 9558 9559 219 320 9843 NOR2_X1
* cell instance $4439 m0 *1 170.05,176.4
X$4439 9437 9560 219 320 9632 NOR2_X1
* cell instance $4440 m0 *1 169.48,176.4
X$4440 9178 219 320 9631 BUF_X1
* cell instance $4441 m0 *1 170.62,176.4
X$4441 9751 5488 219 320 9752 NOR2_X2
* cell instance $4442 m0 *1 171.57,176.4
X$4442 9628 7044 9060 219 9751 320 AOI21_X1
* cell instance $4446 r0 *1 171.38,176.4
X$4446 9753 320 6186 219 BUF_X4
* cell instance $4448 m0 *1 172.71,176.4
X$4448 9753 219 320 8123 INV_X4
* cell instance $4450 m0 *1 174.61,176.4
X$4450 3866 320 9058 219 BUF_X4
* cell instance $4451 m0 *1 175.94,176.4
X$4451 8381 320 6949 219 BUF_X4
* cell instance $4454 m0 *1 178.22,176.4
X$4454 7735 320 6187 219 BUF_X4
* cell instance $4455 m0 *1 179.55,176.4
X$4455 9323 5537 219 320 9758 NOR2_X2
* cell instance $4456 m0 *1 180.5,176.4
X$4456 4180 4442 9757 1449 3787 320 219 9623 OAI221_X1
* cell instance $4457 m0 *1 181.64,176.4
X$4457 9623 6870 9060 219 9760 320 AOI21_X1
* cell instance $4461 r0 *1 173.09,176.4
X$4461 7329 5793 219 320 9754 NAND2_X1
* cell instance $4464 r0 *1 174.23,176.4
X$4464 9058 9754 8261 219 9847 320 AOI21_X2
* cell instance $4468 r0 *1 175.56,176.4
X$4468 7147 5793 219 320 9848 NAND2_X1
* cell instance $4470 r0 *1 176.89,176.4
X$4470 9672 219 320 6539 CLKBUF_X3
* cell instance $4471 r0 *1 177.84,176.4
X$4471 7735 320 4083 219 BUF_X4
* cell instance $4473 r0 *1 179.55,176.4
X$4473 9497 7044 8119 219 10262 320 AOI21_X1
* cell instance $4476 r0 *1 181.26,176.4
X$4476 9060 5793 219 320 9850 NAND2_X1
* cell instance $4478 r0 *1 182.02,176.4
X$4478 7462 320 4883 219 BUF_X4
* cell instance $4480 r0 *1 183.54,176.4
X$4480 7735 9066 9668 4883 320 219 9673 OAI22_X2
* cell instance $4481 m0 *1 184.87,176.4
X$4481 7676 5793 219 320 9619 NAND2_X1
* cell instance $4482 m0 *1 184.3,176.4
X$4482 9760 5537 219 320 9761 NOR2_X1
* cell instance $4484 r0 *1 185.25,176.4
X$4484 6951 9055 7106 9674 219 320 9970 AOI22_X1
* cell instance $4485 m0 *1 186.01,176.4
X$4485 9058 9619 7673 219 9759 320 AOI21_X2
* cell instance $4489 r0 *1 186.58,176.4
X$4489 7889 5793 219 320 9756 NAND2_X1
* cell instance $4490 r0 *1 187.15,176.4
X$4490 6982 9055 6732 9674 219 320 9788 AOI22_X1
* cell instance $4491 m0 *1 187.91,176.4
X$4491 9546 2814 219 320 9845 NAND2_X1
* cell instance $4495 r0 *1 188.1,176.4
X$4495 9058 9756 7990 219 9755 320 AOI21_X2
* cell instance $4497 m0 *1 189.81,176.4
X$4497 556 219 320 9789 INV_X1
* cell instance $4502 m0 *1 192.66,176.4
X$4502 8119 2813 219 320 9614 NAND2_X1
* cell instance $4503 m0 *1 193.23,176.4
X$4503 2811 9614 9750 219 9735 320 AOI21_X2
* cell instance $4504 m0 *1 194.56,176.4
X$4504 9748 6870 8119 219 9675 320 AOI21_X1
* cell instance $4506 m0 *1 195.51,176.4
X$4506 7845 219 320 9570 INV_X1
* cell instance $4507 m0 *1 195.89,176.4
X$4507 9612 7884 8119 219 9716 320 AOI21_X1
* cell instance $4509 m0 *1 197.41,176.4
X$4509 7737 320 7106 219 BUF_X4
* cell instance $4510 m0 *1 198.74,176.4
X$4510 598 219 320 9739 INV_X1
* cell instance $4511 m0 *1 199.12,176.4
X$4511 9570 320 6950 219 BUF_X4
* cell instance $4513 m0 *1 201.21,176.4
X$4513 9676 320 6732 219 BUF_X4
* cell instance $4515 r0 *1 190.19,176.4
X$4515 219 2811 320 5632 BUF_X8
* cell instance $4517 r0 *1 193.04,176.4
X$4517 6138 2813 219 320 9744 NAND2_X1
* cell instance $4518 r0 *1 193.61,176.4
X$4518 2197 2813 219 320 9792 NAND2_X1
* cell instance $4519 r0 *1 194.18,176.4
X$4519 2811 9744 9837 219 9699 320 AOI21_X2
* cell instance $4520 r0 *1 195.51,176.4
X$4520 5841 219 320 9676 INV_X1
* cell instance $4523 r0 *1 199.69,176.4
X$4523 528 219 320 9738 INV_X1
* cell instance $4524 r0 *1 200.07,176.4
X$4524 9739 6075 9683 4083 9736 8103 219 320 OAI221_X2
* cell instance $4527 m0 *1 202.92,176.4
X$4527 9570 9677 8421 9571 219 320 9605 AOI22_X1
* cell instance $4528 r0 *1 202.92,176.4
X$4528 9570 9732 8421 9680 219 320 9679 AOI22_X1
* cell instance $4530 r0 *1 204.06,176.4
X$4530 6187 9681 9679 9575 6075 320 219 9714 OAI221_X1
* cell instance $4531 m0 *1 205.2,176.4
X$4531 4301 9573 9572 9574 8324 320 219 9442 OAI221_X1
* cell instance $4532 m0 *1 204.25,176.4
X$4532 9676 9677 8380 9571 219 320 9572 AOI22_X1
* cell instance $4533 m0 *1 206.34,176.4
X$4533 6187 9573 9605 9574 6075 320 219 9577 OAI221_X1
* cell instance $4535 m0 *1 207.67,176.4
X$4535 9718 6394 2197 219 9443 320 AOI21_X1
* cell instance $4536 m0 *1 208.43,176.4
X$4536 9577 7884 6138 219 9713 320 AOI21_X1
* cell instance $4539 r0 *1 205.39,176.4
X$4539 4301 9725 9722 9789 8324 320 219 9576 OAI221_X1
* cell instance $4541 r0 *1 206.72,176.4
X$4541 4180 9681 9682 9575 3787 320 219 9718 OAI221_X1
* cell instance $4543 r0 *1 208.24,176.4
X$4543 9714 7884 2197 219 9815 320 AOI21_X1
* cell instance $4544 r0 *1 209,176.4
X$4544 9716 5977 219 320 9712 NOR2_X1
* cell instance $4547 m0 *1 209.57,176.4
X$4547 9713 5977 219 320 9588 NOR2_X1
* cell instance $4548 m0 *1 210.33,176.4
X$4548 9569 5977 219 320 9601 NOR2_X1
* cell instance $4553 r0 *1 210.52,176.4
X$4553 2275 219 320 9683 INV_X2
* cell instance $4555 m0 *1 213.75,176.4
X$4555 1874 219 320 9681 INV_X2
* cell instance $4557 m0 *1 214.32,176.4
X$4557 3519 1874 2967 1970 219 320 10282 NOR4_X1
* cell instance $4558 m0 *1 215.27,176.4
X$4558 3519 219 320 9573 INV_X2
* cell instance $4563 m0 *1 219.45,176.4
X$4563 9579 7751 9582 219 320 9711 MUX2_X1
* cell instance $4565 m0 *1 220.78,176.4
X$4565 219 12693 9581 9580 8953 320 DFF_X1
* cell instance $4568 r0 *1 219.83,176.4
X$4568 219 14257 9582 9711 8953 320 DFF_X1
* cell instance $4572 m0 *1 224.58,176.4
X$4572 9448 7751 9593 219 320 9710 MUX2_X1
* cell instance $4574 m0 *1 225.91,176.4
X$4574 219 12753 9593 9710 9077 320 DFF_X1
* cell instance $4576 r0 *1 224.39,176.4
X$4576 9684 9801 9800 219 320 9709 MUX2_X1
* cell instance $4577 r0 *1 225.72,176.4
X$4577 9709 9707 8861 320 219 9227 MUX2_X2
* cell instance $4581 m0 *1 229.52,176.4
X$4581 9448 7750 9583 219 320 9592 MUX2_X1
* cell instance $4583 r0 *1 230.09,176.4
X$4583 9690 219 320 8979 BUF_X1
* cell instance $4584 r0 *1 230.66,176.4
X$4584 219 14024 9685 9810 8844 320 DFF_X1
* cell instance $4589 m0 *1 231.23,176.4
X$4589 219 12880 9687 9705 9077 320 DFF_X1
* cell instance $4590 r0 *1 233.89,176.4
X$4590 9686 7291 9687 219 320 9705 MUX2_X1
* cell instance $4592 m0 *1 234.84,176.4
X$4592 219 12837 9590 9584 8844 320 DFF_X1
* cell instance $4593 r0 *1 235.22,176.4
X$4593 9686 7165 9459 219 320 9700 MUX2_X1
* cell instance $4594 r0 *1 236.55,176.4
X$4594 9439 219 320 9688 BUF_X1
* cell instance $4595 r0 *1 237.12,176.4
X$4595 9699 219 320 9691 BUF_X1
* cell instance $4597 r0 *1 237.88,176.4
X$4597 9587 219 320 8841 BUF_X1
* cell instance $4598 r0 *1 238.45,176.4
X$4598 8976 219 320 9585 BUF_X1
* cell instance $4599 m0 *1 239.02,176.4
X$4599 9588 219 320 9451 BUF_X1
* cell instance $4600 m0 *1 238.45,176.4
X$4600 9367 219 320 9450 BUF_X1
* cell instance $4601 m0 *1 239.59,176.4
X$4601 9342 219 320 9812 BUF_X1
* cell instance $4602 m0 *1 240.16,176.4
X$4602 9343 219 320 8500 BUF_X1
* cell instance $4604 r0 *1 239.02,176.4
X$4604 9689 219 320 5340 CLKBUF_X3
* cell instance $4609 m0 *1 6.84,196
X$4609 219 13602 10953 10995 10857 320 DFF_X1
* cell instance $4610 m0 *1 10.07,196
X$4610 10953 8788 10952 219 320 10997 MUX2_X1
* cell instance $4621 r0 *1 8.17,196
X$4621 10996 7121 10952 219 320 10993 MUX2_X1
* cell instance $4622 r0 *1 9.5,196
X$4622 10996 7171 10953 219 320 10995 MUX2_X1
* cell instance $4625 r0 *1 12.54,196
X$4625 9526 219 320 10857 CLKBUF_X3
* cell instance $4627 m0 *1 12.54,196
X$4627 10996 7123 10858 219 320 10915 MUX2_X1
* cell instance $4628 r0 *1 13.49,196
X$4628 10996 219 320 9640 BUF_X2
* cell instance $4630 m0 *1 14.44,196
X$4630 10996 7177 10954 219 320 10998 MUX2_X1
* cell instance $4632 m0 *1 15.77,196
X$4632 219 12601 10954 10998 10857 320 DFF_X1
* cell instance $4633 m0 *1 19,196
X$4633 10954 9287 10770 219 320 10918 MUX2_X1
* cell instance $4637 m0 *1 27.36,196
X$4637 219 12645 10920 10860 10562 320 DFF_X1
* cell instance $4638 m0 *1 30.59,196
X$4638 9526 219 320 10562 CLKBUF_X3
* cell instance $4642 m0 *1 35.53,196
X$4642 219 12745 10921 10865 11045 320 DFF_X1
* cell instance $4643 m0 *1 38.76,196
X$4643 11094 9287 10921 219 320 10924 MUX2_X1
* cell instance $4649 r0 *1 21.66,196
X$4649 219 13674 11039 11091 11038 320 DFF_X1
* cell instance $4651 r0 *1 25.08,196
X$4651 11039 9763 11128 219 320 11041 MUX2_X1
* cell instance $4652 r0 *1 26.41,196
X$4652 11040 9527 11041 219 320 10862 MUX2_X1
* cell instance $4653 r0 *1 27.74,196
X$4653 219 14650 10955 11184 10562 320 DFF_X1
* cell instance $4657 r0 *1 33.63,196
X$4657 10032 6802 11042 219 320 11043 MUX2_X1
* cell instance $4658 r0 *1 34.96,196
X$4658 11042 9763 11129 219 320 11093 MUX2_X1
* cell instance $4660 r0 *1 36.67,196
X$4660 11044 9527 11093 219 320 10923 MUX2_X1
* cell instance $4661 r0 *1 38,196
X$4661 219 13702 11094 11185 11045 320 DFF_X1
* cell instance $4664 m0 *1 41.99,196
X$4664 9531 6853 11000 219 320 11046 MUX2_X1
* cell instance $4666 r0 *1 42.75,196
X$4666 219 13776 11000 11046 9859 320 DFF_X1
* cell instance $4668 m0 *1 45.22,196
X$4668 11187 9287 11000 219 320 11002 MUX2_X1
* cell instance $4671 m0 *1 53.58,196
X$4671 219 12871 10927 10956 10671 320 DFF_X1
* cell instance $4674 r0 *1 46.36,196
X$4674 9531 6802 11047 219 320 11096 MUX2_X1
* cell instance $4675 r0 *1 47.69,196
X$4675 219 13688 11047 11096 11048 320 DFF_X1
* cell instance $4678 m0 *1 57.38,196
X$4678 219 12794 10957 10870 10671 320 DFF_X1
* cell instance $4685 r0 *1 61.37,196
X$4685 11098 219 320 10185 BUF_X1
* cell instance $4686 m0 *1 64.98,196
X$4686 10185 7356 11007 219 320 10958 MUX2_X1
* cell instance $4687 m0 *1 61.75,196
X$4687 219 13530 10928 11005 10671 320 DFF_X1
* cell instance $4689 m0 *1 67.07,196
X$4689 219 13485 10778 11008 10780 320 DFF_X1
* cell instance $4692 m0 *1 72.01,196
X$4692 8926 219 320 10780 CLKBUF_X3
* cell instance $4693 m0 *1 72.96,196
X$4693 10780 219 320 CLKBUF_X1
* cell instance $4702 m0 *1 106.4,196
X$4702 219 10959 11013 11009 11010 320 DFF_X1
* cell instance $4703 m0 *1 109.63,196
X$4703 11053 10877 10878 320 11012 219 OAI21_X1
* cell instance $4710 r0 *1 65.17,196
X$4710 219 14167 11007 10958 10780 320 DFF_X1
* cell instance $4713 r0 *1 70.3,196
X$4713 11099 219 320 10443 CLKBUF_X2
* cell instance $4718 r0 *1 84.36,196
X$4718 11100 219 320 10529 BUF_X1
* cell instance $4722 r0 *1 97.28,196
X$4722 11103 219 320 7594 BUF_X2
* cell instance $4725 r0 *1 99.75,196
X$4725 11050 7820 219 320 11194 NOR2_X1
* cell instance $4727 r0 *1 100.7,196
X$4727 11050 11103 12534 320 219 11052 HA_X1
* cell instance $4729 r0 *1 103.36,196
X$4729 11052 11051 7825 219 320 NOR2_X4
* cell instance $4731 r0 *1 105.83,196
X$4731 219 11104 11010 11198 11053 320 DFF_X2
* cell instance $4732 r0 *1 109.44,196
X$4732 11012 7820 219 320 11104 NOR2_X1
* cell instance $4733 r0 *1 110.01,196
X$4733 11013 10877 10959 219 320 10960 MUX2_X1
* cell instance $4735 m0 *1 110.77,196
X$4735 10539 10960 320 219 11009 AND2_X1
* cell instance $4737 r0 *1 111.34,196
X$4737 11052 219 320 11016 INV_X2
* cell instance $4738 r0 *1 111.91,196
X$4738 11053 11016 11106 320 219 11107 HA_X1
* cell instance $4739 r0 *1 113.81,196
X$4739 11107 11013 11106 219 11054 320 AOI21_X1
* cell instance $4746 r0 *1 6.84,198.8
X$4746 11302 219 320 10996 BUF_X1
* cell instance $4750 m0 *1 8.55,198.8
X$4750 219 13601 11122 11179 10857 320 DFF_X1
* cell instance $4751 m0 *1 7.22,198.8
X$4751 10996 7232 11122 219 320 11179 MUX2_X1
* cell instance $4752 m0 *1 11.78,198.8
X$4752 11123 6902 9640 219 320 11180 MUX2_X1
* cell instance $4753 m0 *1 13.11,198.8
X$4753 11123 9287 11122 219 320 11181 MUX2_X1
* cell instance $4759 r0 *1 10.64,198.8
X$4759 219 14528 11123 11180 10857 320 DFF_X1
* cell instance $4762 r0 *1 15.01,198.8
X$4762 10996 7348 11126 219 320 11264 MUX2_X1
* cell instance $4763 r0 *1 16.34,198.8
X$4763 219 14647 11125 11124 11038 320 DFF_X1
* cell instance $4765 m0 *1 17.1,198.8
X$4765 9640 6802 11125 219 320 11124 MUX2_X1
* cell instance $4766 m0 *1 19,198.8
X$4766 11125 9763 11126 219 320 11182 MUX2_X1
* cell instance $4768 m0 *1 20.33,198.8
X$4768 11181 9527 11182 219 320 10999 MUX2_X1
* cell instance $4773 r0 *1 22.04,198.8
X$4773 219 14616 11128 11127 11038 320 DFF_X1
* cell instance $4775 m0 *1 22.04,198.8
X$4775 11183 7348 11128 219 320 11127 MUX2_X1
* cell instance $4777 m0 *1 24.32,198.8
X$4777 10433 6802 11039 219 320 11091 MUX2_X1
* cell instance $4780 m0 *1 27.36,198.8
X$4780 11183 7177 10955 219 320 11184 MUX2_X1
* cell instance $4783 m0 *1 32.49,198.8
X$4783 219 12690 11042 11043 11045 320 DFF_X1
* cell instance $4784 m0 *1 35.72,198.8
X$4784 11227 7348 11129 219 320 11186 MUX2_X1
* cell instance $4787 r0 *1 25.27,198.8
X$4787 11183 219 320 10433 BUF_X2
* cell instance $4788 r0 *1 26.03,198.8
X$4788 219 14624 11349 11223 11038 320 DFF_X1
* cell instance $4790 r0 *1 30.02,198.8
X$4790 11225 9207 11226 219 320 10667 MUX2_X1
* cell instance $4793 r0 *1 33.06,198.8
X$4793 219 14400 11129 11186 11045 320 DFF_X1
* cell instance $4794 r0 *1 36.29,198.8
X$4794 11227 219 320 10032 BUF_X2
* cell instance $4796 r0 *1 37.43,198.8
X$4796 11227 7123 11228 219 320 11265 MUX2_X1
* cell instance $4798 m0 *1 38.19,198.8
X$4798 11227 7177 11094 219 320 11185 MUX2_X1
* cell instance $4801 m0 *1 44.27,198.8
X$4801 219 12918 11187 11266 11048 320 DFF_X1
* cell instance $4804 r0 *1 38.95,198.8
X$4804 11350 9101 11228 219 320 11130 MUX2_X1
* cell instance $4806 r0 *1 40.66,198.8
X$4806 11130 9207 11434 219 320 10727 MUX2_X1
* cell instance $4809 r0 *1 45.22,198.8
X$4809 11229 7177 11187 219 320 11266 MUX2_X1
* cell instance $4811 r0 *1 46.74,198.8
X$4811 11229 219 320 9531 BUF_X2
* cell instance $4812 r0 *1 47.5,198.8
X$4812 11229 7348 11267 219 320 11268 MUX2_X1
* cell instance $4813 m0 *1 48.07,198.8
X$4813 11047 9763 11267 219 320 11189 MUX2_X1
* cell instance $4815 m0 *1 49.4,198.8
X$4815 11131 9527 11189 219 320 10867 MUX2_X1
* cell instance $4826 m0 *1 98.04,198.8
X$4826 7594 219 320 11049 INV_X1
* cell instance $4829 m0 *1 99.37,198.8
X$4829 219 13505 11196 11194 10347 320 DFF_X1
* cell instance $4830 m0 *1 102.6,198.8
X$4830 11050 11049 11195 320 219 11051 HA_X1
* cell instance $4835 r0 *1 49.4,198.8
X$4835 11230 7014 9531 219 320 11231 MUX2_X1
* cell instance $4836 r0 *1 50.73,198.8
X$4836 9405 219 320 11048 CLKBUF_X3
* cell instance $4839 r0 *1 52.63,198.8
X$4839 11229 7123 11232 219 320 11269 MUX2_X1
* cell instance $4840 r0 *1 53.96,198.8
X$4840 11230 9101 11232 219 320 11132 MUX2_X1
* cell instance $4842 r0 *1 56.05,198.8
X$4842 11132 9207 11233 219 320 9813 MUX2_X1
* cell instance $4845 r0 *1 57.95,198.8
X$4845 219 14382 11232 11269 10671 320 DFF_X1
* cell instance $4857 r0 *1 98.61,198.8
X$4857 11384 11049 12553 320 219 11272 HA_X1
* cell instance $4858 r0 *1 100.51,198.8
X$4858 11051 11272 7818 219 320 NOR2_X4
* cell instance $4861 m0 *1 105.64,198.8
X$4861 11195 219 320 10877 BUF_X2
* cell instance $4863 m0 *1 106.97,198.8
X$4863 219 11198 11133 10879 11052 10959 320 FA_X1
* cell instance $4864 m0 *1 110.01,198.8
X$4864 11133 11134 320 219 11234 XNOR2_X1
* cell instance $4865 m0 *1 111.15,198.8
X$4865 11135 11016 11134 320 219 11203 HA_X1
* cell instance $4866 m0 *1 113.05,198.8
X$4866 11133 11199 11137 320 11201 219 OAI21_X1
* cell instance $4868 m0 *1 114,198.8
X$4868 11199 11054 11137 320 11273 219 OAI21_X1
* cell instance $4870 m0 *1 114.95,198.8
X$4870 11202 11201 11138 219 10961 320 AOI21_X1
* cell instance $4871 m0 *1 115.71,198.8
X$4871 11055 11016 11138 320 219 11202 HA_X1
* cell instance $4872 m0 *1 117.61,198.8
X$4872 11203 219 320 11137 INV_X1
* cell instance $4879 r0 *1 110.58,198.8
X$4879 11135 10877 11234 219 320 11136 MUX2_X1
* cell instance $4881 r0 *1 112.1,198.8
X$4881 10539 11136 320 219 11314 AND2_X1
* cell instance $4883 r0 *1 113.05,198.8
X$4883 11134 219 320 11199 INV_X1
* cell instance $4884 r0 *1 113.43,198.8
X$4884 11138 11273 219 320 11274 XOR2_X1
* cell instance $4885 r0 *1 114.57,198.8
X$4885 11055 10877 11274 219 320 11236 MUX2_X1
* cell instance $4886 r0 *1 115.9,198.8
X$4886 10539 11236 320 219 11235 AND2_X1
* cell instance $4897 r0 *1 127.87,198.8
X$4897 219 14388 11279 11278 11057 320 DFF_X1
* cell instance $4898 m0 *1 128.44,198.8
X$4898 9425 219 320 11057 CLKBUF_X3
* cell instance $4903 m0 *1 133.38,198.8
X$4903 11114 9154 11060 219 320 11059 MUX2_X1
* cell instance $4907 r0 *1 134.52,198.8
X$4907 9425 219 320 10967 CLKBUF_X3
* cell instance $4909 m0 *1 135.09,198.8
X$4909 219 12926 11211 11209 10967 320 DFF_X1
* cell instance $4912 r0 *1 135.47,198.8
X$4912 11114 9157 11211 219 320 11209 MUX2_X1
* cell instance $4913 r0 *1 136.8,198.8
X$4913 11060 11387 11211 219 320 9957 MUX2_X1
* cell instance $4914 r0 *1 138.13,198.8
X$4914 10967 219 320 CLKBUF_X1
* cell instance $4917 m0 *1 142.12,198.8
X$4917 219 13055 11215 11213 10975 320 DFF_X1
* cell instance $4918 m0 *1 140.98,198.8
X$4918 11140 11283 219 320 11139 XOR2_X1
* cell instance $4919 m0 *1 145.35,198.8
X$4919 11062 11141 320 219 11288 XNOR2_X1
* cell instance $4920 m0 *1 146.49,198.8
X$4920 11215 11142 11144 320 11143 219 OAI21_X1
* cell instance $4921 m0 *1 147.25,198.8
X$4921 11142 11145 219 320 11144 NAND2_X1
* cell instance $4924 m0 *1 148.77,198.8
X$4924 10886 11146 11142 320 219 11117 HA_X1
* cell instance $4925 m0 *1 150.67,198.8
X$4925 11063 11146 12523 320 219 11062 HA_X1
* cell instance $4928 r0 *1 141.36,198.8
X$4928 3264 11289 320 219 11284 AND2_X1
* cell instance $4929 r0 *1 142.12,198.8
X$4929 219 11290 11292 11284 11319 320 DFF_X1
* cell instance $4930 r0 *1 145.35,198.8
X$4930 219 11215 11141 11145 11291 11292 320 FA_X1
* cell instance $4932 m0 *1 153.14,198.8
X$4932 9383 219 320 10975 CLKBUF_X3
* cell instance $4934 m0 *1 154.09,198.8
X$4934 10975 219 320 14744 INV_X1
* cell instance $4936 m0 *1 154.66,198.8
X$4936 11146 219 320 10756 INV_X2
* cell instance $4948 m0 *1 7.41,81.2
X$4948 3123 219 320 3421 CLKBUF_X2
* cell instance $4950 m0 *1 8.17,81.2
X$4950 219 13315 3297 3178 3296 320 DFF_X1
* cell instance $4955 r0 *1 10.64,81.2
X$4955 219 14472 3301 3298 3296 320 DFF_X1
* cell instance $4957 m0 *1 12.54,81.2
X$4957 2881 1599 3301 219 320 3298 MUX2_X1
* cell instance $4960 m0 *1 14.25,81.2
X$4960 3297 320 2439 219 BUF_X4
* cell instance $4962 m0 *1 16.91,81.2
X$4962 2881 1734 3181 219 320 3125 MUX2_X1
* cell instance $4964 m0 *1 18.24,81.2
X$4964 3032 2957 3181 219 320 3127 MUX2_X1
* cell instance $4968 m0 *1 31.92,81.2
X$4968 219 12650 3356 3420 3244 320 DFF_X1
* cell instance $4969 m0 *1 35.15,81.2
X$4969 3245 1307 3357 219 320 3305 MUX2_X1
* cell instance $4971 m0 *1 38,81.2
X$4971 219 12656 3358 3246 3086 320 DFF_X1
* cell instance $4972 m0 *1 41.23,81.2
X$4972 3245 1523 3247 219 320 3428 MUX2_X1
* cell instance $4973 m0 *1 42.56,81.2
X$4973 1515 219 320 3086 CLKBUF_X3
* cell instance $4979 r0 *1 22.04,81.2
X$4979 219 13812 3354 3416 3353 320 DFF_X1
* cell instance $4981 r0 *1 26.03,81.2
X$4981 219 14325 3355 3417 2771 320 DFF_X1
* cell instance $4983 r0 *1 29.64,81.2
X$4983 3355 2772 3476 219 320 3423 MUX2_X1
* cell instance $4986 r0 *1 31.54,81.2
X$4986 3421 1467 3356 219 320 3420 MUX2_X1
* cell instance $4988 r0 *1 33.06,81.2
X$4988 219 13816 3357 3305 3244 320 DFF_X1
* cell instance $4991 r0 *1 36.86,81.2
X$4991 3356 2657 3357 219 320 3426 MUX2_X1
* cell instance $4992 r0 *1 38.19,81.2
X$4992 3358 1469 3245 219 320 3246 MUX2_X1
* cell instance $4995 r0 *1 40.09,81.2
X$4995 3358 2888 3247 219 320 3359 MUX2_X1
* cell instance $4997 r0 *1 41.61,81.2
X$4997 219 14423 3247 3428 3086 320 DFF_X1
* cell instance $4998 m0 *1 45.98,81.2
X$4998 3245 1695 3249 219 320 3312 MUX2_X1
* cell instance $4999 m0 *1 44.65,81.2
X$4999 3245 1609 3248 219 320 3190 MUX2_X1
* cell instance $5000 m0 *1 47.31,81.2
X$5000 3248 2787 3249 219 320 3250 MUX2_X1
* cell instance $5001 m0 *1 48.64,81.2
X$5001 219 13597 3249 3312 3313 320 DFF_X1
* cell instance $5006 m0 *1 53.2,81.2
X$5006 3192 3044 3251 320 219 3193 OAI21_X4
* cell instance $5011 m0 *1 60.99,81.2
X$5011 3129 2148 3316 219 320 3315 MUX2_X1
* cell instance $5012 m0 *1 62.32,81.2
X$5012 3197 2772 3042 219 320 3431 MUX2_X1
* cell instance $5014 m0 *1 64.41,81.2
X$5014 3041 1746 3433 219 320 3432 MUX2_X1
* cell instance $5016 m0 *1 66.5,81.2
X$5016 3041 219 320 3129 CLKBUF_X2
* cell instance $5019 m0 *1 68.21,81.2
X$5019 3041 1571 3131 219 320 3130 MUX2_X1
* cell instance $5022 r0 *1 55.48,81.2
X$5022 219 14275 3482 3360 2975 320 DFF_X1
* cell instance $5024 r0 *1 59.47,81.2
X$5024 219 14254 3316 3315 3361 320 DFF_X1
* cell instance $5025 r0 *1 62.7,81.2
X$5025 3362 2963 3431 219 320 3539 MUX2_X1
* cell instance $5030 r0 *1 64.22,81.2
X$5030 219 13648 3433 3432 2785 320 DFF_X1
* cell instance $5032 r0 *1 68.97,81.2
X$5032 3435 1756 3129 219 320 3436 MUX2_X1
* cell instance $5033 m0 *1 70.11,81.2
X$5033 3435 2731 3131 219 320 3252 MUX2_X1
* cell instance $5035 m0 *1 71.44,81.2
X$5035 3252 2659 3099 219 320 3253 MUX2_X1
* cell instance $5036 m0 *1 72.77,81.2
X$5036 219 13561 3320 3254 2785 320 DFF_X1
* cell instance $5039 r0 *1 71.06,81.2
X$5039 1570 219 320 2785 CLKBUF_X3
* cell instance $5041 r0 *1 72.77,81.2
X$5041 3320 2032 3129 219 320 3254 MUX2_X1
* cell instance $5043 r0 *1 74.48,81.2
X$5043 3320 2714 3439 219 320 3363 MUX2_X1
* cell instance $5044 r0 *1 75.81,81.2
X$5044 3363 2892 3321 219 320 3440 MUX2_X1
* cell instance $5045 m0 *1 76.57,81.2
X$5045 3132 2787 3104 219 320 3321 MUX2_X1
* cell instance $5053 r0 *1 82.08,81.2
X$5053 219 14435 3255 3323 2790 320 DFF_X1
* cell instance $5054 m0 *1 84.17,81.2
X$5054 3326 1756 3202 219 320 3201 MUX2_X1
* cell instance $5055 m0 *1 82.84,81.2
X$5055 3202 2037 3255 219 320 3323 MUX2_X1
* cell instance $5057 m0 *1 85.69,81.2
X$5057 3326 3214 3204 219 320 3585 MUX2_X1
* cell instance $5061 m0 *1 91.01,81.2
X$5061 3046 1746 3328 219 320 3327 MUX2_X1
* cell instance $5062 m0 *1 92.34,81.2
X$5062 219 13342 3328 3327 3133 320 DFF_X1
* cell instance $5065 m0 *1 97.28,81.2
X$5065 3213 3214 3047 219 320 3256 MUX2_X1
* cell instance $5068 m0 *1 99.56,81.2
X$5068 3257 1841 3050 219 320 3333 MUX2_X1
* cell instance $5069 m0 *1 100.89,81.2
X$5069 219 13035 3257 3333 2668 320 DFF_X1
* cell instance $5076 r0 *1 92.72,81.2
X$5076 219 13858 3364 3444 3133 320 DFF_X1
* cell instance $5077 r0 *1 95.95,81.2
X$5077 3050 1983 3364 219 320 3444 MUX2_X1
* cell instance $5078 r0 *1 97.28,81.2
X$5078 3207 3365 3364 219 320 3447 MUX2_X1
* cell instance $5081 r0 *1 99.75,81.2
X$5081 3367 1756 3050 219 320 3366 MUX2_X1
* cell instance $5084 r0 *1 101.65,81.2
X$5084 3367 3365 3258 219 320 3553 MUX2_X1
* cell instance $5085 r0 *1 102.98,81.2
X$5085 3368 2468 219 320 3369 NOR2_X1
* cell instance $5087 r0 *1 103.93,81.2
X$5087 3257 3370 3371 219 320 3451 MUX2_X1
* cell instance $5088 r0 *1 105.26,81.2
X$5088 3371 2086 3050 219 320 3492 MUX2_X1
* cell instance $5090 m0 *1 106.02,81.2
X$5090 3258 2032 3050 219 320 3336 MUX2_X1
* cell instance $5093 m0 *1 108.68,81.2
X$5093 219 12948 3258 3336 3493 320 DFF_X1
* cell instance $5101 r0 *1 117.23,81.2
X$5101 219 14485 3372 3455 3495 320 DFF_X1
* cell instance $5105 r0 *1 120.46,81.2
X$5105 3372 3496 3456 219 320 3455 MUX2_X1
* cell instance $5109 m0 *1 125.4,81.2
X$5109 219 12613 3259 3458 3134 320 DFF_X1
* cell instance $5112 m0 *1 129.39,81.2
X$5112 3259 3260 3340 219 320 3343 MUX2_X1
* cell instance $5114 m0 *1 130.91,81.2
X$5114 1396 3136 3459 219 320 3342 MUX2_X1
* cell instance $5119 r0 *1 125.78,81.2
X$5119 324 3135 3259 219 320 3458 MUX2_X1
* cell instance $5120 r0 *1 127.11,81.2
X$5120 324 3136 3340 219 320 3225 MUX2_X1
* cell instance $5121 r0 *1 128.44,81.2
X$5121 219 13945 3137 3227 2800 320 DFF_X1
* cell instance $5122 r0 *1 131.67,81.2
X$5122 219 14391 3459 3342 2800 320 DFF_X1
* cell instance $5123 m0 *1 135.85,81.2
X$5123 219 12860 3263 3232 3604 320 DFF_X1
* cell instance $5124 m0 *1 133.38,81.2
X$5124 3261 3262 3343 320 219 3218 OAI21_X4
* cell instance $5125 m0 *1 139.08,81.2
X$5125 3140 3260 3263 219 320 3345 MUX2_X1
* cell instance $5127 m0 *1 140.6,81.2
X$5127 3234 3262 3345 320 219 3224 OAI21_X4
* cell instance $5130 m0 *1 144.02,81.2
X$5130 3235 3260 3142 219 320 3348 MUX2_X1
* cell instance $5132 m0 *1 145.54,81.2
X$5132 3144 3262 3348 320 219 3394 OAI21_X4
* cell instance $5134 m0 *1 148.2,81.2
X$5134 3264 3351 320 219 3373 AND2_X1
* cell instance $5136 m0 *1 149.15,81.2
X$5136 3265 3266 219 320 3240 NAND2_X1
* cell instance $5137 m0 *1 149.72,81.2
X$5137 3266 3265 3267 219 320 3351 MUX2_X1
* cell instance $5141 r0 *1 138.32,81.2
X$5141 2156 219 320 1902 CLKBUF_X3
* cell instance $5146 r0 *1 147.44,81.2
X$5146 219 3267 3266 3373 2916 320 DFF_X1
* cell instance $5148 r0 *1 151.05,81.2
X$5148 3267 3265 219 320 3461 XOR2_X1
* cell instance $5149 m0 *1 151.62,81.2
X$5149 3461 3238 219 320 2675 NOR2_X1
* cell instance $5154 m0 *1 154.66,81.2
X$5154 3462 3238 219 320 3145 NOR2_X1
* cell instance $5156 m0 *1 156.75,81.2
X$5156 3350 219 320 3241 BUF_X1
* cell instance $5157 m0 *1 157.32,81.2
X$5157 3053 219 320 3350 BUF_X2
* cell instance $5161 r0 *1 153.33,81.2
X$5161 219 13676 3463 3145 3375 320 DFF_X1
* cell instance $5162 r0 *1 156.56,81.2
X$5162 3463 3670 219 320 3462 XOR2_X1
* cell instance $5164 m0 *1 158.65,81.2
X$5164 3349 219 320 1772 BUF_X1
* cell instance $5167 m0 *1 160.74,81.2
X$5167 3268 3270 219 320 3055 NOR2_X1
* cell instance $5168 m0 *1 161.31,81.2
X$5168 3269 3377 219 320 3022 NOR2_X1
* cell instance $5171 r0 *1 159.41,81.2
X$5171 3563 3464 219 320 3021 NOR2_X1
* cell instance $5172 r0 *1 159.98,81.2
X$5172 3376 3465 219 320 3147 NOR2_X1
* cell instance $5174 r0 *1 160.74,81.2
X$5174 3382 3188 3271 1350 320 219 3465 OAI22_X1
* cell instance $5175 r0 *1 161.69,81.2
X$5175 3382 3378 3271 1348 320 219 3464 OAI22_X1
* cell instance $5176 m0 *1 162.45,81.2
X$5176 3272 3346 219 320 3148 NOR2_X1
* cell instance $5179 r0 *1 162.64,81.2
X$5179 3273 3379 3275 3378 320 219 3272 OAI22_X1
* cell instance $5180 m0 *1 163.59,81.2
X$5180 3274 3150 219 320 3026 NOR2_X1
* cell instance $5182 m0 *1 164.16,81.2
X$5182 3347 1350 3276 713 320 219 3150 OAI22_X1
* cell instance $5186 m0 *1 167.58,81.2
X$5186 3344 3469 219 320 2865 NOR2_X1
* cell instance $5187 m0 *1 168.15,81.2
X$5187 3337 3341 3271 1616 320 219 3153 OAI22_X1
* cell instance $5188 m0 *1 169.1,81.2
X$5188 3153 3386 219 320 3152 NOR2_X1
* cell instance $5190 m0 *1 170.43,81.2
X$5190 3339 3338 219 320 3237 NOR2_X1
* cell instance $5192 m0 *1 171.19,81.2
X$5192 3280 839 3275 3156 320 219 3338 OAI22_X1
* cell instance $5193 m0 *1 172.14,81.2
X$5193 3391 3334 3335 839 320 219 3155 OAI22_X1
* cell instance $5194 m0 *1 173.09,81.2
X$5194 3155 3157 219 320 3113 NOR2_X1
* cell instance $5195 m0 *1 173.66,81.2
X$5195 3278 3334 839 3276 320 219 3229 OAI22_X2
* cell instance $5197 m0 *1 175.56,81.2
X$5197 3278 3392 777 3276 320 219 3332 OAI22_X2
* cell instance $5199 r0 *1 163.59,81.2
X$5199 3273 3504 3275 3188 320 219 3467 OAI22_X1
* cell instance $5200 r0 *1 164.54,81.2
X$5200 3467 3380 219 320 2924 NOR2_X1
* cell instance $5201 r0 *1 165.11,81.2
X$5201 3468 1348 3470 1368 320 219 3346 OAI22_X1
* cell instance $5202 r0 *1 166.06,81.2
X$5202 3466 3381 219 320 3239 NOR2_X1
* cell instance $5203 r0 *1 166.63,81.2
X$5203 3387 3385 3383 663 320 219 3381 OAI22_X1
* cell instance $5204 r0 *1 167.58,81.2
X$5204 3384 3385 3276 663 320 219 3469 OAI22_X1
* cell instance $5205 r0 *1 168.53,81.2
X$5205 3277 3341 3390 1616 320 219 3466 OAI22_X1
* cell instance $5207 r0 *1 169.86,81.2
X$5207 3277 3334 3383 839 320 219 3388 OAI22_X1
* cell instance $5208 r0 *1 170.81,81.2
X$5208 3388 3389 219 320 2929 NOR2_X1
* cell instance $5209 r0 *1 171.38,81.2
X$5209 3387 3156 3390 1442 320 219 3389 OAI22_X1
* cell instance $5211 r0 *1 172.71,81.2
X$5211 3277 3392 777 3383 320 219 3450 OAI22_X2
* cell instance $5212 r0 *1 174.42,81.2
X$5212 3393 839 3156 3457 320 219 3159 OAI22_X2
* cell instance $5216 r0 *1 176.13,81.2
X$5216 3384 3156 1442 3507 320 219 3160 OAI22_X2
* cell instance $5218 m0 *1 177.65,81.2
X$5218 3332 3331 219 320 3060 NOR2_X2
* cell instance $5219 m0 *1 178.79,81.2
X$5219 3450 3396 219 320 2931 NOR2_X2
* cell instance $5221 r0 *1 177.84,81.2
X$5221 3395 3454 219 320 3453 NOR2_X2
* cell instance $5223 r0 *1 178.98,81.2
X$5223 3387 3452 1344 3390 320 219 3396 OAI22_X2
* cell instance $5224 m0 *1 181.07,81.2
X$5224 3449 3330 3329 219 320 3220 NOR3_X1
* cell instance $5225 m0 *1 180.12,81.2
X$5225 3217 2538 3158 1343 320 219 3329 OAI22_X1
* cell instance $5229 r0 *1 180.88,81.2
X$5229 3397 3162 219 320 3449 NOR2_X1
* cell instance $5231 r0 *1 181.64,81.2
X$5231 3397 3398 219 320 3510 NOR2_X1
* cell instance $5233 r0 *1 182.59,81.2
X$5233 3279 3162 219 320 3446 NOR2_X1
* cell instance $5234 r0 *1 183.16,81.2
X$5234 3512 3224 3280 549 320 219 3445 OAI22_X1
* cell instance $5236 m0 *1 183.73,81.2
X$5236 3217 549 3158 1203 320 219 3281 OAI22_X1
* cell instance $5238 m0 *1 187.91,81.2
X$5238 3325 3282 219 320 428 NOR2_X2
* cell instance $5239 m0 *1 188.86,81.2
X$5239 3442 3282 219 320 271 NOR2_X2
* cell instance $5241 r0 *1 184.11,81.2
X$5241 3446 3399 3281 219 320 3322 NOR3_X1
* cell instance $5242 r0 *1 184.87,81.2
X$5242 3279 3398 219 320 3400 NOR2_X1
* cell instance $5244 r0 *1 185.63,81.2
X$5244 3400 3445 3401 219 320 3325 NOR3_X1
* cell instance $5247 r0 *1 187.53,81.2
X$5247 3443 3374 3217 706 320 219 3438 OAI22_X1
* cell instance $5248 r0 *1 188.48,81.2
X$5248 3093 3398 219 320 3402 NOR2_X1
* cell instance $5249 r0 *1 189.05,81.2
X$5249 3402 3441 3551 219 320 3442 NOR3_X1
* cell instance $5250 r0 *1 189.81,81.2
X$5250 3512 3218 3280 544 320 219 3441 OAI22_X1
* cell instance $5251 m0 *1 190.38,81.2
X$5251 3193 3162 219 320 3283 NOR2_X1
* cell instance $5254 m0 *1 191.14,81.2
X$5254 3322 3163 219 320 266 NOR2_X2
* cell instance $5255 m0 *1 192.09,81.2
X$5255 3546 3282 219 320 278 NOR2_X2
* cell instance $5256 m0 *1 193.04,81.2
X$5256 219 13238 3284 3318 3210 320 DFF_X1
* cell instance $5257 m0 *1 196.27,81.2
X$5257 3284 2590 3209 219 320 3319 MUX2_X1
* cell instance $5258 m0 *1 197.6,81.2
X$5258 3165 2256 3284 219 320 3318 MUX2_X1
* cell instance $5259 m0 *1 198.93,81.2
X$5259 3165 2490 3285 219 320 3286 MUX2_X1
* cell instance $5263 r0 *1 190.76,81.2
X$5263 3283 3438 3547 219 320 3437 NOR3_X1
* cell instance $5266 r0 *1 193.42,81.2
X$5266 219 14695 3404 3434 3210 320 DFF_X1
* cell instance $5267 r0 *1 196.65,81.2
X$5267 3165 2364 3404 219 320 3434 MUX2_X1
* cell instance $5268 r0 *1 197.98,81.2
X$5268 3543 3282 219 320 282 NOR2_X2
* cell instance $5269 r0 *1 198.93,81.2
X$5269 219 14010 3285 3286 3289 320 DFF_X1
* cell instance $5271 r0 *1 202.54,81.2
X$5271 219 13651 3317 3430 3289 320 DFF_X1
* cell instance $5272 m0 *1 205.77,81.2
X$5272 3317 2065 3166 219 320 3287 MUX2_X1
* cell instance $5273 m0 *1 204.44,81.2
X$5273 2938 2490 3166 219 320 3203 MUX2_X1
* cell instance $5276 r0 *1 205.77,81.2
X$5276 2938 2364 3317 219 320 3430 MUX2_X1
* cell instance $5278 r0 *1 207.86,81.2
X$5278 219 13869 3405 3429 3289 320 DFF_X1
* cell instance $5279 m0 *1 211.47,81.2
X$5279 3169 2368 3290 219 320 3314 MUX2_X1
* cell instance $5280 m0 *1 208.24,81.2
X$5280 219 13590 3290 3314 3289 320 DFF_X1
* cell instance $5281 m0 *1 212.8,81.2
X$5281 3167 3096 3310 219 320 3311 MUX2_X1
* cell instance $5282 m0 *1 214.13,81.2
X$5282 219 13020 3310 3168 3291 320 DFF_X1
* cell instance $5285 m0 *1 218.31,81.2
X$5285 3308 1868 2943 219 320 3407 MUX2_X1
* cell instance $5286 m0 *1 219.64,81.2
X$5286 219 13145 3308 3199 3291 320 DFF_X1
* cell instance $5289 m0 *1 226.67,81.2
X$5289 3306 3171 3066 219 320 3424 MUX2_X1
* cell instance $5290 m0 *1 228,81.2
X$5290 3069 3293 3306 219 320 3196 MUX2_X1
* cell instance $5293 r0 *1 211.09,81.2
X$5293 3169 2495 3405 219 320 3429 MUX2_X1
* cell instance $5295 r0 *1 212.61,81.2
X$5295 219 13826 3170 3309 3291 320 DFF_X1
* cell instance $5297 r0 *1 216.22,81.2
X$5297 219 13851 3406 3427 3291 320 DFF_X1
* cell instance $5299 r0 *1 219.83,81.2
X$5299 3407 3307 2072 320 219 3519 MUX2_X2
* cell instance $5303 r0 *1 225.15,81.2
X$5303 3520 3070 3408 219 320 3425 MUX2_X1
* cell instance $5305 r0 *1 226.67,81.2
X$5305 3304 3419 3424 320 219 3156 OAI21_X4
* cell instance $5311 m0 *1 231.23,81.2
X$5311 3173 3194 219 320 3304 OR2_X1
* cell instance $5315 r0 *1 232.37,81.2
X$5315 3422 219 320 3175 BUF_X1
* cell instance $5316 r0 *1 232.94,81.2
X$5316 219 14338 3524 3523 3415 320 DFF_X1
* cell instance $5317 m0 *1 237.12,81.2
X$5317 3303 219 320 3073 BUF_X1
* cell instance $5318 m0 *1 234.65,81.2
X$5318 3185 3624 3172 320 219 3188 OAI21_X4
* cell instance $5319 m0 *1 237.69,81.2
X$5319 3300 219 320 3069 BUF_X1
* cell instance $5320 m0 *1 238.26,81.2
X$5320 3414 3071 3412 219 320 3294 MUX2_X1
* cell instance $5321 m0 *1 239.59,81.2
X$5321 3299 219 320 2820 BUF_X1
* cell instance $5322 m0 *1 240.16,81.2
X$5322 3292 219 320 3295 BUF_X1
* cell instance $5324 r0 *1 236.17,81.2
X$5324 3418 219 320 3410 BUF_X1
* cell instance $5325 r0 *1 236.74,81.2
X$5325 219 14518 3414 3409 3415 320 DFF_X1
* cell instance $5326 r0 *1 239.97,81.2
X$5326 3411 219 320 3413 BUF_X1
* cell instance $5338 m0 *1 8.17,84
X$5338 3471 219 320 3526 BUF_X2
* cell instance $5340 m0 *1 8.93,84
X$5340 1370 219 320 3296 CLKBUF_X3
* cell instance $5341 m0 *1 9.88,84
X$5341 219 13314 3570 3472 3296 320 DFF_X1
* cell instance $5346 r0 *1 9.12,84
X$5346 3568 219 320 3497 BUF_X2
* cell instance $5347 r0 *1 9.88,84
X$5347 3421 1547 3570 219 320 3472 MUX2_X1
* cell instance $5348 r0 *1 11.21,84
X$5348 3421 1599 3571 219 320 3569 MUX2_X1
* cell instance $5350 r0 *1 12.73,84
X$5350 3570 2520 3571 219 320 3711 MUX2_X1
* cell instance $5352 m0 *1 19,84
X$5352 3473 1550 3245 219 320 3529 MUX2_X1
* cell instance $5353 m0 *1 15.77,84
X$5353 219 13177 3473 3529 3353 320 DFF_X1
* cell instance $5357 r0 *1 17.29,84
X$5357 3421 1734 3628 219 320 3629 MUX2_X1
* cell instance $5358 r0 *1 18.62,84
X$5358 219 13825 3628 3629 3353 320 DFF_X1
* cell instance $5359 m0 *1 21.66,84
X$5359 3354 1507 3245 219 320 3416 MUX2_X1
* cell instance $5362 r0 *1 21.85,84
X$5362 3421 219 320 3245 BUF_X2
* cell instance $5364 m0 *1 23.56,84
X$5364 219 13170 3572 3474 3353 320 DFF_X1
* cell instance $5367 r0 *1 23.37,84
X$5367 3421 1553 3572 219 320 3474 MUX2_X1
* cell instance $5370 r0 *1 25.27,84
X$5370 3354 2842 3572 219 320 3532 MUX2_X1
* cell instance $5372 m0 *1 27.36,84
X$5372 3245 1303 3355 219 320 3417 MUX2_X1
* cell instance $5376 r0 *1 28.88,84
X$5376 219 14258 3476 3475 3244 320 DFF_X1
* cell instance $5378 m0 *1 29.07,84
X$5378 3421 1261 3476 219 320 3475 MUX2_X1
* cell instance $5380 m0 *1 30.78,84
X$5380 3532 2963 3423 219 320 3533 MUX2_X1
* cell instance $5382 m0 *1 33.82,84
X$5382 1515 219 320 3244 CLKBUF_X3
* cell instance $5387 r0 *1 32.49,84
X$5387 219 14184 3574 3573 3244 320 DFF_X1
* cell instance $5389 r0 *1 36.1,84
X$5389 3574 1520 3575 219 320 3576 MUX2_X1
* cell instance $5392 r0 *1 38,84
X$5392 219 14178 3631 3630 3086 320 DFF_X1
* cell instance $5393 m0 *1 39.9,84
X$5393 3359 1835 3426 219 320 3477 MUX2_X1
* cell instance $5395 m0 *1 41.23,84
X$5395 3533 2776 219 320 3535 NAND2_X1
* cell instance $5396 m0 *1 41.8,84
X$5396 3477 2777 219 320 3534 NAND2_X1
* cell instance $5400 r0 *1 42.37,84
X$5400 219 14278 3718 3633 3086 320 DFF_X1
* cell instance $5401 m0 *1 42.94,84
X$5401 3535 3534 2890 219 320 3717 NAND3_X2
* cell instance $5405 r0 *1 45.6,84
X$5405 219 14543 3479 3478 3313 320 DFF_X1
* cell instance $5407 m0 *1 46.17,84
X$5407 3245 1385 3479 219 320 3478 MUX2_X1
* cell instance $5408 m0 *1 48.26,84
X$5408 3634 2892 3250 219 320 3480 MUX2_X1
* cell instance $5411 r0 *1 48.83,84
X$5411 3480 2149 3719 219 320 3577 MUX2_X1
* cell instance $5413 m0 *1 50.92,84
X$5413 219 13594 3677 3481 3313 320 DFF_X1
* cell instance $5417 m0 *1 55.86,84
X$5417 219 12626 3638 3538 2975 320 DFF_X1
* cell instance $5418 m0 *1 59.09,84
X$5418 3482 1841 3129 219 320 3360 MUX2_X1
* cell instance $5419 m0 *1 60.42,84
X$5419 219 13509 3483 3580 3361 320 DFF_X1
* cell instance $5421 m0 *1 63.84,84
X$5421 3539 2776 219 320 3540 NAND2_X1
* cell instance $5425 r0 *1 51.49,84
X$5425 219 13870 3579 3578 3313 320 DFF_X1
* cell instance $5429 r0 *1 56.81,84
X$5429 3041 1480 3638 219 320 3538 MUX2_X1
* cell instance $5431 r0 *1 58.33,84
X$5431 3482 4058 3638 219 320 3362 MUX2_X1
* cell instance $5432 r0 *1 59.66,84
X$5432 3483 2086 3129 219 320 3580 MUX2_X1
* cell instance $5435 r0 *1 62.13,84
X$5435 3483 2888 3316 219 320 3581 MUX2_X1
* cell instance $5440 r0 *1 63.84,84
X$5440 3581 4003 3541 219 320 3582 MUX2_X1
* cell instance $5441 m0 *1 66.12,84
X$5441 3129 1898 3484 219 320 3643 MUX2_X1
* cell instance $5442 m0 *1 64.79,84
X$5442 3433 2657 3484 219 320 3541 MUX2_X1
* cell instance $5445 m0 *1 68.4,84
X$5445 219 13246 3435 3436 2785 320 DFF_X1
* cell instance $5446 m0 *1 71.63,84
X$5446 3440 3758 3253 219 320 3645 MUX2_X1
* cell instance $5450 r0 *1 65.17,84
X$5450 3540 3583 2890 219 320 3642 NAND3_X2
* cell instance $5451 r0 *1 66.5,84
X$5451 219 14585 3484 3643 2785 320 DFF_X1
* cell instance $5454 r0 *1 70.87,84
X$5454 3642 3044 3645 320 219 3647 OAI21_X4
* cell instance $5458 m0 *1 75.62,84
X$5458 3129 2037 3439 219 320 3485 MUX2_X1
* cell instance $5459 m0 *1 79.99,84
X$5459 3352 219 320 3584 BUF_X1
* cell instance $5465 r0 *1 75.81,84
X$5465 219 14478 3439 3485 3680 320 DFF_X1
* cell instance $5469 r0 *1 82.65,84
X$5469 3584 1571 3649 219 320 3648 MUX2_X1
* cell instance $5472 r0 *1 87.78,84
X$5472 3585 3486 2792 219 320 3765 NOR3_X1
* cell instance $5473 r0 *1 88.54,84
X$5473 3584 219 320 3202 BUF_X2
* cell instance $5475 m0 *1 94.05,84
X$5475 3487 3370 3328 219 320 3549 MUX2_X1
* cell instance $5476 m0 *1 90.82,84
X$5476 219 13172 3487 3651 3133 320 DFF_X1
* cell instance $5477 m0 *1 95.38,84
X$5477 3549 3491 219 320 3550 NOR2_X1
* cell instance $5481 r0 *1 92.53,84
X$5481 3856 219 320 3133 CLKBUF_X3
* cell instance $5482 r0 *1 93.48,84
X$5482 3050 1647 3487 219 320 3651 MUX2_X1
* cell instance $5484 r0 *1 95.19,84
X$5484 3050 1999 3683 219 320 3828 MUX2_X1
* cell instance $5485 r0 *1 96.52,84
X$5485 2904 2998 219 320 3587 NAND2_X2
* cell instance $5486 r0 *1 97.47,84
X$5486 3652 3486 219 320 3586 NOR2_X1
* cell instance $5487 m0 *1 98.42,84
X$5487 3256 2468 219 320 3488 NOR2_X1
* cell instance $5488 m0 *1 97.85,84
X$5488 3447 3486 219 320 3552 NOR2_X1
* cell instance $5490 r0 *1 98.04,84
X$5490 3586 3488 2669 3550 3552 3923 219 320 3653 OAI33_X1
* cell instance $5492 m0 *1 102.6,84
X$5492 3489 3486 219 320 3490 NOR2_X1
* cell instance $5493 m0 *1 99.37,84
X$5493 219 13095 3367 3366 3133 320 DFF_X1
* cell instance $5494 m0 *1 103.17,84
X$5494 3553 3486 219 320 3554 NOR2_X1
* cell instance $5496 m0 *1 104.5,84
X$5496 3451 3491 219 320 3555 NOR2_X1
* cell instance $5497 m0 *1 105.07,84
X$5497 219 12982 3371 3492 3589 320 DFF_X1
* cell instance $5498 m0 *1 108.3,84
X$5498 219 12947 3657 3656 3493 320 DFF_X1
* cell instance $5502 m0 *1 114,84
X$5502 219 12995 3593 3494 3495 320 DFF_X1
* cell instance $5506 r0 *1 103.36,84
X$5506 3490 3369 3587 3555 3554 2575 219 320 3588 OAI33_X1
* cell instance $5507 r0 *1 104.69,84
X$5507 3588 3653 219 320 3654 OR2_X2
* cell instance $5508 r0 *1 105.64,84
X$5508 219 14684 3590 3655 3589 320 DFF_X1
* cell instance $5511 r0 *1 109.82,84
X$5511 3657 3496 3859 219 320 3656 MUX2_X1
* cell instance $5515 r0 *1 112.48,84
X$5515 3593 3491 3657 219 320 3591 MUX2_X1
* cell instance $5516 r0 *1 113.81,84
X$5516 3593 3592 3859 219 320 3494 MUX2_X1
* cell instance $5520 r0 *1 117.61,84
X$5520 3596 3659 3456 219 320 3594 MUX2_X1
* cell instance $5522 m0 *1 117.61,84
X$5522 219 12946 3596 3594 3495 320 DFF_X1
* cell instance $5523 m0 *1 121.6,84
X$5523 219 13414 3600 3601 3495 320 DFF_X1
* cell instance $5528 m0 *1 133.38,84
X$5528 3137 3260 3459 219 320 3558 MUX2_X1
* cell instance $5530 m0 *1 134.9,84
X$5530 3139 3262 3558 320 219 3374 OAI21_X4
* cell instance $5533 m0 *1 141.93,84
X$5533 3497 2799 3498 219 320 3667 MUX2_X1
* cell instance $5534 m0 *1 143.26,84
X$5534 3497 2805 3499 219 320 3559 MUX2_X1
* cell instance $5535 m0 *1 144.59,84
X$5535 219 12852 3499 3559 2916 320 DFF_X1
* cell instance $5536 m0 *1 147.82,84
X$5536 219 12714 3606 3500 3375 320 DFF_X1
* cell instance $5539 m0 *1 154.28,84
X$5539 1954 3561 320 219 3607 AND2_X1
* cell instance $5541 m0 *1 155.8,84
X$5541 3502 3501 3562 219 320 3561 MUX2_X1
* cell instance $5544 r0 *1 118.94,84
X$5544 3596 3595 3372 219 320 3597 MUX2_X1
* cell instance $5548 r0 *1 120.27,84
X$5548 3598 3595 3600 219 320 3599 MUX2_X1
* cell instance $5549 r0 *1 121.6,84
X$5549 3600 3592 3456 219 320 3601 MUX2_X1
* cell instance $5557 r0 *1 127.68,84
X$5557 3526 2799 3602 219 320 3661 MUX2_X1
* cell instance $5558 r0 *1 129.01,84
X$5558 219 13685 3602 3661 2800 320 DFF_X1
* cell instance $5560 r0 *1 132.62,84
X$5560 3526 2805 3662 219 320 3603 MUX2_X1
* cell instance $5561 r0 *1 133.95,84
X$5561 3602 2909 3662 219 320 3663 MUX2_X1
* cell instance $5565 r0 *1 136.61,84
X$5565 3605 3663 219 320 3664 OR2_X1
* cell instance $5568 r0 *1 140.6,84
X$5568 219 14006 3498 3667 3604 320 DFF_X1
* cell instance $5572 r0 *1 145.16,84
X$5572 3498 2909 3499 219 320 3668 MUX2_X1
* cell instance $5574 r0 *1 146.68,84
X$5574 3497 3136 3606 219 320 3500 MUX2_X1
* cell instance $5576 r0 *1 148.2,84
X$5576 3605 3668 219 320 3669 OR2_X1
* cell instance $5579 r0 *1 153.52,84
X$5579 219 3562 3502 3607 3375 320 DFF_X1
* cell instance $5580 r0 *1 156.75,84
X$5580 3501 3502 219 320 3670 NAND2_X1
* cell instance $5583 m0 *1 159.98,84
X$5583 3337 3504 3503 713 320 219 3376 OAI22_X1
* cell instance $5584 m0 *1 159.03,84
X$5584 3337 3379 3503 1368 320 219 3563 OAI22_X1
* cell instance $5587 r0 *1 159.98,84
X$5587 3277 3504 3565 3188 320 219 3268 OAI22_X1
* cell instance $5588 r0 *1 160.93,84
X$5588 3671 3665 219 320 3024 NOR2_X1
* cell instance $5589 m0 *1 162.26,84
X$5589 3609 1350 3383 713 320 219 3270 OAI22_X1
* cell instance $5590 m0 *1 161.31,84
X$5590 3277 3379 3565 3378 320 219 3269 OAI22_X1
* cell instance $5591 m0 *1 163.21,84
X$5591 3278 3504 3608 3188 320 219 3274 OAI22_X1
* cell instance $5592 m0 *1 164.16,84
X$5592 3566 3567 219 320 3025 NOR2_X1
* cell instance $5593 m0 *1 164.73,84
X$5593 3347 1348 3276 1368 320 219 3567 OAI22_X1
* cell instance $5594 m0 *1 165.68,84
X$5594 3468 1350 3470 713 320 219 3380 OAI22_X1
* cell instance $5597 r0 *1 161.5,84
X$5597 3391 3504 3693 3188 320 219 3671 OAI22_X1
* cell instance $5598 r0 *1 162.45,84
X$5598 3609 1348 3383 1368 320 219 3377 OAI22_X1
* cell instance $5599 r0 *1 163.4,84
X$5599 3278 3379 3608 3378 320 219 3566 OAI22_X1
* cell instance $5600 r0 *1 164.35,84
X$5600 3745 3610 219 320 3119 NOR2_X1
* cell instance $5602 r0 *1 165.3,84
X$5602 3666 1348 3335 1368 320 219 3610 OAI22_X1
* cell instance $5603 r0 *1 166.25,84
X$5603 3666 1350 3335 713 320 219 3665 OAI22_X1
* cell instance $5604 r0 *1 167.2,84
X$5604 3391 3341 3335 663 320 219 3744 OAI22_X1
* cell instance $5605 m0 *1 167.96,84
X$5605 3278 3341 3507 1616 320 219 3344 OAI22_X1
* cell instance $5607 m0 *1 168.91,84
X$5607 3382 3385 3503 663 320 219 3386 OAI22_X1
* cell instance $5609 m0 *1 170.05,84
X$5609 3564 3505 219 320 3057 NOR2_X1
* cell instance $5612 r0 *1 168.91,84
X$5612 3273 3341 3470 663 320 219 3564 OAI22_X1
* cell instance $5613 r0 *1 169.86,84
X$5613 3660 1616 3275 3385 320 219 3505 OAI22_X1
* cell instance $5616 m0 *1 171,84
X$5616 3273 3334 3506 1442 320 219 3339 OAI22_X1
* cell instance $5617 m0 *1 172.14,84
X$5617 3391 3392 3335 777 320 219 3560 OAI22_X1
* cell instance $5620 r0 *1 171.95,84
X$5620 3273 3392 3470 777 320 219 3161 OAI22_X1
* cell instance $5623 m0 *1 173.47,84
X$5623 3337 3334 1442 3271 320 219 3231 OAI22_X2
* cell instance $5626 r0 *1 174.04,84
X$5626 3560 3611 219 320 3612 NOR2_X1
* cell instance $5627 r0 *1 174.61,84
X$5627 3233 3452 3158 1344 320 219 3611 OAI22_X1
* cell instance $5631 r0 *1 175.56,84
X$5631 3337 3392 1344 3271 320 219 3395 OAI22_X2
* cell instance $5632 m0 *1 176.51,84
X$5632 3393 777 3452 3457 320 219 3454 OAI22_X2
* cell instance $5634 m0 *1 178.22,84
X$5634 3508 3452 3506 1344 320 219 3509 OAI22_X1
* cell instance $5637 r0 *1 177.27,84
X$5637 3384 3452 1344 3507 320 219 3331 OAI22_X2
* cell instance $5639 m0 *1 181.26,84
X$5639 3510 3448 3511 320 3543 219 NOR3_X2
* cell instance $5640 m0 *1 180.31,84
X$5640 3443 3394 3513 3557 320 219 3330 OAI22_X1
* cell instance $5641 m0 *1 182.59,84
X$5641 3512 3394 3557 3508 320 219 3448 OAI22_X2
* cell instance $5642 m0 *1 184.3,84
X$5642 3443 3224 3513 3514 320 219 3399 OAI22_X1
* cell instance $5644 m0 *1 185.44,84
X$5644 3516 3514 3506 1203 320 219 3401 OAI22_X1
* cell instance $5647 m0 *1 188.1,84
X$5647 3443 3218 3513 3515 320 219 3324 OAI22_X1
* cell instance $5648 m0 *1 189.05,84
X$5648 3516 3515 3506 1206 320 219 3551 OAI22_X1
* cell instance $5649 m0 *1 190,84
X$5649 3512 3374 3280 706 320 219 3548 OAI22_X1
* cell instance $5650 m0 *1 190.95,84
X$5650 3193 3398 219 320 3403 NOR2_X1
* cell instance $5652 m0 *1 191.71,84
X$5652 3403 3548 3517 219 320 3546 NOR3_X1
* cell instance $5654 m0 *1 193.99,84
X$5654 3319 3544 2352 320 219 3545 MUX2_X2
* cell instance $5655 m0 *1 195.7,84
X$5655 2362 219 320 3210 CLKBUF_X3
* cell instance $5656 m0 *1 196.65,84
X$5656 3404 2590 3285 219 320 3544 MUX2_X1
* cell instance $5661 r0 *1 180.69,84
X$5661 3650 2538 1343 3506 320 219 3511 OAI22_X2
* cell instance $5665 r0 *1 190.19,84
X$5665 3730 3613 3158 1131 320 219 3547 OAI22_X1
* cell instance $5666 r0 *1 191.14,84
X$5666 3516 3613 3506 1131 320 219 3517 OAI22_X1
* cell instance $5670 r0 *1 196.08,84
X$5670 3210 219 320 CLKBUF_X1
* cell instance $5674 r0 *1 198.74,84
X$5674 219 14033 3706 3646 3210 320 DFF_X1
* cell instance $5676 m0 *1 200.64,84
X$5676 219 13626 3542 3644 3289 320 DFF_X1
* cell instance $5677 m0 *1 204.06,84
X$5677 3289 219 320 CLKBUF_X1
* cell instance $5678 m0 *1 204.63,84
X$5678 2362 219 320 3289 CLKBUF_X3
* cell instance $5679 m0 *1 205.58,84
X$5679 3288 2933 3287 320 219 4010 OAI21_X4
* cell instance $5682 r0 *1 201.97,84
X$5682 3413 2165 3542 219 320 3644 MUX2_X1
* cell instance $5687 r0 *1 209,84
X$5687 3641 2933 3518 320 219 3640 OAI21_X4
* cell instance $5688 m0 *1 210.14,84
X$5688 3290 2065 3405 219 320 3518 MUX2_X1
* cell instance $5692 m0 *1 212.61,84
X$5692 3291 219 320 CLKBUF_X1
* cell instance $5693 m0 *1 211.85,84
X$5693 2072 3537 219 320 3641 OR2_X1
* cell instance $5694 m0 *1 213.18,84
X$5694 219 2491 3062 320 BUF_X16
* cell instance $5695 m0 *1 217.93,84
X$5695 3170 2976 3406 219 320 3537 MUX2_X1
* cell instance $5696 m0 *1 219.26,84
X$5696 3169 2169 3406 219 320 3427 MUX2_X1
* cell instance $5702 r0 *1 214.32,84
X$5702 2362 219 320 3291 CLKBUF_X3
* cell instance $5706 r0 *1 216.6,84
X$5706 219 14674 3617 3639 3615 320 DFF_X1
* cell instance $5707 r0 *1 219.83,84
X$5707 3618 2169 3617 219 320 3639 MUX2_X1
* cell instance $5711 r0 *1 223.63,84
X$5711 219 14640 3619 3637 3521 320 DFF_X1
* cell instance $5712 m0 *1 227.24,84
X$5712 3619 3171 3408 219 320 3536 MUX2_X1
* cell instance $5713 m0 *1 224.01,84
X$5713 219 13232 3408 3425 3521 320 DFF_X1
* cell instance $5715 m0 *1 228.76,84
X$5715 219 13291 3522 3635 3415 320 DFF_X1
* cell instance $5718 r0 *1 227.05,84
X$5718 219 14679 3620 3636 3521 320 DFF_X1
* cell instance $5719 r0 *1 230.28,84
X$5719 3620 3071 3522 219 320 3621 MUX2_X1
* cell instance $5723 r0 *1 231.61,84
X$5723 3520 3081 3522 219 320 3635 MUX2_X1
* cell instance $5724 m0 *1 235.6,84
X$5724 3173 3294 219 320 3531 OR2_X1
* cell instance $5725 m0 *1 232.37,84
X$5725 219 13180 3623 3632 3415 320 DFF_X1
* cell instance $5727 r0 *1 232.94,84
X$5727 3622 3293 3623 219 320 3632 MUX2_X1
* cell instance $5729 r0 *1 234.65,84
X$5729 3531 3624 3625 320 219 3378 OAI21_X4
* cell instance $5730 m0 *1 236.93,84
X$5730 3530 219 320 3527 BUF_X1
* cell instance $5732 m0 *1 237.5,84
X$5732 219 13155 3412 3528 3415 320 DFF_X1
* cell instance $5735 r0 *1 237.31,84
X$5735 3622 2831 3414 219 320 3409 MUX2_X1
* cell instance $5736 r0 *1 238.64,84
X$5736 3622 3081 3412 219 320 3528 MUX2_X1
* cell instance $5737 r0 *1 239.97,84
X$5737 3525 219 320 2728 CLKBUF_X2
* cell instance $5741 m0 *1 6.84,100.8
X$5741 4598 219 320 4601 BUF_X1
* cell instance $5746 m0 *1 12.92,100.8
X$5746 4601 4445 4602 219 320 4538 MUX2_X1
* cell instance $5747 m0 *1 14.25,100.8
X$5747 219 13436 4603 4600 4541 320 DFF_X1
* cell instance $5748 m0 *1 17.48,100.8
X$5748 4143 219 320 CLKBUF_X1
* cell instance $5749 m0 *1 18.05,100.8
X$5749 4602 2957 4603 219 320 4653 MUX2_X1
* cell instance $5752 m0 *1 21.66,100.8
X$5752 4601 4359 4604 219 320 4750 MUX2_X1
* cell instance $5755 m0 *1 23.94,100.8
X$5755 4360 4058 4604 219 320 4650 MUX2_X1
* cell instance $5758 m0 *1 26.22,100.8
X$5758 4601 4277 4605 219 320 4697 MUX2_X1
* cell instance $5759 m0 *1 27.55,100.8
X$5759 4650 3126 4651 219 320 4751 MUX2_X1
* cell instance $5762 m0 *1 31.16,100.8
X$5762 4601 3990 4477 219 320 4652 MUX2_X1
* cell instance $5770 r0 *1 11.78,100.8
X$5770 4599 219 320 4799 CLKBUF_X2
* cell instance $5772 r0 *1 13.3,100.8
X$5772 219 14114 4846 4800 4143 320 DFF_X1
* cell instance $5773 r0 *1 16.53,100.8
X$5773 4601 4238 4603 219 320 4600 MUX2_X1
* cell instance $5776 r0 *1 19.57,100.8
X$5776 4541 219 320 14792 INV_X1
* cell instance $5777 r0 *1 19.95,100.8
X$5777 4051 219 320 4541 CLKBUF_X3
* cell instance $5778 r0 *1 20.9,100.8
X$5778 219 13739 4604 4750 4541 320 DFF_X1
* cell instance $5781 r0 *1 26.41,100.8
X$5781 219 13727 4605 4697 4802 320 DFF_X1
* cell instance $5784 m0 *1 33.06,100.8
X$5784 4542 2787 4477 219 320 4606 MUX2_X1
* cell instance $5790 r0 *1 33.82,100.8
X$5790 4606 2892 4653 219 320 4757 MUX2_X1
* cell instance $5791 r0 *1 35.15,100.8
X$5791 219 14641 4698 4753 4479 320 DFF_X1
* cell instance $5793 m0 *1 37.05,100.8
X$5793 3679 219 320 4479 CLKBUF_X3
* cell instance $5796 r0 *1 38.38,100.8
X$5796 4698 4006 4700 219 320 4753 MUX2_X1
* cell instance $5797 r0 *1 39.71,100.8
X$5797 4698 3848 4804 219 320 4699 MUX2_X1
* cell instance $5798 r0 *1 41.04,100.8
X$5798 4700 3910 4804 219 320 4852 MUX2_X1
* cell instance $5800 m0 *1 43.13,100.8
X$5800 4657 4003 4655 219 320 4759 MUX2_X1
* cell instance $5805 r0 *1 44.27,100.8
X$5805 4759 4906 219 320 4701 NAND2_X1
* cell instance $5806 r0 *1 44.84,100.8
X$5806 4758 3758 4757 219 320 4761 MUX2_X1
* cell instance $5807 r0 *1 46.17,100.8
X$5807 4856 4279 4761 320 219 4187 OAI21_X4
* cell instance $5808 m0 *1 48.07,100.8
X$5808 4607 3948 4475 219 320 4660 MUX2_X1
* cell instance $5810 m0 *1 49.4,100.8
X$5810 219 13201 4607 4660 4281 320 DFF_X1
* cell instance $5811 m0 *1 52.63,100.8
X$5811 4607 4702 4763 219 320 4608 MUX2_X1
* cell instance $5817 r0 *1 49.21,100.8
X$5817 4475 3947 4763 219 320 4762 MUX2_X1
* cell instance $5818 r0 *1 50.54,100.8
X$5818 219 13807 4763 4762 4281 320 DFF_X1
* cell instance $5819 r0 *1 53.77,100.8
X$5819 4608 4765 4609 219 320 4758 MUX2_X1
* cell instance $5822 r0 *1 56.81,100.8
X$5822 4700 4282 4806 219 320 4862 MUX2_X1
* cell instance $5825 r0 *1 58.71,100.8
X$5825 4700 4364 4703 219 320 4769 MUX2_X1
* cell instance $5826 m0 *1 59.09,100.8
X$5826 3723 219 320 4436 CLKBUF_X3
* cell instance $5831 m0 *1 64.03,100.8
X$5831 219 13501 4610 4662 4285 320 DFF_X1
* cell instance $5832 m0 *1 67.26,100.8
X$5832 4610 3592 4611 219 320 4662 MUX2_X1
* cell instance $5835 r0 *1 60.23,100.8
X$5835 219 14262 4703 4769 4436 320 DFF_X1
* cell instance $5839 r0 *1 63.46,100.8
X$5839 4610 3848 4705 219 320 4704 MUX2_X1
* cell instance $5840 r0 *1 64.79,100.8
X$5840 219 14168 4705 4773 4285 320 DFF_X1
* cell instance $5841 r0 *1 68.02,100.8
X$5841 4611 3858 4705 219 320 4773 MUX2_X1
* cell instance $5842 m0 *1 69.92,100.8
X$5842 4285 219 320 CLKBUF_X1
* cell instance $5843 m0 *1 68.97,100.8
X$5843 3723 219 320 4285 CLKBUF_X3
* cell instance $5846 m0 *1 71.44,100.8
X$5846 4666 3496 4611 219 320 4667 MUX2_X1
* cell instance $5847 m0 *1 72.77,100.8
X$5847 219 13513 4666 4667 4612 320 DFF_X1
* cell instance $5850 m0 *1 76.95,100.8
X$5850 219 13188 4780 4778 4612 320 DFF_X1
* cell instance $5851 m0 *1 80.18,100.8
X$5851 219 13192 4672 4671 4612 320 DFF_X1
* cell instance $5852 m0 *1 83.41,100.8
X$5852 4707 4161 4672 219 320 4671 MUX2_X1
* cell instance $5857 r0 *1 70.3,100.8
X$5857 4696 219 320 4808 BUF_X1
* cell instance $5860 r0 *1 72.01,100.8
X$5860 4666 2714 4486 219 320 4777 MUX2_X1
* cell instance $5863 r0 *1 73.91,100.8
X$5863 219 13881 4871 4706 4612 320 DFF_X1
* cell instance $5866 r0 *1 77.71,100.8
X$5866 4707 4492 4780 219 320 4778 MUX2_X1
* cell instance $5869 r0 *1 79.61,100.8
X$5869 219 14569 4708 4782 4612 320 DFF_X1
* cell instance $5871 r0 *1 83.22,100.8
X$5871 4708 3766 4672 219 320 4711 MUX2_X1
* cell instance $5873 r0 *1 84.74,100.8
X$5873 4808 4255 4709 219 320 4487 MUX2_X1
* cell instance $5874 m0 *1 89.11,100.8
X$5874 4615 3592 4707 219 320 4675 MUX2_X1
* cell instance $5875 m0 *1 85.88,100.8
X$5875 219 13187 4613 4674 4966 320 DFF_X1
* cell instance $5876 m0 *1 90.44,100.8
X$5876 219 13194 4616 4614 4489 320 DFF_X1
* cell instance $5877 m0 *1 93.67,100.8
X$5877 4616 3766 4615 219 320 4713 MUX2_X1
* cell instance $5879 r0 *1 86.07,100.8
X$5879 4707 3858 4613 219 320 4674 MUX2_X1
* cell instance $5882 r0 *1 87.97,100.8
X$5882 4709 3214 4613 219 320 4710 MUX2_X1
* cell instance $5885 r0 *1 90.25,100.8
X$5885 4616 3735 4707 219 320 4614 MUX2_X1
* cell instance $5887 r0 *1 91.96,100.8
X$5887 4710 2665 2095 219 320 4877 NOR3_X1
* cell instance $5889 r0 *1 92.91,100.8
X$5889 2669 4711 4713 2575 320 219 4712 OAI22_X2
* cell instance $5890 r0 *1 94.62,100.8
X$5890 4710 2672 4713 219 320 4714 MUX2_X1
* cell instance $5891 m0 *1 95.57,100.8
X$5891 219 13024 4491 4678 4489 320 DFF_X1
* cell instance $5896 r0 *1 96.14,100.8
X$5896 3856 219 320 4489 CLKBUF_X3
* cell instance $5897 r0 *1 97.09,100.8
X$5897 4489 219 320 14775 INV_X1
* cell instance $5900 r0 *1 102.03,100.8
X$5900 4160 4485 4786 219 320 4787 MUX2_X1
* cell instance $5902 m0 *1 102.22,100.8
X$5902 4160 4617 4493 219 320 4561 MUX2_X1
* cell instance $5903 r0 *1 103.36,100.8
X$5903 219 13849 4786 4787 4453 320 DFF_X1
* cell instance $5905 m0 *1 103.93,100.8
X$5905 5122 2752 219 320 4618 NAND2_X1
* cell instance $5906 m0 *1 105.26,100.8
X$5906 4786 1844 4568 219 320 4682 MUX2_X1
* cell instance $5910 m0 *1 110.58,100.8
X$5910 219 12621 4569 4684 4372 320 DFF_X1
* cell instance $5915 r0 *1 107.73,100.8
X$5915 4488 219 320 3859 BUF_X2
* cell instance $5916 r0 *1 108.49,100.8
X$5916 2468 1651 219 320 4790 NAND2_X1
* cell instance $5919 m0 *1 115.9,100.8
X$5919 219 12655 4502 4619 4620 320 DFF_X1
* cell instance $5927 r0 *1 119.7,100.8
X$5927 219 4715 4790 4918 5258 4622 320 OAI22_X4
* cell instance $5928 m0 *1 121.6,100.8
X$5928 4578 4367 4686 219 320 4715 MUX2_X1
* cell instance $5929 m0 *1 120.27,100.8
X$5929 4501 4367 4621 219 320 4622 MUX2_X1
* cell instance $5930 m0 *1 122.93,100.8
X$5930 4131 4617 4577 219 320 4688 MUX2_X1
* cell instance $5931 m0 *1 124.26,100.8
X$5931 219 12988 4577 4688 4376 320 DFF_X1
* cell instance $5942 r0 *1 128.63,100.8
X$5942 1902 219 320 4376 CLKBUF_X3
* cell instance $5943 r0 *1 129.58,100.8
X$5943 4376 219 320 CLKBUF_X1
* cell instance $5946 r0 *1 133.95,100.8
X$5946 4294 320 4819 219 BUF_X4
* cell instance $5948 r0 *1 135.47,100.8
X$5948 219 14591 4820 4716 4506 320 DFF_X1
* cell instance $5949 m0 *1 137.56,100.8
X$5949 1902 219 320 4506 CLKBUF_X3
* cell instance $5950 m0 *1 136.23,100.8
X$5950 4505 320 4623 219 BUF_X4
* cell instance $5953 m0 *1 140.79,100.8
X$5953 1161 4623 4626 219 320 4624 MUX2_X1
* cell instance $5954 m0 *1 142.12,100.8
X$5954 1161 4625 4627 219 320 4690 MUX2_X1
* cell instance $5955 m0 *1 143.45,100.8
X$5955 219 13104 4627 4690 4793 320 DFF_X1
* cell instance $5959 r0 *1 139.08,100.8
X$5959 219 13895 4717 4889 4506 320 DFF_X1
* cell instance $5961 r0 *1 142.69,100.8
X$5961 219 13716 4892 4891 4793 320 DFF_X1
* cell instance $5964 r0 *1 146.49,100.8
X$5964 3605 4821 219 320 4794 OR2_X1
* cell instance $5966 r0 *1 147.44,100.8
X$5966 4794 3746 4893 320 219 4171 OAI21_X2
* cell instance $5967 m0 *1 151.81,100.8
X$5967 4719 4623 4630 219 320 4694 MUX2_X1
* cell instance $5968 m0 *1 148.58,100.8
X$5968 219 13103 4628 4691 4629 320 DFF_X1
* cell instance $5969 m0 *1 153.14,100.8
X$5969 219 13479 4630 4694 4629 320 DFF_X1
* cell instance $5974 r0 *1 150.48,100.8
X$5974 4719 4819 4628 219 320 4691 MUX2_X1
* cell instance $5975 r0 *1 151.81,100.8
X$5975 4628 4718 4630 219 320 4895 MUX2_X1
* cell instance $5976 r0 *1 153.14,100.8
X$5976 4719 4625 4720 219 320 4796 MUX2_X1
* cell instance $5977 r0 *1 154.47,100.8
X$5977 219 13973 4720 4796 4629 320 DFF_X1
* cell instance $5978 m0 *1 157.7,100.8
X$5978 4470 2296 4459 4518 320 219 4588 OAI22_X1
* cell instance $5984 m0 *1 160.55,100.8
X$5984 4177 4721 219 320 4593 NOR2_X1
* cell instance $5985 m0 *1 161.31,100.8
X$5985 4472 2528 3391 4084 320 219 4798 OAI22_X1
* cell instance $5986 m0 *1 162.26,100.8
X$5986 4522 2241 3233 4082 320 219 4723 OAI22_X1
* cell instance $5987 m0 *1 163.21,100.8
X$5987 4472 2296 4521 4518 320 219 4693 OAI22_X1
* cell instance $5988 m0 *1 164.16,100.8
X$5988 4724 4692 4693 219 320 4689 NOR3_X1
* cell instance $5990 m0 *1 165.11,100.8
X$5990 4346 2125 4631 4512 320 219 4692 OAI22_X1
* cell instance $5994 r0 *1 161.5,100.8
X$5994 4141 4721 219 320 4722 NOR2_X1
* cell instance $5995 r0 *1 162.07,100.8
X$5995 4722 4798 4723 219 320 4797 NOR3_X1
* cell instance $5998 r0 *1 163.78,100.8
X$5998 4390 4721 219 320 4724 NOR2_X1
* cell instance $6002 r0 *1 167.01,100.8
X$6002 4302 4725 219 320 4727 NOR2_X1
* cell instance $6003 m0 *1 168.15,100.8
X$6003 4689 4687 219 320 3806 NOR2_X2
* cell instance $6004 m0 *1 167.2,100.8
X$6004 4472 2681 3391 4171 320 219 4726 OAI22_X1
* cell instance $6005 m0 *1 169.1,100.8
X$6005 4633 4358 219 320 4634 NOR2_X1
* cell instance $6006 m0 *1 169.67,100.8
X$6006 4633 4721 219 320 4887 NOR2_X1
* cell instance $6007 m0 *1 170.24,100.8
X$6007 4633 4081 219 320 4679 NOR2_X1
* cell instance $6008 m0 *1 170.81,100.8
X$6008 4827 4687 219 320 3302 NOR2_X2
* cell instance $6010 r0 *1 167.58,100.8
X$6010 4727 4726 4632 219 320 4728 NOR3_X1
* cell instance $6012 r0 *1 168.72,100.8
X$6012 4826 4795 4792 320 3939 219 NOR3_X2
* cell instance $6013 r0 *1 170.05,100.8
X$6013 4883 4729 950 3280 320 219 4795 OAI22_X2
* cell instance $6026 r0 *1 7.79,112
X$6026 5412 219 320 5347 BUF_X1
* cell instance $6027 m0 *1 8.17,112
X$6027 5344 219 320 5225 BUF_X2
* cell instance $6030 r0 *1 8.36,112
X$6030 5413 219 320 5351 CLKBUF_X2
* cell instance $6033 m0 *1 9.31,112
X$6033 5343 219 320 5379 BUF_X1
* cell instance $6037 m0 *1 21.28,112
X$6037 219 13409 5345 5382 5290 320 DFF_X1
* cell instance $6038 m0 *1 24.51,112
X$6038 5345 4361 5094 219 320 5382 MUX2_X1
* cell instance $6044 r0 *1 16.34,112
X$6044 219 13989 5555 5415 5287 320 DFF_X1
* cell instance $6047 r0 *1 22.8,112
X$6047 4904 219 320 4051 CLKBUF_X3
* cell instance $6050 r0 *1 25.46,112
X$6050 219 14018 5416 5461 5290 320 DFF_X1
* cell instance $6051 m0 *1 28.69,112
X$6051 219 12883 5095 5242 4802 320 DFF_X1
* cell instance $6055 r0 *1 28.69,112
X$6055 5416 2842 5417 219 320 5558 MUX2_X1
* cell instance $6056 r0 *1 30.02,112
X$6056 5243 2842 5095 219 320 5346 MUX2_X1
* cell instance $6059 m0 *1 35.34,112
X$6059 219 13027 5297 5296 4990 320 DFF_X1
* cell instance $6061 m0 *1 39.14,112
X$6061 5099 3848 5348 219 320 5301 MUX2_X1
* cell instance $6064 m0 *1 41.23,112
X$6064 5094 3910 5348 219 320 5385 MUX2_X1
* cell instance $6065 m0 *1 42.56,112
X$6065 219 12615 5348 5385 4990 320 DFF_X1
* cell instance $6071 r0 *1 42.56,112
X$6071 5418 5464 4854 219 320 5419 NAND3_X2
* cell instance $6074 r0 *1 44.46,112
X$6074 219 14054 5465 5466 5710 320 DFF_X1
* cell instance $6075 m0 *1 50.16,112
X$6075 4906 320 2777 219 BUF_X4
* cell instance $6076 m0 *1 46.93,112
X$6076 219 12679 5389 5386 5388 320 DFF_X1
* cell instance $6078 m0 *1 52.25,112
X$6078 5102 320 4702 219 BUF_X4
* cell instance $6079 m0 *1 53.58,112
X$6079 5102 320 2731 219 BUF_X4
* cell instance $6082 r0 *1 47.69,112
X$6082 5420 4364 5465 219 320 5466 MUX2_X1
* cell instance $6083 r0 *1 49.02,112
X$6083 5389 3948 5420 219 320 5386 MUX2_X1
* cell instance $6084 r0 *1 50.35,112
X$6084 219 14206 5505 5468 5388 320 DFF_X1
* cell instance $6088 m0 *1 57.38,112
X$6088 4996 320 1567 219 BUF_X4
* cell instance $6089 m0 *1 56.05,112
X$6089 4996 320 2657 219 BUF_X4
* cell instance $6090 m0 *1 58.71,112
X$6090 4996 320 2772 219 BUF_X4
* cell instance $6091 m0 *1 60.04,112
X$6091 4996 320 4058 219 BUF_X4
* cell instance $6094 r0 *1 56.43,112
X$6094 5102 320 2714 219 BUF_X4
* cell instance $6095 r0 *1 57.76,112
X$6095 219 2904 5102 320 BUF_X16
* cell instance $6096 m0 *1 61.94,112
X$6096 5103 4490 5106 219 320 5246 MUX2_X1
* cell instance $6098 m0 *1 63.27,112
X$6098 219 13344 5105 5390 5107 320 DFF_X1
* cell instance $6099 m0 *1 66.5,112
X$6099 4611 4492 5105 219 320 5390 MUX2_X1
* cell instance $6107 r0 *1 67.26,112
X$6107 5421 320 2890 219 BUF_X4
* cell instance $6108 m0 *1 68.4,112
X$6108 219 13407 5392 5248 5108 320 DFF_X1
* cell instance $6110 m0 *1 71.63,112
X$6110 5103 4072 5349 219 320 5393 MUX2_X1
* cell instance $6117 r0 *1 68.97,112
X$6117 3910 320 3858 219 BUF_X4
* cell instance $6118 r0 *1 70.3,112
X$6118 5392 2957 5109 219 320 5001 MUX2_X1
* cell instance $6119 r0 *1 71.63,112
X$6119 3990 320 4072 219 BUF_X4
* cell instance $6124 r0 *1 83.22,112
X$6124 5350 5102 2029 219 320 NOR2_X4
* cell instance $6125 r0 *1 84.93,112
X$6125 219 13896 5422 5474 5112 320 DFF_X1
* cell instance $6126 r0 *1 88.16,112
X$6126 5511 4559 5422 219 320 5474 MUX2_X1
* cell instance $6129 r0 *1 90.06,112
X$6129 219 14436 5423 5476 5112 320 DFF_X1
* cell instance $6130 m0 *1 90.25,112
X$6130 3214 320 5350 219 BUF_X4
* cell instance $6136 r0 *1 93.67,112
X$6136 5514 4497 5425 219 320 5352 MUX2_X1
* cell instance $6137 m0 *1 94.43,112
X$6137 219 12739 5425 5352 5009 320 DFF_X1
* cell instance $6139 m0 *1 97.66,112
X$6139 3686 320 5421 219 BUF_X4
* cell instance $6140 m0 *1 98.99,112
X$6140 3214 5253 219 4566 320 NAND2_X4
* cell instance $6141 m0 *1 100.7,112
X$6141 5131 5379 320 219 5399 AND2_X1
* cell instance $6142 m0 *1 101.46,112
X$6142 219 13047 5402 5400 5009 320 DFF_X1
* cell instance $6145 m0 *1 105.64,112
X$6145 5402 320 2248 219 BUF_X4
* cell instance $6148 r0 *1 95,112
X$6148 219 13677 5516 5424 5426 320 DFF_X1
* cell instance $6151 r0 *1 99.37,112
X$6151 2244 5322 219 320 5477 XOR2_X1
* cell instance $6153 r0 *1 100.89,112
X$6153 5131 5347 320 219 5400 AND2_X1
* cell instance $6156 r0 *1 103.36,112
X$6156 5479 2750 219 320 4069 NAND2_X1
* cell instance $6159 r0 *1 105.64,112
X$6159 5328 5117 5252 219 320 5482 MUX2_X1
* cell instance $6160 r0 *1 106.97,112
X$6160 5131 5351 320 219 5483 AND2_X1
* cell instance $6162 r0 *1 107.92,112
X$6162 219 14036 5485 5483 5426 320 DFF_X1
* cell instance $6163 m0 *1 113.62,112
X$6163 5256 5353 5405 219 320 5354 MUX2_X1
* cell instance $6164 m0 *1 110.39,112
X$6164 219 12861 5256 5330 5426 320 DFF_X1
* cell instance $6165 m0 *1 114.95,112
X$6165 219 13083 5257 5331 5126 320 DFF_X1
* cell instance $6168 r0 *1 111.34,112
X$6168 4812 4559 5405 219 320 5583 MUX2_X1
* cell instance $6170 r0 *1 112.86,112
X$6170 219 14681 5427 5486 5519 320 DFF_X1
* cell instance $6171 r0 *1 116.09,112
X$6171 5427 3659 4917 219 320 5486 MUX2_X1
* cell instance $6173 r0 *1 117.61,112
X$6173 5485 320 2536 219 BUF_X4
* cell instance $6174 m0 *1 119.51,112
X$6174 5126 219 320 14727 INV_X1
* cell instance $6175 m0 *1 118.56,112
X$6175 5428 219 320 5126 CLKBUF_X3
* cell instance $6181 r0 *1 119.13,112
X$6181 5429 5353 5355 219 320 5589 MUX2_X1
* cell instance $6182 m0 *1 121.6,112
X$6182 219 13360 5355 5406 5126 320 DFF_X1
* cell instance $6183 m0 *1 120.27,112
X$6183 4917 3860 5355 219 320 5406 MUX2_X1
* cell instance $6184 m0 *1 124.83,112
X$6184 4917 4497 5356 219 320 5407 MUX2_X1
* cell instance $6187 r0 *1 120.46,112
X$6187 5429 3496 4917 219 320 5489 MUX2_X1
* cell instance $6188 r0 *1 121.79,112
X$6188 219 14045 5429 5489 5259 320 DFF_X1
* cell instance $6190 r0 *1 125.21,112
X$6190 4917 4163 5591 219 320 5430 MUX2_X1
* cell instance $6192 m0 *1 127.68,112
X$6192 219 12634 5356 5407 5259 320 DFF_X1
* cell instance $6193 m0 *1 127.3,112
X$6193 5259 219 320 14723 INV_X1
* cell instance $6194 m0 *1 130.91,112
X$6194 5014 4294 5261 219 320 5260 MUX2_X1
* cell instance $6199 r0 *1 131.67,112
X$6199 219 14374 5431 5490 5358 320 DFF_X1
* cell instance $6200 m0 *1 132.81,112
X$6200 5261 4136 5132 219 320 5357 MUX2_X1
* cell instance $6202 m0 *1 134.14,112
X$6202 5359 5357 219 320 5015 OR2_X1
* cell instance $6207 m0 *1 148.01,112
X$6207 5359 5360 219 320 5409 OR2_X1
* cell instance $6208 m0 *1 148.77,112
X$6208 5264 4921 5337 219 320 5408 MUX2_X1
* cell instance $6210 m0 *1 150.29,112
X$6210 219 12630 5339 5266 5531 320 DFF_X1
* cell instance $6211 m0 *1 153.52,112
X$6211 5409 4383 5267 320 219 4729 OAI21_X4
* cell instance $6214 m0 *1 158.27,112
X$6214 5532 4173 219 320 390 NOR2_X2
* cell instance $6216 m0 *1 159.98,112
X$6216 5410 4268 219 320 5411 NOR2_X1
* cell instance $6218 m0 *1 160.74,112
X$6218 4179 2440 3382 5362 320 219 5361 OAI22_X1
* cell instance $6220 m0 *1 163.21,112
X$6220 4472 3019 3391 5437 320 219 5495 OAI22_X1
* cell instance $6221 m0 *1 164.16,112
X$6221 4522 2440 3233 5362 320 219 5363 OAI22_X1
* cell instance $6226 r0 *1 134.9,112
X$6226 5432 4383 5491 320 219 5275 OAI21_X4
* cell instance $6230 r0 *1 146.87,112
X$6230 5433 4136 5529 219 320 5360 MUX2_X1
* cell instance $6234 r0 *1 154.85,112
X$6234 223 4625 5435 219 320 5436 MUX2_X1
* cell instance $6236 r0 *1 157.7,112
X$6236 5598 3966 3556 219 320 NOR2_X4
* cell instance $6238 r0 *1 159.6,112
X$6238 5410 4081 219 320 5498 NOR2_X1
* cell instance $6240 r0 *1 160.36,112
X$6240 4389 3019 5437 4400 320 219 5496 OAI22_X2
* cell instance $6242 r0 *1 162.45,112
X$6242 4301 3019 3337 5437 320 219 5597 OAI22_X1
* cell instance $6245 r0 *1 164.54,112
X$6245 5438 5495 5363 219 320 5494 NOR3_X1
* cell instance $6248 r0 *1 167.01,112
X$6248 5494 4687 219 320 3418 NOR2_X2
* cell instance $6252 r0 *1 169.29,112
X$6252 4180 320 3390 219 BUF_X4
* cell instance $6255 r0 *1 171.57,112
X$6255 5493 5439 5492 219 320 5487 NOR3_X1
* cell instance $6256 r0 *1 172.33,112
X$6256 3730 5440 3335 846 320 219 5492 OAI22_X1
* cell instance $6257 r0 *1 173.28,112
X$6257 4883 320 4396 219 BUF_X4
* cell instance $6258 m0 *1 174.04,112
X$6258 4308 320 4254 219 BUF_X4
* cell instance $6263 r0 *1 174.61,112
X$6263 4735 320 3337 219 BUF_X4
* cell instance $6267 r0 *1 175.94,112
X$6267 5487 5488 219 320 5303 NOR2_X2
* cell instance $6270 r0 *1 178.6,112
X$6270 3730 320 3513 219 BUF_X4
* cell instance $6276 m0 *1 7.79,128.8
X$6276 6452 219 320 6362 BUF_X1
* cell instance $6287 r0 *1 13.11,128.8
X$6287 219 13914 6405 6559 6899 320 DFF_X1
* cell instance $6288 m0 *1 16.53,128.8
X$6288 6092 219 320 CLKBUF_X1
* cell instance $6289 m0 *1 13.3,128.8
X$6289 219 13635 6363 6361 6092 320 DFF_X1
* cell instance $6290 m0 *1 17.1,128.8
X$6290 6362 6154 6485 219 320 6453 MUX2_X1
* cell instance $6292 m0 *1 18.62,128.8
X$6292 6524 2731 6485 219 320 6487 MUX2_X1
* cell instance $6294 r0 *1 16.34,128.8
X$6294 219 14520 6485 6453 6092 320 DFF_X1
* cell instance $6295 r0 *1 19.57,128.8
X$6295 6524 6207 6416 219 320 6561 MUX2_X1
* cell instance $6296 m0 *1 21.66,128.8
X$6296 6362 219 320 6416 CLKBUF_X2
* cell instance $6297 m0 *1 20.33,128.8
X$6297 6487 2659 6407 219 320 6367 MUX2_X1
* cell instance $6298 m0 *1 22.42,128.8
X$6298 6362 6156 6489 219 320 6409 MUX2_X1
* cell instance $6302 r0 *1 22.8,128.8
X$6302 6490 5801 6416 219 320 6525 MUX2_X1
* cell instance $6304 m0 *1 24.13,128.8
X$6304 6490 4058 6489 219 320 6412 MUX2_X1
* cell instance $6305 m0 *1 26.22,128.8
X$6305 219 13140 6454 6491 6157 320 DFF_X1
* cell instance $6306 m0 *1 29.45,128.8
X$6306 219 12844 6456 6526 6455 320 DFF_X1
* cell instance $6307 m0 *1 32.68,128.8
X$6307 219 13404 6567 6566 6455 320 DFF_X1
* cell instance $6308 m0 *1 35.91,128.8
X$6308 6416 5804 6366 219 320 6415 MUX2_X1
* cell instance $6311 r0 *1 24.51,128.8
X$6311 219 14370 6364 6562 6157 320 DFF_X1
* cell instance $6313 r0 *1 27.93,128.8
X$6313 6364 2772 6454 219 320 6563 MUX2_X1
* cell instance $6315 r0 *1 29.45,128.8
X$6315 6362 5933 6456 219 320 6526 MUX2_X1
* cell instance $6317 r0 *1 31.16,128.8
X$6317 6416 6046 6365 219 320 6565 MUX2_X1
* cell instance $6319 r0 *1 32.87,128.8
X$6319 6456 2657 6365 219 320 6264 MUX2_X1
* cell instance $6322 r0 *1 34.77,128.8
X$6322 6567 5864 6416 219 320 6566 MUX2_X1
* cell instance $6323 r0 *1 36.1,128.8
X$6323 6567 3848 6366 219 320 6263 MUX2_X1
* cell instance $6325 m0 *1 38.95,128.8
X$6325 219 13396 6417 6495 6115 320 DFF_X1
* cell instance $6326 m0 *1 37.62,128.8
X$6326 6416 5930 6369 219 320 6368 MUX2_X1
* cell instance $6327 m0 *1 42.18,128.8
X$6327 6494 4765 6500 219 320 6457 MUX2_X1
* cell instance $6328 m0 *1 43.51,128.8
X$6328 219 13221 6499 6569 6115 320 DFF_X1
* cell instance $6329 m0 *1 46.74,128.8
X$6329 6419 3950 6499 219 320 6500 MUX2_X1
* cell instance $6331 m0 *1 48.83,128.8
X$6331 6458 320 2963 219 BUF_X4
* cell instance $6334 m0 *1 53.39,128.8
X$6334 3679 219 320 6159 CLKBUF_X3
* cell instance $6335 m0 *1 54.34,128.8
X$6335 6159 219 320 14741 INV_X1
* cell instance $6340 r0 *1 40.85,128.8
X$6340 6417 6110 6416 219 320 6495 MUX2_X1
* cell instance $6342 r0 *1 42.94,128.8
X$6342 6457 3758 6367 219 320 6265 MUX2_X1
* cell instance $6343 r0 *1 44.27,128.8
X$6343 6416 6270 6499 219 320 6569 MUX2_X1
* cell instance $6346 r0 *1 47.31,128.8
X$6346 6458 320 1835 219 BUF_X4
* cell instance $6347 r0 *1 48.64,128.8
X$6347 6458 320 1510 219 BUF_X4
* cell instance $6348 r0 *1 49.97,128.8
X$6348 6370 6154 6571 219 320 6527 MUX2_X1
* cell instance $6349 r0 *1 51.3,128.8
X$6349 6458 320 4003 219 BUF_X4
* cell instance $6353 r0 *1 55.1,128.8
X$6353 6609 6207 6043 219 320 6657 MUX2_X1
* cell instance $6356 r0 *1 57,128.8
X$6356 219 14285 6505 6504 6267 320 DFF_X1
* cell instance $6357 m0 *1 57.57,128.8
X$6357 6505 5801 6043 219 320 6504 MUX2_X1
* cell instance $6361 m0 *1 59.85,128.8
X$6361 6505 2904 6459 219 320 6573 MUX2_X1
* cell instance $6366 r0 *1 60.99,128.8
X$6366 6573 6215 5077 320 219 6574 MUX2_X2
* cell instance $6367 r0 *1 62.7,128.8
X$6367 6575 1520 6576 219 320 6528 MUX2_X1
* cell instance $6371 r0 *1 64.03,128.8
X$6371 219 14248 6575 6610 6325 320 DFF_X1
* cell instance $6374 r0 *1 68.21,128.8
X$6374 6373 219 320 6325 CLKBUF_X3
* cell instance $6375 m0 *1 68.59,128.8
X$6375 6337 320 1640 219 BUF_X4
* cell instance $6378 m0 *1 70.68,128.8
X$6378 219 12812 6371 6507 6325 320 DFF_X1
* cell instance $6379 m0 *1 73.91,128.8
X$6379 219 13080 6460 6578 6427 320 DFF_X1
* cell instance $6380 m0 *1 77.14,128.8
X$6380 6371 2901 6460 219 320 6508 MUX2_X1
* cell instance $6381 m0 *1 78.47,128.8
X$6381 6372 2901 6579 219 320 6509 MUX2_X1
* cell instance $6383 m0 *1 79.99,128.8
X$6383 6508 6277 6509 219 320 6510 MUX2_X1
* cell instance $6386 m0 *1 83.6,128.8
X$6386 219 6510 6430 6374 6431 6223 320 OAI22_X4
* cell instance $6387 m0 *1 86.83,128.8
X$6387 6277 320 2095 219 BUF_X4
* cell instance $6391 r0 *1 69.16,128.8
X$6391 6325 219 320 CLKBUF_X1
* cell instance $6394 r0 *1 70.68,128.8
X$6394 6337 320 3758 219 BUF_X4
* cell instance $6396 r0 *1 73.53,128.8
X$6396 6043 5930 6460 219 320 6578 MUX2_X1
* cell instance $6397 r0 *1 74.86,128.8
X$6397 6043 6270 6579 219 320 6580 MUX2_X1
* cell instance $6398 r0 *1 76.19,128.8
X$6398 219 14676 6579 6580 6427 320 DFF_X1
* cell instance $6403 r0 *1 83.79,128.8
X$6403 219 14066 6613 6668 6053 320 DFF_X1
* cell instance $6406 r0 *1 87.97,128.8
X$6406 6164 4255 6529 219 320 6581 MUX2_X1
* cell instance $6407 r0 *1 89.3,128.8
X$6407 219 13885 6529 6581 6053 320 DFF_X1
* cell instance $6410 m0 *1 93.29,128.8
X$6410 219 13624 6583 6461 6273 320 DFF_X1
* cell instance $6414 r0 *1 93.1,128.8
X$6414 5678 3858 6583 219 320 6461 MUX2_X1
* cell instance $6418 r0 *1 95.76,128.8
X$6418 6529 6590 6583 219 320 6584 MUX2_X1
* cell instance $6420 r0 *1 97.47,128.8
X$6420 6337 320 2149 219 BUF_X4
* cell instance $6421 m0 *1 98.61,128.8
X$6421 6462 2149 6280 219 320 6376 MUX2_X1
* cell instance $6424 m0 *1 100.13,128.8
X$6424 5117 6512 320 219 6437 AND2_X1
* cell instance $6428 m0 *1 101.27,128.8
X$6428 2338 6512 219 320 6281 XOR2_X1
* cell instance $6429 m0 *1 102.6,128.8
X$6429 5479 320 4906 219 BUF_X4
* cell instance $6430 m0 *1 103.93,128.8
X$6430 2438 6462 219 320 6515 XOR2_X1
* cell instance $6431 m0 *1 105.07,128.8
X$6431 2471 6464 5819 320 6463 219 OAI21_X1
* cell instance $6433 m0 *1 106.02,128.8
X$6433 6515 5479 6463 6464 2471 6514 320 219 AOI221_X2
* cell instance $6435 r0 *1 101.84,128.8
X$6435 219 6585 5582 6618 6617 6574 320 OAI22_X4
* cell instance $6436 r0 *1 105.07,128.8
X$6436 2994 2861 5479 219 320 6677 NOR3_X1
* cell instance $6437 r0 *1 105.83,128.8
X$6437 219 6586 6676 4906 2867 320 AOI21_X4
* cell instance $6438 r0 *1 108.3,128.8
X$6438 5479 2757 2867 320 219 6678 AND3_X1
* cell instance $6440 m0 *1 108.49,128.8
X$6440 6464 5946 219 320 6440 NAND2_X1
* cell instance $6441 m0 *1 109.82,128.8
X$6441 2439 6516 320 219 6283 XNOR2_X1
* cell instance $6442 m0 *1 110.96,128.8
X$6442 219 13174 6588 6465 6145 320 DFF_X1
* cell instance $6447 r0 *1 110.77,128.8
X$6447 5941 4255 6588 219 320 6465 MUX2_X1
* cell instance $6448 r0 *1 112.1,128.8
X$6448 5820 3858 6681 219 320 6530 MUX2_X1
* cell instance $6452 m0 *1 118.56,128.8
X$6452 219 13229 6531 6518 6466 320 DFF_X1
* cell instance $6457 m0 *1 131.67,128.8
X$6457 219 13339 6381 6519 6058 320 DFF_X1
* cell instance $6458 m0 *1 134.9,128.8
X$6458 6245 4505 6381 219 320 6519 MUX2_X1
* cell instance $6461 m0 *1 137.18,128.8
X$6461 219 13162 6520 6593 6058 320 DFF_X1
* cell instance $6462 m0 *1 140.41,128.8
X$6462 6532 5828 6520 219 320 6467 MUX2_X1
* cell instance $6464 m0 *1 142.5,128.8
X$6464 3605 6467 219 320 6521 OR2_X1
* cell instance $6465 m0 *1 143.26,128.8
X$6465 6467 4921 6533 219 320 6447 MUX2_X1
* cell instance $6466 m0 *1 144.59,128.8
X$6466 6521 3746 6533 320 219 5834 OAI21_X4
* cell instance $6469 m0 *1 148.01,128.8
X$6469 3605 6625 219 320 6523 OR2_X1
* cell instance $6470 m0 *1 148.77,128.8
X$6470 219 5434 6468 6448 6383 6522 320 NOR4_X4
* cell instance $6472 m0 *1 155.23,128.8
X$6472 2438 6631 219 320 6384 XNOR2_X2
* cell instance $6475 m0 *1 160.36,128.8
X$6475 6287 4358 219 320 6470 NOR2_X1
* cell instance $6476 m0 *1 160.93,128.8
X$6476 6385 6449 6469 219 320 6797 NOR3_X1
* cell instance $6477 m0 *1 161.69,128.8
X$6477 4522 1365 3693 6257 320 219 6469 OAI22_X1
* cell instance $6478 m0 *1 162.64,128.8
X$6478 6259 4721 219 320 6386 NOR2_X1
* cell instance $6479 m0 *1 163.21,128.8
X$6479 6386 6387 6517 219 320 6633 NOR3_X1
* cell instance $6480 m0 *1 163.97,128.8
X$6480 4522 2158 3693 6297 320 219 6517 OAI22_X1
* cell instance $6481 m0 *1 164.92,128.8
X$6481 5919 4721 219 320 6388 NOR2_X1
* cell instance $6482 m0 *1 165.49,128.8
X$6482 6388 6389 6511 219 320 6698 NOR3_X1
* cell instance $6483 m0 *1 166.25,128.8
X$6483 5919 4358 219 320 6390 NOR2_X1
* cell instance $6484 m0 *1 166.82,128.8
X$6484 6390 6391 6513 219 320 6595 NOR3_X1
* cell instance $6485 m0 *1 167.58,128.8
X$6485 4511 2449 3608 5960 320 219 6513 OAI22_X1
* cell instance $6486 m0 *1 168.53,128.8
X$6486 6259 4358 219 320 6601 NOR2_X1
* cell instance $6487 m0 *1 169.1,128.8
X$6487 3871 2158 3608 6297 320 219 6600 OAI22_X1
* cell instance $6488 m0 *1 170.05,128.8
X$6488 3868 2158 3457 6297 320 219 6472 OAI22_X1
* cell instance $6489 m0 *1 171,128.8
X$6489 6728 2449 3233 5960 320 219 6511 OAI22_X1
* cell instance $6491 m0 *1 172.14,128.8
X$6491 6177 4173 219 320 6473 NOR2_X2
* cell instance $6492 m0 *1 173.09,128.8
X$6492 3781 6179 2105 3507 320 219 6393 OAI22_X2
* cell instance $6493 m0 *1 174.8,128.8
X$6493 3730 320 4631 219 BUF_X4
* cell instance $6497 r0 *1 118.94,128.8
X$6497 5727 3858 6531 219 320 6518 MUX2_X1
* cell instance $6501 r0 *1 120.27,128.8
X$6501 6444 6590 6531 219 320 6591 MUX2_X1
* cell instance $6510 r0 *1 136.99,128.8
X$6510 219 14497 6532 6592 6058 320 DFF_X1
* cell instance $6511 r0 *1 140.22,128.8
X$6511 6623 6719 6520 219 320 6593 MUX2_X1
* cell instance $6514 r0 *1 142.12,128.8
X$6514 2338 6596 219 320 6597 XNOR2_X2
* cell instance $6517 r0 *1 145.16,128.8
X$6517 219 6597 6062 6598 6695 6468 320 NAND4_X4
* cell instance $6520 r0 *1 149.15,128.8
X$6520 6523 3746 6534 320 219 5437 OAI21_X4
* cell instance $6523 r0 *1 152.19,128.8
X$6523 219 13864 6627 6535 6726 320 DFF_X1
* cell instance $6524 r0 *1 155.42,128.8
X$6524 219 14108 6628 6630 6063 320 DFF_X1
* cell instance $6527 r0 *1 160.93,128.8
X$6527 6287 4268 219 320 6699 NOR2_X1
* cell instance $6529 r0 *1 161.88,128.8
X$6529 4135 2545 4387 6295 320 219 6602 OAI22_X1
* cell instance $6530 r0 *1 162.83,128.8
X$6530 6470 6602 6604 219 320 6536 NOR3_X1
* cell instance $6532 r0 *1 163.78,128.8
X$6532 3871 1365 3608 6257 320 219 6604 OAI22_X1
* cell instance $6533 r0 *1 164.73,128.8
X$6533 3868 1365 3382 6257 320 219 6603 OAI22_X1
* cell instance $6537 r0 *1 168.15,128.8
X$6537 6259 4268 219 320 6599 NOR2_X1
* cell instance $6538 r0 *1 168.72,128.8
X$6538 6601 6471 6600 219 320 6537 NOR3_X1
* cell instance $6540 r0 *1 169.86,128.8
X$6540 6599 6438 6472 219 320 6594 NOR3_X1
* cell instance $6543 r0 *1 171.76,128.8
X$6543 6595 5533 219 320 6503 NOR2_X2
* cell instance $6544 r0 *1 172.71,128.8
X$6544 6594 4173 219 320 6587 NOR2_X2
* cell instance $6545 r0 *1 173.66,128.8
X$6545 6393 6434 219 320 6674 NOR2_X2
* cell instance $6547 r0 *1 174.99,128.8
X$6547 5898 320 3275 219 BUF_X4
* cell instance $6551 r0 *1 176.32,128.8
X$6551 5901 320 3565 219 BUF_X4
* cell instance $6552 m0 *1 177.46,128.8
X$6552 6187 320 3660 219 BUF_X4
* cell instance $6554 m0 *1 178.79,128.8
X$6554 6239 6506 6429 219 6484 320 AOI21_X2
* cell instance $6556 m0 *1 180.88,128.8
X$6556 6237 320 3271 219 BUF_X4
* cell instance $6558 m0 *1 182.4,128.8
X$6558 6237 320 4470 219 BUF_X4
* cell instance $6561 r0 *1 177.65,128.8
X$6561 6353 6539 219 320 6589 NAND2_X1
* cell instance $6563 r0 *1 178.6,128.8
X$6563 6239 320 4173 219 BUF_X4
* cell instance $6564 r0 *1 179.93,128.8
X$6564 6540 320 4389 219 BUF_X4
* cell instance $6565 r0 *1 181.26,128.8
X$6565 4464 219 320 6541 INV_X1
* cell instance $6566 r0 *1 181.64,128.8
X$6566 6541 320 6184 219 BUF_X4
* cell instance $6644 m0 *1 20.33,137.2
X$6644 6800 7014 6806 219 320 6968 MUX2_X1
* cell instance $6645 m0 *1 17.1,137.2
X$6645 219 13163 6800 6968 6899 320 DFF_X1
* cell instance $6648 r0 *1 17.1,137.2
X$6648 219 14061 7015 7122 6899 320 DFF_X1
* cell instance $6650 r0 *1 20.52,137.2
X$6650 3955 320 7014 219 BUF_X4
* cell instance $6651 r0 *1 21.85,137.2
X$6651 4445 320 6002 219 BUF_X4
* cell instance $6653 m0 *1 23.75,137.2
X$6653 6897 219 320 6806 CLKBUF_X2
* cell instance $6658 m0 *1 26.98,137.2
X$6658 4361 320 6902 219 BUF_X4
* cell instance $6661 r0 *1 24.89,137.2
X$6661 4359 320 6156 219 BUF_X4
* cell instance $6665 m0 *1 28.88,137.2
X$6665 219 12843 6905 6904 7236 320 DFF_X1
* cell instance $6667 m0 *1 32.11,137.2
X$6667 6806 7081 6907 219 320 6971 MUX2_X1
* cell instance $6671 m0 *1 40.47,137.2
X$6671 4006 320 6906 219 BUF_X4
* cell instance $6673 r0 *1 28.69,137.2
X$6673 6896 219 320 7182 BUF_X1
* cell instance $6675 r0 *1 30.78,137.2
X$6675 4237 320 6042 219 BUF_X4
* cell instance $6679 r0 *1 33.44,137.2
X$6679 4237 320 6802 219 BUF_X4
* cell instance $6684 r0 *1 39.14,137.2
X$6684 3993 320 6046 219 BUF_X4
* cell instance $6687 r0 *1 41.42,137.2
X$6687 6606 219 320 6908 CLKBUF_X3
* cell instance $6688 m0 *1 43.51,137.2
X$6688 6806 7016 6910 219 320 6975 MUX2_X1
* cell instance $6689 m0 *1 42.18,137.2
X$6689 3910 320 7081 219 BUF_X4
* cell instance $6692 r0 *1 42.37,137.2
X$6692 6908 219 320 CLKBUF_X1
* cell instance $6696 r0 *1 44.27,137.2
X$6696 7013 219 320 7017 BUF_X1
* cell instance $6698 r0 *1 46.36,137.2
X$6698 3947 320 7082 219 BUF_X4
* cell instance $6700 m0 *1 46.74,137.2
X$6700 3948 320 6909 219 BUF_X4
* cell instance $6703 m0 *1 48.45,137.2
X$6703 4364 320 6974 219 BUF_X4
* cell instance $6704 m0 *1 50.54,137.2
X$6704 4282 320 7016 219 BUF_X4
* cell instance $6706 m0 *1 54.91,137.2
X$6706 4006 320 5864 219 BUF_X4
* cell instance $6707 m0 *1 56.24,137.2
X$6707 219 13438 7022 7190 7023 320 DFF_X1
* cell instance $6708 m0 *1 59.47,137.2
X$6708 7022 1564 7128 219 320 6978 MUX2_X1
* cell instance $6713 r0 *1 49.02,137.2
X$6713 7017 5923 7018 219 320 7186 MUX2_X1
* cell instance $6714 r0 *1 50.35,137.2
X$6714 7017 6154 7020 219 320 7019 MUX2_X1
* cell instance $6717 r0 *1 52.82,137.2
X$6717 7241 2904 7018 219 320 7188 MUX2_X1
* cell instance $6718 r0 *1 54.15,137.2
X$6718 7242 2904 7020 219 320 7021 MUX2_X1
* cell instance $6721 r0 *1 56.05,137.2
X$6721 219 14571 7128 7191 7023 320 DFF_X1
* cell instance $6722 r0 *1 59.28,137.2
X$6722 219 14072 6705 6980 7023 320 DFF_X1
* cell instance $6723 m0 *1 62.13,137.2
X$6723 7024 7089 6705 219 320 6980 MUX2_X1
* cell instance $6726 m0 *1 63.65,137.2
X$6726 7024 7136 6911 219 320 7090 MUX2_X1
* cell instance $6729 r0 *1 62.51,137.2
X$6729 219 14349 6911 7090 7023 320 DFF_X1
* cell instance $6733 r0 *1 65.74,137.2
X$6733 219 14673 6912 6983 6914 320 DFF_X1
* cell instance $6735 m0 *1 66.12,137.2
X$6735 6612 7091 6912 219 320 6983 MUX2_X1
* cell instance $6737 r0 *1 68.97,137.2
X$6737 7093 320 3910 219 BUF_X4
* cell instance $6739 m0 *1 72.2,137.2
X$6739 4364 320 7025 219 BUF_X4
* cell instance $6740 m0 *1 70.87,137.2
X$6740 4361 320 6856 219 BUF_X4
* cell instance $6741 m0 *1 73.53,137.2
X$6741 6612 7027 6988 219 320 6989 MUX2_X1
* cell instance $6742 m0 *1 74.86,137.2
X$6742 6612 7026 6865 219 320 6990 MUX2_X1
* cell instance $6743 m0 *1 76.19,137.2
X$6743 3947 320 7027 219 BUF_X4
* cell instance $6747 m0 *1 81.51,137.2
X$6747 219 12810 6994 6916 6775 320 DFF_X1
* cell instance $6749 m0 *1 84.93,137.2
X$6749 7029 3491 2672 219 320 7030 NOR3_X1
* cell instance $6750 m0 *1 85.69,137.2
X$6750 6918 7030 7257 7099 219 320 7101 NOR4_X1
* cell instance $6754 r0 *1 71.25,137.2
X$6754 7130 320 4364 219 BUF_X4
* cell instance $6755 r0 *1 72.58,137.2
X$6755 7311 320 3947 219 BUF_X4
* cell instance $6758 r0 *1 74.48,137.2
X$6758 4282 320 7026 219 BUF_X4
* cell instance $6764 r0 *1 81.7,137.2
X$6764 219 14354 7028 7132 6775 320 DFF_X1
* cell instance $6765 r0 *1 84.93,137.2
X$6765 7097 4289 219 320 7199 NOR2_X1
* cell instance $6766 r0 *1 85.5,137.2
X$6766 7133 3491 2672 219 320 7098 NOR3_X1
* cell instance $6767 r0 *1 86.26,137.2
X$6767 7599 3919 219 320 7099 NOR2_X1
* cell instance $6769 r0 *1 87.21,137.2
X$6769 7371 3919 219 320 7135 NOR2_X1
* cell instance $6772 m0 *1 88.54,137.2
X$6772 6373 219 320 6775 CLKBUF_X3
* cell instance $6775 m0 *1 94.81,137.2
X$6775 6590 320 3766 219 BUF_X4
* cell instance $6776 m0 *1 96.14,137.2
X$6776 5077 320 4997 219 BUF_X4
* cell instance $6778 r0 *1 88.54,137.2
X$6778 219 14551 7031 7137 6775 320 DFF_X1
* cell instance $6779 r0 *1 91.77,137.2
X$6779 7100 7101 2750 320 219 6516 MUX2_X2
* cell instance $6781 r0 *1 94.24,137.2
X$6781 7203 2904 2998 320 7103 219 NOR3_X2
* cell instance $6784 r0 *1 96.71,137.2
X$6784 7259 2669 219 320 7104 NOR2_X1
* cell instance $6785 r0 *1 97.28,137.2
X$6785 219 7032 7033 7104 7103 6377 320 NOR4_X4
* cell instance $6786 m0 *1 98.04,137.2
X$6786 6997 2665 2752 320 7032 219 NOR3_X2
* cell instance $6789 m0 *1 100.13,137.2
X$6789 3595 5253 219 4127 320 OR2_X4
* cell instance $6791 r0 *1 100.7,137.2
X$6791 7107 2575 219 320 7033 NOR2_X1
* cell instance $6793 r0 *1 101.46,137.2
X$6793 7140 3365 7327 219 320 7107 MUX2_X1
* cell instance $6794 m0 *1 103.55,137.2
X$6794 6873 320 2575 219 BUF_X4
* cell instance $6795 m0 *1 102.22,137.2
X$6795 3491 320 5819 219 BUF_X4
* cell instance $6797 m0 *1 105.07,137.2
X$6797 219 12723 7034 7108 6919 320 DFF_X1
* cell instance $6800 m0 *1 109.25,137.2
X$6800 7000 6616 219 320 6921 NOR2_X1
* cell instance $6803 m0 *1 113.62,137.2
X$6803 5820 4492 7110 219 320 7036 MUX2_X1
* cell instance $6805 m0 *1 115.71,137.2
X$6805 219 13333 6923 6922 7037 320 DFF_X1
* cell instance $6808 r0 *1 105.83,137.2
X$6808 5941 4490 7034 219 320 7108 MUX2_X1
* cell instance $6810 r0 *1 107.54,137.2
X$6810 7111 6165 5515 320 6820 219 NOR3_X2
* cell instance $6812 r0 *1 109.63,137.2
X$6812 5941 4485 7035 219 320 7141 MUX2_X1
* cell instance $6814 r0 *1 111.72,137.2
X$6814 7110 5217 7035 219 320 7111 MUX2_X1
* cell instance $6817 r0 *1 113.62,137.2
X$6817 219 13700 7110 7036 7037 320 DFF_X1
* cell instance $6820 r0 *1 117.8,137.2
X$6820 219 14198 7038 7004 7037 320 DFF_X1
* cell instance $6824 m0 *1 119.51,137.2
X$6824 5727 4492 7038 219 320 7004 MUX2_X1
* cell instance $6829 r0 *1 121.03,137.2
X$6829 7038 6590 7142 219 320 7005 MUX2_X1
* cell instance $6837 r0 *1 132.43,137.2
X$6837 4505 320 6719 219 BUF_X4
* cell instance $6839 m0 *1 133.38,137.2
X$6839 4351 219 320 6724 CLKBUF_X3
* cell instance $6840 r0 *1 133.76,137.2
X$6840 4294 320 6622 219 BUF_X4
* cell instance $6842 m0 *1 134.71,137.2
X$6842 6884 6622 6926 219 320 7010 MUX2_X1
* cell instance $6844 r0 *1 135.47,137.2
X$6844 219 14425 6927 7012 7384 320 DFF_X1
* cell instance $6845 m0 *1 136.61,137.2
X$6845 6884 6719 6927 219 320 7012 MUX2_X1
* cell instance $6847 m0 *1 137.94,137.2
X$6847 6926 5828 6927 219 320 6826 MUX2_X1
* cell instance $6853 r0 *1 140.98,137.2
X$6853 219 14427 7039 7217 6291 320 DFF_X1
* cell instance $6854 m0 *1 143.64,137.2
X$6854 7144 5828 7040 219 320 6930 MUX2_X1
* cell instance $6856 m0 *1 144.97,137.2
X$6856 6929 4921 6930 219 320 6794 MUX2_X1
* cell instance $6857 m0 *1 146.3,137.2
X$6857 7042 4383 6930 320 219 6790 OAI21_X4
* cell instance $6858 m0 *1 148.77,137.2
X$6858 7113 219 320 5828 CLKBUF_X3
* cell instance $6860 r0 *1 144.21,137.2
X$6860 7041 5828 7039 219 320 6929 MUX2_X1
* cell instance $6861 r0 *1 145.54,137.2
X$6861 5359 6929 219 320 7042 OR2_X1
* cell instance $6863 r0 *1 146.49,137.2
X$6863 219 14494 6931 7112 7268 320 DFF_X1
* cell instance $6864 r0 *1 149.72,137.2
X$6864 6931 219 320 7113 BUF_X1
* cell instance $6866 m0 *1 150.1,137.2
X$6866 6931 219 320 7009 BUF_X1
* cell instance $6870 r0 *1 151.24,137.2
X$6870 5732 219 320 12515 INV_X4
* cell instance $6871 r0 *1 152.19,137.2
X$6871 7395 219 320 5732 CLKBUF_X3
* cell instance $6874 r0 *1 153.71,137.2
X$6874 7224 6622 7145 219 320 7227 MUX2_X1
* cell instance $6875 m0 *1 154.28,137.2
X$6875 6796 6622 6932 219 320 7008 MUX2_X1
* cell instance $6877 m0 *1 155.61,137.2
X$6877 6796 6691 7006 219 320 6933 MUX2_X1
* cell instance $6878 m0 *1 156.94,137.2
X$6878 6796 6719 6828 219 320 7115 MUX2_X1
* cell instance $6881 m0 *1 159.22,137.2
X$6881 219 13242 6828 7115 6726 320 DFF_X1
* cell instance $6886 r0 *1 156.18,137.2
X$6886 5732 219 320 6726 CLKBUF_X3
* cell instance $6891 r0 *1 162.83,137.2
X$6891 219 7116 5623 7043 6934 320 AOI21_X4
* cell instance $6892 m0 *1 165.68,137.2
X$6892 6936 7044 6516 219 7231 320 AOI21_X1
* cell instance $6893 m0 *1 164.35,137.2
X$6893 4596 320 3503 219 BUF_X4
* cell instance $6895 m0 *1 166.63,137.2
X$6895 3443 6889 6831 3335 320 219 7001 OAI22_X2
* cell instance $6896 m0 *1 168.34,137.2
X$6896 972 219 320 6831 BUF_X1
* cell instance $6898 r0 *1 165.3,137.2
X$6898 7045 5959 219 320 7043 NAND2_X1
* cell instance $6901 r0 *1 166.44,137.2
X$6901 7044 219 320 5959 CLKBUF_X3
* cell instance $6902 r0 *1 167.39,137.2
X$6902 3384 7275 3276 1213 320 219 7117 OAI22_X1
* cell instance $6903 r0 *1 168.34,137.2
X$6903 6935 7117 219 320 7049 NOR2_X1
* cell instance $6905 m0 *1 169.86,137.2
X$6905 4387 6939 3608 6940 320 219 7118 OAI22_X1
* cell instance $6906 m0 *1 169.29,137.2
X$6906 7120 6998 219 320 7146 NOR2_X1
* cell instance $6907 m0 *1 170.81,137.2
X$6907 5837 6939 3470 1025 320 219 7120 OAI22_X1
* cell instance $6908 m0 *1 171.76,137.2
X$6908 4387 6889 6941 3608 320 219 6944 OAI22_X2
* cell instance $6909 m0 *1 173.47,137.2
X$6909 3347 6942 6831 3276 320 219 7047 OAI22_X2
* cell instance $6910 m0 *1 175.18,137.2
X$6910 6943 6946 219 320 7048 NOR2_X1
* cell instance $6912 m0 *1 175.94,137.2
X$6912 7050 6947 219 320 6991 NOR2_X1
* cell instance $6915 r0 *1 169.86,137.2
X$6915 3347 6938 3276 1025 320 219 7119 OAI22_X1
* cell instance $6917 r0 *1 171,137.2
X$6917 7119 7118 219 320 7216 NOR2_X1
* cell instance $6918 r0 *1 171.57,137.2
X$6918 4459 6889 3457 6941 320 219 7220 OAI22_X1
* cell instance $6919 r0 *1 172.52,137.2
X$6919 4193 6942 3503 6831 320 219 7046 OAI22_X1
* cell instance $6920 r0 *1 173.47,137.2
X$6920 3788 6939 3383 1025 320 219 7050 OAI22_X1
* cell instance $6921 r0 *1 174.42,137.2
X$6921 7047 6944 219 320 7052 NOR2_X2
* cell instance $6925 r0 *1 175.37,137.2
X$6925 7045 6539 219 320 7114 NAND2_X1
* cell instance $6926 r0 *1 175.94,137.2
X$6926 7051 7114 6991 219 7079 320 AOI21_X2
* cell instance $6927 m0 *1 178.98,137.2
X$6927 7054 1769 6731 6949 219 320 7053 AOI22_X2
* cell instance $6928 m0 *1 176.89,137.2
X$6928 2532 6728 6790 5736 7053 6936 219 320 OAI221_X2
* cell instance $6929 m0 *1 180.69,137.2
X$6929 6186 6790 6984 2532 4389 320 219 6981 OAI221_X1
* cell instance $6930 m0 *1 181.83,137.2
X$6930 6951 1769 7106 6731 219 320 6952 AOI22_X1
* cell instance $6931 m0 *1 182.78,137.2
X$6931 6538 6790 6952 2532 4511 320 219 7109 OAI221_X1
* cell instance $6932 m0 *1 183.92,137.2
X$6932 6951 1134 7106 6474 219 320 6976 AOI22_X1
* cell instance $6934 r0 *1 177.27,137.2
X$6934 7045 6833 219 320 7215 NAND2_X1
* cell instance $6936 r0 *1 178.03,137.2
X$6936 7148 7149 7049 219 7080 320 AOI21_X2
* cell instance $6937 r0 *1 179.36,137.2
X$6937 7058 320 3276 219 BUF_X4
* cell instance $6938 r0 *1 180.69,137.2
X$6938 6673 219 320 7054 INV_X2
* cell instance $6939 r0 *1 181.26,137.2
X$6939 6981 6870 6516 219 7322 320 AOI21_X1
* cell instance $6942 r0 *1 182.97,137.2
X$6942 7109 6955 6516 219 7212 320 AOI21_X1
* cell instance $6943 r0 *1 183.73,137.2
X$6943 7151 2292 7102 6335 219 320 7056 AOI22_X1
* cell instance $6944 r0 *1 184.68,137.2
X$6944 7105 3608 219 320 7055 NAND2_X1
* cell instance $6946 m0 *1 186.01,137.2
X$6946 6954 219 320 6955 CLKBUF_X3
* cell instance $6947 m0 *1 185.25,137.2
X$6947 6953 6976 7056 219 320 7057 NAND3_X1
* cell instance $6950 m0 *1 190.19,137.2
X$6950 6956 4018 7059 320 219 7060 HA_X1
* cell instance $6952 m0 *1 192.28,137.2
X$6952 6395 219 320 6951 INV_X4
* cell instance $6955 r0 *1 185.44,137.2
X$6955 7055 7057 320 219 7087 AND2_X1
* cell instance $6958 r0 *1 187.91,137.2
X$6958 7058 320 3698 219 BUF_X4
* cell instance $6962 m0 *1 196.65,137.2
X$6962 7313 6394 6586 219 7096 320 AOI21_X1
* cell instance $6963 m0 *1 198.17,137.2
X$6963 7096 3725 219 320 6957 NOR2_X1
* cell instance $6964 m0 *1 198.74,137.2
X$6964 219 13325 7063 7198 7061 320 DFF_X1
* cell instance $6965 m0 *1 201.97,137.2
X$6965 7062 6080 7063 219 320 6735 MUX2_X1
* cell instance $6966 m0 *1 203.3,137.2
X$6966 7064 6080 7094 219 320 6776 MUX2_X1
* cell instance $6969 m0 *1 206.34,137.2
X$6969 6397 219 320 6080 BUF_X1
* cell instance $6972 m0 *1 207.86,137.2
X$6972 6958 6397 7287 219 320 6659 MUX2_X1
* cell instance $6973 m0 *1 209.19,137.2
X$6973 7156 6397 6959 219 320 6548 MUX2_X1
* cell instance $6974 m0 *1 210.52,137.2
X$6974 219 6397 320 6960 BUF_X8
* cell instance $6979 m0 *1 223.06,137.2
X$6979 7084 5445 7187 320 219 5843 OAI21_X4
* cell instance $6980 m0 *1 225.53,137.2
X$6980 5640 6969 219 320 7084 OR2_X1
* cell instance $6981 m0 *1 226.29,137.2
X$6981 219 12967 7068 6962 7067 320 DFF_X1
* cell instance $6984 r0 *1 198.36,137.2
X$6984 219 14345 7062 7200 7061 320 DFF_X1
* cell instance $6985 r0 *1 201.59,137.2
X$6985 219 14328 7064 7095 7061 320 DFF_X1
* cell instance $6986 r0 *1 204.82,137.2
X$6986 219 14334 7094 7092 7061 320 DFF_X1
* cell instance $6987 r0 *1 208.05,137.2
X$6987 7065 6860 7156 219 320 7197 MUX2_X1
* cell instance $6989 r0 *1 209.76,137.2
X$6989 7065 6843 6959 219 320 7196 MUX2_X1
* cell instance $6990 r0 *1 211.09,137.2
X$6990 6960 219 320 6961 BUF_X1
* cell instance $6992 r0 *1 214.7,137.2
X$6992 219 14055 7307 7194 7157 320 DFF_X1
* cell instance $6994 r0 *1 218.12,137.2
X$6994 7085 3419 7158 320 219 6948 OAI21_X4
* cell instance $6995 r0 *1 220.59,137.2
X$6995 5161 7086 219 7085 320 OR2_X4
* cell instance $6996 r0 *1 222.3,137.2
X$6996 7159 4530 7161 219 320 7086 MUX2_X1
* cell instance $6999 r0 *1 225.91,137.2
X$6999 219 13717 7163 7066 7067 320 DFF_X1
* cell instance $7002 r0 *1 229.71,137.2
X$7002 219 14174 7069 7083 7067 320 DFF_X1
* cell instance $7007 m0 *1 231.42,137.2
X$7007 6963 4531 7069 219 320 6969 MUX2_X1
* cell instance $7008 m0 *1 232.94,137.2
X$7008 5757 219 320 7067 CLKBUF_X3
* cell instance $7012 r0 *1 233.13,137.2
X$7012 219 13721 7070 7293 7067 320 DFF_X1
* cell instance $7013 m0 *1 236.36,137.2
X$7013 6957 219 320 6848 BUF_X1
* cell instance $7014 m0 *1 235.03,137.2
X$7014 6964 3880 7070 219 320 6745 MUX2_X1
* cell instance $7019 r0 *1 236.74,137.2
X$7019 7167 7176 7072 219 320 7071 MUX2_X1
* cell instance $7021 r0 *1 238.45,137.2
X$7021 7072 3071 7294 219 320 6754 MUX2_X1
* cell instance $7022 m0 *1 240.16,137.2
X$7022 7078 219 320 7073 BUF_X1
* cell instance $7023 m0 *1 239.59,137.2
X$7023 7079 219 320 7173 BUF_X1
* cell instance $7026 r0 *1 240.16,137.2
X$7026 7074 219 320 7164 BUF_X1
* cell instance $7028 m0 *1 8.93,165.2
X$7028 8786 7121 8787 219 320 8849 MUX2_X1
* cell instance $7029 m0 *1 5.7,165.2
X$7029 219 12610 8850 8785 8847 320 DFF_X1
* cell instance $7030 m0 *1 10.26,165.2
X$7030 8850 8788 8787 219 320 8853 MUX2_X1
* cell instance $7032 m0 *1 12.35,165.2
X$7032 219 12906 8789 8854 8680 320 DFF_X1
* cell instance $7033 m0 *1 15.58,165.2
X$7033 8786 7348 8789 219 320 8854 MUX2_X1
* cell instance $7034 m0 *1 16.91,165.2
X$7034 8680 219 320 14731 INV_X1
* cell instance $7035 m0 *1 17.29,165.2
X$7035 8546 8795 8789 219 320 8855 MUX2_X1
* cell instance $7038 m0 *1 25.46,165.2
X$7038 8682 5923 8857 219 320 8790 MUX2_X1
* cell instance $7040 m0 *1 27.55,165.2
X$7040 8550 8788 8857 219 320 8858 MUX2_X1
* cell instance $7041 m0 *1 28.88,165.2
X$7041 7172 219 320 8441 CLKBUF_X3
* cell instance $7044 r0 *1 5.7,165.2
X$7044 8786 7171 8850 219 320 8785 MUX2_X1
* cell instance $7048 r0 *1 7.03,165.2
X$7048 219 14612 8787 8849 8847 320 DFF_X1
* cell instance $7051 r0 *1 10.83,165.2
X$7051 8786 7123 8966 219 320 8848 MUX2_X1
* cell instance $7054 r0 *1 13.11,165.2
X$7054 9031 8791 8966 219 320 8967 MUX2_X1
* cell instance $7055 r0 *1 14.44,165.2
X$7055 8967 8792 8853 219 320 8972 MUX2_X1
* cell instance $7056 r0 *1 15.77,165.2
X$7056 8786 7232 8909 219 320 8907 MUX2_X1
* cell instance $7058 r0 *1 18.62,165.2
X$7058 8547 8908 8909 219 320 8910 MUX2_X1
* cell instance $7059 r0 *1 19.95,165.2
X$7059 8910 8860 8855 219 320 8969 MUX2_X1
* cell instance $7060 r0 *1 21.28,165.2
X$7060 8970 8262 8968 219 320 8911 MUX2_X1
* cell instance $7061 r0 *1 22.61,165.2
X$7061 8911 2719 8969 219 320 8918 MUX2_X1
* cell instance $7065 r0 *1 26.03,165.2
X$7065 8548 7016 8915 219 320 9032 MUX2_X1
* cell instance $7068 r0 *1 29.07,165.2
X$7068 8914 8913 8916 219 320 9033 MUX2_X1
* cell instance $7069 r0 *1 30.4,165.2
X$7069 8917 8867 8972 219 320 8919 MUX2_X1
* cell instance $7070 m0 *1 31.16,165.2
X$7070 8793 8792 8858 219 320 8869 MUX2_X1
* cell instance $7072 m0 *1 32.49,165.2
X$7072 219 13036 8794 8684 8441 320 DFF_X1
* cell instance $7073 m0 *1 35.72,165.2
X$7073 8682 6121 8864 219 320 8863 MUX2_X1
* cell instance $7075 m0 *1 37.24,165.2
X$7075 8794 8908 8731 219 320 8866 MUX2_X1
* cell instance $7078 m0 *1 40.28,165.2
X$7078 8685 8262 8866 219 320 9095 MUX2_X1
* cell instance $7080 m0 *1 43.13,165.2
X$7080 8797 8791 8686 219 320 8868 MUX2_X1
* cell instance $7081 m0 *1 44.46,165.2
X$7081 8552 5808 8797 219 320 8687 MUX2_X1
* cell instance $7085 m0 *1 49.78,165.2
X$7085 8798 6154 8688 219 320 8870 MUX2_X1
* cell instance $7086 m0 *1 51.11,165.2
X$7086 8555 8799 8688 219 320 8982 MUX2_X1
* cell instance $7092 r0 *1 33.06,165.2
X$7092 5946 320 9035 219 BUF_X4
* cell instance $7094 r0 *1 34.77,165.2
X$7094 219 13806 8864 8863 8554 320 DFF_X1
* cell instance $7095 r0 *1 38,165.2
X$7095 8442 8795 8864 219 320 8974 MUX2_X1
* cell instance $7097 r0 *1 40.85,165.2
X$7097 8554 219 320 14764 INV_X1
* cell instance $7098 r0 *1 41.23,165.2
X$7098 6606 219 320 8554 CLKBUF_X3
* cell instance $7099 r0 *1 42.18,165.2
X$7099 8975 8920 8868 219 320 8796 MUX2_X1
* cell instance $7100 r0 *1 43.51,165.2
X$7100 8796 8867 8869 219 320 8921 MUX2_X1
* cell instance $7103 r0 *1 47.12,165.2
X$7103 8798 5923 8922 219 320 8981 MUX2_X1
* cell instance $7106 r0 *1 49.02,165.2
X$7106 4702 320 8799 219 BUF_X4
* cell instance $7109 r0 *1 52.06,165.2
X$7109 8982 8792 8923 219 320 8878 MUX2_X1
* cell instance $7110 r0 *1 53.39,165.2
X$7110 4702 320 8791 219 BUF_X4
* cell instance $7111 m0 *1 54.91,165.2
X$7111 219 13075 8800 8872 8446 320 DFF_X1
* cell instance $7112 m0 *1 53.58,165.2
X$7112 8798 6121 8800 219 320 8872 MUX2_X1
* cell instance $7113 m0 *1 58.14,165.2
X$7113 8689 8795 8800 219 320 8801 MUX2_X1
* cell instance $7114 m0 *1 59.47,165.2
X$7114 8798 5933 8873 219 320 8874 MUX2_X1
* cell instance $7116 m0 *1 61.56,165.2
X$7116 219 12892 8690 8875 8804 320 DFF_X1
* cell instance $7117 m0 *1 64.79,165.2
X$7117 8640 8145 8691 219 320 8805 MUX2_X1
* cell instance $7121 m0 *1 70.11,165.2
X$7121 219 13000 8806 8877 8449 320 DFF_X1
* cell instance $7122 m0 *1 73.34,165.2
X$7122 8556 5930 8806 219 320 8877 MUX2_X1
* cell instance $7123 m0 *1 74.67,165.2
X$7123 8739 8799 8645 219 320 8807 MUX2_X1
* cell instance $7125 m0 *1 79.04,165.2
X$7125 8880 219 320 7924 CLKBUF_X2
* cell instance $7129 m0 *1 85.12,165.2
X$7129 219 12951 8812 8882 8809 320 DFF_X1
* cell instance $7130 m0 *1 88.35,165.2
X$7130 8811 7129 8812 219 320 8882 MUX2_X1
* cell instance $7137 r0 *1 58.33,165.2
X$7137 8798 219 320 8556 BUF_X2
* cell instance $7138 r0 *1 59.09,165.2
X$7138 9040 8860 8801 219 320 8802 MUX2_X1
* cell instance $7141 r0 *1 62.13,165.2
X$7141 8873 8729 8690 219 320 8803 MUX2_X1
* cell instance $7145 r0 *1 63.46,165.2
X$7145 8805 8262 8803 219 320 8983 MUX2_X1
* cell instance $7147 r0 *1 65.17,165.2
X$7147 8983 2719 8802 219 320 8924 MUX2_X1
* cell instance $7151 r0 *1 68.97,165.2
X$7151 4997 320 4765 219 BUF_X4
* cell instance $7153 r0 *1 70.68,165.2
X$7153 219 14484 8984 8925 8449 320 DFF_X1
* cell instance $7154 r0 *1 73.91,165.2
X$7154 8926 219 320 8449 CLKBUF_X3
* cell instance $7155 r0 *1 74.86,165.2
X$7155 8985 8920 8807 219 320 8808 MUX2_X1
* cell instance $7156 r0 *1 76.19,165.2
X$7156 8808 8927 8878 219 320 8986 MUX2_X1
* cell instance $7157 r0 *1 77.52,165.2
X$7157 8924 8986 5946 320 219 8484 MUX2_X2
* cell instance $7161 r0 *1 80.56,165.2
X$7161 6337 320 8927 219 BUF_X4
* cell instance $7165 r0 *1 84.36,165.2
X$7165 8811 7243 8810 219 320 8988 MUX2_X1
* cell instance $7166 r0 *1 85.69,165.2
X$7166 219 14514 8810 8988 8809 320 DFF_X1
* cell instance $7170 r0 *1 90.25,165.2
X$7170 8811 7136 8928 219 320 8989 MUX2_X1
* cell instance $7171 r0 *1 91.58,165.2
X$7171 219 14179 8928 8989 8809 320 DFF_X1
* cell instance $7172 m0 *1 94.05,165.2
X$7172 8811 7089 8694 219 320 8813 MUX2_X1
* cell instance $7174 m0 *1 95.38,165.2
X$7174 8811 219 320 8559 BUF_X2
* cell instance $7177 m0 *1 98.42,165.2
X$7177 8883 7492 8559 219 320 8814 MUX2_X1
* cell instance $7179 m0 *1 101.27,165.2
X$7179 8883 6057 9109 219 320 8884 MUX2_X1
* cell instance $7184 m0 *1 112.67,165.2
X$7184 8999 8121 8816 219 320 8815 MUX2_X1
* cell instance $7186 m0 *1 114.19,165.2
X$7186 8816 8458 8817 219 320 8886 MUX2_X1
* cell instance $7187 m0 *1 115.52,165.2
X$7187 8456 219 320 CLKBUF_X1
* cell instance $7188 m0 *1 116.09,165.2
X$7188 8818 8886 7607 320 219 8468 MUX2_X2
* cell instance $7190 m0 *1 119.32,165.2
X$7190 219 13612 8747 8698 8819 320 DFF_X1
* cell instance $7195 r0 *1 94.81,165.2
X$7195 1282 219 320 9302 CLKBUF_X3
* cell instance $7197 r0 *1 95.95,165.2
X$7197 8928 6057 8929 219 320 8563 MUX2_X1
* cell instance $7200 r0 *1 98.42,165.2
X$7200 219 14667 8883 8814 8992 320 DFF_X1
* cell instance $7201 r0 *1 101.65,165.2
X$7201 8559 7025 8930 219 320 8993 MUX2_X1
* cell instance $7202 r0 *1 102.98,165.2
X$7202 219 14533 8930 8993 8992 320 DFF_X1
* cell instance $7203 r0 *1 106.21,165.2
X$7203 8930 6057 9111 219 320 8994 MUX2_X1
* cell instance $7205 r0 *1 110.58,165.2
X$7205 8999 8278 8998 219 320 8997 MUX2_X1
* cell instance $7206 r0 *1 111.91,165.2
X$7206 219 14143 8931 9000 8456 320 DFF_X1
* cell instance $7207 r0 *1 115.14,165.2
X$7207 8998 8458 8931 219 320 8818 MUX2_X1
* cell instance $7214 r0 *1 120.08,165.2
X$7214 8932 8166 9004 219 320 9003 MUX2_X1
* cell instance $7215 r0 *1 121.41,165.2
X$7215 9042 7501 9004 219 320 9006 MUX2_X1
* cell instance $7221 r0 *1 127.49,165.2
X$7221 219 14525 8822 9007 9045 320 DFF_X1
* cell instance $7223 m0 *1 128.25,165.2
X$7223 8820 8821 8822 219 320 9007 MUX2_X1
* cell instance $7225 m0 *1 131.86,165.2
X$7225 219 7723 8458 320 BUF_X32
* cell instance $7228 r0 *1 130.72,165.2
X$7228 8822 7501 8933 219 320 9008 MUX2_X1
* cell instance $7232 r0 *1 133.38,165.2
X$7232 7723 320 4136 219 BUF_X4
* cell instance $7233 r0 *1 134.71,165.2
X$7233 4377 320 8040 219 BUF_X4
* cell instance $7235 r0 *1 136.42,165.2
X$7235 9010 8821 8573 219 320 8462 MUX2_X1
* cell instance $7236 r0 *1 137.75,165.2
X$7236 9158 4136 9120 219 320 8666 MUX2_X1
* cell instance $7237 r0 *1 139.08,165.2
X$7237 9010 8699 8463 219 320 8753 MUX2_X1
* cell instance $7240 r0 *1 142.12,165.2
X$7240 8669 7612 9013 219 320 9012 MUX2_X1
* cell instance $7241 m0 *1 145.54,165.2
X$7241 8823 4136 9013 219 320 8466 MUX2_X1
* cell instance $7242 m0 *1 142.31,165.2
X$7242 219 13335 8823 8891 8465 320 DFF_X1
* cell instance $7243 m0 *1 146.87,165.2
X$7243 5428 219 320 8465 CLKBUF_X3
* cell instance $7244 m0 *1 147.82,165.2
X$7244 8660 219 320 8899 INV_X1
* cell instance $7246 m0 *1 148.96,165.2
X$7246 8293 219 320 8824 INV_X1
* cell instance $7247 m0 *1 149.34,165.2
X$7247 8659 8363 8894 320 219 8897 HA_X1
* cell instance $7248 m0 *1 151.24,165.2
X$7248 8897 219 320 8826 INV_X1
* cell instance $7249 m0 *1 151.62,165.2
X$7249 8900 8825 8826 219 8759 320 AOI21_X1
* cell instance $7250 m0 *1 152.38,165.2
X$7250 8709 8899 8825 320 219 8900 HA_X1
* cell instance $7252 m0 *1 154.47,165.2
X$7252 7147 219 320 8828 INV_X1
* cell instance $7253 m0 *1 154.85,165.2
X$7253 8523 8828 8934 320 219 8830 HA_X1
* cell instance $7254 m0 *1 156.75,165.2
X$7254 8901 8704 8829 219 8937 320 AOI21_X1
* cell instance $7256 m0 *1 159.03,165.2
X$7256 8575 8905 8477 219 9521 320 AOI21_X2
* cell instance $7257 m0 *1 160.36,165.2
X$7257 8484 2866 219 320 8905 NAND2_X1
* cell instance $7258 m0 *1 160.93,165.2
X$7258 8575 8904 8436 219 8903 320 AOI21_X2
* cell instance $7260 m0 *1 162.45,165.2
X$7260 8575 8706 8373 219 8902 320 AOI21_X2
* cell instance $7262 r0 *1 143.45,165.2
X$7262 219 14659 9013 9012 8465 320 DFF_X1
* cell instance $7266 r0 *1 148.77,165.2
X$7266 8894 8825 8701 9016 219 320 9125 NAND4_X1
* cell instance $7267 r0 *1 149.72,165.2
X$7267 8470 8824 9016 320 219 8827 HA_X1
* cell instance $7268 r0 *1 151.62,165.2
X$7268 8827 9016 9018 219 9128 320 AOI21_X1
* cell instance $7270 r0 *1 153.9,165.2
X$7270 8829 8935 8934 8703 219 9019 320 NAND4_X2
* cell instance $7271 r0 *1 155.61,165.2
X$7271 8318 8936 8829 320 219 8901 HA_X1
* cell instance $7272 r0 *1 157.51,165.2
X$7272 8832 9022 8935 320 219 8938 HA_X1
* cell instance $7276 r0 *1 161.5,165.2
X$7276 7624 5959 219 320 8904 NAND2_X1
* cell instance $7277 r0 *1 162.07,165.2
X$7277 8575 9025 8879 219 9023 320 AOI21_X2
* cell instance $7278 r0 *1 163.4,165.2
X$7278 8660 2866 219 320 9025 NAND2_X1
* cell instance $7281 m0 *1 164.16,165.2
X$7281 5623 320 8575 219 BUF_X4
* cell instance $7283 r0 *1 164.54,165.2
X$7283 9028 320 6068 219 BUF_X4
* cell instance $7285 m0 *1 166.06,165.2
X$7285 972 8523 8708 320 219 8898 HA_X1
* cell instance $7288 m0 *1 168.15,165.2
X$7288 8543 8893 8675 320 219 8940 OAI21_X2
* cell instance $7289 m0 *1 169.48,165.2
X$7289 8832 1449 8577 320 219 9024 HA_X1
* cell instance $7291 r0 *1 166.63,165.2
X$7291 8895 8831 219 9130 320 OR2_X4
* cell instance $7292 r0 *1 168.34,165.2
X$7292 8940 8941 320 219 9027 AND2_X2
* cell instance $7293 r0 *1 169.29,165.2
X$7293 8898 9026 9024 219 8896 320 AOI21_X1
* cell instance $7294 r0 *1 170.05,165.2
X$7294 8895 8831 219 320 9054 NOR2_X1
* cell instance $7296 r0 *1 171,165.2
X$7296 9014 7044 8479 219 9280 320 AOI21_X1
* cell instance $7299 m0 *1 171.76,165.2
X$7299 8784 8582 8892 219 8893 320 AOI21_X1
* cell instance $7302 m0 *1 177.27,165.2
X$7302 8890 320 6540 219 BUF_X4
* cell instance $7306 r0 *1 173.09,165.2
X$7306 5736 8942 9020 8944 3730 320 219 9179 OAI221_X1
* cell instance $7307 r0 *1 174.23,165.2
X$7307 7679 4767 8049 3734 219 320 9020 AOI22_X1
* cell instance $7312 r0 *1 175.37,165.2
X$7312 7462 8942 8944 5898 320 219 8945 OAI22_X2
* cell instance $7314 r0 *1 177.84,165.2
X$7314 7522 8944 9015 8942 6020 320 219 9011 OAI221_X1
* cell instance $7315 r0 *1 178.98,165.2
X$7315 7849 4767 6982 3734 219 320 9015 AOI22_X1
* cell instance $7316 m0 *1 179.17,165.2
X$7316 8576 6539 219 320 8889 NAND2_X1
* cell instance $7319 m0 *1 179.93,165.2
X$7319 8476 6635 8576 219 8888 320 AOI21_X1
* cell instance $7320 m0 *1 180.69,165.2
X$7320 4010 6728 8588 5736 8887 9014 219 320 OAI221_X2
* cell instance $7321 m0 *1 182.78,165.2
X$7321 7054 8710 8670 6949 219 320 8887 AOI22_X2
* cell instance $7323 m0 *1 185.25,165.2
X$7323 8714 6951 8833 8713 7151 9062 320 219 AOI221_X2
* cell instance $7325 m0 *1 187.53,165.2
X$7325 219 8859 7148 8885 8715 320 AOI21_X4
* cell instance $7327 m0 *1 190.19,165.2
X$7327 8660 2810 219 320 9002 NAND2_X1
* cell instance $7328 m0 *1 190.76,165.2
X$7328 8052 8835 8735 6540 320 219 8834 OAI22_X2
* cell instance $7330 m0 *1 192.66,165.2
X$7330 8836 8049 8881 8746 8060 8879 320 219 AOI221_X2
* cell instance $7332 m0 *1 194.94,165.2
X$7332 1020 219 320 8836 INV_X1
* cell instance $7333 m0 *1 195.32,165.2
X$7333 7782 3788 7952 4586 8717 8876 219 320 OAI221_X2
* cell instance $7335 m0 *1 197.6,165.2
X$7335 7522 8835 8837 1020 8324 320 219 8838 OAI221_X1
* cell instance $7338 m0 *1 201.02,165.2
X$7338 219 8871 8720 8722 9067 320 NOR3_X4
* cell instance $7339 m0 *1 203.68,165.2
X$7339 8832 4442 8604 320 219 8721 HA_X1
* cell instance $7345 r0 *1 179.93,165.2
X$7345 6538 8942 8944 8001 320 219 9117 OAI22_X2
* cell instance $7346 r0 *1 181.64,165.2
X$7346 8888 5570 219 320 9009 NOR2_X2
* cell instance $7349 r0 *1 183.54,165.2
X$7349 8711 6870 8479 219 9001 320 AOI21_X1
* cell instance $7351 r0 *1 184.49,165.2
X$7351 6685 8588 8946 5841 320 219 8712 OAI22_X2
* cell instance $7352 r0 *1 186.2,165.2
X$7352 7945 8588 8946 8001 320 219 8833 OAI22_X2
* cell instance $7355 r0 *1 189.81,165.2
X$7355 2808 9002 8996 219 8976 320 AOI21_X2
* cell instance $7356 r0 *1 191.14,165.2
X$7356 8746 8123 8834 8836 7406 8996 320 219 AOI221_X2
* cell instance $7357 r0 *1 193.23,165.2
X$7357 7845 8835 8735 7735 320 219 8995 OAI22_X2
* cell instance $7359 r0 *1 195.13,165.2
X$7359 8991 4239 8948 7058 8990 8063 219 320 OAI221_X2
* cell instance $7361 r0 *1 197.98,165.2
X$7361 8838 8115 8660 219 8950 320 AOI21_X1
* cell instance $7364 r0 *1 200.64,165.2
X$7364 4770 4336 219 320 8987 OR2_X1
* cell instance $7366 r0 *1 201.78,165.2
X$7366 8670 219 320 8946 INV_X2
* cell instance $7367 r0 *1 202.35,165.2
X$7367 4336 4770 219 320 8951 NOR2_X2
* cell instance $7373 r0 *1 214.89,165.2
X$7373 219 14116 8839 8865 8953 320 DFF_X1
* cell instance $7374 m0 *1 217.55,165.2
X$7374 8979 7749 8839 219 320 8865 MUX2_X1
* cell instance $7376 m0 *1 218.88,165.2
X$7376 219 7957 320 5369 BUF_X8
* cell instance $7378 m0 *1 222.11,165.2
X$7378 219 12774 8955 8862 8314 320 DFF_X1
* cell instance $7382 r0 *1 218.12,165.2
X$7382 9096 7539 8978 219 320 8954 MUX2_X1
* cell instance $7383 r0 *1 219.45,165.2
X$7383 8979 7753 8977 219 320 8980 MUX2_X1
* cell instance $7385 r0 *1 220.97,165.2
X$7385 8861 320 5640 219 BUF_X4
* cell instance $7388 r0 *1 223.25,165.2
X$7388 9189 7751 8955 219 320 8862 MUX2_X1
* cell instance $7391 r0 *1 225.15,165.2
X$7391 9090 7539 8955 219 320 8956 MUX2_X1
* cell instance $7392 r0 *1 226.48,165.2
X$7392 8861 219 320 6410 CLKBUF_X3
* cell instance $7394 r0 *1 227.81,165.2
X$7394 8957 7420 8958 219 320 8973 MUX2_X1
* cell instance $7395 m0 *1 231.23,165.2
X$7395 8841 7751 8611 219 320 8728 MUX2_X1
* cell instance $7396 m0 *1 228,165.2
X$7396 219 12827 8840 8856 8501 320 DFF_X1
* cell instance $7397 m0 *1 232.56,165.2
X$7397 8841 7750 8840 219 320 8856 MUX2_X1
* cell instance $7398 m0 *1 233.89,165.2
X$7398 8959 7539 8842 219 320 8971 MUX2_X1
* cell instance $7399 m0 *1 235.22,165.2
X$7399 5757 219 320 8501 CLKBUF_X3
* cell instance $7400 m0 *1 236.17,165.2
X$7400 219 13061 8852 8843 8844 320 DFF_X1
* cell instance $7401 m0 *1 239.4,165.2
X$7401 8724 219 320 6553 BUF_X1
* cell instance $7402 m0 *1 239.97,165.2
X$7402 9086 219 320 8846 BUF_X1
* cell instance $7407 r0 *1 229.71,165.2
X$7407 219 14237 8842 8851 8501 320 DFF_X1
* cell instance $7412 r0 *1 233.13,165.2
X$7412 8960 7957 8971 320 219 8482 OAI21_X4
* cell instance $7413 r0 *1 235.6,165.2
X$7413 8841 7749 8852 219 320 8843 MUX2_X1
* cell instance $7414 r0 *1 236.93,165.2
X$7414 8961 7291 8842 219 320 8851 MUX2_X1
* cell instance $7415 r0 *1 238.26,165.2
X$7415 8961 7176 8962 219 320 9085 MUX2_X1
* cell instance $7417 r0 *1 239.78,165.2
X$7417 8963 219 320 8669 BUF_X2
* cell instance $7420 m0 *1 7.41,187.6
X$7420 10028 7232 10334 219 320 10514 MUX2_X1
* cell instance $7422 m0 *1 8.74,187.6
X$7422 219 12625 10335 10382 10127 320 DFF_X1
* cell instance $7423 m0 *1 11.97,187.6
X$7423 10335 9287 10334 219 320 10387 MUX2_X1
* cell instance $7425 m0 *1 13.49,187.6
X$7425 10028 219 320 9852 BUF_X2
* cell instance $7426 m0 *1 14.25,187.6
X$7426 10028 7348 10336 219 320 10276 MUX2_X1
* cell instance $7429 m0 *1 16.53,187.6
X$7429 10432 8795 10336 219 320 10517 MUX2_X1
* cell instance $7430 m0 *1 17.86,187.6
X$7430 10387 9527 10517 219 320 10170 MUX2_X1
* cell instance $7434 m0 *1 23.94,187.6
X$7434 219 12575 10337 10519 9941 320 DFF_X1
* cell instance $7436 m0 *1 27.36,187.6
X$7436 10433 7016 10435 219 320 10521 MUX2_X1
* cell instance $7437 m0 *1 28.69,187.6
X$7437 10337 8799 10224 219 320 10393 MUX2_X1
* cell instance $7439 m0 *1 30.78,187.6
X$7439 10225 8867 10667 219 320 10394 MUX2_X1
* cell instance $7441 m0 *1 33.63,187.6
X$7441 10032 6974 10227 219 320 10338 MUX2_X1
* cell instance $7443 m0 *1 35.15,187.6
X$7443 10032 7016 10436 219 320 10398 MUX2_X1
* cell instance $7444 m0 *1 36.48,187.6
X$7444 10227 9101 10436 219 320 10525 MUX2_X1
* cell instance $7447 m0 *1 38.76,187.6
X$7447 10339 8920 10525 219 320 10437 MUX2_X1
* cell instance $7448 m0 *1 40.09,187.6
X$7448 10437 8867 10727 219 320 10404 MUX2_X1
* cell instance $7449 m0 *1 41.42,187.6
X$7449 10340 10404 9035 320 219 8479 MUX2_X2
* cell instance $7452 m0 *1 45.41,187.6
X$7452 10341 7177 10342 219 320 10407 MUX2_X1
* cell instance $7455 m0 *1 47.69,187.6
X$7455 10341 219 320 9944 BUF_X2
* cell instance $7458 m0 *1 49.4,187.6
X$7458 10343 7014 9944 219 320 10526 MUX2_X1
* cell instance $7459 m0 *1 50.73,187.6
X$7459 219 12868 10343 10526 9865 320 DFF_X1
* cell instance $7463 m0 *1 59.28,187.6
X$7463 10185 7243 10441 219 320 10528 MUX2_X1
* cell instance $7478 r0 *1 7.79,187.6
X$7478 219 14639 10334 10514 10127 320 DFF_X1
* cell instance $7481 r0 *1 12.16,187.6
X$7481 9526 219 320 10127 CLKBUF_X3
* cell instance $7485 r0 *1 15.77,187.6
X$7485 9852 6802 10432 219 320 10516 MUX2_X1
* cell instance $7490 r0 *1 22.8,187.6
X$7490 9762 219 320 9526 CLKBUF_X3
* cell instance $7491 r0 *1 23.75,187.6
X$7491 9526 219 320 14799 CLKBUF_X3
* cell instance $7494 r0 *1 25.65,187.6
X$7494 10433 6974 10520 219 320 10434 MUX2_X1
* cell instance $7496 r0 *1 27.36,187.6
X$7496 10520 9101 10435 219 320 10173 MUX2_X1
* cell instance $7497 r0 *1 28.69,187.6
X$7497 219 14634 10435 10521 10562 320 DFF_X1
* cell instance $7501 r0 *1 34.01,187.6
X$7501 219 14218 10436 10398 9942 320 DFF_X1
* cell instance $7504 r0 *1 43.7,187.6
X$7504 10563 6902 9944 219 320 10621 MUX2_X1
* cell instance $7506 r0 *1 46.55,187.6
X$7506 9944 6802 10438 219 320 10623 MUX2_X1
* cell instance $7509 r0 *1 49.59,187.6
X$7509 10438 8913 10835 219 320 10439 MUX2_X1
* cell instance $7514 r0 *1 53.77,187.6
X$7514 10343 5005 10626 219 320 10440 MUX2_X1
* cell instance $7515 r0 *1 55.1,187.6
X$7515 10440 9207 10869 219 320 10344 MUX2_X1
* cell instance $7517 r0 *1 56.81,187.6
X$7517 219 14223 10441 10528 10671 320 DFF_X1
* cell instance $7518 r0 *1 60.04,187.6
X$7518 10441 9101 10442 219 320 10345 MUX2_X1
* cell instance $7520 m0 *1 60.99,187.6
X$7520 10443 7490 10288 219 320 10289 MUX2_X1
* cell instance $7521 m0 *1 62.51,187.6
X$7521 10412 8792 10346 219 320 10416 MUX2_X1
* cell instance $7527 r0 *1 62.7,187.6
X$7527 10185 219 320 9537 BUF_X2
* cell instance $7536 m0 *1 68.21,187.6
X$7536 10443 7136 10228 219 320 10414 MUX2_X1
* cell instance $7537 m0 *1 64.98,187.6
X$7537 219 13369 10137 10295 10135 320 DFF_X1
* cell instance $7539 r0 *1 65.74,187.6
X$7539 8926 219 320 10135 CLKBUF_X3
* cell instance $7542 m0 *1 69.92,187.6
X$7542 9947 7091 10296 219 320 10415 MUX2_X1
* cell instance $7543 m0 *1 72.77,187.6
X$7543 10424 8867 10416 219 320 10417 MUX2_X1
* cell instance $7548 m0 *1 77.33,187.6
X$7548 219 13343 10444 10418 9767 320 DFF_X1
* cell instance $7549 m0 *1 76,187.6
X$7549 10444 7312 9947 219 320 10418 MUX2_X1
* cell instance $7550 m0 *1 80.56,187.6
X$7550 10444 8913 10229 219 320 10421 MUX2_X1
* cell instance $7555 r0 *1 78.28,187.6
X$7555 8926 219 320 9767 CLKBUF_X3
* cell instance $7558 m0 *1 83.03,187.6
X$7558 10529 7136 10298 219 320 10425 MUX2_X1
* cell instance $7561 m0 *1 85.69,187.6
X$7561 10529 7490 10348 219 320 10427 MUX2_X1
* cell instance $7563 m0 *1 87.02,187.6
X$7563 219 13338 10348 10427 10347 320 DFF_X1
* cell instance $7564 m0 *1 90.25,187.6
X$7564 10204 5005 10348 219 320 10445 MUX2_X1
* cell instance $7571 r0 *1 90.25,187.6
X$7571 10445 9207 10530 219 320 10301 MUX2_X1
* cell instance $7575 r0 *1 105.26,187.6
X$7575 219 14007 10446 10531 9772 320 DFF_X1
* cell instance $7576 m0 *1 106.21,187.6
X$7576 10532 10429 10349 6675 10431 10430 219 320 OAI221_X2
* cell instance $7577 m0 *1 105.64,187.6
X$7577 10532 10429 219 320 10428 NOR2_X1
* cell instance $7578 m0 *1 108.3,187.6
X$7578 10446 10429 219 320 10431 NAND2_X1
* cell instance $7581 m0 *1 109.82,187.6
X$7581 3264 10350 320 219 10447 AND2_X1
* cell instance $7582 m0 *1 110.58,187.6
X$7582 9797 10043 10533 219 320 10350 MUX2_X1
* cell instance $7583 m0 *1 111.91,187.6
X$7583 9999 10535 219 320 10232 NAND2_X1
* cell instance $7585 r0 *1 108.49,187.6
X$7585 10635 219 320 10532 INV_X1
* cell instance $7588 r0 *1 109.44,187.6
X$7588 219 14563 10234 10447 9920 320 DFF_X1
* cell instance $7589 r0 *1 112.67,187.6
X$7589 10535 7820 219 320 10448 NOR2_X1
* cell instance $7590 m0 *1 113.05,187.6
X$7590 10234 10351 219 320 10533 XOR2_X1
* cell instance $7592 m0 *1 114.19,187.6
X$7592 10352 10142 2293 219 10535 320 AOI21_X1
* cell instance $7593 m0 *1 114.95,187.6
X$7593 10353 10142 219 320 10352 NOR2_X1
* cell instance $7594 m0 *1 115.52,187.6
X$7594 10310 7820 219 320 10450 NOR2_X1
* cell instance $7597 m0 *1 118.37,187.6
X$7597 10143 219 320 CLKBUF_X1
* cell instance $7600 r0 *1 113.43,187.6
X$7600 10567 10234 10449 219 320 10208 OR3_X1
* cell instance $7602 r0 *1 114.57,187.6
X$7602 10567 10449 219 320 10353 XOR2_X1
* cell instance $7604 r0 *1 115.9,187.6
X$7604 10429 219 320 10638 INV_X1
* cell instance $7606 r0 *1 116.47,187.6
X$7606 10536 10429 219 320 10449 NAND2_X1
* cell instance $7607 r0 *1 117.04,187.6
X$7607 10451 10676 10784 10743 10429 10311 320 219 AOI221_X2
* cell instance $7614 r0 *1 119.13,187.6
X$7614 8697 219 320 10143 CLKBUF_X3
* cell instance $7616 m0 *1 119.32,187.6
X$7616 10452 10142 6586 219 10537 320 AOI21_X2
* cell instance $7617 m0 *1 126.73,187.6
X$7617 10454 10426 12517 320 219 10541 HA_X1
* cell instance $7618 m0 *1 128.63,187.6
X$7618 10241 10456 219 320 10354 NAND2_X1
* cell instance $7619 m0 *1 129.2,187.6
X$7619 10241 10541 219 320 10355 NAND2_X1
* cell instance $7620 m0 *1 129.77,187.6
X$7620 9425 219 320 10050 CLKBUF_X3
* cell instance $7621 m0 *1 130.72,187.6
X$7621 10241 10457 219 320 10319 NAND2_X1
* cell instance $7622 m0 *1 131.29,187.6
X$7622 10050 219 320 14749 INV_X1
* cell instance $7624 m0 *1 132.43,187.6
X$7624 10571 8699 10356 219 320 10423 MUX2_X1
* cell instance $7625 m0 *1 133.76,187.6
X$7625 219 13068 10356 10423 10112 320 DFF_X1
* cell instance $7626 m0 *1 136.99,187.6
X$7626 10458 10051 10356 219 320 10357 MUX2_X1
* cell instance $7627 m0 *1 138.32,187.6
X$7627 5131 10652 320 219 10214 AND2_X1
* cell instance $7630 r0 *1 120.08,187.6
X$7630 10640 10142 219 320 10452 NOR2_X1
* cell instance $7631 r0 *1 120.65,187.6
X$7631 10238 10537 9745 219 320 10531 NOR3_X1
* cell instance $7634 r0 *1 123.12,187.6
X$7634 10642 219 320 5131 CLKBUF_X3
* cell instance $7635 r0 *1 124.07,187.6
X$7635 10539 10644 320 219 10570 AND2_X1
* cell instance $7639 r0 *1 125.97,187.6
X$7639 10454 10453 12545 320 219 10456 HA_X1
* cell instance $7640 r0 *1 127.87,187.6
X$7640 10539 10455 320 219 10645 AND2_X1
* cell instance $7641 r0 *1 128.63,187.6
X$7641 10240 10453 12538 320 219 10457 HA_X1
* cell instance $7645 r0 *1 133,187.6
X$7645 219 13923 10458 10542 10112 320 DFF_X1
* cell instance $7646 r0 *1 136.23,187.6
X$7646 10571 8821 10458 219 320 10542 MUX2_X1
* cell instance $7649 r0 *1 139.46,187.6
X$7649 10676 10451 320 219 10358 AND2_X1
* cell instance $7651 m0 *1 141.17,187.6
X$7651 10359 10142 10147 219 320 10420 NAND3_X1
* cell instance $7652 m0 *1 140.22,187.6
X$7652 10358 219 320 10142 CLKBUF_X3
* cell instance $7654 m0 *1 142.12,187.6
X$7654 10245 9017 10546 219 10545 320 AOI21_X1
* cell instance $7655 m0 *1 142.88,187.6
X$7655 10420 10419 6341 320 219 10547 MUX2_X2
* cell instance $7656 m0 *1 144.59,187.6
X$7656 9017 9124 10358 219 320 10548 NAND3_X1
* cell instance $7658 m0 *1 145.54,187.6
X$7658 10358 9124 9017 320 219 10551 AND3_X1
* cell instance $7660 m0 *1 146.68,187.6
X$7660 10360 10361 9124 219 320 10462 OR3_X1
* cell instance $7661 m0 *1 147.63,187.6
X$7661 9124 10361 10360 219 320 10550 NOR3_X1
* cell instance $7665 r0 *1 141.55,187.6
X$7665 10147 10358 10359 320 219 10459 AND3_X1
* cell instance $7668 r0 *1 144.78,187.6
X$7668 10142 9388 219 320 10549 NAND2_X1
* cell instance $7669 r0 *1 145.35,187.6
X$7669 9388 10360 10361 219 320 10461 OR3_X1
* cell instance $7670 r0 *1 146.3,187.6
X$7670 9551 10549 10461 219 10460 320 AOI21_X1
* cell instance $7671 r0 *1 147.06,187.6
X$7671 10249 10548 10462 219 10463 320 AOI21_X1
* cell instance $7672 r0 *1 147.82,187.6
X$7672 10551 10550 10247 320 10575 219 OAI21_X1
* cell instance $7673 r0 *1 148.58,187.6
X$7673 10361 10360 9388 219 320 10465 NOR3_X1
* cell instance $7674 m0 *1 149.72,187.6
X$7674 10329 10362 8119 219 320 10363 NAND3_X1
* cell instance $7675 m0 *1 148.77,187.6
X$7675 10249 10052 8118 10362 219 320 10466 AOI22_X1
* cell instance $7677 m0 *1 150.67,187.6
X$7677 10363 10364 219 320 10553 NAND2_X1
* cell instance $7679 m0 *1 151.43,187.6
X$7679 10329 8119 10147 219 320 10467 NAND3_X1
* cell instance $7681 m0 *1 153.71,187.6
X$7681 10252 10244 9560 219 320 10469 NOR3_X1
* cell instance $7684 r0 *1 149.53,187.6
X$7684 9551 8118 9474 219 10576 320 AOI21_X1
* cell instance $7686 r0 *1 150.67,187.6
X$7686 10364 10363 320 219 10468 AND2_X1
* cell instance $7688 r0 *1 151.62,187.6
X$7688 10467 10468 6341 320 219 10658 MUX2_X2
* cell instance $7690 r0 *1 153.71,187.6
X$7690 10469 10553 6341 320 219 10587 MUX2_X2
* cell instance $7691 m0 *1 155.04,187.6
X$7691 10362 219 320 10554 INV_X1
* cell instance $7694 m0 *1 158.46,187.6
X$7694 10115 219 320 CLKBUF_X1
* cell instance $7695 m0 *1 159.03,187.6
X$7695 9383 219 320 10115 CLKBUF_X3
* cell instance $7696 m0 *1 159.98,187.6
X$7696 9786 10756 10365 219 320 10330 MUX2_X1
* cell instance $7698 m0 *1 162.07,187.6
X$7698 10496 10254 320 219 10149 AND2_X1
* cell instance $7700 m0 *1 168.91,187.6
X$7700 9611 10557 10259 8119 10252 10470 219 320 10471 OAI33_X1
* cell instance $7701 m0 *1 170.24,187.6
X$7701 10474 10257 10470 10413 10123 10366 219 320 OAI221_X2
* cell instance $7703 m0 *1 172.52,187.6
X$7703 10475 10258 10476 10220 10313 10478 219 320 10479 OAI33_X1
* cell instance $7704 m0 *1 173.85,187.6
X$7704 10473 10479 9672 10367 219 320 10368 AOI22_X1
* cell instance $7705 m0 *1 174.8,187.6
X$7705 10324 10368 10480 320 10216 219 OAI21_X1
* cell instance $7706 m0 *1 175.56,187.6
X$7706 10261 219 320 10557 INV_X1
* cell instance $7707 m0 *1 175.94,187.6
X$7707 10261 10266 219 320 10582 NAND2_X1
* cell instance $7710 m0 *1 179.74,187.6
X$7710 10264 10263 219 320 10408 NOR2_X1
* cell instance $7711 m0 *1 180.31,187.6
X$7711 219 10055 10560 10406 10483 320 DFF_X1
* cell instance $7712 m0 *1 183.54,187.6
X$7712 10560 219 320 10482 BUF_X2
* cell instance $7715 r0 *1 155.42,187.6
X$7715 9560 10554 6341 320 219 10470 MUX2_X2
* cell instance $7719 r0 *1 164.16,187.6
X$7719 9028 219 320 7679 INV_X4
* cell instance $7724 r0 *1 169.48,187.6
X$7724 10470 10413 219 320 10473 OR2_X1
* cell instance $7725 r0 *1 170.24,187.6
X$7725 10324 10472 10152 219 320 10411 NAND3_X1
* cell instance $7726 r0 *1 171,187.6
X$7726 10474 10314 10123 10477 320 219 10558 AND4_X1
* cell instance $7727 r0 *1 172.14,187.6
X$7727 10257 10474 219 320 10475 NOR2_X1
* cell instance $7728 r0 *1 172.71,187.6
X$7728 9561 7596 10477 219 10476 320 AOI21_X1
* cell instance $7730 r0 *1 173.85,187.6
X$7730 10260 10477 10151 219 10478 320 AOI21_X1
* cell instance $7731 r0 *1 174.61,187.6
X$7731 9386 10583 10324 219 10480 320 AOI21_X1
* cell instance $7738 r0 *1 175.37,187.6
X$7738 10324 10472 2810 219 320 10662 NAND3_X1
* cell instance $7742 r0 *1 180.12,187.6
X$7742 10015 10482 219 320 10481 NAND2_X1
* cell instance $7743 r0 *1 180.69,187.6
X$7743 10482 10314 320 219 10485 AND2_X1
* cell instance $7744 r0 *1 181.45,187.6
X$7744 10590 10588 10484 320 10406 219 OAI21_X1
* cell instance $7745 r0 *1 182.21,187.6
X$7745 9386 10485 10590 219 10484 320 AOI21_X1
* cell instance $7748 r0 *1 184.87,187.6
X$7748 219 10487 10488 10486 10483 320 DFF_X1
* cell instance $7750 m0 *1 186.2,187.6
X$7750 6233 10263 219 320 10400 NOR2_X1
* cell instance $7751 m0 *1 186.96,187.6
X$7751 10119 10263 219 320 10399 NOR2_X1
* cell instance $7752 m0 *1 187.53,187.6
X$7752 10559 10263 219 320 10397 NOR2_X1
* cell instance $7755 m0 *1 192.66,187.6
X$7755 7740 320 7151 219 BUF_X4
* cell instance $7758 m0 *1 194.94,187.6
X$7758 10556 10267 10555 219 320 10217 MUX2_X1
* cell instance $7760 m0 *1 197.79,187.6
X$7760 10614 219 320 7952 INV_X2
* cell instance $7761 m0 *1 198.36,187.6
X$7761 9185 10267 8871 9560 219 320 10491 NOR4_X1
* cell instance $7762 m0 *1 199.31,187.6
X$7762 8718 10147 219 320 10552 NAND2_X1
* cell instance $7763 m0 *1 199.88,187.6
X$7763 8743 8871 219 320 10391 NOR2_X1
* cell instance $7764 m0 *1 200.45,187.6
X$7764 9388 9069 10493 320 10544 219 OAI21_X1
* cell instance $7765 m0 *1 201.21,187.6
X$7765 8489 9551 219 320 10493 NOR2_X1
* cell instance $7766 m0 *1 201.78,187.6
X$7766 9068 10374 10147 219 320 10494 NAND3_X1
* cell instance $7773 r0 *1 189.43,187.6
X$7773 10594 320 6395 219 BUF_X4
* cell instance $7774 r0 *1 190.76,187.6
X$7774 7701 8292 219 320 10702 OR2_X1
* cell instance $7776 r0 *1 191.9,187.6
X$7776 10489 10147 9183 219 320 10649 NAND3_X1
* cell instance $7777 r0 *1 192.66,187.6
X$7777 9551 6582 219 320 10704 NOR2_X2
* cell instance $7780 r0 *1 194.75,187.6
X$7780 9070 9352 9231 219 320 10706 NAND3_X2
* cell instance $7781 r0 *1 196.08,187.6
X$7781 8292 6582 9352 9070 320 219 10490 AND4_X1
* cell instance $7784 r0 *1 198.17,187.6
X$7784 10491 10267 10391 219 10983 320 AOI21_X1
* cell instance $7786 r0 *1 199.31,187.6
X$7786 10552 10267 8743 219 320 10492 MUX2_X1
* cell instance $7787 r0 *1 200.64,187.6
X$7787 10544 8657 10267 320 219 10543 MUX2_X2
* cell instance $7789 r0 *1 202.54,187.6
X$7789 10494 10267 219 320 10495 NOR2_X1
* cell instance $7792 m0 *1 205.2,187.6
X$7792 8489 320 8871 219 BUF_X4
* cell instance $7797 r0 *1 207.1,187.6
X$7797 10538 10374 2694 219 10540 320 AOI21_X1
* cell instance $7799 r0 *1 208.05,187.6
X$7799 10636 219 320 10497 INV_X1
* cell instance $7801 r0 *1 208.81,187.6
X$7801 10496 10498 320 219 10636 AND2_X1
* cell instance $7802 m0 *1 209.38,187.6
X$7802 1970 8871 10499 219 320 10498 MUX2_X1
* cell instance $7806 m0 *1 212.42,187.6
X$7806 10603 10372 10500 10285 219 320 10534 AOI22_X2
* cell instance $7807 m0 *1 214.13,187.6
X$7807 219 13448 10375 10373 9978 320 DFF_X1
* cell instance $7811 r0 *1 209.57,187.6
X$7811 10497 10158 10188 10534 219 320 10740 NOR4_X1
* cell instance $7812 r0 *1 210.52,187.6
X$7812 10158 10188 10534 10498 219 320 10634 NOR4_X1
* cell instance $7815 r0 *1 213.18,187.6
X$7815 2275 2702 2694 219 320 10500 NOR3_X1
* cell instance $7816 r0 *1 213.94,187.6
X$7816 10372 10285 9745 219 320 10373 NOR3_X1
* cell instance $7817 r0 *1 214.7,187.6
X$7817 2702 8871 219 320 10502 NOR2_X1
* cell instance $7818 r0 *1 215.27,187.6
X$7818 10501 10375 10604 219 320 10065 OR3_X1
* cell instance $7819 r0 *1 216.22,187.6
X$7819 2275 8871 219 320 10715 NOR2_X1
* cell instance $7821 r0 *1 216.98,187.6
X$7821 9447 219 320 9978 CLKBUF_X3
* cell instance $7822 r0 *1 217.93,187.6
X$7822 9978 219 320 14766 INV_X1
* cell instance $7824 r0 *1 218.69,187.6
X$7824 10527 5369 10504 320 219 10905 OAI21_X2
* cell instance $7825 r0 *1 220.02,187.6
X$7825 8861 10503 219 320 10527 OR2_X1
* cell instance $7826 m0 *1 220.21,187.6
X$7826 9976 219 320 9447 CLKBUF_X3
* cell instance $7829 m0 *1 221.92,187.6
X$7829 10377 219 320 8861 CLKBUF_X3
* cell instance $7833 r0 *1 220.78,187.6
X$7833 10503 10504 8861 320 219 9674 MUX2_X2
* cell instance $7837 r0 *1 223.82,187.6
X$7837 10505 9801 10506 219 320 10503 MUX2_X1
* cell instance $7839 m0 *1 225.72,187.6
X$7839 6398 219 320 10378 BUF_X1
* cell instance $7845 m0 *1 228.19,187.6
X$7845 219 13639 10523 10524 10717 320 DFF_X1
* cell instance $7846 m0 *1 231.61,187.6
X$7846 219 12627 10618 10522 10616 320 DFF_X1
* cell instance $7849 m0 *1 235.79,187.6
X$7849 10515 7176 10508 219 320 10518 MUX2_X1
* cell instance $7850 m0 *1 237.12,187.6
X$7850 10515 7165 10380 219 320 10509 MUX2_X1
* cell instance $7851 m0 *1 238.45,187.6
X$7851 10508 10820 10380 219 320 10613 MUX2_X1
* cell instance $7855 r0 *1 228.95,187.6
X$7855 219 10507 9801 320 BUF_X16
* cell instance $7863 r0 *1 234.08,187.6
X$7863 219 14103 10508 10518 10616 320 DFF_X1
* cell instance $7864 r0 *1 237.31,187.6
X$7864 219 14235 10380 10509 10616 320 DFF_X1
* cell instance $7867 m0 *1 26.79,72.8
X$7867 2647 1303 2646 219 320 2704 MUX2_X1
* cell instance $7870 m0 *1 28.31,72.8
X$7870 219 12718 2773 2705 2771 320 DFF_X1
* cell instance $7874 m0 *1 35.53,72.8
X$7874 2647 1307 2649 219 320 2708 MUX2_X1
* cell instance $7876 m0 *1 22.99,72.8
X$7876 219 13282 2770 2645 2309 320 DFF_X1
* cell instance $7879 r0 *1 22.8,72.8
X$7879 2770 1507 2647 219 320 2645 MUX2_X1
* cell instance $7880 r0 *1 24.13,72.8
X$7880 2559 1553 2703 219 320 2560 MUX2_X1
* cell instance $7882 r0 *1 25.84,72.8
X$7882 2770 2842 2703 219 320 2843 MUX2_X1
* cell instance $7886 r0 *1 29.26,72.8
X$7886 2646 2772 2773 219 320 2774 MUX2_X1
* cell instance $7889 r0 *1 34.01,72.8
X$7889 219 14577 2649 2708 2314 320 DFF_X1
* cell instance $7891 m0 *1 37.24,72.8
X$7891 2648 1520 2649 219 320 2711 MUX2_X1
* cell instance $7892 m0 *1 39.33,72.8
X$7892 2561 2888 2651 219 320 2650 MUX2_X1
* cell instance $7893 m0 *1 40.66,72.8
X$7893 2647 1523 2651 219 320 2710 MUX2_X1
* cell instance $7898 r0 *1 40.47,72.8
X$7898 2650 1835 2711 219 320 2970 MUX2_X1
* cell instance $7903 m0 *1 43.89,72.8
X$7903 219 13606 2778 2652 2217 320 DFF_X1
* cell instance $7905 r0 *1 43.89,72.8
X$7905 2778 1384 2647 219 320 2652 MUX2_X1
* cell instance $7906 r0 *1 45.22,72.8
X$7906 2778 2714 2780 219 320 2779 MUX2_X1
* cell instance $7907 r0 *1 46.55,72.8
X$7907 2647 1385 2780 219 320 2847 MUX2_X1
* cell instance $7909 m0 *1 48.45,72.8
X$7909 2716 2787 2563 219 320 2653 MUX2_X1
* cell instance $7912 m0 *1 50.54,72.8
X$7912 1515 219 320 2217 CLKBUF_X3
* cell instance $7913 m0 *1 51.49,72.8
X$7913 2217 219 320 CLKBUF_X1
* cell instance $7917 m0 *1 54.53,72.8
X$7917 2713 2654 1643 320 219 2720 MUX2_X2
* cell instance $7920 r0 *1 48.83,72.8
X$7920 219 14444 2780 2847 2217 320 DFF_X1
* cell instance $7923 r0 *1 53.2,72.8
X$7923 219 14324 2782 2781 2217 320 DFF_X1
* cell instance $7925 m0 *1 56.81,72.8
X$7925 219 12996 2723 2722 2975 320 DFF_X1
* cell instance $7927 m0 *1 60.04,72.8
X$7927 2783 2086 2462 219 320 2724 MUX2_X1
* cell instance $7930 r0 *1 57.95,72.8
X$7930 2723 2842 2323 219 320 2977 MUX2_X1
* cell instance $7933 r0 *1 59.85,72.8
X$7933 219 14230 2783 2724 2565 320 DFF_X1
* cell instance $7938 m0 *1 63.46,72.8
X$7938 2462 2148 2656 219 320 2850 MUX2_X1
* cell instance $7941 r0 *1 63.84,72.8
X$7941 219 14096 2656 2850 2565 320 DFF_X1
* cell instance $7942 m0 *1 66.5,72.8
X$7942 2462 1898 2658 219 320 2725 MUX2_X1
* cell instance $7943 m0 *1 65.17,72.8
X$7943 2220 2657 2658 219 320 2980 MUX2_X1
* cell instance $7944 m0 *1 67.83,72.8
X$7944 1570 219 320 2565 CLKBUF_X3
* cell instance $7947 m0 *1 69.73,72.8
X$7947 2784 1756 2462 219 320 2732 MUX2_X1
* cell instance $7948 m0 *1 71.06,72.8
X$7948 2733 2659 2521 219 320 2734 MUX2_X1
* cell instance $7952 r0 *1 68.02,72.8
X$7952 219 14221 2784 2732 2565 320 DFF_X1
* cell instance $7955 r0 *1 71.82,72.8
X$7955 2462 1999 2786 219 320 2852 MUX2_X1
* cell instance $7956 m0 *1 72.96,72.8
X$7956 219 13566 2660 2566 2223 320 DFF_X1
* cell instance $7958 m0 *1 76.19,72.8
X$7958 2462 1983 2661 219 320 2735 MUX2_X1
* cell instance $7960 m0 *1 77.71,72.8
X$7960 219 12576 2661 2735 2223 320 DFF_X1
* cell instance $7962 m0 *1 81.7,72.8
X$7962 219 12571 2662 2736 2223 320 DFF_X1
* cell instance $7963 m0 *1 84.93,72.8
X$7963 2465 1571 2662 219 320 2736 MUX2_X1
* cell instance $7965 r0 *1 73.15,72.8
X$7965 219 14118 2786 2852 2785 320 DFF_X1
* cell instance $7966 r0 *1 76.38,72.8
X$7966 2661 2787 2786 219 320 2989 MUX2_X1
* cell instance $7970 r0 *1 81.32,72.8
X$7970 2465 1389 2789 219 320 2788 MUX2_X1
* cell instance $7971 r0 *1 82.65,72.8
X$7971 219 13692 2789 2788 2223 320 DFF_X1
* cell instance $7972 r0 *1 85.88,72.8
X$7972 2465 1476 2738 219 320 2990 MUX2_X1
* cell instance $7973 m0 *1 86.83,72.8
X$7973 2789 2327 2738 219 320 2856 MUX2_X1
* cell instance $7977 m0 *1 89.11,72.8
X$7977 2465 1478 2742 219 320 2741 MUX2_X1
* cell instance $7980 m0 *1 91.39,72.8
X$7980 2664 2665 2095 320 2746 219 NOR3_X2
* cell instance $7985 r0 *1 87.78,72.8
X$7985 219 13902 2742 2741 2790 320 DFF_X1
* cell instance $7987 r0 *1 91.39,72.8
X$7987 2663 2665 1651 320 2791 219 NOR3_X2
* cell instance $7989 r0 *1 93.1,72.8
X$7989 2856 2669 219 320 2995 NOR2_X1
* cell instance $7991 m0 *1 94.05,72.8
X$7991 2571 1756 2569 219 320 2744 MUX2_X1
* cell instance $7993 m0 *1 95.38,72.8
X$7993 219 12736 2571 2744 2668 320 DFF_X1
* cell instance $7996 r0 *1 94.24,72.8
X$7996 2667 2575 219 320 2858 NOR2_X1
* cell instance $8000 r0 *1 97.28,72.8
X$8000 219 2748 2746 2859 2749 2861 320 NOR4_X4
* cell instance $8001 m0 *1 99.18,72.8
X$8001 2666 2327 2627 219 320 2862 MUX2_X1
* cell instance $8003 m0 *1 100.51,72.8
X$8003 1760 2669 219 320 2749 NOR2_X1
* cell instance $8006 m0 *1 102.79,72.8
X$8006 2417 2792 2750 219 320 2754 NOR3_X1
* cell instance $8008 m0 *1 103.74,72.8
X$8008 2670 1576 2467 219 320 2671 MUX2_X1
* cell instance $8009 m0 *1 105.07,72.8
X$8009 2419 2672 2752 219 320 2753 NOR3_X1
* cell instance $8010 m0 *1 105.83,72.8
X$8010 2751 2575 219 320 2673 NOR2_X1
* cell instance $8011 m0 *1 106.4,72.8
X$8011 219 2757 2756 2754 2753 2755 320 OR4_X4
* cell instance $8012 m0 *1 108.87,72.8
X$8012 2574 2669 219 320 2756 NOR2_X1
* cell instance $8019 m0 *1 141.36,72.8
X$8019 1943 219 320 2637 CLKBUF_X3
* cell instance $8020 m0 *1 142.31,72.8
X$8020 2637 219 320 14751 INV_X1
* cell instance $8024 m0 *1 148.01,72.8
X$8024 2763 320 2761 219 BUF_X4
* cell instance $8025 m0 *1 149.34,72.8
X$8025 2759 219 320 2760 BUF_X1
* cell instance $8027 m0 *1 152.95,72.8
X$8027 2676 2677 219 320 2584 NAND2_X1
* cell instance $8031 r0 *1 102.41,72.8
X$8031 2862 2792 2750 219 320 2793 NOR3_X1
* cell instance $8033 r0 *1 104.69,72.8
X$8033 2671 2665 2752 219 320 2794 NOR3_X1
* cell instance $8034 r0 *1 105.45,72.8
X$8034 219 2867 2863 2793 2794 2673 320 OR4_X4
* cell instance $8035 r0 *1 107.92,72.8
X$8035 2869 2669 219 320 2863 NOR2_X1
* cell instance $8036 r0 *1 108.49,72.8
X$8036 219 13728 2796 2868 2236 320 DFF_X1
* cell instance $8048 r0 *1 126.54,72.8
X$8048 219 14321 2907 2798 2800 320 DFF_X1
* cell instance $8051 r0 *1 130.72,72.8
X$8051 219 14125 2803 2801 2800 320 DFF_X1
* cell instance $8056 r0 *1 139.46,72.8
X$8056 219 14555 2804 2876 2637 320 DFF_X1
* cell instance $8061 r0 *1 151.24,72.8
X$8061 2874 2875 12550 320 219 2677 HA_X1
* cell instance $8062 r0 *1 153.14,72.8
X$8062 2874 2873 12537 320 219 2758 HA_X1
* cell instance $8063 m0 *1 154.09,72.8
X$8063 2676 2919 219 320 1078 NAND2_X1
* cell instance $8066 m0 *1 155.23,72.8
X$8066 2676 2758 219 320 2678 NAND2_X1
* cell instance $8069 m0 *1 156.56,72.8
X$8069 1943 219 320 2343 CLKBUF_X3
* cell instance $8072 m0 *1 165.11,72.8
X$8072 219 12884 2683 2739 2348 320 DFF_X1
* cell instance $8073 m0 *1 168.34,72.8
X$8073 810 2053 2682 219 320 2745 MUX2_X1
* cell instance $8075 m0 *1 169.86,72.8
X$8075 810 2054 2683 219 320 2739 MUX2_X1
* cell instance $8076 m0 *1 171.19,72.8
X$8076 810 1852 2685 219 320 2740 MUX2_X1
* cell instance $8077 m0 *1 172.52,72.8
X$8077 2685 1772 2686 219 320 2737 MUX2_X1
* cell instance $8078 m0 *1 173.85,72.8
X$8078 810 2057 2686 219 320 2687 MUX2_X1
* cell instance $8083 m0 *1 180.69,72.8
X$8083 219 13259 2730 2729 2727 320 DFF_X1
* cell instance $8084 m0 *1 183.92,72.8
X$8084 2728 2054 2730 219 320 2729 MUX2_X1
* cell instance $8086 m0 *1 186.01,72.8
X$8086 2728 2057 2855 219 320 2726 MUX2_X1
* cell instance $8093 r0 *1 159.41,72.8
X$8093 1747 2866 219 320 2809 NAND2_X1
* cell instance $8095 r0 *1 160.74,72.8
X$8095 2720 2810 219 320 2871 NAND2_X1
* cell instance $8097 r0 *1 162.07,72.8
X$8097 2720 2813 219 320 2812 NAND2_X1
* cell instance $8101 r0 *1 163.97,72.8
X$8101 1925 2813 219 320 2680 NAND2_X1
* cell instance $8103 r0 *1 164.73,72.8
X$8103 2811 2680 2865 219 246 320 AOI21_X2
* cell instance $8104 r0 *1 166.06,72.8
X$8104 2864 2527 2684 320 219 3019 OAI21_X4
* cell instance $8106 r0 *1 169.29,72.8
X$8106 2352 2737 219 320 2864 OR2_X1
* cell instance $8109 r0 *1 170.62,72.8
X$8109 219 14384 2685 2740 2727 320 DFF_X1
* cell instance $8110 r0 *1 173.85,72.8
X$8110 219 14678 2686 2687 2727 320 DFF_X1
* cell instance $8115 r0 *1 178.6,72.8
X$8115 2287 2813 219 320 3007 NAND2_X1
* cell instance $8117 r0 *1 179.55,72.8
X$8117 219 14638 2816 2857 2727 320 DFF_X1
* cell instance $8118 r0 *1 182.78,72.8
X$8118 2728 1852 2816 219 320 2857 MUX2_X1
* cell instance $8119 r0 *1 184.11,72.8
X$8119 2362 219 320 2727 CLKBUF_X3
* cell instance $8120 r0 *1 185.06,72.8
X$8120 2727 219 320 CLKBUF_X1
* cell instance $8121 r0 *1 185.63,72.8
X$8121 219 14369 2855 2726 2727 320 DFF_X1
* cell instance $8122 r0 *1 188.86,72.8
X$8122 219 14666 2817 2688 2727 320 DFF_X1
* cell instance $8124 m0 *1 189.24,72.8
X$8124 2689 2053 2817 219 320 2688 MUX2_X1
* cell instance $8125 m0 *1 191.14,72.8
X$8125 219 3001 1893 320 BUF_X16
* cell instance $8128 m0 *1 196.08,72.8
X$8128 2689 1852 2690 219 320 2721 MUX2_X1
* cell instance $8135 r0 *1 192.09,72.8
X$8135 2689 2054 2997 219 320 2854 MUX2_X1
* cell instance $8136 r0 *1 193.42,72.8
X$8136 219 14652 2690 2721 2255 320 DFF_X1
* cell instance $8137 r0 *1 196.65,72.8
X$8137 2689 2057 2818 219 320 2851 MUX2_X1
* cell instance $8138 r0 *1 197.98,72.8
X$8138 2690 2065 2818 219 320 3098 MUX2_X1
* cell instance $8139 r0 *1 199.31,72.8
X$8139 2820 2053 2821 219 320 2819 MUX2_X1
* cell instance $8140 r0 *1 200.64,72.8
X$8140 2820 1852 2822 219 320 2849 MUX2_X1
* cell instance $8141 r0 *1 201.97,72.8
X$8141 219 14360 2822 2849 2366 320 DFF_X1
* cell instance $8142 r0 *1 205.2,72.8
X$8142 2366 219 320 CLKBUF_X1
* cell instance $8144 r0 *1 206.15,72.8
X$8144 219 14387 2848 2691 2366 320 DFF_X1
* cell instance $8147 r0 *1 211.09,72.8
X$8147 219 14378 2823 2983 2591 320 DFF_X1
* cell instance $8148 r0 *1 214.32,72.8
X$8148 219 13830 2824 2825 2591 320 DFF_X1
* cell instance $8151 r0 *1 218.5,72.8
X$8151 219 2712 1868 320 BUF_X16
* cell instance $8152 m0 *1 220.02,72.8
X$8152 219 13230 2707 2845 2594 320 DFF_X1
* cell instance $8154 m0 *1 223.25,72.8
X$8154 2826 2169 2692 219 320 2709 MUX2_X1
* cell instance $8156 r0 *1 223.25,72.8
X$8156 2826 2261 2707 219 320 2845 MUX2_X1
* cell instance $8157 r0 *1 224.58,72.8
X$8157 2707 1868 2692 219 320 2844 MUX2_X1
* cell instance $8158 m0 *1 225.15,72.8
X$8158 219 13182 2827 2693 2594 320 DFF_X1
* cell instance $8163 m0 *1 232.37,72.8
X$8163 2695 219 320 2493 BUF_X1
* cell instance $8166 m0 *1 236.17,72.8
X$8166 2596 2700 2072 320 219 2702 MUX2_X2
* cell instance $8169 m0 *1 240.16,72.8
X$8169 2696 219 320 2265 BUF_X1
* cell instance $8171 r0 *1 225.91,72.8
X$8171 2826 2368 2827 219 320 2693 MUX2_X1
* cell instance $8172 r0 *1 227.24,72.8
X$8172 2827 1596 2828 219 320 2839 MUX2_X1
* cell instance $8179 r0 *1 232.75,72.8
X$8179 2834 219 320 2826 BUF_X1
* cell instance $8183 r0 *1 235.41,72.8
X$8183 2836 219 320 2830 BUF_X1
* cell instance $8186 r0 *1 237.12,72.8
X$8186 2832 2831 2953 219 320 2838 MUX2_X1
* cell instance $8190 m0 *1 11.21,159.6
X$8190 219 12569 8359 8508 8680 320 DFF_X1
* cell instance $8192 m0 *1 14.44,159.6
X$8192 7578 7121 8359 219 320 8508 MUX2_X1
* cell instance $8199 m0 *1 36.48,159.6
X$8199 7914 219 320 CLKBUF_X1
* cell instance $8217 r0 *1 15.96,159.6
X$8217 219 14060 8547 8619 8680 320 DFF_X1
* cell instance $8220 r0 *1 19.76,159.6
X$8220 219 13820 8549 8621 7913 320 DFF_X1
* cell instance $8221 r0 *1 22.99,159.6
X$8221 8440 6906 8548 219 320 8623 MUX2_X1
* cell instance $8223 r0 *1 24.51,159.6
X$8223 219 14075 8440 8623 8441 320 DFF_X1
* cell instance $8226 r0 *1 28.88,159.6
X$8226 219 13987 8551 8625 8441 320 DFF_X1
* cell instance $8230 r0 *1 36.29,159.6
X$8230 8552 6042 8442 219 320 8626 MUX2_X1
* cell instance $8231 r0 *1 37.62,159.6
X$8231 219 13936 8553 8630 7914 320 DFF_X1
* cell instance $8232 r0 *1 40.85,159.6
X$8232 8553 5864 8552 219 320 8630 MUX2_X1
* cell instance $8235 m0 *1 54.72,159.6
X$8235 219 12933 8443 8514 8446 320 DFF_X1
* cell instance $8236 m0 *1 53.39,159.6
X$8236 8020 6121 8443 219 320 8514 MUX2_X1
* cell instance $8237 m0 *1 57.95,159.6
X$8237 8020 5933 8445 219 320 8444 MUX2_X1
* cell instance $8243 r0 *1 57.95,159.6
X$8243 219 14320 8445 8444 8446 320 DFF_X1
* cell instance $8245 m0 *1 61.37,159.6
X$8245 8270 6046 8447 219 320 8517 MUX2_X1
* cell instance $8247 m0 *1 62.7,159.6
X$8247 219 12923 8447 8517 8446 320 DFF_X1
* cell instance $8249 m0 *1 66.12,159.6
X$8249 8414 2095 8520 219 320 8415 MUX2_X1
* cell instance $8256 r0 *1 63.65,159.6
X$8256 8445 6165 8447 219 320 8520 MUX2_X1
* cell instance $8259 m0 *1 67.83,159.6
X$8259 6373 219 320 8022 CLKBUF_X3
* cell instance $8263 r0 *1 68.97,159.6
X$8263 219 14322 8448 8642 8022 320 DFF_X1
* cell instance $8265 m0 *1 70.68,159.6
X$8265 8448 6110 8270 219 320 8642 MUX2_X1
* cell instance $8268 m0 *1 72.39,159.6
X$8268 8270 5930 8364 219 320 8643 MUX2_X1
* cell instance $8269 m0 *1 79.8,159.6
X$8269 219 12938 8366 8418 8326 320 DFF_X1
* cell instance $8271 m0 *1 83.79,159.6
X$8271 8522 219 320 7258 CLKBUF_X2
* cell instance $8275 m0 *1 89.3,159.6
X$8275 5254 320 5120 219 BUF_X4
* cell instance $8276 m0 *1 90.63,159.6
X$8276 219 13483 8451 8450 8105 320 DFF_X1
* cell instance $8277 m0 *1 93.86,159.6
X$8277 8451 5353 8560 219 320 8527 MUX2_X1
* cell instance $8279 m0 *1 95.95,159.6
X$8279 7926 219 320 CLKBUF_X1
* cell instance $8280 m0 *1 96.52,159.6
X$8280 6284 219 320 7926 CLKBUF_X3
* cell instance $8281 m0 *1 97.47,159.6
X$8281 8527 3370 5515 320 8528 219 NOR3_X2
* cell instance $8285 r0 *1 72.77,159.6
X$8285 219 14454 8364 8643 8449 320 DFF_X1
* cell instance $8290 r0 *1 84.74,159.6
X$8290 7924 7129 8558 219 320 8557 MUX2_X1
* cell instance $8291 r0 *1 86.07,159.6
X$8291 8742 5120 8558 219 320 7823 MUX2_X1
* cell instance $8294 r0 *1 90.82,159.6
X$8294 8559 7192 8451 219 320 8450 MUX2_X1
* cell instance $8297 r0 *1 94.05,159.6
X$8297 8562 6856 8559 219 320 8561 MUX2_X1
* cell instance $8301 r0 *1 96.71,159.6
X$8301 8562 5120 8694 219 320 8652 MUX2_X1
* cell instance $8303 r0 *1 98.42,159.6
X$8303 8652 4127 219 320 8653 NOR2_X1
* cell instance $8304 r0 *1 98.99,159.6
X$8304 219 8653 8528 8452 8564 6279 320 NOR4_X4
* cell instance $8305 m0 *1 102.03,159.6
X$8305 8530 3370 5515 219 320 8531 NOR3_X1
* cell instance $8306 m0 *1 100.7,159.6
X$8306 8453 5122 6277 320 8452 219 NOR3_X2
* cell instance $8309 m0 *1 104.5,159.6
X$8309 8454 8532 8531 219 320 6464 OR3_X2
* cell instance $8310 m0 *1 105.64,159.6
X$8310 8533 5122 6277 219 320 8532 NOR3_X1
* cell instance $8311 m0 *1 106.4,159.6
X$8311 8566 5353 8455 219 320 8533 MUX2_X1
* cell instance $8314 m0 *1 110.96,159.6
X$8314 219 13557 8424 8333 8028 320 DFF_X1
* cell instance $8315 m0 *1 114.19,159.6
X$8315 219 13625 8459 8567 8456 320 DFF_X1
* cell instance $8320 m0 *1 125.97,159.6
X$8320 8284 8460 219 320 8535 OR2_X1
* cell instance $8322 m0 *1 128.25,159.6
X$8322 8033 219 320 CLKBUF_X1
* cell instance $8323 m0 *1 128.82,159.6
X$8323 5428 219 320 8033 CLKBUF_X3
* cell instance $8324 m0 *1 129.77,159.6
X$8324 8167 8242 8539 219 320 8537 MUX2_X1
* cell instance $8325 m0 *1 131.1,159.6
X$8325 219 13241 8539 8537 7934 320 DFF_X1
* cell instance $8326 m0 *1 134.33,159.6
X$8326 8458 320 3260 219 BUF_X4
* cell instance $8330 r0 *1 104.31,159.6
X$8330 8559 7027 8455 219 320 8654 MUX2_X1
* cell instance $8331 r0 *1 105.64,159.6
X$8331 219 13824 8455 8654 8028 320 DFF_X1
* cell instance $8335 r0 *1 110.96,159.6
X$8335 8325 320 8119 219 BUF_X4
* cell instance $8337 r0 *1 112.48,159.6
X$8337 219 13644 8457 8367 8456 320 DFF_X1
* cell instance $8338 r0 *1 115.71,159.6
X$8338 8424 8458 8457 219 320 8370 MUX2_X1
* cell instance $8343 r0 *1 120.08,159.6
X$8343 8568 8166 8569 219 320 8658 MUX2_X1
* cell instance $8345 r0 *1 121.79,159.6
X$8345 8747 7501 8569 219 320 8662 MUX2_X1
* cell instance $8347 r0 *1 123.5,159.6
X$8347 8568 8242 8749 219 320 8661 MUX2_X1
* cell instance $8351 r0 *1 125.4,159.6
X$8351 8535 7606 8662 320 219 7832 OAI21_X4
* cell instance $8353 r0 *1 128.25,159.6
X$8353 219 14691 8571 8664 8033 320 DFF_X1
* cell instance $8354 r0 *1 131.48,159.6
X$8354 4505 320 7612 219 BUF_X4
* cell instance $8355 r0 *1 132.81,159.6
X$8355 8571 4136 8539 219 320 8344 MUX2_X1
* cell instance $8358 r0 *1 135.28,159.6
X$8358 8572 3260 8461 219 320 8540 MUX2_X1
* cell instance $8360 m0 *1 136.04,159.6
X$8360 219 8458 3775 320 BUF_X16
* cell instance $8362 r0 *1 136.61,159.6
X$8362 219 14413 8573 8462 7934 320 DFF_X1
* cell instance $8363 r0 *1 139.84,159.6
X$8363 8573 3260 8463 219 320 8541 MUX2_X1
* cell instance $8367 m0 *1 141.93,159.6
X$8367 8188 8038 8464 219 320 8429 MUX2_X1
* cell instance $8370 r0 *1 142.5,159.6
X$8370 219 14468 8467 8667 8465 320 DFF_X1
* cell instance $8371 m0 *1 144.59,159.6
X$8371 219 13247 8371 8430 8465 320 DFF_X1
* cell instance $8373 m0 *1 147.82,159.6
X$8373 8371 4136 8372 219 320 8431 MUX2_X1
* cell instance $8379 m0 *1 168.34,159.6
X$8379 8470 8290 8581 320 219 8471 HA_X1
* cell instance $8380 m0 *1 170.24,159.6
X$8380 8381 219 320 7939 INV_X4
* cell instance $8381 m0 *1 171.19,159.6
X$8381 8472 5488 219 320 8544 NOR2_X2
* cell instance $8384 m0 *1 176.7,159.6
X$8384 7944 8473 6732 8474 219 320 8437 AOI22_X1
* cell instance $8385 m0 *1 177.65,159.6
X$8385 6540 7671 7689 6987 320 219 8374 OAI22_X2
* cell instance $8386 m0 *1 179.36,159.6
X$8386 7689 219 320 8678 INV_X1
* cell instance $8389 m0 *1 180.69,159.6
X$8389 7689 219 320 8375 BUF_X1
* cell instance $8391 m0 *1 184.3,159.6
X$8391 8435 5570 219 320 8510 NOR2_X1
* cell instance $8393 r0 *1 145.73,159.6
X$8393 8574 3260 8467 219 320 8171 MUX2_X1
* cell instance $8397 r0 *1 152,159.6
X$8397 8468 219 320 8473 BUF_X1
* cell instance $8402 r0 *1 163.59,159.6
X$8402 7840 5959 219 320 8469 NAND2_X1
* cell instance $8405 r0 *1 166.44,159.6
X$8405 8491 8672 8578 320 219 8580 HA_X1
* cell instance $8406 r0 *1 168.34,159.6
X$8406 8318 1290 8673 320 219 8583 HA_X1
* cell instance $8407 r0 *1 170.24,159.6
X$8407 8471 8583 8580 219 320 8543 NOR3_X1
* cell instance $8410 r0 *1 172.9,159.6
X$8410 6068 7671 7689 6673 320 219 8679 OAI22_X2
* cell instance $8411 r0 *1 174.61,159.6
X$8411 8473 219 320 8585 BUF_X1
* cell instance $8415 r0 *1 175.18,159.6
X$8415 8434 219 320 8474 INV_X2
* cell instance $8417 r0 *1 176.13,159.6
X$8417 7735 7671 8434 7845 320 219 8586 OAI22_X2
* cell instance $8418 r0 *1 177.84,159.6
X$8418 8475 8260 8586 8678 7949 8542 320 219 AOI221_X2
* cell instance $8419 r0 *1 179.93,159.6
X$8419 8674 7671 7689 6395 320 219 8587 OAI22_X2
* cell instance $8420 r0 *1 181.64,159.6
X$8420 8595 320 6237 219 BUF_X4
* cell instance $8421 r0 *1 182.97,159.6
X$8421 1154 219 320 8672 INV_X1
* cell instance $8424 r0 *1 184.49,159.6
X$8424 6835 1154 6950 8670 219 320 8589 AOI22_X1
* cell instance $8425 m0 *1 185.44,159.6
X$8425 8478 6636 8479 219 7741 320 AOI21_X1
* cell instance $8427 m0 *1 186.2,159.6
X$8427 8479 2807 219 320 8538 NAND2_X1
* cell instance $8429 m0 *1 186.96,159.6
X$8429 8260 320 8421 219 BUF_X4
* cell instance $8430 m0 *1 188.29,159.6
X$8430 8481 5537 219 320 8536 NOR2_X2
* cell instance $8431 m0 *1 189.24,159.6
X$8431 5898 8482 8534 8480 5837 320 219 8377 OAI221_X1
* cell instance $8432 m0 *1 190.38,159.6
X$8432 8480 219 320 8483 INV_X1
* cell instance $8433 m0 *1 190.76,159.6
X$8433 8377 6636 8484 219 8378 320 AOI21_X1
* cell instance $8434 m0 *1 191.52,159.6
X$8434 6540 3640 8482 5901 320 219 8379 OAI22_X2
* cell instance $8435 m0 *1 193.23,159.6
X$8435 8595 8219 8186 5841 320 219 8428 OAI22_X2
* cell instance $8436 m0 *1 194.94,159.6
X$8436 8296 5537 219 320 8413 NOR2_X2
* cell instance $8437 m0 *1 195.89,159.6
X$8437 3058 8529 8427 219 8496 320 AOI21_X2
* cell instance $8438 m0 *1 197.22,159.6
X$8438 8378 5958 219 320 8495 NOR2_X1
* cell instance $8439 m0 *1 197.79,159.6
X$8439 8526 5958 219 320 8515 NOR2_X2
* cell instance $8442 r0 *1 185.44,159.6
X$8442 1154 219 320 8710 BUF_X1
* cell instance $8443 r0 *1 186.01,159.6
X$8443 4010 219 320 8713 INV_X1
* cell instance $8444 r0 *1 186.39,159.6
X$8444 5736 8480 8482 7939 320 219 8590 OAI22_X2
* cell instance $8445 r0 *1 188.1,159.6
X$8445 7945 8480 8482 8001 320 219 8591 OAI22_X2
* cell instance $8446 r0 *1 189.81,159.6
X$8446 7628 8592 7949 1019 219 320 8534 AOI22_X1
* cell instance $8447 r0 *1 190.76,159.6
X$8447 3640 219 320 8592 INV_X1
* cell instance $8448 r0 *1 191.14,159.6
X$8448 8483 8123 8379 1019 7406 8668 320 219 AOI221_X2
* cell instance $8449 r0 *1 193.23,159.6
X$8449 8484 2807 219 320 8594 NAND2_X1
* cell instance $8450 r0 *1 193.8,159.6
X$8450 8595 3640 8482 5841 320 219 8665 OAI22_X2
* cell instance $8454 r0 *1 199.5,159.6
X$8454 219 8596 7528 8656 7874 8489 320 OR4_X4
* cell instance $8455 m0 *1 201.21,159.6
X$8455 8524 219 320 8485 BUF_X1
* cell instance $8456 m0 *1 200.64,159.6
X$8456 7546 219 320 8525 BUF_X1
* cell instance $8457 m0 *1 201.78,159.6
X$8457 8487 8490 8486 219 8383 320 AOI21_X1
* cell instance $8458 m0 *1 202.54,159.6
X$8458 2524 8523 8388 320 219 8487 HA_X1
* cell instance $8459 m0 *1 204.44,159.6
X$8459 8491 4010 8385 320 219 8386 HA_X1
* cell instance $8460 m0 *1 206.34,159.6
X$8460 8521 8387 219 320 8492 NAND2_X1
* cell instance $8461 m0 *1 206.91,159.6
X$8461 8470 8219 8519 320 219 8390 HA_X1
* cell instance $8462 m0 *1 208.81,159.6
X$8462 8518 3640 8650 320 219 8391 HA_X1
* cell instance $8463 m0 *1 210.71,159.6
X$8463 8417 8497 8391 219 8648 320 AOI21_X1
* cell instance $8467 m0 *1 215.46,159.6
X$8467 219 13045 8512 8513 8314 320 DFF_X1
* cell instance $8468 m0 *1 218.69,159.6
X$8468 8610 7420 8512 219 320 8499 MUX2_X1
* cell instance $8469 m0 *1 220.02,159.6
X$8469 8314 219 320 14750 INV_X1
* cell instance $8471 r0 *1 201.97,159.6
X$8471 8524 8599 8488 219 8656 320 AOI21_X2
* cell instance $8472 r0 *1 203.3,159.6
X$8472 8525 219 320 8524 BUF_X2
* cell instance $8475 r0 *1 204.63,159.6
X$8475 219 8603 8493 8492 8599 320 NOR3_X4
* cell instance $8477 r0 *1 207.67,159.6
X$8477 8650 8519 8604 8606 219 8603 320 NAND4_X2
* cell instance $8478 r0 *1 209.38,159.6
X$8478 8388 219 320 8494 BUF_X1
* cell instance $8479 r0 *1 209.95,159.6
X$8479 8519 219 320 8497 BUF_X1
* cell instance $8480 r0 *1 210.52,159.6
X$8480 8516 8608 8648 320 8607 219 OAI21_X1
* cell instance $8481 r0 *1 211.28,159.6
X$8481 8647 8497 219 320 8516 NAND2_X1
* cell instance $8484 r0 *1 215.27,159.6
X$8484 219 13678 8610 8641 8314 320 DFF_X1
* cell instance $8485 r0 *1 218.5,159.6
X$8485 8498 6740 8512 219 320 8513 MUX2_X1
* cell instance $8486 r0 *1 219.83,159.6
X$8486 8498 6843 8632 219 320 8634 MUX2_X1
* cell instance $8488 m0 *1 220.78,159.6
X$8488 8498 6860 8511 219 320 8637 MUX2_X1
* cell instance $8490 r0 *1 221.16,159.6
X$8490 219 13791 8511 8637 7958 320 DFF_X1
* cell instance $8493 m0 *1 228.76,159.6
X$8493 219 12832 8394 8509 8501 320 DFF_X1
* cell instance $8495 m0 *1 231.99,159.6
X$8495 8500 7751 8395 219 320 8397 MUX2_X1
* cell instance $8497 m0 *1 233.51,159.6
X$8497 8500 7749 8504 219 320 8502 MUX2_X1
* cell instance $8499 m0 *1 235.03,159.6
X$8499 8504 8503 8398 219 320 8301 MUX2_X1
* cell instance $8500 m0 *1 236.36,159.6
X$8500 8500 7753 8398 219 320 8407 MUX2_X1
* cell instance $8501 m0 *1 237.69,159.6
X$8501 8506 219 320 7289 BUF_X1
* cell instance $8505 r0 *1 230.09,159.6
X$8505 8500 7750 8394 219 320 8509 MUX2_X1
* cell instance $8509 r0 *1 231.42,159.6
X$8509 8840 7420 8611 219 320 8628 MUX2_X1
* cell instance $8511 r0 *1 233.13,159.6
X$8511 219 13819 8504 8502 8501 320 DFF_X1
* cell instance $8513 r0 *1 236.74,159.6
X$8513 8399 219 320 8072 BUF_X1
* cell instance $8516 r0 *1 237.88,159.6
X$8516 8495 219 320 8402 BUF_X1
* cell instance $8518 m0 *1 238.83,159.6
X$8518 8297 219 320 8401 BUF_X1
* cell instance $8521 m0 *1 239.97,159.6
X$8521 8505 219 320 8188 BUF_X2
* cell instance $8526 m0 *1 198.74,44.8
X$8526 219 12820 1334 1354 1053 320 DFF_X1
* cell instance $8528 m0 *1 201.97,44.8
X$8528 219 12983 1244 1287 1248 320 DFF_X1
* cell instance $8529 m0 *1 205.2,44.8
X$8529 1246 1120 1335 219 320 1291 MUX2_X1
* cell instance $8530 m0 *1 206.53,44.8
X$8530 1246 1057 1244 219 320 1287 MUX2_X1
* cell instance $8532 m0 *1 208.62,44.8
X$8532 1185 1210 219 320 1247 OR2_X1
* cell instance $8533 m0 *1 209.38,44.8
X$8533 1185 1283 219 320 1337 OR2_X1
* cell instance $8534 m0 *1 210.14,44.8
X$8534 1250 1112 1249 219 320 1283 MUX2_X1
* cell instance $8535 m0 *1 211.47,44.8
X$8535 1251 929 1249 219 320 1187 MUX2_X1
* cell instance $8536 m0 *1 212.8,44.8
X$8536 1251 927 1250 219 320 1338 MUX2_X1
* cell instance $8539 r0 *1 198.55,44.8
X$8539 219 14037 1333 1355 1248 320 DFF_X1
* cell instance $8540 r0 *1 201.78,44.8
X$8540 219 14214 1335 1291 1248 320 DFF_X1
* cell instance $8541 r0 *1 205.01,44.8
X$8541 1335 1113 1244 219 320 1439 MUX2_X1
* cell instance $8542 r0 *1 206.34,44.8
X$8542 1185 1352 219 320 1353 OR2_X1
* cell instance $8543 r0 *1 207.1,44.8
X$8543 1349 1112 1336 219 320 1352 MUX2_X1
* cell instance $8544 r0 *1 208.43,44.8
X$8544 1247 1407 1115 320 219 1350 OAI21_X4
* cell instance $8546 r0 *1 211.28,44.8
X$8546 1241 320 929 219 BUF_X4
* cell instance $8547 r0 *1 212.61,44.8
X$8547 219 14004 1250 1338 1188 320 DFF_X1
* cell instance $8549 m0 *1 219.26,44.8
X$8549 1251 1120 1276 219 320 1189 MUX2_X1
* cell instance $8550 m0 *1 216.03,44.8
X$8550 219 12924 1346 1279 1188 320 DFF_X1
* cell instance $8551 m0 *1 220.59,44.8
X$8551 1190 1057 1253 219 320 1252 MUX2_X1
* cell instance $8552 m0 *1 221.92,44.8
X$8552 1065 1201 219 320 1339 OR2_X1
* cell instance $8553 m0 *1 222.68,44.8
X$8553 1190 1120 1268 219 320 1273 MUX2_X1
* cell instance $8554 m0 *1 224.01,44.8
X$8554 219 12606 1268 1273 1001 320 DFF_X1
* cell instance $8558 r0 *1 216.41,44.8
X$8558 1251 1057 1346 219 320 1279 MUX2_X1
* cell instance $8560 r0 *1 218.5,44.8
X$8560 1276 1113 1346 219 320 1345 MUX2_X1
* cell instance $8562 r0 *1 220.59,44.8
X$8562 219 14199 1253 1252 1001 320 DFF_X1
* cell instance $8563 r0 *1 223.82,44.8
X$8563 1268 1113 1253 219 320 1433 MUX2_X1
* cell instance $8566 r0 *1 228.38,44.8
X$8566 1267 1119 1257 320 219 1343 OAI21_X4
* cell instance $8567 m0 *1 229.33,44.8
X$8567 1065 1264 219 320 1267 OR2_X1
* cell instance $8569 m0 *1 230.09,44.8
X$8569 1254 1057 1255 219 320 1194 MUX2_X1
* cell instance $8570 m0 *1 231.42,44.8
X$8570 1258 1069 1255 219 320 1257 MUX2_X1
* cell instance $8572 m0 *1 233.51,44.8
X$8572 1254 1120 1258 219 320 1265 MUX2_X1
* cell instance $8573 m0 *1 234.84,44.8
X$8573 1341 932 1259 219 320 1264 MUX2_X1
* cell instance $8582 r0 *1 234.08,44.8
X$8582 1254 927 1341 219 320 1342 MUX2_X1
* cell instance $8583 r0 *1 235.41,44.8
X$8583 219 14172 1341 1342 1124 320 DFF_X1
* cell instance $8584 r0 *1 238.64,44.8
X$8584 1260 219 320 1125 BUF_X1
* cell instance $8587 m0 *1 123.69,218.4
X$8587 219 12915 11942 11998 11911 320 DFF_X1
* cell instance $8589 m0 *1 126.92,218.4
X$8589 219 12911 11804 11913 11911 320 DFF_X1
* cell instance $8595 r0 *1 123.69,218.4
X$8595 3222 320 1954 219 BUF_X4
* cell instance $8597 r0 *1 125.21,218.4
X$8597 11853 7691 11942 219 320 11998 MUX2_X1
* cell instance $8602 r0 *1 129.39,218.4
X$8602 9425 219 320 11911 CLKBUF_X3
* cell instance $8603 r0 *1 130.34,218.4
X$8603 11943 7691 12038 219 320 12037 MUX2_X1
* cell instance $8606 r0 *1 132.24,218.4
X$8606 12038 11387 11973 219 320 11974 MUX2_X1
* cell instance $8608 r0 *1 136.61,218.4
X$8608 12107 11387 12007 219 320 11946 MUX2_X1
* cell instance $8611 r0 *1 139.65,218.4
X$8611 12040 11387 12041 219 320 11861 MUX2_X1
* cell instance $8612 m0 *1 140.79,218.4
X$8612 11836 11949 12525 320 219 11950 HA_X1
* cell instance $8613 m0 *1 140.41,218.4
X$8613 11471 219 320 11949 INV_X1
* cell instance $8614 m0 *1 142.69,218.4
X$8614 11950 11976 219 320 10678 NOR2_X2
* cell instance $8618 r0 *1 140.98,218.4
X$8618 11975 219 320 11836 INV_X2
* cell instance $8619 r0 *1 141.55,218.4
X$8619 11836 11471 11977 320 219 11976 HA_X1
* cell instance $8620 r0 *1 143.45,218.4
X$8620 11976 12008 219 320 10941 NOR2_X2
* cell instance $8624 r0 *1 145.73,218.4
X$8624 12010 11977 12044 219 320 12043 MUX2_X1
* cell instance $8625 r0 *1 147.06,218.4
X$8625 11977 12071 219 320 12070 NAND2_X1
* cell instance $8627 m0 *1 148.01,218.4
X$8627 11790 219 320 CLKBUF_X1
* cell instance $8629 m0 *1 148.58,218.4
X$8629 219 12956 11809 11951 11790 320 DFF_X1
* cell instance $8635 r0 *1 160.55,218.4
X$8635 10642 320 3243 219 BUF_X4
* cell instance $8637 m0 *1 161.31,218.4
X$8637 10664 11813 10679 219 320 11959 OR3_X1
* cell instance $8643 r0 *1 163.21,218.4
X$8643 12006 12013 12003 219 12048 320 AOI21_X1
* cell instance $8644 r0 *1 163.97,218.4
X$8644 12049 12048 12052 9386 219 320 12050 NOR4_X1
* cell instance $8645 r0 *1 164.92,218.4
X$8645 12004 11967 12005 11978 12052 320 219 AOI211_X2
* cell instance $8646 m0 *1 165.11,218.4
X$8646 11963 11962 11643 10679 11978 219 320 OAI211_X2
* cell instance $8648 m0 *1 166.82,218.4
X$8648 10543 11493 219 320 11965 NOR2_X1
* cell instance $8649 m0 *1 167.39,218.4
X$8649 11968 11865 11887 10679 219 320 12003 NAND4_X1
* cell instance $8650 m0 *1 168.34,218.4
X$8650 11757 11980 219 320 11968 NOR2_X1
* cell instance $8652 m0 *1 169.1,218.4
X$8652 7469 12122 11799 219 320 11980 OR3_X2
* cell instance $8653 m0 *1 170.24,218.4
X$8653 11916 11980 11979 9390 11465 320 219 AOI211_X2
* cell instance $8656 m0 *1 173.66,218.4
X$8656 11813 10543 219 320 11970 OR2_X1
* cell instance $8657 m0 *1 174.42,218.4
X$8657 11970 11969 11917 320 11981 219 OAI21_X1
* cell instance $8659 m0 *1 175.37,218.4
X$8659 219 12002 11982 11972 11702 320 DFF_X1
* cell instance $8660 m0 *1 178.6,218.4
X$8660 9383 219 320 11702 CLKBUF_X3
* cell instance $8662 r0 *1 166.63,218.4
X$8662 11687 11979 219 320 12006 NAND2_X1
* cell instance $8663 r0 *1 167.2,218.4
X$8663 11963 219 320 12013 INV_X1
* cell instance $8664 r0 *1 167.58,218.4
X$8664 11561 11687 12013 11979 219 320 12004 AOI22_X2
* cell instance $8665 r0 *1 169.29,218.4
X$8665 219 11561 11980 11979 9390 320 AOI21_X4
* cell instance $8666 r0 *1 171.76,218.4
X$8666 12056 320 11644 219 BUF_X4
* cell instance $8668 r0 *1 174.61,218.4
X$8668 219 12059 11918 11981 11702 320 DFF_X1
* cell instance $8673 r0 *1 178.6,218.4
X$8673 11982 219 320 11543 CLKBUF_X3
* cell instance $8674 r0 *1 179.55,218.4
X$8674 12059 219 320 8595 CLKBUF_X3
* cell instance $8675 m0 *1 180.12,218.4
X$8675 12002 320 5841 219 BUF_X4
* cell instance $8681 r0 *1 182.21,218.4
X$8681 219 11562 11983 10054 11889 320 AOI21_X4
* cell instance $8683 m0 *1 182.59,218.4
X$8683 11919 219 320 11983 INV_X1
* cell instance $8684 m0 *1 183.16,218.4
X$8684 11983 10054 11889 219 11923 320 AOI21_X2
* cell instance $8686 m0 *1 184.68,218.4
X$8686 11920 11923 11620 219 11761 320 AOI21_X2
* cell instance $8687 m0 *1 186.01,218.4
X$8687 11961 11877 219 320 11921 NOR2_X1
* cell instance $8688 m0 *1 186.58,218.4
X$8688 11921 11954 11955 11879 11984 320 219 AOI211_X2
* cell instance $8689 m0 *1 188.29,218.4
X$8689 11952 12001 10642 219 320 11954 NAND3_X1
* cell instance $8690 m0 *1 189.05,218.4
X$8690 11922 11923 11620 219 320 11948 MUX2_X1
* cell instance $8691 m0 *1 190.38,218.4
X$8691 11948 320 11570 219 BUF_X4
* cell instance $8695 m0 *1 204.06,218.4
X$8695 219 13144 11986 12058 11924 320 DFF_X1
* cell instance $8696 m0 *1 207.29,218.4
X$8696 9818 219 320 11924 CLKBUF_X3
* cell instance $8697 m0 *1 208.24,218.4
X$8697 12000 11941 219 320 12057 NOR2_X1
* cell instance $8699 m0 *1 209,218.4
X$8699 11987 219 320 11999 CLKBUF_X2
* cell instance $8701 m0 *1 209.95,218.4
X$8701 12020 11997 11925 219 11988 320 AOI21_X1
* cell instance $8702 m0 *1 210.71,218.4
X$8702 11986 219 320 11941 INV_X1
* cell instance $8704 m0 *1 211.85,218.4
X$8704 11999 219 320 11995 INV_X1
* cell instance $8705 m0 *1 212.23,218.4
X$8705 11938 11997 11935 219 320 11926 MUX2_X1
* cell instance $8706 m0 *1 213.56,218.4
X$8706 11933 11995 11940 320 11938 219 OAI21_X1
* cell instance $8708 m0 *1 214.51,218.4
X$8708 11925 11927 11992 320 219 11934 HA_X1
* cell instance $8709 m0 *1 216.41,218.4
X$8709 11934 219 320 12025 BUF_X2
* cell instance $8710 m0 *1 217.17,218.4
X$8710 11992 219 320 11933 INV_X1
* cell instance $8713 r0 *1 184.87,218.4
X$8713 11923 11888 219 320 11920 NOR2_X1
* cell instance $8715 r0 *1 185.63,218.4
X$8715 11889 11888 320 219 11876 AND2_X1
* cell instance $8717 r0 *1 186.58,218.4
X$8717 11876 11620 219 320 12001 NAND2_X1
* cell instance $8719 r0 *1 187.34,218.4
X$8719 11620 11919 11889 11922 219 320 11878 AOI22_X1
* cell instance $8721 r0 *1 188.48,218.4
X$8721 12014 219 320 11888 BUF_X1
* cell instance $8726 r0 *1 196.46,218.4
X$8726 3243 11923 320 219 12063 AND2_X1
* cell instance $8730 r0 *1 199.88,218.4
X$8730 219 12061 12000 12063 11924 320 DFF_X1
* cell instance $8731 r0 *1 203.11,218.4
X$8731 219 14687 12016 12017 11924 320 DFF_X1
* cell instance $8732 r0 *1 206.34,218.4
X$8732 12055 12000 12116 320 219 11989 HA_X1
* cell instance $8734 r0 *1 208.43,218.4
X$8734 11925 11989 12051 320 219 12018 HA_X1
* cell instance $8735 r0 *1 210.33,218.4
X$8735 12047 12021 11988 219 11985 320 AOI21_X1
* cell instance $8737 r0 *1 211.28,218.4
X$8737 10496 12039 320 219 12024 AND2_X1
* cell instance $8738 r0 *1 212.04,218.4
X$8738 11926 12021 11996 12042 11993 11990 320 219 AOI221_X2
* cell instance $8739 r0 *1 214.13,218.4
X$8739 12023 11940 12027 320 11996 219 OAI21_X1
* cell instance $8740 r0 *1 214.89,218.4
X$8740 11933 11989 219 320 11940 NAND2_X1
* cell instance $8741 r0 *1 215.46,218.4
X$8741 11991 11883 320 219 12036 XNOR2_X1
* cell instance $8742 r0 *1 216.6,218.4
X$8742 11925 11927 12541 320 219 12029 HA_X1
* cell instance $8743 m0 *1 218.12,218.4
X$8743 11927 219 320 11993 INV_X1
* cell instance $8759 r0 *1 233.32,218.4
X$8759 9758 219 320 12032 BUF_X1
* cell instance $8762 r0 *1 234.46,218.4
X$8762 9849 219 320 12030 BUF_X1
* cell instance $8764 m0 *1 236.55,218.4
X$8764 9279 219 320 11994 BUF_X1
* cell instance $8768 m0 *1 239.4,218.4
X$8768 11932 219 320 11422 BUF_X1
* cell instance $8769 m0 *1 239.97,218.4
X$8769 11931 219 320 10607 BUF_X1
* cell instance $8776 m0 *1 172.52,58.8
X$8776 219 12944 1950 1851 1661 320 DFF_X1
* cell instance $8777 m0 *1 171.19,58.8
X$8777 236 1852 1950 219 320 1851 MUX2_X1
* cell instance $8779 r0 *1 171.19,58.8
X$8779 219 14317 2002 2134 1661 320 DFF_X1
* cell instance $8781 r0 *1 174.61,58.8
X$8781 236 2057 2002 219 320 2134 MUX2_X1
* cell instance $8786 m0 *1 176.32,58.8
X$8786 219 13029 1897 1951 1668 320 DFF_X1
* cell instance $8788 m0 *1 179.55,58.8
X$8788 1856 1407 1854 320 219 1998 OAI21_X4
* cell instance $8790 r0 *1 177.46,58.8
X$8790 334 2053 2058 219 320 2130 MUX2_X1
* cell instance $8791 r0 *1 178.79,58.8
X$8791 1897 1775 2126 219 320 2059 MUX2_X1
* cell instance $8793 r0 *1 180.88,58.8
X$8793 334 2057 2126 219 320 2060 MUX2_X1
* cell instance $8796 m0 *1 182.4,58.8
X$8796 545 219 320 1668 CLKBUF_X3
* cell instance $8797 m0 *1 183.54,58.8
X$8797 219 12740 1995 1895 1668 320 DFF_X1
* cell instance $8801 m0 *1 190.76,58.8
X$8801 587 1662 1991 219 320 1992 MUX2_X1
* cell instance $8802 m0 *1 192.09,58.8
X$8802 219 12761 1991 1992 1952 320 DFF_X1
* cell instance $8805 r0 *1 182.97,58.8
X$8805 219 13684 2119 2118 1668 320 DFF_X1
* cell instance $8806 r0 *1 186.2,58.8
X$8806 322 1662 2119 219 320 2118 MUX2_X1
* cell instance $8808 r0 *1 187.72,58.8
X$8808 219 13696 2114 2115 1952 320 DFF_X1
* cell instance $8810 r0 *1 191.33,58.8
X$8810 587 1493 2063 219 320 2111 MUX2_X1
* cell instance $8812 r0 *1 192.85,58.8
X$8812 219 13778 2063 2111 1952 320 DFF_X1
* cell instance $8814 r0 *1 196.27,58.8
X$8814 219 13787 2064 2106 1670 320 DFF_X1
* cell instance $8815 m0 *1 197.41,58.8
X$8815 219 12834 2103 1986 1670 320 DFF_X1
* cell instance $8817 m0 *1 200.64,58.8
X$8817 219 12838 1857 1981 1670 320 DFF_X1
* cell instance $8818 m0 *1 203.87,58.8
X$8818 1858 932 1857 219 320 1980 MUX2_X1
* cell instance $8823 r0 *1 199.69,58.8
X$8823 1953 2053 2103 219 320 1986 MUX2_X1
* cell instance $8825 r0 *1 201.21,58.8
X$8825 2064 1113 2103 219 320 2100 MUX2_X1
* cell instance $8826 r0 *1 202.54,58.8
X$8826 1953 2057 1857 219 320 1981 MUX2_X1
* cell instance $8828 r0 *1 204.06,58.8
X$8828 1185 1980 219 320 2097 OR2_X1
* cell instance $8831 r0 *1 207.1,58.8
X$8831 2065 320 932 219 BUF_X4
* cell instance $8832 m0 *1 208.62,58.8
X$8832 1779 1859 1978 219 320 1979 MUX2_X1
* cell instance $8833 m0 *1 207.86,58.8
X$8833 1954 1979 320 219 1888 AND2_X1
* cell instance $8834 m0 *1 209.95,58.8
X$8834 1807 1779 12526 320 219 1974 HA_X1
* cell instance $8835 m0 *1 211.85,58.8
X$8835 1956 1862 219 320 1977 NAND2_X1
* cell instance $8836 m0 *1 212.42,58.8
X$8836 1975 320 1330 219 BUF_X4
* cell instance $8837 m0 *1 213.75,58.8
X$8837 1956 1863 219 320 1975 NAND2_X1
* cell instance $8839 m0 *1 215.08,58.8
X$8839 219 13382 1865 1957 1501 320 DFF_X1
* cell instance $8840 m0 *1 218.31,58.8
X$8840 1782 1408 1865 219 320 1957 MUX2_X1
* cell instance $8841 m0 *1 219.64,58.8
X$8841 1501 219 320 CLKBUF_X1
* cell instance $8842 m0 *1 220.21,58.8
X$8842 1879 1069 1867 219 320 1972 MUX2_X1
* cell instance $8843 m0 *1 221.54,58.8
X$8843 219 13235 1867 1880 1501 320 DFF_X1
* cell instance $8846 m0 *1 226.48,58.8
X$8846 2067 1408 1969 219 320 1971 MUX2_X1
* cell instance $8847 m0 *1 227.81,58.8
X$8847 219 13528 1969 1971 1698 320 DFF_X1
* cell instance $8849 m0 *1 231.23,58.8
X$8849 1968 1870 2072 320 219 1970 MUX2_X2
* cell instance $8851 m0 *1 234.46,58.8
X$8851 1869 219 320 1680 CLKBUF_X3
* cell instance $8852 m0 *1 235.41,58.8
X$8852 1958 1596 2172 219 320 1959 MUX2_X1
* cell instance $8856 r0 *1 209.57,58.8
X$8856 1956 1861 219 320 1955 NAND2_X1
* cell instance $8857 r0 *1 210.14,58.8
X$8857 1955 320 1182 219 BUF_X4
* cell instance $8858 r0 *1 211.47,58.8
X$8858 1977 320 1181 219 BUF_X4
* cell instance $8859 r0 *1 212.8,58.8
X$8859 2093 320 1241 219 BUF_X4
* cell instance $8860 r0 *1 214.13,58.8
X$8860 1956 1974 219 320 2093 NAND2_X1
* cell instance $8863 r0 *1 217.93,58.8
X$8863 1869 219 320 1501 CLKBUF_X3
* cell instance $8864 r0 *1 218.88,58.8
X$8864 1065 1866 219 320 2087 OR2_X1
* cell instance $8869 r0 *1 224.77,58.8
X$8869 219 14696 2068 2066 1698 320 DFF_X1
* cell instance $8872 r0 *1 229.9,58.8
X$8872 2067 1677 2070 219 320 2071 MUX2_X1
* cell instance $8878 r0 *1 234.46,58.8
X$8878 2073 1781 1960 219 320 2075 MUX2_X1
* cell instance $8879 r0 *1 235.79,58.8
X$8879 219 13743 1960 2075 1680 320 DFF_X1
* cell instance $8881 m0 *1 237.12,58.8
X$8881 1960 1596 1961 219 320 2274 MUX2_X1
* cell instance $8882 m0 *1 239.02,58.8
X$8882 1963 219 320 1410 BUF_X1
* cell instance $8885 r0 *1 239.02,58.8
X$8885 2074 219 320 2067 BUF_X1
* cell instance $8886 r0 *1 239.59,58.8
X$8886 1962 219 320 2073 BUF_X1
* cell instance $8887 m0 *1 240.16,58.8
X$8887 1964 219 320 1592 BUF_X1
* cell instance $8893 m0 *1 13.11,109.2
X$8893 219 13352 5170 5169 5287 320 DFF_X1
* cell instance $8894 m0 *1 11.78,109.2
X$8894 4987 4445 5171 219 320 5240 MUX2_X1
* cell instance $8896 m0 *1 16.53,109.2
X$8896 4987 3990 4986 219 320 4985 MUX2_X1
* cell instance $8898 m0 *1 18.05,109.2
X$8898 5241 2731 4986 219 320 5092 MUX2_X1
* cell instance $8900 m0 *1 20.14,109.2
X$8900 5241 3955 5094 219 320 5288 MUX2_X1
* cell instance $8912 r0 *1 12.54,109.2
X$8912 219 14120 5171 5240 5287 320 DFF_X1
* cell instance $8916 r0 *1 17.86,109.2
X$8916 219 13963 5241 5288 5290 320 DFF_X1
* cell instance $8918 r0 *1 21.47,109.2
X$8918 219 13755 5093 5291 5290 320 DFF_X1
* cell instance $8920 m0 *1 21.85,109.2
X$8920 4987 4359 5093 219 320 5291 MUX2_X1
* cell instance $8922 m0 *1 27.74,109.2
X$8922 5094 4237 5243 219 320 5292 MUX2_X1
* cell instance $8924 r0 *1 24.7,109.2
X$8924 5345 4058 5093 219 320 5295 MUX2_X1
* cell instance $8927 r0 *1 26.98,109.2
X$8927 219 14020 5243 5292 4802 320 DFF_X1
* cell instance $8929 m0 *1 29.45,109.2
X$8929 4987 4277 5095 219 320 5242 MUX2_X1
* cell instance $8930 r0 *1 30.21,109.2
X$8930 5295 3126 5346 219 320 5299 MUX2_X1
* cell instance $8931 m0 *1 31.35,109.2
X$8931 4987 4278 5098 219 320 5096 MUX2_X1
* cell instance $8933 m0 *1 32.68,109.2
X$8933 219 12594 5098 5096 5097 320 DFF_X1
* cell instance $8940 r0 *1 35.72,109.2
X$8940 5094 3993 5297 219 320 5296 MUX2_X1
* cell instance $8941 r0 *1 37.05,109.2
X$8941 5098 2657 5297 219 320 5300 MUX2_X1
* cell instance $8942 r0 *1 38.38,109.2
X$8942 5099 4006 5094 219 320 5298 MUX2_X1
* cell instance $8943 m0 *1 38.76,109.2
X$8943 219 13604 5099 5298 4990 320 DFF_X1
* cell instance $8945 m0 *1 41.99,109.2
X$8945 5244 5180 4854 219 320 4993 NAND3_X2
* cell instance $8948 r0 *1 39.71,109.2
X$8948 5301 4003 5300 219 320 5178 MUX2_X1
* cell instance $8950 r0 *1 41.42,109.2
X$8950 5299 4992 219 320 5244 NAND2_X1
* cell instance $8951 r0 *1 41.99,109.2
X$8951 3679 219 320 4990 CLKBUF_X3
* cell instance $8952 r0 *1 42.94,109.2
X$8952 4990 219 320 CLKBUF_X1
* cell instance $8954 m0 *1 45.41,109.2
X$8954 4904 219 320 3679 CLKBUF_X3
* cell instance $8959 r0 *1 46.93,109.2
X$8959 219 14194 5100 5302 5388 320 DFF_X1
* cell instance $8960 m0 *1 48.45,109.2
X$8960 5094 4364 5100 219 320 5302 MUX2_X1
* cell instance $8962 m0 *1 49.78,109.2
X$8962 5100 3950 5245 219 320 5101 MUX2_X1
* cell instance $8966 r0 *1 50.16,109.2
X$8966 5094 4282 5245 219 320 5304 MUX2_X1
* cell instance $8967 r0 *1 51.49,109.2
X$8967 219 14040 5245 5304 5388 320 DFF_X1
* cell instance $8969 r0 *1 55.1,109.2
X$8969 4996 320 2842 219 BUF_X4
* cell instance $8970 m0 *1 56.24,109.2
X$8970 4996 320 1520 219 BUF_X4
* cell instance $8972 m0 *1 57.57,109.2
X$8972 5185 219 320 5103 BUF_X1
* cell instance $8974 m0 *1 58.33,109.2
X$8974 219 13441 5188 5186 5107 320 DFF_X1
* cell instance $8976 r0 *1 56.43,109.2
X$8976 4996 320 1377 219 BUF_X4
* cell instance $8977 r0 *1 57.76,109.2
X$8977 219 4996 320 5102 BUF_X8
* cell instance $8980 r0 *1 60.8,109.2
X$8980 5247 4058 5188 219 320 5104 MUX2_X1
* cell instance $8982 m0 *1 61.94,109.2
X$8982 5105 2772 5106 219 320 5191 MUX2_X1
* cell instance $8983 r0 *1 62.13,109.2
X$8983 219 13980 5106 5246 5107 320 DFF_X1
* cell instance $8987 m0 *1 63.84,109.2
X$8987 219 13346 5247 5307 5108 320 DFF_X1
* cell instance $8989 m0 *1 67.07,109.2
X$8989 5103 219 320 4611 BUF_X2
* cell instance $8990 m0 *1 67.83,109.2
X$8990 219 13398 5109 5310 5108 320 DFF_X1
* cell instance $8992 m0 *1 71.82,109.2
X$8992 5110 2731 5349 219 320 5197 MUX2_X1
* cell instance $8994 m0 *1 73.91,109.2
X$8994 5110 3659 4611 219 320 5249 MUX2_X1
* cell instance $8996 m0 *1 76,109.2
X$8996 4808 4072 5111 219 320 5250 MUX2_X1
* cell instance $8998 r0 *1 65.36,109.2
X$8998 5247 3735 4611 219 320 5307 MUX2_X1
* cell instance $9000 r0 *1 67.45,109.2
X$9000 5103 4559 5109 219 320 5310 MUX2_X1
* cell instance $9001 r0 *1 68.78,109.2
X$9001 5103 4617 5392 219 320 5248 MUX2_X1
* cell instance $9002 r0 *1 70.11,109.2
X$9002 219 14242 5349 5393 5108 320 DFF_X1
* cell instance $9003 r0 *1 73.34,109.2
X$9003 219 14227 5110 5249 5108 320 DFF_X1
* cell instance $9004 r0 *1 76.57,109.2
X$9004 219 14626 5111 5250 5315 320 DFF_X1
* cell instance $9005 m0 *1 77.9,109.2
X$9005 219 13391 5317 5316 5315 320 DFF_X1
* cell instance $9009 m0 *1 82.08,109.2
X$9009 5111 3365 5069 219 320 5114 MUX2_X1
* cell instance $9010 m0 *1 83.41,109.2
X$9010 4707 4163 5251 219 320 5318 MUX2_X1
* cell instance $9012 m0 *1 85.5,109.2
X$9012 3723 219 320 4966 CLKBUF_X3
* cell instance $9013 m0 *1 86.45,109.2
X$9013 219 13637 5113 5204 5112 320 DFF_X1
* cell instance $9014 m0 *1 89.68,109.2
X$9014 5113 3659 4707 219 320 5204 MUX2_X1
* cell instance $9016 m0 *1 91.2,109.2
X$9016 5114 2672 5115 219 320 5205 MUX2_X1
* cell instance $9017 m0 *1 92.53,109.2
X$9017 5205 5117 219 320 5206 NAND2_X1
* cell instance $9020 r0 *1 79.99,109.2
X$9020 4808 4559 5317 219 320 5316 MUX2_X1
* cell instance $9021 r0 *1 81.32,109.2
X$9021 219 14212 5251 5318 4966 320 DFF_X1
* cell instance $9022 r0 *1 84.55,109.2
X$9022 5317 3766 5251 219 320 5116 MUX2_X1
* cell instance $9026 r0 *1 92.53,109.2
X$9026 5114 2665 2752 219 320 5324 NOR3_X1
* cell instance $9028 m0 *1 93.67,109.2
X$9028 2669 5116 2575 5115 320 219 5323 OAI22_X1
* cell instance $9032 m0 *1 96.33,109.2
X$9032 219 12742 5119 5209 5009 320 DFF_X1
* cell instance $9033 m0 *1 99.56,109.2
X$9033 5119 5120 4915 219 320 5210 MUX2_X1
* cell instance $9035 m0 *1 101.08,109.2
X$9035 5121 5077 5210 219 320 5252 MUX2_X1
* cell instance $9036 m0 *1 102.41,109.2
X$9036 3856 219 320 5009 CLKBUF_X3
* cell instance $9037 m0 *1 103.36,109.2
X$9037 5009 219 320 CLKBUF_X1
* cell instance $9040 r0 *1 94.05,109.2
X$9040 5323 5118 5324 219 320 5322 NOR3_X1
* cell instance $9045 r0 *1 99.18,109.2
X$9045 5217 320 3214 219 BUF_X4
* cell instance $9046 r0 *1 100.51,109.2
X$9046 219 13908 5326 5399 5009 320 DFF_X1
* cell instance $9048 r0 *1 103.93,109.2
X$9048 5326 320 2243 219 BUF_X4
* cell instance $9051 m0 *1 107.54,109.2
X$9051 5123 5254 4973 219 320 5255 MUX2_X1
* cell instance $9055 r0 *1 107.73,109.2
X$9055 5329 5253 5255 219 320 5328 MUX2_X1
* cell instance $9057 m0 *1 110.58,109.2
X$9057 219 12859 5124 5125 5126 320 DFF_X1
* cell instance $9058 m0 *1 109.25,109.2
X$9058 4916 5254 5124 219 320 5329 MUX2_X1
* cell instance $9063 r0 *1 111.15,109.2
X$9063 4812 4617 5256 219 320 5330 MUX2_X1
* cell instance $9066 m0 *1 116.47,109.2
X$9066 4812 4255 5127 219 320 5214 MUX2_X1
* cell instance $9067 m0 *1 115.71,109.2
X$9067 4812 219 320 4917 BUF_X2
* cell instance $9068 m0 *1 117.8,109.2
X$9068 219 12808 5127 5214 5126 320 DFF_X1
* cell instance $9070 m0 *1 121.79,109.2
X$9070 5127 5217 5013 219 320 5128 MUX2_X1
* cell instance $9071 m0 *1 123.12,109.2
X$9071 5128 4367 5220 219 320 5129 MUX2_X1
* cell instance $9072 m0 *1 124.45,109.2
X$9072 4976 5217 5130 219 320 5220 MUX2_X1
* cell instance $9076 r0 *1 115.71,109.2
X$9076 4812 4072 5257 219 320 5331 MUX2_X1
* cell instance $9086 r0 *1 128.63,109.2
X$9086 1902 219 320 5259 CLKBUF_X3
* cell instance $9088 r0 *1 130.34,109.2
X$9088 219 14502 5261 5260 5259 320 DFF_X1
* cell instance $9090 m0 *1 130.72,109.2
X$9090 219 12568 5132 5222 5259 320 DFF_X1
* cell instance $9092 r0 *1 133.57,109.2
X$9092 5014 4505 5132 219 320 5222 MUX2_X1
* cell instance $9094 r0 *1 135.28,109.2
X$9094 219 14694 5262 5333 5358 320 DFF_X1
* cell instance $9096 m0 *1 135.85,109.2
X$9096 1160 4890 5262 219 320 5333 MUX2_X1
* cell instance $9097 m0 *1 140.22,109.2
X$9097 219 12583 5133 5223 4793 320 DFF_X1
* cell instance $9098 m0 *1 143.45,109.2
X$9098 5225 4623 5133 219 320 5223 MUX2_X1
* cell instance $9099 m0 *1 144.78,109.2
X$9099 219 13629 5227 5134 4793 320 DFF_X1
* cell instance $9100 m0 *1 148.01,109.2
X$9100 3605 5264 219 320 5229 OR2_X1
* cell instance $9101 m0 *1 148.77,109.2
X$9101 2243 5408 219 320 5228 XNOR2_X2
* cell instance $9102 m0 *1 150.67,109.2
X$9102 5229 3746 5337 320 219 4084 OAI21_X2
* cell instance $9105 r0 *1 138.51,109.2
X$9105 5225 4819 5263 219 320 5334 MUX2_X1
* cell instance $9106 r0 *1 139.84,109.2
X$9106 219 13933 5263 5334 4793 320 DFF_X1
* cell instance $9107 r0 *1 143.07,109.2
X$9107 5263 4718 5133 219 320 5264 MUX2_X1
* cell instance $9108 r0 *1 144.4,109.2
X$9108 5225 4625 5265 219 320 5335 MUX2_X1
* cell instance $9109 r0 *1 145.73,109.2
X$9109 219 14535 5265 5335 4793 320 DFF_X1
* cell instance $9110 r0 *1 148.96,109.2
X$9110 5227 4718 5265 219 320 5337 MUX2_X1
* cell instance $9112 r0 *1 150.67,109.2
X$9112 5340 4890 5339 219 320 5266 MUX2_X1
* cell instance $9115 r0 *1 152.57,109.2
X$9115 5340 4625 5232 219 320 5135 MUX2_X1
* cell instance $9116 m0 *1 153.33,109.2
X$9116 5339 4584 5232 219 320 5267 MUX2_X1
* cell instance $9123 r0 *1 155.23,109.2
X$9123 219 14232 5341 5268 4629 320 DFF_X1
* cell instance $9125 m0 *1 155.8,109.2
X$9125 5131 5173 320 219 5268 AND2_X1
* cell instance $9127 m0 *1 160.36,109.2
X$9127 5023 4464 219 320 5137 NOR2_X1
* cell instance $9128 m0 *1 160.93,109.2
X$9128 5137 5138 5237 219 320 5234 NOR3_X1
* cell instance $9129 m0 *1 161.69,109.2
X$9129 4470 2139 4459 5024 320 219 5237 OAI22_X1
* cell instance $9130 m0 *1 162.64,109.2
X$9130 5236 5342 5139 219 320 5140 NOR3_X1
* cell instance $9131 m0 *1 163.4,109.2
X$9131 4596 1542 3784 5235 320 219 5138 OAI22_X1
* cell instance $9133 m0 *1 164.54,109.2
X$9133 5023 4306 219 320 5142 NOR2_X1
* cell instance $9134 m0 *1 165.11,109.2
X$9134 5142 5141 5269 219 320 5143 NOR3_X1
* cell instance $9135 m0 *1 165.87,109.2
X$9135 4472 2139 4521 5024 320 219 5338 OAI22_X1
* cell instance $9136 m0 *1 166.82,109.2
X$9136 5023 4725 219 320 5144 NOR2_X1
* cell instance $9138 m0 *1 167.58,109.2
X$9138 5023 4304 219 320 5145 NOR2_X1
* cell instance $9139 m0 *1 168.15,109.2
X$9139 5145 5239 5238 320 3938 219 NOR3_X2
* cell instance $9143 r0 *1 158.46,109.2
X$9143 5341 320 2206 219 BUF_X4
* cell instance $9146 r0 *1 163.21,109.2
X$9146 4308 1542 3925 5235 320 219 5342 OAI22_X1
* cell instance $9148 r0 *1 164.54,109.2
X$9148 4182 1542 3278 5024 320 219 5141 OAI22_X1
* cell instance $9149 r0 *1 165.49,109.2
X$9149 4511 2139 3384 5235 320 219 5269 OAI22_X1
* cell instance $9150 r0 *1 166.44,109.2
X$9150 4346 1542 4631 5235 320 219 5270 OAI22_X1
* cell instance $9151 r0 *1 167.39,109.2
X$9151 5144 5270 5338 219 320 5336 NOR3_X1
* cell instance $9153 m0 *1 174.61,109.2
X$9153 5146 5231 5147 219 320 4931 NOR3_X1
* cell instance $9154 m0 *1 173.66,109.2
X$9154 4740 5148 3609 2526 320 219 5231 OAI22_X1
* cell instance $9156 m0 *1 175.56,109.2
X$9156 4586 5026 4254 723 320 219 5147 OAI22_X1
* cell instance $9157 m0 *1 176.51,109.2
X$9157 4735 5148 4193 2526 320 219 5226 OAI22_X1
* cell instance $9158 m0 *1 177.46,109.2
X$9158 4241 5026 3393 723 320 219 5149 OAI22_X1
* cell instance $9166 r0 *1 176.13,109.2
X$9166 4087 320 3280 219 BUF_X4
* cell instance $9170 r0 *1 180.12,109.2
X$9170 5213 4304 219 320 5271 NOR2_X1
* cell instance $9171 r0 *1 180.69,109.2
X$9171 5271 5272 5332 320 3108 219 NOR3_X2
* cell instance $9172 m0 *1 182.02,109.2
X$9172 5213 4306 219 320 5150 NOR2_X1
* cell instance $9174 m0 *1 182.59,109.2
X$9174 5150 5327 5218 219 320 5212 NOR3_X1
* cell instance $9175 m0 *1 183.35,109.2
X$9175 5404 2808 219 320 268 NOR2_X2
* cell instance $9176 m0 *1 184.3,109.2
X$9176 5213 4464 219 320 5211 NOR2_X1
* cell instance $9177 m0 *1 184.87,109.2
X$9177 4179 1030 4193 1444 320 219 5151 OAI22_X1
* cell instance $9178 m0 *1 185.82,109.2
X$9178 5211 5325 5151 219 320 5030 NOR3_X1
* cell instance $9181 m0 *1 195.7,109.2
X$9181 4834 219 320 14757 INV_X1
* cell instance $9182 m0 *1 196.08,109.2
X$9182 219 12566 5154 5200 4557 320 DFF_X1
* cell instance $9184 r0 *1 182.02,109.2
X$9184 4740 5275 3925 5274 320 219 5273 OAI22_X1
* cell instance $9185 r0 *1 182.97,109.2
X$9185 4736 5275 4239 5274 320 219 5327 OAI22_X1
* cell instance $9187 r0 *1 184.3,109.2
X$9187 4735 5275 4241 5274 320 219 5325 OAI22_X1
* cell instance $9190 r0 *1 192.09,109.2
X$9190 4245 3816 219 320 5396 NOR2_X1
* cell instance $9191 r0 *1 192.66,109.2
X$9191 5321 3163 219 320 5294 NOR2_X1
* cell instance $9195 r0 *1 195.89,109.2
X$9195 219 14507 5276 5320 4834 320 DFF_X1
* cell instance $9197 r0 *1 199.31,109.2
X$9197 5154 5277 5276 219 320 5319 MUX2_X1
* cell instance $9198 m0 *1 199.88,109.2
X$9198 5155 5447 5154 219 320 5200 MUX2_X1
* cell instance $9204 r0 *1 201.59,109.2
X$9204 5445 5319 219 320 5278 OR2_X1
* cell instance $9206 m0 *1 202.54,109.2
X$9206 5155 5036 5156 219 320 5199 MUX2_X1
* cell instance $9208 m0 *1 203.87,109.2
X$9208 5155 5198 5279 219 320 5280 MUX2_X1
* cell instance $9211 r0 *1 202.73,109.2
X$9211 5279 5277 5156 219 320 5370 MUX2_X1
* cell instance $9212 r0 *1 204.06,109.2
X$9212 219 14598 5279 5280 5314 320 DFF_X1
* cell instance $9213 r0 *1 207.29,109.2
X$9213 5313 5161 5312 320 219 4082 OAI21_X4
* cell instance $9214 m0 *1 208.81,109.2
X$9214 5034 5198 5157 219 320 5196 MUX2_X1
* cell instance $9216 m0 *1 210.14,109.2
X$9216 219 12599 5157 5196 5158 320 DFF_X1
* cell instance $9219 m0 *1 214.32,109.2
X$9219 219 13031 5037 5194 5158 320 DFF_X1
* cell instance $9220 m0 *1 217.55,109.2
X$9220 5158 219 320 CLKBUF_X1
* cell instance $9222 m0 *1 221.16,109.2
X$9222 219 12930 5305 5187 5544 320 DFF_X1
* cell instance $9223 m0 *1 224.39,109.2
X$9223 5039 5162 5305 219 320 5187 MUX2_X1
* cell instance $9225 r0 *1 209.76,109.2
X$9225 5157 5277 5035 219 320 5312 MUX2_X1
* cell instance $9226 r0 *1 211.09,109.2
X$9226 219 14604 5373 5311 5158 320 DFF_X1
* cell instance $9227 r0 *1 214.32,109.2
X$9227 3987 5198 5281 219 320 5309 MUX2_X1
* cell instance $9229 r0 *1 216.03,109.2
X$9229 219 14487 5281 5309 5158 320 DFF_X1
* cell instance $9232 r0 *1 219.83,109.2
X$9232 5308 5445 5159 320 219 5274 OAI21_X4
* cell instance $9235 r0 *1 222.87,109.2
X$9235 5160 320 5036 219 BUF_X4
* cell instance $9236 r0 *1 224.2,109.2
X$9236 4322 5306 219 320 5308 OR2_X1
* cell instance $9237 r0 *1 224.96,109.2
X$9237 5305 4531 5040 219 320 5306 MUX2_X1
* cell instance $9238 m0 *1 226.29,109.2
X$9238 219 12952 5042 5182 5043 320 DFF_X1
* cell instance $9240 m0 *1 229.52,109.2
X$9240 5162 320 2831 219 BUF_X4
* cell instance $9242 m0 *1 231.04,109.2
X$9242 5160 320 3081 219 BUF_X4
* cell instance $9243 m0 *1 232.37,109.2
X$9243 4747 4942 5163 219 320 5179 MUX2_X1
* cell instance $9246 r0 *1 226.67,109.2
X$9246 5041 4530 5042 219 320 5183 MUX2_X1
* cell instance $9253 r0 *1 232.18,109.2
X$9253 1869 219 320 5043 CLKBUF_X3
* cell instance $9254 r0 *1 233.13,109.2
X$9254 5286 219 320 5034 BUF_X1
* cell instance $9255 r0 *1 233.7,109.2
X$9255 5043 219 320 CLKBUF_X1
* cell instance $9257 m0 *1 234.08,109.2
X$9257 5177 3624 5164 320 219 5026 OAI21_X4
* cell instance $9258 m0 *1 236.74,109.2
X$9258 219 13122 5166 5293 5165 320 DFF_X1
* cell instance $9262 r0 *1 234.65,109.2
X$9262 5303 219 320 5289 BUF_X1
* cell instance $9263 r0 *1 235.22,109.2
X$9263 3173 5283 219 320 5177 OR2_X1
* cell instance $9264 r0 *1 235.98,109.2
X$9264 4747 5162 5048 219 320 5282 MUX2_X1
* cell instance $9265 r0 *1 237.31,109.2
X$9265 5294 219 320 5378 BUF_X1
* cell instance $9267 r0 *1 238.26,109.2
X$9267 4747 5160 5166 219 320 5293 MUX2_X1
* cell instance $9268 r0 *1 239.59,109.2
X$9268 5285 219 320 5284 BUF_X1
* cell instance $9269 r0 *1 240.16,109.2
X$9269 5380 219 320 5155 BUF_X1
* cell instance $9271 m0 *1 13.11,117.6
X$9271 219 13354 5599 5652 5287 320 DFF_X1
* cell instance $9274 m0 *1 16.53,117.6
X$9274 4051 219 320 5287 CLKBUF_X3
* cell instance $9275 m0 *1 17.48,117.6
X$9275 5600 2731 5555 219 320 5708 MUX2_X1
* cell instance $9276 m0 *1 18.81,117.6
X$9276 5708 2659 5763 219 320 5602 MUX2_X1
* cell instance $9279 m0 *1 21.85,117.6
X$9279 219 13403 5601 5654 5290 320 DFF_X1
* cell instance $9287 m0 *1 5.7,117.6
X$9287 5707 219 320 5613 BUF_X2
* cell instance $9295 r0 *1 16.15,117.6
X$9295 5599 2957 5552 219 320 5763 MUX2_X1
* cell instance $9299 m0 *1 28.5,117.6
X$9299 219 12885 5417 5656 5097 320 DFF_X1
* cell instance $9301 m0 *1 34.96,117.6
X$9301 219 12629 5658 5659 5710 320 DFF_X1
* cell instance $9303 m0 *1 38.95,117.6
X$9303 5661 4003 5657 219 320 5663 MUX2_X1
* cell instance $9304 m0 *1 40.28,117.6
X$9304 219 12961 5603 5662 5710 320 DFF_X1
* cell instance $9307 m0 *1 55.67,117.6
X$9307 5667 5801 5711 219 320 5666 MUX2_X1
* cell instance $9308 m0 *1 57,117.6
X$9308 5667 1392 5605 219 320 5769 MUX2_X1
* cell instance $9309 m0 *1 58.33,117.6
X$9309 5772 1392 6003 219 320 5771 MUX2_X1
* cell instance $9310 m0 *1 59.66,117.6
X$9310 5769 1651 5771 219 320 5669 MUX2_X1
* cell instance $9314 m0 *1 63.46,117.6
X$9314 219 13350 5713 5712 5107 320 DFF_X1
* cell instance $9317 m0 *1 67.64,117.6
X$9317 4238 320 4559 219 BUF_X4
* cell instance $9318 m0 *1 68.97,117.6
X$9318 5776 2095 5673 219 320 5672 MUX2_X1
* cell instance $9319 m0 *1 70.3,117.6
X$9319 219 13356 5717 5715 5716 320 DFF_X1
* cell instance $9325 r0 *1 33.25,117.6
X$9325 219 14544 5929 5709 5097 320 DFF_X1
* cell instance $9326 r0 *1 36.48,117.6
X$9326 5803 5804 5991 219 320 5805 MUX2_X1
* cell instance $9330 r0 *1 41.8,117.6
X$9330 3679 219 320 5710 CLKBUF_X3
* cell instance $9331 r0 *1 42.75,117.6
X$9331 5710 219 320 14791 INV_X1
* cell instance $9334 r0 *1 44.27,117.6
X$9334 5803 5808 5868 219 320 5809 MUX2_X1
* cell instance $9339 r0 *1 48.45,117.6
X$9339 5810 320 1374 219 BUF_X4
* cell instance $9342 r0 *1 56.05,117.6
X$9342 5605 6207 5711 219 320 5507 MUX2_X1
* cell instance $9343 r0 *1 57.38,117.6
X$9343 219 14264 5772 5872 5107 320 DFF_X1
* cell instance $9351 r0 *1 63.46,117.6
X$9351 5713 5864 5711 219 320 5712 MUX2_X1
* cell instance $9352 r0 *1 64.79,117.6
X$9352 5711 5808 5508 219 320 5670 MUX2_X1
* cell instance $9355 r0 *1 66.69,117.6
X$9355 5714 6110 5711 219 320 5873 MUX2_X1
* cell instance $9356 r0 *1 68.02,117.6
X$9356 5713 1844 5714 219 320 5776 MUX2_X1
* cell instance $9358 r0 *1 69.54,117.6
X$9358 5711 5804 5717 219 320 5715 MUX2_X1
* cell instance $9359 r0 *1 70.87,117.6
X$9359 219 14052 5811 5875 5716 320 DFF_X1
* cell instance $9361 m0 *1 75.62,117.6
X$9361 5678 3860 5607 219 320 5676 MUX2_X1
* cell instance $9363 m0 *1 76.95,117.6
X$9363 5509 5120 5607 219 320 5876 MUX2_X1
* cell instance $9365 m0 *1 78.85,117.6
X$9365 5678 4497 5718 219 320 5679 MUX2_X1
* cell instance $9367 m0 *1 80.18,117.6
X$9367 5718 5120 5574 219 320 5719 MUX2_X1
* cell instance $9371 r0 *1 80.94,117.6
X$9371 5876 5077 5719 219 320 5720 MUX2_X1
* cell instance $9372 r0 *1 82.27,117.6
X$9372 5720 5517 5934 219 320 5721 MUX2_X1
* cell instance $9374 m0 *1 83.41,117.6
X$9374 219 2029 5669 6052 5672 2031 320 AOI22_X4
* cell instance $9376 m0 *1 88.35,117.6
X$9376 5814 3659 5514 219 320 5883 MUX2_X1
* cell instance $9377 m0 *1 89.68,117.6
X$9377 5511 219 320 5514 BUF_X2
* cell instance $9381 m0 *1 95.76,117.6
X$9381 5781 4127 219 320 5686 NOR2_X1
* cell instance $9385 m0 *1 103.36,117.6
X$9385 5426 219 320 14729 INV_X1
* cell instance $9386 m0 *1 103.74,117.6
X$9386 3856 219 320 5426 CLKBUF_X3
* cell instance $9387 m0 *1 104.69,117.6
X$9387 5721 5421 5723 320 5608 219 OAI21_X1
* cell instance $9388 m0 *1 105.45,117.6
X$9388 5724 5608 219 320 5784 OR2_X1
* cell instance $9389 m0 *1 106.21,117.6
X$9389 2248 219 320 5723 INV_X1
* cell instance $9390 m0 *1 106.59,117.6
X$9390 5117 5609 5785 320 5691 219 OAI21_X1
* cell instance $9391 m0 *1 107.35,117.6
X$9391 5350 219 320 5479 CLKBUF_X3
* cell instance $9396 r0 *1 84.93,117.6
X$9396 5517 2672 2151 219 320 NOR2_X4
* cell instance $9397 r0 *1 86.64,117.6
X$9397 219 14243 5814 5883 5112 320 DFF_X1
* cell instance $9398 r0 *1 89.87,117.6
X$9398 5514 4161 5887 219 320 5780 MUX2_X1
* cell instance $9399 r0 *1 91.2,117.6
X$9399 219 14193 5887 5780 5112 320 DFF_X1
* cell instance $9403 r0 *1 99.37,117.6
X$9403 219 4177 5815 5946 5722 320 AOI21_X4
* cell instance $9405 r0 *1 102.03,117.6
X$9405 2239 5722 219 320 5818 XOR2_X1
* cell instance $9407 r0 *1 103.36,117.6
X$9407 5783 5477 5421 219 320 5891 NOR3_X1
* cell instance $9409 r0 *1 104.31,117.6
X$9409 2206 5892 219 320 5783 XOR2_X1
* cell instance $9411 r0 *1 105.83,117.6
X$9411 5723 5721 5819 219 5785 320 AOI21_X1
* cell instance $9413 r0 *1 106.78,117.6
X$9413 219 14677 5787 5821 5426 320 DFF_X1
* cell instance $9415 m0 *1 108.68,117.6
X$9415 5725 5784 5691 5610 219 5823 320 NAND4_X2
* cell instance $9419 r0 *1 110.39,117.6
X$9419 219 14170 5947 5824 5519 320 DFF_X1
* cell instance $9421 r0 *1 114,117.6
X$9421 5820 4497 5726 219 320 5825 MUX2_X1
* cell instance $9422 m0 *1 114.76,117.6
X$9422 3856 219 320 5519 CLKBUF_X3
* cell instance $9428 r0 *1 115.71,117.6
X$9428 5820 4163 5949 219 320 5950 MUX2_X1
* cell instance $9429 r0 *1 117.04,117.6
X$9429 5519 219 320 CLKBUF_X1
* cell instance $9431 r0 *1 118.37,117.6
X$9431 5897 3659 5727 219 320 5896 MUX2_X1
* cell instance $9437 m0 *1 119.89,117.6
X$9437 5216 5611 2534 320 5692 219 OAI21_X1
* cell instance $9438 m0 *1 120.84,117.6
X$9438 5216 5611 5617 219 320 NOR2_X4
* cell instance $9442 r0 *1 121.22,117.6
X$9442 5728 3496 5727 219 320 5899 MUX2_X1
* cell instance $9447 r0 *1 125.21,117.6
X$9447 5727 4163 5953 219 320 5826 MUX2_X1
* cell instance $9449 r0 *1 128.06,117.6
X$9449 5592 4294 5730 219 320 5900 MUX2_X1
* cell instance $9450 r0 *1 129.39,117.6
X$9450 219 14523 5730 5900 5729 320 DFF_X1
* cell instance $9451 m0 *1 133,117.6
X$9451 5592 4505 5794 219 320 5791 MUX2_X1
* cell instance $9452 m0 *1 129.77,117.6
X$9452 219 12633 5794 5791 5729 320 DFF_X1
* cell instance $9455 m0 *1 137.56,117.6
X$9455 5358 219 320 CLKBUF_X1
* cell instance $9456 m0 *1 138.13,117.6
X$9456 5428 219 320 5358 CLKBUF_X3
* cell instance $9457 m0 *1 139.08,117.6
X$9457 5613 4623 5526 219 320 5699 MUX2_X1
* cell instance $9459 r0 *1 132.62,117.6
X$9459 5730 4136 5794 219 320 5612 MUX2_X1
* cell instance $9462 r0 *1 140.22,117.6
X$9462 219 13737 5731 5795 5358 320 DFF_X1
* cell instance $9463 m0 *1 140.98,117.6
X$9463 5613 4625 5731 219 320 5795 MUX2_X1
* cell instance $9466 m0 *1 142.88,117.6
X$9466 5527 5828 5731 219 320 5615 MUX2_X1
* cell instance $9471 m0 *1 144.59,117.6
X$9471 5528 4921 5615 219 320 5829 MUX2_X1
* cell instance $9472 m0 *1 146.68,117.6
X$9472 5340 4819 5433 219 320 5616 MUX2_X1
* cell instance $9473 m0 *1 148.01,117.6
X$9473 5340 4623 5529 219 320 5596 MUX2_X1
* cell instance $9475 m0 *1 149.53,117.6
X$9475 223 4819 5797 219 320 5618 MUX2_X1
* cell instance $9479 r0 *1 146.11,117.6
X$9479 2248 5829 320 219 5830 XNOR2_X1
* cell instance $9483 r0 *1 149.91,117.6
X$9483 5732 219 320 5531 CLKBUF_X3
* cell instance $9484 r0 *1 150.86,117.6
X$9484 5531 219 320 CLKBUF_X1
* cell instance $9486 m0 *1 151.24,117.6
X$9486 223 4623 5733 219 320 5530 MUX2_X1
* cell instance $9489 m0 *1 152.95,117.6
X$9489 5797 6027 5733 219 320 5734 MUX2_X1
* cell instance $9491 m0 *1 155.99,117.6
X$9491 5734 4921 5735 219 320 5915 MUX2_X1
* cell instance $9492 m0 *1 154.66,117.6
X$9492 5703 5832 5435 219 320 5735 MUX2_X1
* cell instance $9493 m0 *1 157.32,117.6
X$9493 3138 5734 219 320 5799 OR2_X1
* cell instance $9498 r0 *1 155.8,117.6
X$9498 5619 219 320 14710 INV_X2
* cell instance $9499 r0 *1 156.37,117.6
X$9499 2244 5915 219 320 6065 XNOR2_X2
* cell instance $9500 r0 *1 158.27,117.6
X$9500 5732 219 320 5619 CLKBUF_X3
* cell instance $9502 m0 *1 159.22,117.6
X$9502 5799 3262 5735 320 219 5024 OAI21_X2
* cell instance $9503 m0 *1 161.31,117.6
X$9503 5410 4358 219 320 5798 NOR2_X1
* cell instance $9507 m0 *1 162.26,117.6
X$9507 5798 5622 5705 320 5706 219 NOR3_X2
* cell instance $9508 m0 *1 163.78,117.6
X$9508 5410 4721 219 320 5438 NOR2_X1
* cell instance $9511 m0 *1 165.3,117.6
X$9511 4596 219 320 4179 CLKBUF_X3
* cell instance $9512 m0 *1 166.25,117.6
X$9512 4596 320 3868 219 BUF_X4
* cell instance $9513 m0 *1 167.58,117.6
X$9513 4725 219 320 4721 CLKBUF_X3
* cell instance $9515 m0 *1 168.72,117.6
X$9515 5737 4358 219 320 5624 NOR2_X1
* cell instance $9516 m0 *1 169.29,117.6
X$9516 5737 4355 219 320 5738 NOR2_X1
* cell instance $9517 m0 *1 169.86,117.6
X$9517 5737 4268 219 320 5792 NOR2_X1
* cell instance $9518 m0 *1 170.43,117.6
X$9518 5737 4081 219 320 5626 NOR2_X1
* cell instance $9519 m0 *1 171,117.6
X$9519 5696 5793 219 320 5796 NAND2_X1
* cell instance $9524 r0 *1 163.97,117.6
X$9524 5623 320 5488 219 BUF_X4
* cell instance $9528 r0 *1 166.63,117.6
X$9528 5736 219 320 4521 CLKBUF_X3
* cell instance $9531 r0 *1 168.15,117.6
X$9531 4179 1281 3337 5834 320 219 5836 OAI22_X1
* cell instance $9532 r0 *1 169.1,117.6
X$9532 219 433 3866 5796 5790 320 AOI21_X4
* cell instance $9533 r0 *1 171.57,117.6
X$9533 5738 5917 5627 219 320 5739 NOR3_X1
* cell instance $9534 r0 *1 172.33,117.6
X$9534 4883 5534 3516 5440 320 219 5917 OAI22_X1
* cell instance $9535 m0 *1 172.9,117.6
X$9535 5792 5628 5698 219 320 5629 NOR3_X1
* cell instance $9537 m0 *1 173.66,117.6
X$9537 4521 5625 3693 5741 320 219 5740 OAI22_X1
* cell instance $9538 m0 *1 174.61,117.6
X$9538 219 3422 5623 5789 5788 320 AOI21_X4
* cell instance $9539 m0 *1 177.08,117.6
X$9539 3781 5625 3608 5741 320 219 5630 OAI22_X1
* cell instance $9540 m0 *1 178.03,117.6
X$9540 5630 5742 219 320 5693 NOR2_X1
* cell instance $9541 m0 *1 178.6,117.6
X$9541 219 259 5632 5786 5693 320 AOI21_X4
* cell instance $9546 r0 *1 173.85,117.6
X$9546 5837 5625 3275 5741 320 219 5912 OAI22_X1
* cell instance $9547 r0 *1 174.8,117.6
X$9547 5912 5911 219 320 5790 NOR2_X1
* cell instance $9552 r0 *1 175.56,117.6
X$9552 5697 5740 219 320 5788 NOR2_X1
* cell instance $9554 r0 *1 176.32,117.6
X$9554 3280 2762 3506 1998 320 219 5911 OAI22_X1
* cell instance $9556 r0 *1 177.65,117.6
X$9556 3788 5625 3565 5741 320 219 5908 OAI22_X1
* cell instance $9558 r0 *1 178.98,117.6
X$9558 3393 2762 3271 1998 320 219 5840 OAI22_X1
* cell instance $9559 r0 *1 179.93,117.6
X$9559 5696 5902 219 320 5786 NAND2_X1
* cell instance $9560 r0 *1 180.5,117.6
X$9560 4135 219 320 3979 CLKBUF_X3
* cell instance $9563 r0 *1 182.02,117.6
X$9563 5841 320 3784 219 BUF_X4
* cell instance $9564 m0 *1 183.54,117.6
X$9564 4304 219 320 3398 CLKBUF_X3
* cell instance $9565 m0 *1 182.21,117.6
X$9565 5623 320 3163 219 BUF_X4
* cell instance $9566 m0 *1 184.49,117.6
X$9566 5736 320 4828 219 BUF_X4
* cell instance $9568 m0 *1 186.01,117.6
X$9568 5744 3162 219 320 5633 NOR2_X1
* cell instance $9569 m0 *1 186.58,117.6
X$9569 5633 5743 5782 219 320 5634 NOR3_X1
* cell instance $9570 m0 *1 187.34,117.6
X$9570 4522 717 3666 2609 320 219 5782 OAI22_X1
* cell instance $9571 m0 *1 188.29,117.6
X$9571 5744 3703 219 320 5779 NOR2_X1
* cell instance $9573 r0 *1 183.35,117.6
X$9573 4306 219 320 3705 CLKBUF_X3
* cell instance $9574 r0 *1 184.3,117.6
X$9574 4464 219 320 3703 CLKBUF_X3
* cell instance $9576 r0 *1 185.44,117.6
X$9576 5632 320 3702 219 BUF_X4
* cell instance $9577 r0 *1 186.77,117.6
X$9577 4828 5842 3513 5843 320 219 5743 OAI22_X1
* cell instance $9579 r0 *1 187.91,117.6
X$9579 3650 717 3468 2609 320 219 5846 OAI22_X1
* cell instance $9581 r0 *1 189.05,117.6
X$9581 4735 5842 3784 5843 320 219 5745 OAI22_X1
* cell instance $9582 m0 *1 189.43,117.6
X$9582 5779 5745 5635 219 320 5777 NOR3_X1
* cell instance $9584 m0 *1 190.19,117.6
X$9584 5744 3705 219 320 5685 NOR2_X1
* cell instance $9585 m0 *1 190.76,117.6
X$9585 3977 717 3978 2609 320 219 5778 OAI22_X1
* cell instance $9588 m0 *1 194.94,117.6
X$9588 2534 5774 219 320 5636 XNOR2_X2
* cell instance $9589 m0 *1 196.84,117.6
X$9589 219 12964 5637 5682 4834 320 DFF_X1
* cell instance $9590 m0 *1 200.07,117.6
X$9590 5539 5447 5748 219 320 5775 MUX2_X1
* cell instance $9592 m0 *1 201.59,117.6
X$9592 219 12978 5749 5773 5314 320 DFF_X1
* cell instance $9593 m0 *1 204.82,117.6
X$9593 5749 5277 5540 219 320 5638 MUX2_X1
* cell instance $9594 m0 *1 206.15,117.6
X$9594 5445 5750 219 320 5770 OR2_X1
* cell instance $9595 m0 *1 206.91,117.6
X$9595 5770 5161 5674 320 219 5741 OAI21_X2
* cell instance $9596 m0 *1 208.24,117.6
X$9596 5751 5036 5671 219 320 5541 MUX2_X1
* cell instance $9598 r0 *1 190,117.6
X$9598 4736 5842 3785 5843 320 219 5746 OAI22_X1
* cell instance $9599 r0 *1 190.95,117.6
X$9599 3871 717 3979 2609 320 219 5848 OAI22_X1
* cell instance $9600 r0 *1 191.9,117.6
X$9600 5685 5746 5848 219 320 5881 NOR3_X1
* cell instance $9602 r0 *1 194.18,117.6
X$9602 2206 5879 320 219 6006 XNOR2_X1
* cell instance $9604 r0 *1 195.51,117.6
X$9604 2248 6004 320 219 5884 XNOR2_X1
* cell instance $9605 r0 *1 196.65,117.6
X$9605 5777 5570 219 320 5766 NOR2_X1
* cell instance $9607 r0 *1 197.6,117.6
X$9607 219 14398 5748 5775 4834 320 DFF_X1
* cell instance $9609 r0 *1 201.21,117.6
X$9609 5681 5369 5638 219 320 5879 MUX2_X1
* cell instance $9611 r0 *1 203.3,117.6
X$9611 5539 5198 5749 219 320 5773 MUX2_X1
* cell instance $9615 r0 *1 207.1,117.6
X$9615 219 14365 5850 5874 5314 320 DFF_X1
* cell instance $9616 m0 *1 210.14,117.6
X$9616 5751 5448 5753 219 320 5768 MUX2_X1
* cell instance $9618 m0 *1 211.47,117.6
X$9618 219 12974 5753 5768 5752 320 DFF_X1
* cell instance $9621 r0 *1 210.33,117.6
X$9621 5751 5447 5871 219 320 5852 MUX2_X1
* cell instance $9623 r0 *1 211.85,117.6
X$9623 5871 5639 5753 219 320 5750 MUX2_X1
* cell instance $9627 r0 *1 215.27,117.6
X$9627 219 13833 5754 5870 5752 320 DFF_X1
* cell instance $9628 m0 *1 219.07,117.6
X$9628 5754 5639 5641 219 320 5853 MUX2_X1
* cell instance $9629 m0 *1 215.84,117.6
X$9629 219 12941 5641 5668 5752 320 DFF_X1
* cell instance $9630 m0 *1 220.4,117.6
X$9630 5643 5639 5755 219 320 5645 MUX2_X1
* cell instance $9632 r0 *1 218.5,117.6
X$9632 219 14327 5643 5644 5752 320 DFF_X1
* cell instance $9633 r0 *1 221.73,117.6
X$9633 5642 5448 5755 219 320 5866 MUX2_X1
* cell instance $9634 m0 *1 222.3,117.6
X$9634 219 12932 5545 5767 5752 320 DFF_X1
* cell instance $9638 m0 *1 226.86,117.6
X$9638 219 12935 5660 5646 5544 320 DFF_X1
* cell instance $9639 m0 *1 225.91,117.6
X$9639 5757 219 320 5544 CLKBUF_X3
* cell instance $9640 m0 *1 230.09,117.6
X$9640 5863 3880 5648 219 320 5756 MUX2_X1
* cell instance $9645 r0 *1 227.24,117.6
X$9645 5544 219 320 CLKBUF_X1
* cell instance $9648 r0 *1 229.52,117.6
X$9648 5765 4532 5756 320 219 4592 OAI21_X4
* cell instance $9653 r0 *1 232.37,117.6
X$9653 5758 4942 5863 219 320 5865 MUX2_X1
* cell instance $9655 m0 *1 233.32,117.6
X$9655 5758 4941 5648 219 320 5655 MUX2_X1
* cell instance $9656 m0 *1 234.84,117.6
X$9656 5650 219 320 5539 BUF_X1
* cell instance $9657 m0 *1 235.41,117.6
X$9657 4322 5764 219 320 5765 OR2_X1
* cell instance $9658 m0 *1 236.17,117.6
X$9658 5762 219 320 5543 BUF_X1
* cell instance $9660 m0 *1 236.93,117.6
X$9660 5165 219 320 CLKBUF_X1
* cell instance $9661 m0 *1 237.5,117.6
X$9661 5985 4531 5759 219 320 5764 MUX2_X1
* cell instance $9662 m0 *1 238.83,117.6
X$9662 5757 219 320 5165 CLKBUF_X3
* cell instance $9663 m0 *1 239.78,117.6
X$9663 5761 219 320 5760 BUF_X1
* cell instance $9666 r0 *1 233.89,117.6
X$9666 5856 219 320 5751 BUF_X1
* cell instance $9669 r0 *1 235.03,117.6
X$9669 5851 219 320 5854 BUF_X1
* cell instance $9672 r0 *1 236.17,117.6
X$9672 5862 219 320 5858 BUF_X1
* cell instance $9675 r0 *1 237.31,117.6
X$9675 219 14665 5759 5860 5165 320 DFF_X1
* cell instance $9680 r0 *1 151.62,5.6
X$9680 219 13792 296 331 241 320 DFF_X1
* cell instance $9682 m0 *1 166.44,240.8
X$9682 11561 219 320 12463 BUF_X2
* cell instance $9685 m0 *1 167.96,240.8
X$9685 9385 219 320 12460 BUF_X1
* cell instance $9686 m0 *1 168.53,240.8
X$9686 9752 219 320 12451 BUF_X1
* cell instance $9690 m0 *1 5.32,162.4
X$9690 8906 219 320 7578 CLKBUF_X2
* cell instance $9695 m0 *1 13.87,162.4
X$9695 219 12905 8546 8616 8680 320 DFF_X1
* cell instance $9704 r0 *1 9.12,162.4
X$9704 219 14597 8966 8848 8680 320 DFF_X1
* cell instance $9707 r0 *1 14.06,162.4
X$9707 7172 219 320 8680 CLKBUF_X3
* cell instance $9708 r0 *1 15.01,162.4
X$9708 8548 6802 8546 219 320 8616 MUX2_X1
* cell instance $9710 m0 *1 18.43,162.4
X$9710 8547 6902 8548 219 320 8619 MUX2_X1
* cell instance $9713 m0 *1 20.52,162.4
X$9713 8548 7081 8549 219 320 8621 MUX2_X1
* cell instance $9714 m0 *1 21.85,162.4
X$9714 8440 8145 8549 219 320 8970 MUX2_X1
* cell instance $9717 m0 *1 24.13,162.4
X$9717 219 12591 8550 8681 8441 320 DFF_X1
* cell instance $9719 m0 *1 28.88,162.4
X$9719 219 12893 8727 8683 8441 320 DFF_X1
* cell instance $9720 m0 *1 32.11,162.4
X$9720 8551 6207 8552 219 320 8625 MUX2_X1
* cell instance $9725 r0 *1 23.37,162.4
X$9725 8682 6002 8550 219 320 8681 MUX2_X1
* cell instance $9727 r0 *1 25.08,162.4
X$9727 219 14192 8857 8790 8441 320 DFF_X1
* cell instance $9730 r0 *1 28.88,162.4
X$9730 8682 6154 8727 219 320 8683 MUX2_X1
* cell instance $9732 r0 *1 30.4,162.4
X$9732 8551 8791 8727 219 320 8793 MUX2_X1
* cell instance $9735 r0 *1 32.3,162.4
X$9735 8682 5933 8794 219 320 8684 MUX2_X1
* cell instance $9736 r0 *1 33.63,162.4
X$9736 1282 219 320 7765 CLKBUF_X3
* cell instance $9738 r0 *1 34.96,162.4
X$9738 219 13865 8731 8730 8554 320 DFF_X1
* cell instance $9739 m0 *1 35.53,162.4
X$9739 219 13064 8442 8626 7914 320 DFF_X1
* cell instance $9742 r0 *1 38.19,162.4
X$9742 8552 6046 8731 219 320 8730 MUX2_X1
* cell instance $9743 m0 *1 39.33,162.4
X$9743 8552 5804 8629 219 320 8631 MUX2_X1
* cell instance $9745 m0 *1 40.66,162.4
X$9745 219 13066 8629 8631 8554 320 DFF_X1
* cell instance $9746 m0 *1 43.89,162.4
X$9746 8552 6270 8686 219 320 8733 MUX2_X1
* cell instance $9749 m0 *1 49.78,162.4
X$9749 219 13128 8555 8635 7915 320 DFF_X1
* cell instance $9750 m0 *1 53.01,162.4
X$9750 8555 6207 8556 219 320 8635 MUX2_X1
* cell instance $9754 r0 *1 39.9,162.4
X$9754 8553 8729 8629 219 320 8685 MUX2_X1
* cell instance $9756 r0 *1 41.42,162.4
X$9756 219 13888 8686 8733 8554 320 DFF_X1
* cell instance $9757 r0 *1 44.65,162.4
X$9757 219 14021 8797 8687 8554 320 DFF_X1
* cell instance $9761 r0 *1 49.21,162.4
X$9761 219 14606 8688 8870 7915 320 DFF_X1
* cell instance $9765 r0 *1 54.91,162.4
X$9765 219 14594 8689 8638 8446 320 DFF_X1
* cell instance $9766 m0 *1 55.67,162.4
X$9766 8556 6042 8689 219 320 8638 MUX2_X1
* cell instance $9770 m0 *1 58.33,162.4
X$9770 6373 219 320 8446 CLKBUF_X3
* cell instance $9775 r0 *1 58.14,162.4
X$9775 219 14680 8873 8874 8446 320 DFF_X1
* cell instance $9777 r0 *1 62.13,162.4
X$9777 8556 6046 8690 219 320 8875 MUX2_X1
* cell instance $9781 m0 *1 64.79,162.4
X$9781 219 13010 8640 8639 8022 320 DFF_X1
* cell instance $9782 m0 *1 63.46,162.4
X$9782 8640 5864 8556 219 320 8639 MUX2_X1
* cell instance $9784 m0 *1 74.1,162.4
X$9784 8556 6270 8645 219 320 8646 MUX2_X1
* cell instance $9785 m0 *1 75.43,162.4
X$9785 219 13085 8645 8646 8449 320 DFF_X1
* cell instance $9788 m0 *1 80.94,162.4
X$9788 7252 7136 8651 219 320 8741 MUX2_X1
* cell instance $9791 m0 *1 83.98,162.4
X$9791 219 12902 8558 8557 8105 320 DFF_X1
* cell instance $9794 m0 *1 88.16,162.4
X$9794 6373 219 320 8105 CLKBUF_X3
* cell instance $9795 m0 *1 89.11,162.4
X$9795 8105 219 320 CLKBUF_X1
* cell instance $9797 m0 *1 89.87,162.4
X$9797 219 13466 8560 8693 8105 320 DFF_X1
* cell instance $9800 r0 *1 64.22,162.4
X$9800 8556 5804 8691 219 320 8737 MUX2_X1
* cell instance $9801 r0 *1 65.55,162.4
X$9801 219 14407 8691 8737 8022 320 DFF_X1
* cell instance $9804 r0 *1 70.49,162.4
X$9804 6337 320 2719 219 BUF_X4
* cell instance $9807 r0 *1 73.53,162.4
X$9807 8556 5808 8739 219 320 8740 MUX2_X1
* cell instance $9808 r0 *1 74.86,162.4
X$9808 8738 219 320 7252 CLKBUF_X2
* cell instance $9811 r0 *1 76.19,162.4
X$9811 219 13970 8739 8740 8449 320 DFF_X1
* cell instance $9813 r0 *1 80.18,162.4
X$9813 219 14483 8651 8741 8105 320 DFF_X1
* cell instance $9815 r0 *1 83.6,162.4
X$9815 7924 7243 8742 219 320 8692 MUX2_X1
* cell instance $9816 r0 *1 84.93,162.4
X$9816 219 14464 8742 8692 8105 320 DFF_X1
* cell instance $9817 r0 *1 88.16,162.4
X$9817 8810 5254 8812 219 320 8530 MUX2_X1
* cell instance $9820 r0 *1 90.44,162.4
X$9820 8811 7356 8560 219 320 8693 MUX2_X1
* cell instance $9823 m0 *1 93.67,162.4
X$9823 219 13240 8562 8561 7926 320 DFF_X1
* cell instance $9825 m0 *1 96.9,162.4
X$9825 8559 6710 8696 219 320 8695 MUX2_X1
* cell instance $9826 m0 *1 98.23,162.4
X$9826 8563 4566 219 320 8564 NOR2_X1
* cell instance $9830 r0 *1 94.05,162.4
X$9830 219 14583 8694 8813 7926 320 DFF_X1
* cell instance $9832 r0 *1 97.47,162.4
X$9832 219 14536 8696 8695 7926 320 DFF_X1
* cell instance $9833 r0 *1 100.7,162.4
X$9833 219 14545 8565 8744 8992 320 DFF_X1
* cell instance $9834 m0 *1 102.79,162.4
X$9834 8565 6662 8559 219 320 8744 MUX2_X1
* cell instance $9835 m0 *1 101.46,162.4
X$9835 8565 5254 8696 219 320 8453 MUX2_X1
* cell instance $9837 r0 *1 103.93,162.4
X$9837 4127 8884 4566 8994 320 219 8454 OAI22_X1
* cell instance $9838 m0 *1 104.69,162.4
X$9838 8566 7312 8559 219 320 8655 MUX2_X1
* cell instance $9840 m0 *1 106.02,162.4
X$9840 219 13186 8566 8655 8028 320 DFF_X1
* cell instance $9844 m0 *1 114,162.4
X$9844 8423 8278 8459 219 320 8567 MUX2_X1
* cell instance $9847 m0 *1 119.13,162.4
X$9847 219 13592 8569 8658 8456 320 DFF_X1
* cell instance $9849 m0 *1 122.55,162.4
X$9849 219 13431 8570 8750 8033 320 DFF_X1
* cell instance $9851 m0 *1 125.97,162.4
X$9851 219 13260 8749 8661 8033 320 DFF_X1
* cell instance $9852 m0 *1 129.2,162.4
X$9852 8167 8278 8571 219 320 8664 MUX2_X1
* cell instance $9853 m0 *1 130.53,162.4
X$9853 4351 320 8038 219 BUF_X4
* cell instance $9857 r0 *1 105.45,162.4
X$9857 6057 320 6165 219 BUF_X4
* cell instance $9861 r0 *1 109.44,162.4
X$9861 219 5254 2904 320 BUF_X16
* cell instance $9865 r0 *1 115.52,162.4
X$9865 8697 219 320 8456 CLKBUF_X3
* cell instance $9871 r0 *1 119.89,162.4
X$9871 8568 8121 8747 219 320 8698 MUX2_X1
* cell instance $9874 r0 *1 123.12,162.4
X$9874 8568 8278 8570 219 320 8750 MUX2_X1
* cell instance $9878 r0 *1 125.21,162.4
X$9878 8570 7723 8749 219 320 8460 MUX2_X1
* cell instance $9880 m0 *1 132.43,162.4
X$9880 219 13261 8572 8751 8033 320 DFF_X1
* cell instance $9882 m0 *1 135.66,162.4
X$9882 219 12614 8461 8700 7934 320 DFF_X1
* cell instance $9886 m0 *1 143.64,162.4
X$9886 8669 8038 8574 219 320 8754 MUX2_X1
* cell instance $9888 m0 *1 145.16,162.4
X$9888 8669 8040 8467 219 320 8667 MUX2_X1
* cell instance $9894 r0 *1 134.33,162.4
X$9894 8752 8821 8572 219 320 8751 MUX2_X1
* cell instance $9895 r0 *1 135.66,162.4
X$9895 8752 8699 8461 219 320 8700 MUX2_X1
* cell instance $9896 r0 *1 136.99,162.4
X$9896 219 14615 8463 8753 7934 320 DFF_X1
* cell instance $9898 r0 *1 140.98,162.4
X$9898 8669 7691 8823 219 320 8891 MUX2_X1
* cell instance $9901 r0 *1 142.88,162.4
X$9901 219 14655 8574 8754 8465 320 DFF_X1
* cell instance $9902 r0 *1 146.11,162.4
X$9902 8465 219 320 14795 INV_X1
* cell instance $9905 r0 *1 148.77,162.4
X$9905 8701 219 320 8761 INV_X1
* cell instance $9906 r0 *1 149.15,162.4
X$9906 8484 219 320 8757 INV_X1
* cell instance $9907 r0 *1 149.53,162.4
X$9907 8518 8757 8701 320 219 8762 HA_X1
* cell instance $9908 r0 *1 151.43,162.4
X$9908 1282 219 320 7395 CLKBUF_X3
* cell instance $9909 r0 *1 152.38,162.4
X$9909 8761 8759 8702 320 9018 219 OAI21_X1
* cell instance $9910 r0 *1 153.14,162.4
X$9910 8762 219 320 8702 INV_X1
* cell instance $9913 r0 *1 154.47,162.4
X$9913 8479 219 320 8763 INV_X1
* cell instance $9914 r0 *1 154.85,162.4
X$9914 8491 8763 8703 320 219 8704 HA_X1
* cell instance $9917 r0 *1 157.89,162.4
X$9917 8575 8765 8241 219 8764 320 AOI21_X2
* cell instance $9919 m0 *1 159.03,162.4
X$9919 8575 8705 8176 219 8766 320 AOI21_X2
* cell instance $9922 r0 *1 159.79,162.4
X$9922 7889 5959 219 320 8765 NAND2_X1
* cell instance $9923 r0 *1 160.36,162.4
X$9923 7329 5959 219 320 8705 NAND2_X1
* cell instance $9924 m0 *1 160.93,162.4
X$9924 8575 8671 8545 219 8767 320 AOI21_X2
* cell instance $9927 m0 *1 162.45,162.4
X$9927 7147 2866 219 320 8671 NAND2_X1
* cell instance $9928 m0 *1 163.02,162.4
X$9928 8575 8469 8005 219 8769 320 AOI21_X2
* cell instance $9929 m0 *1 164.35,162.4
X$9929 7676 5959 219 320 8772 NAND2_X1
* cell instance $9932 r0 *1 161.31,162.4
X$9932 8939 320 6673 219 BUF_X4
* cell instance $9933 r0 *1 162.64,162.4
X$9933 8293 2866 219 320 8706 NAND2_X1
* cell instance $9936 r0 *1 163.78,162.4
X$9936 8575 8772 7678 219 8770 320 AOI21_X2
* cell instance $9937 r0 *1 165.11,162.4
X$9937 8575 8776 8777 219 8775 320 AOI21_X2
* cell instance $9938 m0 *1 165.49,162.4
X$9938 8583 219 320 8778 INV_X1
* cell instance $9940 m0 *1 165.87,162.4
X$9940 8576 5959 219 320 8776 NAND2_X1
* cell instance $9941 m0 *1 166.44,162.4
X$9941 8708 8577 219 320 8707 NAND2_X1
* cell instance $9942 m0 *1 167.01,162.4
X$9942 8580 8578 8673 320 8579 219 OAI21_X1
* cell instance $9944 m0 *1 167.96,162.4
X$9944 8673 8578 8584 8582 219 8831 320 NAND4_X2
* cell instance $9947 r0 *1 166.82,162.4
X$9947 8707 8778 8579 219 8941 320 AOI21_X2
* cell instance $9948 r0 *1 168.15,162.4
X$9948 8577 8581 8708 8782 219 8895 320 NAND4_X2
* cell instance $9950 m0 *1 171.95,162.4
X$9950 8676 8584 8581 320 8675 219 OAI21_X1
* cell instance $9951 m0 *1 170.05,162.4
X$9951 8518 8677 8584 320 219 8676 HA_X1
* cell instance $9952 m0 *1 172.71,162.4
X$9952 8676 8781 219 320 8784 OR2_X1
* cell instance $9954 m0 *1 173.66,162.4
X$9954 8585 8050 8679 8474 6949 8777 320 219 AOI221_X2
* cell instance $9956 r0 *1 170.24,162.4
X$9956 8709 1020 8582 320 219 8781 HA_X1
* cell instance $9957 r0 *1 172.14,162.4
X$9957 8659 3734 8782 320 219 8783 HA_X1
* cell instance $9958 r0 *1 174.04,162.4
X$9958 8783 219 320 8892 INV_X1
* cell instance $9963 m0 *1 176.32,162.4
X$9963 1019 219 320 8677 INV_X2
* cell instance $9965 m0 *1 176.89,162.4
X$9965 8473 219 320 8475 BUF_X1
* cell instance $9966 m0 *1 177.46,162.4
X$9966 8474 6979 8374 8475 8220 8780 320 219 AOI221_X2
* cell instance $9967 m0 *1 179.55,162.4
X$9967 8475 8056 8587 8474 7106 8771 320 219 AOI221_X2
* cell instance $9970 r0 *1 177.65,162.4
X$9970 219 8779 7051 8889 8780 320 AOI21_X4
* cell instance $9972 r0 *1 180.31,162.4
X$9972 8576 6833 219 320 8773 NAND2_X1
* cell instance $9974 r0 *1 181.07,162.4
X$9974 219 8774 7148 8773 8771 320 AOI21_X4
* cell instance $9976 m0 *1 182.02,162.4
X$9976 7054 320 8049 219 BUF_X4
* cell instance $9978 r0 *1 183.73,162.4
X$9978 6977 8710 6979 8670 219 320 8768 AOI22_X1
* cell instance $9980 m0 *1 183.73,162.4
X$9980 6186 8588 8768 4010 4389 320 219 8711 OAI221_X1
* cell instance $9981 m0 *1 185.06,162.4
X$9981 6187 4010 8589 8588 5837 320 219 8478 OAI221_X1
* cell instance $9983 m0 *1 186.39,162.4
X$9983 1019 8049 8590 8592 7679 8477 320 219 AOI221_X2
* cell instance $9984 m0 *1 188.48,162.4
X$9984 1019 6951 8591 8592 7151 8715 320 219 AOI221_X2
* cell instance $9986 m0 *1 190.76,162.4
X$9986 8484 2810 219 320 8593 NAND2_X1
* cell instance $9987 m0 *1 191.33,162.4
X$9987 7051 8593 8668 219 8622 320 AOI21_X2
* cell instance $9988 m0 *1 192.66,162.4
X$9988 3058 8594 8663 219 8732 320 AOI21_X2
* cell instance $9989 m0 *1 193.99,162.4
X$9989 1019 6982 8665 8483 8380 8663 320 219 AOI221_X2
* cell instance $9991 m0 *1 196.27,162.4
X$9991 8716 6955 8660 219 8745 320 AOI21_X1
* cell instance $9995 r0 *1 184.87,162.4
X$9995 8713 7849 8712 8755 6982 8760 320 219 AOI221_X2
* cell instance $9996 r0 *1 186.96,162.4
X$9996 3058 8538 8760 219 8756 320 AOI21_X2
* cell instance $9997 r0 *1 188.29,162.4
X$9997 8710 219 320 8714 BUF_X1
* cell instance $9998 r0 *1 188.86,162.4
X$9998 8714 219 320 8755 BUF_X1
* cell instance $9999 r0 *1 189.43,162.4
X$9999 8484 6833 219 320 8885 NAND2_X1
* cell instance $10002 r0 *1 191.9,162.4
X$10002 7939 8835 8735 6068 320 219 8881 OAI22_X2
* cell instance $10003 r0 *1 193.61,162.4
X$10003 8056 8746 7740 3905 219 320 8748 AOI22_X1
* cell instance $10004 r0 *1 194.56,162.4
X$10004 7058 1020 8748 8835 4239 320 219 8716 OAI221_X1
* cell instance $10005 r0 *1 195.7,162.4
X$10005 7406 693 2967 7314 219 320 8717 AOI22_X2
* cell instance $10006 r0 *1 197.41,162.4
X$10006 7944 8746 7849 3905 219 320 8837 AOI22_X1
* cell instance $10007 m0 *1 198.36,162.4
X$10007 8745 5979 219 320 8620 NOR2_X1
* cell instance $10010 m0 *1 199.12,162.4
X$10010 7633 8109 8719 8718 219 320 8743 AOI22_X2
* cell instance $10011 m0 *1 200.83,162.4
X$10011 8601 8485 219 320 8719 NOR2_X2
* cell instance $10012 m0 *1 201.78,162.4
X$10012 9069 8601 8597 8736 8598 8657 219 320 OAI221_X2
* cell instance $10013 m0 *1 203.87,162.4
X$10013 8487 8721 8599 219 320 8597 OR3_X1
* cell instance $10014 m0 *1 204.82,162.4
X$10014 8600 8602 9068 8599 219 320 8722 AOI22_X2
* cell instance $10015 m0 *1 206.53,162.4
X$10015 8492 8493 8603 219 320 8601 OR3_X2
* cell instance $10017 m0 *1 207.86,162.4
X$10017 8659 4767 8521 320 219 8649 HA_X1
* cell instance $10018 m0 *1 209.76,162.4
X$10018 8650 219 320 8647 BUF_X1
* cell instance $10020 m0 *1 210.52,162.4
X$10020 8649 219 320 8609 INV_X1
* cell instance $10021 m0 *1 210.9,162.4
X$10021 8734 8644 8609 219 8608 320 AOI21_X1
* cell instance $10024 m0 *1 213.37,162.4
X$10024 1282 219 320 6972 CLKBUF_X3
* cell instance $10030 r0 *1 199.69,162.4
X$10030 4336 4770 3812 4015 320 8488 219 NOR4_X2
* cell instance $10031 r0 *1 201.4,162.4
X$10031 8485 219 320 8720 BUF_X1
* cell instance $10033 r0 *1 202.73,162.4
X$10033 8604 8721 219 320 8486 OR2_X1
* cell instance $10034 r0 *1 203.49,162.4
X$10034 8388 219 320 8490 BUF_X1
* cell instance $10036 r0 *1 204.25,162.4
X$10036 8487 8384 8721 219 8600 320 AOI21_X1
* cell instance $10038 r0 *1 206.53,162.4
X$10038 8605 8607 8604 8494 219 320 8602 NAND4_X1
* cell instance $10039 r0 *1 207.48,162.4
X$10039 8607 8605 320 219 8736 AND2_X1
* cell instance $10042 r0 *1 209.19,162.4
X$10042 3905 219 320 8735 INV_X4
* cell instance $10043 r0 *1 210.14,162.4
X$10043 8709 8735 8606 320 219 8734 HA_X1
* cell instance $10044 r0 *1 212.04,162.4
X$10044 8606 219 320 8644 BUF_X1
* cell instance $10046 m0 *1 216.41,162.4
X$10046 8498 6861 8610 219 320 8641 MUX2_X1
* cell instance $10048 m0 *1 217.74,162.4
X$10048 8636 7957 8499 320 219 7400 OAI21_X4
* cell instance $10049 m0 *1 220.21,162.4
X$10049 219 12773 8632 8634 8314 320 DFF_X1
* cell instance $10050 m0 *1 223.44,162.4
X$10050 8511 8503 8632 219 320 8633 MUX2_X1
* cell instance $10053 r0 *1 218.69,162.4
X$10053 5757 219 320 8314 CLKBUF_X3
* cell instance $10056 r0 *1 220.59,162.4
X$10056 8861 8633 219 320 8636 OR2_X1
* cell instance $10060 r0 *1 226.67,162.4
X$10060 219 8212 7539 320 BUF_X32
* cell instance $10061 m0 *1 231.42,162.4
X$10061 8627 7957 8628 320 219 8434 OAI21_X4
* cell instance $10062 m0 *1 228.19,162.4
X$10062 219 12830 8611 8728 8501 320 DFF_X1
* cell instance $10063 m0 *1 233.89,162.4
X$10063 6410 8624 219 320 8627 OR2_X1
* cell instance $10064 m0 *1 234.65,162.4
X$10064 8841 7753 8612 219 320 8726 MUX2_X1
* cell instance $10065 m0 *1 235.98,162.4
X$10065 8852 8503 8612 219 320 8624 MUX2_X1
* cell instance $10066 m0 *1 237.31,162.4
X$10066 7772 219 320 8618 BUF_X1
* cell instance $10068 m0 *1 238.64,162.4
X$10068 8723 219 320 7609 BUF_X2
* cell instance $10069 m0 *1 239.4,162.4
X$10069 8725 219 320 8617 BUF_X1
* cell instance $10071 m0 *1 240.16,162.4
X$10071 6686 219 320 8507 BUF_X1
* cell instance $10076 r0 *1 235.98,162.4
X$10076 219 13887 8612 8726 8501 320 DFF_X1
* cell instance $10077 r0 *1 239.21,162.4
X$10077 8622 219 320 8614 BUF_X1
* cell instance $10078 r0 *1 239.78,162.4
X$10078 8620 219 320 8615 BUF_X1
* cell instance $10081 m0 *1 157.7,240.8
X$10081 12454 219 320 11063 CLKBUF_X2
* cell instance $10083 m0 *1 158.46,240.8
X$10083 9847 219 320 12456 BUF_X1
* cell instance $10085 m0 *1 159.22,240.8
X$10085 8769 219 320 12480 BUF_X1
* cell instance $10087 m0 *1 159.98,240.8
X$10087 7003 219 320 12458 BUF_X1
* cell instance $10088 m0 *1 160.55,240.8
X$10088 8903 219 320 12459 BUF_X1
* cell instance $10090 m0 *1 161.31,240.8
X$10090 8775 219 320 12461 BUF_X1
* cell instance $10092 m0 *1 162.07,240.8
X$10092 8770 219 320 12462 BUF_X1
* cell instance $10095 m0 *1 5.32,86.8
X$10095 3672 219 320 3674 CLKBUF_X2
* cell instance $10099 m0 *1 10.64,86.8
X$10099 219 13306 3571 3569 3296 320 DFF_X1
* cell instance $10102 m0 *1 15.58,86.8
X$10102 3674 1734 3712 219 320 3805 MUX2_X1
* cell instance $10107 r0 *1 6.08,86.8
X$10107 219 14511 3751 3803 3296 320 DFF_X1
* cell instance $10111 r0 *1 9.31,86.8
X$10111 3674 1547 3751 219 320 3803 MUX2_X1
* cell instance $10113 r0 *1 11.02,86.8
X$10113 3674 1599 3752 219 320 3804 MUX2_X1
* cell instance $10116 r0 *1 12.92,86.8
X$10116 3751 2520 3752 219 320 3807 MUX2_X1
* cell instance $10117 r0 *1 14.25,86.8
X$10117 219 13949 3712 3805 3353 320 DFF_X1
* cell instance $10120 r0 *1 18.05,86.8
X$10120 3886 1550 3675 219 320 3753 MUX2_X1
* cell instance $10121 m0 *1 18.24,86.8
X$10121 3473 2731 3628 219 320 3673 MUX2_X1
* cell instance $10124 m0 *1 19.76,86.8
X$10124 3673 2659 3711 219 320 3719 MUX2_X1
* cell instance $10125 m0 *1 21.09,86.8
X$10125 1370 219 320 3353 CLKBUF_X3
* cell instance $10131 r0 *1 21.85,86.8
X$10131 219 13799 3754 3808 3353 320 DFF_X1
* cell instance $10133 m0 *1 23.94,86.8
X$10133 3674 219 320 3675 BUF_X2
* cell instance $10135 m0 *1 32.3,86.8
X$10135 3674 1467 3574 219 320 3573 MUX2_X1
* cell instance $10137 m0 *1 33.82,86.8
X$10137 3244 219 320 CLKBUF_X1
* cell instance $10139 m0 *1 35.91,86.8
X$10139 3675 1307 3575 219 320 3715 MUX2_X1
* cell instance $10141 r0 *1 25.08,86.8
X$10141 3754 1507 3675 219 320 3808 MUX2_X1
* cell instance $10146 r0 *1 34.58,86.8
X$10146 219 13666 3575 3715 3244 320 DFF_X1
* cell instance $10148 m0 *1 37.62,86.8
X$10148 3631 1469 3675 219 320 3630 MUX2_X1
* cell instance $10151 r0 *1 38.76,86.8
X$10151 3631 2888 3676 219 320 3755 MUX2_X1
* cell instance $10153 m0 *1 39.33,86.8
X$10153 3675 1523 3676 219 320 3716 MUX2_X1
* cell instance $10154 m0 *1 40.85,86.8
X$10154 219 12635 3676 3716 3086 320 DFF_X1
* cell instance $10156 r0 *1 40.09,86.8
X$10156 3755 1835 3576 219 320 3810 MUX2_X1
* cell instance $10158 r0 *1 41.8,86.8
X$10158 3810 2777 219 320 3756 NAND2_X1
* cell instance $10161 m0 *1 44.46,86.8
X$10161 3718 1384 3245 219 320 3633 MUX2_X1
* cell instance $10162 m0 *1 46.55,86.8
X$10162 3718 2714 3479 219 320 3634 MUX2_X1
* cell instance $10165 m0 *1 48.26,86.8
X$10165 3717 3044 3577 320 219 3720 OAI21_X4
* cell instance $10167 m0 *1 51.49,86.8
X$10167 3675 1695 3579 219 320 3578 MUX2_X1
* cell instance $10168 m0 *1 51.11,86.8
X$10168 3313 219 320 14740 INV_X1
* cell instance $10169 m0 *1 52.82,86.8
X$10169 3677 2787 3579 219 320 3678 MUX2_X1
* cell instance $10170 m0 *1 54.15,86.8
X$10170 3679 219 320 3313 CLKBUF_X3
* cell instance $10175 r0 *1 51.68,86.8
X$10175 3675 1609 3677 219 320 3481 MUX2_X1
* cell instance $10176 r0 *1 53.01,86.8
X$10176 3903 2892 3678 219 320 3900 MUX2_X1
* cell instance $10181 r0 *1 60.04,86.8
X$10181 3759 2148 3757 219 320 3906 MUX2_X1
* cell instance $10184 m0 *1 62.32,86.8
X$10184 3723 219 320 3361 CLKBUF_X3
* cell instance $10190 m0 *1 65.17,86.8
X$10190 3582 2777 219 320 3583 NAND2_X1
* cell instance $10193 m0 *1 70.49,86.8
X$10193 219 13574 3681 3818 3680 320 DFF_X1
* cell instance $10194 m0 *1 73.72,86.8
X$10194 219 13244 3760 3821 3680 320 DFF_X1
* cell instance $10199 r0 *1 69.35,86.8
X$10199 3819 1756 3759 219 320 3911 MUX2_X1
* cell instance $10202 r0 *1 71.63,86.8
X$10202 3759 2037 3681 219 320 3818 MUX2_X1
* cell instance $10206 r0 *1 74.29,86.8
X$10206 3760 2032 3759 219 320 3821 MUX2_X1
* cell instance $10207 r0 *1 75.62,86.8
X$10207 3760 2714 3681 219 320 3822 MUX2_X1
* cell instance $10210 r0 *1 78.85,86.8
X$10210 219 14290 3762 3727 3761 320 DFF_X1
* cell instance $10211 m0 *1 80.56,86.8
X$10211 3762 2086 3202 219 320 3727 MUX2_X1
* cell instance $10213 m0 *1 81.89,86.8
X$10213 219 13295 3649 3648 3761 320 DFF_X1
* cell instance $10214 m0 *1 85.12,86.8
X$10214 3649 3214 3255 219 320 3731 MUX2_X1
* cell instance $10215 m0 *1 86.45,86.8
X$10215 219 13330 3826 3824 3133 320 DFF_X1
* cell instance $10218 r0 *1 82.08,86.8
X$10218 3854 1841 3202 219 320 3916 MUX2_X1
* cell instance $10220 r0 *1 83.6,86.8
X$10220 3854 3370 3762 219 320 3917 MUX2_X1
* cell instance $10221 r0 *1 84.93,86.8
X$10221 219 14341 3763 3918 3761 320 DFF_X1
* cell instance $10222 r0 *1 88.16,86.8
X$10222 3731 3919 219 320 3920 NOR2_X1
* cell instance $10223 r0 *1 88.73,86.8
X$10223 3202 2148 3826 219 320 3824 MUX2_X1
* cell instance $10224 r0 *1 90.06,86.8
X$10224 3763 3766 3826 219 320 3827 MUX2_X1
* cell instance $10225 m0 *1 92.15,86.8
X$10225 219 13139 3682 3733 3133 320 DFF_X1
* cell instance $10226 m0 *1 90.82,86.8
X$10226 3046 1476 3682 219 320 3733 MUX2_X1
* cell instance $10227 m0 *1 95.38,86.8
X$10227 3682 3766 3683 219 320 3652 MUX2_X1
* cell instance $10230 m0 *1 102.98,86.8
X$10230 219 13088 3768 3830 3589 320 DFF_X1
* cell instance $10233 r0 *1 91.77,86.8
X$10233 3827 2468 2665 219 320 3764 NOR3_X1
* cell instance $10236 r0 *1 93.1,86.8
X$10236 219 13844 3683 3828 3133 320 DFF_X1
* cell instance $10239 r0 *1 100.13,86.8
X$10239 219 14610 3767 3829 3589 320 DFF_X1
* cell instance $10240 r0 *1 103.36,86.8
X$10240 3768 3592 3684 219 320 3830 MUX2_X1
* cell instance $10241 r0 *1 104.69,86.8
X$10241 2468 320 3491 219 BUF_X4
* cell instance $10243 m0 *1 107.92,86.8
X$10243 219 12912 3737 3738 3493 320 DFF_X1
* cell instance $10244 m0 *1 106.59,86.8
X$10244 3590 3735 3684 219 320 3655 MUX2_X1
* cell instance $10247 m0 *1 112.1,86.8
X$10247 3587 3685 3591 2575 320 219 3658 OAI22_X2
* cell instance $10248 m0 *1 113.81,86.8
X$10248 2901 219 320 3686 INV_X2
* cell instance $10252 r0 *1 106.78,86.8
X$10252 3590 1576 3737 219 320 3857 MUX2_X1
* cell instance $10253 r0 *1 108.11,86.8
X$10253 3737 3659 3684 219 320 3738 MUX2_X1
* cell instance $10256 r0 *1 110.39,86.8
X$10256 3493 219 320 CLKBUF_X1
* cell instance $10257 r0 *1 110.96,86.8
X$10257 3856 219 320 3493 CLKBUF_X3
* cell instance $10258 r0 *1 111.91,86.8
X$10258 3831 3491 3769 219 320 3685 MUX2_X1
* cell instance $10259 r0 *1 113.24,86.8
X$10259 219 14505 3831 3927 3493 320 DFF_X1
* cell instance $10262 r0 *1 118.37,86.8
X$10262 1902 219 320 3495 CLKBUF_X3
* cell instance $10266 r0 *1 119.32,86.8
X$10266 219 3587 3770 3835 4167 2575 320 OAI22_X4
* cell instance $10267 m0 *1 119.51,86.8
X$10267 3495 219 320 CLKBUF_X1
* cell instance $10270 m0 *1 120.27,86.8
X$10270 3597 3686 3599 219 320 3835 MUX2_X1
* cell instance $10272 m0 *1 122.17,86.8
X$10272 3598 3735 3456 219 320 3741 MUX2_X1
* cell instance $10274 m0 *1 123.5,86.8
X$10274 219 13011 3598 3741 3134 320 DFF_X1
* cell instance $10276 m0 *1 128.25,86.8
X$10276 337 3136 3742 219 320 3687 MUX2_X1
* cell instance $10278 m0 *1 130.34,86.8
X$10278 219 12744 3662 3603 3604 320 DFF_X1
* cell instance $10280 m0 *1 133.76,86.8
X$10280 3526 3136 3771 219 320 3688 MUX2_X1
* cell instance $10281 m0 *1 135.09,86.8
X$10281 3526 3135 3743 219 320 3689 MUX2_X1
* cell instance $10283 m0 *1 137.18,86.8
X$10283 3664 3746 3690 320 219 3392 OAI21_X4
* cell instance $10285 m0 *1 141.17,86.8
X$10285 219 12786 3774 3747 3604 320 DFF_X1
* cell instance $10293 r0 *1 125.97,86.8
X$10293 3134 219 320 CLKBUF_X1
* cell instance $10294 r0 *1 126.54,86.8
X$10294 1902 219 320 3134 CLKBUF_X3
* cell instance $10295 r0 *1 127.49,86.8
X$10295 219 13882 3742 3687 3134 320 DFF_X1
* cell instance $10299 r0 *1 134.33,86.8
X$10299 219 13924 3771 3688 3604 320 DFF_X1
* cell instance $10300 r0 *1 137.56,86.8
X$10300 3743 3775 3771 219 320 3690 MUX2_X1
* cell instance $10302 r0 *1 139.08,86.8
X$10302 3773 2799 3772 219 320 3837 MUX2_X1
* cell instance $10303 r0 *1 140.41,86.8
X$10303 219 14088 3772 3837 3604 320 DFF_X1
* cell instance $10304 r0 *1 143.64,86.8
X$10304 3773 2805 3774 219 320 3747 MUX2_X1
* cell instance $10305 r0 *1 144.97,86.8
X$10305 3772 2909 3774 219 320 3838 MUX2_X1
* cell instance $10306 m0 *1 147.63,86.8
X$10306 219 12847 3691 3748 3375 320 DFF_X1
* cell instance $10307 m0 *1 146.3,86.8
X$10307 3497 3135 3691 219 320 3748 MUX2_X1
* cell instance $10308 m0 *1 150.86,86.8
X$10308 3691 3775 3606 219 320 3750 MUX2_X1
* cell instance $10310 m0 *1 152.38,86.8
X$10310 3669 3746 3750 320 219 3341 OAI21_X2
* cell instance $10311 m0 *1 153.71,86.8
X$10311 1943 219 320 3375 CLKBUF_X3
* cell instance $10314 r0 *1 146.68,86.8
X$10314 3605 3838 219 320 3840 OR2_X1
* cell instance $10319 r0 *1 151.81,86.8
X$10319 3840 3746 3776 320 219 3504 OAI21_X2
* cell instance $10321 r0 *1 154.66,86.8
X$10321 219 13683 3844 3692 3375 320 DFF_X1
* cell instance $10322 m0 *1 155.23,86.8
X$10322 3562 3501 219 320 3749 XOR2_X1
* cell instance $10324 m0 *1 156.37,86.8
X$10324 3749 3238 219 320 3692 NOR2_X1
* cell instance $10329 m0 *1 162.45,86.8
X$10329 3391 3379 3693 3378 320 219 3745 OAI22_X1
* cell instance $10333 r0 *1 158.65,86.8
X$10333 3844 320 2482 219 BUF_X4
* cell instance $10334 r0 *1 159.98,86.8
X$10334 3841 3054 219 320 240 NOR2_X2
* cell instance $10336 m0 *1 167.01,86.8
X$10336 4038 2925 219 320 422 NOR2_X2
* cell instance $10340 r0 *1 167.77,86.8
X$10340 2922 3151 3842 219 3843 320 AOI21_X2
* cell instance $10341 m0 *1 168.91,86.8
X$10341 3940 1616 3693 3385 320 219 3694 OAI22_X1
* cell instance $10342 m0 *1 168.34,86.8
X$10342 3744 3694 219 320 3842 NOR2_X1
* cell instance $10344 r0 *1 169.1,86.8
X$10344 3781 3696 3507 1708 320 219 3839 OAI22_X1
* cell instance $10345 r0 *1 170.05,86.8
X$10345 3839 3777 219 320 3017 NOR2_X1
* cell instance $10347 m0 *1 170.24,86.8
X$10347 3740 3695 219 320 2927 NOR2_X1
* cell instance $10348 r0 *1 170.62,86.8
X$10348 3508 3778 3470 658 320 219 3695 OAI22_X1
* cell instance $10349 m0 *1 172.14,86.8
X$10349 3277 3696 3390 1708 320 219 3739 OAI22_X1
* cell instance $10350 m0 *1 171.19,86.8
X$10350 3273 3696 3506 1708 320 219 3740 OAI22_X1
* cell instance $10351 m0 *1 173.09,86.8
X$10351 3739 3697 219 320 3013 NOR2_X1
* cell instance $10354 r0 *1 171.57,86.8
X$10354 3337 3696 658 3503 320 219 3836 OAI22_X2
* cell instance $10355 r0 *1 173.28,86.8
X$10355 3387 3778 3383 658 320 219 3697 OAI22_X1
* cell instance $10357 r0 *1 174.61,86.8
X$10357 3836 3779 219 320 3059 NOR2_X2
* cell instance $10359 m0 *1 174.8,86.8
X$10359 2922 3460 3612 219 3736 320 AOI21_X2
* cell instance $10366 r0 *1 177.08,86.8
X$10366 3397 3705 219 320 3833 NOR2_X1
* cell instance $10367 r0 *1 177.65,86.8
X$10367 3834 3792 219 320 255 NOR2_X2
* cell instance $10368 r0 *1 178.6,86.8
X$10368 3782 3394 3784 3557 320 219 3780 OAI22_X1
* cell instance $10369 m0 *1 178.98,86.8
X$10369 3698 2538 3507 1343 320 219 3699 OAI22_X1
* cell instance $10373 r0 *1 179.55,86.8
X$10373 3833 3934 3699 219 320 3732 NOR3_X1
* cell instance $10375 r0 *1 180.5,86.8
X$10375 4033 3832 3783 320 3724 219 NOR3_X2
* cell instance $10376 m0 *1 182.02,86.8
X$10376 3698 549 3507 1203 320 219 3700 OAI22_X1
* cell instance $10378 m0 *1 182.97,86.8
X$10378 3701 3702 219 320 265 NOR2_X2
* cell instance $10380 m0 *1 185.44,86.8
X$10380 3732 3702 219 320 420 NOR2_X2
* cell instance $10383 r0 *1 181.83,86.8
X$10383 3787 549 3390 1203 320 219 3825 OAI22_X1
* cell instance $10384 r0 *1 182.78,86.8
X$10384 3933 3786 3700 219 320 3701 NOR3_X1
* cell instance $10385 r0 *1 183.54,86.8
X$10385 3781 3224 3785 3514 320 219 3786 OAI22_X1
* cell instance $10386 r0 *1 184.49,86.8
X$10386 3788 3224 3387 3514 320 219 3790 OAI22_X1
* cell instance $10387 r0 *1 185.44,86.8
X$10387 3789 3790 3825 219 320 3823 NOR3_X1
* cell instance $10391 r0 *1 188.29,86.8
X$10391 3788 3218 3387 3515 320 219 3728 OAI22_X1
* cell instance $10393 m0 *1 188.29,86.8
X$10393 3823 3725 219 320 424 NOR2_X2
* cell instance $10394 r0 *1 189.24,86.8
X$10394 3782 3218 3784 3515 320 219 3820 OAI22_X1
* cell instance $10395 m0 *1 189.81,86.8
X$10395 3093 3816 219 320 3729 NOR2_X1
* cell instance $10397 m0 *1 190.38,86.8
X$10397 3093 3703 219 320 3614 NOR2_X1
* cell instance $10399 m0 *1 191.14,86.8
X$10399 3729 3728 3791 219 320 3726 NOR3_X1
* cell instance $10400 m0 *1 191.9,86.8
X$10400 3093 3705 219 320 3704 NOR2_X1
* cell instance $10403 m0 *1 193.42,86.8
X$10403 3726 3725 219 320 277 NOR2_X2
* cell instance $10407 m0 *1 198.36,86.8
X$10407 3724 3725 219 320 467 NOR2_X2
* cell instance $10409 m0 *1 199.5,86.8
X$10409 3413 2256 3706 219 320 3646 MUX2_X1
* cell instance $10410 m0 *1 200.83,86.8
X$10410 3706 2976 3542 219 320 3912 MUX2_X1
* cell instance $10412 m0 *1 202.92,86.8
X$10412 219 2976 2589 320 BUF_X16
* cell instance $10413 m0 *1 207.67,86.8
X$10413 3707 2364 3721 219 320 3722 MUX2_X1
* cell instance $10414 m0 *1 209,86.8
X$10414 2940 219 320 2362 CLKBUF_X3
* cell instance $10418 r0 *1 190.19,86.8
X$10418 3781 3218 3785 3515 320 219 3817 OAI22_X1
* cell instance $10419 r0 *1 191.14,86.8
X$10419 3614 3820 3870 219 320 3815 NOR3_X1
* cell instance $10420 r0 *1 191.9,86.8
X$10420 3704 3817 3924 219 320 3814 NOR3_X1
* cell instance $10423 r0 *1 194.94,86.8
X$10423 3815 3792 219 320 396 NOR2_X2
* cell instance $10424 r0 *1 196.84,86.8
X$10424 219 13993 3793 3813 3210 320 DFF_X1
* cell instance $10425 r0 *1 200.07,86.8
X$10425 3413 2490 3793 219 320 3813 MUX2_X1
* cell instance $10427 r0 *1 201.78,86.8
X$10427 3311 2941 2482 320 219 3812 MUX2_X2
* cell instance $10428 r0 *1 203.49,86.8
X$10428 2072 3311 219 320 4013 OR2_X1
* cell instance $10429 r0 *1 204.25,86.8
X$10429 219 14187 3721 3722 3289 320 DFF_X1
* cell instance $10430 r0 *1 207.48,86.8
X$10430 219 14205 3908 3876 3291 320 DFF_X1
* cell instance $10433 m0 *1 218.12,86.8
X$10433 3616 3062 3617 219 320 3796 MUX2_X1
* cell instance $10434 m0 *1 214.89,86.8
X$10434 219 13019 3616 3811 3615 320 DFF_X1
* cell instance $10437 r0 *1 215.65,86.8
X$10437 3618 2261 3616 219 320 3811 MUX2_X1
* cell instance $10440 r0 *1 217.55,86.8
X$10440 3618 2368 3795 219 320 3794 MUX2_X1
* cell instance $10441 r0 *1 218.88,86.8
X$10441 3795 3062 3708 219 320 3879 MUX2_X1
* cell instance $10443 m0 *1 219.83,86.8
X$10443 3618 2495 3708 219 320 3809 MUX2_X1
* cell instance $10445 r0 *1 220.21,86.8
X$10445 219 14700 3708 3809 3615 320 DFF_X1
* cell instance $10447 m0 *1 225.91,86.8
X$10447 3714 3419 3536 320 219 3385 OAI21_X4
* cell instance $10448 m0 *1 224.58,86.8
X$10448 3520 3293 3619 219 320 3637 MUX2_X1
* cell instance $10449 m0 *1 228.38,86.8
X$10449 3520 2831 3620 219 320 3636 MUX2_X1
* cell instance $10454 r0 *1 230.66,86.8
X$10454 219 14443 3797 3896 3521 320 DFF_X1
* cell instance $10455 m0 *1 231.04,86.8
X$10455 3173 3621 219 320 3714 OR2_X1
* cell instance $10462 m0 *1 235.03,86.8
X$10462 3623 3171 3524 219 320 3625 MUX2_X1
* cell instance $10463 m0 *1 233.7,86.8
X$10463 3622 3070 3524 219 320 3523 MUX2_X1
* cell instance $10464 m0 *1 236.36,86.8
X$10464 1869 219 320 3415 CLKBUF_X3
* cell instance $10465 m0 *1 237.31,86.8
X$10465 3415 219 320 CLKBUF_X1
* cell instance $10466 m0 *1 237.88,86.8
X$10466 3713 219 320 3165 BUF_X1
* cell instance $10467 m0 *1 238.45,86.8
X$10467 3627 219 320 3618 BUF_X1
* cell instance $10469 r0 *1 233.89,86.8
X$10469 3890 219 320 3798 BUF_X1
* cell instance $10473 r0 *1 235.79,86.8
X$10473 3883 219 320 3986 BUF_X1
* cell instance $10474 r0 *1 236.36,86.8
X$10474 3710 219 320 3987 BUF_X1
* cell instance $10475 r0 *1 236.93,86.8
X$10475 3802 219 320 3707 BUF_X1
* cell instance $10477 r0 *1 237.69,86.8
X$10477 3991 3071 3882 219 320 3888 MUX2_X1
* cell instance $10478 r0 *1 239.02,86.8
X$10478 3801 219 320 3520 BUF_X1
* cell instance $10479 m0 *1 239.59,86.8
X$10479 3626 219 320 3622 BUF_X1
* cell instance $10482 r0 *1 239.59,86.8
X$10482 3806 219 320 3709 BUF_X1
* cell instance $10483 r0 *1 240.16,86.8
X$10483 3799 219 320 3800 BUF_X1
* cell instance $10487 m0 *1 7.41,42
X$10487 665 219 320 1299 CLKBUF_X2
* cell instance $10525 r0 *1 26.41,42
X$10525 219 14022 1223 1157 1158 320 DFF_X1
* cell instance $10552 m0 *1 131.86,42
X$10552 472 1011 1162 219 320 1197 MUX2_X1
* cell instance $10553 m0 *1 128.63,42
X$10553 219 12708 1162 1197 982 320 DFF_X1
* cell instance $10554 m0 *1 133.19,42
X$10554 293 219 320 982 CLKBUF_X3
* cell instance $10555 m0 *1 134.14,42
X$10555 472 1041 1199 219 320 1163 MUX2_X1
* cell instance $10559 r0 *1 132.05,42
X$10559 472 1012 1226 219 320 1266 MUX2_X1
* cell instance $10560 r0 *1 133.38,42
X$10560 1162 1040 1226 219 320 1271 MUX2_X1
* cell instance $10561 r0 *1 134.71,42
X$10561 219 14276 1199 1163 1088 320 DFF_X1
* cell instance $10563 m0 *1 137.37,42
X$10563 1133 1040 1199 219 320 1164 MUX2_X1
* cell instance $10564 m0 *1 139.46,42
X$10564 293 219 320 1088 CLKBUF_X3
* cell instance $10565 m0 *1 140.41,42
X$10565 1200 733 219 320 1272 NAND2_X1
* cell instance $10569 r0 *1 138.13,42
X$10569 1164 522 1271 219 320 1227 MUX2_X1
* cell instance $10570 r0 *1 139.46,42
X$10570 1272 541 1164 320 219 1228 OAI21_X4
* cell instance $10573 m0 *1 144.59,42
X$10573 969 219 320 1040 BUF_X1
* cell instance $10578 r0 *1 145.16,42
X$10578 219 14201 1231 1275 1091 320 DFF_X1
* cell instance $10579 r0 *1 148.39,42
X$10579 1166 219 320 1277 INV_X1
* cell instance $10580 r0 *1 148.77,42
X$10580 1277 733 219 320 1204 NAND2_X1
* cell instance $10581 r0 *1 149.34,42
X$10581 293 219 320 1091 CLKBUF_X3
* cell instance $10582 m0 *1 150.29,42
X$10582 1092 969 1168 219 320 1167 MUX2_X1
* cell instance $10586 m0 *1 153.33,42
X$10586 332 903 1169 219 320 1209 MUX2_X1
* cell instance $10587 m0 *1 154.66,42
X$10587 219 13138 1169 1209 1233 320 DFF_X1
* cell instance $10588 m0 *1 157.89,42
X$10588 969 219 320 704 BUF_X2
* cell instance $10589 m0 *1 158.65,42
X$10589 332 902 1170 219 320 1284 MUX2_X1
* cell instance $10592 m0 *1 160.93,42
X$10592 219 13317 1046 1148 991 320 DFF_X1
* cell instance $10594 m0 *1 164.35,42
X$10594 364 219 320 991 CLKBUF_X3
* cell instance $10595 m0 *1 165.3,42
X$10595 1214 995 1087 320 219 1213 OAI21_X4
* cell instance $10596 m0 *1 167.77,42
X$10596 1171 1216 993 320 219 1215 OAI21_X4
* cell instance $10600 r0 *1 150.29,42
X$10600 1204 541 1167 320 219 1281 OAI21_X4
* cell instance $10605 r0 *1 157.89,42
X$10605 219 14390 1170 1284 1233 320 DFF_X1
* cell instance $10607 r0 *1 161.31,42
X$10607 1169 1084 1170 219 320 1216 MUX2_X1
* cell instance $10610 r0 *1 163.21,42
X$10610 358 803 1235 219 320 1286 MUX2_X1
* cell instance $10611 r0 *1 164.54,42
X$10611 219 14383 1235 1286 991 320 DFF_X1
* cell instance $10612 r0 *1 167.77,42
X$10612 1094 993 1236 320 219 1290 OAI21_X4
* cell instance $10616 r0 *1 172.33,42
X$10616 1172 995 219 1292 320 NAND2_X4
* cell instance $10618 m0 *1 175.75,42
X$10618 364 219 320 1085 CLKBUF_X3
* cell instance $10619 m0 *1 174.42,42
X$10619 344 801 1049 219 320 1099 MUX2_X1
* cell instance $10620 m0 *1 176.7,42
X$10620 1085 219 320 14728 INV_X1
* cell instance $10621 m0 *1 177.08,42
X$10621 1220 219 320 1173 INV_X2
* cell instance $10630 r0 *1 176.89,42
X$10630 1173 995 219 320 1325 NAND2_X2
* cell instance $10633 r0 *1 179.55,42
X$10633 1295 995 219 320 1461 NAND2_X1
* cell instance $10635 r0 *1 180.88,42
X$10635 327 803 1175 219 320 1239 MUX2_X1
* cell instance $10636 m0 *1 181.26,42
X$10636 1174 219 320 1295 INV_X1
* cell instance $10640 m0 *1 182.02,42
X$10640 435 803 1105 219 320 1176 MUX2_X1
* cell instance $10642 m0 *1 185.63,42
X$10642 1177 1084 1180 219 320 1219 MUX2_X1
* cell instance $10647 r0 *1 185.44,42
X$10647 1178 993 1219 320 219 1298 OAI21_X4
* cell instance $10654 m0 *1 199.69,42
X$10654 682 1181 1183 219 320 1212 MUX2_X1
* cell instance $10655 m0 *1 201.02,42
X$10655 219 12969 1183 1212 926 320 DFF_X1
* cell instance $10660 r0 *1 188.29,42
X$10660 219 14702 1180 1179 1053 320 DFF_X1
* cell instance $10661 r0 *1 191.52,42
X$10661 219 13853 1242 1296 1053 320 DFF_X1
* cell instance $10663 r0 *1 195.13,42
X$10663 545 219 320 1053 CLKBUF_X3
* cell instance $10664 r0 *1 196.08,42
X$10664 1053 219 320 CLKBUF_X1
* cell instance $10668 r0 *1 205.96,42
X$10668 1185 1288 219 320 1245 OR2_X1
* cell instance $10672 r0 *1 208.05,42
X$10672 1181 219 320 1120 CLKBUF_X3
* cell instance $10674 m0 *1 210.14,42
X$10674 1182 219 320 1057 CLKBUF_X3
* cell instance $10679 m0 *1 223.44,42
X$10679 1190 927 1191 219 320 1202 MUX2_X1
* cell instance $10680 m0 *1 224.77,42
X$10680 1191 932 1192 219 320 1201 MUX2_X1
* cell instance $10681 m0 *1 226.1,42
X$10681 1190 929 1192 219 320 1193 MUX2_X1
* cell instance $10687 r0 *1 211.66,42
X$10687 219 14479 1249 1187 1188 320 DFF_X1
* cell instance $10690 r0 *1 219.45,42
X$10690 219 14438 1276 1189 1001 320 DFF_X1
* cell instance $10691 r0 *1 222.68,42
X$10691 219 14567 1191 1202 1001 320 DFF_X1
* cell instance $10692 r0 *1 225.91,42
X$10692 219 14607 1192 1193 1001 320 DFF_X1
* cell instance $10694 m0 *1 233.32,42
X$10694 1196 219 320 933 BUF_X1
* cell instance $10695 m0 *1 230.09,42
X$10695 219 13529 1255 1194 1124 320 DFF_X1
* cell instance $10698 m0 *1 234.84,42
X$10698 1195 219 320 1003 BUF_X1
* cell instance $10700 m0 *1 236.17,42
X$10700 380 219 320 1124 CLKBUF_X3
* cell instance $10701 m0 *1 237.12,42
X$10701 1124 219 320 CLKBUF_X1
* cell instance $10704 r0 *1 230.66,42
X$10704 219 14163 1258 1265 1256 320 DFF_X1
* cell instance $10710 r0 *1 235.03,42
X$10710 1254 929 1259 219 320 1263 MUX2_X1
* cell instance $10711 r0 *1 236.36,42
X$10711 219 13732 1259 1263 1124 320 DFF_X1
* cell instance $10715 m0 *1 206.15,240.8
X$10715 12397 219 320 11255 CLKBUF_X2
* cell instance $10720 m0 *1 209.38,240.8
X$10720 12490 219 320 11715 BUF_X1
* cell instance $10722 m0 *1 210.71,240.8
X$10722 11168 219 320 12396 BUF_X1
* cell instance $10733 m0 *1 129.01,240.8
X$10733 12473 219 320 9010 CLKBUF_X2
* cell instance $10736 m0 *1 8.17,53.2
X$10736 1546 219 320 1740 CLKBUF_X2
* cell instance $10738 m0 *1 8.93,53.2
X$10738 219 12824 1635 1684 1733 320 DFF_X1
* cell instance $10739 m0 *1 12.16,53.2
X$10739 1224 1599 1636 219 320 1786 MUX2_X1
* cell instance $10741 m0 *1 14.25,53.2
X$10741 1635 1564 1636 219 320 1689 MUX2_X1
* cell instance $10744 m0 *1 17.29,53.2
X$10744 1224 1734 1638 219 320 1685 MUX2_X1
* cell instance $10747 m0 *1 19.57,53.2
X$10747 219 12873 1638 1685 1789 320 DFF_X1
* cell instance $10748 m0 *1 22.8,53.2
X$10748 1637 1552 1638 219 320 1688 MUX2_X1
* cell instance $10762 r0 *1 10.45,53.2
X$10762 219 13937 1636 1786 1733 320 DFF_X1
* cell instance $10764 r0 *1 13.87,53.2
X$10764 219 14280 1787 1788 1158 320 DFF_X1
* cell instance $10766 r0 *1 17.48,53.2
X$10766 1299 1734 1465 219 320 1549 MUX2_X1
* cell instance $10768 r0 *1 19,53.2
X$10768 219 14019 1637 1687 1789 320 DFF_X1
* cell instance $10769 r0 *1 22.23,53.2
X$10769 1637 1550 1304 219 320 1687 MUX2_X1
* cell instance $10771 r0 *1 23.94,53.2
X$10771 1740 1553 1736 219 320 1791 MUX2_X1
* cell instance $10772 m0 *1 24.7,53.2
X$10772 1688 1639 1689 219 320 1696 MUX2_X1
* cell instance $10775 r0 *1 25.27,53.2
X$10775 219 14273 1736 1791 1302 320 DFF_X1
* cell instance $10777 m0 *1 26.41,53.2
X$10777 219 12866 1556 1690 1302 320 DFF_X1
* cell instance $10782 r0 *1 29.45,53.2
X$10782 1738 1303 1739 219 320 1794 MUX2_X1
* cell instance $10783 r0 *1 30.78,53.2
X$10783 1739 1374 1795 219 320 1877 MUX2_X1
* cell instance $10784 r0 *1 32.11,53.2
X$10784 1740 1261 1795 219 320 1741 MUX2_X1
* cell instance $10787 m0 *1 37.62,53.2
X$10787 219 12762 1557 1607 1306 320 DFF_X1
* cell instance $10788 m0 *1 42.37,53.2
X$10788 1692 1640 1691 219 320 1641 MUX2_X1
* cell instance $10795 r0 *1 40.85,53.2
X$10795 1743 1469 1738 219 320 1797 MUX2_X1
* cell instance $10800 r0 *1 47.69,53.2
X$10800 219 14658 1642 1697 1559 320 DFF_X1
* cell instance $10801 m0 *1 49.21,53.2
X$10801 1611 1640 1696 219 320 1699 MUX2_X1
* cell instance $10802 m0 *1 47.88,53.2
X$10802 1304 1695 1642 219 320 1697 MUX2_X1
* cell instance $10804 r0 *1 50.92,53.2
X$10804 1641 1699 1643 320 219 1747 MUX2_X2
* cell instance $10806 m0 *1 50.92,53.2
X$10806 1560 1552 1642 219 320 1561 MUX2_X1
* cell instance $10809 m0 *1 53.58,53.2
X$10809 1702 1640 1604 219 320 1800 MUX2_X1
* cell instance $10813 r0 *1 54.15,53.2
X$10813 1608 1800 1643 320 219 1721 MUX2_X2
* cell instance $10816 m0 *1 56.05,53.2
X$10816 1527 1562 1705 219 320 1702 MUX2_X1
* cell instance $10821 r0 *1 60.23,53.2
X$10821 219 14012 1565 1804 1644 320 DFF_X1
* cell instance $10822 m0 *1 64.03,53.2
X$10822 1645 1374 1429 219 320 1646 MUX2_X1
* cell instance $10823 m0 *1 60.8,53.2
X$10823 219 13495 1645 1707 1644 320 DFF_X1
* cell instance $10830 r0 *1 63.46,53.2
X$10830 1749 1647 1645 219 320 1707 MUX2_X1
* cell instance $10831 r0 *1 64.79,53.2
X$10831 1805 1510 1646 219 320 1750 MUX2_X1
* cell instance $10834 m0 *1 68.21,53.2
X$10834 1388 1571 1650 219 320 1569 MUX2_X1
* cell instance $10836 m0 *1 69.54,53.2
X$10836 1712 1562 1710 219 320 1648 MUX2_X1
* cell instance $10837 m0 *1 70.87,53.2
X$10837 1649 1552 1650 219 320 1712 MUX2_X1
* cell instance $10842 r0 *1 68.4,53.2
X$10842 219 14283 1649 1806 1432 320 DFF_X1
* cell instance $10843 r0 *1 71.63,53.2
X$10843 1649 1756 1749 219 320 1806 MUX2_X1
* cell instance $10848 r0 *1 75.81,53.2
X$10848 1390 1746 1752 219 320 1751 MUX2_X1
* cell instance $10851 m0 *1 80.94,53.2
X$10851 1620 1651 1393 219 320 1713 MUX2_X1
* cell instance $10854 m0 *1 83.6,53.2
X$10854 1652 1647 1572 219 320 1622 MUX2_X1
* cell instance $10856 m0 *1 84.93,53.2
X$10856 1715 1651 1714 219 320 1757 MUX2_X1
* cell instance $10859 m0 *1 87.21,53.2
X$10859 1573 1841 1652 219 320 1574 MUX2_X1
* cell instance $10862 r0 *1 83.6,53.2
X$10862 219 13991 1653 1809 1481 320 DFF_X1
* cell instance $10863 r0 *1 86.83,53.2
X$10863 1653 1756 1652 219 320 1809 MUX2_X1
* cell instance $10866 r0 *1 89.87,53.2
X$10866 1481 219 320 CLKBUF_X1
* cell instance $10868 r0 *1 90.63,53.2
X$10868 1479 1746 1758 219 320 1810 MUX2_X1
* cell instance $10869 m0 *1 92.15,53.2
X$10869 1577 1651 1483 219 320 1624 MUX2_X1
* cell instance $10871 m0 *1 93.48,53.2
X$10871 1479 219 320 1652 BUF_X2
* cell instance $10880 m0 *1 135.28,53.2
X$10880 219 13614 1655 1724 1763 320 DFF_X1
* cell instance $10885 r0 *1 93.86,53.2
X$10885 1159 1389 1654 219 320 1813 MUX2_X1
* cell instance $10886 r0 *1 95.19,53.2
X$10886 219 14082 1654 1813 1395 320 DFF_X1
* cell instance $10900 r0 *1 129.2,53.2
X$10900 387 1012 1761 219 320 1816 MUX2_X1
* cell instance $10904 r0 *1 134.52,53.2
X$10904 219 14375 1817 1762 1763 320 DFF_X1
* cell instance $10905 r0 *1 137.75,53.2
X$10905 527 1012 1655 219 320 1724 MUX2_X1
* cell instance $10907 m0 *1 142.12,53.2
X$10907 219 12963 1658 1730 1656 320 DFF_X1
* cell instance $10908 m0 *1 139.65,53.2
X$10908 1581 733 1580 320 219 1727 OAI21_X4
* cell instance $10910 m0 *1 146.87,53.2
X$10910 351 851 1731 219 320 1732 MUX2_X1
* cell instance $10911 m0 *1 148.2,53.2
X$10911 219 12937 1731 1732 1656 320 DFF_X1
* cell instance $10915 m0 *1 155.42,53.2
X$10915 219 13596 1729 1728 1660 320 DFF_X1
* cell instance $10916 m0 *1 158.65,53.2
X$10916 354 1662 1729 219 320 1728 MUX2_X1
* cell instance $10917 m0 *1 159.98,53.2
X$10917 364 219 320 1660 CLKBUF_X3
* cell instance $10921 r0 *1 140.22,53.2
X$10921 288 900 1657 219 320 1819 MUX2_X1
* cell instance $10922 r0 *1 141.55,53.2
X$10922 219 14141 1657 1819 1656 320 DFF_X1
* cell instance $10923 r0 *1 144.78,53.2
X$10923 1657 1765 1658 219 320 1766 MUX2_X1
* cell instance $10924 r0 *1 146.11,53.2
X$10924 219 14137 1767 1659 1656 320 DFF_X1
* cell instance $10925 r0 *1 149.34,53.2
X$10925 351 900 1767 219 320 1659 MUX2_X1
* cell instance $10929 r0 *1 153.33,53.2
X$10929 354 1403 1770 219 320 1824 MUX2_X1
* cell instance $10930 r0 *1 154.66,53.2
X$10930 219 14584 1770 1824 1660 320 DFF_X1
* cell instance $10932 r0 *1 158.27,53.2
X$10932 219 14622 1773 1771 1660 320 DFF_X1
* cell instance $10933 r0 *1 161.5,53.2
X$10933 1660 219 320 14717 INV_X2
* cell instance $10935 r0 *1 162.26,53.2
X$10935 219 14575 1827 1826 1661 320 DFF_X1
* cell instance $10936 m0 *1 166.06,53.2
X$10936 437 1493 1726 219 320 1725 MUX2_X1
* cell instance $10937 m0 *1 162.83,53.2
X$10937 219 13236 1726 1725 1661 320 DFF_X1
* cell instance $10940 m0 *1 168.34,53.2
X$10940 336 1662 1664 219 320 1723 MUX2_X1
* cell instance $10941 m0 *1 169.67,53.2
X$10941 219 12919 1664 1723 1323 320 DFF_X1
* cell instance $10942 m0 *1 172.9,53.2
X$10942 219 12987 1722 1631 1323 320 DFF_X1
* cell instance $10945 r0 *1 166.25,53.2
X$10945 437 1662 1827 219 320 1826 MUX2_X1
* cell instance $10947 r0 *1 168.34,53.2
X$10947 336 1403 1663 219 320 1825 MUX2_X1
* cell instance $10948 r0 *1 169.67,53.2
X$10948 219 13835 1663 1825 1323 320 DFF_X1
* cell instance $10949 r0 *1 172.9,53.2
X$10949 1664 1775 1582 219 320 1854 MUX2_X1
* cell instance $10950 r0 *1 174.23,53.2
X$10950 1663 1775 1722 219 320 1823 MUX2_X1
* cell instance $10955 m0 *1 176.7,53.2
X$10955 304 1403 1583 219 320 1630 MUX2_X1
* cell instance $10957 m0 *1 178.03,53.2
X$10957 304 1662 1666 219 320 1665 MUX2_X1
* cell instance $10959 m0 *1 179.55,53.2
X$10959 1583 1775 1491 219 320 1776 MUX2_X1
* cell instance $10960 m0 *1 180.88,53.2
X$10960 304 1493 1719 219 320 1720 MUX2_X1
* cell instance $10961 m0 *1 182.21,53.2
X$10961 219 12738 1719 1720 1668 320 DFF_X1
* cell instance $10963 m0 *1 186.2,53.2
X$10963 297 1662 1717 219 320 1718 MUX2_X1
* cell instance $10964 m0 *1 187.53,53.2
X$10964 219 13057 1717 1718 1328 320 DFF_X1
* cell instance $10966 m0 *1 190.95,53.2
X$10966 587 1492 1669 219 320 1716 MUX2_X1
* cell instance $10967 m0 *1 192.28,53.2
X$10967 219 12778 1669 1716 1670 320 DFF_X1
* cell instance $10968 m0 *1 195.51,53.2
X$10968 1626 1112 1499 219 320 1987 MUX2_X1
* cell instance $10972 r0 *1 177.84,53.2
X$10972 219 13829 1666 1665 1668 320 DFF_X1
* cell instance $10975 r0 *1 181.64,53.2
X$10975 1666 1719 1775 320 219 1667 MUX2_X2
* cell instance $10978 r0 *1 184.49,53.2
X$10978 219 13766 1821 1822 1328 320 DFF_X1
* cell instance $10981 r0 *1 190.95,53.2
X$10981 587 1403 1778 219 320 1818 MUX2_X1
* cell instance $10982 r0 *1 192.28,53.2
X$10982 219 13733 1778 1818 1952 320 DFF_X1
* cell instance $10985 m0 *1 198.93,53.2
X$10985 219 12831 1671 1623 1500 320 DFF_X1
* cell instance $10987 m0 *1 202.16,53.2
X$10987 1671 1069 1711 219 320 1672 MUX2_X1
* cell instance $10989 m0 *1 205.01,53.2
X$10989 1584 1182 1711 219 320 1811 MUX2_X1
* cell instance $10992 r0 *1 200.26,53.2
X$10992 219 14065 1586 1587 1500 320 DFF_X1
* cell instance $10993 r0 *1 203.49,53.2
X$10993 1405 1588 219 320 1814 OR2_X1
* cell instance $10996 r0 *1 205.39,53.2
X$10996 219 14067 1711 1811 1500 320 DFF_X1
* cell instance $10997 m0 *1 206.91,53.2
X$10997 1589 1585 1706 320 219 1709 OAI21_X4
* cell instance $11000 m0 *1 209.57,53.2
X$11000 1590 1407 1704 320 219 1708 OAI21_X4
* cell instance $11002 m0 *1 212.23,53.2
X$11002 1674 1112 1703 219 320 1706 MUX2_X1
* cell instance $11004 m0 *1 213.75,53.2
X$11004 219 13384 1674 1675 1188 320 DFF_X1
* cell instance $11007 r0 *1 208.81,53.2
X$11007 1780 1859 1807 219 320 1673 MUX2_X1
* cell instance $11009 r0 *1 213.18,53.2
X$11009 1409 1781 1674 219 320 1675 MUX2_X1
* cell instance $11012 m0 *1 217.36,53.2
X$11012 1409 1677 1703 219 320 1802 MUX2_X1
* cell instance $11015 r0 *1 217.74,53.2
X$11015 219 14556 1703 1802 1188 320 DFF_X1
* cell instance $11016 m0 *1 220.02,53.2
X$11016 1700 1113 1676 219 320 1704 MUX2_X1
* cell instance $11018 m0 *1 221.35,53.2
X$11018 219 13234 1700 1701 1698 320 DFF_X1
* cell instance $11020 m0 *1 224.77,53.2
X$11020 1592 1677 1676 219 320 1605 MUX2_X1
* cell instance $11022 m0 *1 226.29,53.2
X$11022 219 12658 1693 1694 1698 320 DFF_X1
* cell instance $11023 m0 *1 229.52,53.2
X$11023 1410 1781 1693 219 320 1694 MUX2_X1
* cell instance $11027 r0 *1 223.25,53.2
X$11027 1592 1781 1700 219 320 1701 MUX2_X1
* cell instance $11033 m0 *1 231.42,53.2
X$11033 1410 1677 1594 219 320 1593 MUX2_X1
* cell instance $11036 m0 *1 232.94,53.2
X$11036 1678 1408 1686 219 320 1595 MUX2_X1
* cell instance $11039 r0 *1 233.89,53.2
X$11039 1784 1596 1686 219 320 1968 MUX2_X1
* cell instance $11040 m0 *1 235.98,53.2
X$11040 219 13461 1681 1597 1680 320 DFF_X1
* cell instance $11041 m0 *1 234.65,53.2
X$11041 1419 1677 1679 219 320 1793 MUX2_X1
* cell instance $11042 m0 *1 239.21,53.2
X$11042 1682 219 320 1419 BUF_X1
* cell instance $11044 r0 *1 235.22,53.2
X$11044 1678 1414 1784 219 320 1792 MUX2_X1
* cell instance $11045 r0 *1 236.55,53.2
X$11045 219 13720 1784 1792 1680 320 DFF_X1
* cell instance $11047 r0 *1 239.97,53.2
X$11047 1785 219 320 1246 BUF_X1
* cell instance $11049 m0 *1 240.16,53.2
X$11049 1683 219 320 1678 BUF_X1
* cell instance $11052 m0 *1 125.21,240.8
X$11052 12422 219 320 8820 CLKBUF_X2
* cell instance $11057 m0 *1 5.51,72.8
X$11057 2555 219 320 2557 BUF_X1
* cell instance $11065 r0 *1 6.46,72.8
X$11065 219 14363 2840 2835 2306 320 DFF_X1
* cell instance $11071 m0 *1 11.97,72.8
X$11071 219 13256 2643 2699 2768 320 DFF_X1
* cell instance $11075 m0 *1 16.15,72.8
X$11075 219 13267 2701 2644 2309 320 DFF_X1
* cell instance $11079 r0 *1 12.35,72.8
X$11079 219 13670 2954 2767 2768 320 DFF_X1
* cell instance $11082 r0 *1 16.15,72.8
X$11082 2559 1734 2701 219 320 2644 MUX2_X1
* cell instance $11084 r0 *1 17.86,72.8
X$11084 219 14581 2769 2841 2309 320 DFF_X1
* cell instance $11085 r0 *1 21.09,72.8
X$11085 2769 1550 2647 219 320 2841 MUX2_X1
* cell instance $11088 m0 *1 71.25,156.8
X$11088 8320 8158 5819 320 219 8325 MUX2_X2
* cell instance $11089 m0 *1 73.15,156.8
X$11089 8322 6917 8365 219 320 8273 MUX2_X1
* cell instance $11092 m0 *1 77.71,156.8
X$11092 6373 219 320 8326 CLKBUF_X3
* cell instance $11093 m0 *1 78.66,156.8
X$11093 8160 7492 6915 219 320 8159 MUX2_X1
* cell instance $11094 m0 *1 79.99,156.8
X$11094 7252 219 320 6915 BUF_X2
* cell instance $11095 m0 *1 80.75,156.8
X$11095 219 12942 8327 8274 8326 320 DFF_X1
* cell instance $11098 m0 *1 85.69,156.8
X$11098 219 13099 8275 8328 7822 320 DFF_X1
* cell instance $11099 m0 *1 88.92,156.8
X$11099 7258 7129 8275 219 320 8328 MUX2_X1
* cell instance $11100 m0 *1 90.25,156.8
X$11100 1282 219 320 7497 CLKBUF_X3
* cell instance $11103 m0 *1 68.21,156.8
X$11103 8415 5517 8319 219 320 8320 MUX2_X1
* cell instance $11105 m0 *1 69.54,156.8
X$11105 8270 5808 8322 219 320 8321 MUX2_X1
* cell instance $11108 r0 *1 68.21,156.8
X$11108 219 14332 8322 8321 8022 320 DFF_X1
* cell instance $11110 r0 *1 71.82,156.8
X$11110 8448 6165 8364 219 320 8323 MUX2_X1
* cell instance $11111 r0 *1 73.15,156.8
X$11111 8270 6270 8365 219 320 8416 MUX2_X1
* cell instance $11112 r0 *1 74.48,156.8
X$11112 219 14106 8365 8416 8326 320 DFF_X1
* cell instance $11115 r0 *1 79.42,156.8
X$11115 8326 219 320 14786 INV_X1
* cell instance $11116 r0 *1 79.8,156.8
X$11116 6915 7192 8366 219 320 8418 MUX2_X1
* cell instance $11117 r0 *1 81.13,156.8
X$11117 8327 7312 6915 219 320 8274 MUX2_X1
* cell instance $11118 r0 *1 82.46,156.8
X$11118 8366 3370 8651 219 320 7097 MUX2_X1
* cell instance $11121 m0 *1 93.67,156.8
X$11121 219 13143 8276 8329 7926 320 DFF_X1
* cell instance $11122 m0 *1 92.34,156.8
X$11122 7258 7490 8276 219 320 8329 MUX2_X1
* cell instance $11125 m0 *1 97.47,156.8
X$11125 8162 7492 7139 219 320 8420 MUX2_X1
* cell instance $11129 m0 *1 99.75,156.8
X$11129 219 13245 8163 8277 8028 320 DFF_X1
* cell instance $11132 r0 *1 97.85,156.8
X$11132 219 14662 8162 8420 7926 320 DFF_X1
* cell instance $11136 m0 *1 103.36,156.8
X$11136 8164 7312 7139 219 320 8331 MUX2_X1
* cell instance $11137 r0 *1 103.36,156.8
X$11137 5515 320 2750 219 BUF_X4
* cell instance $11140 m0 *1 105.07,156.8
X$11140 219 13184 8164 8331 8028 320 DFF_X1
* cell instance $11142 m0 *1 109.25,156.8
X$11142 8235 320 6057 219 BUF_X4
* cell instance $11143 m0 *1 110.58,156.8
X$11143 8422 320 5353 219 BUF_X4
* cell instance $11145 m0 *1 112.67,156.8
X$11145 8423 8121 8424 219 320 8333 MUX2_X1
* cell instance $11147 r0 *1 106.21,156.8
X$11147 6284 219 320 8028 CLKBUF_X3
* cell instance $11148 r0 *1 107.16,156.8
X$11148 8028 219 320 CLKBUF_X1
* cell instance $11151 r0 *1 109.44,156.8
X$11151 8235 219 320 8422 BUF_X1
* cell instance $11154 r0 *1 112.29,156.8
X$11154 8423 8166 8457 219 320 8367 MUX2_X1
* cell instance $11155 r0 *1 113.62,156.8
X$11155 219 13646 8368 8335 7928 320 DFF_X1
* cell instance $11157 m0 *1 114.38,156.8
X$11157 8423 8242 8368 219 320 8335 MUX2_X1
* cell instance $11159 m0 *1 119.51,156.8
X$11159 8122 8278 8280 219 320 8336 MUX2_X1
* cell instance $11160 m0 *1 120.84,156.8
X$11160 8122 8242 8337 219 320 8279 MUX2_X1
* cell instance $11163 r0 *1 117.04,156.8
X$11163 8459 7501 8368 219 320 8369 MUX2_X1
* cell instance $11164 r0 *1 118.37,156.8
X$11164 8369 8370 7607 320 219 8179 MUX2_X2
* cell instance $11170 r0 *1 121.03,156.8
X$11170 219 14044 8337 8279 7928 320 DFF_X1
* cell instance $11171 m0 *1 122.74,156.8
X$11171 8280 7610 8337 219 320 8340 MUX2_X1
* cell instance $11178 m0 *1 125.4,156.8
X$11178 8284 8340 219 320 8281 OR2_X1
* cell instance $11181 m0 *1 127.68,156.8
X$11181 219 7607 320 8284 BUF_X8
* cell instance $11185 m0 *1 132.62,156.8
X$11185 219 13237 8283 8282 7934 320 DFF_X1
* cell instance $11186 m0 *1 131.29,156.8
X$11186 8168 8166 8283 219 320 8282 MUX2_X1
* cell instance $11187 m0 *1 135.85,156.8
X$11187 8284 320 5359 219 BUF_X4
* cell instance $11190 r0 *1 135.85,156.8
X$11190 7934 219 320 CLKBUF_X1
* cell instance $11193 r0 *1 137.37,156.8
X$11193 5428 219 320 7934 CLKBUF_X3
* cell instance $11194 m0 *1 137.75,156.8
X$11194 5359 8666 219 320 8285 OR2_X1
* cell instance $11200 m0 *1 141.17,156.8
X$11200 219 13334 8346 8347 7726 320 DFF_X1
* cell instance $11201 m0 *1 140.41,156.8
X$11201 5359 8286 219 320 8345 OR2_X1
* cell instance $11202 m0 *1 144.4,156.8
X$11202 8464 3260 8346 219 320 8349 MUX2_X1
* cell instance $11204 r0 *1 140.6,156.8
X$11204 219 14488 8464 8429 7726 320 DFF_X1
* cell instance $11206 r0 *1 144.21,156.8
X$11206 8188 8040 8346 219 320 8347 MUX2_X1
* cell instance $11209 m0 *1 146.3,156.8
X$11209 3138 8466 219 320 8170 OR2_X1
* cell instance $11213 m0 *1 148.77,156.8
X$11213 3138 8431 219 320 8350 OR2_X1
* cell instance $11216 m0 *1 151.81,156.8
X$11216 8468 219 320 8351 INV_X1
* cell instance $11219 r0 *1 146.11,156.8
X$11219 8188 7691 8371 219 320 8430 MUX2_X1
* cell instance $11222 r0 *1 148.01,156.8
X$11222 8188 7612 8372 219 320 8432 MUX2_X1
* cell instance $11223 r0 *1 149.34,156.8
X$11223 219 14439 8372 8432 8758 320 DFF_X1
* cell instance $11228 r0 *1 158.08,156.8
X$11228 8287 219 320 8254 INV_X1
* cell instance $11229 r0 *1 158.46,156.8
X$11229 7450 8434 8287 320 219 8433 HA_X1
* cell instance $11230 m0 *1 158.84,156.8
X$11230 8433 8287 8256 219 8046 320 AOI21_X2
* cell instance $11232 m0 *1 160.17,156.8
X$11232 8288 8044 8287 8045 219 320 8352 NAND4_X1
* cell instance $11234 r0 *1 160.36,156.8
X$11234 7210 8059 8288 320 219 8173 HA_X1
* cell instance $11235 m0 *1 161.69,156.8
X$11235 8352 7797 8292 219 320 NOR2_X4
* cell instance $11239 m0 *1 163.97,156.8
X$11239 7904 5958 219 320 8353 NOR2_X2
* cell instance $11241 m0 *1 164.92,156.8
X$11241 11037 219 320 8356 BUF_X2
* cell instance $11244 m0 *1 167.77,156.8
X$11244 7001 8357 219 320 8545 NOR2_X1
* cell instance $11249 m0 *1 170.43,156.8
X$11249 7044 320 2866 219 BUF_X4
* cell instance $11250 m0 *1 169.48,156.8
X$11250 8356 219 320 8050 INV_X4
* cell instance $11251 m0 *1 171.76,156.8
X$11251 3940 6942 3693 6941 320 219 8357 OAI22_X1
* cell instance $11256 r0 *1 171.95,156.8
X$11256 8354 7044 8289 219 8472 320 AOI21_X1
* cell instance $11258 m0 *1 174.04,156.8
X$11258 8050 8179 6949 8059 219 320 8355 AOI22_X1
* cell instance $11260 m0 *1 174.99,156.8
X$11260 6634 8178 8355 8237 6728 320 219 8354 OAI221_X1
* cell instance $11268 r0 *1 176.7,156.8
X$11268 219 8438 7051 8439 8258 320 AOI21_X4
* cell instance $11269 m0 *1 177.46,156.8
X$11269 7941 219 320 7517 BUF_X1
* cell instance $11272 m0 *1 178.22,156.8
X$11272 7329 6539 219 320 8439 NAND2_X1
* cell instance $11274 m0 *1 178.98,156.8
X$11274 8123 320 8220 219 BUF_X4
* cell instance $11276 m0 *1 180.5,156.8
X$11276 8348 5570 219 320 8334 NOR2_X1
* cell instance $11277 m0 *1 181.07,156.8
X$11277 8260 8179 6950 8059 219 320 8343 AOI22_X1
* cell instance $11278 m0 *1 182.02,156.8
X$11278 6237 8237 8291 8178 3868 320 219 8376 OAI221_X1
* cell instance $11279 m0 *1 183.16,156.8
X$11279 6187 8237 8343 8178 6075 320 219 8342 OAI221_X1
* cell instance $11280 m0 *1 184.3,156.8
X$11280 8243 6955 8289 219 8339 320 AOI21_X1
* cell instance $11283 r0 *1 179.93,156.8
X$11283 6237 7671 8437 8375 3868 320 219 8476 OAI221_X1
* cell instance $11286 r0 *1 182.02,156.8
X$11286 7462 219 320 8260 INV_X2
* cell instance $11287 r0 *1 182.59,156.8
X$11287 8376 6635 8289 219 8435 320 AOI21_X1
* cell instance $11289 r0 *1 184.87,156.8
X$11289 8342 6636 8289 219 8425 320 AOI21_X1
* cell instance $11290 m0 *1 185.63,156.8
X$11290 8339 5533 219 320 8338 NOR2_X2
* cell instance $11296 m0 *1 192.09,156.8
X$11296 8332 6636 8293 219 8526 320 AOI21_X1
* cell instance $11297 m0 *1 192.85,156.8
X$11297 6068 8219 8186 7939 320 219 8294 OAI22_X2
* cell instance $11298 m0 *1 194.56,156.8
X$11298 8184 219 320 8295 INV_X1
* cell instance $11299 m0 *1 194.94,156.8
X$11299 8330 6870 8293 219 8296 320 AOI21_X1
* cell instance $11304 r0 *1 187.72,156.8
X$11304 8182 6870 8289 219 8481 320 AOI21_X1
* cell instance $11307 r0 *1 189.05,156.8
X$11307 1079 219 320 8290 INV_X4
* cell instance $11309 r0 *1 191.52,156.8
X$11309 1079 219 320 8062 BUF_X1
* cell instance $11310 r0 *1 192.09,156.8
X$11310 1079 8049 8294 8295 8060 8373 320 219 AOI221_X2
* cell instance $11311 r0 *1 194.18,156.8
X$11311 8062 6982 8428 8295 8380 8427 320 219 AOI221_X2
* cell instance $11313 m0 *1 196.08,156.8
X$11313 8189 3940 8190 4346 8382 8426 219 320 OAI221_X2
* cell instance $11314 m0 *1 198.36,156.8
X$11314 8183 5570 219 320 8297 NOR2_X1
* cell instance $11316 m0 *1 200.45,156.8
X$11316 6950 8192 8421 8194 219 320 8225 AOI22_X1
* cell instance $11317 m0 *1 201.4,156.8
X$11317 8190 8324 8189 4301 8298 6866 219 320 OAI221_X2
* cell instance $11320 m0 *1 205.77,156.8
X$11320 8318 4007 8387 320 219 8315 HA_X1
* cell instance $11321 m0 *1 207.67,156.8
X$11321 8315 219 320 8389 INV_X1
* cell instance $11324 m0 *1 214.89,156.8
X$11324 219 12870 8197 8299 8314 320 DFF_X1
* cell instance $11325 m0 *1 218.12,156.8
X$11325 8197 7420 8393 219 320 8311 MUX2_X1
* cell instance $11327 r0 *1 196.27,156.8
X$11327 8293 2807 219 320 8529 NAND2_X1
* cell instance $11329 r0 *1 197.22,156.8
X$11329 8425 5958 219 320 8410 NOR2_X1
* cell instance $11331 r0 *1 197.98,156.8
X$11331 8381 8192 8194 8060 219 320 8382 AOI22_X2
* cell instance $11334 r0 *1 200.83,156.8
X$11334 6732 8192 8194 8380 219 320 8298 AOI22_X2
* cell instance $11336 r0 *1 202.92,156.8
X$11336 7542 219 320 6941 BUF_X1
* cell instance $11337 r0 *1 203.49,156.8
X$11337 8383 7546 8489 219 320 8598 NOR3_X1
* cell instance $11338 r0 *1 204.25,156.8
X$11338 2524 219 320 6942 BUF_X1
* cell instance $11339 r0 *1 204.82,156.8
X$11339 8490 219 320 8384 BUF_X1
* cell instance $11340 r0 *1 205.39,156.8
X$11340 8385 8386 8387 320 8419 219 OAI21_X1
* cell instance $11342 r0 *1 206.34,156.8
X$11342 8388 8385 219 320 8493 NAND2_X2
* cell instance $11343 r0 *1 207.29,156.8
X$11343 8419 8389 219 320 8605 NAND2_X1
* cell instance $11344 r0 *1 207.86,156.8
X$11344 8390 8315 8386 219 320 8417 OR3_X1
* cell instance $11349 r0 *1 214.51,156.8
X$11349 219 14058 8393 8392 8314 320 DFF_X1
* cell instance $11351 r0 *1 217.93,156.8
X$11351 8196 6740 8393 219 320 8392 MUX2_X1
* cell instance $11353 m0 *1 220.02,156.8
X$11353 8196 6860 8300 219 320 8310 MUX2_X1
* cell instance $11355 m0 *1 221.35,156.8
X$11355 219 12771 8300 8310 7958 320 DFF_X1
* cell instance $11358 m0 *1 227.81,156.8
X$11358 8072 7753 8073 219 320 8200 MUX2_X1
* cell instance $11362 r0 *1 220.21,156.8
X$11362 8196 6843 8411 219 320 8412 MUX2_X1
* cell instance $11363 r0 *1 221.54,156.8
X$11363 219 13785 8411 8412 7958 320 DFF_X1
* cell instance $11369 m0 *1 233.51,156.8
X$11369 8302 219 320 8070 BUF_X1
* cell instance $11370 m0 *1 231.04,156.8
X$11370 8308 7957 8396 320 219 7948 OAI21_X4
* cell instance $11371 m0 *1 234.08,156.8
X$11371 6410 8301 219 320 8308 OR2_X1
* cell instance $11372 m0 *1 234.84,156.8
X$11372 5757 219 320 8086 CLKBUF_X3
* cell instance $11373 m0 *1 235.79,156.8
X$11373 7963 8212 7962 219 320 8076 MUX2_X1
* cell instance $11374 m0 *1 237.12,156.8
X$11374 8101 219 320 8079 BUF_X1
* cell instance $11375 m0 *1 237.69,156.8
X$11375 7860 219 320 8202 BUF_X1
* cell instance $11379 r0 *1 231.42,156.8
X$11379 8394 7539 8395 219 320 8396 MUX2_X1
* cell instance $11380 r0 *1 232.75,156.8
X$11380 219 13821 8395 8397 8086 320 DFF_X1
* cell instance $11382 r0 *1 236.17,156.8
X$11382 219 13952 8398 8407 8086 320 DFF_X1
* cell instance $11383 r0 *1 239.4,156.8
X$11383 7087 219 320 8400 BUF_X1
* cell instance $11385 m0 *1 239.4,156.8
X$11385 8206 219 320 8201 BUF_X1
* cell instance $11386 m0 *1 240.16,156.8
X$11386 7871 219 320 8203 BUF_X1
* cell instance $11389 r0 *1 240.16,156.8
X$11389 8334 219 320 8303 BUF_X1
* cell instance $11392 m0 *1 21.66,78.4
X$11392 219 13190 3033 3080 2771 320 DFF_X1
* cell instance $11393 m0 *1 25.08,78.4
X$11393 2881 1553 2885 219 320 3082 MUX2_X1
* cell instance $11394 m0 *1 26.41,78.4
X$11394 3033 2842 2885 219 320 3083 MUX2_X1
* cell instance $11397 m0 *1 28.69,78.4
X$11397 1370 219 320 2771 CLKBUF_X3
* cell instance $11398 m0 *1 29.64,78.4
X$11398 2881 1261 3034 219 320 3035 MUX2_X1
* cell instance $11399 m0 *1 30.97,78.4
X$11399 2771 219 320 CLKBUF_X1
* cell instance $11401 m0 *1 31.73,78.4
X$11401 3083 2963 2886 219 320 3085 MUX2_X1
* cell instance $11403 m0 *1 34.58,78.4
X$11403 219 12648 2968 3036 2771 320 DFF_X1
* cell instance $11407 m0 *1 40.28,78.4
X$11407 219 12570 3037 3087 3086 320 DFF_X1
* cell instance $11408 m0 *1 43.51,78.4
X$11408 3037 1469 2775 219 320 3087 MUX2_X1
* cell instance $11413 m0 *1 50.35,78.4
X$11413 219 12644 3038 3094 2975 320 DFF_X1
* cell instance $11414 m0 *1 53.58,78.4
X$11414 3038 2714 3191 219 320 3040 MUX2_X1
* cell instance $11415 m0 *1 54.91,78.4
X$11415 3040 2892 2896 219 320 3039 MUX2_X1
* cell instance $11418 m0 *1 59.47,78.4
X$11418 219 13511 3197 3195 2975 320 DFF_X1
* cell instance $11419 m0 *1 62.7,78.4
X$11419 3041 1389 3042 219 320 3198 MUX2_X1
* cell instance $11421 m0 *1 67.07,78.4
X$11421 3041 1476 2900 219 320 2982 MUX2_X1
* cell instance $11422 m0 *1 68.4,78.4
X$11422 3041 1478 3043 219 320 2984 MUX2_X1
* cell instance $11424 m0 *1 69.92,78.4
X$11424 3043 2520 2900 219 320 3099 MUX2_X1
* cell instance $11427 m0 *1 5.32,78.4
X$11427 3029 219 320 3076 BUF_X1
* cell instance $11429 m0 *1 5.89,78.4
X$11429 2880 219 320 3030 BUF_X1
* cell instance $11430 m0 *1 6.46,78.4
X$11430 2558 3030 320 219 3031 AND2_X1
* cell instance $11431 m0 *1 7.22,78.4
X$11431 2558 3076 320 219 3077 AND2_X1
* cell instance $11432 m0 *1 7.98,78.4
X$11432 219 13313 3078 3077 2768 320 DFF_X1
* cell instance $11436 r0 *1 5.32,78.4
X$11436 3027 219 320 3177 BUF_X1
* cell instance $11438 r0 *1 6.08,78.4
X$11438 2558 3177 320 219 3178 AND2_X1
* cell instance $11439 r0 *1 6.84,78.4
X$11439 219 14422 3180 3031 3296 320 DFF_X1
* cell instance $11443 r0 *1 10.07,78.4
X$11443 2881 1547 3124 219 320 3179 MUX2_X1
* cell instance $11444 r0 *1 11.4,78.4
X$11444 219 14330 3124 3179 3296 320 DFF_X1
* cell instance $11445 m0 *1 12.54,78.4
X$11445 3078 320 2239 219 BUF_X4
* cell instance $11449 m0 *1 14.25,78.4
X$11449 2768 219 320 CLKBUF_X1
* cell instance $11451 r0 *1 14.63,78.4
X$11451 3124 2520 3301 219 320 3182 MUX2_X1
* cell instance $11453 m0 *1 17.29,78.4
X$11453 219 13179 3032 3079 2768 320 DFF_X1
* cell instance $11454 m0 *1 15.96,78.4
X$11454 3180 320 2342 219 BUF_X4
* cell instance $11457 r0 *1 16.34,78.4
X$11457 219 14300 3181 3125 2768 320 DFF_X1
* cell instance $11458 r0 *1 19.57,78.4
X$11458 3127 3126 3182 219 320 3184 MUX2_X1
* cell instance $11464 r0 *1 29.83,78.4
X$11464 219 14130 3034 3035 3244 320 DFF_X1
* cell instance $11468 r0 *1 40.09,78.4
X$11468 3085 2776 219 320 3189 NAND2_X1
* cell instance $11469 r0 *1 40.66,78.4
X$11469 3088 1835 3186 219 320 3187 MUX2_X1
* cell instance $11471 r0 *1 42.18,78.4
X$11471 3187 2777 219 320 3089 NAND2_X1
* cell instance $11472 r0 *1 42.75,78.4
X$11472 3189 3089 2890 219 320 3192 NAND3_X2
* cell instance $11474 r0 *1 45.6,78.4
X$11474 219 14664 3248 3190 3086 320 DFF_X1
* cell instance $11477 r0 *1 49.97,78.4
X$11477 2775 1385 3191 219 320 3128 MUX2_X1
* cell instance $11478 r0 *1 51.3,78.4
X$11478 219 13652 3191 3128 2975 320 DFF_X1
* cell instance $11479 r0 *1 54.53,78.4
X$11479 3039 2149 3184 219 320 3251 MUX2_X1
* cell instance $11481 r0 *1 56.24,78.4
X$11481 1515 219 320 2975 CLKBUF_X3
* cell instance $11482 r0 *1 57.19,78.4
X$11482 3028 219 320 3041 BUF_X1
* cell instance $11483 r0 *1 57.76,78.4
X$11483 2975 219 320 CLKBUF_X1
* cell instance $11486 r0 *1 60.61,78.4
X$11486 3129 1647 3197 219 320 3195 MUX2_X1
* cell instance $11488 r0 *1 62.7,78.4
X$11488 219 13768 3042 3198 3361 320 DFF_X1
* cell instance $11494 r0 *1 68.21,78.4
X$11494 219 14568 3131 3130 2785 320 DFF_X1
* cell instance $11499 r0 *1 74.29,78.4
X$11499 3129 1999 3104 219 320 3045 MUX2_X1
* cell instance $11500 m0 *1 74.86,78.4
X$11500 219 13166 3104 3045 2785 320 DFF_X1
* cell instance $11504 m0 *1 79.8,78.4
X$11504 2901 320 1392 219 BUF_X4
* cell instance $11505 m0 *1 81.13,78.4
X$11505 2901 320 1844 219 BUF_X4
* cell instance $11508 m0 *1 83.41,78.4
X$11508 219 13294 3204 3107 2790 320 DFF_X1
* cell instance $11511 r0 *1 76,78.4
X$11511 3129 1983 3132 219 320 3200 MUX2_X1
* cell instance $11513 r0 *1 77.71,78.4
X$11513 219 14402 3132 3200 3761 320 DFF_X1
* cell instance $11516 r0 *1 82.08,78.4
X$11516 219 14434 3326 3201 2790 320 DFF_X1
* cell instance $11519 r0 *1 85.88,78.4
X$11519 3204 2032 3202 219 320 3107 MUX2_X1
* cell instance $11520 m0 *1 87.21,78.4
X$11520 3046 1480 3111 219 320 3110 MUX2_X1
* cell instance $11522 m0 *1 88.54,78.4
X$11522 219 13255 3111 3110 2790 320 DFF_X1
* cell instance $11525 m0 *1 94.05,78.4
X$11525 3046 219 320 3050 BUF_X2
* cell instance $11530 r0 *1 88.35,78.4
X$11530 219 14346 3207 3208 2790 320 DFF_X1
* cell instance $11531 r0 *1 91.58,78.4
X$11531 3046 1478 3207 219 320 3208 MUX2_X1
* cell instance $11533 r0 *1 93.29,78.4
X$11533 3046 1389 3213 219 320 3211 MUX2_X1
* cell instance $11534 r0 *1 94.62,78.4
X$11534 219 13837 3213 3211 3133 320 DFF_X1
* cell instance $11535 m0 *1 96.14,78.4
X$11535 219 13120 3047 3212 2668 320 DFF_X1
* cell instance $11538 m0 *1 99.56,78.4
X$11538 3050 2037 2906 219 320 3048 MUX2_X1
* cell instance $11539 m0 *1 100.89,78.4
X$11539 1578 219 320 2668 CLKBUF_X3
* cell instance $11541 m0 *1 102.6,78.4
X$11541 3050 2148 3049 219 320 3215 MUX2_X1
* cell instance $11543 m0 *1 104.12,78.4
X$11543 2901 320 1576 219 BUF_X4
* cell instance $11552 m0 *1 135.28,78.4
X$11552 287 3135 3140 219 320 3118 MUX2_X1
* cell instance $11557 m0 *1 142.12,78.4
X$11557 219 12803 3142 3236 2916 320 DFF_X1
* cell instance $11559 m0 *1 145.54,78.4
X$11559 219 12848 3051 2583 2916 320 DFF_X1
* cell instance $11562 r0 *1 97.85,78.4
X$11562 3050 1898 3047 219 320 3212 MUX2_X1
* cell instance $11565 r0 *1 100.13,78.4
X$11565 2905 3214 2906 219 320 3489 MUX2_X1
* cell instance $11566 r0 *1 101.46,78.4
X$11566 3111 3214 3049 219 320 3368 MUX2_X1
* cell instance $11568 r0 *1 102.98,78.4
X$11568 219 13834 3049 3215 2668 320 DFF_X1
* cell instance $11572 r0 *1 118.56,78.4
X$11572 3222 219 320 2558 CLKBUF_X3
* cell instance $11583 r0 *1 125.78,78.4
X$11583 219 14592 3340 3225 3134 320 DFF_X1
* cell instance $11586 r0 *1 130.15,78.4
X$11586 1396 3135 3137 219 320 3227 MUX2_X1
* cell instance $11588 r0 *1 131.67,78.4
X$11588 1943 219 320 2800 CLKBUF_X3
* cell instance $11589 r0 *1 132.62,78.4
X$11589 3138 3116 219 320 3261 OR2_X1
* cell instance $11592 r0 *1 133.95,78.4
X$11592 3138 2911 219 320 3139 OR2_X1
* cell instance $11593 r0 *1 134.71,78.4
X$11593 219 13751 3140 3118 2800 320 DFF_X1
* cell instance $11594 r0 *1 137.94,78.4
X$11594 287 3136 3263 219 320 3232 MUX2_X1
* cell instance $11595 r0 *1 139.27,78.4
X$11595 3138 2914 219 320 3234 OR2_X1
* cell instance $11596 r0 *1 140.03,78.4
X$11596 760 3135 3235 219 320 3141 MUX2_X1
* cell instance $11597 r0 *1 141.36,78.4
X$11597 219 14053 3235 3141 2916 320 DFF_X1
* cell instance $11598 r0 *1 144.59,78.4
X$11598 760 3136 3142 219 320 3236 MUX2_X1
* cell instance $11599 r0 *1 145.92,78.4
X$11599 3143 3238 219 320 2583 NOR2_X1
* cell instance $11600 r0 *1 146.49,78.4
X$11600 1943 219 320 2916 CLKBUF_X3
* cell instance $11602 r0 *1 147.82,78.4
X$11602 3051 3240 219 320 3143 XOR2_X1
* cell instance $11603 r0 *1 148.96,78.4
X$11603 3138 3015 219 320 3144 OR2_X1
* cell instance $11605 m0 *1 150.1,78.4
X$11605 3264 3122 320 219 3052 AND2_X1
* cell instance $11607 m0 *1 150.86,78.4
X$11607 2874 3121 2918 219 320 3122 MUX2_X1
* cell instance $11608 m0 *1 152.19,78.4
X$11608 2875 3121 3018 219 320 3242 MUX2_X1
* cell instance $11613 r0 *1 153.14,78.4
X$11613 3243 3242 320 219 3016 AND2_X1
* cell instance $11614 r0 *1 153.9,78.4
X$11614 219 13962 3146 3145 3375 320 DFF_X1
* cell instance $11615 m0 *1 156.37,78.4
X$11615 3146 219 320 3053 BUF_X1
* cell instance $11619 r0 *1 157.13,78.4
X$11619 219 2679 320 3146 BUF_X8
* cell instance $11621 m0 *1 158.08,78.4
X$11621 3054 3120 3147 219 233 320 AOI21_X2
* cell instance $11623 m0 *1 161.12,78.4
X$11623 1747 2810 219 320 3056 NAND2_X1
* cell instance $11624 m0 *1 159.79,78.4
X$11624 2808 3056 3055 219 226 320 AOI21_X2
* cell instance $11627 r0 *1 160.17,78.4
X$11627 3241 219 320 3349 BUF_X1
* cell instance $11629 r0 *1 161.12,78.4
X$11629 2925 3149 3148 219 237 320 AOI21_X2
* cell instance $11631 m0 *1 162.07,78.4
X$11631 1747 2813 219 320 2921 NAND2_X1
* cell instance $11634 m0 *1 163.02,78.4
X$11634 2720 2814 219 320 3149 NAND2_X1
* cell instance $11636 m0 *1 163.97,78.4
X$11636 2808 3117 3239 219 412 320 AOI21_X2
* cell instance $11639 m0 *1 165.68,78.4
X$11639 1925 2810 219 320 3117 NAND2_X1
* cell instance $11640 m0 *1 167.77,78.4
X$11640 3058 3115 3152 219 495 320 AOI21_X2
* cell instance $11641 m0 *1 169.1,78.4
X$11641 1925 2807 219 320 3115 NAND2_X1
* cell instance $11642 m0 *1 169.67,78.4
X$11642 2925 3114 3057 219 250 320 AOI21_X2
* cell instance $11648 r0 *1 168.34,78.4
X$11648 1925 2866 219 320 3151 NAND2_X1
* cell instance $11651 m0 *1 172.33,78.4
X$11651 2191 2866 219 320 3154 NAND2_X1
* cell instance $11653 m0 *1 172.9,78.4
X$11653 2191 2807 219 320 3112 NAND2_X1
* cell instance $11655 m0 *1 173.66,78.4
X$11655 219 384 3058 3112 3059 320 AOI21_X4
* cell instance $11658 r0 *1 173.09,78.4
X$11658 3233 3156 3158 1442 320 219 3157 OAI22_X1
* cell instance $11659 r0 *1 174.04,78.4
X$11659 2287 2866 219 320 3460 NAND2_X1
* cell instance $11661 r0 *1 174.99,78.4
X$11661 3231 3159 219 320 3228 NOR2_X2
* cell instance $11665 r0 *1 175.94,78.4
X$11665 3229 3160 219 320 3230 NOR2_X2
* cell instance $11667 m0 *1 179.17,78.4
X$11667 2287 2810 219 320 3061 NAND2_X1
* cell instance $11669 m0 *1 179.93,78.4
X$11669 2287 2814 219 320 3109 NAND2_X1
* cell instance $11672 r0 *1 178.41,78.4
X$11672 3161 3509 219 320 3223 NOR2_X1
* cell instance $11673 r0 *1 178.98,78.4
X$11673 3226 2925 219 320 243 NOR2_X2
* cell instance $11676 m0 *1 180.88,78.4
X$11676 2925 3109 3223 219 456 320 AOI21_X2
* cell instance $11677 m0 *1 183.73,78.4
X$11677 3106 3105 2352 320 219 3103 MUX2_X2
* cell instance $11682 m0 *1 196.84,78.4
X$11682 2259 3098 219 320 3101 OR2_X1
* cell instance $11689 r0 *1 184.3,78.4
X$11689 3220 3163 219 320 274 NOR2_X2
* cell instance $11690 r0 *1 185.25,78.4
X$11690 3219 3163 219 320 269 NOR2_X2
* cell instance $11693 r0 *1 187.15,78.4
X$11693 3093 3162 219 320 3164 NOR2_X1
* cell instance $11694 r0 *1 187.72,78.4
X$11694 3164 3324 3216 219 320 3219 NOR3_X1
* cell instance $11695 r0 *1 188.48,78.4
X$11695 3217 544 3158 1206 320 219 3216 OAI22_X1
* cell instance $11700 r0 *1 192.28,78.4
X$11700 3437 3163 219 320 409 NOR2_X2
* cell instance $11701 r0 *1 193.23,78.4
X$11701 219 14550 3209 3206 3210 320 DFF_X1
* cell instance $11702 r0 *1 196.46,78.4
X$11702 3165 2165 3209 219 320 3206 MUX2_X1
* cell instance $11706 r0 *1 200.26,78.4
X$11706 3097 2933 2935 320 219 3205 OAI21_X4
* cell instance $11707 m0 *1 201.97,78.4
X$11707 2072 2936 219 320 3097 OR2_X1
* cell instance $11714 r0 *1 203.87,78.4
X$11714 219 13712 3166 3203 3289 320 DFF_X1
* cell instance $11715 m0 *1 208.24,78.4
X$11715 219 13607 3064 2939 2366 320 DFF_X1
* cell instance $11716 m0 *1 206.91,78.4
X$11716 3064 3062 2848 219 320 3063 MUX2_X1
* cell instance $11719 m0 *1 212.42,78.4
X$11719 3065 2261 3167 219 320 3095 MUX2_X1
* cell instance $11722 m0 *1 216.03,78.4
X$11722 2830 2368 2942 219 320 2974 MUX2_X1
* cell instance $11723 m0 *1 217.36,78.4
X$11723 219 2491 2976 320 BUF_X32
* cell instance $11724 m0 *1 226.67,78.4
X$11724 219 13218 3066 3090 2945 320 DFF_X1
* cell instance $11725 m0 *1 229.9,78.4
X$11725 219 13299 3068 3067 2945 320 DFF_X1
* cell instance $11726 m0 *1 233.13,78.4
X$11726 3069 3081 2946 219 320 2965 MUX2_X1
* cell instance $11727 m0 *1 234.46,78.4
X$11727 2832 3293 2959 219 320 2961 MUX2_X1
* cell instance $11728 m0 *1 235.79,78.4
X$11728 2832 3070 2958 219 320 2960 MUX2_X1
* cell instance $11729 m0 *1 237.12,78.4
X$11729 2953 3071 3072 219 320 3084 MUX2_X1
* cell instance $11730 m0 *1 238.45,78.4
X$11730 2832 3081 3072 219 320 2956 MUX2_X1
* cell instance $11731 m0 *1 239.78,78.4
X$11731 3302 219 320 3074 BUF_X1
* cell instance $11734 r0 *1 207.48,78.4
X$11734 2259 3063 219 320 3288 OR2_X1
* cell instance $11736 r0 *1 209,78.4
X$11736 219 13932 3167 3095 3291 320 DFF_X1
* cell instance $11740 r0 *1 213.56,78.4
X$11740 3065 2169 3310 219 320 3168 MUX2_X1
* cell instance $11741 r0 *1 214.89,78.4
X$11741 3169 2261 3170 219 320 3309 MUX2_X1
* cell instance $11745 r0 *1 218.69,78.4
X$11745 2830 2261 3308 219 320 3199 MUX2_X1
* cell instance $11746 r0 *1 220.02,78.4
X$11746 219 14633 2943 3091 2591 320 DFF_X1
* cell instance $11750 r0 *1 225.34,78.4
X$11750 219 13842 3306 3196 2945 320 DFF_X1
* cell instance $11751 r0 *1 228.57,78.4
X$11751 3069 3070 3066 219 320 3090 MUX2_X1
* cell instance $11752 r0 *1 229.9,78.4
X$11752 3069 2831 3068 219 320 3067 MUX2_X1
* cell instance $11756 r0 *1 231.23,78.4
X$11756 3068 3071 2946 219 320 3194 MUX2_X1
* cell instance $11757 r0 *1 232.56,78.4
X$11757 1869 219 320 2945 CLKBUF_X3
* cell instance $11759 r0 *1 234.27,78.4
X$11759 3174 219 320 2938 BUF_X1
* cell instance $11761 r0 *1 235.03,78.4
X$11761 2959 3171 2958 219 320 3172 MUX2_X1
* cell instance $11763 r0 *1 236.55,78.4
X$11763 3173 3084 219 320 3185 OR2_X1
* cell instance $11764 r0 *1 237.31,78.4
X$11764 3075 219 320 3169 BUF_X1
* cell instance $11765 r0 *1 237.88,78.4
X$11765 3176 219 320 2832 BUF_X1
* cell instance $11766 r0 *1 238.45,78.4
X$11766 3183 219 320 3065 BUF_X1
* cell instance $11769 r0 *1 239.59,78.4
X$11769 2948 219 320 2689 BUF_X1
* cell instance $11776 m0 *1 5.51,184.8
X$11776 10125 219 320 10028 BUF_X1
* cell instance $11777 m0 *1 6.08,184.8
X$11777 219 12735 10129 10126 10127 320 DFF_X1
* cell instance $11778 m0 *1 9.31,184.8
X$11778 10129 8788 10128 219 320 10166 MUX2_X1
* cell instance $11785 r0 *1 5.89,184.8
X$11785 10028 7171 10129 219 320 10126 MUX2_X1
* cell instance $11791 r0 *1 8.36,184.8
X$11791 10028 7121 10128 219 320 10027 MUX2_X1
* cell instance $11795 r0 *1 11.78,184.8
X$11795 10335 6902 9852 219 320 10382 MUX2_X1
* cell instance $11796 r0 *1 13.11,184.8
X$11796 219 14538 10336 10276 9936 320 DFF_X1
* cell instance $11797 m0 *1 18.05,184.8
X$11797 10131 9287 10223 219 320 10169 MUX2_X1
* cell instance $11798 m0 *1 14.82,184.8
X$11798 219 12737 10131 10130 9936 320 DFF_X1
* cell instance $11801 r0 *1 16.53,184.8
X$11801 9852 6853 10223 219 320 10277 MUX2_X1
* cell instance $11802 r0 *1 17.86,184.8
X$11802 219 14632 10223 10277 9936 320 DFF_X1
* cell instance $11803 m0 *1 19.95,184.8
X$11803 10168 8262 10169 219 320 10132 MUX2_X1
* cell instance $11808 m0 *1 21.66,184.8
X$11808 10132 8927 10170 219 320 10172 MUX2_X1
* cell instance $11810 m0 *1 25.27,184.8
X$11810 9941 219 320 CLKBUF_X1
* cell instance $11811 m0 *1 25.84,184.8
X$11811 219 13042 10079 10171 9941 320 DFF_X1
* cell instance $11816 r0 *1 25.46,184.8
X$11816 10337 6909 10433 219 320 10519 MUX2_X1
* cell instance $11817 r0 *1 26.79,184.8
X$11817 10433 7082 10224 219 320 10279 MUX2_X1
* cell instance $11818 r0 *1 28.12,184.8
X$11818 219 14657 10224 10279 9942 320 DFF_X1
* cell instance $11819 m0 *1 29.64,184.8
X$11819 10393 8792 10173 219 320 10225 MUX2_X1
* cell instance $11825 r0 *1 31.92,184.8
X$11825 10226 10394 9035 320 219 9060 MUX2_X2
* cell instance $11826 m0 *1 33.82,184.8
X$11826 219 12728 10084 10133 9942 320 DFF_X1
* cell instance $11827 m0 *1 32.87,184.8
X$11827 9405 219 320 9942 CLKBUF_X3
* cell instance $11828 m0 *1 37.05,184.8
X$11828 219 12787 10178 10176 9859 320 DFF_X1
* cell instance $11832 r0 *1 33.82,184.8
X$11832 219 14271 10227 10338 9942 320 DFF_X1
* cell instance $11833 r0 *1 37.05,184.8
X$11833 9942 219 320 14787 INV_X1
* cell instance $11834 r0 *1 37.43,184.8
X$11834 10084 8799 10178 219 320 10339 MUX2_X1
* cell instance $11835 r0 *1 38.76,184.8
X$11835 9858 8867 10281 219 320 10283 MUX2_X1
* cell instance $11837 r0 *1 40.47,184.8
X$11837 10284 10283 9035 320 219 7889 MUX2_X2
* cell instance $11838 m0 *1 42.75,184.8
X$11838 219 12793 10134 10286 9861 320 DFF_X1
* cell instance $11839 m0 *1 41.42,184.8
X$11839 9944 6853 10134 219 320 10286 MUX2_X1
* cell instance $11840 m0 *1 45.98,184.8
X$11840 10342 9763 10134 219 320 10181 MUX2_X1
* cell instance $11844 m0 *1 49.78,184.8
X$11844 9944 6974 10184 219 320 10183 MUX2_X1
* cell instance $11845 m0 *1 51.11,184.8
X$11845 219 12783 10184 10183 9865 320 DFF_X1
* cell instance $11849 m0 *1 58.33,184.8
X$11849 10185 7490 10187 219 320 10186 MUX2_X1
* cell instance $11851 m0 *1 59.85,184.8
X$11851 219 12823 10136 10189 10135 320 DFF_X1
* cell instance $11853 m0 *1 63.27,184.8
X$11853 10136 7492 9947 219 320 10189 MUX2_X1
* cell instance $11854 m0 *1 64.6,184.8
X$11854 10185 7136 10191 219 320 10293 MUX2_X1
* cell instance $11856 m0 *1 66.12,184.8
X$11856 9537 7091 10137 219 320 10295 MUX2_X1
* cell instance $11857 m0 *1 67.45,184.8
X$11857 10191 8729 10137 219 320 10095 MUX2_X1
* cell instance $11858 m0 *1 68.78,184.8
X$11858 10036 8262 10193 219 320 10096 MUX2_X1
* cell instance $11859 m0 *1 70.11,184.8
X$11859 10228 8908 10296 219 320 10193 MUX2_X1
* cell instance $11866 r0 *1 44.65,184.8
X$11866 219 14368 10342 10407 9861 320 DFF_X1
* cell instance $11867 r0 *1 47.88,184.8
X$11867 9405 219 320 9861 CLKBUF_X3
* cell instance $11868 r0 *1 48.83,184.8
X$11868 9861 219 320 14793 INV_X1
* cell instance $11873 r0 *1 59.28,184.8
X$11873 10136 8791 10288 219 320 10412 MUX2_X1
* cell instance $11874 r0 *1 60.61,184.8
X$11874 219 14183 10288 10289 10135 320 DFF_X1
* cell instance $11878 r0 *1 63.84,184.8
X$11878 219 13974 10191 10293 10135 320 DFF_X1
* cell instance $11879 r0 *1 67.07,184.8
X$11879 219 13765 10228 10414 10135 320 DFF_X1
* cell instance $11880 r0 *1 70.3,184.8
X$11880 219 14123 10296 10415 10135 320 DFF_X1
* cell instance $11882 m0 *1 77.33,184.8
X$11882 219 12713 10196 10195 9767 320 DFF_X1
* cell instance $11883 m0 *1 74.1,184.8
X$11883 219 12716 10040 10194 9767 320 DFF_X1
* cell instance $11887 r0 *1 75.43,184.8
X$11887 9947 7027 10229 219 320 10297 MUX2_X1
* cell instance $11888 r0 *1 76.76,184.8
X$11888 219 14298 10229 10297 9767 320 DFF_X1
* cell instance $11890 r0 *1 80.18,184.8
X$11890 10421 8920 10198 219 320 10424 MUX2_X1
* cell instance $11892 m0 *1 83.03,184.8
X$11892 219 12672 10202 10200 9770 320 DFF_X1
* cell instance $11893 m0 *1 81.7,184.8
X$11893 9869 7091 10202 219 320 10200 MUX2_X1
* cell instance $11896 m0 *1 87.97,184.8
X$11896 10204 7492 9869 219 320 10230 MUX2_X1
* cell instance $11898 r0 *1 81.7,184.8
X$11898 10298 9763 10202 219 320 10299 MUX2_X1
* cell instance $11900 r0 *1 83.41,184.8
X$11900 219 14121 10298 10425 9770 320 DFF_X1
* cell instance $11902 r0 *1 87.4,184.8
X$11902 219 14023 10204 10230 10347 320 DFF_X1
* cell instance $11903 m0 *1 89.87,184.8
X$11903 219 12678 10139 10138 9770 320 DFF_X1
* cell instance $11905 m0 *1 93.1,184.8
X$11905 10231 5005 10139 219 320 10205 MUX2_X1
* cell instance $11912 r0 *1 91.01,184.8
X$11912 9869 7027 10139 219 320 10138 MUX2_X1
* cell instance $11914 r0 *1 93.1,184.8
X$11914 10231 7312 9869 219 320 10304 MUX2_X1
* cell instance $11915 r0 *1 94.43,184.8
X$11915 219 14140 10231 10304 9772 320 DFF_X1
* cell instance $11919 r0 *1 102.41,184.8
X$11919 8697 219 320 9772 CLKBUF_X3
* cell instance $11920 r0 *1 103.36,184.8
X$11920 9772 219 320 14767 INV_X1
* cell instance $11923 r0 *1 106.02,184.8
X$11923 10305 6785 10428 10446 10429 10307 320 219 AOI221_X2
* cell instance $11925 m0 *1 106.21,184.8
X$11925 2293 9488 9797 2197 320 10305 219 NOR4_X2
* cell instance $11927 r0 *1 108.11,184.8
X$11927 9797 9488 2293 2197 219 320 10349 OR4_X1
* cell instance $11929 m0 *1 113.05,184.8
X$11929 9951 10141 320 219 10046 XNOR2_X1
* cell instance $11930 m0 *1 109.82,184.8
X$11930 219 12727 10140 10206 9920 320 DFF_X1
* cell instance $11931 m0 *1 114.19,184.8
X$11931 10140 10208 320 219 10237 XNOR2_X1
* cell instance $11932 m0 *1 115.33,184.8
X$11932 8697 219 320 9920 CLKBUF_X3
* cell instance $11934 m0 *1 116.47,184.8
X$11934 10209 6713 10142 219 10106 320 AOI21_X1
* cell instance $11936 m0 *1 120.27,184.8
X$11936 219 13432 10109 10108 10143 320 DFF_X1
* cell instance $11937 m0 *1 123.5,184.8
X$11937 10109 7610 10048 219 320 10212 MUX2_X1
* cell instance $11942 r0 *1 110.96,184.8
X$11942 10236 7820 219 320 10206 NOR2_X1
* cell instance $11943 r0 *1 111.53,184.8
X$11943 10350 10104 10232 219 320 10233 NOR3_X1
* cell instance $11944 r0 *1 112.29,184.8
X$11944 10140 10234 219 320 10235 NOR2_X1
* cell instance $11945 r0 *1 112.86,184.8
X$11945 10235 10351 219 320 10141 NAND2_X1
* cell instance $11946 r0 *1 113.43,184.8
X$11946 10208 9951 10140 219 320 10308 NOR3_X1
* cell instance $11947 r0 *1 114.19,184.8
X$11947 10142 10237 9488 320 10236 219 OAI21_X1
* cell instance $11949 r0 *1 115.14,184.8
X$11949 10106 10236 10310 10233 219 320 10238 NAND4_X1
* cell instance $11951 r0 *1 116.28,184.8
X$11951 10311 10142 6680 219 10310 320 AOI21_X1
* cell instance $11957 r0 *1 121.6,184.8
X$11957 9870 8121 9953 219 320 10239 MUX2_X1
* cell instance $11965 r0 *1 126.54,184.8
X$11965 10240 10426 10677 320 219 10242 HA_X1
* cell instance $11966 m0 *1 127.68,184.8
X$11966 10318 320 4294 219 BUF_X4
* cell instance $11968 m0 *1 129.01,184.8
X$11968 10354 320 4377 219 BUF_X4
* cell instance $11969 m0 *1 130.34,184.8
X$11969 4294 320 9154 219 BUF_X4
* cell instance $11970 m0 *1 131.67,184.8
X$11970 4351 320 8821 219 BUF_X4
* cell instance $11971 m0 *1 133,184.8
X$11971 4377 320 8699 219 BUF_X4
* cell instance $11973 m0 *1 134.52,184.8
X$11973 219 10243 10050 12494 7450 320 DFF_X2
* cell instance $11974 m0 *1 138.13,184.8
X$11974 10325 320 9329 219 BUF_X4
* cell instance $11975 m0 *1 139.46,184.8
X$11975 219 10214 10112 12500 7399 320 DFF_X2
* cell instance $11976 m0 *1 143.07,184.8
X$11976 9546 10244 8114 10144 320 219 10246 AND4_X1
* cell instance $11977 m0 *1 144.21,184.8
X$11977 9124 219 320 10144 INV_X1
* cell instance $11980 m0 *1 147.82,184.8
X$11980 9835 10215 10464 320 10145 219 NOR3_X2
* cell instance $11983 r0 *1 128.44,184.8
X$11983 10241 10242 219 320 10318 NAND2_X1
* cell instance $11985 r0 *1 129.2,184.8
X$11985 10355 320 4351 219 BUF_X4
* cell instance $11986 r0 *1 130.53,184.8
X$11986 10319 320 4505 219 BUF_X4
* cell instance $11988 r0 *1 132.05,184.8
X$11988 5131 10747 320 219 10111 AND2_X1
* cell instance $11991 r0 *1 134.71,184.8
X$11991 5131 10422 320 219 10243 AND2_X1
* cell instance $11993 r0 *1 135.66,184.8
X$11993 219 7502 10051 320 BUF_X16
* cell instance $11995 r0 *1 140.6,184.8
X$11995 9546 10244 8114 320 219 10359 AND3_X1
* cell instance $11997 r0 *1 141.93,184.8
X$11997 10247 10358 219 320 10245 NAND2_X1
* cell instance $11999 r0 *1 142.88,184.8
X$11999 10144 8114 10244 9546 219 320 10546 NAND4_X1
* cell instance $12000 r0 *1 143.83,184.8
X$12000 9017 219 320 10327 INV_X1
* cell instance $12002 r0 *1 144.4,184.8
X$12002 10327 10246 10248 320 10419 219 OAI21_X1
* cell instance $12003 r0 *1 145.16,184.8
X$12003 10249 10043 219 320 10248 NOR2_X1
* cell instance $12004 r0 *1 145.73,184.8
X$12004 9147 9546 219 320 10360 OR2_X1
* cell instance $12005 r0 *1 146.49,184.8
X$12005 8114 8119 219 320 10361 NAND2_X1
* cell instance $12006 r0 *1 147.06,184.8
X$12006 8114 9546 9147 320 10329 219 NOR3_X2
* cell instance $12009 r0 *1 148.96,184.8
X$12009 9124 10249 219 320 10362 NOR2_X1
* cell instance $12010 r0 *1 149.53,184.8
X$12010 10043 10052 219 320 10364 OR2_X1
* cell instance $12011 m0 *1 150.48,184.8
X$12011 10145 10146 219 320 10251 NAND2_X1
* cell instance $12013 m0 *1 151.05,184.8
X$12013 10147 6522 10146 219 320 10148 MUX2_X1
* cell instance $12014 m0 *1 152.38,184.8
X$12014 10145 10148 320 219 10220 AND2_X2
* cell instance $12020 r0 *1 151.43,184.8
X$12020 10145 10147 219 320 10250 NAND2_X1
* cell instance $12021 r0 *1 152,184.8
X$12021 10250 6522 10251 219 320 10322 MUX2_X1
* cell instance $12023 r0 *1 153.71,184.8
X$12023 10329 219 320 10252 INV_X1
* cell instance $12024 r0 *1 154.09,184.8
X$12024 10329 10244 219 320 10413 NAND2_X2
* cell instance $12027 r0 *1 156.94,184.8
X$12027 219 14014 9786 10332 10115 320 DFF_X1
* cell instance $12028 r0 *1 160.17,184.8
X$12028 9386 10330 219 320 10332 OR2_X1
* cell instance $12029 m0 *1 160.74,184.8
X$12029 10149 219 320 10331 INV_X1
* cell instance $12032 m0 *1 164.16,184.8
X$12032 9935 10150 219 320 10253 NAND2_X1
* cell instance $12034 r0 *1 160.93,184.8
X$12034 10331 10253 10222 9964 219 320 10760 NOR4_X1
* cell instance $12035 r0 *1 161.88,184.8
X$12035 10253 10222 9964 10254 219 320 10365 NOR4_X1
* cell instance $12036 r0 *1 162.83,184.8
X$12036 3243 10222 320 219 10328 AND2_X1
* cell instance $12037 r0 *1 163.59,184.8
X$12037 219 14039 10255 10328 9965 320 DFF_X1
* cell instance $12038 m0 *1 165.3,184.8
X$12038 10150 10326 219 320 10221 NOR2_X1
* cell instance $12040 m0 *1 165.87,184.8
X$12040 219 13535 9966 10221 9965 320 DFF_X1
* cell instance $12042 m0 *1 170.62,184.8
X$12042 10256 10323 10411 320 10219 219 OAI21_X1
* cell instance $12043 m0 *1 171.38,184.8
X$12043 10152 10217 320 219 10257 AND2_X1
* cell instance $12044 m0 *1 172.14,184.8
X$12044 10151 10123 9672 219 10321 320 AOI21_X1
* cell instance $12046 m0 *1 173.09,184.8
X$12046 10315 10320 219 320 10024 OR2_X1
* cell instance $12049 r0 *1 169.86,184.8
X$12049 10324 10322 219 320 10256 OR2_X1
* cell instance $12050 r0 *1 170.62,184.8
X$12050 10410 10324 10366 10321 10320 320 219 AOI211_X2
* cell instance $12051 r0 *1 172.33,184.8
X$12051 10257 10322 9561 219 320 10258 NOR3_X1
* cell instance $12052 r0 *1 173.09,184.8
X$12052 10316 7596 219 320 10410 NAND2_X1
* cell instance $12054 r0 *1 173.85,184.8
X$12054 9561 10317 219 320 10367 OR2_X1
* cell instance $12056 m0 *1 174.23,184.8
X$12056 9968 219 320 10260 CLKBUF_X3
* cell instance $12058 m0 *1 176.13,184.8
X$12058 10124 219 320 10151 CLKBUF_X3
* cell instance $12060 m0 *1 180.12,184.8
X$12060 5623 219 320 10263 BUF_X2
* cell instance $12062 m0 *1 181.07,184.8
X$12062 10153 219 320 8674 INV_X2
* cell instance $12065 r0 *1 174.61,184.8
X$12065 10313 10316 10220 219 320 10317 NOR3_X1
* cell instance $12069 r0 *1 175.37,184.8
X$12069 10260 10314 10324 320 219 10315 AND3_X1
* cell instance $12070 r0 *1 176.32,184.8
X$12070 10266 10261 320 219 10313 AND2_X1
* cell instance $12074 r0 *1 179.55,184.8
X$12074 10262 10263 219 320 10409 NOR2_X1
* cell instance $12075 r0 *1 180.12,184.8
X$12075 10309 10263 219 320 10369 NOR2_X1
* cell instance $12076 r0 *1 180.69,184.8
X$12076 10265 10263 219 320 10405 NOR2_X1
* cell instance $12077 r0 *1 181.26,184.8
X$12077 10153 320 7740 219 BUF_X4
* cell instance $12079 m0 *1 182.97,184.8
X$12079 10154 10056 9546 219 10309 320 AOI21_X1
* cell instance $12084 r0 *1 184.11,184.8
X$12084 10302 3163 219 320 10403 NOR2_X1
* cell instance $12086 r0 *1 184.87,184.8
X$12086 9066 10374 219 320 10259 NAND2_X1
* cell instance $12087 r0 *1 185.44,184.8
X$12087 10120 10263 219 320 10402 NOR2_X1
* cell instance $12090 m0 *1 117.99,240.8
X$12090 12418 219 320 7266 BUF_X2
* cell instance $12091 m0 *1 118.94,240.8
X$12091 12369 219 320 8168 BUF_X2
* cell instance $12092 m0 *1 119.7,240.8
X$12092 12471 219 320 5014 BUF_X2
* cell instance $12094 m0 *1 120.65,240.8
X$12094 12417 219 320 5909 BUF_X2
* cell instance $12095 m0 *1 121.41,240.8
X$12095 12420 219 320 9505 CLKBUF_X2
* cell instance $12096 m0 *1 122.17,240.8
X$12096 12421 219 320 6718 BUF_X2
* cell instance $12099 m0 *1 123.88,240.8
X$12099 12472 219 320 5903 BUF_X2
* cell instance $12109 m0 *1 156.56,240.8
X$12109 8766 219 320 12455 BUF_X1
* cell instance $12111 m0 *1 108.68,240.8
X$12111 12467 219 320 7335 BUF_X2
* cell instance $12118 m0 *1 6.08,70
X$12118 2558 2599 320 219 2601 AND2_X1
* cell instance $12119 m0 *1 6.84,70
X$12119 2558 2557 320 219 2600 AND2_X1
* cell instance $12120 m0 *1 7.6,70
X$12120 219 13252 2604 2600 2306 320 DFF_X1
* cell instance $12123 r0 *1 5.32,70
X$12123 2556 219 320 2599 BUF_X1
* cell instance $12125 r0 *1 6.65,70
X$12125 2554 219 320 2697 BUF_X1
* cell instance $12130 r0 *1 8.74,70
X$12130 2558 2697 320 219 2698 AND2_X1
* cell instance $12131 r0 *1 9.5,70
X$12131 219 2698 2306 12506 2463 320 DFF_X2
* cell instance $12133 m0 *1 11.21,70
X$12133 219 2601 2306 12495 2602 320 DFF_X2
* cell instance $12134 m0 *1 15.01,70
X$12134 2457 1564 2307 219 320 2605 MUX2_X1
* cell instance $12137 r0 *1 13.11,70
X$12137 2306 219 320 CLKBUF_X1
* cell instance $12138 r0 *1 13.68,70
X$12138 2559 1547 2643 219 320 2699 MUX2_X1
* cell instance $12140 m0 *1 17.67,70
X$12140 2604 320 2338 219 BUF_X4
* cell instance $12144 m0 *1 20.71,70
X$12144 2311 1639 2605 219 320 2514 MUX2_X1
* cell instance $12150 r0 *1 21.28,70
X$12150 2559 219 320 2647 BUF_X2
* cell instance $12151 r0 *1 22.04,70
X$12151 1370 219 320 2309 CLKBUF_X3
* cell instance $12152 r0 *1 22.99,70
X$12152 219 14529 2703 2560 2309 320 DFF_X1
* cell instance $12153 r0 *1 26.22,70
X$12153 219 14618 2646 2704 2309 320 DFF_X1
* cell instance $12154 r0 *1 29.45,70
X$12154 2559 1261 2773 219 320 2705 MUX2_X1
* cell instance $12157 r0 *1 31.35,70
X$12157 2559 1467 2648 219 320 2706 MUX2_X1
* cell instance $12158 m0 *1 33.25,70
X$12158 2314 219 320 CLKBUF_X1
* cell instance $12159 m0 *1 32.3,70
X$12159 1370 219 320 2314 CLKBUF_X3
* cell instance $12163 r0 *1 32.68,70
X$12163 219 14586 2648 2706 2314 320 DFF_X1
* cell instance $12166 m0 *1 36.48,70
X$12166 219 12628 2561 2608 2214 320 DFF_X1
* cell instance $12168 m0 *1 41.42,70
X$12168 1515 219 320 2214 CLKBUF_X3
* cell instance $12169 m0 *1 42.37,70
X$12169 2562 1640 2607 219 320 2713 MUX2_X1
* cell instance $12175 r0 *1 38.38,70
X$12175 2561 1469 2647 219 320 2608 MUX2_X1
* cell instance $12176 r0 *1 39.71,70
X$12176 219 14593 2651 2710 2214 320 DFF_X1
* cell instance $12180 m0 *1 46.36,70
X$12180 219 12957 2716 2610 2217 320 DFF_X1
* cell instance $12183 r0 *1 46.93,70
X$12183 2647 1609 2716 219 320 2610 MUX2_X1
* cell instance $12186 r0 *1 48.83,70
X$12186 2647 1695 2563 219 320 2717 MUX2_X1
* cell instance $12187 r0 *1 50.16,70
X$12187 219 14440 2563 2717 2217 320 DFF_X1
* cell instance $12188 m0 *1 50.92,70
X$12188 2564 1384 2211 219 320 2611 MUX2_X1
* cell instance $12190 m0 *1 52.25,70
X$12190 219 13005 2564 2611 2217 320 DFF_X1
* cell instance $12194 m0 *1 59.47,70
X$12194 219 13515 2461 2614 2565 320 DFF_X1
* cell instance $12200 r0 *1 53.77,70
X$12200 2516 2719 2514 219 320 2654 MUX2_X1
* cell instance $12204 r0 *1 58.71,70
X$12204 2723 1841 2462 219 320 2722 MUX2_X1
* cell instance $12206 r0 *1 61.56,70
X$12206 2461 2772 2397 219 320 2655 MUX2_X1
* cell instance $12212 r0 *1 64.6,70
X$12212 219 13999 2658 2725 2565 320 DFF_X1
* cell instance $12215 m0 *1 68.4,70
X$12215 219 13583 2618 2617 2565 320 DFF_X1
* cell instance $12217 m0 *1 83.79,70
X$12217 2465 1480 2568 219 320 2622 MUX2_X1
* cell instance $12221 r0 *1 70.11,70
X$12221 2784 2731 2618 219 320 2733 MUX2_X1
* cell instance $12224 r0 *1 73.15,70
X$12224 2660 2032 2462 219 320 2566 MUX2_X1
* cell instance $12225 r0 *1 74.48,70
X$12225 2462 2037 2567 219 320 2620 MUX2_X1
* cell instance $12226 r0 *1 75.81,70
X$12226 219 14429 2567 2620 2223 320 DFF_X1
* cell instance $12228 r0 *1 80.56,70
X$12228 1570 219 320 2223 CLKBUF_X3
* cell instance $12230 r0 *1 81.7,70
X$12230 219 13759 2568 2622 2223 320 DFF_X1
* cell instance $12231 r0 *1 84.93,70
X$12231 2568 2327 2662 219 320 2663 MUX2_X1
* cell instance $12234 m0 *1 88.73,70
X$12234 2465 219 320 2569 BUF_X2
* cell instance $12236 m0 *1 89.49,70
X$12236 219 13390 2570 2625 2227 320 DFF_X1
* cell instance $12237 m0 *1 92.72,70
X$12237 2570 1841 2569 219 320 2625 MUX2_X1
* cell instance $12240 m0 *1 95.76,70
X$12240 2569 1983 2627 219 320 2747 MUX2_X1
* cell instance $12243 m0 *1 100.89,70
X$12243 2569 2037 2467 219 320 2631 MUX2_X1
* cell instance $12244 m0 *1 102.22,70
X$12244 219 13056 2467 2631 2236 320 DFF_X1
* cell instance $12247 m0 *1 106.4,70
X$12247 2572 2086 2569 219 320 2529 MUX2_X1
* cell instance $12248 m0 *1 107.73,70
X$12248 219 12558 2573 2634 2236 320 DFF_X1
* cell instance $12251 m0 *1 114.19,70
X$12251 2602 320 2534 219 BUF_X4
* cell instance $12257 r0 *1 89.11,70
X$12257 2465 1746 2666 219 320 2743 MUX2_X1
* cell instance $12258 r0 *1 90.44,70
X$12258 219 13781 2666 2743 2227 320 DFF_X1
* cell instance $12260 r0 *1 94.05,70
X$12260 2570 1844 2571 219 320 2667 MUX2_X1
* cell instance $12262 r0 *1 96.14,70
X$12262 219 13699 2627 2747 2668 320 DFF_X1
* cell instance $12263 r0 *1 99.37,70
X$12263 2466 2575 219 320 2748 NOR2_X1
* cell instance $12267 r0 *1 102.41,70
X$12267 2569 2148 2670 219 320 2632 MUX2_X1
* cell instance $12268 r0 *1 103.74,70
X$12268 219 13687 2670 2632 2236 320 DFF_X1
* cell instance $12269 r0 *1 106.97,70
X$12269 2572 2468 2573 219 320 2751 MUX2_X1
* cell instance $12270 r0 *1 108.3,70
X$12270 2573 2032 2569 219 320 2634 MUX2_X1
* cell instance $12271 r0 *1 109.63,70
X$12271 1578 219 320 2236 CLKBUF_X3
* cell instance $12272 r0 *1 110.58,70
X$12272 2530 2575 219 320 2755 NOR2_X1
* cell instance $12281 m0 *1 125.21,70
X$12281 219 12647 2578 2469 2237 320 DFF_X1
* cell instance $12283 m0 *1 128.44,70
X$12283 286 1041 2580 219 320 2579 MUX2_X1
* cell instance $12288 r0 *1 127.87,70
X$12288 219 14162 2580 2579 2237 320 DFF_X1
* cell instance $12289 m0 *1 130.34,70
X$12289 2578 1629 2580 219 320 2476 MUX2_X1
* cell instance $12293 m0 *1 132.24,70
X$12293 2326 1035 2472 219 320 2470 MUX2_X1
* cell instance $12297 m0 *1 134.52,70
X$12297 219 12603 2473 2638 2637 320 DFF_X1
* cell instance $12300 m0 *1 138.7,70
X$12300 2540 714 219 320 2581 NAND2_X1
* cell instance $12304 r0 *1 138.32,70
X$12304 2581 714 2476 320 219 2762 OAI21_X4
* cell instance $12306 m0 *1 139.65,70
X$12306 2476 1274 2474 219 320 2640 MUX2_X1
* cell instance $12308 r0 *1 140.79,70
X$12308 2536 2640 219 320 2642 XNOR2_X2
* cell instance $12309 m0 *1 142.12,70
X$12309 219 2641 2582 2337 2642 2544 320 NAND4_X4
* cell instance $12310 m0 *1 145.54,70
X$12310 219 2544 2478 2340 2339 2763 320 NOR4_X4
* cell instance $12311 m0 *1 148.96,70
X$12311 2760 320 1629 219 BUF_X4
* cell instance $12312 m0 *1 150.29,70
X$12312 2479 219 320 2123 BUF_X1
* cell instance $12314 m0 *1 152.38,70
X$12314 408 1662 2585 219 320 2639 MUX2_X1
* cell instance $12315 m0 *1 153.71,70
X$12315 219 13470 2585 2639 2343 320 DFF_X1
* cell instance $12316 m0 *1 156.94,70
X$12316 2585 2344 2553 219 320 2550 MUX2_X1
* cell instance $12317 m0 *1 158.27,70
X$12317 219 12699 2481 2636 2343 320 DFF_X1
* cell instance $12318 m0 *1 161.5,70
X$12318 2586 2679 2481 219 320 2635 MUX2_X1
* cell instance $12319 m0 *1 162.83,70
X$12319 2483 2527 2635 320 219 2870 OAI21_X2
* cell instance $12320 m0 *1 164.16,70
X$12320 2345 2482 2550 219 320 2484 MUX2_X1
* cell instance $12322 m0 *1 165.68,70
X$12322 2485 2527 2550 320 219 2681 OAI21_X2
* cell instance $12328 r0 *1 145.92,70
X$12328 219 2583 2637 12507 2479 320 DFF_X2
* cell instance $12329 r0 *1 149.53,70
X$12329 2674 1134 219 320 2548 XNOR2_X2
* cell instance $12330 r0 *1 151.43,70
X$12330 2479 219 320 2759 BUF_X1
* cell instance $12332 r0 *1 152.76,70
X$12332 2584 320 570 219 BUF_X4
* cell instance $12336 r0 *1 155.42,70
X$12336 2343 219 320 14774 INV_X1
* cell instance $12337 r0 *1 155.8,70
X$12337 2678 320 512 219 BUF_X4
* cell instance $12339 r0 *1 157.32,70
X$12339 219 13658 2586 2480 2343 320 DFF_X1
* cell instance $12340 r0 *1 160.55,70
X$12340 2679 219 320 2344 BUF_X1
* cell instance $12345 r0 *1 165.49,70
X$12345 219 14453 2682 2745 2348 320 DFF_X1
* cell instance $12346 r0 *1 168.72,70
X$12346 2683 1772 2682 219 320 2684 MUX2_X1
* cell instance $12347 m0 *1 170.62,70
X$12347 2633 2527 2351 320 219 2543 OAI21_X4
* cell instance $12348 m0 *1 169.67,70
X$12348 2482 219 320 1853 CLKBUF_X3
* cell instance $12349 m0 *1 173.09,70
X$12349 2352 2353 219 320 2633 OR2_X1
* cell instance $12351 m0 *1 175.37,70
X$12351 2471 2630 320 219 2629 XNOR2_X1
* cell instance $12352 m0 *1 176.51,70
X$12352 2438 2537 320 219 2628 XNOR2_X1
* cell instance $12353 m0 *1 177.65,70
X$12353 2587 2628 2486 2629 219 2626 320 NAND4_X2
* cell instance $12355 m0 *1 180.12,70
X$12355 219 2626 2444 2623 2624 2619 320 NOR4_X4
* cell instance $12356 m0 *1 183.54,70
X$12356 2588 2527 2621 320 219 2532 OAI21_X4
* cell instance $12360 r0 *1 171,70
X$12360 2348 219 320 CLKBUF_X1
* cell instance $12363 r0 *1 172.14,70
X$12363 2737 1853 2684 219 320 2630 MUX2_X1
* cell instance $12370 r0 *1 177.65,70
X$12370 2674 2292 320 219 2587 XNOR2_X1
* cell instance $12374 r0 *1 182.78,70
X$12374 2679 219 320 2250 BUF_X1
* cell instance $12376 m0 *1 186.58,70
X$12376 2357 1893 2356 219 320 2621 MUX2_X1
* cell instance $12380 m0 *1 189.24,70
X$12380 2589 320 1069 219 BUF_X4
* cell instance $12383 m0 *1 190.76,70
X$12383 2359 2527 2110 320 219 2528 OAI21_X4
* cell instance $12385 m0 *1 193.42,70
X$12385 219 2527 320 2933 BUF_X8
* cell instance $12386 m0 *1 195.89,70
X$12386 2072 219 320 2352 BUF_X2
* cell instance $12388 m0 *1 198.17,70
X$12388 219 13560 2489 2616 2255 320 DFF_X1
* cell instance $12394 r0 *1 192.85,70
X$12394 219 14301 2818 2851 2255 320 DFF_X1
* cell instance $12396 r0 *1 196.27,70
X$12396 219 2072 320 2482 BUF_X8
* cell instance $12399 r0 *1 203.3,70
X$12399 219 14313 2615 2718 2366 320 DFF_X1
* cell instance $12401 m0 *1 204.06,70
X$12401 2285 2364 2615 219 320 2718 MUX2_X1
* cell instance $12402 m0 *1 205.58,70
X$12402 2615 1113 2522 219 320 2523 MUX2_X1
* cell instance $12404 m0 *1 207.67,70
X$12404 2260 2364 2613 219 320 2715 MUX2_X1
* cell instance $12406 m0 *1 209.19,70
X$12406 219 13318 2519 2492 2263 320 DFF_X1
* cell instance $12408 m0 *1 212.61,70
X$12408 219 1113 320 2590 BUF_X8
* cell instance $12409 m0 *1 215.08,70
X$12409 2493 2368 2592 219 320 2612 MUX2_X1
* cell instance $12412 r0 *1 206.53,70
X$12412 219 1585 320 2933 BUF_X8
* cell instance $12413 r0 *1 209,70
X$12413 219 14379 2613 2715 2591 320 DFF_X1
* cell instance $12416 r0 *1 213.94,70
X$12416 219 13828 2592 2612 2591 320 DFF_X1
* cell instance $12417 r0 *1 217.17,70
X$12417 2592 1069 2496 219 320 2494 MUX2_X1
* cell instance $12419 m0 *1 217.55,70
X$12419 219 13227 2496 2593 2594 320 DFF_X1
* cell instance $12423 r0 *1 220.59,70
X$12423 219 13860 2692 2709 2594 320 DFF_X1
* cell instance $12425 m0 *1 221.16,70
X$12425 2269 1119 2512 320 219 2609 OAI21_X4
* cell instance $12428 m0 *1 228.38,70
X$12428 219 13301 2374 2508 2594 320 DFF_X1
* cell instance $12429 m0 *1 231.61,70
X$12429 2374 1596 2595 219 320 2606 MUX2_X1
* cell instance $12434 r0 *1 224.77,70
X$12434 1869 219 320 2594 CLKBUF_X3
* cell instance $12439 r0 *1 230.09,70
X$12439 2606 2373 2072 320 219 2694 MUX2_X2
* cell instance $12444 m0 *1 235.03,70
X$12444 2598 219 320 2260 BUF_X1
* cell instance $12446 m0 *1 235.6,70
X$12446 2498 1596 2603 219 320 2596 MUX2_X1
* cell instance $12447 m0 *1 236.93,70
X$12447 219 13197 2501 2499 2382 320 DFF_X1
* cell instance $12448 m0 *1 240.16,70
X$12448 2597 219 320 2361 BUF_X1
* cell instance $12452 r0 *1 235.79,70
X$12452 219 13958 2603 2377 2382 320 DFF_X1
* cell instance $12453 r0 *1 239.02,70
X$12453 1869 219 320 2382 CLKBUF_X3
* cell instance $12458 m0 *1 6.08,173.6
X$12458 219 13009 9453 9391 8847 320 DFF_X1
* cell instance $12459 m0 *1 9.31,173.6
X$12459 219 12977 9456 9454 8847 320 DFF_X1
* cell instance $12462 r0 *1 5.32,173.6
X$12462 9524 219 320 9393 BUF_X1
* cell instance $12464 r0 *1 6.08,173.6
X$12464 9393 7171 9453 219 320 9391 MUX2_X1
* cell instance $12468 r0 *1 7.41,173.6
X$12468 9393 7121 9392 219 320 9452 MUX2_X1
* cell instance $12471 r0 *1 9.88,173.6
X$12471 9456 7014 9396 219 320 9454 MUX2_X1
* cell instance $12472 r0 *1 11.21,173.6
X$12472 9393 7123 9395 219 320 9394 MUX2_X1
* cell instance $12473 r0 *1 12.54,173.6
X$12473 9456 8791 9395 219 320 9457 MUX2_X1
* cell instance $12474 m0 *1 13.11,173.6
X$12474 9457 8792 9455 219 320 9458 MUX2_X1
* cell instance $12479 r0 *1 14.25,173.6
X$12479 9393 219 320 9396 BUF_X2
* cell instance $12481 m0 *1 17.67,173.6
X$12481 219 12989 9461 9460 9135 320 DFF_X1
* cell instance $12482 m0 *1 16.34,173.6
X$12482 9396 6853 9461 219 320 9460 MUX2_X1
* cell instance $12483 m0 *1 20.9,173.6
X$12483 9397 6906 9396 219 320 9463 MUX2_X1
* cell instance $12486 r0 *1 16.91,173.6
X$12486 9526 219 320 9135 CLKBUF_X3
* cell instance $12490 r0 *1 19.95,173.6
X$12490 9397 8729 9638 219 320 9398 MUX2_X1
* cell instance $12491 r0 *1 21.28,173.6
X$12491 9398 8262 9462 219 320 9399 MUX2_X1
* cell instance $12492 r0 *1 22.61,173.6
X$12492 9399 8927 9591 219 320 9465 MUX2_X1
* cell instance $12493 m0 *1 22.8,173.6
X$12493 219 12909 9397 9463 9401 320 DFF_X1
* cell instance $12497 m0 *1 26.98,173.6
X$12497 219 13001 9402 9400 9401 320 DFF_X1
* cell instance $12501 r0 *1 25.08,173.6
X$12501 9401 219 320 14778 INV_X1
* cell instance $12502 r0 *1 25.46,173.6
X$12502 9526 219 320 9401 CLKBUF_X3
* cell instance $12503 r0 *1 26.41,173.6
X$12503 9402 6909 9396 219 320 9400 MUX2_X1
* cell instance $12504 r0 *1 27.74,173.6
X$12504 219 14091 9594 9528 9401 320 DFF_X1
* cell instance $12505 m0 *1 30.78,173.6
X$12505 9466 8867 9458 219 320 9596 MUX2_X1
* cell instance $12510 r0 *1 31.35,173.6
X$12510 9465 9596 9035 320 219 9050 MUX2_X2
* cell instance $12512 m0 *1 33.44,173.6
X$12512 9396 7016 9403 219 320 9467 MUX2_X1
* cell instance $12514 m0 *1 34.77,173.6
X$12514 219 13053 9403 9467 9202 320 DFF_X1
* cell instance $12518 r0 *1 33.44,173.6
X$12518 9529 8791 9403 219 320 9698 MUX2_X1
* cell instance $12519 r0 *1 34.77,173.6
X$12519 9396 6974 9529 219 320 9597 MUX2_X1
* cell instance $12522 r0 *1 38,173.6
X$12522 219 13758 9529 9597 9202 320 DFF_X1
* cell instance $12523 r0 *1 41.23,173.6
X$12523 9405 219 320 9202 CLKBUF_X3
* cell instance $12524 r0 *1 42.18,173.6
X$12524 9202 219 320 CLKBUF_X1
* cell instance $12525 m0 *1 43.51,173.6
X$12525 6458 320 8262 219 BUF_X4
* cell instance $12526 m0 *1 42.18,173.6
X$12526 5810 320 9287 219 BUF_X4
* cell instance $12527 m0 *1 44.84,173.6
X$12527 6458 320 9527 219 BUF_X4
* cell instance $12530 m0 *1 49.4,173.6
X$12530 219 12673 9471 9404 9205 320 DFF_X1
* cell instance $12532 m0 *1 53.39,173.6
X$12532 9405 219 320 9205 CLKBUF_X3
* cell instance $12533 m0 *1 54.34,173.6
X$12533 9205 219 320 14748 INV_X1
* cell instance $12535 m0 *1 56.24,173.6
X$12535 9408 7490 9289 219 320 9288 MUX2_X1
* cell instance $12536 m0 *1 57.57,173.6
X$12536 219 12757 9407 9472 9205 320 DFF_X1
* cell instance $12537 m0 *1 60.8,173.6
X$12537 9407 7492 9143 219 320 9472 MUX2_X1
* cell instance $12538 m0 *1 62.13,173.6
X$12538 9408 7089 9409 219 320 9473 MUX2_X1
* cell instance $12539 m0 *1 63.46,173.6
X$12539 9408 7356 9476 219 320 9478 MUX2_X1
* cell instance $12540 m0 *1 64.79,173.6
X$12540 219 12973 9476 9478 8804 320 DFF_X1
* cell instance $12542 m0 *1 68.78,173.6
X$12542 9480 8262 9482 219 320 9410 MUX2_X1
* cell instance $12543 m0 *1 70.11,173.6
X$12543 9410 2719 9359 219 320 9483 MUX2_X1
* cell instance $12544 m0 *1 71.44,173.6
X$12544 9362 8867 9411 219 320 9412 MUX2_X1
* cell instance $12545 m0 *1 72.77,173.6
X$12545 9483 9412 9035 320 219 7676 MUX2_X2
* cell instance $12549 r0 *1 43.13,173.6
X$12549 9531 7082 9532 219 320 9599 MUX2_X1
* cell instance $12550 r0 *1 44.46,173.6
X$12550 219 14211 9532 9599 9202 320 DFF_X1
* cell instance $12553 r0 *1 48.83,173.6
X$12553 9531 7016 9471 219 320 9404 MUX2_X1
* cell instance $12554 r0 *1 50.16,173.6
X$12554 219 14200 9603 9600 9205 320 DFF_X1
* cell instance $12555 r0 *1 53.39,173.6
X$12555 9603 9101 9471 219 320 9406 MUX2_X1
* cell instance $12558 r0 *1 58.52,173.6
X$12558 9408 7243 9534 219 320 9604 MUX2_X1
* cell instance $12560 r0 *1 60.04,173.6
X$12560 9290 8792 9535 219 320 9411 MUX2_X1
* cell instance $12561 r0 *1 61.37,173.6
X$12561 219 14215 9409 9473 8804 320 DFF_X1
* cell instance $12565 r0 *1 64.6,173.6
X$12565 9408 219 320 9143 CLKBUF_X2
* cell instance $12567 r0 *1 68.4,173.6
X$12567 9606 8908 9536 219 320 9482 MUX2_X1
* cell instance $12569 r0 *1 70.11,173.6
X$12569 9143 7091 9536 219 320 9608 MUX2_X1
* cell instance $12570 r0 *1 71.44,173.6
X$12570 219 14393 9536 9608 9413 320 DFF_X1
* cell instance $12572 m0 *1 75.81,173.6
X$12572 9143 7026 9296 219 320 9484 MUX2_X1
* cell instance $12574 m0 *1 77.14,173.6
X$12574 219 12659 9296 9484 9413 320 DFF_X1
* cell instance $12578 m0 *1 82.65,173.6
X$12578 8926 219 320 9295 CLKBUF_X3
* cell instance $12579 m0 *1 82.27,173.6
X$12579 9295 219 320 14732 INV_X1
* cell instance $12580 m0 *1 83.6,173.6
X$12580 9297 7243 9414 219 320 9486 MUX2_X1
* cell instance $12581 m0 *1 84.93,173.6
X$12581 219 12657 9414 9486 9295 320 DFF_X1
* cell instance $12582 m0 *1 88.16,173.6
X$12582 9414 6172 9416 219 320 9298 MUX2_X1
* cell instance $12583 m0 *1 89.49,173.6
X$12583 9415 7025 9416 219 320 9487 MUX2_X1
* cell instance $12585 m0 *1 91.01,173.6
X$12585 9297 7356 9301 219 320 9300 MUX2_X1
* cell instance $12586 m0 *1 92.34,173.6
X$12586 9415 7091 9417 219 320 9609 MUX2_X1
* cell instance $12588 m0 *1 93.86,173.6
X$12588 9301 4076 9417 219 320 9365 MUX2_X1
* cell instance $12589 m0 *1 95.19,173.6
X$12589 9297 7490 9418 219 320 9489 MUX2_X1
* cell instance $12590 m0 *1 96.52,173.6
X$12590 219 13332 9418 9489 8992 320 DFF_X1
* cell instance $12595 r0 *1 89.11,173.6
X$12595 219 14144 9416 9487 8809 320 DFF_X1
* cell instance $12597 r0 *1 92.72,173.6
X$12597 219 14291 9417 9609 9242 320 DFF_X1
* cell instance $12602 r0 *1 101.08,173.6
X$12602 9540 2904 9610 219 320 9150 MUX2_X1
* cell instance $12603 m0 *1 101.84,173.6
X$12603 9418 5217 9419 219 320 9490 MUX2_X1
* cell instance $12606 m0 *1 103.36,173.6
X$12606 9415 7027 9419 219 320 9491 MUX2_X1
* cell instance $12607 m0 *1 104.69,173.6
X$12607 219 13212 9419 9491 9242 320 DFF_X1
* cell instance $12610 m0 *1 110.2,173.6
X$12610 9494 8278 9420 219 320 9492 MUX2_X1
* cell instance $12613 r0 *1 102.41,173.6
X$12613 8697 219 320 9242 CLKBUF_X3
* cell instance $12614 r0 *1 103.36,173.6
X$12614 9242 219 320 CLKBUF_X1
* cell instance $12619 r0 *1 109.06,173.6
X$12619 219 14428 9420 9492 9421 320 DFF_X1
* cell instance $12620 r0 *1 112.29,173.6
X$12620 219 14698 9541 9495 9421 320 DFF_X1
* cell instance $12622 m0 *1 112.67,173.6
X$12622 9494 8242 9493 219 320 9496 MUX2_X1
* cell instance $12623 m0 *1 117.61,173.6
X$12623 9422 8121 9499 219 320 9498 MUX2_X1
* cell instance $12624 m0 *1 114.38,173.6
X$12624 219 13148 9493 9496 9421 320 DFF_X1
* cell instance $12627 m0 *1 120.65,173.6
X$12627 9422 8166 9423 219 320 9721 MUX2_X1
* cell instance $12628 m0 *1 121.98,173.6
X$12628 9499 8458 9423 219 320 9502 MUX2_X1
* cell instance $12630 m0 *1 124.07,173.6
X$12630 9305 7606 9502 320 219 8184 OAI21_X4
* cell instance $12632 m0 *1 128.06,173.6
X$12632 9505 8821 9424 219 320 9504 MUX2_X1
* cell instance $12633 m0 *1 129.39,173.6
X$12633 9425 219 320 9045 CLKBUF_X3
* cell instance $12635 m0 *1 136.42,173.6
X$12635 9425 219 320 9046 CLKBUF_X3
* cell instance $12636 m0 *1 137.37,173.6
X$12636 9046 219 320 CLKBUF_X1
* cell instance $12641 r0 *1 115.52,173.6
X$12641 9420 8458 9493 219 320 9615 MUX2_X1
* cell instance $12642 r0 *1 116.85,173.6
X$12642 9615 9616 7607 320 219 9272 MUX2_X2
* cell instance $12648 r0 *1 119.13,173.6
X$12648 219 14449 9542 9617 8819 320 DFF_X1
* cell instance $12649 r0 *1 122.36,173.6
X$12649 9542 7723 9655 219 320 9501 MUX2_X1
* cell instance $12655 r0 *1 125.59,173.6
X$12655 219 14686 9424 9504 9045 320 DFF_X1
* cell instance $12656 r0 *1 128.82,173.6
X$12656 9424 8458 9659 219 320 9620 MUX2_X1
* cell instance $12657 r0 *1 130.15,173.6
X$12657 9621 9620 7607 320 219 9048 MUX2_X2
* cell instance $12661 r0 *1 133.95,173.6
X$12661 9543 8699 9545 219 320 9544 MUX2_X1
* cell instance $12662 r0 *1 135.28,173.6
X$12662 219 9622 9046 12509 7451 320 DFF_X2
* cell instance $12663 r0 *1 138.89,173.6
X$12663 7824 219 320 9546 CLKBUF_X3
* cell instance $12666 r0 *1 140.79,173.6
X$12666 219 9730 8465 7210 9624 320 DFF_X2
* cell instance $12667 m0 *1 143.83,173.6
X$12667 9159 9161 9163 9508 219 320 9663 NAND4_X1
* cell instance $12669 m0 *1 144.78,173.6
X$12669 9306 9508 9376 219 9960 320 AOI21_X1
* cell instance $12670 m0 *1 145.54,173.6
X$12670 219 7274 7399 7440 7614 9548 320 NOR4_X4
* cell instance $12671 m0 *1 148.96,173.6
X$12671 9164 9308 9426 9266 9310 9511 320 219 AOI221_X2
* cell instance $12672 m0 *1 151.05,173.6
X$12672 9426 9266 9310 219 9510 320 AOI21_X1
* cell instance $12673 m0 *1 151.81,173.6
X$12673 9514 9427 9511 9512 9428 219 320 OAI211_X2
* cell instance $12675 r0 *1 144.4,173.6
X$12675 219 6956 9624 7451 7450 9547 320 NOR4_X4
* cell instance $12678 r0 *1 148.39,173.6
X$12678 9549 219 320 9266 BUF_X2
* cell instance $12679 r0 *1 149.15,173.6
X$12679 8470 8184 9549 320 219 9426 HA_X1
* cell instance $12680 r0 *1 151.05,173.6
X$12680 9550 9168 9308 9311 219 320 9666 NAND4_X1
* cell instance $12681 r0 *1 152,173.6
X$12681 9307 9312 9510 320 9625 219 OAI21_X1
* cell instance $12685 m0 *1 206.53,212.8
X$12685 11781 219 320 11329 CLKBUF_X3
* cell instance $12687 m0 *1 208.43,212.8
X$12687 219 13178 11773 11782 11924 320 DFF_X1
* cell instance $12688 m0 *1 211.66,212.8
X$12688 11773 11826 219 320 11731 XOR2_X1
* cell instance $12689 m0 *1 212.8,212.8
X$12689 11671 11774 11773 219 320 11781 OR3_X1
* cell instance $12690 m0 *1 213.75,212.8
X$12690 11780 10326 219 320 11728 NOR2_X1
* cell instance $12691 m0 *1 214.32,212.8
X$12691 11671 11662 11775 320 11780 219 OAI21_X1
* cell instance $12692 m0 *1 215.08,212.8
X$12692 11662 11717 219 320 11775 NAND2_X1
* cell instance $12694 m0 *1 215.84,212.8
X$12694 219 11779 11774 11718 11342 320 DFF_X1
* cell instance $12700 m0 *1 203.87,212.8
X$12700 11783 11713 9386 219 320 11828 NOR3_X1
* cell instance $12704 r0 *1 203.68,212.8
X$12704 219 14477 11827 11828 11924 320 DFF_X1
* cell instance $12705 r0 *1 206.91,212.8
X$12705 11827 219 320 11712 BUF_X1
* cell instance $12710 r0 *1 211.85,212.8
X$12710 11716 11662 219 320 11826 NAND2_X1
* cell instance $12716 r0 *1 222.87,212.8
X$12716 9447 219 320 11579 CLKBUF_X3
* cell instance $12717 r0 *1 223.82,212.8
X$12717 11579 219 320 14781 INV_X1
* cell instance $12725 m0 *1 233.89,212.8
X$12725 8341 219 320 11778 BUF_X1
* cell instance $12728 r0 *1 235.6,212.8
X$12728 9284 219 320 11825 BUF_X1
* cell instance $12730 m0 *1 236.55,212.8
X$12730 11777 219 320 11580 BUF_X1
* cell instance $12734 m0 *1 238.07,212.8
X$12734 11776 219 320 9579 BUF_X1
* cell instance $12735 m0 *1 238.64,212.8
X$12735 10312 219 320 11720 BUF_X1
* cell instance $12739 r0 *1 237.31,212.8
X$12739 8859 219 320 11824 BUF_X1
* cell instance $12746 m0 *1 146.3,240.8
X$12746 6798 219 320 12441 BUF_X1
* cell instance $12747 m0 *1 147.63,240.8
X$12747 6894 219 320 12395 BUF_X1
* cell instance $12752 m0 *1 109.82,240.8
X$12752 12409 219 320 9494 CLKBUF_X2
* cell instance $12754 m0 *1 111.53,240.8
X$12754 12408 219 320 8423 CLKBUF_X2
* cell instance $12758 m0 *1 114.76,240.8
X$12758 12468 219 320 7143 BUF_X2
* cell instance $12759 m0 *1 115.52,240.8
X$12759 12469 219 320 8122 BUF_X2
* cell instance $12760 m0 *1 116.28,240.8
X$12760 12412 219 320 9870 BUF_X1
* cell instance $12761 m0 *1 116.85,240.8
X$12761 12470 219 320 6884 BUF_X2
* cell instance $12766 m0 *1 6.27,114.8
X$12766 5414 219 320 5499 BUF_X1
* cell instance $12770 m0 *1 13.87,114.8
X$12770 5499 4238 5552 219 320 5553 MUX2_X1
* cell instance $12779 r0 *1 11.78,114.8
X$12779 5499 4445 5599 219 320 5652 MUX2_X1
* cell instance $12780 r0 *1 13.11,114.8
X$12780 219 14076 5552 5553 5287 320 DFF_X1
* cell instance $12781 r0 *1 16.34,114.8
X$12781 219 14111 5600 5653 5287 320 DFF_X1
* cell instance $12782 m0 *1 16.53,114.8
X$12782 5499 3990 5555 219 320 5415 MUX2_X1
* cell instance $12786 r0 *1 19.57,114.8
X$12786 5600 3955 5420 219 320 5653 MUX2_X1
* cell instance $12787 m0 *1 19.95,114.8
X$12787 5499 219 320 5420 BUF_X2
* cell instance $12791 m0 *1 22.42,114.8
X$12791 5290 219 320 CLKBUF_X1
* cell instance $12792 m0 *1 22.99,114.8
X$12792 4051 219 320 5290 CLKBUF_X3
* cell instance $12793 m0 *1 23.94,114.8
X$12793 219 13370 5557 5500 5290 320 DFF_X1
* cell instance $12794 m0 *1 27.17,114.8
X$12794 5420 4237 5416 219 320 5461 MUX2_X1
* cell instance $12797 r0 *1 21.09,114.8
X$12797 5499 4359 5601 219 320 5654 MUX2_X1
* cell instance $12799 r0 *1 23.94,114.8
X$12799 5557 4361 5420 219 320 5500 MUX2_X1
* cell instance $12800 r0 *1 25.27,114.8
X$12800 5557 4058 5601 219 320 5501 MUX2_X1
* cell instance $12804 m0 *1 29.07,114.8
X$12804 5501 3126 5558 219 320 5561 MUX2_X1
* cell instance $12807 r0 *1 29.07,114.8
X$12807 5499 4277 5417 219 320 5656 MUX2_X1
* cell instance $12809 m0 *1 131.48,240.8
X$12809 12475 219 320 10747 BUF_X1
* cell instance $12812 m0 *1 132.24,240.8
X$12812 12433 219 320 8752 CLKBUF_X2
* cell instance $12813 m0 *1 133,240.8
X$12813 12431 219 320 11317 BUF_X1
* cell instance $12815 m0 *1 133.76,240.8
X$12815 12435 219 320 11114 BUF_X1
* cell instance $12816 m0 *1 134.33,240.8
X$12816 12436 219 320 10571 BUF_X1
* cell instance $12817 m0 *1 134.9,240.8
X$12817 12434 219 320 9726 BUF_X1
* cell instance $12820 m0 *1 136.42,240.8
X$12820 12476 219 320 10652 BUF_X1
* cell instance $12821 m0 *1 136.99,240.8
X$12821 12477 219 320 9728 BUF_X1
* cell instance $12824 m0 *1 138.89,240.8
X$12824 12478 219 320 11945 BUF_X1
* cell instance $12826 m0 *1 139.46,240.8
X$12826 12438 219 320 11690 BUF_X1
* cell instance $12827 m0 *1 140.03,240.8
X$12827 12440 219 320 11858 BUF_X1
* cell instance $12832 m0 *1 130.34,240.8
X$12832 12429 219 320 10422 BUF_X1
* cell instance $12835 m0 *1 151.05,240.8
X$12835 8767 219 320 12445 BUF_X1
* cell instance $12838 m0 *1 126.54,240.8
X$12838 12425 219 320 11237 BUF_X1
* cell instance $12840 m0 *1 127.11,240.8
X$12840 12426 219 320 11853 BUF_X1
* cell instance $12841 m0 *1 127.68,240.8
X$12841 12474 219 320 5592 BUF_X2
* cell instance $12843 m0 *1 5.32,75.6
X$12843 2764 219 320 2949 BUF_X1
* cell instance $12845 m0 *1 5.89,75.6
X$12845 2878 219 320 2795 CLKBUF_X2
* cell instance $12846 m0 *1 6.65,75.6
X$12846 2558 2949 320 219 2835 AND2_X1
* cell instance $12847 m0 *1 7.41,75.6
X$12847 2558 2882 320 219 2951 AND2_X1
* cell instance $12852 r0 *1 5.89,75.6
X$12852 2766 219 320 2881 CLKBUF_X2
* cell instance $12853 r0 *1 6.65,75.6
X$12853 2879 219 320 2882 BUF_X1
* cell instance $12857 r0 *1 7.22,75.6
X$12857 2877 219 320 2950 BUF_X1
* cell instance $12860 r0 *1 8.36,75.6
X$12860 2558 2950 320 219 2952 AND2_X1
* cell instance $12861 m0 *1 8.74,75.6
X$12861 219 2951 2768 12493 2837 320 DFF_X2
* cell instance $12863 m0 *1 12.35,75.6
X$12863 2559 1599 2954 219 320 2767 MUX2_X1
* cell instance $12866 m0 *1 14.63,75.6
X$12866 2643 2520 2954 219 320 2955 MUX2_X1
* cell instance $12867 m0 *1 15.96,75.6
X$12867 2840 320 2244 219 BUF_X4
* cell instance $12870 m0 *1 19,75.6
X$12870 2769 2957 2701 219 320 2883 MUX2_X1
* cell instance $12878 r0 *1 13.11,75.6
X$12878 1370 219 320 2768 CLKBUF_X3
* cell instance $12879 r0 *1 14.06,75.6
X$12879 219 2952 2768 12512 2902 320 DFF_X2
* cell instance $12882 r0 *1 18.81,75.6
X$12882 3032 1550 2775 219 320 3079 MUX2_X1
* cell instance $12883 r0 *1 20.14,75.6
X$12883 2883 3126 2955 219 320 2884 MUX2_X1
* cell instance $12886 r0 *1 22.61,75.6
X$12886 2881 219 320 2775 BUF_X2
* cell instance $12887 r0 *1 23.37,75.6
X$12887 3033 1507 2775 219 320 3080 MUX2_X1
* cell instance $12888 r0 *1 24.7,75.6
X$12888 219 13769 2885 3082 2771 320 DFF_X1
* cell instance $12889 m0 *1 26.22,75.6
X$12889 219 13276 2964 2962 2771 320 DFF_X1
* cell instance $12891 m0 *1 29.45,75.6
X$12891 2843 2963 2774 219 320 2846 MUX2_X1
* cell instance $12893 m0 *1 31.54,75.6
X$12893 1282 219 320 2316 CLKBUF_X3
* cell instance $12895 m0 *1 32.68,75.6
X$12895 219 12611 2887 2966 2771 320 DFF_X1
* cell instance $12899 m0 *1 40.66,75.6
X$12899 2775 1523 2889 219 320 2969 MUX2_X1
* cell instance $12901 r0 *1 27.93,75.6
X$12901 2775 1303 2964 219 320 2962 MUX2_X1
* cell instance $12904 r0 *1 29.83,75.6
X$12904 2964 2772 3034 219 320 2886 MUX2_X1
* cell instance $12907 r0 *1 32.3,75.6
X$12907 2881 1467 2887 219 320 2966 MUX2_X1
* cell instance $12910 r0 *1 34.77,75.6
X$12910 2775 1307 2968 219 320 3036 MUX2_X1
* cell instance $12912 r0 *1 36.86,75.6
X$12912 2887 1520 2968 219 320 3186 MUX2_X1
* cell instance $12914 r0 *1 38.57,75.6
X$12914 219 14631 2889 2969 3086 320 DFF_X1
* cell instance $12915 r0 *1 41.8,75.6
X$12915 3037 2888 2889 219 320 3088 MUX2_X1
* cell instance $12916 m0 *1 42.56,75.6
X$12916 2846 2776 219 320 2891 NAND2_X1
* cell instance $12918 m0 *1 43.13,75.6
X$12918 2970 2777 219 320 2971 NAND2_X1
* cell instance $12921 m0 *1 45.98,75.6
X$12921 2779 2892 2653 219 320 2893 MUX2_X1
* cell instance $12925 r0 *1 43.13,75.6
X$12925 2891 2971 2890 219 320 3092 NAND3_X2
* cell instance $12928 r0 *1 46.36,75.6
X$12928 2893 2149 2884 219 320 2972 MUX2_X1
* cell instance $12929 r0 *1 47.69,75.6
X$12929 3092 3044 2972 320 219 3093 OAI21_X4
* cell instance $12932 r0 *1 51.3,75.6
X$12932 3038 1384 2775 219 320 3094 MUX2_X1
* cell instance $12933 m0 *1 53.58,75.6
X$12933 219 13012 2895 2894 2975 320 DFF_X1
* cell instance $12934 m0 *1 52.25,75.6
X$12934 2775 1695 2782 219 320 2781 MUX2_X1
* cell instance $12937 m0 *1 61.37,75.6
X$12937 2977 2963 2655 219 320 2978 MUX2_X1
* cell instance $12938 m0 *1 62.7,75.6
X$12938 2783 2888 2656 219 320 2897 MUX2_X1
* cell instance $12941 r0 *1 53.01,75.6
X$12941 2775 1609 2895 219 320 2894 MUX2_X1
* cell instance $12942 r0 *1 54.34,75.6
X$12942 2895 2787 2782 219 320 2896 MUX2_X1
* cell instance $12950 r0 *1 63.84,75.6
X$12950 2978 2776 219 320 2981 NAND2_X1
* cell instance $12952 m0 *1 64.41,75.6
X$12952 2897 1835 2980 219 320 2898 MUX2_X1
* cell instance $12957 r0 *1 65.74,75.6
X$12957 2898 2777 219 320 2899 NAND2_X1
* cell instance $12958 r0 *1 66.31,75.6
X$12958 2981 2899 2890 219 320 3100 NAND3_X2
* cell instance $12960 m0 *1 66.88,75.6
X$12960 219 13581 2900 2982 2565 320 DFF_X1
* cell instance $12963 m0 *1 72.58,75.6
X$12963 2985 2149 2734 219 320 2986 MUX2_X1
* cell instance $12964 m0 *1 73.91,75.6
X$12964 2660 2714 2567 219 320 2987 MUX2_X1
* cell instance $12965 m0 *1 75.24,75.6
X$12965 2987 2892 2989 219 320 2985 MUX2_X1
* cell instance $12970 m0 *1 82.08,75.6
X$12970 2765 219 320 3046 BUF_X1
* cell instance $12973 m0 *1 83.6,75.6
X$12973 219 12589 2738 2990 2790 320 DFF_X1
* cell instance $12977 r0 *1 68.21,75.6
X$12977 219 14482 3043 2984 2785 320 DFF_X1
* cell instance $12980 r0 *1 72.58,75.6
X$12980 3100 3044 2986 320 219 2912 OAI21_X4
* cell instance $12985 r0 *1 79.42,75.6
X$12985 2901 320 1933 219 BUF_X4
* cell instance $12988 r0 *1 84.17,75.6
X$12988 1282 219 320 2297 CLKBUF_X3
* cell instance $12991 r0 *1 87.02,75.6
X$12991 1578 219 320 2790 CLKBUF_X3
* cell instance $12993 m0 *1 87.21,75.6
X$12993 219 12641 2903 2991 2790 320 DFF_X1
* cell instance $12994 m0 *1 90.63,75.6
X$12994 219 2858 2791 2996 2995 2994 320 NOR4_X4
* cell instance $12995 m0 *1 94.05,75.6
X$12995 2993 2904 2998 320 2996 219 NOR3_X2
* cell instance $12999 r0 *1 88.92,75.6
X$12999 2569 1647 2903 219 320 2991 MUX2_X1
* cell instance $13000 r0 *1 90.25,75.6
X$13000 2903 2901 2742 219 320 2993 MUX2_X1
* cell instance $13002 r0 *1 93.1,75.6
X$13002 2902 320 2438 219 BUF_X4
* cell instance $13003 r0 *1 94.43,75.6
X$13003 3046 1571 2905 219 320 2999 MUX2_X1
* cell instance $13006 m0 *1 95.76,75.6
X$13006 2329 2904 2998 320 2859 219 NOR3_X2
* cell instance $13009 r0 *1 95.95,75.6
X$13009 219 14343 2905 2999 2668 320 DFF_X1
* cell instance $13011 r0 *1 99.37,75.6
X$13011 219 14380 2906 3048 2668 320 DFF_X1
* cell instance $13012 m0 *1 99.94,75.6
X$13012 2837 320 2674 219 BUF_X4
* cell instance $13017 r0 *1 102.6,75.6
X$13017 2668 219 320 CLKBUF_X1
* cell instance $13020 m0 *1 107.54,75.6
X$13020 2796 1576 2797 219 320 2869 MUX2_X1
* cell instance $13021 m0 *1 106.21,75.6
X$13021 2569 1898 2796 219 320 2868 MUX2_X1
* cell instance $13022 m0 *1 108.87,75.6
X$13022 2569 1999 2797 219 320 3002 MUX2_X1
* cell instance $13025 r0 *1 108.11,75.6
X$13025 219 14636 2797 3002 2236 320 DFF_X1
* cell instance $13026 m0 *1 110.77,75.6
X$13026 2558 2795 320 219 3005 AND2_X1
* cell instance $13030 m0 *1 112.1,75.6
X$13030 219 12767 3004 3005 2236 320 DFF_X1
* cell instance $13032 m0 *1 115.33,75.6
X$13032 3004 320 2477 219 BUF_X4
* cell instance $13035 m0 *1 125.78,75.6
X$13035 324 2799 2907 219 320 2798 MUX2_X1
* cell instance $13045 r0 *1 126.92,75.6
X$13045 219 14231 2908 3006 2800 320 DFF_X1
* cell instance $13046 m0 *1 127.68,75.6
X$13046 324 2805 2908 219 320 3006 MUX2_X1
* cell instance $13051 m0 *1 130.15,75.6
X$13051 1396 2805 2803 219 320 2801 MUX2_X1
* cell instance $13053 r0 *1 130.15,75.6
X$13053 2907 2909 2908 219 320 3116 MUX2_X1
* cell instance $13054 r0 *1 131.48,75.6
X$13054 1396 2799 2910 219 320 2802 MUX2_X1
* cell instance $13056 m0 *1 132.62,75.6
X$13056 219 13609 2910 2802 2800 320 DFF_X1
* cell instance $13058 m0 *1 136.8,75.6
X$13058 287 2799 2913 219 320 3008 MUX2_X1
* cell instance $13061 m0 *1 139.08,75.6
X$13061 287 2805 2804 219 320 2876 MUX2_X1
* cell instance $13064 r0 *1 132.81,75.6
X$13064 2910 2909 2803 219 320 2911 MUX2_X1
* cell instance $13067 r0 *1 136.04,75.6
X$13067 219 14209 2913 3008 2637 320 DFF_X1
* cell instance $13068 r0 *1 139.27,75.6
X$13068 2913 2909 2804 219 320 2914 MUX2_X1
* cell instance $13072 r0 *1 141.93,75.6
X$13072 219 14219 2917 2915 2916 320 DFF_X1
* cell instance $13073 m0 *1 142.5,75.6
X$13073 760 2799 2917 219 320 2915 MUX2_X1
* cell instance $13077 m0 *1 144.78,75.6
X$13077 760 2805 2806 219 320 3012 MUX2_X1
* cell instance $13078 m0 *1 146.11,75.6
X$13078 219 13328 2806 3012 2916 320 DFF_X1
* cell instance $13080 m0 *1 150.1,75.6
X$13080 219 2873 2875 3016 2637 320 DFF_X1
* cell instance $13081 m0 *1 153.33,75.6
X$13081 2918 2873 3018 320 219 2872 HA_X1
* cell instance $13082 m0 *1 155.23,75.6
X$13082 2676 2872 219 320 1145 NAND2_X1
* cell instance $13085 m0 *1 157.51,75.6
X$13085 2720 2807 219 320 2920 NAND2_X1
* cell instance $13086 m0 *1 158.08,75.6
X$13086 1943 219 320 12513 INV_X4
* cell instance $13087 m0 *1 159.03,75.6
X$13087 2156 219 320 1943 CLKBUF_X3
* cell instance $13088 m0 *1 159.98,75.6
X$13088 2808 2871 3022 219 232 320 AOI21_X2
* cell instance $13090 m0 *1 161.5,75.6
X$13090 2811 2921 3026 219 403 320 AOI21_X2
* cell instance $13092 r0 *1 145.16,75.6
X$13092 2917 2909 2806 219 320 3015 MUX2_X1
* cell instance $13097 r0 *1 149.34,75.6
X$13097 219 2918 2874 3052 2916 320 DFF_X1
* cell instance $13098 r0 *1 152.57,75.6
X$13098 2918 2875 12535 320 219 2919 HA_X1
* cell instance $13101 r0 *1 157.7,75.6
X$13101 1747 2807 219 320 3120 NAND2_X1
* cell instance $13102 r0 *1 158.27,75.6
X$13102 3054 2920 3021 219 228 320 AOI21_X2
* cell instance $13103 r0 *1 159.6,75.6
X$13103 2922 2809 3024 219 235 320 AOI21_X2
* cell instance $13105 r0 *1 161.31,75.6
X$13105 2811 2812 3025 219 238 320 AOI21_X2
* cell instance $13106 r0 *1 162.64,75.6
X$13106 2922 3023 3119 219 245 320 AOI21_X2
* cell instance $13108 m0 *1 163.21,75.6
X$13108 2720 2866 219 320 3023 NAND2_X1
* cell instance $13109 m0 *1 163.97,75.6
X$13109 1747 2814 219 320 2923 NAND2_X1
* cell instance $13112 r0 *1 163.97,75.6
X$13112 2925 2923 2924 219 407 320 AOI21_X2
* cell instance $13113 r0 *1 165.3,75.6
X$13113 2925 2926 2927 219 411 320 AOI21_X2
* cell instance $13114 m0 *1 165.87,75.6
X$13114 2191 2814 219 320 2926 NAND2_X1
* cell instance $13117 r0 *1 166.63,75.6
X$13117 2925 3020 3237 219 491 320 AOI21_X2
* cell instance $13118 m0 *1 167.01,75.6
X$13118 1721 2814 219 320 3020 NAND2_X1
* cell instance $13122 m0 *1 169.86,75.6
X$13122 2811 2815 3017 219 248 320 AOI21_X2
* cell instance $13126 r0 *1 168.15,75.6
X$13126 1721 2810 219 320 2928 NAND2_X1
* cell instance $13127 r0 *1 168.72,75.6
X$13127 2808 2928 2929 219 432 320 AOI21_X2
* cell instance $13128 r0 *1 170.05,75.6
X$13128 1925 2814 219 320 3114 NAND2_X1
* cell instance $13129 r0 *1 170.62,75.6
X$13129 2191 2813 219 320 2815 NAND2_X1
* cell instance $13131 r0 *1 171.95,75.6
X$13131 2808 3014 3013 219 252 320 AOI21_X2
* cell instance $13133 m0 *1 172.33,75.6
X$13133 2191 2810 219 320 3014 NAND2_X1
* cell instance $13134 m0 *1 173.66,75.6
X$13134 1721 2813 219 320 3010 NAND2_X1
* cell instance $13135 m0 *1 174.23,75.6
X$13135 1721 2807 219 320 3009 NAND2_X1
* cell instance $13136 m0 *1 174.8,75.6
X$13136 219 468 2811 3010 3230 320 AOI21_X4
* cell instance $13137 m0 *1 177.27,75.6
X$13137 219 280 2811 3007 3060 320 AOI21_X4
* cell instance $13138 m0 *1 179.74,75.6
X$13138 2860 2925 219 320 258 NOR2_X2
* cell instance $13140 m0 *1 180.88,75.6
X$13140 219 13610 2932 3003 2727 320 DFF_X1
* cell instance $13142 m0 *1 184.3,75.6
X$13142 2728 2053 2932 219 320 3003 MUX2_X1
* cell instance $13144 r0 *1 173.28,75.6
X$13144 1721 2866 219 320 3011 NAND2_X1
* cell instance $13145 r0 *1 173.85,75.6
X$13145 2922 3011 3113 219 261 320 AOI21_X2
* cell instance $13149 r0 *1 175.18,75.6
X$13149 219 281 3054 3009 3228 320 AOI21_X4
* cell instance $13150 r0 *1 177.65,75.6
X$13150 2287 2807 219 320 2930 NAND2_X1
* cell instance $13151 r0 *1 178.22,75.6
X$13151 219 397 2808 3061 2931 320 AOI21_X4
* cell instance $13152 r0 *1 180.69,75.6
X$13152 3108 2925 219 320 275 NOR2_X2
* cell instance $13155 r0 *1 182.59,75.6
X$13155 2816 2590 2855 219 320 3106 MUX2_X1
* cell instance $13156 r0 *1 183.92,75.6
X$13156 2730 2590 2932 219 320 3105 MUX2_X1
* cell instance $13158 m0 *1 186.2,75.6
X$13158 2679 219 320 2712 BUF_X1
* cell instance $13160 m0 *1 186.77,75.6
X$13160 219 2679 2491 320 BUF_X32
* cell instance $13161 m0 *1 196.08,75.6
X$13161 2997 2589 2817 219 320 3000 MUX2_X1
* cell instance $13163 r0 *1 186.77,75.6
X$13163 2679 219 320 3096 BUF_X1
* cell instance $13164 r0 *1 187.34,75.6
X$13164 219 3001 320 2679 BUF_X8
* cell instance $13165 r0 *1 189.81,75.6
X$13165 219 14003 2997 2854 3210 320 DFF_X1
* cell instance $13166 r0 *1 193.04,75.6
X$13166 3101 2933 3000 320 219 3102 OAI21_X4
* cell instance $13167 r0 *1 195.51,75.6
X$13167 219 13979 2934 2992 2255 320 DFF_X1
* cell instance $13168 m0 *1 197.98,75.6
X$13168 219 13550 2821 2819 2366 320 DFF_X1
* cell instance $13172 r0 *1 198.74,75.6
X$13172 2820 2054 2934 219 320 2992 MUX2_X1
* cell instance $13173 r0 *1 200.07,75.6
X$13173 2934 2065 2821 219 320 2935 MUX2_X1
* cell instance $13175 r0 *1 201.78,75.6
X$13175 2822 3062 2988 219 320 2936 MUX2_X1
* cell instance $13176 m0 *1 202.54,75.6
X$13176 2820 2057 2988 219 320 2937 MUX2_X1
* cell instance $13178 m0 *1 203.87,75.6
X$13178 2362 219 320 2366 CLKBUF_X3
* cell instance $13179 m0 *1 204.82,75.6
X$13179 219 2976 2590 320 BUF_X32
* cell instance $13180 m0 *1 214.13,75.6
X$13180 3065 2495 2824 219 320 2825 MUX2_X1
* cell instance $13182 r0 *1 203.11,75.6
X$13182 219 14251 2988 2937 2366 320 DFF_X1
* cell instance $13183 r0 *1 206.34,75.6
X$13183 2938 2165 2848 219 320 2691 MUX2_X1
* cell instance $13184 r0 *1 207.67,75.6
X$13184 2938 2256 3064 219 320 2939 MUX2_X1
* cell instance $13185 r0 *1 209,75.6
X$13185 2072 219 320 2259 CLKBUF_X3
* cell instance $13187 r0 *1 210.71,75.6
X$13187 3065 2368 2823 219 320 2983 MUX2_X1
* cell instance $13188 r0 *1 212.04,75.6
X$13188 2823 2824 2979 320 219 2941 MUX2_X2
* cell instance $13189 r0 *1 213.75,75.6
X$13189 3096 219 320 2979 BUF_X1
* cell instance $13191 m0 *1 216.79,75.6
X$13191 2591 219 320 14754 INV_X1
* cell instance $13192 m0 *1 215.84,75.6
X$13192 1869 219 320 2591 CLKBUF_X3
* cell instance $13197 r0 *1 217.55,75.6
X$13197 219 14441 2942 2974 2591 320 DFF_X1
* cell instance $13198 m0 *1 221.16,75.6
X$13198 219 13222 2944 2973 2594 320 DFF_X1
* cell instance $13199 m0 *1 219.83,75.6
X$13199 2830 2495 2944 219 320 2973 MUX2_X1
* cell instance $13200 m0 *1 224.39,75.6
X$13200 2844 2839 2072 320 219 2967 MUX2_X2
* cell instance $13201 m0 *1 226.1,75.6
X$13201 2826 2495 2828 219 320 2829 MUX2_X1
* cell instance $13203 m0 *1 227.62,75.6
X$13203 219 13298 2828 2829 2945 320 DFF_X1
* cell instance $13207 r0 *1 220.78,75.6
X$13207 2830 2169 2943 219 320 3091 MUX2_X1
* cell instance $13208 r0 *1 222.11,75.6
X$13208 2942 1596 2944 219 320 3307 MUX2_X1
* cell instance $13211 r0 *1 226.86,75.6
X$13211 2940 219 320 1869 CLKBUF_X3
* cell instance $13214 r0 *1 229.71,75.6
X$13214 2945 219 320 CLKBUF_X1
* cell instance $13215 r0 *1 230.28,75.6
X$13215 219 14463 2946 2965 2945 320 DFF_X1
* cell instance $13219 m0 *1 236.74,75.6
X$13219 219 13196 2953 2838 2382 320 DFF_X1
* cell instance $13220 m0 *1 233.51,75.6
X$13220 219 13205 2959 2961 2945 320 DFF_X1
* cell instance $13222 m0 *1 240.16,75.6
X$13222 2833 219 320 2947 BUF_X1
* cell instance $13225 r0 *1 234.27,75.6
X$13225 219 14446 2958 2960 2945 320 DFF_X1
* cell instance $13226 r0 *1 237.5,75.6
X$13226 219 14442 3072 2956 2382 320 DFF_X1
* cell instance $13228 m0 *1 163.97,240.8
X$13228 6152 219 320 12465 BUF_X1
* cell instance $13231 m0 *1 165.3,240.8
X$13231 12482 219 320 12389 BUF_X1
* cell instance $13233 m0 *1 152.57,240.8
X$13233 7230 219 320 12448 BUF_X1
* cell instance $13234 m0 *1 152,240.8
X$13234 12125 219 320 12446 BUF_X1
* cell instance $13235 m0 *1 153.14,240.8
X$13235 6696 219 320 12449 BUF_X1
* cell instance $13236 m0 *1 153.71,240.8
X$13236 6895 219 320 12452 BUF_X1
* cell instance $13238 m0 *1 154.47,240.8
X$13238 12481 219 320 12126 BUF_X1
* cell instance $13239 m0 *1 155.04,240.8
X$13239 8353 219 320 12479 BUF_X1
* cell instance $13240 m0 *1 155.61,240.8
X$13240 7116 219 320 12453 BUF_X1
* cell instance $13242 m0 *1 169.67,240.8
X$13242 8544 219 320 12457 BUF_X1
* cell instance $13245 m0 *1 170.43,240.8
X$13245 10977 219 320 12450 BUF_X1
* cell instance $13248 m0 *1 172.71,240.8
X$13248 11562 219 320 12443 BUF_X2
* cell instance $13252 m0 *1 177.46,240.8
X$13252 10369 219 320 12439 BUF_X1
* cell instance $13254 m0 *1 178.79,240.8
X$13254 10405 219 320 12437 BUF_X1
* cell instance $13255 m0 *1 179.36,240.8
X$13255 10408 219 320 12432 BUF_X1
* cell instance $13256 m0 *1 179.93,240.8
X$13256 12430 219 320 12373 BUF_X1
* cell instance $13258 m0 *1 180.69,240.8
X$13258 10396 219 320 12427 BUF_X1
* cell instance $13259 m0 *1 181.26,240.8
X$13259 12192 219 320 12428 BUF_X1
* cell instance $13262 m0 *1 182.78,240.8
X$13262 10403 219 320 12424 BUF_X1
* cell instance $13263 m0 *1 183.35,240.8
X$13263 11467 219 320 12423 BUF_X2
* cell instance $13264 m0 *1 184.11,240.8
X$13264 10400 219 320 12419 BUF_X1
* cell instance $13266 m0 *1 184.87,240.8
X$13266 10402 219 320 12415 BUF_X1
* cell instance $13269 m0 *1 187.15,240.8
X$13269 10399 219 320 12411 BUF_X1
* cell instance $13270 m0 *1 187.72,240.8
X$13270 10397 219 320 12410 BUF_X1
* cell instance $13271 m0 *1 188.29,240.8
X$13271 10395 219 320 12406 BUF_X1
* cell instance $13274 m0 *1 189.81,240.8
X$13274 12484 219 320 12301 BUF_X1
* cell instance $13278 m0 *1 195.7,240.8
X$13278 12486 219 320 12375 BUF_X1
* cell instance $13279 m0 *1 196.27,240.8
X$13279 12487 219 320 12382 BUF_X1
* cell instance $13282 m0 *1 197.79,240.8
X$13282 12485 219 320 12346 BUF_X1
* cell instance $13283 m0 *1 198.36,240.8
X$13283 12488 219 320 12379 BUF_X1
* cell instance $13284 m0 *1 198.93,240.8
X$13284 12403 219 320 12347 BUF_X1
* cell instance $13285 m0 *1 199.5,240.8
X$13285 12399 219 320 12378 BUF_X1
* cell instance $13286 m0 *1 200.07,240.8
X$13286 11882 219 320 12398 BUF_X1
* cell instance $13291 m0 *1 239.21,92.4
X$13291 3736 219 320 4096 BUF_X1
* cell instance $13296 r0 *1 239.02,92.4
X$13296 4206 219 320 4092 BUF_X1
* cell instance $13297 r0 *1 239.59,92.4
X$13297 4097 219 320 3985 BUF_X1
* cell instance $13301 m0 *1 201.21,240.8
X$13301 12489 219 320 12376 BUF_X1
* cell instance $13306 m0 *1 154.66,173.6
X$13306 9314 219 320 9430 BUF_X1
* cell instance $13307 m0 *1 153.9,173.6
X$13307 9169 9430 9170 219 9514 320 AOI21_X1
* cell instance $13308 m0 *1 155.23,173.6
X$13308 9314 219 320 9518 BUF_X1
* cell instance $13309 m0 *1 155.8,173.6
X$13309 9517 9519 9431 320 9170 219 OAI21_X1
* cell instance $13310 m0 *1 156.56,173.6
X$13310 9317 219 320 9517 INV_X1
* cell instance $13311 m0 *1 156.94,173.6
X$13311 8832 9432 9317 320 219 9629 HA_X1
* cell instance $13314 r0 *1 154.09,173.6
X$13314 1282 219 320 10946 CLKBUF_X3
* cell instance $13316 r0 *1 155.23,173.6
X$13316 9518 219 320 9316 BUF_X1
* cell instance $13318 r0 *1 156.56,173.6
X$13318 9629 219 320 9431 INV_X1
* cell instance $13321 r0 *1 158.08,173.6
X$13321 9272 219 320 9563 BUF_X1
* cell instance $13323 m0 *1 159.41,173.6
X$13323 9438 219 320 9432 INV_X2
* cell instance $13326 m0 *1 160.74,173.6
X$13326 9433 7838 219 320 9434 NAND2_X1
* cell instance $13329 r0 *1 159.6,173.6
X$13329 9555 9554 320 219 9433 XNOR2_X1
* cell instance $13332 m0 *1 161.69,173.6
X$13332 9172 219 320 9555 BUF_X1
* cell instance $13333 m0 *1 163.78,173.6
X$13333 7838 9522 9523 219 9435 320 AOI21_X2
* cell instance $13334 m0 *1 165.11,173.6
X$13334 7838 9551 219 320 9436 NOR2_X1
* cell instance $13338 r0 *1 166.06,173.6
X$13338 532 598 528 219 320 9558 OR3_X1
* cell instance $13339 m0 *1 166.25,173.6
X$13339 9055 9276 9474 219 320 9523 NAND3_X1
* cell instance $13341 m0 *1 167.01,173.6
X$13341 9382 219 320 7838 CLKBUF_X3
* cell instance $13342 m0 *1 167.96,173.6
X$13342 9321 9276 9177 219 320 9634 NAND3_X1
* cell instance $13343 m0 *1 168.72,173.6
X$13343 9321 9276 219 320 9437 NAND2_X1
* cell instance $13345 m0 *1 169.48,173.6
X$13345 9319 9437 219 320 9520 NOR2_X1
* cell instance $13347 m0 *1 173.09,173.6
X$13347 9515 5488 219 320 9516 NOR2_X2
* cell instance $13349 m0 *1 174.8,173.6
X$13349 9506 7044 9050 219 9513 320 AOI21_X1
* cell instance $13351 m0 *1 178.6,173.6
X$13351 7945 9432 1449 6395 320 219 9509 OAI22_X2
* cell instance $13352 m0 *1 180.31,173.6
X$13352 8947 7106 9509 9566 7151 9181 320 219 AOI221_X2
* cell instance $13356 r0 *1 167.77,173.6
X$13356 9437 9319 219 320 9633 OR2_X1
* cell instance $13357 r0 *1 168.53,173.6
X$13357 9634 9633 9178 320 219 10123 MUX2_X2
* cell instance $13358 r0 *1 170.24,173.6
X$13358 9632 9520 9178 320 219 9561 MUX2_X2
* cell instance $13359 r0 *1 171.95,173.6
X$13359 9322 9631 9560 320 9562 219 NOR3_X2
* cell instance $13360 r0 *1 173.28,173.6
X$13360 9513 5488 219 320 9630 NOR2_X1
* cell instance $13367 r0 *1 175.18,173.6
X$13367 6634 1449 9626 4442 6728 320 219 9628 OAI221_X1
* cell instance $13368 r0 *1 176.32,173.6
X$13368 8050 9438 6949 8947 219 320 9626 AOI22_X1
* cell instance $13370 r0 *1 178.03,173.6
X$13370 8123 9438 6979 8947 219 320 9757 AOI22_X1
* cell instance $13371 r0 *1 178.98,173.6
X$13371 4442 219 320 9566 INV_X1
* cell instance $13372 r0 *1 179.36,173.6
X$13372 7462 9432 1449 6073 320 219 9564 OAI22_X2
* cell instance $13373 r0 *1 181.07,173.6
X$13373 9566 7628 9564 8947 6950 9565 320 219 AOI221_X2
* cell instance $13374 r0 *1 183.16,173.6
X$13374 8050 9563 9353 6949 219 320 9503 AOI22_X2
* cell instance $13376 m0 *1 183.54,173.6
X$13376 7944 9563 6732 9353 219 320 9507 AOI22_X1
* cell instance $13378 m0 *1 184.87,173.6
X$13378 4007 6728 1290 6634 9503 9506 219 320 OAI221_X2
* cell instance $13379 m0 *1 187.15,173.6
X$13379 9369 8123 9328 9275 7314 9500 320 219 AOI221_X2
* cell instance $13381 m0 *1 189.43,173.6
X$13381 4007 219 320 9275 INV_X1
* cell instance $13383 r0 *1 184.87,173.6
X$13383 9563 219 320 9369 BUF_X1
* cell instance $13387 r0 *1 187.91,173.6
X$13387 9050 2810 219 320 9618 NAND2_X1
* cell instance $13388 r0 *1 188.48,173.6
X$13388 7051 9618 9500 219 9567 320 AOI21_X2
* cell instance $13390 r0 *1 190,173.6
X$13390 8991 4631 8948 6634 9613 9790 219 320 OAI221_X2
* cell instance $13392 m0 *1 190.19,173.6
X$13392 9183 3730 9180 6634 9440 9497 219 320 OAI221_X2
* cell instance $13394 r0 *1 192.28,173.6
X$13394 7679 3812 9064 8050 219 320 9613 AOI22_X2
* cell instance $13395 m0 *1 194.37,173.6
X$13395 5901 9183 9441 9180 3787 320 219 9748 OAI221_X1
* cell instance $13396 m0 *1 192.66,173.6
X$13396 7679 4015 9329 8050 219 320 9440 AOI22_X2
* cell instance $13397 m0 *1 195.51,173.6
X$13397 7314 4015 8220 9329 219 320 9441 AOI22_X1
* cell instance $13399 m0 *1 197.22,173.6
X$13399 9485 7884 6713 219 9470 320 AOI21_X2
* cell instance $13402 r0 *1 194.37,173.6
X$13402 5898 9183 9568 9180 6075 320 219 9612 OAI221_X1
* cell instance $13403 r0 *1 195.51,173.6
X$13403 7628 4015 8421 9329 219 320 9568 AOI22_X1
* cell instance $13404 r0 *1 196.46,173.6
X$13404 3812 4015 219 320 9611 OR2_X1
* cell instance $13408 r0 *1 198.55,173.6
X$13408 9481 7884 8114 219 9569 320 AOI21_X1
* cell instance $13409 m0 *1 200.64,173.6
X$13409 9551 8488 9474 219 9475 320 AOI21_X1
* cell instance $13410 m0 *1 198.93,173.6
X$13410 9477 8596 2619 320 219 9479 MUX2_X2
* cell instance $13412 m0 *1 201.59,173.6
X$13412 8489 9475 219 320 9477 OR2_X1
* cell instance $13418 r0 *1 205.58,173.6
X$13418 820 219 320 9574 INV_X2
* cell instance $13419 r0 *1 206.15,173.6
X$13419 693 525 820 689 320 9607 219 OR4_X2
* cell instance $13421 m0 *1 206.53,173.6
X$13421 9442 8115 6138 219 8195 320 AOI21_X1
* cell instance $13423 r0 *1 207.48,173.6
X$13423 525 219 320 9575 INV_X2
* cell instance $13425 r0 *1 208.24,173.6
X$13425 9576 8115 9233 219 9444 320 AOI21_X1
* cell instance $13426 m0 *1 208.62,173.6
X$13426 9443 6836 219 320 9346 NOR2_X1
* cell instance $13430 m0 *1 215.46,173.6
X$13430 219 12665 9445 9602 8953 320 DFF_X1
* cell instance $13431 m0 *1 218.69,173.6
X$13431 9445 9340 9446 219 320 9469 MUX2_X1
* cell instance $13432 m0 *1 220.02,173.6
X$13432 9579 7753 9446 219 320 9468 MUX2_X1
* cell instance $13433 m0 *1 221.35,173.6
X$13433 9447 219 320 8953 CLKBUF_X3
* cell instance $13435 r0 *1 209,173.6
X$13435 9444 6328 219 320 9086 NOR2_X1
* cell instance $13437 r0 *1 209.95,173.6
X$13437 9470 5977 219 320 9578 NOR2_X2
* cell instance $13441 r0 *1 217.93,173.6
X$13441 9579 7749 9445 219 320 9602 MUX2_X1
* cell instance $13442 r0 *1 219.26,173.6
X$13442 9469 9598 8861 320 219 8670 MUX2_X2
* cell instance $13443 r0 *1 220.97,173.6
X$13443 9579 7750 9581 219 320 9580 MUX2_X1
* cell instance $13444 r0 *1 222.3,173.6
X$13444 9581 9340 9582 219 320 9598 MUX2_X1
* cell instance $13445 m0 *1 225.91,173.6
X$13445 9448 7753 9349 219 320 9339 MUX2_X1
* cell instance $13446 m0 *1 222.68,173.6
X$13446 219 12697 9337 9464 8953 320 DFF_X1
* cell instance $13447 m0 *1 227.24,173.6
X$13447 219 9340 7420 320 BUF_X32
* cell instance $13448 m0 *1 236.55,173.6
X$13448 9590 8503 9459 219 320 9345 MUX2_X1
* cell instance $13449 m0 *1 237.88,173.6
X$13449 9447 219 320 8844 CLKBUF_X3
* cell instance $13450 m0 *1 238.83,173.6
X$13450 9192 219 320 7611 BUF_X2
* cell instance $13451 m0 *1 239.59,173.6
X$13451 9214 219 320 9341 BUF_X1
* cell instance $13452 m0 *1 240.16,173.6
X$13452 9213 219 320 9449 BUF_X1
* cell instance $13455 r0 *1 223.82,173.6
X$13455 9448 7749 9337 219 320 9464 MUX2_X1
* cell instance $13457 r0 *1 225.53,173.6
X$13457 9338 9595 8861 320 219 9353 MUX2_X2
* cell instance $13459 r0 *1 227.62,173.6
X$13459 9583 8212 9593 219 320 9595 MUX2_X1
* cell instance $13461 r0 *1 229.33,173.6
X$13461 219 14089 9583 9592 9077 320 DFF_X1
* cell instance $13467 r0 *1 233.51,173.6
X$13467 9685 7420 9687 219 320 9079 MUX2_X1
* cell instance $13468 r0 *1 234.84,173.6
X$13468 9686 7176 9590 219 320 9584 MUX2_X1
* cell instance $13470 r0 *1 236.55,173.6
X$13470 219 14068 9459 9700 8844 320 DFF_X1
* cell instance $13471 r0 *1 239.78,173.6
X$13471 9223 219 320 9193 BUF_X1
* cell instance $13478 r0 *1 135.66,5.6
X$13478 219 13943 341 325 339 320 DFF_X1
* cell instance $13481 r0 *1 185.25,5.6
X$13481 330 302 308 219 320 307 MUX2_X1
* cell instance $13485 r0 *1 159.22,5.6
X$13485 219 14175 299 298 241 320 DFF_X1
* cell instance $13486 r0 *1 165.3,5.6
X$13486 219 14351 249 335 303 320 DFF_X1
* cell instance $13487 r0 *1 169.1,5.6
X$13487 301 302 249 219 320 335 MUX2_X1
* cell instance $13534 m0 *1 13.49,154
X$13534 7910 219 320 14704 INV_X2
* cell instance $13535 m0 *1 10.26,154
X$13535 219 12851 8012 8204 7910 320 DFF_X1
* cell instance $13536 m0 *1 14.06,154
X$13536 7911 6002 8014 219 320 8082 MUX2_X1
* cell instance $13537 m0 *1 15.39,154
X$13537 219 12850 8207 8083 7910 320 DFF_X1
* cell instance $13539 m0 *1 18.81,154
X$13539 219 12779 8208 8147 7913 320 DFF_X1
* cell instance $13542 r0 *1 10.64,154
X$13542 7578 7123 8013 219 320 7909 MUX2_X1
* cell instance $13543 r0 *1 11.97,154
X$13543 8012 7014 7345 219 320 8204 MUX2_X1
* cell instance $13544 r0 *1 13.3,154
X$13544 8012 8145 8013 219 320 8205 MUX2_X1
* cell instance $13546 r0 *1 14.82,154
X$13546 7172 219 320 7910 CLKBUF_X3
* cell instance $13548 r0 *1 16.15,154
X$13548 7911 5923 8207 219 320 8083 MUX2_X1
* cell instance $13550 r0 *1 17.67,154
X$13550 8014 8145 8207 219 320 8146 MUX2_X1
* cell instance $13551 r0 *1 19,154
X$13551 7911 6154 8208 219 320 8147 MUX2_X1
* cell instance $13553 r0 *1 21.09,154
X$13553 8306 8145 8208 219 320 8148 MUX2_X1
* cell instance $13555 r0 *1 22.8,154
X$13555 7172 219 320 7913 CLKBUF_X3
* cell instance $13556 m0 *1 23.37,154
X$13556 7345 6974 8085 219 320 8210 MUX2_X1
* cell instance $13558 m0 *1 24.7,154
X$13558 7345 7016 8211 219 320 8263 MUX2_X1
* cell instance $13560 m0 *1 26.22,154
X$13560 8085 8145 8211 219 320 8015 MUX2_X1
* cell instance $13563 m0 *1 28.5,154
X$13563 7911 5933 8017 219 320 8214 MUX2_X1
* cell instance $13566 m0 *1 31.54,154
X$13566 8017 7482 8307 219 320 8088 MUX2_X1
* cell instance $13568 r0 *1 23.75,154
X$13568 219 14098 8085 8210 7913 320 DFF_X1
* cell instance $13570 r0 *1 27.17,154
X$13570 8016 2719 8213 219 320 8149 MUX2_X1
* cell instance $13572 r0 *1 28.88,154
X$13572 219 13988 8017 8214 7913 320 DFF_X1
* cell instance $13574 r0 *1 32.49,154
X$13574 219 13878 8151 8150 7914 320 DFF_X1
* cell instance $13575 m0 *1 33.44,154
X$13575 8405 1639 8088 219 320 8018 MUX2_X1
* cell instance $13577 m0 *1 34.77,154
X$13577 8018 2719 7976 219 320 8090 MUX2_X1
* cell instance $13582 r0 *1 36.1,154
X$13582 219 13928 8152 8216 7914 320 DFF_X1
* cell instance $13583 m0 *1 41.99,154
X$13583 5810 219 320 7482 CLKBUF_X3
* cell instance $13584 m0 *1 38.76,154
X$13584 219 12800 8092 8091 7487 320 DFF_X1
* cell instance $13588 r0 *1 39.33,154
X$13588 8152 6110 7805 219 320 8216 MUX2_X1
* cell instance $13589 r0 *1 40.66,154
X$13589 8152 7482 8092 219 320 8153 MUX2_X1
* cell instance $13590 r0 *1 41.99,154
X$13590 8153 1639 8154 219 320 8217 MUX2_X1
* cell instance $13593 r0 *1 46.55,154
X$13593 219 14682 8094 8218 7915 320 DFF_X1
* cell instance $13595 m0 *1 47.12,154
X$13595 8020 5923 8094 219 320 8218 MUX2_X1
* cell instance $13596 m0 *1 49.02,154
X$13596 8269 6917 8094 219 320 8222 MUX2_X1
* cell instance $13602 r0 *1 50.92,154
X$13602 8020 6154 8155 219 320 8019 MUX2_X1
* cell instance $13604 m0 *1 51.49,154
X$13604 219 12833 8155 8019 7915 320 DFF_X1
* cell instance $13607 r0 *1 53.77,154
X$13607 8312 6917 8155 219 320 8223 MUX2_X1
* cell instance $13609 r0 *1 55.29,154
X$13609 8223 2752 8222 219 320 8226 MUX2_X1
* cell instance $13610 m0 *1 57.19,154
X$13610 219 12795 8021 8096 7918 320 DFF_X1
* cell instance $13611 m0 *1 55.86,154
X$13611 8020 6156 8021 219 320 8096 MUX2_X1
* cell instance $13613 m0 *1 60.61,154
X$13613 6373 219 320 7918 CLKBUF_X3
* cell instance $13618 r0 *1 57.38,154
X$13618 219 14289 8224 8313 7918 320 DFF_X1
* cell instance $13619 r0 *1 60.61,154
X$13619 8224 6165 8021 219 320 8156 MUX2_X1
* cell instance $13624 r0 *1 63.46,154
X$13624 219 14405 8157 8316 7918 320 DFF_X1
* cell instance $13625 m0 *1 66.69,154
X$13625 219 13490 8024 8023 8022 320 DFF_X1
* cell instance $13633 r0 *1 70.49,154
X$13633 8227 5517 8226 219 320 8158 MUX2_X1
* cell instance $13637 r0 *1 73.15,154
X$13637 8323 2095 8273 219 320 8227 MUX2_X1
* cell instance $13641 r0 *1 78.66,154
X$13641 219 14295 8160 8159 8326 320 DFF_X1
* cell instance $13644 r0 *1 82.46,154
X$13644 8160 3370 8327 219 320 7318 MUX2_X1
* cell instance $13646 m0 *1 87.21,154
X$13646 6373 219 320 7822 CLKBUF_X3
* cell instance $13647 m0 *1 83.98,154
X$13647 219 13474 7923 8025 7822 320 DFF_X1
* cell instance $13648 m0 *1 88.16,154
X$13648 7924 7136 8026 219 320 8104 MUX2_X1
* cell instance $13649 m0 *1 89.49,154
X$13649 219 13487 8026 8104 8105 320 DFF_X1
* cell instance $13650 m0 *1 92.72,154
X$13650 7924 7490 8108 219 320 8107 MUX2_X1
* cell instance $13651 m0 *1 94.05,154
X$13651 219 13460 8108 8107 7926 320 DFF_X1
* cell instance $13653 m0 *1 98.04,154
X$13653 7139 7025 8112 219 320 8110 MUX2_X1
* cell instance $13654 m0 *1 99.37,154
X$13654 219 13478 8112 8110 8028 320 DFF_X1
* cell instance $13655 m0 *1 102.6,154
X$13655 8232 8029 8113 8233 320 6512 219 NOR4_X2
* cell instance $13657 r0 *1 83.98,154
X$13657 7258 7243 8161 219 320 8229 MUX2_X1
* cell instance $13658 r0 *1 85.31,154
X$13658 219 14348 8161 8229 7822 320 DFF_X1
* cell instance $13659 r0 *1 88.54,154
X$13659 8161 5816 8275 219 320 8027 MUX2_X1
* cell instance $13661 r0 *1 90.63,154
X$13661 7258 219 320 7139 BUF_X2
* cell instance $13667 r0 *1 97.28,154
X$13667 8162 5816 8276 219 320 8230 MUX2_X1
* cell instance $13669 r0 *1 98.8,154
X$13669 8230 4127 219 320 8029 NOR2_X1
* cell instance $13671 r0 *1 99.75,154
X$13671 7139 7026 8163 219 320 8277 MUX2_X1
* cell instance $13673 r0 *1 101.46,154
X$13673 8112 5816 8163 219 320 8231 MUX2_X1
* cell instance $13674 r0 *1 102.79,154
X$13674 8231 4566 219 320 8232 NOR2_X1
* cell instance $13676 r0 *1 104.12,154
X$13676 7139 7027 8165 219 320 8234 MUX2_X1
* cell instance $13677 m0 *1 104.88,154
X$13677 8164 5353 8165 219 320 8117 MUX2_X1
* cell instance $13679 m0 *1 106.21,154
X$13679 8117 5122 6277 219 320 8233 NOR3_X1
* cell instance $13683 m0 *1 109.44,154
X$13683 8030 219 320 8235 BUF_X1
* cell instance $13685 m0 *1 110.2,154
X$13685 219 13477 8030 7929 7928 320 DFF_X1
* cell instance $13689 r0 *1 105.45,154
X$13689 219 13823 8165 8234 8028 320 DFF_X1
* cell instance $13691 r0 *1 109.06,154
X$13691 219 5254 320 8030 BUF_X8
* cell instance $13695 m0 *1 116.28,154
X$13695 8122 8121 8120 219 320 8031 MUX2_X1
* cell instance $13697 m0 *1 117.61,154
X$13697 219 13462 8239 8238 7928 320 DFF_X1
* cell instance $13698 m0 *1 120.84,154
X$13698 8120 7501 8239 219 320 8124 MUX2_X1
* cell instance $13703 r0 *1 116.66,154
X$13703 6284 219 320 7928 CLKBUF_X3
* cell instance $13706 r0 *1 118.56,154
X$13706 8122 8166 8239 219 320 8238 MUX2_X1
* cell instance $13710 r0 *1 119.89,154
X$13710 219 14049 8280 8336 7928 320 DFF_X1
* cell instance $13713 m0 *1 126.16,154
X$13713 219 13412 7933 8125 8033 320 DFF_X1
* cell instance $13714 m0 *1 124.83,154
X$13714 8167 8121 7932 219 320 8032 MUX2_X1
* cell instance $13718 r0 *1 125.21,154
X$13718 8281 7606 8124 320 219 7688 OAI21_X4
* cell instance $13719 r0 *1 127.68,154
X$13719 8167 8166 7933 219 320 8125 MUX2_X1
* cell instance $13722 m0 *1 130.53,154
X$13722 8168 8278 8035 219 320 8034 MUX2_X1
* cell instance $13723 m0 *1 132.05,154
X$13723 8168 8242 8037 219 320 8036 MUX2_X1
* cell instance $13726 r0 *1 132.24,154
X$13726 8168 8121 8169 219 320 8245 MUX2_X1
* cell instance $13727 r0 *1 133.57,154
X$13727 219 14689 8169 8245 7934 320 DFF_X1
* cell instance $13728 m0 *1 133.95,154
X$13728 8035 4584 8037 219 320 8127 MUX2_X1
* cell instance $13730 m0 *1 135.28,154
X$13730 5359 8344 219 320 8128 OR2_X1
* cell instance $13733 r0 *1 136.8,154
X$13733 8169 3775 8283 219 320 8246 MUX2_X1
* cell instance $13734 m0 *1 139.65,154
X$13734 7865 320 8114 219 BUF_X4
* cell instance $13735 m0 *1 137.18,154
X$13735 8129 8246 4383 320 219 8043 OAI21_X4
* cell instance $13736 m0 *1 140.98,154
X$13736 7609 8038 7936 219 320 7935 MUX2_X1
* cell instance $13737 m0 *1 142.31,154
X$13737 7609 8040 8039 219 320 8130 MUX2_X1
* cell instance $13739 m0 *1 143.83,154
X$13739 5428 219 320 7726 CLKBUF_X3
* cell instance $13740 m0 *1 144.78,154
X$13740 7611 8038 8133 219 320 8131 MUX2_X1
* cell instance $13741 m0 *1 146.11,154
X$13741 219 12807 8133 8131 7726 320 DFF_X1
* cell instance $13743 r0 *1 138.13,154
X$13743 8285 4383 8540 320 219 5842 OAI21_X4
* cell instance $13744 r0 *1 140.6,154
X$13744 8345 4383 8541 320 219 5967 OAI21_X4
* cell instance $13747 r0 *1 144.02,154
X$13747 7726 219 320 CLKBUF_X1
* cell instance $13750 r0 *1 146.49,154
X$13750 8170 3262 8171 320 219 5366 OAI21_X4
* cell instance $13751 r0 *1 148.96,154
X$13751 8350 3262 8349 320 219 4933 OAI21_X4
* cell instance $13752 m0 *1 150.48,154
X$13752 8137 219 320 8041 INV_X1
* cell instance $13753 m0 *1 149.72,154
X$13753 8138 8042 8041 219 8134 320 AOI21_X1
* cell instance $13754 m0 *1 150.86,154
X$13754 6956 7688 8042 320 219 8138 HA_X1
* cell instance $13755 m0 *1 152.76,154
X$13755 8172 219 320 8135 BUF_X1
* cell instance $13756 m0 *1 153.33,154
X$13756 8043 219 320 6889 BUF_X1
* cell instance $13759 m0 *1 157.7,154
X$13759 8044 219 320 8251 INV_X1
* cell instance $13760 m0 *1 158.08,154
X$13760 8006 8044 8252 219 8249 320 AOI21_X1
* cell instance $13761 m0 *1 158.84,154
X$13761 8006 219 320 8250 INV_X1
* cell instance $13762 m0 *1 159.22,154
X$13762 8045 219 320 8142 INV_X1
* cell instance $13763 m0 *1 159.6,154
X$13763 8140 8142 8046 320 219 7905 OAI21_X2
* cell instance $13764 m0 *1 160.93,154
X$13764 8047 219 320 8140 INV_X1
* cell instance $13768 r0 *1 151.43,154
X$13768 7450 8351 8172 320 219 8247 HA_X1
* cell instance $13772 r0 *1 157.51,154
X$13772 8173 219 320 8252 INV_X1
* cell instance $13773 r0 *1 157.89,154
X$13773 8250 8173 8251 320 219 8256 OAI21_X2
* cell instance $13774 r0 *1 159.22,154
X$13774 8254 8249 8174 320 8175 219 OAI21_X1
* cell instance $13775 r0 *1 159.98,154
X$13775 8433 219 320 8174 INV_X1
* cell instance $13776 r0 *1 160.36,154
X$13776 8047 8045 8175 219 8257 320 AOI21_X1
* cell instance $13777 r0 *1 161.12,154
X$13777 7618 7797 8257 320 219 8259 OAI21_X2
* cell instance $13781 m0 *1 166.25,154
X$13781 8356 320 5736 219 BUF_X4
* cell instance $13782 m0 *1 167.77,154
X$13782 7939 7275 7207 6068 320 219 8048 OAI22_X2
* cell instance $13786 r0 *1 168.15,154
X$13786 7505 8049 8048 7729 8060 8176 320 219 AOI221_X2
* cell instance $13788 m0 *1 169.86,154
X$13788 8177 8050 8144 7625 7679 8436 320 219 AOI221_X2
* cell instance $13790 r0 *1 170.24,154
X$13790 8050 320 8060 219 BUF_X4
* cell instance $13792 m0 *1 173.28,154
X$13792 7688 219 320 8177 INV_X1
* cell instance $13795 m0 *1 174.42,154
X$13795 7729 8123 8143 7505 7406 8258 320 219 AOI221_X2
* cell instance $13797 m0 *1 176.7,154
X$13797 7845 7275 7207 7735 320 219 8053 OAI22_X2
* cell instance $13798 m0 *1 178.41,154
X$13798 8177 8123 8139 7625 7314 8253 320 219 AOI221_X2
* cell instance $13800 m0 *1 180.69,154
X$13800 8056 8177 7740 7625 219 320 8057 AOI22_X1
* cell instance $13801 m0 *1 181.64,154
X$13801 8058 6955 7624 219 8244 320 AOI21_X1
* cell instance $13803 m0 *1 182.59,154
X$13803 8056 8179 7106 8059 219 320 8180 AOI22_X1
* cell instance $13805 m0 *1 185.06,154
X$13805 7889 6539 219 320 8236 NAND2_X1
* cell instance $13807 r0 *1 174.61,154
X$13807 7729 8260 8053 7505 7949 8261 320 219 AOI221_X2
* cell instance $13811 r0 *1 176.7,154
X$13811 7275 219 320 8051 BUF_X1
* cell instance $13812 r0 *1 177.27,154
X$13812 7521 219 320 8054 BUF_X1
* cell instance $13813 r0 *1 177.84,154
X$13813 8141 6635 7329 219 8348 320 AOI21_X1
* cell instance $13815 r0 *1 178.79,154
X$13815 219 8255 7051 8248 8253 320 AOI21_X4
* cell instance $13817 r0 *1 181.45,154
X$13817 7624 6539 219 320 8248 NAND2_X1
* cell instance $13819 r0 *1 182.21,154
X$13819 7944 8179 6732 8059 219 320 8291 AOI22_X1
* cell instance $13820 r0 *1 183.16,154
X$13820 7058 8178 8180 8237 4511 320 219 8243 OAI221_X1
* cell instance $13821 r0 *1 184.3,154
X$13821 8244 5533 219 320 8341 NOR2_X2
* cell instance $13822 r0 *1 185.25,154
X$13822 7945 219 320 8056 INV_X2
* cell instance $13824 m0 *1 186.2,154
X$13824 7947 8049 8126 7946 8060 8241 320 219 AOI221_X2
* cell instance $13826 m0 *1 188.29,154
X$13826 219 8098 7051 8236 8061 320 AOI21_X4
* cell instance $13827 m0 *1 190.76,154
X$13827 8052 320 4586 219 BUF_X4
* cell instance $13831 r0 *1 186.77,154
X$13831 8181 6635 7889 219 8183 320 AOI21_X1
* cell instance $13833 r0 *1 187.91,154
X$13833 8055 8240 219 320 8182 NAND2_X1
* cell instance $13835 r0 *1 188.67,154
X$13835 7314 3545 6979 8059 219 320 8240 AOI22_X1
* cell instance $13837 r0 *1 189.81,154
X$13837 3545 219 320 8237 INV_X1
* cell instance $13841 r0 *1 192.28,154
X$13841 5898 8186 7950 8184 5837 320 219 8332 OAI221_X1
* cell instance $13842 m0 *1 194.18,154
X$13842 7314 5033 7406 8062 219 320 8187 AOI22_X1
* cell instance $13843 m0 *1 193.23,154
X$13843 7740 5033 6951 8062 219 320 8185 AOI22_X1
* cell instance $13845 r0 *1 193.42,154
X$13845 6538 8184 8185 8186 4239 320 219 8228 OAI221_X1
* cell instance $13846 r0 *1 194.56,154
X$13846 5901 8186 8187 8184 3788 320 219 8330 OAI221_X1
* cell instance $13847 m0 *1 195.7,154
X$13847 8063 5902 8114 219 7878 320 AOI21_X1
* cell instance $13851 r0 *1 195.7,154
X$13851 8228 6955 8293 219 8221 320 AOI21_X1
* cell instance $13854 r0 *1 198.17,154
X$13854 7106 8192 7102 8194 219 320 8191 AOI22_X1
* cell instance $13855 m0 *1 198.55,154
X$13855 532 219 320 8190 INV_X2
* cell instance $13857 m0 *1 199.12,154
X$13857 8065 5902 6680 219 8064 320 AOI21_X1
* cell instance $13858 m0 *1 199.88,154
X$13858 8064 3702 219 320 8101 NOR2_X1
* cell instance $13860 m0 *1 200.64,154
X$13860 4180 8189 8193 8190 3787 320 219 8106 OAI221_X1
* cell instance $13861 m0 *1 201.78,154
X$13861 4083 8189 8225 8190 6075 320 219 8067 OAI221_X1
* cell instance $13862 m0 *1 202.92,154
X$13862 8221 5979 219 320 8068 NOR2_X1
* cell instance $13863 m0 *1 203.49,154
X$13863 2694 219 320 8189 INV_X2
* cell instance $13867 m0 *1 213.37,154
X$13867 219 12896 8099 8100 7162 320 DFF_X1
* cell instance $13868 m0 *1 216.6,154
X$13868 8070 6861 7955 219 320 8069 MUX2_X1
* cell instance $13869 m0 *1 217.93,154
X$13869 8070 6740 8099 219 320 8100 MUX2_X1
* cell instance $13871 m0 *1 220.78,154
X$13871 8070 6860 8071 219 320 8097 MUX2_X1
* cell instance $13872 m0 *1 222.11,154
X$13872 8070 6843 7959 219 320 7975 MUX2_X1
* cell instance $13874 r0 *1 199.12,154
X$13874 7058 8190 8191 8189 3347 320 219 8065 OAI221_X1
* cell instance $13875 r0 *1 200.26,154
X$13875 6979 8192 8220 8194 219 320 8193 AOI22_X1
* cell instance $13879 r0 *1 206.53,154
X$13879 5033 219 320 8219 INV_X1
* cell instance $13882 r0 *1 208.62,154
X$13882 8195 6328 219 320 8206 NOR2_X1
* cell instance $13887 r0 *1 217.36,154
X$13887 8196 6861 8197 219 320 8299 MUX2_X1
* cell instance $13889 r0 *1 219.45,154
X$13889 8215 7957 8311 320 219 7275 OAI21_X4
* cell instance $13892 r0 *1 222.49,154
X$13892 8300 8212 8411 219 320 8198 MUX2_X1
* cell instance $13894 m0 *1 224.77,154
X$13894 8093 8089 5640 320 219 8059 MUX2_X2
* cell instance $13895 m0 *1 223.82,154
X$13895 6410 8198 219 320 8215 OR2_X2
* cell instance $13897 r0 *1 224.2,154
X$13897 5757 219 320 7958 CLKBUF_X3
* cell instance $13898 r0 *1 225.15,154
X$13898 219 13909 8199 8095 7958 320 DFF_X1
* cell instance $13899 m0 *1 228.19,154
X$13899 8199 7539 8073 219 320 8093 MUX2_X1
* cell instance $13900 m0 *1 226.86,154
X$13900 8072 7749 8199 219 320 8095 MUX2_X1
* cell instance $13902 m0 *1 229.71,154
X$13902 8074 7539 7960 219 320 8089 MUX2_X1
* cell instance $13903 m0 *1 231.04,154
X$13903 219 12891 8077 8087 8086 320 DFF_X1
* cell instance $13904 m0 *1 234.27,154
X$13904 8077 7420 7967 219 320 8209 MUX2_X1
* cell instance $13906 r0 *1 228.38,154
X$13906 219 14026 8073 8200 8086 320 DFF_X1
* cell instance $13913 r0 *1 233.7,154
X$13913 8075 7957 8209 320 219 7941 OAI21_X4
* cell instance $13915 m0 *1 235.98,154
X$13915 219 12886 7962 8084 8086 320 DFF_X1
* cell instance $13916 r0 *1 236.17,154
X$13916 8086 219 320 CLKBUF_X1
* cell instance $13918 r0 *1 236.93,154
X$13918 219 13955 7963 8078 8086 320 DFF_X1
* cell instance $13920 m0 *1 239.59,154
X$13920 6693 219 320 7966 BUF_X1
* cell instance $13921 r0 *1 240.16,154
X$13921 8080 219 320 7065 BUF_X1
* cell instance $13926 m0 *1 174.42,103.6
X$13926 4736 4729 4239 4676 320 219 4884 OAI22_X1
* cell instance $13928 m0 *1 179.17,103.6
X$13928 4883 4737 4738 3516 320 219 4733 OAI22_X2
* cell instance $13929 m0 *1 180.88,103.6
X$13929 4402 4725 219 320 4881 NOR2_X1
* cell instance $13931 m0 *1 182.21,103.6
X$13931 5067 3054 219 320 256 NOR2_X2
* cell instance $13932 m0 *1 183.16,103.6
X$13932 4828 4737 4631 4738 320 219 4829 OAI22_X1
* cell instance $13933 m0 *1 184.11,103.6
X$13933 4881 4829 4739 219 320 4880 NOR3_X1
* cell instance $13936 r0 *1 174.61,103.6
X$13936 4929 4304 219 320 4930 NOR2_X1
* cell instance $13941 r0 *1 175.56,103.6
X$13941 4931 2808 219 320 279 NOR2_X2
* cell instance $13944 r0 *1 177.65,103.6
X$13944 4929 4725 219 320 4932 NOR2_X1
* cell instance $13947 m0 *1 185.44,103.6
X$13947 4880 2922 219 320 4837 NOR2_X1
* cell instance $13951 r0 *1 187.34,103.6
X$13951 3443 4933 3513 4935 320 219 4970 OAI22_X1
* cell instance $13953 m0 *1 187.91,103.6
X$13953 3647 3162 219 320 4830 NOR2_X1
* cell instance $13954 m0 *1 189.24,103.6
X$13954 3647 3398 219 320 4831 NOR2_X1
* cell instance $13956 m0 *1 190,103.6
X$13956 3512 4933 3280 607 320 219 4875 OAI22_X1
* cell instance $13957 m0 *1 190.95,103.6
X$13957 4831 4875 4967 219 320 4874 NOR3_X1
* cell instance $13959 r0 *1 188.29,103.6
X$13959 4830 4970 4969 219 320 4832 NOR3_X1
* cell instance $13960 r0 *1 189.05,103.6
X$13960 3217 607 3666 1509 320 219 4969 OAI22_X1
* cell instance $13961 r0 *1 190,103.6
X$13961 3781 4933 3785 4935 320 219 4934 OAI22_X1
* cell instance $13962 r0 *1 190.95,103.6
X$13962 4523 4935 3468 1509 320 219 4967 OAI22_X1
* cell instance $13963 r0 *1 191.9,103.6
X$13963 3871 607 3979 1509 320 219 4936 OAI22_X1
* cell instance $13964 m0 *1 192.28,103.6
X$13964 3647 3705 219 320 4833 NOR2_X1
* cell instance $13968 r0 *1 192.85,103.6
X$13968 4832 3163 219 320 4848 NOR2_X1
* cell instance $13970 m0 *1 194.18,103.6
X$13970 4874 3282 219 320 4839 NOR2_X1
* cell instance $13972 m0 *1 194.75,103.6
X$13972 219 12562 4775 4774 4834 320 DFF_X1
* cell instance $13973 m0 *1 197.98,103.6
X$13973 4775 1893 4638 219 320 4835 MUX2_X1
* cell instance $13974 m0 *1 199.31,103.6
X$13974 4639 2490 4937 219 320 4872 MUX2_X1
* cell instance $13975 m0 *1 200.64,103.6
X$13975 4639 2364 4868 219 320 4836 MUX2_X1
* cell instance $13977 m0 *1 202.16,103.6
X$13977 219 13630 4742 4772 4557 320 DFF_X1
* cell instance $13979 m0 *1 205.58,103.6
X$13979 4742 2491 4838 219 320 5032 MUX2_X1
* cell instance $13981 m0 *1 207.1,103.6
X$13981 4645 2364 4939 219 320 4866 MUX2_X1
* cell instance $13984 r0 *1 195.7,103.6
X$13984 219 13704 4937 4872 4834 320 DFF_X1
* cell instance $13985 r0 *1 198.93,103.6
X$13985 4835 4961 2072 320 219 4938 MUX2_X2
* cell instance $13986 r0 *1 200.64,103.6
X$13986 4868 2491 4937 219 320 4961 MUX2_X1
* cell instance $13988 r0 *1 202.73,103.6
X$13988 4557 219 320 CLKBUF_X1
* cell instance $13989 r0 *1 203.3,103.6
X$13989 219 14284 4838 4771 4557 320 DFF_X1
* cell instance $13990 r0 *1 206.53,103.6
X$13990 219 13919 4939 4866 4557 320 DFF_X1
* cell instance $13991 m0 *1 210.14,103.6
X$13991 219 12559 4864 4863 4415 320 DFF_X1
* cell instance $13992 m0 *1 208.81,103.6
X$13992 4645 2490 4864 219 320 4863 MUX2_X1
* cell instance $13994 r0 *1 209.76,103.6
X$13994 4939 2491 4864 219 320 4958 MUX2_X1
* cell instance $13996 m0 *1 213.94,103.6
X$13996 4415 219 320 CLKBUF_X1
* cell instance $14003 m0 *1 224.2,103.6
X$14003 4219 3293 4840 219 320 4861 MUX2_X1
* cell instance $14004 m0 *1 220.97,103.6
X$14004 219 12897 4840 4861 4317 320 DFF_X1
* cell instance $14005 m0 *1 225.53,103.6
X$14005 4840 4530 4640 219 320 4859 MUX2_X1
* cell instance $14006 m0 *1 226.86,103.6
X$14006 4219 2831 4744 219 320 4756 MUX2_X1
* cell instance $14007 m0 *1 228.19,103.6
X$14007 4744 4531 4641 219 320 4552 MUX2_X1
* cell instance $14010 m0 *1 232.75,103.6
X$14010 4533 3293 4841 219 320 4851 MUX2_X1
* cell instance $14011 m0 *1 234.08,103.6
X$14011 4533 3070 4842 219 320 4754 MUX2_X1
* cell instance $14012 m0 *1 235.41,103.6
X$14012 4841 3880 4842 219 320 4642 MUX2_X1
* cell instance $14013 m0 *1 236.74,103.6
X$14013 4752 219 320 4845 BUF_X1
* cell instance $14015 m0 *1 237.5,103.6
X$14015 219 12992 4535 4644 4323 320 DFF_X1
* cell instance $14017 r0 *1 221.16,103.6
X$14017 219 14506 5058 4940 4317 320 DFF_X1
* cell instance $14020 r0 *1 226.1,103.6
X$14020 1869 219 320 4317 CLKBUF_X3
* cell instance $14023 r0 *1 228.76,103.6
X$14023 4941 320 3070 219 BUF_X4
* cell instance $14030 r0 *1 231.42,103.6
X$14030 4942 320 3293 219 BUF_X4
* cell instance $14033 r0 *1 233.32,103.6
X$14033 4837 219 320 5044 BUF_X1
* cell instance $14036 r0 *1 234.84,103.6
X$14036 4951 219 320 4946 BUF_X1
* cell instance $14038 r0 *1 236.17,103.6
X$14038 4865 219 320 4944 BUF_X1
* cell instance $14041 r0 *1 237.69,103.6
X$14041 4848 219 320 4943 BUF_X1
* cell instance $14042 r0 *1 238.26,103.6
X$14042 4949 219 320 4945 BUF_X1
* cell instance $14044 r0 *1 239.59,103.6
X$14044 4839 219 320 4843 BUF_X1
* cell instance $14045 r0 *1 240.16,103.6
X$14045 4950 219 320 4749 BUF_X1
* cell instance $14050 m0 *1 9.12,168
X$14050 219 12600 9031 9083 8680 320 DFF_X1
* cell instance $14051 m0 *1 12.35,168
X$14051 9031 7014 8548 219 320 9083 MUX2_X1
* cell instance $14057 r0 *1 5.51,168
X$14057 9195 219 320 8786 BUF_X1
* cell instance $14063 r0 *1 8.36,168
X$14063 9344 219 320 8682 CLKBUF_X2
* cell instance $14069 r0 *1 15.01,168
X$14069 8786 219 320 8548 BUF_X2
* cell instance $14070 r0 *1 15.77,168
X$14070 8786 7177 9136 219 320 9196 MUX2_X1
* cell instance $14071 m0 *1 16.53,168
X$14071 219 12618 8909 8907 8680 320 DFF_X1
* cell instance $14076 r0 *1 18.62,168
X$14076 219 14469 9087 9198 9135 320 DFF_X1
* cell instance $14078 m0 *1 20.9,168
X$14078 9136 8908 9087 219 320 8968 MUX2_X1
* cell instance $14080 r0 *1 21.85,168
X$14080 8548 6853 9087 219 320 9198 MUX2_X1
* cell instance $14082 r0 *1 23.37,168
X$14082 219 14466 8912 9199 9401 320 DFF_X1
* cell instance $14084 m0 *1 24.13,168
X$14084 8548 6974 8912 219 320 9199 MUX2_X1
* cell instance $14085 m0 *1 26.03,168
X$14085 219 12595 8915 9032 8441 320 DFF_X1
* cell instance $14087 m0 *1 29.26,168
X$14087 8912 8799 8915 219 320 9034 MUX2_X1
* cell instance $14091 r0 *1 26.79,168
X$14091 219 14512 8914 9200 8441 320 DFF_X1
* cell instance $14093 r0 *1 30.21,168
X$14093 9033 8920 9034 219 320 8917 MUX2_X1
* cell instance $14096 m0 *1 31.73,168
X$14096 8918 8919 9035 320 219 8576 MUX2_X2
* cell instance $14099 r0 *1 33.44,168
X$14099 8682 219 320 8552 BUF_X2
* cell instance $14100 r0 *1 34.2,168
X$14100 8682 6156 9139 219 320 9138 MUX2_X1
* cell instance $14102 m0 *1 35.34,168
X$14102 9037 5801 8552 219 320 9036 MUX2_X1
* cell instance $14105 m0 *1 39.14,168
X$14105 9092 8860 8974 219 320 9094 MUX2_X1
* cell instance $14107 m0 *1 41.23,168
X$14107 9095 8927 9094 219 320 9097 MUX2_X1
* cell instance $14108 m0 *1 42.56,168
X$14108 4765 320 8792 219 BUF_X4
* cell instance $14109 m0 *1 43.89,168
X$14109 9097 8921 9035 320 219 8660 MUX2_X2
* cell instance $14111 m0 *1 45.79,168
X$14111 219 12692 8922 8981 8554 320 DFF_X1
* cell instance $14113 m0 *1 49.21,168
X$14113 8798 6002 9039 219 320 9206 MUX2_X1
* cell instance $14115 r0 *1 35.53,168
X$14115 219 14213 9037 9036 8554 320 DFF_X1
* cell instance $14116 r0 *1 38.76,168
X$14116 9037 9287 9139 219 320 9092 MUX2_X1
* cell instance $14120 r0 *1 42.56,168
X$14120 9140 8913 9038 219 320 8975 MUX2_X1
* cell instance $14122 r0 *1 44.27,168
X$14122 8552 5930 9038 219 320 9204 MUX2_X1
* cell instance $14123 r0 *1 45.6,168
X$14123 4765 320 9207 219 BUF_X4
* cell instance $14124 r0 *1 46.93,168
X$14124 9030 219 320 8798 BUF_X1
* cell instance $14126 r0 *1 48.26,168
X$14126 219 14208 9039 9206 9205 320 DFF_X1
* cell instance $14128 m0 *1 50.92,168
X$14128 9039 9101 8922 219 320 8923 MUX2_X1
* cell instance $14129 r0 *1 51.49,168
X$14129 4702 320 8913 219 BUF_X4
* cell instance $14130 m0 *1 52.82,168
X$14130 4702 320 8788 219 BUF_X4
* cell instance $14132 m0 *1 54.15,168
X$14132 219 13073 9208 9141 8446 320 DFF_X1
* cell instance $14138 r0 *1 53.01,168
X$14138 4702 320 9101 219 BUF_X4
* cell instance $14140 r0 *1 54.53,168
X$14140 9208 5801 8556 219 320 9141 MUX2_X1
* cell instance $14142 r0 *1 56.05,168
X$14142 8798 6156 9142 219 320 9209 MUX2_X1
* cell instance $14144 r0 *1 57.76,168
X$14144 9208 8908 9142 219 320 9040 MUX2_X1
* cell instance $14147 r0 *1 62.89,168
X$14147 219 14041 9211 9210 8804 320 DFF_X1
* cell instance $14152 m0 *1 68.59,168
X$14152 6337 320 8867 219 BUF_X4
* cell instance $14155 m0 *1 70.68,168
X$14155 8984 6110 8556 219 320 8925 MUX2_X1
* cell instance $14157 m0 *1 72.77,168
X$14157 8984 8913 8806 219 320 8985 MUX2_X1
* cell instance $14158 m0 *1 74.1,168
X$14158 8449 219 320 CLKBUF_X1
* cell instance $14163 r0 *1 69.16,168
X$14163 219 13965 9356 9212 8449 320 DFF_X1
* cell instance $14168 r0 *1 78.09,168
X$14168 219 13971 9217 9216 9295 320 DFF_X1
* cell instance $14172 m0 *1 87.97,168
X$14172 6337 320 4992 219 BUF_X4
* cell instance $14176 r0 *1 90.06,168
X$14176 8926 219 320 8809 CLKBUF_X3
* cell instance $14178 m0 *1 91.39,168
X$14178 8559 7091 8929 219 320 9107 MUX2_X1
* cell instance $14181 m0 *1 92.91,168
X$14181 219 13268 8929 9107 8992 320 DFF_X1
* cell instance $14184 r0 *1 94.24,168
X$14184 2750 4450 219 320 9232 OR2_X1
* cell instance $14185 r0 *1 95,168
X$14185 219 4450 9234 9488 9108 3922 320 AOI22_X4
* cell instance $14187 m0 *1 96.52,168
X$14187 9147 4997 219 320 9108 NOR2_X2
* cell instance $14189 m0 *1 97.85,168
X$14189 8811 7490 9109 219 320 9110 MUX2_X1
* cell instance $14190 r0 *1 98.23,168
X$14190 9147 2750 219 320 9234 NOR2_X1
* cell instance $14193 m0 *1 99.75,168
X$14193 219 13239 9109 9110 8992 320 DFF_X1
* cell instance $14199 r0 *1 100.13,168
X$14199 8697 219 320 8992 CLKBUF_X3
* cell instance $14201 r0 *1 101.84,168
X$14201 2750 9238 219 320 9237 OR2_X1
* cell instance $14203 r0 *1 102.79,168
X$14203 9238 9151 2750 320 219 6442 MUX2_X2
* cell instance $14205 m0 *1 105.83,168
X$14205 8559 7026 9111 219 320 9041 MUX2_X1
* cell instance $14209 r0 *1 106.02,168
X$14209 219 13831 9111 9041 9242 320 DFF_X1
* cell instance $14211 m0 *1 109.06,168
X$14211 219 13608 8998 8997 9421 320 DFF_X1
* cell instance $14212 m0 *1 112.48,168
X$14212 8999 8166 8817 219 320 9243 MUX2_X1
* cell instance $14214 m0 *1 114,168
X$14214 219 13600 8816 8815 8456 320 DFF_X1
* cell instance $14216 m0 *1 117.42,168
X$14216 8932 8121 9042 219 320 9112 MUX2_X1
* cell instance $14221 r0 *1 111.72,168
X$14221 219 13808 8817 9243 8456 320 DFF_X1
* cell instance $14224 r0 *1 117.23,168
X$14224 219 13809 9042 9112 8819 320 DFF_X1
* cell instance $14229 m0 *1 119.13,168
X$14229 219 13618 9004 9003 8819 320 DFF_X1
* cell instance $14230 m0 *1 122.55,168
X$14230 9152 7723 9153 219 320 9043 MUX2_X1
* cell instance $14233 r0 *1 120.65,168
X$14233 219 14043 9153 9246 8819 320 DFF_X1
* cell instance $14234 r0 *1 123.88,168
X$14234 7607 9043 219 320 9044 OR2_X1
* cell instance $14235 m0 *1 124.45,168
X$14235 9044 7606 9006 320 219 9005 OAI21_X4
* cell instance $14239 m0 *1 127.87,168
X$14239 219 13263 8933 9116 9045 320 DFF_X1
* cell instance $14245 r0 *1 125.78,168
X$14245 8820 9154 9155 219 320 9115 MUX2_X1
* cell instance $14246 r0 *1 127.11,168
X$14246 219 14549 9155 9115 9045 320 DFF_X1
* cell instance $14247 r0 *1 130.34,168
X$14247 8820 8699 8933 219 320 9116 MUX2_X1
* cell instance $14249 m0 *1 131.48,168
X$14249 9119 7606 9008 320 219 8942 OAI21_X4
* cell instance $14250 r0 *1 131.67,168
X$14250 8284 9250 219 320 9119 OR2_X1
* cell instance $14252 r0 *1 133.19,168
X$14252 8752 9154 9158 219 320 9249 MUX2_X1
* cell instance $14253 m0 *1 135.66,168
X$14253 219 12640 9120 9122 9046 320 DFF_X1
* cell instance $14254 m0 *1 134.33,168
X$14254 8752 9157 9120 219 320 9122 MUX2_X1
* cell instance $14255 m0 *1 138.89,168
X$14255 9123 4136 9254 219 320 8286 MUX2_X1
* cell instance $14258 m0 *1 141.17,168
X$14258 8576 219 320 9047 INV_X1
* cell instance $14262 r0 *1 134.52,168
X$14262 219 14448 9123 9252 9046 320 DFF_X1
* cell instance $14263 r0 *1 137.75,168
X$14263 219 14408 9254 9253 9046 320 DFF_X1
* cell instance $14264 r0 *1 140.98,168
X$14264 7450 9047 9159 320 219 9258 HA_X1
* cell instance $14265 r0 *1 142.88,168
X$14265 9258 219 320 9160 INV_X1
* cell instance $14268 m0 *1 148.77,168
X$14268 9019 9125 219 320 9124 OR2_X2
* cell instance $14272 r0 *1 149.91,168
X$14272 8659 9049 9166 320 219 9264 HA_X1
* cell instance $14273 m0 *1 151.05,168
X$14273 9126 9019 9128 320 219 9017 OAI21_X2
* cell instance $14276 r0 *1 151.81,168
X$14276 9048 219 320 9265 INV_X1
* cell instance $14277 r0 *1 152.19,168
X$14277 9048 219 320 8746 BUF_X1
* cell instance $14278 r0 *1 152.76,168
X$14278 8523 8043 9313 320 219 9169 HA_X1
* cell instance $14280 m0 *1 152.76,168
X$14280 8942 219 320 9049 INV_X1
* cell instance $14283 m0 *1 154.28,168
X$14283 9005 219 320 8588 BUF_X1
* cell instance $14284 m0 *1 155.04,168
X$14284 8830 8934 9021 219 9126 320 AOI21_X1
* cell instance $14285 m0 *1 155.8,168
X$14285 8935 219 320 9133 INV_X1
* cell instance $14287 m0 *1 156.37,168
X$14287 9133 8937 9134 320 9021 219 OAI21_X1
* cell instance $14289 m0 *1 157.89,168
X$14289 9060 219 320 9022 INV_X1
* cell instance $14293 r0 *1 155.8,168
X$14293 9050 219 320 8936 INV_X1
* cell instance $14296 r0 *1 157.89,168
X$14296 9272 219 320 9171 INV_X2
* cell instance $14298 m0 *1 158.84,168
X$14298 8938 219 320 9134 INV_X1
* cell instance $14306 m0 *1 163.59,168
X$14306 7700 9051 320 9029 219 AND2_X4
* cell instance $14307 m0 *1 165.3,168
X$14307 9132 9130 9129 9027 9029 9052 219 320 OAI221_X2
* cell instance $14308 m0 *1 167.39,168
X$14308 8896 9130 219 9129 320 NAND2_X4
* cell instance $14309 m0 *1 169.1,168
X$14309 9127 8940 8941 219 9056 320 AOI21_X1
* cell instance $14310 m0 *1 169.86,168
X$14310 8708 219 320 9026 BUF_X1
* cell instance $14313 m0 *1 173.66,168
X$14313 8123 9049 7406 3734 219 320 8943 AOI22_X1
* cell instance $14315 m0 *1 175.37,168
X$14315 4767 219 320 9057 INV_X1
* cell instance $14316 m0 *1 175.75,168
X$14316 5901 8944 8943 9057 3609 320 219 9283 OAI221_X1
* cell instance $14318 m0 *1 177.08,168
X$14318 4767 7628 8945 3734 7949 9059 320 219 AOI221_X2
* cell instance $14319 m0 *1 179.17,168
X$14319 8576 5793 219 320 9285 NAND2_X1
* cell instance $14320 m0 *1 179.74,168
X$14320 8001 320 4458 219 BUF_X4
* cell instance $14321 m0 *1 181.07,168
X$14321 3734 6951 9117 4767 7151 9061 320 219 AOI221_X2
* cell instance $14324 m0 *1 185.44,168
X$14324 8479 6833 219 320 9182 NAND2_X1
* cell instance $14329 r0 *1 163.97,168
X$14329 9051 2761 7907 9131 320 219 9173 AND4_X1
* cell instance $14331 r0 *1 165.3,168
X$14331 7700 9054 219 320 9319 NAND2_X1
* cell instance $14332 r0 *1 165.87,168
X$14332 9053 7700 219 320 9131 NAND2_X1
* cell instance $14333 r0 *1 166.44,168
X$14333 9054 9055 9276 219 320 9053 NAND3_X1
* cell instance $14334 r0 *1 167.2,168
X$14334 8896 9051 219 320 9127 NAND2_X1
* cell instance $14336 r0 *1 167.96,168
X$14336 9175 9056 7700 320 9278 219 OAI21_X1
* cell instance $14337 r0 *1 168.72,168
X$14337 7838 769 219 320 9176 NOR2_X1
* cell instance $14343 r0 *1 175.75,168
X$14343 8363 2814 219 320 9121 NAND2_X1
* cell instance $14345 r0 *1 176.51,168
X$14345 219 9284 9058 9121 9059 320 AOI21_X4
* cell instance $14346 r0 *1 178.98,168
X$14346 9058 9285 8542 219 9118 320 AOI21_X2
* cell instance $14348 r0 *1 180.5,168
X$14348 9060 6833 219 320 9282 NAND2_X1
* cell instance $14349 r0 *1 181.07,168
X$14349 8363 2813 219 320 9114 NAND2_X1
* cell instance $14350 r0 *1 181.64,168
X$14350 219 9281 7148 9114 9061 320 AOI21_X4
* cell instance $14353 r0 *1 185.06,168
X$14353 219 9279 7148 9182 9062 320 AOI21_X4
* cell instance $14354 r0 *1 187.53,168
X$14354 9050 6833 219 320 9273 NAND2_X1
* cell instance $14355 r0 *1 188.1,168
X$14355 9050 2814 219 320 9113 NAND2_X1
* cell instance $14357 m0 *1 188.67,168
X$14357 9001 5537 219 320 9100 NOR2_X2
* cell instance $14359 r0 *1 189.05,168
X$14359 9058 9113 9370 219 8725 320 AOI21_X2
* cell instance $14360 m0 *1 190.19,168
X$14360 8660 2814 219 320 9063 NAND2_X1
* cell instance $14363 r0 *1 190.38,168
X$14363 9058 9063 9268 219 9228 320 AOI21_X2
* cell instance $14364 m0 *1 193.23,168
X$14364 8595 219 320 7849 INV_X2
* cell instance $14365 m0 *1 191.14,168
X$14365 8746 8421 8995 8836 7949 9268 320 219 AOI221_X2
* cell instance $14368 m0 *1 194.75,168
X$14368 7740 3812 9064 7102 219 320 8990 AOI22_X2
* cell instance $14370 m0 *1 196.65,168
X$14370 4586 8991 9065 8948 3787 320 219 8949 OAI221_X1
* cell instance $14373 r0 *1 192.47,168
X$14373 6835 693 2967 7628 219 320 9260 AOI22_X2
* cell instance $14374 r0 *1 194.18,168
X$14374 7782 5837 7952 4523 9260 9485 219 320 OAI221_X2
* cell instance $14375 r0 *1 196.27,168
X$14375 7314 3812 8220 9064 219 320 9065 AOI22_X1
* cell instance $14376 r0 *1 197.22,168
X$14376 7849 3812 7944 9064 219 320 9255 AOI22_X1
* cell instance $14378 m0 *1 198.17,168
X$14378 8950 5570 219 320 9072 NOR2_X2
* cell instance $14379 m0 *1 199.88,168
X$14379 8987 219 320 9066 CLKBUF_X3
* cell instance $14380 m0 *1 200.83,168
X$14380 4015 9066 4016 320 9068 219 NOR3_X2
* cell instance $14382 m0 *1 202.35,168
X$14382 8523 7542 9106 320 219 9071 HA_X1
* cell instance $14384 m0 *1 204.44,168
X$14384 8947 219 320 9241 INV_X1
* cell instance $14386 m0 *1 205.01,168
X$14386 8491 8946 9073 320 219 9074 HA_X1
* cell instance $14387 m0 *1 206.91,168
X$14387 8470 8186 9104 320 219 9075 HA_X1
* cell instance $14389 m0 *1 209,168
X$14389 9104 219 320 9103 INV_X1
* cell instance $14391 m0 *1 210.14,168
X$14391 9102 219 320 9098 INV_X1
* cell instance $14393 r0 *1 198.17,168
X$14393 8949 6870 8114 219 9247 320 AOI21_X1
* cell instance $14395 r0 *1 199.69,168
X$14395 4014 8951 3812 320 8718 219 NOR3_X2
* cell instance $14396 r0 *1 201.02,168
X$14396 4014 8951 4016 320 9069 219 NOR3_X2
* cell instance $14398 r0 *1 202.73,168
X$14398 9071 9106 9240 219 9070 320 AOI21_X2
* cell instance $14399 r0 *1 204.06,168
X$14399 8832 9241 9244 320 219 9240 HA_X1
* cell instance $14401 r0 *1 206.72,168
X$14401 9074 9186 9073 219 320 9105 NOR3_X1
* cell instance $14403 r0 *1 207.67,168
X$14403 9074 9186 9075 219 320 9235 NOR3_X1
* cell instance $14405 r0 *1 208.62,168
X$14405 9103 9099 9235 320 9187 219 OAI21_X1
* cell instance $14407 r0 *1 209.57,168
X$14407 8518 8482 9188 320 219 9226 HA_X1
* cell instance $14409 m0 *1 210.9,168
X$14409 8709 8835 9102 320 219 8952 HA_X1
* cell instance $14411 r0 *1 211.47,168
X$14411 9226 9188 9221 219 9099 320 AOI21_X1
* cell instance $14412 r0 *1 212.23,168
X$14412 8952 219 320 9220 INV_X1
* cell instance $14414 r0 *1 214.13,168
X$14414 219 14117 9096 9218 8953 320 DFF_X1
* cell instance $14416 m0 *1 214.7,168
X$14416 219 12878 8977 8980 8953 320 DFF_X1
* cell instance $14417 m0 *1 218.12,168
X$14417 9093 8954 5640 320 219 8947 MUX2_X2
* cell instance $14419 m0 *1 220.02,168
X$14419 8979 7751 8978 219 320 9076 MUX2_X1
* cell instance $14424 r0 *1 217.93,168
X$14424 8839 7539 8977 219 320 9093 MUX2_X1
* cell instance $14426 r0 *1 219.64,168
X$14426 219 14185 8978 9076 9077 320 DFF_X1
* cell instance $14427 r0 *1 222.87,168
X$14427 9189 7750 9090 219 320 9091 MUX2_X1
* cell instance $14429 m0 *1 223.25,168
X$14429 219 12730 9090 9091 9077 320 DFF_X1
* cell instance $14430 m0 *1 226.67,168
X$14430 6410 8973 219 320 9089 OR2_X1
* cell instance $14433 r0 *1 224.39,168
X$14433 9089 7957 8956 320 219 8186 OAI21_X4
* cell instance $14435 r0 *1 227.05,168
X$14435 9189 7749 8957 219 320 9190 MUX2_X1
* cell instance $14436 m0 *1 228,168
X$14436 9189 7753 8958 219 320 9078 MUX2_X1
* cell instance $14440 r0 *1 228.57,168
X$14440 219 13653 8958 9078 8844 320 DFF_X1
* cell instance $14441 m0 *1 229.9,168
X$14441 219 12781 8959 9088 8501 320 DFF_X1
* cell instance $14447 r0 *1 231.8,168
X$14447 8961 7166 8959 219 320 9088 MUX2_X1
* cell instance $14448 r0 *1 233.13,168
X$14448 9191 7957 9079 320 219 8835 OAI21_X4
* cell instance $14449 m0 *1 234.08,168
X$14449 219 9340 8503 320 BUF_X16
* cell instance $14450 m0 *1 233.51,168
X$14450 8501 219 320 CLKBUF_X1
* cell instance $14451 m0 *1 238.83,168
X$14451 8961 7165 9084 219 320 9197 MUX2_X1
* cell instance $14452 m0 *1 240.16,168
X$14452 8756 219 320 8613 BUF_X1
* cell instance $14454 r0 *1 235.6,168
X$14454 8962 8503 9084 219 320 9201 MUX2_X1
* cell instance $14455 r0 *1 236.93,168
X$14455 7769 219 320 8845 BUF_X1
* cell instance $14456 r0 *1 237.5,168
X$14456 219 13783 9084 9197 8844 320 DFF_X1
* cell instance $14462 m0 *1 10.64,145.6
X$14462 219 13253 7480 7536 7427 320 DFF_X1
* cell instance $14472 r0 *1 8.17,145.6
X$14472 7578 7232 7577 219 320 7647 MUX2_X1
* cell instance $14473 r0 *1 9.5,145.6
X$14473 219 14619 7577 7647 7427 320 DFF_X1
* cell instance $14476 r0 *1 13.87,145.6
X$14476 7578 7348 7580 219 320 7579 MUX2_X1
* cell instance $14477 m0 *1 14.44,145.6
X$14477 7480 7482 7577 219 320 7648 MUX2_X1
* cell instance $14479 m0 *1 15.77,145.6
X$14479 219 13603 7481 7538 7427 320 DFF_X1
* cell instance $14481 m0 *1 19.19,145.6
X$14481 7346 7482 7347 219 320 7483 MUX2_X1
* cell instance $14483 m0 *1 23.56,145.6
X$14483 219 13258 7484 7652 7299 320 DFF_X1
* cell instance $14485 m0 *1 26.98,145.6
X$14485 7172 219 320 7299 CLKBUF_X3
* cell instance $14486 m0 *1 27.93,145.6
X$14486 7299 219 320 14753 INV_X1
* cell instance $14490 m0 *1 32.3,145.6
X$14490 6606 219 320 7236 CLKBUF_X3
* cell instance $14494 r0 *1 15.39,145.6
X$14494 7172 219 320 7427 CLKBUF_X3
* cell instance $14495 r0 *1 16.34,145.6
X$14495 7427 219 320 14776 INV_X1
* cell instance $14498 r0 *1 17.29,145.6
X$14498 7481 7482 7580 219 320 7650 MUX2_X1
* cell instance $14501 r0 *1 19.57,145.6
X$14501 7648 1639 7650 219 320 7651 MUX2_X1
* cell instance $14504 r0 *1 23.18,145.6
X$14504 7484 6909 7345 219 320 7652 MUX2_X1
* cell instance $14505 r0 *1 24.51,145.6
X$14505 7345 7082 7581 219 320 7653 MUX2_X1
* cell instance $14506 r0 *1 25.84,145.6
X$14506 219 13986 7581 7653 7299 320 DFF_X1
* cell instance $14508 r0 *1 30.59,145.6
X$14508 219 13996 7543 7654 7299 320 DFF_X1
* cell instance $14509 r0 *1 33.82,145.6
X$14509 7543 6207 7350 219 320 7654 MUX2_X1
* cell instance $14511 m0 *1 34.39,145.6
X$14511 7543 7582 7125 219 320 7544 MUX2_X1
* cell instance $14513 m0 *1 36.67,145.6
X$14513 7544 2752 7485 219 320 7549 MUX2_X1
* cell instance $14516 m0 *1 44.27,145.6
X$14516 7656 2752 7659 219 320 7547 MUX2_X1
* cell instance $14522 r0 *1 38.95,145.6
X$14522 7583 6110 7350 219 320 7763 MUX2_X1
* cell instance $14523 r0 *1 40.28,145.6
X$14523 7762 2752 7486 219 320 7658 MUX2_X1
* cell instance $14526 r0 *1 42.56,145.6
X$14526 7350 6270 7585 219 320 7584 MUX2_X1
* cell instance $14527 r0 *1 43.89,145.6
X$14527 7657 7582 7585 219 320 7659 MUX2_X1
* cell instance $14528 r0 *1 45.22,145.6
X$14528 7658 5517 7586 219 320 7661 MUX2_X1
* cell instance $14529 r0 *1 46.55,145.6
X$14529 7547 5517 7549 219 320 7712 MUX2_X1
* cell instance $14530 r0 *1 47.88,145.6
X$14530 7017 6156 7488 219 320 7662 MUX2_X1
* cell instance $14532 m0 *1 48.26,145.6
X$14532 219 13473 7488 7662 7487 320 DFF_X1
* cell instance $14533 m0 *1 52.25,145.6
X$14533 7017 219 320 7489 BUF_X2
* cell instance $14534 m0 *1 53.01,145.6
X$14534 7489 6042 7588 219 320 7551 MUX2_X1
* cell instance $14535 m0 *1 54.34,145.6
X$14535 219 13519 7588 7551 7240 320 DFF_X1
* cell instance $14538 m0 *1 59.85,145.6
X$14538 7024 7490 7355 219 320 7437 MUX2_X1
* cell instance $14540 m0 *1 61.37,145.6
X$14540 3990 320 7490 219 BUF_X4
* cell instance $14541 m0 *1 62.7,145.6
X$14541 7354 7492 6612 219 320 7589 MUX2_X1
* cell instance $14543 m0 *1 64.22,145.6
X$14543 219 12689 7357 7491 6914 320 DFF_X1
* cell instance $14545 m0 *1 67.64,145.6
X$14545 7553 320 4277 219 BUF_X4
* cell instance $14547 m0 *1 69.16,145.6
X$14547 7494 7361 219 320 7493 NAND2_X1
* cell instance $14548 m0 *1 69.73,145.6
X$14548 7443 7250 219 320 7247 NAND2_X1
* cell instance $14549 m0 *1 70.3,145.6
X$14549 7494 7250 219 320 7553 NAND2_X1
* cell instance $14550 m0 *1 70.87,145.6
X$14550 7494 7360 219 320 7358 NAND2_X1
* cell instance $14552 m0 *1 71.63,145.6
X$14552 7495 7556 12533 320 219 7360 HA_X1
* cell instance $14553 m0 *1 73.53,145.6
X$14553 7593 7364 219 320 7362 NOR2_X1
* cell instance $14554 m0 *1 74.1,145.6
X$14554 7593 7367 7591 320 7443 219 NOR3_X2
* cell instance $14555 m0 *1 75.43,145.6
X$14555 7364 7557 7368 219 320 7245 NOR3_X1
* cell instance $14557 r0 *1 49.21,145.6
X$14557 219 13950 7587 7766 7240 320 DFF_X1
* cell instance $14558 r0 *1 52.44,145.6
X$14558 7587 7582 7488 219 320 7768 MUX2_X1
* cell instance $14561 r0 *1 54.91,145.6
X$14561 7588 7582 7434 219 320 7770 MUX2_X1
* cell instance $14565 r0 *1 62.89,145.6
X$14565 219 13897 7354 7589 7023 320 DFF_X1
* cell instance $14573 r0 *1 68.97,145.6
X$14573 5120 219 320 7582 CLKBUF_X3
* cell instance $14576 r0 *1 71.63,145.6
X$14576 7592 7590 12536 320 219 7361 HA_X1
* cell instance $14577 r0 *1 73.53,145.6
X$14577 7592 7556 7713 320 219 7595 HA_X1
* cell instance $14579 r0 *1 75.81,145.6
X$14579 7367 7596 219 320 7364 NAND2_X1
* cell instance $14580 r0 *1 76.38,145.6
X$14580 7594 7597 219 320 7365 NAND2_X1
* cell instance $14581 m0 *1 77.52,145.6
X$14581 7594 7595 7368 219 320 7366 NAND3_X1
* cell instance $14582 m0 *1 76.57,145.6
X$14582 7497 219 320 6373 CLKBUF_X3
* cell instance $14583 m0 *1 78.28,145.6
X$14583 219 13105 7496 7559 7254 320 DFF_X1
* cell instance $14584 m0 *1 81.51,145.6
X$14584 7252 7243 7369 219 320 7670 MUX2_X1
* cell instance $14585 m0 *1 82.84,145.6
X$14585 219 13118 7369 7670 7254 320 DFF_X1
* cell instance $14588 m0 *1 90.63,145.6
X$14588 7379 7091 7560 219 320 7672 MUX2_X1
* cell instance $14589 m0 *1 91.96,145.6
X$14589 7780 3766 7560 219 320 7561 MUX2_X1
* cell instance $14592 m0 *1 97.85,145.6
X$14592 7498 4367 6277 219 320 7564 NOR3_X1
* cell instance $14595 r0 *1 76.95,145.6
X$14595 7594 7595 219 320 7557 NAND2_X1
* cell instance $14596 r0 *1 77.52,145.6
X$14596 7594 7368 219 320 7593 NAND2_X1
* cell instance $14597 r0 *1 78.09,145.6
X$14597 7368 219 320 7597 INV_X1
* cell instance $14600 r0 *1 81.89,145.6
X$14600 7252 7490 7598 219 320 7669 MUX2_X1
* cell instance $14601 r0 *1 83.22,145.6
X$14601 6373 219 320 7254 CLKBUF_X3
* cell instance $14603 r0 *1 84.93,145.6
X$14603 7598 5350 7777 219 320 7599 MUX2_X1
* cell instance $14606 r0 *1 89.68,145.6
X$14606 219 13689 7560 7672 6919 320 DFF_X1
* cell instance $14610 r0 *1 97.09,145.6
X$14610 7379 6710 7717 219 320 7674 MUX2_X1
* cell instance $14611 r0 *1 98.42,145.6
X$14611 219 14344 7377 7675 7378 320 DFF_X1
* cell instance $14612 m0 *1 99.94,145.6
X$14612 219 13006 7456 7499 7378 320 DFF_X1
* cell instance $14614 m0 *1 103.17,145.6
X$14614 7456 6662 7379 219 320 7499 MUX2_X1
* cell instance $14615 m0 *1 104.5,145.6
X$14615 5517 320 6337 219 BUF_X4
* cell instance $14617 m0 *1 106.02,145.6
X$14617 7379 7025 7500 219 320 7567 MUX2_X1
* cell instance $14619 m0 *1 107.54,145.6
X$14619 7500 6057 7459 219 320 7460 MUX2_X1
* cell instance $14624 r0 *1 101.65,145.6
X$14624 7377 6856 7379 219 320 7675 MUX2_X1
* cell instance $14627 r0 *1 104.12,145.6
X$14627 6284 219 320 7378 CLKBUF_X3
* cell instance $14631 r0 *1 106.4,145.6
X$14631 219 13656 7718 7600 7378 320 DFF_X1
* cell instance $14634 r0 *1 111.91,145.6
X$14634 219 13701 7602 7601 7262 320 DFF_X1
* cell instance $14635 m0 *1 114.76,145.6
X$14635 6284 219 320 7262 CLKBUF_X3
* cell instance $14637 m0 *1 115.71,145.6
X$14637 7262 219 320 14739 INV_X1
* cell instance $14639 r0 *1 115.14,145.6
X$14639 7720 3238 219 320 7601 NOR2_X1
* cell instance $14641 r0 *1 116.09,145.6
X$14641 7787 3238 219 320 7681 NOR2_X1
* cell instance $14642 m0 *1 116.66,145.6
X$14642 219 12970 7570 7681 7262 320 DFF_X1
* cell instance $14646 r0 *1 116.66,145.6
X$14646 219 13690 7682 7681 7262 320 DFF_X1
* cell instance $14651 r0 *1 120.65,145.6
X$14651 219 14047 7721 7788 7037 320 DFF_X1
* cell instance $14655 r0 *1 125.21,145.6
X$14655 7603 7606 7604 320 219 7605 OAI21_X4
* cell instance $14657 m0 *1 126.35,145.6
X$14657 7337 7501 7381 219 320 7604 MUX2_X1
* cell instance $14659 m0 *1 128.63,145.6
X$14659 6925 219 320 CLKBUF_X1
* cell instance $14663 r0 *1 128.44,145.6
X$14663 7607 7685 219 320 7686 OR2_X1
* cell instance $14664 r0 *1 129.2,145.6
X$14664 7686 7606 7687 320 219 7405 OAI21_X4
* cell instance $14665 m0 *1 130.53,145.6
X$14665 7607 219 320 3605 CLKBUF_X3
* cell instance $14667 m0 *1 131.48,145.6
X$14667 7266 6622 7574 219 320 7608 MUX2_X1
* cell instance $14670 r0 *1 132.43,145.6
X$14670 219 13693 7574 7608 7384 320 DFF_X1
* cell instance $14672 m0 *1 133.19,145.6
X$14672 7266 6719 7385 219 320 7572 MUX2_X1
* cell instance $14673 m0 *1 135.28,145.6
X$14673 7574 7501 7385 219 320 7725 MUX2_X1
* cell instance $14676 r0 *1 135.66,145.6
X$14676 219 7606 4383 320 BUF_X16
* cell instance $14677 m0 *1 147.06,145.6
X$14677 219 13231 7692 7613 7268 320 DFF_X1
* cell instance $14678 m0 *1 137.75,145.6
X$14678 219 6928 7610 320 BUF_X32
* cell instance $14679 m0 *1 150.29,145.6
X$14679 4382 7693 219 320 7393 OR2_X1
* cell instance $14682 m0 *1 153.33,145.6
X$14682 7440 6939 7695 320 219 7616 HA_X1
* cell instance $14687 m0 *1 160.74,145.6
X$14687 7504 7697 7571 219 7618 320 AOI21_X1
* cell instance $14688 m0 *1 161.5,145.6
X$14688 7503 219 320 7698 INV_X1
* cell instance $14691 m0 *1 163.59,145.6
X$14691 4135 320 3347 219 BUF_X4
* cell instance $14692 m0 *1 164.92,145.6
X$14692 4135 320 4511 219 BUF_X4
* cell instance $14693 m0 *1 166.25,145.6
X$14693 7440 1025 7569 320 219 7507 HA_X1
* cell instance $14694 m0 *1 168.15,145.6
X$14694 7506 7509 7510 320 7508 219 OAI21_X1
* cell instance $14695 m0 *1 168.91,145.6
X$14695 7699 219 320 7510 BUF_X1
* cell instance $14697 m0 *1 169.67,145.6
X$14697 7565 7402 7568 7566 7512 7620 320 219 AOI221_X2
* cell instance $14698 m0 *1 171.76,145.6
X$14698 7731 219 320 7513 BUF_X1
* cell instance $14699 m0 *1 172.33,145.6
X$14699 7515 7621 7514 320 7565 219 OAI21_X1
* cell instance $14701 m0 *1 173.28,145.6
X$14701 6020 7688 3503 7521 320 219 7563 OAI22_X1
* cell instance $14702 m0 *1 174.23,145.6
X$14702 1460 219 320 7516 BUF_X1
* cell instance $14703 m0 *1 174.8,145.6
X$14703 1363 219 320 7689 BUF_X1
* cell instance $14705 m0 *1 175.56,145.6
X$14705 7563 7562 219 320 7466 NOR2_X1
* cell instance $14706 m0 *1 176.13,145.6
X$14706 3382 7517 3271 4018 320 219 7562 OAI22_X1
* cell instance $14707 m0 *1 177.08,145.6
X$14707 7518 219 320 7515 INV_X1
* cell instance $14708 m0 *1 177.46,145.6
X$14708 5898 7517 7520 7521 3650 320 219 7523 OAI221_X1
* cell instance $14709 m0 *1 178.6,145.6
X$14709 4193 3205 3457 7683 320 219 7623 OAI22_X1
* cell instance $14711 m0 *1 180.31,145.6
X$14711 7524 7679 7558 7408 6949 7678 320 219 AOI221_X2
* cell instance $14712 m0 *1 182.4,145.6
X$14712 7737 7408 7740 7524 219 320 7555 AOI22_X1
* cell instance $14713 m0 *1 183.35,145.6
X$14713 6538 7405 7555 7554 3698 320 219 7626 OAI221_X1
* cell instance $14714 m0 *1 184.49,145.6
X$14714 7403 219 320 7554 BUF_X1
* cell instance $14718 r0 *1 141.55,145.6
X$14718 7609 7691 7388 219 320 7793 MUX2_X1
* cell instance $14720 r0 *1 143.26,145.6
X$14720 7609 7612 7573 219 320 7795 MUX2_X1
* cell instance $14723 r0 *1 146.49,145.6
X$14723 7611 7691 7392 219 320 7391 MUX2_X1
* cell instance $14724 r0 *1 147.82,145.6
X$14724 7611 7612 7692 219 320 7613 MUX2_X1
* cell instance $14726 r0 *1 149.34,145.6
X$14726 7392 4584 7692 219 320 7693 MUX2_X1
* cell instance $14728 r0 *1 150.86,145.6
X$14728 7614 7605 7694 320 219 7696 HA_X1
* cell instance $14730 r0 *1 152.95,145.6
X$14730 7694 7695 320 219 7615 AND2_X2
* cell instance $14731 r0 *1 153.9,145.6
X$14731 7616 7696 7695 219 7796 320 AOI21_X1
* cell instance $14735 r0 *1 159.98,145.6
X$14735 7729 219 320 6830 INV_X1
* cell instance $14736 r0 *1 160.36,145.6
X$14736 7617 219 320 7697 BUF_X1
* cell instance $14737 r0 *1 160.93,145.6
X$14737 7698 7905 7504 7617 7571 7619 320 219 AOI221_X2
* cell instance $14738 r0 *1 163.02,145.6
X$14738 7619 320 7701 219 BUF_X4
* cell instance $14739 r0 *1 164.35,145.6
X$14739 7503 320 7797 219 BUF_X4
* cell instance $14742 r0 *1 166.63,145.6
X$14742 219 7402 7702 7699 7569 7700 320 AND4_X4
* cell instance $14743 r0 *1 169.1,145.6
X$14743 7614 7511 7699 320 219 7401 HA_X1
* cell instance $14744 r0 *1 171,145.6
X$14744 1463 6956 7731 320 219 7622 HA_X1
* cell instance $14746 r0 *1 173.09,145.6
X$14746 1363 7450 7798 320 219 7470 HA_X1
* cell instance $14751 r0 *1 175.18,145.6
X$14751 6020 7605 3503 7511 320 219 7684 OAI22_X1
* cell instance $14753 r0 *1 176.51,145.6
X$14753 7462 7688 7735 4018 320 219 7404 OAI22_X1
* cell instance $14754 r0 *1 177.46,145.6
X$14754 7624 6184 219 320 7519 NAND2_X1
* cell instance $14756 r0 *1 178.79,145.6
X$14756 7684 7623 219 320 7680 NOR2_X1
* cell instance $14757 r0 *1 179.36,145.6
X$14757 3205 219 320 7736 INV_X2
* cell instance $14758 r0 *1 179.93,145.6
X$14758 7523 6636 7624 219 7627 320 AOI21_X1
* cell instance $14759 r0 *1 180.69,145.6
X$14759 4018 219 320 7625 INV_X1
* cell instance $14761 r0 *1 184.11,145.6
X$14761 7676 6184 219 320 7677 NAND2_X1
* cell instance $14762 r0 *1 184.68,145.6
X$14762 7676 6539 219 320 7629 NAND2_X1
* cell instance $14763 r0 *1 185.25,145.6
X$14763 7051 7629 7630 219 7632 320 AOI21_X2
* cell instance $14765 m0 *1 185.44,145.6
X$14765 7524 7628 7552 7408 6950 7673 320 219 AOI221_X2
* cell instance $14768 m0 *1 191.52,145.6
X$14768 7409 7413 219 320 7631 NAND2_X1
* cell instance $14770 m0 *1 192.85,145.6
X$14770 4567 219 320 7671 BUF_X1
* cell instance $14772 m0 *1 196.46,145.6
X$14772 7614 3205 7550 320 219 7526 HA_X1
* cell instance $14774 m0 *1 198.55,145.6
X$14774 7550 7527 219 320 7416 NAND2_X1
* cell instance $14775 m0 *1 199.12,145.6
X$14775 7416 7633 320 219 7528 AND2_X1
* cell instance $14776 m0 *1 199.88,145.6
X$14776 7548 7778 7526 219 7633 320 AOI21_X2
* cell instance $14777 m0 *1 201.21,145.6
X$14777 7633 7546 219 7666 320 NAND2_X4
* cell instance $14781 m0 *1 207.67,145.6
X$14781 7065 6861 6958 219 320 7438 MUX2_X1
* cell instance $14784 r0 *1 186.58,145.6
X$14784 7524 219 320 7455 BUF_X1
* cell instance $14788 r0 *1 191.33,145.6
X$14788 5841 320 7522 219 BUF_X4
* cell instance $14793 r0 *1 198.17,145.6
X$14793 7550 219 320 7668 BUF_X1
* cell instance $14794 r0 *1 198.74,145.6
X$14794 7441 7668 7667 7631 219 8109 320 NAND4_X2
* cell instance $14795 r0 *1 200.45,145.6
X$14795 219 7874 7666 7441 7631 320 AOI21_X4
* cell instance $14798 r0 *1 206.34,145.6
X$14798 219 14458 7744 7665 7157 320 DFF_X1
* cell instance $14801 r0 *1 211.85,145.6
X$14801 3243 7545 320 219 7634 AND2_X1
* cell instance $14802 m0 *1 212.61,145.6
X$14802 219 7529 7419 7634 7157 320 DFF_X1
* cell instance $14804 m0 *1 215.84,145.6
X$14804 7529 7664 7635 320 219 7637 HA_X1
* cell instance $14805 m0 *1 217.74,145.6
X$14805 7530 7531 219 320 7532 NAND2_X1
* cell instance $14807 m0 *1 218.5,145.6
X$14807 7532 320 4942 219 BUF_X4
* cell instance $14808 m0 *1 219.83,145.6
X$14808 4941 320 6740 219 BUF_X4
* cell instance $14811 r0 *1 212.61,145.6
X$14811 219 7664 7636 7775 7162 320 DFF_X1
* cell instance $14812 r0 *1 215.84,145.6
X$14812 7419 7664 12544 320 219 7531 HA_X1
* cell instance $14813 r0 *1 217.74,145.6
X$14813 7529 7636 12540 320 219 7663 HA_X1
* cell instance $14814 r0 *1 219.64,145.6
X$14814 7530 7663 219 320 7638 NAND2_X1
* cell instance $14815 r0 *1 220.21,145.6
X$14815 7638 320 5160 219 BUF_X4
* cell instance $14816 r0 *1 221.54,145.6
X$14816 219 14554 7541 7660 7162 320 DFF_X1
* cell instance $14817 m0 *1 225.53,145.6
X$14817 6972 219 320 5757 CLKBUF_X3
* cell instance $14818 m0 *1 222.3,145.6
X$14818 219 13311 7431 7655 7162 320 DFF_X1
* cell instance $14820 m0 *1 226.67,145.6
X$14820 219 12584 7540 7640 7292 320 DFF_X1
* cell instance $14822 m0 *1 230.66,145.6
X$14822 7539 320 3880 219 BUF_X4
* cell instance $14825 m0 *1 232.94,145.6
X$14825 219 13297 7426 7641 7292 320 DFF_X1
* cell instance $14826 m0 *1 236.17,145.6
X$14826 219 13469 7649 7537 7292 320 DFF_X1
* cell instance $14827 m0 *1 239.4,145.6
X$14827 7302 219 320 7168 BUF_X1
* cell instance $14828 m0 *1 239.97,145.6
X$14828 7421 219 320 6245 BUF_X2
* cell instance $14830 r0 *1 224.77,145.6
X$14830 7639 7753 7431 219 320 7655 MUX2_X1
* cell instance $14832 r0 *1 226.48,145.6
X$14832 7639 7750 7540 219 320 7640 MUX2_X1
* cell instance $14837 r0 *1 230.66,145.6
X$14837 4942 320 7750 219 BUF_X4
* cell instance $14842 r0 *1 232.37,145.6
X$14842 219 13680 7642 7760 7292 320 DFF_X1
* cell instance $14843 r0 *1 235.6,145.6
X$14843 5757 219 320 7292 CLKBUF_X3
* cell instance $14844 r0 *1 236.55,145.6
X$14844 7292 219 320 CLKBUF_X1
* cell instance $14846 r0 *1 237.5,145.6
X$14846 219 13915 7296 7858 7292 320 DFF_X1
* cell instance $14859 r0 *1 7.6,61.6
X$14859 2140 219 320 2308 CLKBUF_X2
* cell instance $14862 r0 *1 10.26,61.6
X$14862 2015 1547 2012 219 320 2011 MUX2_X1
* cell instance $14864 m0 *1 11.02,61.6
X$14864 219 13457 2012 2011 1733 320 DFF_X1
* cell instance $14866 m0 *1 18.05,61.6
X$14866 219 13456 2014 2013 1789 320 DFF_X1
* cell instance $14868 m0 *1 22.8,61.6
X$14868 2015 219 320 2016 BUF_X2
* cell instance $14869 m0 *1 23.56,61.6
X$14869 2017 1507 2016 219 320 2174 MUX2_X1
* cell instance $14873 r0 *1 12.35,61.6
X$14873 2015 1599 2142 219 320 2141 MUX2_X1
* cell instance $14876 r0 *1 14.82,61.6
X$14876 2012 1564 2142 219 320 2183 MUX2_X1
* cell instance $14879 r0 *1 17.86,61.6
X$14879 2015 1734 2014 219 320 2013 MUX2_X1
* cell instance $14880 r0 *1 19.19,61.6
X$14880 219 13992 2143 2175 1789 320 DFF_X1
* cell instance $14881 r0 *1 22.42,61.6
X$14881 2143 1550 2016 219 320 2175 MUX2_X1
* cell instance $14883 r0 *1 23.94,61.6
X$14883 219 13990 2017 2174 1915 320 DFF_X1
* cell instance $14884 m0 *1 30.02,61.6
X$14884 219 13442 1916 2078 1915 320 DFF_X1
* cell instance $14885 m0 *1 26.79,61.6
X$14885 219 13454 2177 2176 1915 320 DFF_X1
* cell instance $14886 m0 *1 33.25,61.6
X$14886 219 13444 2021 2020 1915 320 DFF_X1
* cell instance $14888 m0 *1 36.67,61.6
X$14888 2021 1567 2144 219 320 2080 MUX2_X1
* cell instance $14891 r0 *1 27.17,61.6
X$14891 2015 1553 2177 219 320 2176 MUX2_X1
* cell instance $14894 r0 *1 29.07,61.6
X$14894 2017 1567 2177 219 320 2178 MUX2_X1
* cell instance $14895 r0 *1 30.4,61.6
X$14895 1370 219 320 1915 CLKBUF_X3
* cell instance $14897 r0 *1 31.73,61.6
X$14897 2178 1510 2019 219 320 2182 MUX2_X1
* cell instance $14899 r0 *1 33.25,61.6
X$14899 2015 1467 2021 219 320 2020 MUX2_X1
* cell instance $14901 r0 *1 35.34,61.6
X$14901 2016 1307 2144 219 320 2213 MUX2_X1
* cell instance $14904 r0 *1 37.81,61.6
X$14904 219 14102 2278 2180 1744 320 DFF_X1
* cell instance $14905 m0 *1 40.09,61.6
X$14905 219 13443 2181 2082 1744 320 DFF_X1
* cell instance $14912 r0 *1 41.04,61.6
X$14912 2181 1469 2016 219 320 2082 MUX2_X1
* cell instance $14915 r0 *1 43.51,61.6
X$14915 2145 1835 2080 219 320 2146 MUX2_X1
* cell instance $14920 r0 *1 49.21,61.6
X$14920 2184 1562 2218 219 320 2186 MUX2_X1
* cell instance $14924 r0 *1 58.33,61.6
X$14924 219 13659 2147 2189 2190 320 DFF_X1
* cell instance $14925 m0 *1 60.61,61.6
X$14925 219 13373 2022 2085 2190 320 DFF_X1
* cell instance $14928 m0 *1 64.03,61.6
X$14928 2022 2086 1749 219 320 2085 MUX2_X1
* cell instance $14929 m0 *1 65.36,61.6
X$14929 1927 2149 1750 219 320 2091 MUX2_X1
* cell instance $14932 r0 *1 61.56,61.6
X$14932 1749 2148 2147 219 320 2189 MUX2_X1
* cell instance $14933 r0 *1 62.89,61.6
X$14933 2022 1520 2147 219 320 1926 MUX2_X1
* cell instance $14938 m0 *1 68.02,61.6
X$14938 219 13534 2090 2089 1929 320 DFF_X1
* cell instance $14940 m0 *1 71.25,61.6
X$14940 2090 1377 2023 219 320 2092 MUX2_X1
* cell instance $14941 m0 *1 72.58,61.6
X$14941 2090 2032 1749 219 320 2089 MUX2_X1
* cell instance $14942 m0 *1 73.91,61.6
X$14942 219 13532 2025 2024 1929 320 DFF_X1
* cell instance $14944 m0 *1 77.33,61.6
X$14944 2026 2095 2027 219 320 2096 MUX2_X1
* cell instance $14949 m0 *1 84.17,61.6
X$14949 2029 2030 2096 2031 219 320 2225 AOI22_X2
* cell instance $14952 r0 *1 71.06,61.6
X$14952 2091 1982 1643 320 219 2191 MUX2_X2
* cell instance $14954 r0 *1 72.96,61.6
X$14954 1570 219 320 1929 CLKBUF_X3
* cell instance $14955 r0 *1 73.91,61.6
X$14955 2025 2086 1842 219 320 2024 MUX2_X1
* cell instance $14959 r0 *1 76.57,61.6
X$14959 2025 1844 2150 219 320 2026 MUX2_X1
* cell instance $14963 r0 *1 81.89,61.6
X$14963 1842 1898 2195 219 320 2193 MUX2_X1
* cell instance $14966 r0 *1 83.79,61.6
X$14966 2152 1713 2408 2151 219 320 2290 AOI22_X2
* cell instance $14968 r0 *1 86.26,61.6
X$14968 2152 1624 2199 2151 219 320 2196 AOI22_X2
* cell instance $14970 m0 *1 86.26,61.6
X$14970 2029 1757 2098 2031 219 320 2099 AOI22_X2
* cell instance $14973 m0 *1 91.96,61.6
X$14973 2034 2095 2033 219 320 2098 MUX2_X1
* cell instance $14975 r0 *1 87.97,61.6
X$14975 2196 2099 219 2197 320 NAND2_X4
* cell instance $14979 m0 *1 93.86,61.6
X$14979 1159 219 320 2035 CLKBUF_X2
* cell instance $14984 r0 *1 93.86,61.6
X$14984 2035 1647 2230 219 320 2198 MUX2_X1
* cell instance $14985 r0 *1 95.19,61.6
X$14985 2297 219 320 1578 CLKBUF_X3
* cell instance $14987 m0 *1 100.51,61.6
X$14987 219 13526 2039 2038 1935 320 DFF_X1
* cell instance $14988 m0 *1 97.28,61.6
X$14988 219 13522 2101 2036 1935 320 DFF_X1
* cell instance $14992 r0 *1 99.18,61.6
X$14992 2153 1756 2035 219 320 2300 MUX2_X1
* cell instance $14994 m0 *1 106.59,61.6
X$14994 2035 1898 2003 219 320 2040 MUX2_X1
* cell instance $14996 m0 *1 107.92,61.6
X$14996 2003 1576 2041 219 320 2574 MUX2_X1
* cell instance $14997 m0 *1 109.25,61.6
X$14997 2035 1999 2041 219 320 2104 MUX2_X1
* cell instance $15002 m0 *1 125.97,61.6
X$15002 219 12766 2107 2108 1485 320 DFF_X1
* cell instance $15003 m0 *1 129.2,61.6
X$15003 441 1041 2107 219 320 2108 MUX2_X1
* cell instance $15015 r0 *1 126.35,61.6
X$15015 219 13956 2154 2201 1485 320 DFF_X1
* cell instance $15016 r0 *1 129.58,61.6
X$15016 2154 1629 2107 219 320 2042 MUX2_X1
* cell instance $15017 m0 *1 132.24,61.6
X$15017 219 12763 2043 2109 1763 320 DFF_X1
* cell instance $15018 m0 *1 130.91,61.6
X$15018 441 1012 2043 219 320 2109 MUX2_X1
* cell instance $15019 m0 *1 135.47,61.6
X$15019 2044 1629 2043 219 320 2117 MUX2_X1
* cell instance $15021 m0 *1 138.32,61.6
X$15021 1938 1274 1847 219 320 2334 MUX2_X1
* cell instance $15022 m0 *1 139.65,61.6
X$15022 2045 714 1938 320 219 2241 OAI21_X4
* cell instance $15023 m0 *1 142.12,61.6
X$15023 2124 733 2046 320 219 2125 OAI21_X4
* cell instance $15030 r0 *1 139.84,61.6
X$15030 2117 219 320 2204 INV_X1
* cell instance $15032 r0 *1 140.41,61.6
X$15032 2204 501 219 320 2305 NAND2_X1
* cell instance $15034 r0 *1 141.74,61.6
X$15034 2206 2120 219 320 2155 XNOR2_X2
* cell instance $15036 m0 *1 145.16,61.6
X$15036 1942 1274 1766 219 320 2157 MUX2_X1
* cell instance $15038 m0 *1 146.49,61.6
X$15038 2047 714 1942 320 219 2440 OAI21_X4
* cell instance $15039 m0 *1 148.96,61.6
X$15039 2049 522 1768 219 320 2129 MUX2_X1
* cell instance $15040 m0 *1 150.29,61.6
X$15040 2048 714 2049 320 219 2158 OAI21_X4
* cell instance $15042 m0 *1 152.95,61.6
X$15042 219 12682 2051 2133 2050 320 DFF_X1
* cell instance $15043 m0 *1 156.18,61.6
X$15043 294 1403 2051 219 320 2133 MUX2_X1
* cell instance $15044 m0 *1 157.51,61.6
X$15044 219 12752 1946 1945 2050 320 DFF_X1
* cell instance $15046 m0 *1 161.5,61.6
X$15046 219 12751 2137 2209 2050 320 DFF_X1
* cell instance $15049 m0 *1 165.68,61.6
X$15049 219 12687 2052 2136 1661 320 DFF_X1
* cell instance $15050 m0 *1 168.91,61.6
X$15050 236 2054 2052 219 320 2136 MUX2_X1
* cell instance $15052 m0 *1 170.43,61.6
X$15052 236 2053 2055 219 320 2135 MUX2_X1
* cell instance $15055 m0 *1 174.04,61.6
X$15055 1950 1775 2002 219 320 2056 MUX2_X1
* cell instance $15059 r0 *1 145.54,61.6
X$15059 1282 219 320 2156 CLKBUF_X3
* cell instance $15062 r0 *1 149.72,61.6
X$15062 1445 219 320 1765 BUF_X1
* cell instance $15065 r0 *1 150.86,61.6
X$15065 219 13954 2131 2675 2050 320 DFF_X1
* cell instance $15066 r0 *1 154.09,61.6
X$15066 294 1662 2159 219 320 2210 MUX2_X1
* cell instance $15067 r0 *1 155.42,61.6
X$15067 219 13921 2159 2210 2050 320 DFF_X1
* cell instance $15068 r0 *1 158.65,61.6
X$15068 2159 1772 1946 219 320 2450 MUX2_X1
* cell instance $15070 r0 *1 160.17,61.6
X$15070 326 1492 2137 219 320 2209 MUX2_X1
* cell instance $15071 r0 *1 161.5,61.6
X$15071 219 13920 2208 2160 2050 320 DFF_X1
* cell instance $15075 r0 *1 170.05,61.6
X$15075 2052 1772 2055 219 320 2246 MUX2_X1
* cell instance $15082 r0 *1 175.37,61.6
X$15082 219 13927 2132 2207 2348 320 DFF_X1
* cell instance $15083 m0 *1 177.84,61.6
X$15083 219 12683 2058 2130 1668 320 DFF_X1
* cell instance $15084 m0 *1 176.51,61.6
X$15084 334 2054 2132 219 320 2207 MUX2_X1
* cell instance $15085 m0 *1 181.07,61.6
X$15085 219 12684 2126 2060 1668 320 DFF_X1
* cell instance $15087 m0 *1 184.49,61.6
X$15087 2121 1853 2062 219 320 2061 MUX2_X1
* cell instance $15088 m0 *1 185.82,61.6
X$15088 2119 1775 1995 219 320 2062 MUX2_X1
* cell instance $15090 m0 *1 187.34,61.6
X$15090 224 2057 2114 219 320 2115 MUX2_X1
* cell instance $15092 r0 *1 178.6,61.6
X$15092 2132 1775 2058 219 320 2162 MUX2_X1
* cell instance $15096 r0 *1 183.92,61.6
X$15096 2202 1585 2062 320 219 2203 OAI21_X4
* cell instance $15097 r0 *1 186.39,61.6
X$15097 1405 2121 219 320 2202 OR2_X1
* cell instance $15099 r0 *1 187.91,61.6
X$15099 2113 1893 2114 219 320 2163 MUX2_X1
* cell instance $15101 m0 *1 189.05,61.6
X$15101 219 12719 2113 2200 1952 320 DFF_X1
* cell instance $15104 r0 *1 189.81,61.6
X$15104 224 1852 2113 219 320 2200 MUX2_X1
* cell instance $15106 r0 *1 191.33,61.6
X$15106 1952 219 320 CLKBUF_X1
* cell instance $15108 r0 *1 192.09,61.6
X$15108 1241 320 2057 219 BUF_X4
* cell instance $15109 m0 *1 193.99,61.6
X$15109 545 219 320 1952 CLKBUF_X3
* cell instance $15110 m0 *1 192.66,61.6
X$15110 1991 1893 2063 219 320 2110 MUX2_X1
* cell instance $15113 m0 *1 196.65,61.6
X$15113 1181 320 2054 219 BUF_X4
* cell instance $15114 m0 *1 197.98,61.6
X$15114 1953 2054 2064 219 320 2106 MUX2_X1
* cell instance $15120 r0 *1 195.51,61.6
X$15120 1330 320 1852 219 BUF_X4
* cell instance $15121 r0 *1 196.84,61.6
X$15121 1182 320 2053 219 BUF_X4
* cell instance $15124 m0 *1 200.45,61.6
X$15124 2097 1407 2100 320 219 2105 OAI21_X4
* cell instance $15126 m0 *1 203.87,61.6
X$15126 2065 320 1329 219 BUF_X4
* cell instance $15127 m0 *1 205.2,61.6
X$15127 219 2065 1112 320 BUF_X16
* cell instance $15128 m0 *1 209.95,61.6
X$15128 219 2491 2065 320 BUF_X16
* cell instance $15134 r0 *1 202.35,61.6
X$15134 1241 320 2165 219 BUF_X4
* cell instance $15136 r0 *1 204.06,61.6
X$15136 219 13894 2258 2194 1670 320 DFF_X1
* cell instance $15138 r0 *1 207.48,61.6
X$15138 219 13891 2166 2192 1500 320 DFF_X1
* cell instance $15140 r0 *1 211.09,61.6
X$15140 219 13942 2167 2168 1501 320 DFF_X1
* cell instance $15141 r0 *1 214.32,61.6
X$15141 1241 219 320 2169 CLKBUF_X3
* cell instance $15144 m0 *1 219.07,61.6
X$15144 2087 1119 1972 320 219 2088 OAI21_X4
* cell instance $15148 m0 *1 225.34,61.6
X$15148 2067 1414 2068 219 320 2066 MUX2_X1
* cell instance $15149 m0 *1 226.67,61.6
X$15149 2068 1868 1969 219 320 2069 MUX2_X1
* cell instance $15151 m0 *1 228.19,61.6
X$15151 2067 1781 2188 219 320 2081 MUX2_X1
* cell instance $15154 r0 *1 220.02,61.6
X$15154 219 13946 2277 2171 1501 320 DFF_X1
* cell instance $15157 r0 *1 224.39,61.6
X$15157 219 13947 2188 2081 1698 320 DFF_X1
* cell instance $15158 r0 *1 227.62,61.6
X$15158 2069 2187 2072 320 219 2371 MUX2_X2
* cell instance $15159 r0 *1 229.33,61.6
X$15159 2188 1868 2070 219 320 2187 MUX2_X1
* cell instance $15161 m0 *1 229.9,61.6
X$15161 219 12769 2070 2071 1680 320 DFF_X1
* cell instance $15162 m0 *1 233.89,61.6
X$15162 2073 1414 1958 219 320 2079 MUX2_X1
* cell instance $15170 r0 *1 231.8,61.6
X$15170 219 13960 1958 2079 1680 320 DFF_X1
* cell instance $15171 r0 *1 235.03,61.6
X$15171 2073 1677 1961 219 320 2276 MUX2_X1
* cell instance $15174 m0 *1 236.36,61.6
X$15174 219 12770 2172 2179 1680 320 DFF_X1
* cell instance $15176 r0 *1 236.74,61.6
X$15176 2073 1408 2172 219 320 2179 MUX2_X1
* cell instance $15178 r0 *1 238.83,61.6
X$15178 2173 219 320 1584 BUF_X1
* cell instance $15189 r0 *1 6.08,182
X$15189 219 14318 10128 10027 10127 320 DFF_X1
* cell instance $15193 m0 *1 11.97,182
X$15193 9851 9101 9937 219 320 10029 MUX2_X1
* cell instance $15194 m0 *1 8.74,182
X$15194 219 12962 9937 10075 9936 320 DFF_X1
* cell instance $15199 r0 *1 10.07,182
X$15199 10028 7123 9937 219 320 10075 MUX2_X1
* cell instance $15202 r0 *1 12.54,182
X$15202 10029 8792 10166 219 320 10031 MUX2_X1
* cell instance $15204 r0 *1 14.25,182
X$15204 10028 7177 10131 219 320 10130 MUX2_X1
* cell instance $15207 r0 *1 16.15,182
X$15207 9526 219 320 9936 CLKBUF_X3
* cell instance $15209 m0 *1 18.43,182
X$15209 219 12922 10076 9938 9936 320 DFF_X1
* cell instance $15211 m0 *1 21.66,182
X$15211 9852 7081 9940 219 320 9939 MUX2_X1
* cell instance $15214 r0 *1 18.62,182
X$15214 10076 6906 9852 219 320 9938 MUX2_X1
* cell instance $15215 r0 *1 19.95,182
X$15215 10076 8729 9940 219 320 10168 MUX2_X1
* cell instance $15217 r0 *1 21.66,182
X$15217 219 14420 10030 10078 9941 320 DFF_X1
* cell instance $15218 m0 *1 25.84,182
X$15218 219 12914 9896 9853 9941 320 DFF_X1
* cell instance $15219 m0 *1 24.89,182
X$15219 9526 219 320 9941 CLKBUF_X3
* cell instance $15220 m0 *1 29.07,182
X$15220 9855 8920 10081 219 320 10080 MUX2_X1
* cell instance $15223 m0 *1 31.35,182
X$15223 219 12747 9856 9988 9942 320 DFF_X1
* cell instance $15224 m0 *1 34.58,182
X$15224 9900 6909 9640 219 320 9897 MUX2_X1
* cell instance $15227 m0 *1 39.71,182
X$15227 9943 6906 9944 219 320 9989 MUX2_X1
* cell instance $15228 m0 *1 41.04,182
X$15228 219 12721 9943 9989 9861 320 DFF_X1
* cell instance $15229 m0 *1 44.27,182
X$15229 9943 9763 9860 219 320 10086 MUX2_X1
* cell instance $15232 m0 *1 46.55,182
X$15232 9944 7082 9945 219 320 9990 MUX2_X1
* cell instance $15233 m0 *1 47.88,182
X$15233 219 12670 9945 9990 9861 320 DFF_X1
* cell instance $15235 r0 *1 24.89,182
X$15235 9852 6974 10030 219 320 10078 MUX2_X1
* cell instance $15237 r0 *1 26.41,182
X$15237 9852 7016 10079 219 320 10171 MUX2_X1
* cell instance $15239 r0 *1 28.12,182
X$15239 10030 8791 10079 219 320 10081 MUX2_X1
* cell instance $15242 r0 *1 30.02,182
X$15242 10080 8867 10031 219 320 10082 MUX2_X1
* cell instance $15243 r0 *1 31.35,182
X$15243 10172 10082 9035 320 219 7624 MUX2_X2
* cell instance $15247 r0 *1 34.39,182
X$15247 10084 6909 10032 219 320 10133 MUX2_X1
* cell instance $15250 r0 *1 37.43,182
X$15250 10032 7082 10178 219 320 10176 MUX2_X1
* cell instance $15254 r0 *1 42.37,182
X$15254 9944 7081 9860 219 320 9902 MUX2_X1
* cell instance $15258 r0 *1 46.36,182
X$15258 10086 9527 10181 219 320 10089 MUX2_X1
* cell instance $15262 r0 *1 50.35,182
X$15262 9944 7016 10035 219 320 10033 MUX2_X1
* cell instance $15264 m0 *1 51.49,182
X$15264 219 12698 10035 10033 9865 320 DFF_X1
* cell instance $15265 r0 *1 51.68,182
X$15265 10089 8927 10625 219 320 10093 MUX2_X1
* cell instance $15267 r0 *1 53.2,182
X$15267 10184 5005 10035 219 320 10090 MUX2_X1
* cell instance $15269 m0 *1 55.29,182
X$15269 10093 9864 1643 320 219 7147 MUX2_X2
* cell instance $15274 r0 *1 55.48,182
X$15274 9865 219 320 14716 INV_X2
* cell instance $15275 r0 *1 56.05,182
X$15275 9405 219 320 9865 CLKBUF_X3
* cell instance $15276 r0 *1 57,182
X$15276 219 14164 10187 10186 9865 320 DFF_X1
* cell instance $15277 m0 *1 59.09,182
X$15277 9866 8791 10187 219 320 9946 MUX2_X1
* cell instance $15279 m0 *1 60.42,182
X$15279 9946 8792 10345 219 320 9993 MUX2_X1
* cell instance $15286 m0 *1 66.88,182
X$15286 9867 8729 9948 219 320 10036 MUX2_X1
* cell instance $15287 m0 *1 63.65,182
X$15287 219 12582 9867 9992 10135 320 DFF_X1
* cell instance $15288 m0 *1 68.21,182
X$15288 9947 6710 9948 219 320 9909 MUX2_X1
* cell instance $15291 m0 *1 71.82,182
X$15291 10097 9868 9035 320 219 7840 MUX2_X2
* cell instance $15298 r0 *1 68.78,182
X$15298 10037 8262 10095 219 320 10038 MUX2_X1
* cell instance $15299 r0 *1 70.11,182
X$15299 10038 2719 10039 219 320 10097 MUX2_X1
* cell instance $15300 r0 *1 71.44,182
X$15300 10096 2719 10737 219 320 10099 MUX2_X1
* cell instance $15303 r0 *1 73.34,182
X$15303 10099 10417 9035 320 219 7329 MUX2_X2
* cell instance $15305 r0 *1 75.43,182
X$15305 9947 7026 10040 219 320 10194 MUX2_X1
* cell instance $15307 r0 *1 76.95,182
X$15307 9947 7025 10196 219 320 10195 MUX2_X1
* cell instance $15308 r0 *1 78.28,182
X$15308 9767 219 320 14780 INV_X1
* cell instance $15309 r0 *1 78.66,182
X$15309 10196 8799 10040 219 320 10198 MUX2_X1
* cell instance $15311 m0 *1 83.22,182
X$15311 9823 9763 9995 219 320 10101 MUX2_X1
* cell instance $15313 m0 *1 84.55,182
X$15313 219 12564 9995 9994 9770 320 DFF_X1
* cell instance $15315 m0 *1 89.3,182
X$15315 9949 10203 1643 320 219 7045 MUX2_X2
* cell instance $15318 m0 *1 91.96,182
X$15318 219 13200 10042 9950 9770 320 DFF_X1
* cell instance $15325 r0 *1 83.22,182
X$15325 10101 9527 10299 219 320 10041 MUX2_X1
* cell instance $15326 r0 *1 84.55,182
X$15326 10041 8927 10566 219 320 9949 MUX2_X1
* cell instance $15328 r0 *1 87.4,182
X$15328 8926 219 320 9770 CLKBUF_X3
* cell instance $15331 r0 *1 89.3,182
X$15331 10102 4992 10301 219 320 10203 MUX2_X1
* cell instance $15334 r0 *1 91.77,182
X$15334 9869 7026 10042 219 320 9950 MUX2_X1
* cell instance $15335 r0 *1 93.1,182
X$15335 9916 5005 10042 219 320 10103 MUX2_X1
* cell instance $15336 r0 *1 94.43,182
X$15336 10205 9207 10103 219 320 10102 MUX2_X1
* cell instance $15341 r0 *1 109.82,182
X$15341 3264 10104 320 219 10044 AND2_X1
* cell instance $15342 m0 *1 110.58,182
X$15342 219 13173 9951 10044 9920 320 DFF_X1
* cell instance $15343 m0 *1 110.01,182
X$15343 9999 10002 219 320 10000 NOR2_X1
* cell instance $15344 m0 *1 113.81,182
X$15344 10141 10001 9951 219 320 10105 NOR3_X1
* cell instance $15345 m0 *1 114.57,182
X$15345 219 13149 10004 9952 9920 320 DFF_X1
* cell instance $15348 m0 *1 119.51,182
X$15348 9870 8242 10048 219 320 10107 MUX2_X1
* cell instance $15349 m0 *1 120.84,182
X$15349 219 13427 9921 10006 9920 320 DFF_X1
* cell instance $15350 m0 *1 124.07,182
X$15350 9953 7610 9921 219 320 10007 MUX2_X1
* cell instance $15352 m0 *1 125.59,182
X$15352 10212 10007 8284 320 219 9438 MUX2_X2
* cell instance $15355 r0 *1 110.58,182
X$15355 6140 10043 10045 219 320 9999 MUX2_X1
* cell instance $15356 r0 *1 111.91,182
X$15356 2197 10043 10046 219 320 10104 MUX2_X1
* cell instance $15357 r0 *1 113.24,182
X$15357 10001 10308 320 219 10045 XNOR2_X1
* cell instance $15359 r0 *1 114.76,182
X$15359 10106 10002 219 320 9952 NOR2_X1
* cell instance $15361 r0 *1 115.71,182
X$15361 10004 10105 320 219 10047 XNOR2_X1
* cell instance $15362 r0 *1 116.85,182
X$15362 10047 10142 219 320 10209 NOR2_X1
* cell instance $15365 r0 *1 118.37,182
X$15365 219 14358 10048 10107 10143 320 DFF_X1
* cell instance $15369 r0 *1 121.6,182
X$15369 219 14080 9953 10239 9920 320 DFF_X1
* cell instance $15375 m0 *1 130.53,182
X$15375 219 13559 9955 10213 10050 320 DFF_X1
* cell instance $15376 m0 *1 129.2,182
X$15376 9543 9154 9954 219 320 10049 MUX2_X1
* cell instance $15377 m0 *1 133.76,182
X$15377 9954 10051 9955 219 320 9956 MUX2_X1
* cell instance $15378 m0 *1 135.09,182
X$15378 8284 9956 219 320 9773 OR2_X1
* cell instance $15380 m0 *1 137.37,182
X$15380 8284 9957 219 320 10008 OR2_X1
* cell instance $15382 r0 *1 129.39,182
X$15382 219 14146 9954 10049 10050 320 DFF_X1
* cell instance $15383 r0 *1 132.62,182
X$15383 9543 9157 9955 219 320 10213 MUX2_X1
* cell instance $15384 r0 *1 133.95,182
X$15384 8325 219 320 10244 INV_X1
* cell instance $15387 r0 *1 135.28,182
X$15387 4505 320 9157 219 BUF_X4
* cell instance $15388 r0 *1 136.61,182
X$15388 219 10111 10112 12505 7274 320 DFF_X2
* cell instance $15389 m0 *1 139.08,182
X$15389 10008 9827 9871 320 219 9777 OAI21_X2
* cell instance $15390 m0 *1 138.51,182
X$15390 10357 9827 219 320 9958 NOR2_X1
* cell instance $15395 m0 *1 144.21,182
X$15395 10010 9872 9775 219 10011 320 AOI21_X1
* cell instance $15396 m0 *1 143.83,182
X$15396 7045 219 320 9959 INV_X1
* cell instance $15397 m0 *1 144.97,182
X$15397 9734 9960 10011 320 10052 219 OAI21_X1
* cell instance $15398 m0 *1 145.73,182
X$15398 9925 9958 219 320 10012 OR2_X1
* cell instance $15400 m0 *1 146.68,182
X$15400 10012 219 320 9668 CLKBUF_X3
* cell instance $15402 m0 *1 147.82,182
X$15402 9551 6522 9961 219 320 9963 OR3_X1
* cell instance $15406 r0 *1 144.59,182
X$15406 9663 9734 219 320 10247 NOR2_X1
* cell instance $15407 r0 *1 145.16,182
X$15407 9734 9663 219 320 10249 OR2_X1
* cell instance $15408 r0 *1 145.92,182
X$15408 9958 9925 219 320 10215 NOR2_X1
* cell instance $15411 m0 *1 149.15,182
X$15411 9962 9873 9522 219 320 10113 NAND3_X1
* cell instance $15413 m0 *1 151.05,182
X$15413 9927 219 320 10146 INV_X1
* cell instance $15414 m0 *1 150.29,182
X$15414 9668 9329 9777 219 320 10017 NOR3_X1
* cell instance $15416 m0 *1 151.62,182
X$15416 9873 10016 10014 320 219 10015 OAI21_X4
* cell instance $15417 m0 *1 154.09,182
X$15417 10017 9873 9177 219 320 10019 NAND3_X1
* cell instance $15418 m0 *1 154.85,182
X$15418 9838 10019 6450 320 219 10054 MUX2_X2
* cell instance $15424 r0 *1 152,182
X$15424 9667 6450 10113 219 320 10218 MUX2_X1
* cell instance $15425 r0 *1 153.33,182
X$15425 6522 10113 219 320 10114 OR2_X1
* cell instance $15426 r0 *1 154.09,182
X$15426 10114 6450 9667 320 219 10333 OAI21_X2
* cell instance $15429 r0 *1 155.99,182
X$15429 9177 219 320 10147 CLKBUF_X3
* cell instance $15430 r0 *1 156.94,182
X$15430 219 9780 9781 10149 10115 320 DFF_X1
* cell instance $15431 r0 *1 160.17,182
X$15431 9556 9781 219 320 10117 XOR2_X1
* cell instance $15432 r0 *1 161.31,182
X$15432 689 7838 10117 219 320 10254 MUX2_X1
* cell instance $15438 m0 *1 9.88,95.2
X$15438 4144 1547 4145 219 320 4210 MUX2_X1
* cell instance $15441 m0 *1 12.16,95.2
X$15441 4144 1599 4275 219 320 4428 MUX2_X1
* cell instance $15444 m0 *1 14.44,95.2
X$15444 4145 2520 4275 219 320 4215 MUX2_X1
* cell instance $15455 r0 *1 10.07,95.2
X$15455 219 14161 4275 4428 4143 320 DFF_X1
* cell instance $15458 r0 *1 14.25,95.2
X$15458 4445 219 320 1547 CLKBUF_X3
* cell instance $15461 m0 *1 19.95,95.2
X$15461 4325 3126 4215 219 320 4147 MUX2_X1
* cell instance $15462 m0 *1 22.8,95.2
X$15462 4144 1553 4327 219 320 4216 MUX2_X1
* cell instance $15464 m0 *1 24.32,95.2
X$15464 4217 2842 4327 219 320 4218 MUX2_X1
* cell instance $15469 r0 *1 23.75,95.2
X$15469 4359 219 320 1553 CLKBUF_X3
* cell instance $15472 m0 *1 26.03,95.2
X$15472 219 13447 4220 4328 3944 320 DFF_X1
* cell instance $15473 m0 *1 30.02,95.2
X$15473 4144 1261 4276 219 320 4362 MUX2_X1
* cell instance $15478 r0 *1 27.55,95.2
X$15478 4237 219 320 1303 CLKBUF_X3
* cell instance $15481 r0 *1 29.45,95.2
X$15481 219 14105 4276 4362 3944 320 DFF_X1
* cell instance $15483 m0 *1 31.73,95.2
X$15483 4277 219 320 1261 CLKBUF_X3
* cell instance $15484 m0 *1 33.44,95.2
X$15484 4278 219 320 1467 CLKBUF_X3
* cell instance $15488 m0 *1 39.14,95.2
X$15488 4102 2776 219 320 4227 NAND2_X1
* cell instance $15493 m0 *1 41.04,95.2
X$15493 4103 1835 4053 219 320 4149 MUX2_X1
* cell instance $15495 m0 *1 42.37,95.2
X$15495 4149 2777 219 320 4280 NAND2_X1
* cell instance $15497 m0 *1 43.13,95.2
X$15497 4227 4280 4279 219 320 4228 NAND3_X2
* cell instance $15498 m0 *1 44.46,95.2
X$15498 3679 219 320 3946 CLKBUF_X3
* cell instance $15499 m0 *1 45.41,95.2
X$15499 3945 1609 4363 219 320 4330 MUX2_X1
* cell instance $15500 m0 *1 46.74,95.2
X$15500 219 13539 4363 4330 4281 320 DFF_X1
* cell instance $15502 m0 *1 51.49,95.2
X$15502 4282 320 1695 219 BUF_X4
* cell instance $15508 r0 *1 47.5,95.2
X$15508 4363 2787 4150 219 320 4109 MUX2_X1
* cell instance $15513 r0 *1 51.68,95.2
X$15513 219 13643 4547 4365 4281 320 DFF_X1
* cell instance $15514 m0 *1 54.15,95.2
X$15514 4364 320 1609 219 BUF_X4
* cell instance $15518 r0 *1 55.67,95.2
X$15518 219 14031 4439 4435 4436 320 DFF_X1
* cell instance $15520 m0 *1 55.86,95.2
X$15520 219 13380 4335 4334 4436 320 DFF_X1
* cell instance $15521 r0 *1 58.9,95.2
X$15521 219 14147 4283 4151 4436 320 DFF_X1
* cell instance $15522 m0 *1 59.66,95.2
X$15522 4366 2963 4233 219 320 4232 MUX2_X1
* cell instance $15525 m0 *1 61.18,95.2
X$15525 4283 2772 4284 219 320 4233 MUX2_X1
* cell instance $15526 m0 *1 62.51,95.2
X$15526 4232 2776 219 320 4338 NAND2_X1
* cell instance $15528 r0 *1 62.13,95.2
X$15528 3952 1389 4284 219 320 4440 MUX2_X1
* cell instance $15532 m0 *1 64.79,95.2
X$15532 4338 4337 2890 219 320 4339 NAND3_X2
* cell instance $15533 m0 *1 63.46,95.2
X$15533 4277 320 1389 219 BUF_X4
* cell instance $15534 m0 *1 66.12,95.2
X$15534 4278 320 1746 219 BUF_X4
* cell instance $15535 m0 *1 67.45,95.2
X$15535 219 13500 4153 4152 4285 320 DFF_X1
* cell instance $15537 m0 *1 70.87,95.2
X$15537 4361 320 1841 219 BUF_X4
* cell instance $15539 m0 *1 72.39,95.2
X$15539 4062 3758 4244 219 320 4342 MUX2_X1
* cell instance $15541 m0 *1 73.91,95.2
X$15541 4339 3044 4342 320 219 4245 OAI21_X4
* cell instance $15543 m0 *1 76.57,95.2
X$15543 219 13156 4287 4286 4285 320 DFF_X1
* cell instance $15547 r0 *1 64.22,95.2
X$15547 4359 320 1480 219 BUF_X4
* cell instance $15548 r0 *1 65.55,95.2
X$15548 219 13738 4443 4441 4285 320 DFF_X1
* cell instance $15549 r0 *1 68.78,95.2
X$15549 3952 1478 4443 219 320 4441 MUX2_X1
* cell instance $15551 r0 *1 70.49,95.2
X$15551 4445 320 1478 219 BUF_X4
* cell instance $15552 r0 *1 71.82,95.2
X$15552 4364 320 1983 219 BUF_X4
* cell instance $15553 r0 *1 73.15,95.2
X$15553 4282 320 1999 219 BUF_X4
* cell instance $15555 r0 *1 74.67,95.2
X$15555 4282 320 4163 219 BUF_X4
* cell instance $15559 m0 *1 81.13,95.2
X$15559 3584 1746 4288 219 320 4246 MUX2_X1
* cell instance $15563 m0 *1 83.41,95.2
X$15563 4154 3365 4288 219 320 4249 MUX2_X1
* cell instance $15565 r0 *1 81.32,95.2
X$15565 219 13934 4154 4063 4121 320 DFF_X1
* cell instance $15567 m0 *1 85.31,95.2
X$15567 4289 4249 219 320 4252 NOR2_X1
* cell instance $15569 m0 *1 85.88,95.2
X$15569 4064 3766 4065 219 320 4344 MUX2_X1
* cell instance $15571 r0 *1 86.07,95.2
X$15571 3919 4344 219 320 4448 NOR2_X1
* cell instance $15572 r0 *1 86.64,95.2
X$15572 1282 219 320 4810 CLKBUF_X3
* cell instance $15573 m0 *1 87.78,95.2
X$15573 219 13136 4156 4155 4121 320 DFF_X1
* cell instance $15575 m0 *1 91.01,95.2
X$15575 4156 3766 4118 219 320 4345 MUX2_X1
* cell instance $15577 r0 *1 87.59,95.2
X$15577 3856 219 320 4121 CLKBUF_X3
* cell instance $15579 r0 *1 88.92,95.2
X$15579 219 14394 4118 4066 4121 320 DFF_X1
* cell instance $15580 r0 *1 92.15,95.2
X$15580 219 4450 4448 4451 4157 4252 320 OR4_X4
* cell instance $15581 m0 *1 92.91,95.2
X$15581 4345 3686 2904 219 320 4157 NOR3_X1
* cell instance $15586 r0 *1 94.81,95.2
X$15586 4159 2468 4367 219 320 4451 NOR3_X1
* cell instance $15587 r0 *1 95.57,95.2
X$15587 4367 320 2672 219 BUF_X4
* cell instance $15590 m0 *1 100.32,95.2
X$15590 3684 4161 4290 219 320 4347 MUX2_X1
* cell instance $15592 m0 *1 101.65,95.2
X$15592 219 12966 4290 4347 4453 320 DFF_X1
* cell instance $15593 m0 *1 104.88,95.2
X$15593 4290 1844 4162 219 320 4348 MUX2_X1
* cell instance $15596 r0 *1 100.32,95.2
X$15596 219 14392 4370 4369 4453 320 DFF_X1
* cell instance $15597 r0 *1 103.55,95.2
X$15597 4070 4371 4302 219 320 NOR2_X4
* cell instance $15599 m0 *1 109.82,95.2
X$15599 3658 4164 219 320 4291 NOR2_X2
* cell instance $15603 m0 *1 111.72,95.2
X$15603 3859 4163 4165 219 320 4349 MUX2_X1
* cell instance $15604 m0 *1 113.05,95.2
X$15604 219 12607 4165 4349 4372 320 DFF_X1
* cell instance $15606 m0 *1 117.8,95.2
X$15606 3456 4161 4292 219 320 4350 MUX2_X1
* cell instance $15613 r0 *1 115.71,95.2
X$15613 1902 219 320 4372 CLKBUF_X3
* cell instance $15614 r0 *1 116.66,95.2
X$15614 4372 219 320 14784 INV_X1
* cell instance $15615 r0 *1 117.04,95.2
X$15615 219 14493 4292 4350 4372 320 DFF_X1
* cell instance $15619 m0 *1 120.46,95.2
X$15619 4131 219 320 3456 BUF_X2
* cell instance $15624 r0 *1 120.27,95.2
X$15624 219 14046 4374 4456 4372 320 DFF_X1
* cell instance $15625 r0 *1 123.5,95.2
X$15625 3456 4163 4374 219 320 4456 MUX2_X1
* cell instance $15630 m0 *1 128.63,95.2
X$15630 4294 219 320 2799 CLKBUF_X3
* cell instance $15634 m0 *1 130.53,95.2
X$15634 4351 320 3135 219 BUF_X4
* cell instance $15637 r0 *1 129.39,95.2
X$15637 4377 320 3136 219 BUF_X4
* cell instance $15638 r0 *1 130.72,95.2
X$15638 4505 320 2805 219 BUF_X4
* cell instance $15639 r0 *1 132.05,95.2
X$15639 440 4351 4379 219 320 4295 MUX2_X1
* cell instance $15641 m0 *1 132.24,95.2
X$15641 219 13089 4379 4295 4376 320 DFF_X1
* cell instance $15643 m0 *1 139.27,95.2
X$15643 222 2799 4168 219 320 4261 MUX2_X1
* cell instance $15644 m0 *1 140.6,95.2
X$15644 222 2805 4381 219 320 4352 MUX2_X1
* cell instance $15646 r0 *1 133.38,95.2
X$15646 219 14527 4380 4460 4506 320 DFF_X1
* cell instance $15647 r0 *1 136.61,95.2
X$15647 4379 3775 4378 219 320 4462 MUX2_X1
* cell instance $15650 r0 *1 138.51,95.2
X$15650 219 13969 4381 4352 4079 320 DFF_X1
* cell instance $15651 r0 *1 141.74,95.2
X$15651 4168 4584 4381 219 320 4296 MUX2_X1
* cell instance $15652 m0 *1 142.5,95.2
X$15652 4079 219 320 CLKBUF_X1
* cell instance $15654 m0 *1 143.07,95.2
X$15654 4293 2799 4354 219 320 4353 MUX2_X1
* cell instance $15655 m0 *1 144.4,95.2
X$15655 219 13111 4354 4353 4079 320 DFF_X1
* cell instance $15658 r0 *1 143.26,95.2
X$15658 4382 4296 219 320 4463 OR2_X1
* cell instance $15660 r0 *1 144.21,95.2
X$15660 4463 4383 4169 320 219 3379 OAI21_X2
* cell instance $15662 r0 *1 145.73,95.2
X$15662 4293 2805 4170 219 320 4263 MUX2_X1
* cell instance $15663 r0 *1 147.06,95.2
X$15663 4354 2909 4170 219 320 4465 MUX2_X1
* cell instance $15664 m0 *1 148.2,95.2
X$15664 4293 3135 4356 219 320 4264 MUX2_X1
* cell instance $15666 m0 *1 149.53,95.2
X$15666 219 12711 4298 4297 4629 320 DFF_X1
* cell instance $15667 m0 *1 152.76,95.2
X$15667 4356 3775 4298 219 320 4172 MUX2_X1
* cell instance $15671 r0 *1 148.77,95.2
X$15671 4293 3136 4298 219 320 4297 MUX2_X1
* cell instance $15674 r0 *1 150.67,95.2
X$15674 4382 4465 219 320 4466 OR2_X1
* cell instance $15676 r0 *1 151.62,95.2
X$15676 4466 4383 4172 320 219 3334 OAI21_X4
* cell instance $15679 r0 *1 154.66,95.2
X$15679 4468 4173 219 320 289 NOR2_X2
* cell instance $15680 m0 *1 156.18,95.2
X$15680 4177 4358 219 320 4174 NOR2_X1
* cell instance $15681 m0 *1 155.23,95.2
X$15681 4299 4173 219 320 239 NOR2_X2
* cell instance $15682 m0 *1 156.75,95.2
X$15682 4174 4357 4385 219 320 4175 NOR3_X1
* cell instance $15683 m0 *1 157.51,95.2
X$15683 4179 1727 3784 4273 320 219 4471 OAI22_X1
* cell instance $15684 m0 *1 158.46,95.2
X$15684 4182 1727 3785 4273 320 219 4357 OAI22_X1
* cell instance $15686 r0 *1 155.61,95.2
X$15686 4469 4080 219 320 449 NOR2_X2
* cell instance $15687 r0 *1 156.56,95.2
X$15687 4177 4268 219 320 4384 NOR2_X1
* cell instance $15689 r0 *1 157.32,95.2
X$15689 4384 4471 4386 219 320 4468 NOR3_X1
* cell instance $15691 r0 *1 158.27,95.2
X$15691 4470 2870 4459 4388 320 219 4386 OAI22_X1
* cell instance $15692 r0 *1 159.22,95.2
X$15692 4389 2870 3277 4388 320 219 4300 OAI22_X1
* cell instance $15693 m0 *1 160.74,95.2
X$15693 4177 4355 219 320 3969 NOR2_X1
* cell instance $15694 m0 *1 159.79,95.2
X$15694 3977 1727 3387 4273 320 219 4271 OAI22_X1
* cell instance $15695 m0 *1 161.31,95.2
X$15695 4141 4355 219 320 3972 NOR2_X1
* cell instance $15697 m0 *1 162.07,95.2
X$15697 4301 2528 3337 4084 320 219 4267 OAI22_X1
* cell instance $15701 r0 *1 160.17,95.2
X$15701 4141 4358 219 320 4137 NOR2_X1
* cell instance $15703 m0 *1 166.25,95.2
X$15703 4302 4307 219 320 4181 NOR2_X1
* cell instance $15704 m0 *1 165.68,95.2
X$15704 4302 4306 219 320 4183 NOR2_X1
* cell instance $15705 m0 *1 166.82,95.2
X$15705 4301 2681 3337 4171 320 219 4303 OAI22_X1
* cell instance $15706 m0 *1 167.77,95.2
X$15706 4302 4304 219 320 4129 NOR2_X1
* cell instance $15707 m0 *1 168.34,95.2
X$15707 4135 2681 3384 4128 320 219 4262 OAI22_X1
* cell instance $15711 r0 *1 167.2,95.2
X$15711 4302 4464 219 320 4392 NOR2_X1
* cell instance $15712 r0 *1 167.77,95.2
X$15712 4392 4303 4467 219 320 4086 NOR3_X1
* cell instance $15714 r0 *1 168.72,95.2
X$15714 4179 1228 3382 4128 320 219 4467 OAI22_X1
* cell instance $15717 m0 *1 172.52,95.2
X$15717 4187 4304 219 320 4186 NOR2_X1
* cell instance $15718 m0 *1 171.19,95.2
X$15718 4186 4185 4461 320 4038 219 NOR3_X2
* cell instance $15719 m0 *1 173.09,95.2
X$15719 4635 4080 219 320 251 NOR2_X2
* cell instance $15720 m0 *1 174.04,95.2
X$15720 4308 883 3609 1453 320 219 4305 OAI22_X1
* cell instance $15721 m0 *1 174.99,95.2
X$15721 4187 4306 219 320 4188 NOR2_X1
* cell instance $15722 m0 *1 175.56,95.2
X$15722 4187 4307 219 320 4191 NOR2_X1
* cell instance $15723 m0 *1 176.13,95.2
X$15723 4191 4305 4397 219 320 4258 NOR3_X1
* cell instance $15726 r0 *1 171.57,95.2
X$15726 4187 4464 219 320 4393 NOR2_X1
* cell instance $15727 r0 *1 172.14,95.2
X$15727 4393 4394 4395 320 3841 219 NOR3_X2
* cell instance $15733 r0 *1 175.37,95.2
X$15733 4458 4592 4387 4391 320 219 4190 OAI22_X1
* cell instance $15736 r0 *1 177.27,95.2
X$15736 4241 4398 4459 4399 320 219 4116 OAI22_X1
* cell instance $15737 m0 *1 178.79,95.2
X$15737 4308 857 1709 3609 320 219 4194 OAI22_X2
* cell instance $15738 m0 *1 178.03,95.2
X$15738 4253 4192 4457 219 320 4026 NOR3_X1
* cell instance $15739 m0 *1 180.5,95.2
X$15739 4346 857 3940 1709 320 219 4250 OAI22_X1
* cell instance $15740 m0 *1 181.45,95.2
X$15740 4089 4196 4455 320 4111 219 NOR3_X2
* cell instance $15741 m0 *1 182.78,95.2
X$15741 4308 320 3787 219 BUF_X4
* cell instance $15744 r0 *1 178.22,95.2
X$15744 4458 4398 4399 4387 320 219 4455 OAI22_X2
* cell instance $15745 r0 *1 179.93,95.2
X$15745 4195 4194 4401 320 4309 219 NOR3_X2
* cell instance $15746 r0 *1 181.26,95.2
X$15746 2912 3162 219 320 4088 NOR2_X1
* cell instance $15748 r0 *1 182.21,95.2
X$15748 4182 656 3979 1815 320 219 4404 OAI22_X1
* cell instance $15749 r0 *1 183.16,95.2
X$15749 4405 4080 219 320 283 NOR2_X2
* cell instance $15752 m0 *1 188.48,95.2
X$15752 4198 4197 4199 219 320 4310 NOR3_X1
* cell instance $15753 m0 *1 187.53,95.2
X$15753 3512 4248 3508 4406 320 219 4197 OAI22_X1
* cell instance $15754 m0 *1 189.24,95.2
X$15754 3650 550 3468 1198 320 219 4199 OAI22_X1
* cell instance $15756 m0 *1 190.38,95.2
X$15756 3720 3162 219 320 4452 NOR2_X1
* cell instance $15758 m0 *1 191.71,95.2
X$15758 4343 3163 219 320 4223 NOR2_X1
* cell instance $15759 m0 *1 192.28,95.2
X$15759 4234 4091 4311 219 320 4341 NOR3_X1
* cell instance $15761 m0 *1 193.8,95.2
X$15761 4341 3702 219 320 4201 NOR2_X1
* cell instance $15764 r0 *1 188.67,95.2
X$15764 3443 4248 3513 4406 320 219 4454 OAI22_X1
* cell instance $15765 r0 *1 189.62,95.2
X$15765 3217 550 3666 1198 320 219 4407 OAI22_X1
* cell instance $15766 r0 *1 190.57,95.2
X$15766 4452 4454 4407 219 320 4343 NOR3_X1
* cell instance $15771 r0 *1 194.18,95.2
X$15771 4236 3792 219 320 4321 NOR2_X1
* cell instance $15772 r0 *1 194.75,95.2
X$15772 4214 2364 4408 219 320 4449 MUX2_X1
* cell instance $15773 m0 *1 198.74,95.2
X$15773 4409 2976 4313 219 320 4446 MUX2_X1
* cell instance $15774 m0 *1 195.51,95.2
X$15774 219 12609 4447 4340 3874 320 DFF_X1
* cell instance $15775 m0 *1 200.07,95.2
X$15775 4214 2165 4313 219 320 4312 MUX2_X1
* cell instance $15778 m0 *1 202.35,95.2
X$15778 4225 3981 4336 219 320 NOR2_X4
* cell instance $15783 r0 *1 196.65,95.2
X$15783 4214 2490 4447 219 320 4340 MUX2_X1
* cell instance $15784 r0 *1 197.98,95.2
X$15784 4214 2256 4409 219 320 4410 MUX2_X1
* cell instance $15786 r0 *1 199.5,95.2
X$15786 219 14292 4313 4312 3874 320 DFF_X1
* cell instance $15788 r0 *1 202.92,95.2
X$15788 219 14063 4413 4444 3874 320 DFF_X1
* cell instance $15789 m0 *1 205.39,95.2
X$15789 4413 2976 4412 219 320 4558 MUX2_X1
* cell instance $15791 m0 *1 206.72,95.2
X$15791 3798 2364 4314 219 320 4333 MUX2_X1
* cell instance $15792 m0 *1 208.05,95.2
X$15792 4314 2065 4556 219 320 4332 MUX2_X1
* cell instance $15797 r0 *1 206.34,95.2
X$15797 4414 2933 4332 320 219 4442 OAI21_X4
* cell instance $15801 r0 *1 211.47,95.2
X$15801 219 14109 4416 4230 4415 320 DFF_X1
* cell instance $15803 m0 *1 213.56,95.2
X$15803 3986 2495 4416 219 320 4230 MUX2_X1
* cell instance $15810 r0 *1 217.55,95.2
X$15810 219 14432 4417 4434 4226 320 DFF_X1
* cell instance $15811 m0 *1 217.74,95.2
X$15811 219 12908 4315 4331 4226 320 DFF_X1
* cell instance $15813 m0 *1 220.97,95.2
X$15813 4316 2495 4315 219 320 4331 MUX2_X1
* cell instance $15816 r0 *1 220.97,95.2
X$15816 4417 1868 4315 219 320 4225 MUX2_X1
* cell instance $15817 r0 *1 222.3,95.2
X$15817 219 14508 4418 4433 4226 320 DFF_X1
* cell instance $15818 m0 *1 222.87,95.2
X$15818 219 12954 4419 4432 4226 320 DFF_X1
* cell instance $15822 m0 *1 227.05,95.2
X$15822 219 12921 4318 4329 4317 320 DFF_X1
* cell instance $15823 m0 *1 230.28,95.2
X$15823 4320 3081 4319 219 320 4224 MUX2_X1
* cell instance $15827 r0 *1 225.72,95.2
X$15827 4431 4532 4420 320 219 3514 OAI21_X4
* cell instance $15829 r0 *1 228.57,95.2
X$15829 4320 2831 4318 219 320 4329 MUX2_X1
* cell instance $15831 r0 *1 230.09,95.2
X$15831 4318 4531 4319 219 320 4430 MUX2_X1
* cell instance $15836 r0 *1 231.61,95.2
X$15836 219 14509 4422 4429 4323 320 DFF_X1
* cell instance $15837 m0 *1 233.7,95.2
X$15837 4201 219 320 4213 BUF_X1
* cell instance $15839 m0 *1 234.27,95.2
X$15839 4421 3880 4422 219 320 4423 MUX2_X1
* cell instance $15841 m0 *1 235.79,95.2
X$15841 4322 4326 219 320 4548 OR2_X1
* cell instance $15842 m0 *1 236.55,95.2
X$15842 219 12990 4205 4204 4323 320 DFF_X1
* cell instance $15843 m0 *1 239.78,95.2
X$15843 4099 219 320 4212 BUF_X1
* cell instance $15846 r0 *1 235.03,95.2
X$15846 4203 3070 4422 219 320 4429 MUX2_X1
* cell instance $15848 r0 *1 236.74,95.2
X$15848 219 14418 4425 4424 4323 320 DFF_X1
* cell instance $15850 r0 *1 240.16,95.2
X$15850 4426 219 320 4316 BUF_X1
* cell instance $15856 m0 *1 9.88,98
X$15856 4473 219 320 4293 BUF_X2
* cell instance $15870 r0 *1 13.68,98
X$15870 219 13705 4602 4538 4143 320 DFF_X1
* cell instance $15872 m0 *1 14.82,98
X$15872 4051 219 320 4143 CLKBUF_X3
* cell instance $15874 m0 *1 20.33,98
X$15874 219 13520 4360 4539 4541 320 DFF_X1
* cell instance $15875 m0 *1 23.56,98
X$15875 4360 4361 4475 219 320 4539 MUX2_X1
* cell instance $15877 m0 *1 25.65,98
X$15877 4475 4237 4476 219 320 4474 MUX2_X1
* cell instance $15881 r0 *1 22.99,98
X$15881 219 14176 4476 4474 4541 320 DFF_X1
* cell instance $15882 r0 *1 26.22,98
X$15882 4476 2842 4605 219 320 4651 MUX2_X1
* cell instance $15883 r0 *1 27.55,98
X$15883 4601 219 320 4475 BUF_X2
* cell instance $15885 m0 *1 30.21,98
X$15885 219 12667 4542 4543 4479 320 DFF_X1
* cell instance $15886 m0 *1 28.88,98
X$15886 4542 3955 4475 219 320 4543 MUX2_X1
* cell instance $15889 r0 *1 30.21,98
X$15889 219 14086 4477 4652 4802 320 DFF_X1
* cell instance $15895 m0 *1 10.64,58.8
X$15895 219 12809 1829 1873 1733 320 DFF_X1
* cell instance $15896 m0 *1 13.87,58.8
X$15896 1740 1547 1911 219 320 1965 MUX2_X1
* cell instance $15907 r0 *1 11.21,58.8
X$15907 219 13714 1911 1965 1733 320 DFF_X1
* cell instance $15908 r0 *1 14.44,58.8
X$15908 1911 1564 1829 219 320 2076 MUX2_X1
* cell instance $15909 m0 *1 16.91,58.8
X$15909 219 12881 1912 1966 1789 320 DFF_X1
* cell instance $15910 m0 *1 15.58,58.8
X$15910 1740 1734 1912 219 320 1966 MUX2_X1
* cell instance $15911 m0 *1 20.14,58.8
X$15911 1913 1550 1738 219 320 1967 MUX2_X1
* cell instance $15912 m0 *1 21.47,58.8
X$15912 1370 219 320 1789 CLKBUF_X3
* cell instance $15913 m0 *1 22.42,58.8
X$15913 1789 219 320 CLKBUF_X1
* cell instance $15919 r0 *1 18.24,58.8
X$15919 219 14119 1913 1967 1789 320 DFF_X1
* cell instance $15920 r0 *1 21.47,58.8
X$15920 1913 1552 1912 219 320 1914 MUX2_X1
* cell instance $15921 r0 *1 22.8,58.8
X$15921 1914 1639 2076 219 320 1917 MUX2_X1
* cell instance $15924 r0 *1 25.08,58.8
X$15924 219 14011 2018 2077 1915 320 DFF_X1
* cell instance $15926 m0 *1 26.41,58.8
X$15926 1740 219 320 1738 BUF_X2
* cell instance $15928 r0 *1 28.31,58.8
X$15928 2016 1303 2018 219 320 2077 MUX2_X1
* cell instance $15929 r0 *1 29.64,58.8
X$15929 2015 1261 1916 219 320 2078 MUX2_X1
* cell instance $15930 r0 *1 30.97,58.8
X$15930 1915 219 320 CLKBUF_X1
* cell instance $15931 r0 *1 31.54,58.8
X$15931 2018 1374 1916 219 320 2019 MUX2_X1
* cell instance $15933 m0 *1 33.82,58.8
X$15933 219 12749 1831 1830 1915 320 DFF_X1
* cell instance $15938 m0 *1 41.04,58.8
X$15938 1881 1835 1973 219 320 1918 MUX2_X1
* cell instance $15939 m0 *1 42.37,58.8
X$15939 1918 1640 1878 219 320 1882 MUX2_X1
* cell instance $15940 m0 *1 43.7,58.8
X$15940 1515 219 320 1744 CLKBUF_X3
* cell instance $15941 m0 *1 44.65,58.8
X$15941 1744 219 320 CLKBUF_X1
* cell instance $15943 m0 *1 46.74,58.8
X$15943 219 13072 1922 1920 1744 320 DFF_X1
* cell instance $15946 m0 *1 50.92,58.8
X$15946 219 13123 1833 1885 1559 320 DFF_X1
* cell instance $15947 m0 *1 54.15,58.8
X$15947 219 13039 1923 1976 1559 320 DFF_X1
* cell instance $15948 m0 *1 57.38,58.8
X$15948 1923 1552 1924 219 320 1887 MUX2_X1
* cell instance $15952 m0 *1 62.7,58.8
X$15952 1745 1567 1928 219 320 1836 MUX2_X1
* cell instance $15953 m0 *1 64.03,58.8
X$15953 1926 1835 1836 219 320 1927 MUX2_X1
* cell instance $15954 m0 *1 65.36,58.8
X$15954 1749 1898 1928 219 320 1837 MUX2_X1
* cell instance $15960 r0 *1 45.6,58.8
X$15960 1921 1384 2016 219 320 1919 MUX2_X1
* cell instance $15961 r0 *1 46.93,58.8
X$15961 2016 1385 1922 219 320 1920 MUX2_X1
* cell instance $15962 r0 *1 48.26,58.8
X$15962 1921 1377 1922 219 320 2184 MUX2_X1
* cell instance $15966 r0 *1 51.68,58.8
X$15966 1738 1609 1923 219 320 1976 MUX2_X1
* cell instance $15967 r0 *1 53.01,58.8
X$15967 1738 1695 1924 219 320 2083 MUX2_X1
* cell instance $15968 r0 *1 54.34,58.8
X$15968 219 13810 1924 2083 1559 320 DFF_X1
* cell instance $15969 r0 *1 57.57,58.8
X$15969 1834 1640 1917 219 320 2084 MUX2_X1
* cell instance $15970 r0 *1 58.9,58.8
X$15970 1882 2084 1643 320 219 1925 MUX2_X2
* cell instance $15977 r0 *1 63.27,58.8
X$15977 219 14157 1928 1837 1644 320 DFF_X1
* cell instance $15980 r0 *1 67.64,58.8
X$15980 219 14272 2023 1985 1644 320 DFF_X1
* cell instance $15981 m0 *1 70.3,58.8
X$15981 2092 1562 1984 219 320 1889 MUX2_X1
* cell instance $15983 m0 *1 71.63,58.8
X$15983 1749 1983 1891 219 320 1838 MUX2_X1
* cell instance $15984 m0 *1 72.96,58.8
X$15984 1891 1552 1988 219 320 1984 MUX2_X1
* cell instance $15985 m0 *1 74.29,58.8
X$15985 219 12890 1990 1989 1753 320 DFF_X1
* cell instance $15986 m0 *1 77.52,58.8
X$15986 1842 1983 1990 219 320 1989 MUX2_X1
* cell instance $15988 r0 *1 70.87,58.8
X$15988 1749 2037 2023 219 320 1985 MUX2_X1
* cell instance $15989 r0 *1 72.2,58.8
X$15989 1749 1999 1988 219 320 2094 MUX2_X1
* cell instance $15990 r0 *1 73.53,58.8
X$15990 219 14265 1988 2094 1929 320 DFF_X1
* cell instance $15992 r0 *1 77.14,58.8
X$15992 1752 1844 1990 219 320 2027 MUX2_X1
* cell instance $15994 m0 *1 79.42,58.8
X$15994 1842 1647 1892 219 320 1839 MUX2_X1
* cell instance $15997 m0 *1 80.94,58.8
X$15997 1892 1933 1755 219 320 1993 MUX2_X1
* cell instance $15998 m0 *1 82.27,58.8
X$15998 1753 219 320 CLKBUF_X1
* cell instance $15999 m0 *1 82.84,58.8
X$15999 1930 1756 1842 219 320 1994 MUX2_X1
* cell instance $16002 m0 *1 85.12,58.8
X$16002 219 12840 1930 1994 1753 320 DFF_X1
* cell instance $16005 m0 *1 89.3,58.8
X$16005 1652 1983 1843 219 320 1896 MUX2_X1
* cell instance $16008 r0 *1 82.27,58.8
X$16008 1840 1392 1930 219 320 2028 MUX2_X1
* cell instance $16009 r0 *1 83.6,58.8
X$16009 2028 1651 1993 219 320 2030 MUX2_X1
* cell instance $16013 r0 *1 87.4,58.8
X$16013 219 13967 1931 1996 1481 320 DFF_X1
* cell instance $16014 r0 *1 90.63,58.8
X$16014 1931 2086 1652 219 320 1996 MUX2_X1
* cell instance $16015 m0 *1 91.2,58.8
X$16015 219 12789 1932 1997 1481 320 DFF_X1
* cell instance $16020 r0 *1 91.96,58.8
X$16020 1931 1844 1932 219 320 2034 MUX2_X1
* cell instance $16021 r0 *1 93.29,58.8
X$16021 1932 2032 1652 219 320 1997 MUX2_X1
* cell instance $16023 r0 *1 97.66,58.8
X$16023 1652 2148 2101 219 320 2036 MUX2_X1
* cell instance $16025 m0 *1 100.7,58.8
X$16025 219 12798 1934 2000 1935 320 DFF_X1
* cell instance $16026 m0 *1 99.37,58.8
X$16026 1652 1999 1934 219 320 2000 MUX2_X1
* cell instance $16027 m0 *1 103.93,58.8
X$16027 1845 1933 1934 219 320 2001 MUX2_X1
* cell instance $16029 m0 *1 106.78,58.8
X$16029 219 12805 2003 2040 1935 320 DFF_X1
* cell instance $16036 r0 *1 100.32,58.8
X$16036 1652 2037 2039 219 320 2038 MUX2_X1
* cell instance $16037 r0 *1 101.65,58.8
X$16037 2101 1933 2039 219 320 2102 MUX2_X1
* cell instance $16040 r0 *1 103.55,58.8
X$16040 2102 1651 2001 219 320 2199 MUX2_X1
* cell instance $16041 r0 *1 104.88,58.8
X$16041 1578 219 320 1935 CLKBUF_X3
* cell instance $16042 r0 *1 105.83,58.8
X$16042 1935 219 320 14770 INV_X1
* cell instance $16045 r0 *1 107.16,58.8
X$16045 219 14071 2041 2104 1935 320 DFF_X1
* cell instance $16052 m0 *1 123.5,58.8
X$16052 219 13022 1936 1900 1485 320 DFF_X1
* cell instance $16062 r0 *1 127.68,58.8
X$16062 219 14306 2006 1937 1485 320 DFF_X1
* cell instance $16063 m0 *1 128.06,58.8
X$16063 387 1041 2006 219 320 1937 MUX2_X1
* cell instance $16066 m0 *1 129.96,58.8
X$16066 1936 1629 2006 219 320 1938 MUX2_X1
* cell instance $16071 r0 *1 131.1,58.8
X$16071 441 1011 2044 219 320 2112 MUX2_X1
* cell instance $16072 r0 *1 132.43,58.8
X$16072 219 14367 2044 2112 1763 320 DFF_X1
* cell instance $16073 m0 *1 134.52,58.8
X$16073 219 13096 1939 2009 1763 320 DFF_X1
* cell instance $16074 m0 *1 133.19,58.8
X$16074 527 1035 1939 219 320 2009 MUX2_X1
* cell instance $16075 m0 *1 137.75,58.8
X$16075 527 1041 1940 219 320 1906 MUX2_X1
* cell instance $16077 r0 *1 135.66,58.8
X$16077 1902 219 320 1763 CLKBUF_X3
* cell instance $16080 r0 *1 137.75,58.8
X$16080 1939 1445 1940 219 320 2046 MUX2_X1
* cell instance $16081 r0 *1 139.08,58.8
X$16081 1847 219 320 2116 INV_X1
* cell instance $16084 m0 *1 139.46,58.8
X$16084 219 12579 1941 2010 1656 320 DFF_X1
* cell instance $16085 r0 *1 139.65,58.8
X$16085 2116 501 219 320 2045 NAND2_X1
* cell instance $16086 r0 *1 140.22,58.8
X$16086 2046 1274 1764 219 320 2120 MUX2_X1
* cell instance $16087 r0 *1 141.55,58.8
X$16087 1764 219 320 2122 INV_X1
* cell instance $16088 r0 *1 141.93,58.8
X$16088 2123 320 1314 219 BUF_X4
* cell instance $16089 m0 *1 143.26,58.8
X$16089 288 903 1941 219 320 2010 MUX2_X1
* cell instance $16092 m0 *1 144.78,58.8
X$16092 288 902 1848 219 320 1910 MUX2_X1
* cell instance $16094 r0 *1 143.26,58.8
X$16094 2122 733 219 320 2124 NAND2_X1
* cell instance $16096 r0 *1 144.59,58.8
X$16096 1941 1314 1848 219 320 1942 MUX2_X1
* cell instance $16098 r0 *1 146.11,58.8
X$16098 1766 219 320 2127 INV_X1
* cell instance $16099 r0 *1 146.49,58.8
X$16099 2127 501 219 320 2047 NAND2_X1
* cell instance $16100 m0 *1 146.68,58.8
X$16100 219 13547 1944 1909 1656 320 DFF_X1
* cell instance $16105 r0 *1 148.96,58.8
X$16105 1768 219 320 2128 INV_X1
* cell instance $16106 r0 *1 149.34,58.8
X$16106 2128 501 219 320 2048 NAND2_X1
* cell instance $16108 r0 *1 150.1,58.8
X$16108 1944 1445 1849 219 320 2049 MUX2_X1
* cell instance $16109 m0 *1 150.48,58.8
X$16109 219 12704 1849 1850 1656 320 DFF_X1
* cell instance $16113 r0 *1 151.43,58.8
X$16113 219 522 320 2131 BUF_X8
* cell instance $16116 r0 *1 155.04,58.8
X$16116 219 14009 2007 2008 2050 320 DFF_X1
* cell instance $16117 m0 *1 155.8,58.8
X$16117 294 1492 2007 219 320 2008 MUX2_X1
* cell instance $16123 r0 *1 158.27,58.8
X$16123 294 1493 1946 219 320 1945 MUX2_X1
* cell instance $16126 r0 *1 161.88,58.8
X$16126 1947 1585 1948 320 219 2296 OAI21_X4
* cell instance $16127 m0 *1 163.02,58.8
X$16127 1405 1903 219 320 1947 OR2_X1
* cell instance $16129 m0 *1 163.78,58.8
X$16129 1903 1853 1948 219 320 2161 MUX2_X1
* cell instance $16131 r0 *1 164.35,58.8
X$16131 2138 1585 1949 320 219 2139 OAI21_X4
* cell instance $16133 m0 *1 165.49,58.8
X$16133 1405 2004 219 320 2138 OR2_X1
* cell instance $16134 m0 *1 166.44,58.8
X$16134 2004 1853 1949 219 320 2005 MUX2_X1
* cell instance $16136 m0 *1 167.96,58.8
X$16136 364 219 320 1661 CLKBUF_X3
* cell instance $16137 m0 *1 168.91,58.8
X$16137 1661 219 320 14752 INV_X1
* cell instance $16141 r0 *1 167.58,58.8
X$16141 219 13948 2055 2135 1661 320 DFF_X1
* cell instance $16147 m0 *1 10.07,89.6
X$16147 219 13308 3752 3804 3296 320 DFF_X1
* cell instance $16151 m0 *1 15.77,89.6
X$16151 219 13146 3886 3753 3353 320 DFF_X1
* cell instance $16153 m0 *1 19.19,89.6
X$16153 3943 3126 3807 219 320 3901 MUX2_X1
* cell instance $16157 m0 *1 24.51,89.6
X$16157 3674 1553 3846 219 320 3887 MUX2_X1
* cell instance $16165 r0 *1 7.6,89.6
X$16165 3941 219 320 3773 BUF_X2
* cell instance $16169 r0 *1 16.15,89.6
X$16169 3990 219 320 1734 CLKBUF_X3
* cell instance $16171 r0 *1 17.86,89.6
X$16171 3886 2957 3712 219 320 3943 MUX2_X1
* cell instance $16175 r0 *1 21.66,89.6
X$16175 3955 219 320 1550 CLKBUF_X3
* cell instance $16178 r0 *1 23.75,89.6
X$16178 219 13845 3846 3887 3944 320 DFF_X1
* cell instance $16179 m0 *1 26.41,89.6
X$16179 3754 2842 3846 219 320 3894 MUX2_X1
* cell instance $16181 m0 *1 27.74,89.6
X$16181 3675 1303 3889 219 320 3847 MUX2_X1
* cell instance $16184 m0 *1 30.02,89.6
X$16184 3889 3848 3849 219 320 3892 MUX2_X1
* cell instance $16185 m0 *1 31.35,89.6
X$16185 3674 1261 3849 219 320 3893 MUX2_X1
* cell instance $16186 m0 *1 32.68,89.6
X$16186 3894 2963 3892 219 320 3895 MUX2_X1
* cell instance $16190 m0 *1 39.33,89.6
X$16190 3895 2776 219 320 3897 NAND2_X1
* cell instance $16194 m0 *1 42.37,89.6
X$16194 3897 3756 4279 219 320 3899 NAND3_X2
* cell instance $16198 m0 *1 46.17,89.6
X$16198 219 13620 3996 3850 3946 320 DFF_X1
* cell instance $16201 r0 *1 26.98,89.6
X$16201 219 14588 3889 3847 3944 320 DFF_X1
* cell instance $16202 r0 *1 30.21,89.6
X$16202 219 14156 3849 3893 3944 320 DFF_X1
* cell instance $16204 r0 *1 34.96,89.6
X$16204 3945 1307 3992 219 320 4101 MUX2_X1
* cell instance $16205 r0 *1 36.29,89.6
X$16205 3993 219 320 1307 CLKBUF_X3
* cell instance $16207 r0 *1 38.76,89.6
X$16207 4006 219 320 1469 CLKBUF_X3
* cell instance $16210 r0 *1 41.61,89.6
X$16210 3910 219 320 1523 CLKBUF_X3
* cell instance $16214 r0 *1 46.74,89.6
X$16214 3945 1385 3996 219 320 3850 MUX2_X1
* cell instance $16216 r0 *1 48.45,89.6
X$16216 3947 320 1385 219 BUF_X4
* cell instance $16218 r0 *1 49.97,89.6
X$16218 3899 3044 3851 320 219 3397 OAI21_X4
* cell instance $16220 m0 *1 50.54,89.6
X$16220 3900 2149 3901 219 320 3851 MUX2_X1
* cell instance $16221 m0 *1 52.06,89.6
X$16221 3852 1384 3675 219 320 3904 MUX2_X1
* cell instance $16222 m0 *1 53.39,89.6
X$16222 219 13605 3852 3904 3313 320 DFF_X1
* cell instance $16225 r0 *1 52.44,89.6
X$16225 3675 1385 3951 219 320 3949 MUX2_X1
* cell instance $16227 r0 *1 53.96,89.6
X$16227 3852 3950 3951 219 320 3903 MUX2_X1
* cell instance $16229 r0 *1 55.48,89.6
X$16229 3845 219 320 3952 CLKBUF_X2
* cell instance $16232 r0 *1 58.14,89.6
X$16232 219 13749 3953 4002 3361 320 DFF_X1
* cell instance $16234 m0 *1 58.52,89.6
X$16234 219 13516 3757 3906 3361 320 DFF_X1
* cell instance $16235 r0 *1 61.37,89.6
X$16235 3952 1746 3909 219 320 3853 MUX2_X1
* cell instance $16237 m0 *1 62.13,89.6
X$16237 219 13591 3909 3853 3361 320 DFF_X1
* cell instance $16238 m0 *1 66.88,89.6
X$16238 3910 320 2148 219 BUF_X4
* cell instance $16239 m0 *1 68.21,89.6
X$16239 219 13250 3819 3911 3680 320 DFF_X1
* cell instance $16240 m0 *1 71.44,89.6
X$16240 3955 320 1756 219 BUF_X4
* cell instance $16247 r0 *1 63.27,89.6
X$16247 219 13941 3954 4004 3361 320 DFF_X1
* cell instance $16249 r0 *1 66.69,89.6
X$16249 4006 320 2086 219 BUF_X4
* cell instance $16250 r0 *1 68.02,89.6
X$16250 219 14617 4009 4008 3680 320 DFF_X1
* cell instance $16251 r0 *1 71.25,89.6
X$16251 3990 320 1571 219 BUF_X4
* cell instance $16253 m0 *1 74.1,89.6
X$16253 3680 219 320 CLKBUF_X1
* cell instance $16254 m0 *1 73.15,89.6
X$16254 3723 219 320 3680 CLKBUF_X3
* cell instance $16256 r0 *1 74.1,89.6
X$16256 3955 320 3659 219 BUF_X4
* cell instance $16258 m0 *1 75.05,89.6
X$16258 3947 320 2037 219 BUF_X4
* cell instance $16260 r0 *1 75.43,89.6
X$16260 3948 320 2032 219 BUF_X4
* cell instance $16262 m0 *1 79.99,89.6
X$16262 219 13327 3854 3916 3761 320 DFF_X1
* cell instance $16264 m0 *1 83.22,89.6
X$16264 3723 219 320 3761 CLKBUF_X3
* cell instance $16269 r0 *1 82.27,89.6
X$16269 3761 219 320 CLKBUF_X1
* cell instance $16271 m0 *1 84.74,89.6
X$16271 3917 4289 219 320 3921 NOR2_X1
* cell instance $16275 m0 *1 86.26,89.6
X$16275 3584 1480 3763 219 320 3918 MUX2_X1
* cell instance $16276 m0 *1 87.59,89.6
X$16276 219 3922 3920 3764 3765 3921 320 OR4_X4
* cell instance $16283 m0 *1 95,89.6
X$16283 3595 320 3370 219 BUF_X4
* cell instance $16286 r0 *1 96.9,89.6
X$16286 219 14340 3956 4124 3589 320 DFF_X1
* cell instance $16287 m0 *1 97.66,89.6
X$16287 3686 320 3486 219 BUF_X4
* cell instance $16289 m0 *1 98.99,89.6
X$16289 2665 1651 219 320 3923 NAND2_X1
* cell instance $16292 m0 *1 101.27,89.6
X$16292 3767 3496 3684 219 320 3829 MUX2_X1
* cell instance $16293 m0 *1 102.6,89.6
X$16293 3768 1933 3767 219 320 3855 MUX2_X1
* cell instance $16294 m0 *1 103.93,89.6
X$16294 3856 219 320 3589 CLKBUF_X3
* cell instance $16295 m0 *1 104.88,89.6
X$16295 3857 2792 219 320 3957 NOR2_X1
* cell instance $16296 m0 *1 105.45,89.6
X$16296 3589 219 320 CLKBUF_X1
* cell instance $16298 m0 *1 112.1,89.6
X$16298 3859 3858 3831 219 320 3927 MUX2_X1
* cell instance $16299 m0 *1 113.43,89.6
X$16299 3859 3860 3769 219 320 4025 MUX2_X1
* cell instance $16302 m0 *1 117.99,89.6
X$16302 3456 3860 3861 219 320 3931 MUX2_X1
* cell instance $16303 m0 *1 119.32,89.6
X$16303 219 12993 3861 3931 3495 320 DFF_X1
* cell instance $16306 m0 *1 125.78,89.6
X$16306 337 3135 3862 219 320 3932 MUX2_X1
* cell instance $16309 m0 *1 129.39,89.6
X$16309 3862 3260 3742 219 320 4030 MUX2_X1
* cell instance $16313 m0 *1 134.71,89.6
X$16313 219 13065 3743 3689 3604 320 DFF_X1
* cell instance $16314 m0 *1 137.94,89.6
X$16314 1902 219 320 3604 CLKBUF_X3
* cell instance $16318 m0 *1 146.68,89.6
X$16318 3773 3136 3863 219 320 3935 MUX2_X1
* cell instance $16319 m0 *1 148.01,89.6
X$16319 219 12846 3863 3935 3375 320 DFF_X1
* cell instance $16320 m0 *1 151.24,89.6
X$16320 3864 3775 3863 219 320 3776 MUX2_X1
* cell instance $16323 m0 *1 158.84,89.6
X$16323 3937 3865 219 320 220 NOR2_X2
* cell instance $16324 m0 *1 159.79,89.6
X$16324 3968 3865 219 320 234 NOR2_X2
* cell instance $16325 m0 *1 160.74,89.6
X$16325 4044 3865 219 320 391 NOR2_X2
* cell instance $16326 m0 *1 161.69,89.6
X$16326 4048 3865 219 320 393 NOR2_X2
* cell instance $16328 m0 *1 164.16,89.6
X$16328 3939 3865 219 320 423 NOR2_X2
* cell instance $16334 r0 *1 103.93,89.6
X$16334 3855 2792 219 320 3958 NOR2_X1
* cell instance $16335 r0 *1 104.5,89.6
X$16335 4023 2672 219 320 4126 NOR2_X1
* cell instance $16336 r0 *1 105.07,89.6
X$16336 4022 1933 3959 219 320 4023 MUX2_X1
* cell instance $16337 r0 *1 106.4,89.6
X$16337 3684 3860 3959 219 320 4024 MUX2_X1
* cell instance $16338 r0 *1 107.73,89.6
X$16338 219 14649 3959 4024 3493 320 DFF_X1
* cell instance $16343 r0 *1 113.81,89.6
X$16343 219 14480 3769 4025 3493 320 DFF_X1
* cell instance $16350 r0 *1 119.7,89.6
X$16350 219 14241 4028 3960 3495 320 DFF_X1
* cell instance $16351 r0 *1 122.93,89.6
X$16351 3456 3858 3961 219 320 4029 MUX2_X1
* cell instance $16355 r0 *1 125.4,89.6
X$16355 219 14430 3862 3932 3134 320 DFF_X1
* cell instance $16356 r0 *1 128.63,89.6
X$16356 337 2799 3963 219 320 3962 MUX2_X1
* cell instance $16359 r0 *1 130.91,89.6
X$16359 337 2805 4032 219 320 4031 MUX2_X1
* cell instance $16360 r0 *1 132.24,89.6
X$16360 219 13931 4032 4031 3604 320 DFF_X1
* cell instance $16364 r0 *1 139.08,89.6
X$16364 222 3135 4034 219 320 3964 MUX2_X1
* cell instance $16368 r0 *1 141.74,89.6
X$16368 222 3136 3965 219 320 4035 MUX2_X1
* cell instance $16373 r0 *1 148.2,89.6
X$16373 3773 3135 3864 219 320 4036 MUX2_X1
* cell instance $16374 r0 *1 149.53,89.6
X$16374 219 14027 3864 4036 3375 320 DFF_X1
* cell instance $16379 r0 *1 157.13,89.6
X$16379 4040 3966 219 320 2577 NOR2_X2
* cell instance $16380 r0 *1 158.08,89.6
X$16380 4140 3966 219 320 2576 NOR2_X2
* cell instance $16381 r0 *1 159.03,89.6
X$16381 4039 3966 219 320 242 NOR2_X2
* cell instance $16382 r0 *1 159.98,89.6
X$16382 4047 3966 219 320 418 NOR2_X2
* cell instance $16383 r0 *1 160.93,89.6
X$16383 3969 4045 4043 219 320 4044 NOR3_X1
* cell instance $16384 r0 *1 161.69,89.6
X$16384 3972 3970 3971 219 320 4048 NOR3_X1
* cell instance $16386 r0 *1 162.83,89.6
X$16386 4049 3865 219 320 231 NOR2_X2
* cell instance $16389 m0 *1 168.72,89.6
X$16389 3866 320 2925 219 BUF_X4
* cell instance $16390 m0 *1 167.77,89.6
X$16390 4046 3865 219 320 221 NOR2_X2
* cell instance $16391 m0 *1 170.05,89.6
X$16391 3384 3778 3276 658 320 219 3777 OAI22_X1
* cell instance $16393 m0 *1 171.19,89.6
X$16393 3938 3865 219 320 276 NOR2_X2
* cell instance $16394 m0 *1 172.14,89.6
X$16394 3391 3696 3158 1708 320 219 3867 OAI22_X1
* cell instance $16395 m0 *1 173.09,89.6
X$16395 3233 3778 3335 658 320 219 4037 OAI22_X1
* cell instance $16396 m0 *1 174.04,89.6
X$16396 4193 1708 3778 3457 320 219 3779 OAI22_X2
* cell instance $16399 r0 *1 168.53,89.6
X$16399 4041 3865 219 320 381 NOR2_X2
* cell instance $16402 r0 *1 171.76,89.6
X$16402 2922 3154 3974 219 4099 320 AOI21_X2
* cell instance $16403 r0 *1 173.09,89.6
X$16403 3867 4037 219 320 3974 NOR2_X1
* cell instance $16408 m0 *1 177.46,89.6
X$16408 3868 2538 3869 1343 320 219 3936 OAI22_X1
* cell instance $16409 m0 *1 176.13,89.6
X$16409 3866 320 3865 219 BUF_X4
* cell instance $16410 m0 *1 178.41,89.6
X$16410 3975 3780 3936 219 320 3834 NOR3_X1
* cell instance $16411 m0 *1 179.17,89.6
X$16411 3788 3394 2538 4254 320 219 3832 OAI22_X2
* cell instance $16412 m0 *1 180.88,89.6
X$16412 3925 3557 1343 3390 320 219 3783 OAI22_X2
* cell instance $16413 m0 *1 182.59,89.6
X$16413 3279 3705 219 320 3933 NOR2_X1
* cell instance $16418 r0 *1 178.03,89.6
X$16418 2912 3703 219 320 3976 NOR2_X1
* cell instance $16419 r0 *1 178.6,89.6
X$16419 3397 3703 219 320 3975 NOR2_X1
* cell instance $16420 r0 *1 179.17,89.6
X$16420 3781 3394 3785 3557 320 219 3934 OAI22_X1
* cell instance $16422 r0 *1 180.5,89.6
X$16422 3397 3816 219 320 4033 NOR2_X1
* cell instance $16424 m0 *1 184.49,89.6
X$16424 3782 3224 3784 3514 320 219 3930 OAI22_X1
* cell instance $16425 m0 *1 183.54,89.6
X$16425 3868 549 3271 1203 320 219 3929 OAI22_X1
* cell instance $16426 m0 *1 185.44,89.6
X$16426 3279 3703 219 320 3928 NOR2_X1
* cell instance $16428 m0 *1 186.2,89.6
X$16428 3928 3930 3929 219 320 3926 NOR3_X1
* cell instance $16429 m0 *1 186.96,89.6
X$16429 3926 3792 219 320 417 NOR2_X2
* cell instance $16431 m0 *1 190.95,89.6
X$16431 3868 544 3869 1206 320 219 3870 OAI22_X1
* cell instance $16432 m0 *1 191.9,89.6
X$16432 3871 544 3979 1206 320 219 3924 OAI22_X1
* cell instance $16433 m0 *1 192.85,89.6
X$16433 3193 3816 219 320 3872 NOR2_X1
* cell instance $16436 m0 *1 195.13,89.6
X$16436 4019 3725 219 320 225 NOR2_X2
* cell instance $16437 m0 *1 196.08,89.6
X$16437 219 13588 3913 3915 3210 320 DFF_X1
* cell instance $16438 m0 *1 199.31,89.6
X$16438 3413 2364 3913 219 320 3915 MUX2_X1
* cell instance $16439 m0 *1 200.64,89.6
X$16439 2259 3912 219 320 3914 OR2_X1
* cell instance $16442 r0 *1 184.3,89.6
X$16442 3279 3816 219 320 3789 NOR2_X1
* cell instance $16443 r0 *1 184.87,89.6
X$16443 4027 3865 219 320 230 NOR2_X2
* cell instance $16448 r0 *1 188.67,89.6
X$16448 4026 3282 219 320 272 NOR2_X2
* cell instance $16449 r0 *1 189.62,89.6
X$16449 3788 3374 3925 3613 320 219 4020 OAI22_X1
* cell instance $16450 r0 *1 190.57,89.6
X$16450 3977 706 3978 1131 320 219 3980 OAI22_X1
* cell instance $16451 r0 *1 191.52,89.6
X$16451 3977 544 3978 1206 320 219 3791 OAI22_X1
* cell instance $16452 r0 *1 192.47,89.6
X$16452 3872 4020 3980 219 320 4019 NOR3_X1
* cell instance $16455 r0 *1 195.51,89.6
X$16455 4310 3282 219 320 3799 NOR2_X1
* cell instance $16456 r0 *1 196.08,89.6
X$16456 3914 2933 4017 320 219 4018 OAI21_X4
* cell instance $16457 r0 *1 198.55,89.6
X$16457 3913 2065 3793 219 320 4017 MUX2_X1
* cell instance $16458 r0 *1 199.88,89.6
X$16458 3873 3982 2482 320 219 4015 MUX2_X2
* cell instance $16459 r0 *1 201.59,89.6
X$16459 4012 3981 3982 320 219 4014 OAI21_X4
* cell instance $16461 m0 *1 201.78,89.6
X$16461 2072 3873 219 320 4012 OR2_X1
* cell instance $16464 m0 *1 203.68,89.6
X$16464 219 13616 3875 4011 3874 320 DFF_X1
* cell instance $16466 r0 *1 205.58,89.6
X$16466 3707 2490 3875 219 320 4011 MUX2_X1
* cell instance $16467 r0 *1 206.91,89.6
X$16467 3721 2065 3875 219 320 3983 MUX2_X1
* cell instance $16468 m0 *1 207.48,89.6
X$16468 3707 2165 3908 219 320 3876 MUX2_X1
* cell instance $16472 m0 *1 209.76,89.6
X$16472 219 13613 3907 3877 3291 320 DFF_X1
* cell instance $16475 m0 *1 213.94,89.6
X$16475 219 13023 4001 3878 3615 320 DFF_X1
* cell instance $16476 m0 *1 217.17,89.6
X$16476 3615 219 320 CLKBUF_X1
* cell instance $16477 m0 *1 217.74,89.6
X$16477 219 13151 3795 3794 3615 320 DFF_X1
* cell instance $16480 m0 *1 227.24,89.6
X$16480 3898 3171 4000 219 320 3902 MUX2_X1
* cell instance $16481 m0 *1 228.57,89.6
X$16481 1869 219 320 3521 CLKBUF_X3
* cell instance $16482 m0 *1 229.52,89.6
X$16482 3521 219 320 CLKBUF_X1
* cell instance $16486 m0 *1 232.56,89.6
X$16486 3985 3070 3797 219 320 3896 MUX2_X1
* cell instance $16488 m0 *1 234.08,89.6
X$16488 3994 3880 3797 219 320 3881 MUX2_X1
* cell instance $16489 m0 *1 235.41,89.6
X$16489 3173 3888 219 320 3891 OR2_X1
* cell instance $16490 m0 *1 236.17,89.6
X$16490 219 13161 3882 3988 3415 320 DFF_X1
* cell instance $16491 m0 *1 239.4,89.6
X$16491 3884 219 320 4214 BUF_X1
* cell instance $16493 m0 *1 240.16,89.6
X$16493 3843 219 320 3885 BUF_X1
* cell instance $16495 r0 *1 208.24,89.6
X$16495 3907 3062 3908 219 320 4108 MUX2_X1
* cell instance $16496 r0 *1 209.57,89.6
X$16496 3707 2256 3907 219 320 3877 MUX2_X1
* cell instance $16497 r0 *1 210.9,89.6
X$16497 219 13747 3984 4005 3615 320 DFF_X1
* cell instance $16498 r0 *1 214.13,89.6
X$16498 3984 4001 3096 320 219 3982 MUX2_X2
* cell instance $16500 r0 *1 216.22,89.6
X$16500 4092 2495 4001 219 320 3878 MUX2_X1
* cell instance $16501 r0 *1 217.55,89.6
X$16501 2362 219 320 3615 CLKBUF_X3
* cell instance $16503 r0 *1 218.69,89.6
X$16503 3796 3879 2072 320 219 3905 MUX2_X2
* cell instance $16507 r0 *1 224.39,89.6
X$16507 219 14561 4000 3999 3521 320 DFF_X1
* cell instance $16508 r0 *1 227.62,89.6
X$16508 3998 3070 4000 219 320 3999 MUX2_X1
* cell instance $16509 r0 *1 228.95,89.6
X$16509 3998 3293 3898 219 320 3997 MUX2_X1
* cell instance $16516 r0 *1 232.37,89.6
X$16516 3985 3293 3994 219 320 3995 MUX2_X1
* cell instance $16517 r0 *1 233.7,89.6
X$16517 3891 3624 3881 320 219 3613 OAI21_X4
* cell instance $16518 r0 *1 236.17,89.6
X$16518 3985 3081 3882 219 320 3988 MUX2_X1
* cell instance $16519 r0 *1 237.5,89.6
X$16519 219 14510 3991 3989 3415 320 DFF_X1
* cell instance $16600 m0 *1 117.04,238
X$16600 12413 219 320 7265 BUF_X2
* cell instance $16601 r0 *1 117.8,238
X$16601 12416 219 320 6623 BUF_X2
* cell instance $16605 r0 *1 119.7,238
X$16605 12385 219 320 8568 CLKBUF_X2
* cell instance $16608 r0 *1 121.6,238
X$16608 12386 219 320 8167 BUF_X2
* cell instance $16611 r0 *1 123.31,238
X$16611 12387 219 320 11593 BUF_X1
* cell instance $16617 r0 *1 125.97,238
X$16617 12388 219 320 10964 BUF_X1
* cell instance $16621 r0 *1 128.63,238
X$16621 12390 219 320 9543 BUF_X1
* cell instance $16622 r0 *1 129.2,238
X$16622 12391 219 320 11943 BUF_X1
* cell instance $16626 r0 *1 134.33,238
X$16626 12393 219 320 9924 BUF_X1
* cell instance $16630 r0 *1 141.17,238
X$16630 12394 219 320 11975 BUF_X1
* cell instance $16636 r0 *1 152.38,238
X$16636 9521 219 320 12447 BUF_X1
* cell instance $16641 r0 *1 156.56,238
X$16641 8764 219 320 12370 BUF_X1
* cell instance $16646 r0 *1 162.07,238
X$16646 9023 219 320 12371 BUF_X1
* cell instance $16647 r0 *1 162.64,238
X$16647 8902 219 320 12392 BUF_X1
* cell instance $16648 r0 *1 163.21,238
X$16648 7229 219 320 12464 BUF_X1
* cell instance $16652 r0 *1 171.38,238
X$16652 9630 219 320 12444 BUF_X1
* cell instance $16657 r0 *1 173.28,238
X$16657 9516 219 320 12442 BUF_X1
* cell instance $16661 r0 *1 178.03,238
X$16661 10409 219 320 12372 BUF_X1
* cell instance $16665 r0 *1 180.5,238
X$16665 11915 219 320 12483 BUF_X1
* cell instance $16670 r0 *1 186.39,238
X$16670 10401 219 320 12414 BUF_X1
* cell instance $16675 r0 *1 193.99,238
X$16675 12384 219 320 12374 BUF_X1
* cell instance $16676 r0 *1 194.56,238
X$16676 12383 219 320 12345 BUF_X1
* cell instance $16680 r0 *1 197.41,238
X$16680 12380 219 320 12381 BUF_X1
* cell instance $16684 r0 *1 200.07,238
X$16684 12377 219 320 12117 BUF_X1
* cell instance $16770 r0 *1 122.74,221.2
X$16770 10642 219 320 10539 CLKBUF_X3
* cell instance $16776 m0 *1 128.25,221.2
X$16776 11911 219 320 14742 INV_X1
* cell instance $16778 m0 *1 128.63,221.2
X$16778 11943 7612 11973 219 320 12104 MUX2_X1
* cell instance $16779 m0 *1 129.96,221.2
X$16779 219 12920 12038 12037 11911 320 DFF_X1
* cell instance $16783 r0 *1 129.77,221.2
X$16783 219 14452 11973 12104 11911 320 DFF_X1
* cell instance $16785 m0 *1 134.52,221.2
X$16785 219 12904 12007 12106 11911 320 DFF_X1
* cell instance $16788 m0 *1 137.94,221.2
X$16788 219 13004 12041 12109 11790 320 DFF_X1
* cell instance $16790 m0 *1 141.36,221.2
X$16790 11975 11471 12524 320 219 12008 HA_X1
* cell instance $16795 r0 *1 135.47,221.2
X$16795 11945 7691 12107 219 320 12108 MUX2_X1
* cell instance $16798 r0 *1 137.37,221.2
X$16798 11945 7612 12007 219 320 12106 MUX2_X1
* cell instance $16800 r0 *1 139.08,221.2
X$16800 11858 7612 12041 219 320 12109 MUX2_X1
* cell instance $16801 r0 *1 140.41,221.2
X$16801 11858 7691 12040 219 320 12066 MUX2_X1
* cell instance $16804 r0 *1 142.69,221.2
X$16804 12008 12110 320 219 12068 XNOR2_X1
* cell instance $16805 r0 *1 143.83,221.2
X$16805 12068 11977 219 320 12112 NAND2_X1
* cell instance $16806 m0 *1 144.59,221.2
X$16806 219 12044 12010 12009 11790 320 DFF_X1
* cell instance $16808 m0 *1 147.82,221.2
X$16808 12074 12010 12069 219 320 11158 OR3_X4
* cell instance $16810 m0 *1 150.67,221.2
X$16810 11471 11550 219 320 12114 NOR2_X1
* cell instance $16813 r0 *1 144.4,221.2
X$16813 12008 219 320 12111 INV_X1
* cell instance $16814 r0 *1 144.78,221.2
X$16814 219 12069 12110 12071 12111 12010 320 FA_X1
* cell instance $16816 r0 *1 148.01,221.2
X$16816 12074 12112 219 320 12073 XOR2_X1
* cell instance $16819 r0 *1 150.1,221.2
X$16819 219 14336 12125 12114 12067 320 DFF_X1
* cell instance $16820 m0 *1 152.57,221.2
X$16820 12125 219 320 11739 BUF_X2
* cell instance $16825 r0 *1 153.71,221.2
X$16825 10539 12126 320 219 12115 AND2_X1
* cell instance $16826 r0 *1 154.47,221.2
X$16826 219 12165 12011 12115 11957 320 DFF_X1
* cell instance $16828 m0 *1 154.47,221.2
X$16828 219 12976 12045 12075 11957 320 DFF_X1
* cell instance $16829 r0 *1 157.7,221.2
X$16829 219 14685 12172 12118 11957 320 DFF_X1
* cell instance $16830 m0 *1 158.27,221.2
X$16830 12011 12046 12527 320 219 12012 HA_X1
* cell instance $16832 m0 *1 160.17,221.2
X$16832 9383 219 320 11957 CLKBUF_X3
* cell instance $16833 m0 *1 161.12,221.2
X$16833 10496 320 3222 219 BUF_X4
* cell instance $16834 m0 *1 162.45,221.2
X$16834 219 12053 12054 12050 11957 320 DFF_X1
* cell instance $16835 m0 *1 165.68,221.2
X$16835 12053 219 320 11979 BUF_X2
* cell instance $16836 m0 *1 166.44,221.2
X$16836 11687 11963 11979 219 320 12049 NOR3_X1
* cell instance $16837 m0 *1 167.2,221.2
X$16837 12054 219 320 11963 CLKBUF_X2
* cell instance $16839 m0 *1 168.72,221.2
X$16839 219 12581 12056 11851 11702 320 DFF_X1
* cell instance $16845 r0 *1 160.93,221.2
X$16845 12077 12011 12045 219 320 12122 NOR3_X1
* cell instance $16850 r0 *1 164.54,221.2
X$16850 1954 11561 320 219 12173 AND2_X1
* cell instance $16858 r0 *1 179.36,221.2
X$16858 1954 12373 320 219 12123 AND2_X1
* cell instance $16860 r0 *1 181.64,221.2
X$16860 12211 12079 12080 320 11371 219 NOR3_X2
* cell instance $16862 m0 *1 183.92,221.2
X$16862 3243 11467 320 219 12060 AND2_X1
* cell instance $16864 m0 *1 184.68,221.2
X$16864 219 12064 12014 11984 12081 320 DFF_X1
* cell instance $16865 m0 *1 187.91,221.2
X$16865 12064 219 320 11889 BUF_X2
* cell instance $16872 r0 *1 185.63,221.2
X$16872 219 12121 12084 12060 12081 320 DFF_X1
* cell instance $16874 r0 *1 189.62,221.2
X$16874 3222 12301 320 219 12082 AND2_X1
* cell instance $16876 r0 *1 190.76,221.2
X$16876 12083 12121 12548 320 219 12089 HA_X1
* cell instance $16878 r0 *1 193.42,221.2
X$16878 12087 12084 12086 320 219 12091 HA_X1
* cell instance $16879 r0 *1 195.32,221.2
X$16879 12089 219 320 12090 CLKBUF_X2
* cell instance $16881 r0 *1 196.27,221.2
X$16881 12144 12091 12171 320 219 12119 HA_X1
* cell instance $16883 m0 *1 199.88,221.2
X$16883 3243 12117 320 219 12062 AND2_X1
* cell instance $16885 m0 *1 200.64,221.2
X$16885 219 12055 12015 12062 11924 320 DFF_X1
* cell instance $16886 m0 *1 203.87,221.2
X$16886 12015 12061 12529 320 219 11987 HA_X1
* cell instance $16887 m0 *1 205.77,221.2
X$16887 12057 12015 12016 320 11892 219 NOR3_X2
* cell instance $16888 m0 *1 207.1,221.2
X$16888 12017 11985 219 320 12058 NOR2_X1
* cell instance $16890 m0 *1 207.86,221.2
X$16890 11925 11987 12095 320 219 12019 HA_X1
* cell instance $16891 m0 *1 209.76,221.2
X$16891 12018 12019 11997 219 320 12020 NOR3_X1
* cell instance $16893 m0 *1 210.71,221.2
X$16893 11999 12022 12023 11989 320 219 12042 OAI22_X2
* cell instance $16894 m0 *1 212.42,221.2
X$16894 12025 12026 11991 320 219 12021 OAI21_X2
* cell instance $16895 m0 *1 213.75,221.2
X$16895 12025 11883 11991 11999 219 320 12039 NAND4_X1
* cell instance $16897 m0 *1 214.89,221.2
X$16897 12025 11991 11999 11992 219 320 12027 NAND4_X1
* cell instance $16898 m0 *1 215.84,221.2
X$16898 11997 12025 12035 219 320 12028 MUX2_X1
* cell instance $16899 m0 *1 217.17,221.2
X$16899 11991 12034 219 320 12035 XOR2_X1
* cell instance $16900 m0 *1 218.31,221.2
X$16900 12029 11989 219 320 12034 NAND2_X1
* cell instance $16908 r0 *1 206.53,221.2
X$16908 12116 219 320 11997 BUF_X1
* cell instance $16911 r0 *1 208.81,221.2
X$16911 12095 12022 12051 12023 320 219 12047 OAI22_X1
* cell instance $16914 r0 *1 210.71,221.2
X$16914 12021 219 320 12096 INV_X1
* cell instance $16915 r0 *1 211.09,221.2
X$16915 11997 12096 12105 219 320 12097 OR3_X1
* cell instance $16916 r0 *1 212.04,221.2
X$16916 12024 12097 12099 11990 219 320 12017 NAND4_X1
* cell instance $16917 r0 *1 212.99,221.2
X$16917 12024 12097 12099 219 320 12098 NAND3_X1
* cell instance $16918 r0 *1 213.75,221.2
X$16918 12025 11991 219 320 12022 NAND2_X1
* cell instance $16919 r0 *1 214.32,221.2
X$16919 12025 12026 219 320 12023 NAND2_X1
* cell instance $16920 r0 *1 214.89,221.2
X$16920 11989 12103 11999 12036 219 320 12105 AOI22_X1
* cell instance $16921 r0 *1 215.84,221.2
X$16921 12028 12026 219 320 12099 NAND2_X1
* cell instance $16923 r0 *1 217.17,221.2
X$16923 11991 12029 320 219 12103 XNOR2_X1
* cell instance $16933 r0 *1 235.6,221.2
X$16933 9578 219 320 12100 BUF_X1
* cell instance $16934 m0 *1 236.17,221.2
X$16934 9985 219 320 12033 BUF_X1
* cell instance $16938 m0 *1 237.31,221.2
X$16938 9798 219 320 12031 BUF_X1
* cell instance $16942 m0 *1 239.59,221.2
X$16942 12102 219 320 7961 CLKBUF_X2
* cell instance $16944 r0 *1 237.69,221.2
X$16944 9009 219 320 12101 BUF_X1
* cell instance $17010 r0 *1 134.52,16.8
X$17010 284 445 616 219 320 560 MUX2_X1
* cell instance $17011 m0 *1 135.09,16.8
X$17011 219 13183 616 560 290 320 DFF_X1
* cell instance $17013 m0 *1 138.32,16.8
X$17013 219 13210 601 561 290 320 DFF_X1
* cell instance $17015 r0 *1 135.85,16.8
X$17015 219 14660 618 643 290 320 DFF_X1
* cell instance $17016 r0 *1 139.08,16.8
X$17016 616 350 601 219 320 648 MUX2_X1
* cell instance $17020 r0 *1 141.74,16.8
X$17020 567 445 619 219 320 646 MUX2_X1
* cell instance $17021 m0 *1 142.12,16.8
X$17021 219 13171 619 646 562 320 DFF_X1
* cell instance $17026 r0 *1 143.26,16.8
X$17026 567 349 620 219 320 602 MUX2_X1
* cell instance $17027 r0 *1 144.59,16.8
X$17027 648 219 320 700 INV_X1
* cell instance $17028 r0 *1 144.97,16.8
X$17028 619 447 620 219 320 652 MUX2_X1
* cell instance $17031 m0 *1 146.49,16.8
X$17031 219 13175 564 605 562 320 DFF_X1
* cell instance $17032 m0 *1 150.48,16.8
X$17032 615 357 566 219 320 606 MUX2_X1
* cell instance $17033 m0 *1 151.81,16.8
X$17033 219 12772 566 606 241 320 DFF_X1
* cell instance $17034 m0 *1 155.04,16.8
X$17034 567 357 568 219 320 654 MUX2_X1
* cell instance $17035 m0 *1 156.37,16.8
X$17035 219 13209 569 610 623 320 DFF_X1
* cell instance $17038 m0 *1 163.4,16.8
X$17038 219 13208 661 571 507 320 DFF_X1
* cell instance $17040 m0 *1 166.82,16.8
X$17040 572 499 660 320 219 656 OAI21_X4
* cell instance $17042 m0 *1 169.48,16.8
X$17042 219 13214 575 614 507 320 DFF_X1
* cell instance $17044 m0 *1 172.9,16.8
X$17044 301 378 575 219 320 614 MUX2_X1
* cell instance $17046 m0 *1 174.42,16.8
X$17046 577 320 378 219 BUF_X4
* cell instance $17047 m0 *1 175.75,16.8
X$17047 219 13215 578 611 559 320 DFF_X1
* cell instance $17048 m0 *1 178.98,16.8
X$17048 312 577 578 219 320 611 MUX2_X1
* cell instance $17051 m0 *1 184.87,16.8
X$17051 330 462 582 219 320 581 MUX2_X1
* cell instance $17052 m0 *1 186.2,16.8
X$17052 582 452 583 219 320 608 MUX2_X1
* cell instance $17053 m0 *1 187.53,16.8
X$17053 584 501 608 320 219 607 OAI21_X4
* cell instance $17057 r0 *1 147.06,16.8
X$17057 284 357 564 219 320 605 MUX2_X1
* cell instance $17058 r0 *1 148.39,16.8
X$17058 284 359 565 219 320 563 MUX2_X1
* cell instance $17059 r0 *1 149.72,16.8
X$17059 577 219 320 359 CLKBUF_X3
* cell instance $17061 r0 *1 150.86,16.8
X$17061 624 219 320 357 CLKBUF_X3
* cell instance $17062 r0 *1 151.81,16.8
X$17062 652 219 320 657 INV_X1
* cell instance $17063 r0 *1 152.19,16.8
X$17063 219 14261 711 622 623 320 DFF_X1
* cell instance $17064 r0 *1 155.42,16.8
X$17064 219 13796 568 654 623 320 DFF_X1
* cell instance $17066 r0 *1 159.03,16.8
X$17066 568 670 569 219 320 716 MUX2_X1
* cell instance $17070 r0 *1 163.02,16.8
X$17070 506 624 626 219 320 662 MUX2_X1
* cell instance $17071 r0 *1 164.35,16.8
X$17071 506 577 661 219 320 571 MUX2_X1
* cell instance $17072 r0 *1 165.68,16.8
X$17072 626 452 661 219 320 660 MUX2_X1
* cell instance $17074 r0 *1 167.39,16.8
X$17074 219 13838 628 659 507 320 DFF_X1
* cell instance $17075 r0 *1 170.62,16.8
X$17075 301 462 628 219 320 659 MUX2_X1
* cell instance $17077 r0 *1 172.33,16.8
X$17077 574 625 219 320 629 NAND2_X1
* cell instance $17079 r0 *1 173.66,16.8
X$17079 364 219 320 559 CLKBUF_X3
* cell instance $17080 r0 *1 174.61,16.8
X$17080 624 320 462 219 BUF_X4
* cell instance $17084 r0 *1 175.94,16.8
X$17084 312 624 630 219 320 653 MUX2_X1
* cell instance $17085 r0 *1 177.27,16.8
X$17085 559 219 320 14765 INV_X1
* cell instance $17086 r0 *1 177.65,16.8
X$17086 512 320 632 219 BUF_X4
* cell instance $17087 r0 *1 178.98,16.8
X$17087 570 320 631 219 BUF_X4
* cell instance $17090 r0 *1 181.45,16.8
X$17090 367 631 650 219 320 651 MUX2_X1
* cell instance $17091 r0 *1 182.78,16.8
X$17091 219 13905 650 651 427 320 DFF_X1
* cell instance $17093 r0 *1 189.05,16.8
X$17093 219 14339 633 647 679 320 DFF_X1
* cell instance $17094 r0 *1 193.61,16.8
X$17094 219 14312 645 644 458 320 DFF_X1
* cell instance $17095 m0 *1 195.13,16.8
X$17095 219 12561 585 604 458 320 DFF_X1
* cell instance $17098 m0 *1 199.12,16.8
X$17098 313 462 599 219 320 600 MUX2_X1
* cell instance $17099 m0 *1 200.45,16.8
X$17099 313 378 588 219 320 586 MUX2_X1
* cell instance $17100 m0 *1 201.78,16.8
X$17100 599 465 588 219 320 589 MUX2_X1
* cell instance $17105 r0 *1 199.12,16.8
X$17105 219 14653 588 586 590 320 DFF_X1
* cell instance $17107 r0 *1 202.73,16.8
X$17107 315 632 637 219 320 642 MUX2_X1
* cell instance $17108 r0 *1 204.06,16.8
X$17108 219 13775 637 642 590 320 DFF_X1
* cell instance $17109 m0 *1 205.2,16.8
X$17109 219 12580 640 641 590 320 DFF_X1
* cell instance $17114 m0 *1 210.9,16.8
X$17114 219 12577 592 597 318 320 DFF_X1
* cell instance $17115 m0 *1 214.13,16.8
X$17115 219 13377 593 594 595 320 DFF_X1
* cell instance $17116 m0 *1 217.36,16.8
X$17116 523 302 593 219 320 594 MUX2_X1
* cell instance $17123 r0 *1 207.29,16.8
X$17123 315 631 640 219 320 641 MUX2_X1
* cell instance $17124 r0 *1 208.62,16.8
X$17124 637 465 640 219 320 692 MUX2_X1
* cell instance $17127 r0 *1 210.9,16.8
X$17127 219 13760 591 639 318 320 DFF_X1
* cell instance $17128 r0 *1 214.13,16.8
X$17128 591 488 592 219 320 688 MUX2_X1
* cell instance $17130 r0 *1 215.84,16.8
X$17130 524 488 593 219 320 638 MUX2_X1
* cell instance $17200 m0 *1 134.33,11.2
X$17200 442 445 444 219 320 443 MUX2_X1
* cell instance $17202 m0 *1 135.66,11.2
X$17202 219 13168 534 533 290 320 DFF_X1
* cell instance $17206 r0 *1 134.52,11.2
X$17206 219 14457 444 443 290 320 DFF_X1
* cell instance $17207 r0 *1 137.75,11.2
X$17207 442 349 534 219 320 533 MUX2_X1
* cell instance $17208 r0 *1 139.08,11.2
X$17208 444 447 534 219 320 536 MUX2_X1
* cell instance $17209 m0 *1 140.41,11.2
X$17209 338 445 446 219 320 473 MUX2_X1
* cell instance $17210 m0 *1 140.03,11.2
X$17210 343 219 320 475 INV_X1
* cell instance $17211 m0 *1 141.74,11.2
X$17211 219 13405 446 473 295 320 DFF_X1
* cell instance $17213 m0 *1 145.16,11.2
X$17213 338 349 448 219 320 353 MUX2_X1
* cell instance $17214 m0 *1 146.49,11.2
X$17214 446 447 448 219 320 538 MUX2_X1
* cell instance $17216 m0 *1 148.01,11.2
X$17216 442 359 478 219 320 355 MUX2_X1
* cell instance $17217 m0 *1 149.34,11.2
X$17217 442 357 482 219 320 481 MUX2_X1
* cell instance $17221 r0 *1 141.55,11.2
X$17221 536 219 320 537 INV_X1
* cell instance $17224 r0 *1 142.88,11.2
X$17224 475 499 219 320 500 NAND2_X1
* cell instance $17228 r0 *1 148.39,11.2
X$17228 219 13893 482 481 295 320 DFF_X1
* cell instance $17229 m0 *1 151.24,11.2
X$17229 482 452 478 219 320 543 MUX2_X1
* cell instance $17231 m0 *1 152.57,11.2
X$17231 296 452 356 219 320 502 MUX2_X1
* cell instance $17234 r0 *1 151.81,11.2
X$17234 538 219 320 547 INV_X1
* cell instance $17236 m0 *1 155.04,11.2
X$17236 352 219 320 487 INV_X1
* cell instance $17238 m0 *1 155.42,11.2
X$17238 293 219 320 241 CLKBUF_X3
* cell instance $17239 m0 *1 156.37,11.2
X$17239 219 12821 548 450 241 320 DFF_X1
* cell instance $17240 m0 *1 159.6,11.2
X$17240 241 219 320 14747 INV_X1
* cell instance $17244 r0 *1 155.61,11.2
X$17244 338 357 451 219 320 546 MUX2_X1
* cell instance $17246 r0 *1 157.32,11.2
X$17246 338 359 548 219 320 450 MUX2_X1
* cell instance $17247 r0 *1 158.65,11.2
X$17247 451 452 548 219 320 504 MUX2_X1
* cell instance $17248 r0 *1 159.98,11.2
X$17248 487 541 219 320 505 NAND2_X1
* cell instance $17250 r0 *1 160.74,11.2
X$17250 505 499 360 320 219 550 OAI21_X4
* cell instance $17252 m0 *1 162.64,11.2
X$17252 219 12669 508 551 507 320 DFF_X1
* cell instance $17256 m0 *1 171.19,11.2
X$17256 333 305 362 219 320 497 MUX2_X1
* cell instance $17259 r0 *1 163.97,11.2
X$17259 219 14133 509 553 507 320 DFF_X1
* cell instance $17262 r0 *1 169.1,11.2
X$17262 554 219 320 511 INV_X1
* cell instance $17265 m0 *1 174.23,11.2
X$17265 333 378 493 219 320 454 MUX2_X1
* cell instance $17266 m0 *1 172.9,11.2
X$17266 362 447 363 219 320 498 MUX2_X1
* cell instance $17269 r0 *1 173.28,11.2
X$17269 333 462 557 219 320 513 MUX2_X1
* cell instance $17270 r0 *1 174.61,11.2
X$17270 219 13786 493 454 559 320 DFF_X1
* cell instance $17274 m0 *1 178.79,11.2
X$17274 366 378 455 219 320 365 MUX2_X1
* cell instance $17275 m0 *1 177.46,11.2
X$17275 366 462 490 219 320 492 MUX2_X1
* cell instance $17276 m0 *1 180.12,11.2
X$17276 490 488 455 219 320 514 MUX2_X1
* cell instance $17277 m0 *1 181.45,11.2
X$17277 306 488 430 219 320 515 MUX2_X1
* cell instance $17279 m0 *1 182.97,11.2
X$17279 219 13049 457 486 427 320 DFF_X1
* cell instance $17280 m0 *1 186.2,11.2
X$17280 457 350 308 219 320 552 MUX2_X1
* cell instance $17283 m0 *1 189.81,11.2
X$17283 219 13284 517 368 458 320 DFF_X1
* cell instance $17284 m0 *1 193.04,11.2
X$17284 479 219 320 480 INV_X1
* cell instance $17286 m0 *1 193.61,11.2
X$17286 219 13292 459 535 458 320 DFF_X1
* cell instance $17287 m0 *1 196.84,11.2
X$17287 310 302 474 219 320 476 MUX2_X1
* cell instance $17289 m0 *1 199.69,11.2
X$17289 219 12653 461 460 371 320 DFF_X1
* cell instance $17290 m0 *1 202.92,11.2
X$17290 219 13476 463 464 371 320 DFF_X1
* cell instance $17291 m0 *1 206.15,11.2
X$17291 316 462 463 219 320 464 MUX2_X1
* cell instance $17292 m0 *1 207.48,11.2
X$17292 463 465 376 219 320 521 MUX2_X1
* cell instance $17297 r0 *1 184.87,11.2
X$17297 330 305 457 219 320 486 MUX2_X1
* cell instance $17298 r0 *1 186.2,11.2
X$17298 427 219 320 CLKBUF_X1
* cell instance $17301 r0 *1 187.34,11.2
X$17301 552 219 320 516 INV_X1
* cell instance $17302 r0 *1 187.72,11.2
X$17302 219 14481 483 484 458 320 DFF_X1
* cell instance $17303 r0 *1 190.95,11.2
X$17303 517 452 483 219 320 518 MUX2_X1
* cell instance $17305 r0 *1 192.47,11.2
X$17305 480 541 219 320 540 NAND2_X1
* cell instance $17309 r0 *1 195.7,11.2
X$17309 310 305 459 219 320 535 MUX2_X1
* cell instance $17310 r0 *1 197.03,11.2
X$17310 459 488 474 219 320 520 MUX2_X1
* cell instance $17314 r0 *1 202.35,11.2
X$17314 314 465 461 219 320 531 MUX2_X1
* cell instance $17315 r0 *1 203.68,11.2
X$17315 545 219 320 371 CLKBUF_X3
* cell instance $17319 m0 *1 209.19,11.2
X$17319 375 465 247 219 320 529 MUX2_X1
* cell instance $17320 m0 *1 211.28,11.2
X$17320 319 462 377 219 320 392 MUX2_X1
* cell instance $17325 r0 *1 210.52,11.2
X$17325 219 465 320 488 BUF_X8
* cell instance $17326 m0 *1 214.32,11.2
X$17326 318 219 320 CLKBUF_X1
* cell instance $17327 m0 *1 212.99,11.2
X$17327 377 465 379 219 320 526 MUX2_X1
* cell instance $17329 m0 *1 215.08,11.2
X$17329 382 465 466 219 320 470 MUX2_X1
* cell instance $17330 m0 *1 216.41,11.2
X$17330 319 302 466 219 320 469 MUX2_X1
* cell instance $17375 m0 *1 152.19,232.4
X$17375 12183 12273 12325 320 219 12353 HA_X1
* cell instance $17377 m0 *1 154.28,232.4
X$17377 12353 219 320 12227 BUF_X2
* cell instance $17378 m0 *1 155.04,232.4
X$17378 12325 219 320 12180 INV_X1
* cell instance $17379 m0 *1 155.42,232.4
X$17379 12227 12228 12224 12325 219 320 12354 NAND4_X1
* cell instance $17380 m0 *1 156.37,232.4
X$17380 12228 12255 320 219 12327 XNOR2_X1
* cell instance $17381 m0 *1 157.51,232.4
X$17381 12259 12127 219 320 12356 NAND2_X1
* cell instance $17383 m0 *1 158.27,232.4
X$17383 12227 12255 12228 12224 219 320 12277 NAND4_X1
* cell instance $17384 m0 *1 159.22,232.4
X$17384 12357 219 320 12228 BUF_X2
* cell instance $17427 r0 *1 155.23,232.4
X$17427 12224 219 320 12274 INV_X1
* cell instance $17428 r0 *1 155.61,232.4
X$17428 12226 12223 12354 320 12326 219 OAI21_X1
* cell instance $17429 r0 *1 156.37,232.4
X$17429 12227 12228 219 320 12225 NAND2_X1
* cell instance $17432 r0 *1 158.08,232.4
X$17432 219 12357 12278 12355 12185 320 DFF_X1
* cell instance $17433 m0 *1 160.55,232.4
X$17433 12279 12282 12280 219 320 12355 NAND3_X1
* cell instance $17438 m0 *1 166.06,232.4
X$17438 9383 219 320 12185 CLKBUF_X3
* cell instance $17439 m0 *1 167.01,232.4
X$17439 12185 219 320 CLKBUF_X1
* cell instance $17440 m0 *1 167.58,232.4
X$17440 12359 219 320 12283 BUF_X1
* cell instance $17441 m0 *1 168.15,232.4
X$17441 12284 219 320 12188 CLKBUF_X2
* cell instance $17443 m0 *1 171.95,232.4
X$17443 12234 12289 12290 12264 219 320 12335 NAND4_X1
* cell instance $17444 m0 *1 172.9,232.4
X$17444 12234 12289 12290 219 320 12364 NAND3_X1
* cell instance $17448 r0 *1 164.35,232.4
X$17448 219 12329 12332 12358 12185 320 DFF_X1
* cell instance $17449 r0 *1 167.58,232.4
X$17449 12330 12332 12359 320 219 12131 HA_X1
* cell instance $17450 r0 *1 169.48,232.4
X$17450 12335 12321 219 320 12360 NOR2_X1
* cell instance $17452 r0 *1 171.57,232.4
X$17452 219 14389 12336 12335 12185 320 DFF_X1
* cell instance $17457 m0 *1 180.69,232.4
X$17457 12366 12294 12520 320 219 12343 HA_X1
* cell instance $17458 m0 *1 177.08,232.4
X$17458 219 12363 12078 12237 12366 320 DFF_X2
* cell instance $17460 m0 *1 182.78,232.4
X$17460 12365 12243 12368 12298 12367 12297 320 219 AOI221_X2
* cell instance $17461 m0 *1 184.87,232.4
X$17461 12299 12362 219 320 12242 XOR2_X1
* cell instance $17462 m0 *1 186.01,232.4
X$17462 12239 12343 12299 12238 219 320 12310 NAND4_X1
* cell instance $17463 m0 *1 186.96,232.4
X$17463 12193 12352 12238 12351 219 320 12308 AOI22_X1
* cell instance $17465 r0 *1 177.84,232.4
X$17465 219 12291 12078 12337 12294 320 DFF_X2
* cell instance $17467 r0 *1 181.64,232.4
X$17467 12237 12337 12542 320 219 12342 HA_X1
* cell instance $17468 r0 *1 183.54,232.4
X$17468 12237 12337 12339 320 219 12340 HA_X1
* cell instance $17469 r0 *1 185.44,232.4
X$17469 12342 12193 219 320 12362 NAND2_X1
* cell instance $17471 r0 *1 186.39,232.4
X$17471 12299 12342 320 219 12352 XNOR2_X1
* cell instance $17474 m0 *1 188.29,232.4
X$17474 12299 12343 320 219 12351 XNOR2_X1
* cell instance $17477 m0 *1 194.18,232.4
X$17477 12344 12345 320 219 12088 AND2_X1
* cell instance $17488 r0 *1 193.61,232.4
X$17488 219 12350 12302 12502 7440 320 DFF_X2
* cell instance $17492 r0 *1 198.55,232.4
X$17492 12344 12379 320 219 11105 AND2_X1
* cell instance $17496 r0 *1 201.4,232.4
X$17496 12344 12376 320 219 12348 AND2_X1
* cell instance $17574 r0 *1 136.61,14
X$17574 290 219 320 CLKBUF_X1
* cell instance $17575 r0 *1 137.18,14
X$17575 293 219 320 290 CLKBUF_X3
* cell instance $17576 r0 *1 138.13,14
X$17576 284 349 601 219 320 561 MUX2_X1
* cell instance $17580 r0 *1 140.79,14
X$17580 570 219 320 349 CLKBUF_X3
* cell instance $17582 r0 *1 142.5,14
X$17582 219 14646 620 602 562 320 DFF_X1
* cell instance $17586 m0 *1 147.82,14
X$17586 537 499 219 320 542 NAND2_X1
* cell instance $17589 r0 *1 148.2,14
X$17589 219 14625 565 563 562 320 DFF_X1
* cell instance $17590 m0 *1 150.48,14
X$17590 542 501 543 320 219 544 OAI21_X4
* cell instance $17592 m0 *1 152.95,14
X$17592 500 501 502 320 219 549 OAI21_X4
* cell instance $17594 m0 *1 158.46,14
X$17594 547 541 219 320 503 NAND2_X1
* cell instance $17595 m0 *1 159.03,14
X$17595 503 499 504 320 219 2538 OAI21_X4
* cell instance $17597 m0 *1 163.02,14
X$17597 506 512 508 219 320 551 MUX2_X1
* cell instance $17598 m0 *1 164.35,14
X$17598 506 570 509 219 320 553 MUX2_X1
* cell instance $17599 m0 *1 165.68,14
X$17599 508 350 509 219 320 555 MUX2_X1
* cell instance $17600 m0 *1 167.01,14
X$17600 555 219 320 510 INV_X1
* cell instance $17603 m0 *1 171.95,14
X$17603 512 219 320 305 CLKBUF_X3
* cell instance $17609 r0 *1 156.56,14
X$17609 567 359 569 219 320 610 MUX2_X1
* cell instance $17613 r0 *1 162.64,14
X$17613 219 14601 626 662 507 320 DFF_X1
* cell instance $17616 r0 *1 166.44,14
X$17616 364 219 320 507 CLKBUF_X3
* cell instance $17617 r0 *1 167.39,14
X$17617 510 541 219 320 572 NAND2_X1
* cell instance $17618 r0 *1 167.96,14
X$17618 507 219 320 14796 INV_X1
* cell instance $17621 r0 *1 169.48,14
X$17621 522 320 573 219 BUF_X4
* cell instance $17622 r0 *1 170.81,14
X$17622 570 219 320 302 CLKBUF_X3
* cell instance $17625 r0 *1 172.71,14
X$17625 498 219 320 574 INV_X1
* cell instance $17627 m0 *1 173.47,14
X$17627 219 13524 557 513 559 320 DFF_X1
* cell instance $17630 r0 *1 173.47,14
X$17630 557 670 493 219 320 576 MUX2_X1
* cell instance $17631 r0 *1 174.8,14
X$17631 219 14642 613 558 559 320 DFF_X1
* cell instance $17635 m0 *1 178.41,14
X$17635 219 13615 580 612 559 320 DFF_X1
* cell instance $17636 m0 *1 177.08,14
X$17636 312 512 613 219 320 558 MUX2_X1
* cell instance $17637 m0 *1 181.64,14
X$17637 514 515 573 320 219 556 MUX2_X2
* cell instance $17639 m0 *1 183.54,14
X$17639 545 219 320 427 CLKBUF_X3
* cell instance $17640 m0 *1 184.49,14
X$17640 219 12724 583 609 427 320 DFF_X1
* cell instance $17641 m0 *1 187.72,14
X$17641 516 499 219 320 584 NAND2_X1
* cell instance $17644 m0 *1 190,14
X$17644 540 499 518 320 219 2853 OAI21_X4
* cell instance $17646 r0 *1 178.03,14
X$17646 312 570 580 219 320 612 MUX2_X1
* cell instance $17647 r0 *1 179.36,14
X$17647 613 447 580 219 320 579 MUX2_X1
* cell instance $17650 r0 *1 183.92,14
X$17650 219 13904 582 581 427 320 DFF_X1
* cell instance $17651 r0 *1 187.15,14
X$17651 330 378 583 219 320 609 MUX2_X1
* cell instance $17654 m0 *1 193.04,14
X$17654 458 219 320 CLKBUF_X1
* cell instance $17656 m0 *1 193.61,14
X$17656 545 219 320 458 CLKBUF_X3
* cell instance $17657 m0 *1 194.56,14
X$17657 310 462 519 219 320 539 MUX2_X1
* cell instance $17660 r0 *1 193.42,14
X$17660 219 14540 519 539 458 320 DFF_X1
* cell instance $17661 m0 *1 196.46,14
X$17661 310 378 585 219 320 604 MUX2_X1
* cell instance $17663 m0 *1 197.79,14
X$17663 603 520 573 320 219 532 MUX2_X2
* cell instance $17668 r0 *1 196.65,14
X$17668 519 488 585 219 320 603 MUX2_X1
* cell instance $17670 r0 *1 198.17,14
X$17670 589 531 573 320 219 598 MUX2_X2
* cell instance $17671 r0 *1 199.88,14
X$17671 219 14329 599 600 371 320 DFF_X1
* cell instance $17674 m0 *1 208.24,14
X$17674 521 529 522 320 219 528 MUX2_X2
* cell instance $17679 r0 *1 211.66,14
X$17679 523 462 591 219 320 639 MUX2_X1
* cell instance $17680 r0 *1 212.99,14
X$17680 523 378 592 219 320 597 MUX2_X1
* cell instance $17681 m0 *1 215.08,14
X$17681 523 305 524 219 320 596 MUX2_X1
* cell instance $17682 m0 *1 213.37,14
X$17682 526 470 522 320 219 525 MUX2_X2
* cell instance $17690 r0 *1 215.46,14
X$17690 219 14282 524 596 595 320 DFF_X1
* cell instance $17775 m0 *1 136.23,8.4
X$17775 219 13181 395 394 290 320 DFF_X1
* cell instance $17776 m0 *1 141.17,8.4
X$17776 219 13185 401 348 295 320 DFF_X1
* cell instance $17778 m0 *1 146.87,8.4
X$17778 293 219 320 295 CLKBUF_X3
* cell instance $17779 m0 *1 147.82,8.4
X$17779 295 219 320 CLKBUF_X1
* cell instance $17781 m0 *1 149.15,8.4
X$17781 219 13154 356 405 295 320 DFF_X1
* cell instance $17782 m0 *1 152.95,8.4
X$17782 340 357 296 219 320 331 MUX2_X1
* cell instance $17784 m0 *1 156.75,8.4
X$17784 347 357 414 219 320 415 MUX2_X1
* cell instance $17785 m0 *1 158.08,8.4
X$17785 219 12674 414 415 241 320 DFF_X1
* cell instance $17787 m0 *1 164.92,8.4
X$17787 219 12675 361 429 507 320 DFF_X1
* cell instance $17788 m0 *1 168.15,8.4
X$17788 301 305 361 219 320 429 MUX2_X1
* cell instance $17790 m0 *1 171.38,8.4
X$17790 219 13628 363 438 303 320 DFF_X1
* cell instance $17791 m0 *1 174.61,8.4
X$17791 333 302 363 219 320 438 MUX2_X1
* cell instance $17793 m0 *1 176.7,8.4
X$17793 219 13598 306 434 303 320 DFF_X1
* cell instance $17794 m0 *1 179.93,8.4
X$17794 366 305 306 219 320 434 MUX2_X1
* cell instance $17798 r0 *1 136.42,8.4
X$17798 340 445 395 219 320 394 MUX2_X1
* cell instance $17799 r0 *1 137.75,8.4
X$17799 340 349 341 219 320 325 MUX2_X1
* cell instance $17800 r0 *1 139.08,8.4
X$17800 395 447 341 219 320 343 MUX2_X1
* cell instance $17803 r0 *1 141.36,8.4
X$17803 347 445 401 219 320 348 MUX2_X1
* cell instance $17804 r0 *1 144.02,8.4
X$17804 401 350 292 219 320 352 MUX2_X1
* cell instance $17805 r0 *1 145.35,8.4
X$17805 219 14532 448 353 295 320 DFF_X1
* cell instance $17806 r0 *1 148.58,8.4
X$17806 219 13953 478 355 295 320 DFF_X1
* cell instance $17807 r0 *1 151.81,8.4
X$17807 340 359 356 219 320 405 MUX2_X1
* cell instance $17811 r0 *1 155.99,8.4
X$17811 219 14217 451 546 241 320 DFF_X1
* cell instance $17812 r0 *1 159.22,8.4
X$17812 347 359 299 219 320 298 MUX2_X1
* cell instance $17814 r0 *1 160.93,8.4
X$17814 414 452 299 219 320 360 MUX2_X1
* cell instance $17819 r0 *1 167.96,8.4
X$17819 361 350 249 219 320 554 MUX2_X1
* cell instance $17820 r0 *1 169.86,8.4
X$17820 219 13763 362 497 303 320 DFF_X1
* cell instance $17823 r0 *1 174.23,8.4
X$17823 303 219 320 14712 INV_X2
* cell instance $17824 r0 *1 174.8,8.4
X$17824 364 219 320 303 CLKBUF_X3
* cell instance $17829 r0 *1 176.13,8.4
X$17829 219 13735 490 492 303 320 DFF_X1
* cell instance $17830 r0 *1 179.36,8.4
X$17830 219 14412 455 365 303 320 DFF_X1
* cell instance $17832 m0 *1 182.21,8.4
X$17832 366 302 430 219 320 431 MUX2_X1
* cell instance $17833 m0 *1 184.87,8.4
X$17833 219 13289 308 307 427 320 DFF_X1
* cell instance $17835 m0 *1 191.71,8.4
X$17835 219 13322 370 309 458 320 DFF_X1
* cell instance $17836 m0 *1 195.51,8.4
X$17836 219 13288 311 410 371 320 DFF_X1
* cell instance $17838 r0 *1 182.59,8.4
X$17838 219 13907 430 431 427 320 DFF_X1
* cell instance $17847 r0 *1 193.8,8.4
X$17847 370 350 311 219 320 479 MUX2_X1
* cell instance $17849 r0 *1 196.65,8.4
X$17849 219 14491 474 476 371 320 DFF_X1
* cell instance $17853 m0 *1 201.97,8.4
X$17853 313 305 314 219 320 374 MUX2_X1
* cell instance $17854 m0 *1 203.87,8.4
X$17854 219 13198 375 400 371 320 DFF_X1
* cell instance $17855 m0 *1 207.1,8.4
X$17855 316 305 375 219 320 400 MUX2_X1
* cell instance $17859 m0 *1 212.61,8.4
X$17859 219 13376 379 389 318 320 DFF_X1
* cell instance $17861 m0 *1 217.74,8.4
X$17861 319 305 382 219 320 383 MUX2_X1
* cell instance $17862 m0 *1 219.07,8.4
X$17862 219 13341 382 383 318 320 DFF_X1
* cell instance $17869 r0 *1 199.88,8.4
X$17869 313 302 461 219 320 460 MUX2_X1
* cell instance $17871 r0 *1 201.97,8.4
X$17871 219 13665 314 374 371 320 DFF_X1
* cell instance $17872 r0 *1 205.2,8.4
X$17872 219 13889 376 398 371 320 DFF_X1
* cell instance $17873 r0 *1 208.43,8.4
X$17873 316 378 376 219 320 398 MUX2_X1
* cell instance $17874 r0 *1 209.76,8.4
X$17874 219 13917 377 392 318 320 DFF_X1
* cell instance $17875 r0 *1 212.99,8.4
X$17875 319 378 379 219 320 389 MUX2_X1
* cell instance $17876 r0 *1 214.32,8.4
X$17876 380 219 320 318 CLKBUF_X3
* cell instance $17877 r0 *1 215.27,8.4
X$17877 219 14159 466 469 318 320 DFF_X1
* cell instance $17911 m0 *1 133.76,19.6
X$17911 615 445 617 219 320 696 MUX2_X1
* cell instance $17912 m0 *1 135.09,19.6
X$17912 219 13225 617 696 290 320 DFF_X1
* cell instance $17913 m0 *1 138.32,19.6
X$17913 615 349 618 219 320 643 MUX2_X1
* cell instance $17914 m0 *1 139.65,19.6
X$17914 617 447 618 219 320 649 MUX2_X1
* cell instance $17918 m0 *1 144.97,19.6
X$17918 649 219 320 709 INV_X1
* cell instance $17920 m0 *1 145.54,19.6
X$17920 293 219 320 562 CLKBUF_X3
* cell instance $17921 m0 *1 146.49,19.6
X$17921 562 219 320 CLKBUF_X1
* cell instance $17923 m0 *1 147.82,19.6
X$17923 700 541 219 320 703 NAND2_X1
* cell instance $17924 m0 *1 148.39,19.6
X$17924 564 621 565 219 320 668 MUX2_X1
* cell instance $17928 m0 *1 152.19,19.6
X$17928 615 359 711 219 320 622 MUX2_X1
* cell instance $17929 m0 *1 153.52,19.6
X$17929 709 625 219 320 671 NAND2_X1
* cell instance $17967 r0 *1 143.45,19.6
X$17967 285 445 701 219 320 699 MUX2_X1
* cell instance $17969 r0 *1 145.54,19.6
X$17969 219 13661 667 666 562 320 DFF_X1
* cell instance $17971 r0 *1 149.15,19.6
X$17971 703 499 668 320 219 706 OAI21_X4
* cell instance $17975 r0 *1 154.28,19.6
X$17975 671 627 655 320 219 713 OAI21_X4
* cell instance $17977 m0 *1 154.47,19.6
X$17977 566 670 711 219 320 655 MUX2_X1
* cell instance $17979 m0 *1 160.36,19.6
X$17979 657 625 219 320 674 NAND2_X1
* cell instance $17980 m0 *1 160.93,19.6
X$17980 674 627 716 320 219 663 OAI21_X4
* cell instance $17983 m0 *1 167.2,19.6
X$17983 219 627 320 573 BUF_X8
* cell instance $17984 m0 *1 169.67,19.6
X$17984 511 627 219 320 786 NAND2_X1
* cell instance $17986 m0 *1 171,19.6
X$17986 629 627 576 320 219 658 OAI21_X4
* cell instance $17989 m0 *1 174.42,19.6
X$17989 219 13167 630 653 559 320 DFF_X1
* cell instance $17990 m0 *1 177.65,19.6
X$17990 630 452 578 219 320 675 MUX2_X1
* cell instance $17991 m0 *1 178.98,19.6
X$17991 579 219 320 676 INV_X1
* cell instance $17995 r0 *1 156.75,19.6
X$17995 219 13801 673 672 623 320 DFF_X1
* cell instance $18000 r0 *1 170.81,19.6
X$18000 628 621 575 219 320 788 MUX2_X1
* cell instance $18008 r0 *1 176.51,19.6
X$18008 722 625 675 320 219 723 OAI21_X4
* cell instance $18009 r0 *1 178.98,19.6
X$18009 676 714 219 320 722 NAND2_X1
* cell instance $18011 m0 *1 182.21,19.6
X$18011 219 13048 718 720 427 320 DFF_X1
* cell instance $18017 m0 *1 192.28,19.6
X$18017 633 488 645 219 320 634 MUX2_X1
* cell instance $18021 r0 *1 182.59,19.6
X$18021 367 632 718 219 320 720 MUX2_X1
* cell instance $18022 r0 *1 183.92,19.6
X$18022 718 447 650 219 320 719 MUX2_X1
* cell instance $18023 r0 *1 185.25,19.6
X$18023 719 219 320 715 INV_X1
* cell instance $18025 r0 *1 186.39,19.6
X$18025 715 501 219 320 678 NAND2_X1
* cell instance $18029 r0 *1 191.9,19.6
X$18029 219 14459 708 712 679 320 DFF_X1
* cell instance $18031 m0 *1 196.27,19.6
X$18031 219 704 488 320 BUF_X16
* cell instance $18033 r0 *1 196.46,19.6
X$18033 219 14310 681 702 590 320 DFF_X1
* cell instance $18036 m0 *1 203.11,19.6
X$18036 219 13568 683 636 590 320 DFF_X1
* cell instance $18039 m0 *1 207.86,19.6
X$18039 683 465 685 219 320 694 MUX2_X1
* cell instance $18040 m0 *1 209.19,19.6
X$18040 694 692 522 320 219 693 MUX2_X2
* cell instance $18043 m0 *1 213.18,19.6
X$18043 688 638 522 320 219 689 MUX2_X2
* cell instance $18050 r0 *1 203.11,19.6
X$18050 590 219 320 CLKBUF_X1
* cell instance $18051 r0 *1 203.68,19.6
X$18051 315 680 683 219 320 636 MUX2_X1
* cell instance $18052 r0 *1 205.01,19.6
X$18052 545 219 320 590 CLKBUF_X3
* cell instance $18053 r0 *1 205.96,19.6
X$18053 219 13871 685 695 590 320 DFF_X1
* cell instance $18077 r0 *1 9.88,67.2
X$18077 2456 219 320 2559 CLKBUF_X2
* cell instance $18078 r0 *1 10.64,67.2
X$18078 2455 219 320 2326 BUF_X2
* cell instance $18079 r0 *1 11.4,67.2
X$18079 1370 219 320 2306 CLKBUF_X3
* cell instance $18080 m0 *1 11.97,67.2
X$18080 219 13233 2307 2380 2306 320 DFF_X1
* cell instance $18082 m0 *1 15.2,67.2
X$18082 2308 1734 2310 219 320 2381 MUX2_X1
* cell instance $18083 m0 *1 16.53,67.2
X$18083 219 13264 2310 2381 2309 320 DFF_X1
* cell instance $18084 m0 *1 19.76,67.2
X$18084 2458 1564 2310 219 320 2311 MUX2_X1
* cell instance $18086 m0 *1 21.85,67.2
X$18086 2316 219 320 1370 CLKBUF_X3
* cell instance $18087 m0 *1 22.8,67.2
X$18087 2312 1507 2211 219 320 2383 MUX2_X1
* cell instance $18089 m0 *1 24.32,67.2
X$18089 2308 1553 2313 219 320 2504 MUX2_X1
* cell instance $18091 r0 *1 12.35,67.2
X$18091 219 13664 2457 2502 2306 320 DFF_X1
* cell instance $18092 r0 *1 15.58,67.2
X$18092 2308 1547 2457 219 320 2502 MUX2_X1
* cell instance $18094 r0 *1 17.67,67.2
X$18094 219 14548 2458 2503 2309 320 DFF_X1
* cell instance $18095 r0 *1 20.9,67.2
X$18095 2458 1550 2211 219 320 2503 MUX2_X1
* cell instance $18099 r0 *1 24.7,67.2
X$18099 219 14635 2313 2504 2314 320 DFF_X1
* cell instance $18100 m0 *1 26.22,67.2
X$18100 219 13257 2315 2384 2314 320 DFF_X1
* cell instance $18102 m0 *1 29.45,67.2
X$18102 219 12705 2212 2387 2314 320 DFF_X1
* cell instance $18104 r0 *1 27.93,67.2
X$18104 2308 219 320 2211 BUF_X2
* cell instance $18108 r0 *1 30.02,67.2
X$18108 2315 1374 2212 219 320 2505 MUX2_X1
* cell instance $18109 r0 *1 31.35,67.2
X$18109 2386 1510 2505 219 320 2607 MUX2_X1
* cell instance $18112 m0 *1 33.06,67.2
X$18112 219 12980 2388 2317 2314 320 DFF_X1
* cell instance $18113 m0 *1 36.48,67.2
X$18113 2211 1307 2318 219 320 2506 MUX2_X1
* cell instance $18117 r0 *1 34.39,67.2
X$18117 219 14566 2318 2506 2314 320 DFF_X1
* cell instance $18118 r0 *1 37.62,67.2
X$18118 2388 1377 2318 219 320 2509 MUX2_X1
* cell instance $18121 r0 *1 39.52,67.2
X$18121 2319 1469 2211 219 320 2510 MUX2_X1
* cell instance $18122 m0 *1 41.04,67.2
X$18122 2211 1523 2391 219 320 2279 MUX2_X1
* cell instance $18123 m0 *1 39.71,67.2
X$18123 2319 1567 2391 219 320 2320 MUX2_X1
* cell instance $18124 m0 *1 42.37,67.2
X$18124 2214 219 320 14745 INV_X1
* cell instance $18128 r0 *1 40.85,67.2
X$18128 2320 1510 2509 219 320 2562 MUX2_X1
* cell instance $18129 r0 *1 42.18,67.2
X$18129 219 14395 2319 2510 2214 320 DFF_X1
* cell instance $18133 r0 *1 49.59,67.2
X$18133 2211 1385 2459 219 320 2513 MUX2_X1
* cell instance $18134 r0 *1 50.92,67.2
X$18134 219 14288 2459 2513 2190 320 DFF_X1
* cell instance $18135 m0 *1 55.48,67.2
X$18135 2395 1564 2394 219 320 2322 MUX2_X1
* cell instance $18136 m0 *1 52.25,67.2
X$18136 219 12958 2394 2321 2190 320 DFF_X1
* cell instance $18137 m0 *1 56.81,67.2
X$18137 219 12934 2323 2517 2190 320 DFF_X1
* cell instance $18138 m0 *1 60.04,67.2
X$18138 219 13510 2397 2324 2190 320 DFF_X1
* cell instance $18139 m0 *1 63.27,67.2
X$18139 219 12560 2220 2398 2565 320 DFF_X1
* cell instance $18141 r0 *1 54.15,67.2
X$18141 2564 1374 2459 219 320 2460 MUX2_X1
* cell instance $18142 r0 *1 55.48,67.2
X$18142 2460 1562 2322 219 320 2516 MUX2_X1
* cell instance $18144 r0 *1 58.33,67.2
X$18144 2221 1480 2323 219 320 2517 MUX2_X1
* cell instance $18145 r0 *1 59.66,67.2
X$18145 2190 219 320 CLKBUF_X1
* cell instance $18147 r0 *1 60.42,67.2
X$18147 2462 1647 2461 219 320 2614 MUX2_X1
* cell instance $18148 r0 *1 61.75,67.2
X$18148 2221 1389 2397 219 320 2324 MUX2_X1
* cell instance $18157 r0 *1 64.98,67.2
X$18157 2221 219 320 2462 CLKBUF_X2
* cell instance $18159 m0 *1 67.07,67.2
X$18159 2221 1476 2401 219 320 2400 MUX2_X1
* cell instance $18161 m0 *1 68.4,67.2
X$18161 219 13546 2464 2403 1929 320 DFF_X1
* cell instance $18162 m0 *1 71.63,67.2
X$18162 2221 1478 2464 219 320 2403 MUX2_X1
* cell instance $18167 r0 *1 68.97,67.2
X$18167 2221 1571 2618 219 320 2617 MUX2_X1
* cell instance $18168 r0 *1 70.3,67.2
X$18168 2464 2520 2401 219 320 2521 MUX2_X1
* cell instance $18172 m0 *1 80.18,67.2
X$18172 2222 1933 2224 219 320 2406 MUX2_X1
* cell instance $18173 m0 *1 81.7,67.2
X$18173 2406 2095 2409 219 320 2408 MUX2_X1
* cell instance $18174 m0 *1 83.03,67.2
X$18174 2195 1933 2407 219 320 2409 MUX2_X1
* cell instance $18177 m0 *1 86.07,67.2
X$18177 219 12651 2325 2226 2227 320 DFF_X1
* cell instance $18178 m0 *1 89.3,67.2
X$18178 2228 2327 2325 219 320 2664 MUX2_X1
* cell instance $18179 m0 *1 90.63,67.2
X$18179 219 13176 2328 2412 2227 320 DFF_X1
* cell instance $18186 r0 *1 90.06,67.2
X$18186 1578 219 320 2227 CLKBUF_X3
* cell instance $18187 r0 *1 91.01,67.2
X$18187 2227 219 320 CLKBUF_X1
* cell instance $18190 r0 *1 92.15,67.2
X$18190 2463 320 2471 219 BUF_X4
* cell instance $18193 m0 *1 95,67.2
X$18193 2230 2327 2328 219 320 2329 MUX2_X1
* cell instance $18195 m0 *1 96.9,67.2
X$18195 2229 2327 2299 219 320 2417 MUX2_X1
* cell instance $18198 m0 *1 98.42,67.2
X$18198 2233 1844 2153 219 320 2466 MUX2_X1
* cell instance $18199 m0 *1 99.75,67.2
X$18199 2233 1841 2035 219 320 2234 MUX2_X1
* cell instance $18201 m0 *1 101.27,67.2
X$18201 2232 219 320 CLKBUF_X1
* cell instance $18202 m0 *1 101.84,67.2
X$18202 1578 219 320 2232 CLKBUF_X3
* cell instance $18205 r0 *1 98.8,67.2
X$18205 2327 320 2468 219 BUF_X4
* cell instance $18208 m0 *1 103.17,67.2
X$18208 2035 2148 2330 219 320 2418 MUX2_X1
* cell instance $18212 m0 *1 104.88,67.2
X$18212 2330 1576 2303 219 320 2419 MUX2_X1
* cell instance $18215 r0 *1 105.26,67.2
X$18215 219 14671 2572 2529 2232 320 DFF_X1
* cell instance $18216 r0 *1 108.49,67.2
X$18216 2331 2468 2304 219 320 2530 MUX2_X1
* cell instance $18217 m0 *1 109.82,67.2
X$18217 2331 2086 2035 219 320 2421 MUX2_X1
* cell instance $18234 m0 *1 126.92,67.2
X$18234 219 13262 2425 2423 2237 320 DFF_X1
* cell instance $18236 m0 *1 130.15,67.2
X$18236 286 1012 2425 219 320 2423 MUX2_X1
* cell instance $18237 m0 *1 131.48,67.2
X$18237 2326 1011 2332 219 320 2429 MUX2_X1
* cell instance $18238 m0 *1 132.81,67.2
X$18238 219 13279 2332 2429 2237 320 DFF_X1
* cell instance $18239 m0 *1 136.04,67.2
X$18239 2326 1012 2333 219 320 2430 MUX2_X1
* cell instance $18240 m0 *1 137.37,67.2
X$18240 2332 1314 2333 219 320 2431 MUX2_X1
* cell instance $18243 r0 *1 127.11,67.2
X$18243 286 1035 2578 219 320 2469 MUX2_X1
* cell instance $18246 r0 *1 129.39,67.2
X$18246 2237 219 320 14761 INV_X1
* cell instance $18247 r0 *1 129.77,67.2
X$18247 2238 1629 2425 219 320 2474 MUX2_X1
* cell instance $18248 r0 *1 131.1,67.2
X$18248 1902 219 320 2237 CLKBUF_X3
* cell instance $18249 r0 *1 132.05,67.2
X$18249 219 14602 2472 2470 2637 320 DFF_X1
* cell instance $18250 r0 *1 135.28,67.2
X$18250 2326 1041 2473 219 320 2638 MUX2_X1
* cell instance $18251 r0 *1 136.61,67.2
X$18251 2472 1629 2473 219 320 2475 MUX2_X1
* cell instance $18252 r0 *1 137.94,67.2
X$18252 2474 219 320 2540 INV_X1
* cell instance $18253 r0 *1 138.32,67.2
X$18253 2475 1274 2431 219 320 2433 MUX2_X1
* cell instance $18255 m0 *1 139.08,67.2
X$18255 2431 219 320 2432 INV_X1
* cell instance $18256 m0 *1 139.65,67.2
X$18256 2432 733 219 320 2541 NAND2_X1
* cell instance $18258 m0 *1 140.41,67.2
X$18258 2248 2433 219 320 2336 XNOR2_X2
* cell instance $18259 m0 *1 142.31,67.2
X$18259 2338 1316 219 320 2337 XNOR2_X2
* cell instance $18261 r0 *1 139.65,67.2
X$18261 2541 733 2475 320 219 2542 OAI21_X4
* cell instance $18263 r0 *1 142.5,67.2
X$18263 2534 2335 219 320 2641 XNOR2_X2
* cell instance $18265 m0 *1 144.59,67.2
X$18265 2477 1227 219 320 2546 XNOR2_X2
* cell instance $18266 m0 *1 146.49,67.2
X$18266 219 2441 2339 2340 2544 2478 320 OR4_X4
* cell instance $18267 m0 *1 148.96,67.2
X$18267 219 1445 320 2479 BUF_X8
* cell instance $18270 m0 *1 153.14,67.2
X$18270 219 13468 2448 2446 2343 320 DFF_X1
* cell instance $18272 r0 *1 145.16,67.2
X$18272 2471 2157 219 320 2582 XNOR2_X2
* cell instance $18274 r0 *1 147.44,67.2
X$18274 219 2341 2549 2546 2548 2478 320 NAND4_X4
* cell instance $18276 r0 *1 151.24,67.2
X$18276 2439 1769 219 320 2549 XNOR2_X2
* cell instance $18278 r0 *1 153.9,67.2
X$18278 219 14197 2553 2552 2343 320 DFF_X1
* cell instance $18279 m0 *1 156.94,67.2
X$18279 2245 2344 2448 219 320 2345 MUX2_X1
* cell instance $18284 r0 *1 157.13,67.2
X$18284 408 1493 2553 219 320 2552 MUX2_X1
* cell instance $18286 r0 *1 158.65,67.2
X$18286 326 1662 2586 219 320 2480 MUX2_X1
* cell instance $18287 r0 *1 159.98,67.2
X$18287 326 1493 2481 219 320 2636 MUX2_X1
* cell instance $18289 r0 *1 162.07,67.2
X$18289 2352 2453 219 320 2483 OR2_X1
* cell instance $18290 r0 *1 162.83,67.2
X$18290 2453 2482 2635 219 320 2551 MUX2_X1
* cell instance $18291 m0 *1 163.21,67.2
X$18291 2239 2551 320 219 2347 XNOR2_X1
* cell instance $18292 m0 *1 164.35,67.2
X$18292 2347 2452 2454 2346 219 2444 320 NAND4_X2
* cell instance $18294 r0 *1 164.16,67.2
X$18294 2477 2484 320 219 2346 XNOR2_X1
* cell instance $18295 r0 *1 165.3,67.2
X$18295 2352 2345 219 320 2485 OR2_X1
* cell instance $18297 m0 *1 169.67,67.2
X$18297 2295 1772 2349 219 320 2351 MUX2_X1
* cell instance $18298 m0 *1 166.44,67.2
X$18298 219 13337 2349 2547 2348 320 DFF_X1
* cell instance $18299 m0 *1 171,67.2
X$18299 2352 2056 219 320 2350 OR2_X1
* cell instance $18300 m0 *1 171.76,67.2
X$18300 219 12685 2247 2451 2348 320 DFF_X1
* cell instance $18301 m0 *1 174.99,67.2
X$18301 2247 1775 2354 219 320 2353 MUX2_X1
* cell instance $18302 m0 *1 176.32,67.2
X$18302 317 2057 2354 219 320 2539 MUX2_X1
* cell instance $18303 m0 *1 177.65,67.2
X$18303 2338 2447 320 219 2535 XNOR2_X1
* cell instance $18307 r0 *1 168.15,67.2
X$18307 317 2053 2349 219 320 2547 MUX2_X1
* cell instance $18309 r0 *1 169.67,67.2
X$18309 2350 2527 2246 320 219 2545 OAI21_X4
* cell instance $18310 r0 *1 172.14,67.2
X$18310 1943 219 320 2348 CLKBUF_X3
* cell instance $18311 r0 *1 173.09,67.2
X$18311 2353 1853 2351 219 320 2537 MUX2_X1
* cell instance $18313 r0 *1 174.61,67.2
X$18313 219 14524 2354 2539 2348 320 DFF_X1
* cell instance $18321 r0 *1 178.03,67.2
X$18321 2536 1855 320 219 2486 XNOR2_X1
* cell instance $18323 m0 *1 179.36,67.2
X$18323 2342 2249 320 219 2487 XNOR2_X1
* cell instance $18325 m0 *1 180.5,67.2
X$18325 2445 1407 1667 320 219 2443 OAI21_X4
* cell instance $18328 r0 *1 179.93,67.2
X$18328 2535 2487 219 320 2624 NAND2_X1
* cell instance $18331 r0 *1 182.78,67.2
X$18331 2352 2163 219 320 2588 OR2_X1
* cell instance $18332 r0 *1 183.54,67.2
X$18332 2534 2289 320 219 2533 XNOR2_X1
* cell instance $18333 m0 *1 184.3,67.2
X$18333 2355 2442 2436 2533 219 2623 320 NAND4_X2
* cell instance $18335 m0 *1 186.01,67.2
X$18335 2439 2531 320 219 2442 XNOR2_X1
* cell instance $18338 m0 *1 188.1,67.2
X$18338 219 13254 2357 2358 1952 320 DFF_X1
* cell instance $18340 r0 *1 184.68,67.2
X$18340 2163 1853 2621 219 320 2531 MUX2_X1
* cell instance $18341 r0 *1 186.01,67.2
X$18341 219 14361 2356 2488 1952 320 DFF_X1
* cell instance $18344 r0 *1 189.81,67.2
X$18344 219 1407 320 2527 BUF_X8
* cell instance $18345 m0 *1 191.9,67.2
X$18345 2352 1498 219 320 2360 OR2_X1
* cell instance $18347 m0 *1 192.66,67.2
X$18347 219 13296 2252 2428 2255 320 DFF_X1
* cell instance $18348 m0 *1 195.89,67.2
X$18348 2361 1852 2252 219 320 2428 MUX2_X1
* cell instance $18349 m0 *1 197.22,67.2
X$18349 2362 219 320 2255 CLKBUF_X3
* cell instance $18350 m0 *1 198.17,67.2
X$18350 2254 2422 1407 320 219 2426 OAI21_X4
* cell instance $18351 m0 *1 200.64,67.2
X$18351 2489 1113 2363 219 320 2422 MUX2_X1
* cell instance $18353 m0 *1 202.16,67.2
X$18353 1181 320 2364 219 BUF_X4
* cell instance $18354 m0 *1 203.49,67.2
X$18354 1185 2365 219 320 2420 OR2_X2
* cell instance $18355 m0 *1 204.44,67.2
X$18355 219 13319 2522 2416 2366 320 DFF_X1
* cell instance $18356 m0 *1 207.67,67.2
X$18356 2367 1585 2413 320 219 2415 OAI21_X4
* cell instance $18358 r0 *1 192.28,67.2
X$18358 2360 2527 1987 320 219 2526 OAI21_X4
* cell instance $18361 r0 *1 195.7,67.2
X$18361 219 1119 320 2527 BUF_X8
* cell instance $18363 r0 *1 198.93,67.2
X$18363 2361 2054 2489 219 320 2616 MUX2_X1
* cell instance $18364 r0 *1 200.26,67.2
X$18364 2361 2053 2363 219 320 2525 MUX2_X1
* cell instance $18368 r0 *1 202.92,67.2
X$18368 2420 1407 2523 320 219 2524 OAI21_X4
* cell instance $18370 r0 *1 205.77,67.2
X$18370 2285 2490 2522 219 320 2416 MUX2_X1
* cell instance $18372 r0 *1 207.29,67.2
X$18372 1182 320 2490 219 BUF_X4
* cell instance $18374 r0 *1 209,67.2
X$18374 2260 2490 2519 219 320 2492 MUX2_X1
* cell instance $18376 m0 *1 210.71,67.2
X$18376 2613 1112 2519 219 320 2413 MUX2_X1
* cell instance $18379 m0 *1 212.8,67.2
X$18379 1181 320 2368 219 BUF_X4
* cell instance $18382 m0 *1 215.08,67.2
X$18382 1065 2402 219 320 2369 OR2_X1
* cell instance $18385 m0 *1 216.79,67.2
X$18385 2493 2169 2264 219 320 2399 MUX2_X1
* cell instance $18387 m0 *1 218.31,67.2
X$18387 1869 219 320 2263 CLKBUF_X3
* cell instance $18388 m0 *1 219.26,67.2
X$18388 2263 219 320 14755 INV_X1
* cell instance $18390 m0 *1 219.83,67.2
X$18390 2265 2368 2392 219 320 2393 MUX2_X1
* cell instance $18395 r0 *1 213.18,67.2
X$18395 1182 320 2495 219 BUF_X4
* cell instance $18398 r0 *1 215.08,67.2
X$18398 2369 1119 2494 320 219 2518 OAI21_X4
* cell instance $18399 r0 *1 217.55,67.2
X$18399 2493 2495 2496 219 320 2593 MUX2_X1
* cell instance $18401 r0 *1 219.07,67.2
X$18401 2265 2495 2497 219 320 2515 MUX2_X1
* cell instance $18402 r0 *1 220.4,67.2
X$18402 219 13863 2497 2515 2263 320 DFF_X1
* cell instance $18404 m0 *1 221.54,67.2
X$18404 219 13219 2392 2393 2263 320 DFF_X1
* cell instance $18405 r0 *1 223.63,67.2
X$18405 2392 1069 2497 219 320 2512 MUX2_X1
* cell instance $18408 m0 *1 225.15,67.2
X$18408 219 13195 2389 2390 2594 320 DFF_X1
* cell instance $18409 r0 *1 228,67.2
X$18409 219 14406 2372 2511 2594 320 DFF_X1
* cell instance $18410 m0 *1 228.95,67.2
X$18410 2370 1781 2372 219 320 2511 MUX2_X1
* cell instance $18413 m0 *1 230.47,67.2
X$18413 2370 1414 2374 219 320 2508 MUX2_X1
* cell instance $18422 r0 *1 231.42,67.2
X$18422 219 13901 2595 2507 2382 320 DFF_X1
* cell instance $18423 m0 *1 232.37,67.2
X$18423 2370 1408 2595 219 320 2507 MUX2_X1
* cell instance $18428 m0 *1 236.17,67.2
X$18428 2376 1408 2603 219 320 2377 MUX2_X1
* cell instance $18429 m0 *1 234.84,67.2
X$18429 2376 1414 2498 219 320 2375 MUX2_X1
* cell instance $18431 m0 *1 238.26,67.2
X$18431 2378 219 320 2376 BUF_X1
* cell instance $18432 m0 *1 238.83,67.2
X$18432 2376 1781 2501 219 320 2499 MUX2_X1
* cell instance $18433 m0 *1 240.16,67.2
X$18433 2379 219 320 2370 BUF_X1
* cell instance $18435 r0 *1 235.03,67.2
X$18435 219 13922 2498 2375 2382 320 DFF_X1
* cell instance $18437 r0 *1 238.45,67.2
X$18437 2501 1596 2273 219 320 2700 MUX2_X1
* cell instance $18439 r0 *1 240.16,67.2
X$18439 2500 219 320 2285 BUF_X1
* cell instance $18464 m0 *1 136.04,22.4
X$18464 512 219 320 445 CLKBUF_X3
* cell instance $18504 r0 *1 136.42,22.4
X$18504 219 13930 725 724 339 320 DFF_X1
* cell instance $18506 m0 *1 137.37,22.4
X$18506 697 445 725 219 320 724 MUX2_X1
* cell instance $18508 m0 *1 139.08,22.4
X$18508 697 349 698 219 320 726 MUX2_X1
* cell instance $18509 r0 *1 139.65,22.4
X$18509 219 13710 698 726 562 320 DFF_X1
* cell instance $18511 m0 *1 140.79,22.4
X$18511 725 621 698 219 320 761 MUX2_X1
* cell instance $18512 m0 *1 145.73,22.4
X$18512 285 349 667 219 320 666 MUX2_X1
* cell instance $18513 m0 *1 142.5,22.4
X$18513 219 13540 701 699 562 320 DFF_X1
* cell instance $18514 m0 *1 147.06,22.4
X$18514 701 621 667 219 320 766 MUX2_X1
* cell instance $18518 r0 *1 143.45,22.4
X$18518 761 219 320 762 INV_X1
* cell instance $18521 r0 *1 144.78,22.4
X$18521 691 349 728 219 320 727 MUX2_X1
* cell instance $18523 m0 *1 148.96,22.4
X$18523 697 359 710 219 320 707 MUX2_X1
* cell instance $18525 m0 *1 150.29,22.4
X$18525 219 13054 710 707 669 320 DFF_X1
* cell instance $18527 m0 *1 156.56,22.4
X$18527 285 357 673 219 320 672 MUX2_X1
* cell instance $18528 m0 *1 157.89,22.4
X$18528 219 13018 773 772 623 320 DFF_X1
* cell instance $18529 m0 *1 161.12,22.4
X$18529 673 670 773 219 320 776 MUX2_X1
* cell instance $18531 m0 *1 163.21,22.4
X$18531 219 12750 779 778 623 320 DFF_X1
* cell instance $18532 m0 *1 166.44,22.4
X$18532 219 13220 782 781 559 320 DFF_X1
* cell instance $18538 r0 *1 150.1,22.4
X$18538 697 357 729 219 320 765 MUX2_X1
* cell instance $18540 r0 *1 152.19,22.4
X$18540 766 219 320 768 INV_X1
* cell instance $18541 r0 *1 152.57,22.4
X$18541 729 670 710 219 320 730 MUX2_X1
* cell instance $18542 r0 *1 153.9,22.4
X$18542 768 625 219 320 774 NAND2_X1
* cell instance $18545 r0 *1 156.18,22.4
X$18545 691 359 771 219 320 775 MUX2_X1
* cell instance $18548 r0 *1 158.08,22.4
X$18548 285 359 773 219 320 772 MUX2_X1
* cell instance $18549 r0 *1 159.41,22.4
X$18549 293 219 320 623 CLKBUF_X3
* cell instance $18550 r0 *1 160.36,22.4
X$18550 774 627 776 320 219 777 OAI21_X4
* cell instance $18553 r0 *1 164.54,22.4
X$18553 731 808 779 219 320 778 MUX2_X1
* cell instance $18556 r0 *1 166.82,22.4
X$18556 731 801 782 219 320 781 MUX2_X1
* cell instance $18557 r0 *1 168.15,22.4
X$18557 779 447 782 219 320 783 MUX2_X1
* cell instance $18558 r0 *1 169.48,22.4
X$18558 783 219 320 785 INV_X1
* cell instance $18560 r0 *1 170.05,22.4
X$18560 786 733 788 320 219 857 OAI21_X4
* cell instance $18564 r0 *1 173.85,22.4
X$18564 372 570 736 219 320 734 MUX2_X1
* cell instance $18565 m0 *1 174.8,22.4
X$18565 372 512 789 219 320 790 MUX2_X1
* cell instance $18568 m0 *1 176.32,22.4
X$18568 624 320 680 219 BUF_X4
* cell instance $18569 m0 *1 177.65,22.4
X$18569 372 624 737 219 320 787 MUX2_X1
* cell instance $18570 m0 *1 178.98,22.4
X$18570 372 577 721 219 320 784 MUX2_X1
* cell instance $18577 r0 *1 175.18,22.4
X$18577 219 14515 789 790 735 320 DFF_X1
* cell instance $18578 r0 *1 178.41,22.4
X$18578 219 14474 721 784 735 320 DFF_X1
* cell instance $18579 r0 *1 181.64,22.4
X$18579 577 320 684 219 BUF_X4
* cell instance $18580 m0 *1 183.16,22.4
X$18580 219 13046 738 677 679 320 DFF_X1
* cell instance $18582 m0 *1 186.39,22.4
X$18582 678 714 740 320 219 717 OAI21_X4
* cell instance $18583 m0 *1 188.86,22.4
X$18583 545 219 320 679 CLKBUF_X3
* cell instance $18584 m0 *1 189.81,22.4
X$18584 679 219 320 14737 INV_X1
* cell instance $18588 r0 *1 183.35,22.4
X$18588 219 13903 739 780 679 320 DFF_X1
* cell instance $18589 r0 *1 186.58,22.4
X$18589 738 452 739 219 320 740 MUX2_X1
* cell instance $18592 r0 *1 188.48,22.4
X$18592 219 14462 741 770 679 320 DFF_X1
* cell instance $18594 m0 *1 192.85,22.4
X$18594 705 634 522 320 219 769 MUX2_X2
* cell instance $18595 m0 *1 194.56,22.4
X$18595 681 488 708 219 320 705 MUX2_X1
* cell instance $18599 m0 *1 201.21,22.4
X$18599 369 680 763 219 320 764 MUX2_X1
* cell instance $18602 m0 *1 206.34,22.4
X$18602 315 684 685 219 320 695 MUX2_X1
* cell instance $18605 r0 *1 191.71,22.4
X$18605 635 684 741 219 320 770 MUX2_X1
* cell instance $18606 r0 *1 193.04,22.4
X$18606 635 632 743 219 320 742 MUX2_X1
* cell instance $18607 r0 *1 194.37,22.4
X$18607 767 219 320 827 INV_X1
* cell instance $18608 r0 *1 194.75,22.4
X$18608 743 350 744 219 320 767 MUX2_X1
* cell instance $18609 r0 *1 196.08,22.4
X$18609 219 14304 744 745 813 320 DFF_X1
* cell instance $18612 r0 *1 200.26,22.4
X$18612 369 684 746 219 320 822 MUX2_X1
* cell instance $18613 r0 *1 201.59,22.4
X$18613 219 13935 763 764 748 320 DFF_X1
* cell instance $18615 r0 *1 205.01,22.4
X$18615 219 13938 759 747 748 320 DFF_X1
* cell instance $18618 m0 *1 209,22.4
X$18618 750 684 687 219 320 690 MUX2_X1
* cell instance $18620 m0 *1 210.33,22.4
X$18620 219 13619 687 690 595 320 DFF_X1
* cell instance $18621 m0 *1 213.56,22.4
X$18621 752 686 687 219 320 756 MUX2_X1
* cell instance $18622 m0 *1 214.89,22.4
X$18622 380 219 320 595 CLKBUF_X3
* cell instance $18623 m0 *1 215.84,22.4
X$18623 595 219 320 CLKBUF_X1
* cell instance $18629 r0 *1 208.81,22.4
X$18629 750 680 752 219 320 751 MUX2_X1
* cell instance $18630 r0 *1 210.14,22.4
X$18630 219 13868 752 751 595 320 DFF_X1
* cell instance $18631 r0 *1 213.37,22.4
X$18631 753 686 754 219 320 757 MUX2_X1
* cell instance $18632 r0 *1 214.7,22.4
X$18632 750 631 754 219 320 755 MUX2_X1
* cell instance $18634 r0 *1 216.22,22.4
X$18634 219 14032 754 755 595 320 DFF_X1
* cell instance $18666 m0 *1 133.19,28
X$18666 219 12702 791 879 339 320 DFF_X1
* cell instance $18667 m0 *1 136.42,28
X$18667 791 350 794 219 320 792 MUX2_X1
* cell instance $18668 m0 *1 137.75,28
X$18668 793 570 794 219 320 821 MUX2_X1
* cell instance $18670 m0 *1 139.27,28
X$18670 219 13434 795 880 847 320 DFF_X1
* cell instance $18674 m0 *1 147.82,28
X$18674 826 219 320 293 CLKBUF_X3
* cell instance $18675 m0 *1 148.77,28
X$18675 293 219 320 14797 CLKBUF_X3
* cell instance $18713 r0 *1 134.33,28
X$18713 793 512 791 219 320 879 MUX2_X1
* cell instance $18716 r0 *1 137.37,28
X$18716 792 219 320 881 INV_X1
* cell instance $18718 r0 *1 137.94,28
X$18718 793 577 795 219 320 880 MUX2_X1
* cell instance $18720 r0 *1 139.46,28
X$18720 793 624 850 219 320 848 MUX2_X1
* cell instance $18723 r0 *1 141.74,28
X$18723 881 627 219 320 849 NAND2_X1
* cell instance $18724 r0 *1 142.31,28
X$18724 850 621 795 219 320 952 MUX2_X1
* cell instance $18728 r0 *1 146.3,28
X$18728 219 499 320 627 BUF_X8
* cell instance $18729 r0 *1 148.77,28
X$18729 219 13782 853 887 669 320 DFF_X1
* cell instance $18731 m0 *1 150.86,28
X$18731 293 219 320 669 CLKBUF_X3
* cell instance $18734 m0 *1 157.13,28
X$18734 797 627 799 320 219 839 OAI21_X4
* cell instance $18735 m0 *1 159.6,28
X$18735 219 12597 800 834 732 320 DFF_X1
* cell instance $18736 m0 *1 162.83,28
X$18736 477 808 800 219 320 834 MUX2_X1
* cell instance $18738 m0 *1 164.92,28
X$18738 477 802 856 219 320 893 MUX2_X1
* cell instance $18739 m0 *1 166.25,28
X$18739 477 803 804 219 320 805 MUX2_X1
* cell instance $18740 m0 *1 167.58,28
X$18740 364 219 320 732 CLKBUF_X3
* cell instance $18747 r0 *1 152.95,28
X$18747 854 219 320 888 INV_X1
* cell instance $18749 r0 *1 153.52,28
X$18749 888 625 219 320 961 NAND2_X1
* cell instance $18750 r0 *1 154.09,28
X$18750 219 14654 892 963 669 320 DFF_X1
* cell instance $18754 r0 *1 159.41,28
X$18754 627 320 625 219 BUF_X4
* cell instance $18757 r0 *1 161.88,28
X$18757 800 621 838 219 320 968 MUX2_X1
* cell instance $18758 r0 *1 163.21,28
X$18758 219 14373 856 893 907 320 DFF_X1
* cell instance $18759 r0 *1 166.44,28
X$18759 732 219 320 14762 INV_X1
* cell instance $18760 r0 *1 166.82,28
X$18760 219 14347 804 805 732 320 DFF_X1
* cell instance $18763 r0 *1 172.33,28
X$18763 219 14669 859 858 735 320 DFF_X1
* cell instance $18769 m0 *1 177.27,28
X$18769 364 219 320 735 CLKBUF_X3
* cell instance $18771 m0 *1 179.93,28
X$18771 453 631 860 219 320 890 MUX2_X1
* cell instance $18775 r0 *1 178.6,28
X$18775 219 14424 860 890 735 320 DFF_X1
* cell instance $18778 m0 *1 186.77,28
X$18778 373 803 809 219 320 889 MUX2_X1
* cell instance $18779 m0 *1 185.44,28
X$18779 916 320 452 219 BUF_X4
* cell instance $18785 r0 *1 186.01,28
X$18785 219 14611 809 889 863 320 DFF_X1
* cell instance $18786 r0 *1 189.24,28
X$18786 373 801 864 219 320 865 MUX2_X1
* cell instance $18788 r0 *1 193.61,28
X$18788 321 631 885 219 320 886 MUX2_X1
* cell instance $18789 m0 *1 193.99,28
X$18789 219 13634 885 886 813 320 DFF_X1
* cell instance $18791 m0 *1 197.22,28
X$18791 545 219 320 813 CLKBUF_X3
* cell instance $18797 r0 *1 194.94,28
X$18797 321 632 823 219 320 866 MUX2_X1
* cell instance $18798 r0 *1 196.27,28
X$18798 823 920 885 219 320 884 MUX2_X1
* cell instance $18799 r0 *1 197.6,28
X$18799 219 13843 868 882 813 320 DFF_X1
* cell instance $18800 r0 *1 200.83,28
X$18800 386 632 868 219 320 882 MUX2_X1
* cell instance $18804 r0 *1 203.49,28
X$18804 386 631 870 219 320 871 MUX2_X1
* cell instance $18808 r0 *1 206.91,28
X$18808 323 684 872 219 320 878 MUX2_X1
* cell instance $18809 r0 *1 208.24,28
X$18809 219 13647 872 878 748 320 DFF_X1
* cell instance $18810 m0 *1 210.14,28
X$18810 380 219 320 748 CLKBUF_X3
* cell instance $18812 m0 *1 211.09,28
X$18812 748 219 320 14759 INV_X1
* cell instance $18815 m0 *1 213.18,28
X$18815 323 632 815 219 320 817 MUX2_X1
* cell instance $18816 m0 *1 214.51,28
X$18816 219 13379 815 817 748 320 DFF_X1
* cell instance $18824 r0 *1 211.47,28
X$18824 873 686 872 219 320 877 MUX2_X1
* cell instance $18825 r0 *1 212.8,28
X$18825 323 631 876 219 320 948 MUX2_X1
* cell instance $18861 m0 *1 143.64,25.2
X$18861 691 445 825 219 320 824 MUX2_X1
* cell instance $18862 m0 *1 144.97,25.2
X$18862 219 13484 728 727 669 320 DFF_X1
* cell instance $18863 m0 *1 148.2,25.2
X$18863 825 621 728 219 320 828 MUX2_X1
* cell instance $18902 r0 *1 135.47,25.2
X$18902 293 219 320 339 CLKBUF_X3
* cell instance $18903 r0 *1 136.42,25.2
X$18903 339 219 320 CLKBUF_X1
* cell instance $18904 r0 *1 136.99,25.2
X$18904 219 14465 794 821 339 320 DFF_X1
* cell instance $18909 r0 *1 145.35,25.2
X$18909 219 13708 825 824 669 320 DFF_X1
* cell instance $18911 m0 *1 153.14,25.2
X$18911 762 625 219 320 796 NAND2_X1
* cell instance $18912 m0 *1 149.91,25.2
X$18912 219 13458 729 765 669 320 DFF_X1
* cell instance $18915 r0 *1 151.62,25.2
X$18915 828 219 320 830 INV_X1
* cell instance $18918 r0 *1 153.14,25.2
X$18918 830 625 219 320 797 NAND2_X1
* cell instance $18919 r0 *1 153.71,25.2
X$18919 796 627 730 320 219 1368 OAI21_X4
* cell instance $18920 m0 *1 158.08,25.2
X$18920 219 13131 771 775 623 320 DFF_X1
* cell instance $18921 m0 *1 154.85,25.2
X$18921 219 13107 798 833 623 320 DFF_X1
* cell instance $18924 r0 *1 156.18,25.2
X$18924 691 357 798 219 320 833 MUX2_X1
* cell instance $18925 r0 *1 157.51,25.2
X$18925 798 670 771 219 320 799 MUX2_X1
* cell instance $18927 r0 *1 160.36,25.2
X$18927 219 14546 838 836 732 320 DFF_X1
* cell instance $18928 r0 *1 163.59,25.2
X$18928 477 801 838 219 320 836 MUX2_X1
* cell instance $18929 m0 *1 164.92,25.2
X$18929 219 12965 843 840 732 320 DFF_X1
* cell instance $18931 m0 *1 168.15,25.2
X$18931 219 13216 807 806 732 320 DFF_X1
* cell instance $18932 m0 *1 171.38,25.2
X$18932 785 714 219 320 844 NAND2_X1
* cell instance $18937 r0 *1 167.01,25.2
X$18937 731 803 843 219 320 840 MUX2_X1
* cell instance $18938 r0 *1 168.34,25.2
X$18938 731 802 807 219 320 806 MUX2_X1
* cell instance $18940 r0 *1 169.86,25.2
X$18940 807 670 843 219 320 845 MUX2_X1
* cell instance $18941 r0 *1 171.19,25.2
X$18941 844 625 845 320 219 846 OAI21_X4
* cell instance $18942 m0 *1 173.66,25.2
X$18942 219 13158 736 734 735 320 DFF_X1
* cell instance $18943 m0 *1 172.33,25.2
X$18943 570 320 801 219 BUF_X4
* cell instance $18946 r0 *1 174.04,25.2
X$18946 512 320 808 219 BUF_X4
* cell instance $18952 r0 *1 176.32,25.2
X$18952 789 350 736 219 320 842 MUX2_X1
* cell instance $18953 m0 *1 180.5,25.2
X$18953 737 452 721 219 320 837 MUX2_X1
* cell instance $18954 m0 *1 177.27,25.2
X$18954 219 13324 737 787 735 320 DFF_X1
* cell instance $18956 m0 *1 183.35,25.2
X$18956 367 680 738 219 320 677 MUX2_X1
* cell instance $18957 m0 *1 184.68,25.2
X$18957 367 684 739 219 320 780 MUX2_X1
* cell instance $18960 r0 *1 177.65,25.2
X$18960 842 219 320 841 INV_X1
* cell instance $18962 r0 *1 178.22,25.2
X$18962 577 320 803 219 BUF_X4
* cell instance $18963 r0 *1 179.55,25.2
X$18963 841 541 219 320 835 NAND2_X1
* cell instance $18965 r0 *1 180.5,25.2
X$18965 835 501 837 320 219 1030 OAI21_X4
* cell instance $18968 m0 *1 190.38,25.2
X$18968 811 621 741 219 320 812 MUX2_X1
* cell instance $18969 m0 *1 187.15,25.2
X$18969 219 13275 811 832 679 320 DFF_X1
* cell instance $18971 m0 *1 191.9,25.2
X$18971 827 541 219 320 829 NAND2_X1
* cell instance $18973 m0 *1 192.66,25.2
X$18973 219 13283 743 742 813 320 DFF_X1
* cell instance $18974 m0 *1 195.89,25.2
X$18974 635 631 744 219 320 745 MUX2_X1
* cell instance $18976 m0 *1 200.26,25.2
X$18976 219 12587 746 822 590 320 DFF_X1
* cell instance $18977 m0 *1 203.49,25.2
X$18977 763 465 746 219 320 814 MUX2_X1
* cell instance $18978 m0 *1 204.82,25.2
X$18978 369 632 759 219 320 747 MUX2_X1
* cell instance $18979 m0 *1 206.15,25.2
X$18979 759 465 749 219 320 819 MUX2_X1
* cell instance $18980 m0 *1 207.48,25.2
X$18980 369 631 749 219 320 758 MUX2_X1
* cell instance $18981 m0 *1 208.81,25.2
X$18981 219 12598 749 758 595 320 DFF_X1
* cell instance $18985 r0 *1 188.1,25.2
X$18985 635 680 811 219 320 832 MUX2_X1
* cell instance $18986 r0 *1 189.43,25.2
X$18986 829 499 812 320 219 831 OAI21_X4
* cell instance $18990 r0 *1 194.56,25.2
X$18990 219 14605 823 866 813 320 DFF_X1
* cell instance $18995 r0 *1 205.2,25.2
X$18995 814 819 522 320 219 820 MUX2_X2
* cell instance $18997 m0 *1 214.13,25.2
X$18997 750 632 753 219 320 816 MUX2_X1
* cell instance $18998 m0 *1 212.42,25.2
X$18998 756 757 522 320 219 818 MUX2_X2
* cell instance $18999 m0 *1 215.46,25.2
X$18999 219 13386 753 816 595 320 DFF_X1
* cell instance $19040 m0 *1 135.28,224
X$19040 219 13007 12107 12108 12067 320 DFF_X1
* cell instance $19042 m0 *1 140.03,224
X$19042 219 12900 12040 12066 12067 320 DFF_X1
* cell instance $19045 m0 *1 144.97,224
X$19045 10539 12043 320 219 12009 AND2_X1
* cell instance $19048 m0 *1 146.68,224
X$19048 12069 11977 12070 320 12072 219 OAI21_X1
* cell instance $19050 m0 *1 147.63,224
X$19050 12072 11550 219 320 12113 NOR2_X1
* cell instance $19051 m0 *1 148.2,224
X$19051 12073 11550 219 320 12162 NOR2_X1
* cell instance $19052 m0 *1 148.77,224
X$19052 219 12901 12074 12162 12067 320 DFF_X1
* cell instance $19091 r0 *1 137.37,224
X$19091 10642 320 3264 219 BUF_X4
* cell instance $19096 r0 *1 144.21,224
X$19096 219 12113 12067 12504 12069 320 DFF_X2
* cell instance $19100 r0 *1 154.85,224
X$19100 12166 11550 219 320 12164 NOR2_X1
* cell instance $19103 m0 *1 156.37,224
X$19103 12075 12166 219 320 12118 NOR2_X1
* cell instance $19105 m0 *1 156.94,224
X$19105 219 12046 12076 12173 11957 320 DFF_X1
* cell instance $19106 m0 *1 160.17,224
X$19106 12076 12128 219 320 12077 NOR2_X1
* cell instance $19107 m0 *1 160.74,224
X$19107 12172 219 320 12128 INV_X1
* cell instance $19113 m0 *1 175.75,224
X$19113 11365 11550 219 320 12124 NOR2_X1
* cell instance $19116 m0 *1 177.27,224
X$19116 219 12178 12079 12123 12078 320 DFF_X1
* cell instance $19117 m0 *1 180.5,224
X$19117 12178 12138 12137 320 219 12193 HA_X1
* cell instance $19118 m0 *1 182.4,224
X$19118 11365 219 320 12192 INV_X2
* cell instance $19123 r0 *1 156.56,224
X$19123 12167 219 320 12168 BUF_X1
* cell instance $19124 r0 *1 157.13,224
X$19124 12165 12076 12167 320 219 12127 HA_X1
* cell instance $19130 r0 *1 167.96,224
X$19130 12129 12219 12130 320 12187 219 OAI21_X1
* cell instance $19131 r0 *1 168.72,224
X$19131 12174 12176 12175 12133 320 219 12272 OAI22_X1
* cell instance $19132 r0 *1 169.67,224
X$19132 12221 219 320 12129 INV_X1
* cell instance $19133 r0 *1 170.05,224
X$19133 12129 12131 219 320 12130 NAND2_X1
* cell instance $19135 r0 *1 171,224
X$19135 12191 12132 219 320 12176 NAND2_X1
* cell instance $19137 r0 *1 171.76,224
X$19137 12132 12135 320 219 12134 XNOR2_X1
* cell instance $19143 r0 *1 176.13,224
X$19143 219 12214 12138 12124 12078 320 DFF_X1
* cell instance $19144 r0 *1 179.36,224
X$19144 219 14362 12080 12136 12078 320 DFF_X1
* cell instance $19148 r0 *1 187.53,224
X$19148 9818 219 320 12081 CLKBUF_X3
* cell instance $19149 r0 *1 188.48,224
X$19149 219 14620 12139 12141 12081 320 DFF_X1
* cell instance $19150 m0 *1 188.86,224
X$19150 12081 219 320 CLKBUF_X1
* cell instance $19153 m0 *1 189.62,224
X$19153 219 12087 12083 12082 12081 320 DFF_X1
* cell instance $19154 m0 *1 192.85,224
X$19154 12084 12085 219 320 12140 NOR2_X1
* cell instance $19156 r0 *1 191.71,224
X$19156 12140 12083 12139 320 11393 219 NOR3_X2
* cell instance $19157 r0 *1 193.04,224
X$19157 12141 12142 219 320 12177 NOR2_X1
* cell instance $19160 m0 *1 193.8,224
X$19160 12086 219 320 12143 BUF_X1
* cell instance $19162 r0 *1 194.18,224
X$19162 12170 12146 12145 219 12142 320 AOI21_X1
* cell instance $19163 m0 *1 196.65,224
X$19163 12119 12120 12143 219 320 12163 NOR3_X1
* cell instance $19164 m0 *1 194.75,224
X$19164 12144 12089 12169 320 219 12120 HA_X1
* cell instance $19167 r0 *1 194.94,224
X$19167 12163 12143 12144 219 12145 320 AOI21_X1
* cell instance $19168 r0 *1 195.7,224
X$19168 12169 12147 12171 12148 320 219 12170 OAI22_X1
* cell instance $19169 r0 *1 196.65,224
X$19169 12090 12147 12148 12091 320 219 12204 OAI22_X2
* cell instance $19170 r0 *1 198.36,224
X$19170 12150 12091 219 320 12149 NAND2_X1
* cell instance $19171 m0 *1 199.12,224
X$19171 12146 219 320 12161 INV_X1
* cell instance $19172 m0 *1 198.55,224
X$19172 12151 12094 219 320 12148 NAND2_X1
* cell instance $19174 m0 *1 199.69,224
X$19174 12143 12161 12092 219 320 12152 OR3_X1
* cell instance $19175 m0 *1 200.64,224
X$19175 12159 12152 12154 12093 219 320 12141 NAND4_X1
* cell instance $19176 m0 *1 201.59,224
X$19176 12153 12094 219 320 12154 NAND2_X1
* cell instance $19181 m0 *1 212.23,224
X$19181 219 12158 12026 12098 11579 320 DFF_X1
* cell instance $19182 m0 *1 215.46,224
X$19182 12158 219 320 11991 BUF_X2
* cell instance $19190 r0 *1 199.31,224
X$19190 12151 12160 219 320 12147 NAND2_X1
* cell instance $19191 r0 *1 199.88,224
X$19191 12143 12151 12199 219 320 12153 MUX2_X1
* cell instance $19192 r0 *1 201.21,224
X$19192 12151 12094 12160 320 219 12146 OAI21_X2
* cell instance $19193 r0 *1 202.54,224
X$19193 10496 12155 320 219 12159 AND2_X1
* cell instance $19203 m0 *1 237.31,224
X$19203 12156 219 320 8961 BUF_X1
* cell instance $19207 m0 *1 239.59,224
X$19207 8098 219 320 12157 BUF_X1
* cell instance $19232 m0 *1 94.43,240.8
X$19232 12400 219 320 11910 BUF_X1
* cell instance $19235 m0 *1 96.71,240.8
X$19235 12401 219 320 11103 BUF_X1
* cell instance $19238 m0 *1 98.99,240.8
X$19238 11384 219 320 12402 BUF_X2
* cell instance $19241 m0 *1 101.46,240.8
X$19241 11196 219 320 12404 BUF_X1
* cell instance $19245 m0 *1 106.02,240.8
X$19245 12405 219 320 8932 CLKBUF_X2
* cell instance $19246 m0 *1 106.78,240.8
X$19246 12466 219 320 9422 CLKBUF_X2
* cell instance $19247 m0 *1 107.54,240.8
X$19247 12407 219 320 8999 CLKBUF_X2
* cell instance $19259 m0 *1 12.35,64.4
X$19259 219 13203 2142 2141 2306 320 DFF_X1
* cell instance $19265 r0 *1 12.92,64.4
X$19265 2308 1599 2307 219 320 2380 MUX2_X1
* cell instance $19270 m0 *1 22.04,64.4
X$19270 2143 1552 2014 219 320 2280 MUX2_X1
* cell instance $19277 r0 *1 23.18,64.4
X$19277 219 14537 2312 2383 2309 320 DFF_X1
* cell instance $19278 r0 *1 26.41,64.4
X$19278 2312 1377 2313 219 320 2386 MUX2_X1
* cell instance $19280 r0 *1 27.93,64.4
X$19280 2211 1303 2315 219 320 2384 MUX2_X1
* cell instance $19283 r0 *1 30.21,64.4
X$19283 2308 1261 2212 219 320 2387 MUX2_X1
* cell instance $19285 r0 *1 33.06,64.4
X$19285 2308 1467 2388 219 320 2317 MUX2_X1
* cell instance $19287 m0 *1 35.34,64.4
X$19287 219 12590 2144 2213 2214 320 DFF_X1
* cell instance $19290 m0 *1 39.33,64.4
X$19290 2016 1523 2278 219 320 2180 MUX2_X1
* cell instance $19295 r0 *1 39.71,64.4
X$19295 1515 219 320 14714 INV_X2
* cell instance $19296 r0 *1 40.28,64.4
X$19296 219 14386 2391 2279 2214 320 DFF_X1
* cell instance $19297 m0 *1 41.99,64.4
X$19297 2181 1520 2278 219 320 2145 MUX2_X1
* cell instance $19300 r0 *1 43.51,64.4
X$19300 2316 219 320 1515 CLKBUF_X3
* cell instance $19301 m0 *1 43.89,64.4
X$19301 2280 1562 2183 219 320 2284 MUX2_X1
* cell instance $19303 m0 *1 45.22,64.4
X$19303 2146 2149 2182 219 320 2185 MUX2_X1
* cell instance $19304 m0 *1 46.55,64.4
X$19304 2016 1695 2215 219 320 2281 MUX2_X1
* cell instance $19305 m0 *1 47.88,64.4
X$19305 219 12943 2283 2216 2217 320 DFF_X1
* cell instance $19306 m0 *1 51.11,64.4
X$19306 2186 1640 2284 219 320 2219 MUX2_X1
* cell instance $19310 r0 *1 44.46,64.4
X$19310 219 14499 2215 2281 2214 320 DFF_X1
* cell instance $19311 r0 *1 47.69,64.4
X$19311 2016 1609 2283 219 320 2216 MUX2_X1
* cell instance $19313 r0 *1 49.21,64.4
X$19313 2283 1552 2215 219 320 2218 MUX2_X1
* cell instance $19315 r0 *1 50.92,64.4
X$19315 2185 2219 1643 320 219 2287 MUX2_X2
* cell instance $19317 r0 *1 53.01,64.4
X$19317 2211 1695 2394 219 320 2321 MUX2_X1
* cell instance $19319 r0 *1 54.72,64.4
X$19319 2211 1609 2395 219 320 2396 MUX2_X1
* cell instance $19321 r0 *1 56.43,64.4
X$19321 219 14299 2395 2396 2190 320 DFF_X1
* cell instance $19322 r0 *1 59.66,64.4
X$19322 1570 219 320 2190 CLKBUF_X3
* cell instance $19325 r0 *1 64.03,64.4
X$19325 2221 1746 2220 219 320 2398 MUX2_X1
* cell instance $19332 r0 *1 67.45,64.4
X$19332 219 14228 2401 2400 1929 320 DFF_X1
* cell instance $19334 m0 *1 72.96,64.4
X$19334 2297 219 320 1570 CLKBUF_X3
* cell instance $19336 m0 *1 73.91,64.4
X$19336 219 13159 2150 2288 1929 320 DFF_X1
* cell instance $19337 m0 *1 77.14,64.4
X$19337 2150 2032 1842 219 320 2288 MUX2_X1
* cell instance $19339 m0 *1 79.23,64.4
X$19339 1842 2037 2224 219 320 2405 MUX2_X1
* cell instance $19342 r0 *1 73.91,64.4
X$19342 1842 2148 2222 219 320 2404 MUX2_X1
* cell instance $19343 r0 *1 75.24,64.4
X$19343 219 14500 2222 2404 1929 320 DFF_X1
* cell instance $19344 r0 *1 78.47,64.4
X$19344 219 14467 2224 2405 2223 320 DFF_X1
* cell instance $19346 m0 *1 80.94,64.4
X$19346 219 12602 2195 2193 2223 320 DFF_X1
* cell instance $19347 r0 *1 81.7,64.4
X$19347 1842 1999 2407 219 320 2410 MUX2_X1
* cell instance $19348 r0 *1 83.03,64.4
X$19348 219 13654 2407 2410 2227 320 DFF_X1
* cell instance $19349 m0 *1 84.74,64.4
X$19349 2290 2225 219 2293 320 NAND2_X4
* cell instance $19353 r0 *1 86.45,64.4
X$19353 1159 1571 2325 219 320 2226 MUX2_X1
* cell instance $19354 m0 *1 87.02,64.4
X$19354 219 12586 2228 2411 2227 320 DFF_X1
* cell instance $19360 r0 *1 88.35,64.4
X$19360 1159 1480 2228 219 320 2411 MUX2_X1
* cell instance $19363 r0 *1 90.25,64.4
X$19363 1159 1478 2328 219 320 2412 MUX2_X1
* cell instance $19364 r0 *1 91.58,64.4
X$19364 1159 1746 2229 219 320 2414 MUX2_X1
* cell instance $19365 m0 *1 92.34,64.4
X$19365 219 13340 2230 2198 2227 320 DFF_X1
* cell instance $19368 m0 *1 96.33,64.4
X$19368 2035 1983 2299 219 320 2231 MUX2_X1
* cell instance $19370 m0 *1 99.18,64.4
X$19370 219 13052 2153 2300 2232 320 DFF_X1
* cell instance $19371 m0 *1 102.41,64.4
X$19371 2035 2037 2303 219 320 2302 MUX2_X1
* cell instance $19372 m0 *1 103.74,64.4
X$19372 219 12722 2303 2302 2232 320 DFF_X1
* cell instance $19375 r0 *1 92.91,64.4
X$19375 219 13660 2229 2414 2232 320 DFF_X1
* cell instance $19377 r0 *1 96.33,64.4
X$19377 219 13671 2299 2231 2232 320 DFF_X1
* cell instance $19379 r0 *1 99.94,64.4
X$19379 219 13916 2233 2234 2232 320 DFF_X1
* cell instance $19381 r0 *1 103.55,64.4
X$19381 219 13761 2330 2418 2232 320 DFF_X1
* cell instance $19384 r0 *1 107.35,64.4
X$19384 2304 2032 2035 219 320 2235 MUX2_X1
* cell instance $19386 m0 *1 108.11,64.4
X$19386 219 12686 2304 2235 2236 320 DFF_X1
* cell instance $19390 m0 *1 127.3,64.4
X$19390 441 1035 2154 219 320 2201 MUX2_X1
* cell instance $19392 m0 *1 134.71,64.4
X$19392 512 320 1011 219 BUF_X4
* cell instance $19396 r0 *1 108.68,64.4
X$19396 219 14145 2331 2421 2236 320 DFF_X1
* cell instance $19403 r0 *1 125.97,64.4
X$19403 219 14623 2238 2424 2237 320 DFF_X1
* cell instance $19404 r0 *1 129.2,64.4
X$19404 286 1011 2238 219 320 2424 MUX2_X1
* cell instance $19409 r0 *1 133.38,64.4
X$19409 219 14599 2333 2430 2237 320 DFF_X1
* cell instance $19412 r0 *1 137.56,64.4
X$19412 570 320 1012 219 BUF_X4
* cell instance $19413 m0 *1 138.89,64.4
X$19413 2042 1274 2117 219 320 2335 MUX2_X1
* cell instance $19415 m0 *1 140.22,64.4
X$19415 2305 714 2042 320 219 2205 OAI21_X4
* cell instance $19416 m0 *1 142.69,64.4
X$19416 2244 1489 219 320 2242 XNOR2_X2
* cell instance $19420 m0 *1 154.47,64.4
X$19420 408 1403 2245 219 320 2301 MUX2_X1
* cell instance $19423 r0 *1 138.89,64.4
X$19423 2243 2334 320 219 2435 XNOR2_X1
* cell instance $19424 r0 *1 140.03,64.4
X$19424 2239 1908 320 219 2240 XNOR2_X1
* cell instance $19425 r0 *1 141.17,64.4
X$19425 2435 2240 219 320 2339 NAND2_X2
* cell instance $19426 r0 *1 142.12,64.4
X$19426 219 2242 2437 2336 2155 2340 320 NAND4_X4
* cell instance $19428 r0 *1 146.3,64.4
X$19428 2438 2129 219 320 2437 XNOR2_X2
* cell instance $19429 r0 *1 148.2,64.4
X$19429 2342 1278 219 320 2341 XNOR2_X2
* cell instance $19432 r0 *1 153.33,64.4
X$19432 219 13711 2245 2301 2343 320 DFF_X1
* cell instance $19433 r0 *1 156.56,64.4
X$19433 408 1492 2448 219 320 2446 MUX2_X1
* cell instance $19434 m0 *1 158.27,64.4
X$19434 1943 219 320 2050 CLKBUF_X3
* cell instance $19435 m0 *1 156.94,64.4
X$19435 2051 2344 2007 219 320 2298 MUX2_X1
* cell instance $19436 m0 *1 159.22,64.4
X$19436 2050 219 320 CLKBUF_X1
* cell instance $19442 r0 *1 159.22,64.4
X$19442 2298 2450 2482 320 219 2292 MUX2_X2
* cell instance $19444 m0 *1 163.02,64.4
X$19444 2208 1772 2137 219 320 2453 MUX2_X1
* cell instance $19445 m0 *1 161.69,64.4
X$19445 326 1403 2208 219 320 2160 MUX2_X1
* cell instance $19446 m0 *1 164.35,64.4
X$19446 2206 2161 320 219 2452 XNOR2_X1
* cell instance $19447 m0 *1 165.49,64.4
X$19447 2244 2005 320 219 2454 XNOR2_X1
* cell instance $19457 r0 *1 166.82,64.4
X$19457 219 13978 2295 2294 2348 320 DFF_X1
* cell instance $19458 r0 *1 170.05,64.4
X$19458 317 2054 2295 219 320 2294 MUX2_X1
* cell instance $19460 r0 *1 172.14,64.4
X$19460 2056 1853 2246 219 320 2447 MUX2_X1
* cell instance $19462 r0 *1 174.23,64.4
X$19462 317 1852 2247 219 320 2451 MUX2_X1
* cell instance $19464 r0 *1 177.08,64.4
X$19464 2291 1585 2162 320 219 2449 OAI21_X4
* cell instance $19465 m0 *1 179.17,64.4
X$19465 2059 1853 2162 219 320 2249 MUX2_X1
* cell instance $19466 m0 *1 178.41,64.4
X$19466 1405 2059 219 320 2291 OR2_X1
* cell instance $19472 r0 *1 180.31,64.4
X$19472 1185 1776 219 320 2445 OR2_X1
* cell instance $19474 r0 *1 181.26,64.4
X$19474 1776 1853 1667 219 320 2289 MUX2_X1
* cell instance $19475 r0 *1 182.59,64.4
X$19475 2250 320 1775 219 BUF_X4
* cell instance $19478 r0 *1 184.49,64.4
X$19478 2248 2061 320 219 2355 XNOR2_X1
* cell instance $19480 r0 *1 185.82,64.4
X$19480 224 2053 2356 219 320 2488 MUX2_X1
* cell instance $19481 r0 *1 187.15,64.4
X$19481 224 2054 2357 219 320 2358 MUX2_X1
* cell instance $19484 r0 *1 189.62,64.4
X$19484 2243 2434 320 219 2436 XNOR2_X1
* cell instance $19485 r0 *1 190.76,64.4
X$19485 2352 2251 219 320 2359 OR2_X1
* cell instance $19487 r0 *1 191.71,64.4
X$19487 2251 2072 2110 219 320 2434 MUX2_X1
* cell instance $19488 r0 *1 193.04,64.4
X$19488 219 14359 2253 2427 2255 320 DFF_X1
* cell instance $19489 m0 *1 196.27,64.4
X$19489 2252 1112 2253 219 320 2164 MUX2_X1
* cell instance $19491 m0 *1 197.6,64.4
X$19491 1185 2164 219 320 2254 OR2_X2
* cell instance $19493 m0 *1 200.07,64.4
X$19493 1330 320 2256 219 BUF_X4
* cell instance $19495 m0 *1 201.59,64.4
X$19495 219 13326 2257 2286 2255 320 DFF_X1
* cell instance $19496 m0 *1 204.82,64.4
X$19496 2285 2165 2258 219 320 2194 MUX2_X1
* cell instance $19499 r0 *1 196.27,64.4
X$19499 2361 2057 2253 219 320 2427 MUX2_X1
* cell instance $19502 r0 *1 198.17,64.4
X$19502 219 14129 2363 2525 2255 320 DFF_X1
* cell instance $19506 r0 *1 202.73,64.4
X$19506 2285 2256 2257 219 320 2286 MUX2_X1
* cell instance $19507 r0 *1 204.06,64.4
X$19507 2257 1112 2258 219 320 2365 MUX2_X1
* cell instance $19509 r0 *1 206.15,64.4
X$19509 2259 219 320 1405 BUF_X2
* cell instance $19511 r0 *1 207.67,64.4
X$19511 1405 2282 219 320 2367 OR2_X1
* cell instance $19512 m0 *1 208.24,64.4
X$19512 2260 2256 2166 219 320 2192 MUX2_X1
* cell instance $19514 m0 *1 209.57,64.4
X$19514 2166 1329 2167 219 320 2282 MUX2_X1
* cell instance $19515 m0 *1 210.9,64.4
X$19515 2260 2165 2167 219 320 2168 MUX2_X1
* cell instance $19517 r0 *1 208.43,64.4
X$19517 2259 219 320 1185 BUF_X2
* cell instance $19520 r0 *1 212.42,64.4
X$19520 2259 219 320 1065 BUF_X2
* cell instance $19521 m0 *1 213.94,64.4
X$19521 219 13030 2170 2262 2263 320 DFF_X1
* cell instance $19522 m0 *1 212.61,64.4
X$19522 1330 320 2261 219 BUF_X4
* cell instance $19523 m0 *1 217.17,64.4
X$19523 2170 1329 2264 219 320 2402 MUX2_X1
* cell instance $19526 r0 *1 213.18,64.4
X$19526 1282 219 320 2940 CLKBUF_X3
* cell instance $19527 r0 *1 214.13,64.4
X$19527 2493 2261 2170 219 320 2262 MUX2_X1
* cell instance $19528 r0 *1 215.46,64.4
X$19528 219 13827 2264 2399 2263 320 DFF_X1
* cell instance $19529 r0 *1 218.69,64.4
X$19529 2265 2169 2267 219 320 2266 MUX2_X1
* cell instance $19531 m0 *1 219.64,64.4
X$19531 219 13224 2267 2266 2263 320 DFF_X1
* cell instance $19536 r0 *1 220.21,64.4
X$19536 2265 2261 2277 219 320 2171 MUX2_X1
* cell instance $19537 r0 *1 221.54,64.4
X$19537 2277 1329 2267 219 320 2268 MUX2_X1
* cell instance $19538 r0 *1 222.87,64.4
X$19538 1065 2268 219 320 2269 OR2_X1
* cell instance $19542 r0 *1 228.38,64.4
X$19542 2370 1677 2389 219 320 2390 MUX2_X1
* cell instance $19543 r0 *1 229.71,64.4
X$19543 2372 1868 2389 219 320 2373 MUX2_X1
* cell instance $19545 m0 *1 237.12,64.4
X$19545 1959 2274 2072 320 219 2275 MUX2_X2
* cell instance $19546 m0 *1 233.89,64.4
X$19546 219 13206 1961 2276 2382 320 DFF_X1
* cell instance $19547 m0 *1 238.83,64.4
X$19547 2270 219 320 1953 BUF_X1
* cell instance $19549 m0 *1 239.59,64.4
X$19549 2272 219 320 1782 BUF_X1
* cell instance $19550 m0 *1 240.16,64.4
X$19550 2271 219 320 1409 BUF_X1
* cell instance $19553 r0 *1 234.84,64.4
X$19553 2376 1677 2273 219 320 2385 MUX2_X1
* cell instance $19555 r0 *1 236.36,64.4
X$19555 219 13940 2273 2385 2382 320 DFF_X1
* cell instance $19597 m0 *1 124.83,215.6
X$19597 219 12631 11831 11830 11546 320 DFF_X1
* cell instance $19630 r0 *1 121.79,215.6
X$19630 219 14079 11912 11939 11911 320 DFF_X1
* cell instance $19633 r0 *1 125.4,215.6
X$19633 11853 8038 11912 219 320 11939 MUX2_X1
* cell instance $19635 r0 *1 126.92,215.6
X$19635 11853 7612 11804 219 320 11913 MUX2_X1
* cell instance $19637 m0 *1 128.63,215.6
X$19637 11805 11803 10749 320 219 8194 MUX2_X2
* cell instance $19639 m0 *1 130.34,215.6
X$19639 219 12567 11807 11914 11806 320 DFF_X1
* cell instance $19644 r0 *1 130.72,215.6
X$19644 11943 8038 11808 219 320 11854 MUX2_X1
* cell instance $19645 r0 *1 132.05,215.6
X$19645 11943 8040 11807 219 320 11914 MUX2_X1
* cell instance $19647 r0 *1 133.57,215.6
X$19647 11974 11834 10749 320 219 9828 MUX2_X2
* cell instance $19648 m0 *1 137.94,215.6
X$19648 11856 11387 11857 219 320 11947 MUX2_X1
* cell instance $19649 m0 *1 134.71,215.6
X$19649 219 12636 11856 11855 11806 320 DFF_X1
* cell instance $19652 r0 *1 135.47,215.6
X$19652 11945 8038 11856 219 320 11855 MUX2_X1
* cell instance $19654 r0 *1 136.99,215.6
X$19654 11945 8040 11857 219 320 11890 MUX2_X1
* cell instance $19655 r0 *1 138.32,215.6
X$19655 11946 10749 11947 219 320 11485 MUX2_X1
* cell instance $19658 m0 *1 139.65,215.6
X$19658 11858 8040 11893 219 320 11837 MUX2_X1
* cell instance $19659 r0 *1 139.84,215.6
X$19659 11858 8038 11860 219 320 11859 MUX2_X1
* cell instance $19660 r0 *1 141.17,215.6
X$19660 219 14470 11860 11859 11806 320 DFF_X1
* cell instance $19661 m0 *1 141.55,215.6
X$19661 11860 11387 11893 219 320 11894 MUX2_X1
* cell instance $19663 m0 *1 142.88,215.6
X$19663 11861 11894 10749 320 219 9998 MUX2_X2
* cell instance $19666 m0 *1 146.87,215.6
X$19666 11862 10464 11863 219 11895 320 AOI21_X1
* cell instance $19667 m0 *1 147.63,215.6
X$19667 9998 10464 3222 320 11862 219 OAI21_X1
* cell instance $19668 m0 *1 148.39,215.6
X$19668 11896 219 320 11863 INV_X1
* cell instance $19669 m0 *1 148.77,215.6
X$19669 11864 11843 219 320 11896 XOR2_X1
* cell instance $19673 r0 *1 145.35,215.6
X$19673 219 14503 11864 11895 11790 320 DFF_X1
* cell instance $19675 r0 *1 149.34,215.6
X$19675 9425 219 320 11790 CLKBUF_X3
* cell instance $19676 r0 *1 150.29,215.6
X$19676 10539 11897 320 219 11951 AND2_X1
* cell instance $19678 m0 *1 150.29,215.6
X$19678 9828 10464 11841 219 320 11897 MUX2_X1
* cell instance $19681 r0 *1 151.62,215.6
X$19681 10539 11810 320 219 11953 AND2_X1
* cell instance $19682 m0 *1 152.19,215.6
X$19682 8194 10464 11900 219 320 11810 MUX2_X1
* cell instance $19685 r0 *1 152.38,215.6
X$19685 219 11812 11844 11953 11790 320 DFF_X1
* cell instance $19686 m0 *1 154.09,215.6
X$19686 11739 219 320 11811 INV_X1
* cell instance $19688 m0 *1 154.47,215.6
X$19688 11901 11739 11899 219 11900 320 AOI21_X1
* cell instance $19689 m0 *1 155.23,215.6
X$19689 11844 11739 219 320 11901 NOR2_X1
* cell instance $19694 r0 *1 157.13,215.6
X$19694 219 14688 11915 11956 11957 320 DFF_X1
* cell instance $19695 m0 *1 161.69,215.6
X$19695 11903 320 4464 219 BUF_X4
* cell instance $19696 m0 *1 158.46,215.6
X$19696 219 11903 11904 11958 11957 320 DFF_X1
* cell instance $19699 m0 *1 165.3,215.6
X$19699 11963 11561 219 320 11797 OR2_X1
* cell instance $19700 m0 *1 166.06,215.6
X$19700 9390 11752 219 320 11908 NOR2_X1
* cell instance $19701 m0 *1 166.63,215.6
X$19701 9390 10218 320 219 11867 AND2_X1
* cell instance $19702 m0 *1 167.39,215.6
X$19702 10218 10543 320 219 11865 AND2_X1
* cell instance $19703 m0 *1 168.15,215.6
X$19703 11754 11866 11865 320 11905 219 OAI21_X1
* cell instance $19704 m0 *1 168.91,215.6
X$19704 11909 11758 219 320 11866 NOR2_X1
* cell instance $19706 m0 *1 169.67,215.6
X$19706 9390 219 320 11757 BUF_X2
* cell instance $19707 m0 *1 170.43,215.6
X$19707 11817 11907 11696 219 320 11902 NAND3_X1
* cell instance $19708 m0 *1 171.19,215.6
X$19708 10574 11816 11868 219 11754 320 AOI21_X1
* cell instance $19710 m0 *1 172.14,215.6
X$19710 11868 10574 11697 320 11870 219 OAI21_X1
* cell instance $19712 m0 *1 173.09,215.6
X$19712 11752 11898 11757 219 11872 320 AOI21_X1
* cell instance $19713 m0 *1 173.85,215.6
X$19713 11543 10746 11705 219 320 11873 OR3_X1
* cell instance $19716 r0 *1 160.74,215.6
X$19716 11959 11906 11960 320 11958 219 OAI21_X1
* cell instance $19717 r0 *1 161.5,215.6
X$19717 11813 10472 11643 219 320 11960 NAND3_X1
* cell instance $19718 r0 *1 162.26,215.6
X$19718 11904 320 11643 219 BUF_X4
* cell instance $19721 r0 *1 164.54,215.6
X$19721 11908 11965 11814 320 11962 219 NOR3_X2
* cell instance $19722 r0 *1 165.87,215.6
X$19722 11962 11867 10679 219 320 12005 NAND3_X1
* cell instance $19724 r0 *1 166.82,215.6
X$19724 11963 11873 10543 11887 219 320 11967 AOI22_X2
* cell instance $19725 r0 *1 168.53,215.6
X$19725 11757 11643 219 320 11909 NAND2_X1
* cell instance $19726 r0 *1 169.1,215.6
X$19726 11867 11815 219 320 11907 NAND2_X1
* cell instance $19727 r0 *1 169.67,215.6
X$19727 11543 11902 11887 219 11906 320 AOI21_X1
* cell instance $19728 r0 *1 170.43,215.6
X$19728 11543 219 320 11816 INV_X1
* cell instance $19729 r0 *1 170.81,215.6
X$19729 11696 11816 11697 6685 219 320 11916 NAND4_X1
* cell instance $19730 r0 *1 171.76,215.6
X$19730 11852 11869 3222 11870 219 320 11969 AOI22_X1
* cell instance $19731 r0 *1 172.71,215.6
X$19731 11493 10543 11643 219 11871 320 AOI21_X1
* cell instance $19732 r0 *1 173.47,215.6
X$19732 10664 11813 11887 11872 219 320 11874 OR4_X1
* cell instance $19733 r0 *1 174.61,215.6
X$19733 11813 10472 11493 219 320 11917 NAND3_X1
* cell instance $19738 m0 *1 175.18,215.6
X$19738 11813 10472 11543 219 320 11971 NAND3_X1
* cell instance $19741 m0 *1 179.93,215.6
X$19741 11846 11892 11564 320 11919 219 NOR3_X2
* cell instance $19742 m0 *1 181.26,215.6
X$19742 1954 11818 11875 11706 11891 219 320 OAI211_X2
* cell instance $19743 m0 *1 182.97,215.6
X$19743 11819 11570 219 320 11875 NOR2_X1
* cell instance $19746 m0 *1 185.82,215.6
X$19746 11876 10054 219 320 11820 NAND2_X1
* cell instance $19747 m0 *1 186.39,215.6
X$19747 11651 219 320 11571 INV_X1
* cell instance $19749 m0 *1 186.96,215.6
X$19749 11767 11821 11878 219 320 11879 NOR3_X1
* cell instance $19752 m0 *1 190,215.6
X$19752 219 11880 11832 11822 11823 320 DFF_X1
* cell instance $19753 m0 *1 193.23,215.6
X$19753 219 11881 11823 12498 8518 320 DFF_X2
* cell instance $19754 m0 *1 196.84,215.6
X$19754 219 13455 11882 11886 11823 320 DFF_X1
* cell instance $19755 m0 *1 200.07,215.6
X$19755 11882 219 320 11466 BUF_X2
* cell instance $19761 m0 *1 212.42,215.6
X$19761 11936 11935 12521 320 219 11883 HA_X1
* cell instance $19768 r0 *1 175.37,215.6
X$19768 11874 11971 219 320 11972 NAND2_X1
* cell instance $19771 r0 *1 176.51,215.6
X$19771 11918 320 11493 219 BUF_X4
* cell instance $19772 r0 *1 177.84,215.6
X$19772 11702 219 320 14773 INV_X1
* cell instance $19774 r0 *1 178.6,215.6
X$19774 219 11966 11964 11891 11702 320 DFF_X1
* cell instance $19775 r0 *1 181.83,215.6
X$19775 11966 320 7462 219 BUF_X4
* cell instance $19777 r0 *1 183.54,215.6
X$19777 11964 219 320 11647 BUF_X2
* cell instance $19779 r0 *1 185.82,215.6
X$19779 11620 11571 11919 11889 219 320 11961 NAND4_X1
* cell instance $19780 r0 *1 186.77,215.6
X$19780 11571 11877 11838 320 11955 219 OAI21_X1
* cell instance $19781 r0 *1 187.53,215.6
X$19781 11889 11888 11620 219 320 11952 OR3_X1
* cell instance $19782 r0 *1 188.48,215.6
X$19782 11888 219 320 11922 INV_X1
* cell instance $19784 r0 *1 189.05,215.6
X$19784 10664 320 9386 219 BUF_X4
* cell instance $19787 r0 *1 193.61,215.6
X$19787 219 12088 11823 12503 8470 320 DFF_X2
* cell instance $19788 r0 *1 197.22,215.6
X$19788 219 12065 11823 12510 8491 320 DFF_X2
* cell instance $19790 r0 *1 206.91,215.6
X$19790 11985 10326 219 320 11944 NOR2_X1
* cell instance $19791 r0 *1 207.48,215.6
X$19791 219 11944 11924 11925 11936 320 DFF_X2
* cell instance $19794 r0 *1 211.66,215.6
X$19794 11990 10326 219 320 11937 NOR2_X1
* cell instance $19795 r0 *1 212.23,215.6
X$19795 219 11937 11579 11927 11935 320 DFF_X2
* cell instance $19804 r0 *1 233.32,215.6
X$19804 7193 219 320 11929 BUF_X1
* cell instance $19806 m0 *1 235.41,215.6
X$19806 11884 219 320 6837 BUF_X2
* cell instance $19808 m0 *1 236.17,215.6
X$19808 10370 219 320 11885 BUF_X1
* cell instance $19812 r0 *1 236.17,215.6
X$19812 8413 219 320 11930 BUF_X1
* cell instance $19815 m0 *1 238.64,215.6
X$19815 11928 219 320 7639 CLKBUF_X2
* cell instance $19850 m0 *1 163.59,235.2
X$19850 3264 12389 320 219 12328 AND2_X1
* cell instance $19852 m0 *1 164.54,235.2
X$19852 3264 10690 320 219 12358 AND2_X1
* cell instance $19887 r0 *1 163.78,235.2
X$19887 219 12330 12331 12328 12185 320 DFF_X1
* cell instance $19888 m0 *1 167.58,235.2
X$19888 219 12661 12334 12360 12185 320 DFF_X1
* cell instance $19889 m0 *1 165.68,235.2
X$19889 12331 12329 12519 320 219 12284 HA_X1
* cell instance $19890 m0 *1 170.81,235.2
X$19890 12332 12333 219 320 12361 NOR2_X1
* cell instance $19891 m0 *1 171.38,235.2
X$19891 12334 219 320 12333 INV_X1
* cell instance $19894 m0 *1 172.71,235.2
X$19894 12361 12331 12336 219 320 11377 NOR3_X1
* cell instance $19899 m0 *1 182.02,235.2
X$19899 12337 219 320 12367 INV_X1
* cell instance $19900 m0 *1 182.4,235.2
X$19900 12339 219 320 12296 INV_X1
* cell instance $19901 m0 *1 182.78,235.2
X$19901 12296 12193 219 320 12338 NAND2_X1
* cell instance $19902 m0 *1 183.35,235.2
X$19902 12241 12338 12341 320 12368 219 OAI21_X1
* cell instance $19903 m0 *1 184.11,235.2
X$19903 12239 12299 12238 12339 219 320 12341 NAND4_X1
* cell instance $19904 m0 *1 185.06,235.2
X$19904 12340 219 320 12239 BUF_X2
* cell instance $19908 m0 *1 193.61,235.2
X$19908 12344 12374 320 219 11881 AND2_X1
* cell instance $19909 m0 *1 194.37,235.2
X$19909 219 12349 12302 12496 7614 320 DFF_X2
* cell instance $19910 m0 *1 197.98,235.2
X$19910 12344 12346 320 219 10929 AND2_X1
* cell instance $19912 m0 *1 199.5,235.2
X$19912 12344 12347 320 219 11017 AND2_X1
* cell instance $19931 r0 *1 195.7,235.2
X$19931 12344 12375 320 219 12350 AND2_X1
* cell instance $19932 r0 *1 196.46,235.2
X$19932 12344 12382 320 219 12349 AND2_X1
* cell instance $19934 r0 *1 197.6,235.2
X$19934 12344 12381 320 219 12065 AND2_X1
* cell instance $19938 r0 *1 199.69,235.2
X$19938 12344 12378 320 219 11205 AND2_X1
* cell instance $19967 m0 *1 12.35,123.2
X$19967 219 13419 5925 6090 6092 320 DFF_X1
* cell instance $19968 m0 *1 15.58,123.2
X$19968 5924 6002 5926 219 320 6091 MUX2_X1
* cell instance $19970 m0 *1 17.1,123.2
X$19970 219 13417 6155 6034 6092 320 DFF_X1
* cell instance $19981 r0 *1 13.3,123.2
X$19981 219 14029 5926 6091 6092 320 DFF_X1
* cell instance $19984 r0 *1 17.1,123.2
X$19984 5924 6154 6155 219 320 6034 MUX2_X1
* cell instance $19987 r0 *1 19.38,123.2
X$19987 5927 2731 6155 219 320 6208 MUX2_X1
* cell instance $19990 r0 *1 22.42,123.2
X$19990 219 14476 6098 6096 6157 320 DFF_X1
* cell instance $19991 m0 *1 24.32,123.2
X$19991 5802 4058 6098 219 320 6100 MUX2_X1
* cell instance $19992 m0 *1 22.99,123.2
X$19992 5924 6156 6098 219 320 6096 MUX2_X1
* cell instance $19994 m0 *1 27.17,123.2
X$19994 5924 219 320 5803 BUF_X2
* cell instance $19998 r0 *1 27.36,123.2
X$19998 219 14547 6037 6102 6157 320 DFF_X1
* cell instance $19999 m0 *1 29.64,123.2
X$19999 5924 6121 6037 219 320 6102 MUX2_X1
* cell instance $20000 m0 *1 28.31,123.2
X$20000 6100 2963 6035 219 320 6036 MUX2_X1
* cell instance $20003 m0 *1 31.92,123.2
X$20003 5803 6046 6103 219 320 6158 MUX2_X1
* cell instance $20007 r0 *1 31.73,123.2
X$20007 219 13890 6103 6158 6157 320 DFF_X1
* cell instance $20008 m0 *1 33.82,123.2
X$20008 5928 2657 6103 219 320 6107 MUX2_X1
* cell instance $20011 m0 *1 35.91,123.2
X$20011 6108 4003 6107 219 320 6106 MUX2_X1
* cell instance $20013 m0 *1 38.76,123.2
X$20013 6106 2777 219 320 6109 NAND2_X1
* cell instance $20014 m0 *1 39.33,123.2
X$20014 6036 2776 219 320 6038 NAND2_X1
* cell instance $20015 m0 *1 39.9,123.2
X$20015 6038 6109 2890 219 320 5998 NAND3_X2
* cell instance $20017 m0 *1 41.42,123.2
X$20017 5931 6110 5803 219 320 5994 MUX2_X1
* cell instance $20019 m0 *1 42.94,123.2
X$20019 5803 6270 6039 219 320 6112 MUX2_X1
* cell instance $20020 m0 *1 44.27,123.2
X$20020 219 13359 6039 6112 6115 320 DFF_X1
* cell instance $20022 m0 *1 47.69,123.2
X$20022 219 13420 6040 6212 6115 320 DFF_X1
* cell instance $20024 m0 *1 51.11,123.2
X$20024 5932 6121 6119 219 320 6041 MUX2_X1
* cell instance $20031 r0 *1 49.59,123.2
X$20031 5932 5923 6040 219 320 6212 MUX2_X1
* cell instance $20032 r0 *1 50.92,123.2
X$20032 219 14017 6119 6041 6159 320 DFF_X1
* cell instance $20033 m0 *1 54.15,123.2
X$20033 6119 1392 6040 219 320 6124 MUX2_X1
* cell instance $20034 m0 *1 52.82,123.2
X$20034 5932 6156 6117 219 320 6120 MUX2_X1
* cell instance $20035 m0 *1 55.48,123.2
X$20035 6117 1392 6266 219 320 6122 MUX2_X1
* cell instance $20037 r0 *1 54.15,123.2
X$20037 219 14255 6117 6120 6159 320 DFF_X1
* cell instance $20039 m0 *1 57.19,123.2
X$20039 6122 6124 1651 320 219 5935 MUX2_X2
* cell instance $20043 m0 *1 64.41,123.2
X$20043 6127 5864 6043 219 320 6162 MUX2_X1
* cell instance $20047 r0 *1 58.33,123.2
X$20047 6043 6042 6161 219 320 6160 MUX2_X1
* cell instance $20048 r0 *1 59.66,123.2
X$20048 6161 2904 6424 219 320 6215 MUX2_X1
* cell instance $20054 r0 *1 64.41,123.2
X$20054 219 14151 6127 6162 6325 320 DFF_X1
* cell instance $20056 m0 *1 66.12,123.2
X$20056 6043 5808 6045 219 320 6129 MUX2_X1
* cell instance $20057 m0 *1 67.64,123.2
X$20057 6044 2327 6045 219 320 6131 MUX2_X1
* cell instance $20059 r0 *1 67.64,123.2
X$20059 6127 2327 6269 219 320 6163 MUX2_X1
* cell instance $20060 r0 *1 68.97,123.2
X$20060 6163 5077 6131 219 320 6223 MUX2_X1
* cell instance $20061 m0 *1 69.54,123.2
X$20061 3910 320 5804 219 BUF_X4
* cell instance $20063 m0 *1 70.87,123.2
X$20063 5711 6046 6048 219 320 6047 MUX2_X1
* cell instance $20064 m0 *1 72.2,123.2
X$20064 5711 6270 6049 219 320 6218 MUX2_X1
* cell instance $20068 r0 *1 72.58,123.2
X$20068 219 13784 6049 6218 6427 320 DFF_X1
* cell instance $20069 m0 *1 74.1,123.2
X$20069 6048 1933 6049 219 320 6135 MUX2_X1
* cell instance $20074 m0 *1 77.9,123.2
X$20074 219 13418 6009 6136 6427 320 DFF_X1
* cell instance $20079 r0 *1 78.47,123.2
X$20079 6164 4617 6221 219 320 6222 MUX2_X1
* cell instance $20080 r0 *1 79.8,123.2
X$20080 219 14035 6221 6222 6053 320 DFF_X1
* cell instance $20081 m0 *1 81.7,123.2
X$20081 6221 5120 6330 219 320 6050 MUX2_X1
* cell instance $20084 m0 *1 83.79,123.2
X$20084 2901 320 2327 219 BUF_X4
* cell instance $20085 m0 *1 85.12,123.2
X$20085 6051 6052 219 6138 320 NAND2_X4
* cell instance $20086 m0 *1 86.83,123.2
X$20086 6052 6051 320 219 6140 AND2_X2
* cell instance $20087 m0 *1 87.78,123.2
X$20087 219 13416 5937 5936 6053 320 DFF_X1
* cell instance $20093 r0 *1 84.55,123.2
X$20093 6165 1392 219 320 4289 OR2_X2
* cell instance $20096 r0 *1 86.45,123.2
X$20096 1933 6165 219 320 3919 NAND2_X2
* cell instance $20098 r0 *1 88.16,123.2
X$20098 5511 4255 6271 219 320 6225 MUX2_X1
* cell instance $20101 r0 *1 96.33,123.2
X$20101 6227 4127 219 320 6229 NOR2_X1
* cell instance $20102 m0 *1 96.9,123.2
X$20102 6139 3370 5515 219 320 6230 NOR3_X1
* cell instance $20104 m0 *1 97.66,123.2
X$20104 6137 4566 219 320 6228 NOR2_X1
* cell instance $20107 r0 *1 96.9,123.2
X$20107 6278 6230 6229 6228 320 5940 219 NOR4_X2
* cell instance $20110 r0 *1 99.75,123.2
X$20110 2438 6231 219 320 6235 XOR2_X1
* cell instance $20113 r0 *1 101.46,123.2
X$20113 6281 6232 6168 219 6234 320 AOI21_X1
* cell instance $20115 m0 *1 101.65,123.2
X$20115 219 5945 6054 6234 6141 5944 5891 6143 320 OAI222_X2
* cell instance $20116 m0 *1 104.5,123.2
X$20116 2243 5819 6169 219 320 6170 OR3_X1
* cell instance $20118 m0 *1 106.21,123.2
X$20118 6142 5122 5077 219 320 6055 NOR3_X1
* cell instance $20119 m0 *1 106.97,123.2
X$20119 6056 5946 6169 320 219 4141 OAI21_X4
* cell instance $20122 m0 *1 111.15,123.2
X$20122 6238 6057 6339 219 320 6019 MUX2_X1
* cell instance $20125 m0 *1 119.32,123.2
X$20125 219 13400 6144 5951 6145 320 DFF_X1
* cell instance $20129 m0 *1 132.43,123.2
X$20129 219 13424 6246 6147 6058 320 DFF_X1
* cell instance $20131 m0 *1 136.42,123.2
X$20131 5903 4819 6059 219 320 6148 MUX2_X1
* cell instance $20132 m0 *1 137.75,123.2
X$20132 219 13429 6059 6148 6058 320 DFF_X1
* cell instance $20133 m0 *1 140.98,123.2
X$20133 6059 5828 6061 219 320 6060 MUX2_X1
* cell instance $20134 m0 *1 142.31,123.2
X$20134 6060 4921 5905 219 320 6149 MUX2_X1
* cell instance $20136 m0 *1 146.68,123.2
X$20136 2239 6149 219 320 6062 XNOR2_X2
* cell instance $20140 r0 *1 102.22,123.2
X$20140 6166 5819 2243 219 320 6232 NAND3_X1
* cell instance $20141 r0 *1 102.98,123.2
X$20141 2243 5421 6166 219 320 6168 OR3_X1
* cell instance $20142 r0 *1 103.93,123.2
X$20142 6235 6236 6170 219 6141 320 AOI21_X1
* cell instance $20143 r0 *1 104.69,123.2
X$20143 6169 5421 2243 219 320 6236 NAND3_X1
* cell instance $20145 r0 *1 106.97,123.2
X$20145 4854 6166 219 320 6056 OR2_X1
* cell instance $20146 r0 *1 107.73,123.2
X$20146 2674 4291 219 320 6171 XNOR2_X2
* cell instance $20149 r0 *1 110.77,123.2
X$20149 219 14333 6238 6340 6145 320 DFF_X1
* cell instance $20151 r0 *1 115.52,123.2
X$20151 219 13912 6173 6240 6145 320 DFF_X1
* cell instance $20152 r0 *1 118.75,123.2
X$20152 6173 6172 6144 219 320 6242 MUX2_X1
* cell instance $20156 r0 *1 120.08,123.2
X$20156 6243 2998 6241 219 320 6166 MUX2_X1
* cell instance $20157 r0 *1 121.41,123.2
X$20157 6174 2904 6242 219 320 6241 MUX2_X1
* cell instance $20160 r0 *1 123.31,123.2
X$20160 6345 2904 6244 219 320 6243 MUX2_X1
* cell instance $20163 r0 *1 125.21,123.2
X$20163 6286 5217 5953 219 320 6244 MUX2_X1
* cell instance $20166 r0 *1 133.38,123.2
X$20166 6245 4377 6246 219 320 6147 MUX2_X1
* cell instance $20170 r0 *1 137.18,123.2
X$20170 5903 4623 6061 219 320 6247 MUX2_X1
* cell instance $20171 r0 *1 138.51,123.2
X$20171 219 14073 6061 6247 6058 320 DFF_X1
* cell instance $20173 r0 *1 144.78,123.2
X$20173 5909 4819 6292 219 320 6290 MUX2_X1
* cell instance $20176 r0 *1 147.06,123.2
X$20176 5909 4623 6175 219 320 6248 MUX2_X1
* cell instance $20178 r0 *1 148.58,123.2
X$20178 219 14070 6175 6248 6291 320 DFF_X1
* cell instance $20179 m0 *1 151.43,123.2
X$20179 219 13421 6150 6249 6063 320 DFF_X1
* cell instance $20182 m0 *1 154.85,123.2
X$20182 4382 6064 219 320 6151 OR2_X1
* cell instance $20183 m0 *1 155.61,123.2
X$20183 6064 4921 6066 219 320 6252 MUX2_X1
* cell instance $20184 m0 *1 156.94,123.2
X$20184 6151 4383 6066 320 219 5961 OAI21_X4
* cell instance $20187 r0 *1 151.81,123.2
X$20187 5831 4623 6150 219 320 6249 MUX2_X1
* cell instance $20188 r0 *1 153.14,123.2
X$20188 5831 4819 6251 219 320 6250 MUX2_X1
* cell instance $20190 r0 *1 155.23,123.2
X$20190 2534 6252 219 320 6451 XNOR2_X2
* cell instance $20194 r0 *1 159.79,123.2
X$20194 6287 4355 219 320 6176 NOR2_X1
* cell instance $20195 r0 *1 160.36,123.2
X$20195 6176 6294 6253 320 6254 219 NOR3_X2
* cell instance $20196 m0 *1 160.74,123.2
X$20196 6256 5958 439 219 320 NOR2_X4
* cell instance $20199 r0 *1 161.69,123.2
X$20199 3650 1365 6257 3275 320 219 6253 OAI22_X2
* cell instance $20200 m0 *1 163.4,123.2
X$20200 219 6152 5623 6153 6067 320 AOI21_X4
* cell instance $20201 m0 *1 162.83,123.2
X$20201 6259 4355 219 320 6260 NOR2_X1
* cell instance $20202 m0 *1 165.87,123.2
X$20202 4087 320 3470 219 BUF_X4
* cell instance $20204 m0 *1 167.96,123.2
X$20204 6068 219 320 4472 CLKBUF_X3
* cell instance $20205 m0 *1 168.91,123.2
X$20205 4254 1281 2449 3390 320 219 6255 OAI22_X2
* cell instance $20207 r0 *1 163.4,123.2
X$20207 6260 6358 6261 320 6256 219 NOR3_X2
* cell instance $20208 r0 *1 164.73,123.2
X$20208 3650 2158 6297 3275 320 219 6261 OAI22_X2
* cell instance $20210 r0 *1 167.96,123.2
X$20210 4400 5834 5960 3565 320 219 6258 OAI22_X2
* cell instance $20212 r0 *1 169.86,123.2
X$20212 6255 6258 219 320 6178 NOR2_X2
* cell instance $20213 r0 *1 170.81,123.2
X$20213 3513 6030 891 3335 320 219 6299 OAI22_X2
* cell instance $20214 m0 *1 171.19,123.2
X$20214 219 253 3866 6300 6069 320 AOI21_X4
* cell instance $20216 m0 *1 173.66,123.2
X$20216 6070 6071 219 320 6069 NOR2_X1
* cell instance $20218 r0 *1 172.52,123.2
X$20218 3443 6179 2105 3158 320 219 6352 OAI22_X2
* cell instance $20221 m0 *1 174.61,123.2
X$20221 4521 5961 5964 3693 320 219 6028 OAI22_X2
* cell instance $20222 m0 *1 176.51,123.2
X$20222 3217 2205 2443 3158 320 219 6146 OAI22_X2
* cell instance $20223 m0 *1 178.22,123.2
X$20223 6075 2205 2443 3506 320 219 5962 OAI22_X2
* cell instance $20224 m0 *1 179.93,123.2
X$20224 6073 320 4087 219 BUF_X4
* cell instance $20226 r0 *1 174.99,123.2
X$20226 6186 320 4400 219 BUF_X4
* cell instance $20231 r0 *1 176.51,123.2
X$20231 3788 6179 3390 2105 320 219 6342 OAI22_X1
* cell instance $20232 r0 *1 177.46,123.2
X$20232 4400 5961 3565 5964 320 219 6181 OAI22_X1
* cell instance $20233 r0 *1 178.41,123.2
X$20233 4254 2205 3390 2443 320 219 6182 OAI22_X1
* cell instance $20234 r0 *1 179.36,123.2
X$20234 3698 2205 3507 2443 320 219 6072 OAI22_X1
* cell instance $20235 r0 *1 180.31,123.2
X$20235 6239 6183 5904 219 6210 320 AOI21_X2
* cell instance $20237 m0 *1 182.97,123.2
X$20237 4735 320 6020 219 BUF_X4
* cell instance $20238 m0 *1 181.64,123.2
X$20238 5632 5966 6074 219 6094 320 AOI21_X2
* cell instance $20241 r0 *1 182.02,123.2
X$20241 5617 6184 219 320 6185 NAND2_X1
* cell instance $20242 r0 *1 182.59,123.2
X$20242 6187 320 3468 219 BUF_X4
* cell instance $20244 r0 *1 184.3,123.2
X$20244 6186 219 320 4740 CLKBUF_X3
* cell instance $20247 m0 *1 187.53,123.2
X$20247 4522 831 2518 3666 320 219 6077 OAI22_X2
* cell instance $20248 m0 *1 186.2,123.2
X$20248 6073 320 6075 219 BUF_X4
* cell instance $20249 m0 *1 189.24,123.2
X$20249 3512 5967 3280 831 320 219 6132 OAI22_X1
* cell instance $20250 m0 *1 190.19,123.2
X$20250 4740 5967 4254 831 320 219 6078 OAI22_X1
* cell instance $20251 m0 *1 191.14,123.2
X$20251 5975 6134 5971 219 320 6126 NOR3_X1
* cell instance $20252 m0 *1 191.9,123.2
X$20252 6133 6132 6130 219 320 6128 NOR3_X1
* cell instance $20253 m0 *1 192.66,123.2
X$20253 4523 5970 3468 2518 320 219 6130 OAI22_X1
* cell instance $20256 m0 *1 195.89,123.2
X$20256 219 13358 6079 6125 6191 320 DFF_X1
* cell instance $20258 m0 *1 199.31,123.2
X$20258 6189 6080 6079 219 320 6081 MUX2_X1
* cell instance $20260 r0 *1 186.39,123.2
X$20260 6077 6188 6076 320 6233 219 NOR3_X2
* cell instance $20261 r0 *1 187.72,123.2
X$20261 4828 5967 5970 3513 320 219 6188 OAI22_X2
* cell instance $20262 r0 *1 189.43,123.2
X$20262 6187 320 3506 219 BUF_X4
* cell instance $20263 r0 *1 190.76,123.2
X$20263 5969 6078 6226 219 320 6224 NOR3_X1
* cell instance $20265 r0 *1 191.71,123.2
X$20265 4586 5970 3978 2518 320 219 6226 OAI22_X1
* cell instance $20270 r0 *1 195.51,123.2
X$20270 219 13731 6189 6327 6190 320 DFF_X1
* cell instance $20271 r0 *1 198.74,123.2
X$20271 219 14307 6192 6220 6191 320 DFF_X1
* cell instance $20272 m0 *1 201.78,123.2
X$20272 219 5235 6123 3624 6082 320 AOI21_X4
* cell instance $20273 m0 *1 201.02,123.2
X$20273 5640 6081 320 219 6123 AND2_X1
* cell instance $20276 m0 *1 205.96,123.2
X$20276 5640 6083 320 219 6118 AND2_X1
* cell instance $20277 m0 *1 206.72,123.2
X$20277 6083 6116 6084 219 320 6004 MUX2_X1
* cell instance $20280 m0 *1 209.76,123.2
X$20280 6196 5277 6085 219 320 6083 MUX2_X1
* cell instance $20283 r0 *1 201.97,123.2
X$20283 219 14097 6193 6219 6191 320 DFF_X1
* cell instance $20284 r0 *1 205.2,123.2
X$20284 6195 5198 6194 219 320 6217 MUX2_X1
* cell instance $20285 r0 *1 206.53,123.2
X$20285 6194 6397 6216 219 320 6084 MUX2_X1
* cell instance $20286 r0 *1 207.86,123.2
X$20286 6195 5036 6216 219 320 6418 MUX2_X1
* cell instance $20287 r0 *1 209.19,123.2
X$20287 6195 5447 6196 219 320 6307 MUX2_X1
* cell instance $20289 r0 *1 211.28,123.2
X$20289 219 14005 6085 6114 6197 320 DFF_X1
* cell instance $20290 m0 *1 212.42,123.2
X$20290 6195 5448 6085 219 320 6114 MUX2_X1
* cell instance $20296 r0 *1 215.27,123.2
X$20296 6197 219 320 CLKBUF_X1
* cell instance $20297 r0 *1 215.84,123.2
X$20297 219 14492 6111 6113 6197 320 DFF_X1
* cell instance $20298 m0 *1 216.6,123.2
X$20298 6309 5036 6111 219 320 6113 MUX2_X1
* cell instance $20301 m0 *1 224.01,123.2
X$20301 219 4532 320 5445 BUF_X8
* cell instance $20302 m0 *1 226.48,123.2
X$20302 5980 4530 6086 219 320 6105 MUX2_X1
* cell instance $20307 r0 *1 220.4,123.2
X$20307 219 14603 6199 6214 6197 320 DFF_X1
* cell instance $20310 r0 *1 225.91,123.2
X$20310 5647 6101 6086 219 320 5981 MUX2_X1
* cell instance $20311 r0 *1 227.24,123.2
X$20311 6201 4531 6200 219 320 6213 MUX2_X1
* cell instance $20313 m0 *1 228.19,123.2
X$20313 4322 6213 219 320 6104 OR2_X1
* cell instance $20315 r0 *1 228.57,123.2
X$20315 5647 6087 6201 219 320 6315 MUX2_X1
* cell instance $20318 r0 *1 230.47,123.2
X$20318 219 14196 6202 6211 6310 320 DFF_X1
* cell instance $20322 m0 *1 233.7,123.2
X$20322 6205 219 320 6309 BUF_X1
* cell instance $20323 m0 *1 232.37,123.2
X$20323 5760 6101 6099 219 320 5992 MUX2_X1
* cell instance $20325 m0 *1 234.46,123.2
X$20325 6202 3880 6099 219 320 6097 MUX2_X1
* cell instance $20327 m0 *1 236.55,123.2
X$20327 6210 219 320 6093 BUF_X1
* cell instance $20328 m0 *1 237.12,123.2
X$20328 6206 219 320 6195 BUF_X1
* cell instance $20330 m0 *1 237.88,123.2
X$20330 5760 6087 6095 219 320 6209 MUX2_X1
* cell instance $20331 m0 *1 239.21,123.2
X$20331 6094 219 320 6088 BUF_X1
* cell instance $20335 r0 *1 233.7,123.2
X$20335 5760 5995 6202 219 320 6211 MUX2_X1
* cell instance $20336 r0 *1 235.03,123.2
X$20336 6314 4532 6097 320 219 5398 OAI21_X4
* cell instance $20338 r0 *1 237.88,123.2
X$20338 5760 6311 6204 219 320 6203 MUX2_X1
* cell instance $20339 r0 *1 239.21,123.2
X$20339 6095 4531 6204 219 320 6406 MUX2_X1
* cell instance $20411 r0 *1 149.34,229.6
X$20411 219 12311 12067 12273 12313 320 DFF_X2
* cell instance $20413 m0 *1 150.86,229.6
X$20413 12275 7820 219 320 12311 NOR2_X1
* cell instance $20416 m0 *1 153.9,229.6
X$20416 12222 12168 12313 219 320 12315 MUX2_X1
* cell instance $20417 m0 *1 155.23,229.6
X$20417 12228 12259 320 219 12257 XNOR2_X1
* cell instance $20418 m0 *1 156.37,229.6
X$20418 12224 12225 12226 12127 320 219 12318 OAI22_X2
* cell instance $20419 m0 *1 158.08,229.6
X$20419 12227 12278 219 320 12226 NAND2_X1
* cell instance $20421 m0 *1 158.84,229.6
X$20421 12227 12278 12228 320 219 12209 OAI21_X2
* cell instance $20422 m0 *1 160.17,229.6
X$20422 12279 12282 12280 12275 219 320 12075 NAND4_X1
* cell instance $20423 m0 *1 161.12,229.6
X$20423 12168 12266 12261 219 320 12282 OR3_X1
* cell instance $20425 r0 *1 152.95,229.6
X$20425 12183 12273 12554 320 219 12259 HA_X1
* cell instance $20426 r0 *1 154.85,229.6
X$20426 12273 219 320 12316 INV_X1
* cell instance $20427 r0 *1 155.23,229.6
X$20427 12315 12209 12326 12318 12316 12275 320 219 AOI221_X2
* cell instance $20428 r0 *1 157.32,229.6
X$20428 12228 12356 219 320 12276 XOR2_X1
* cell instance $20429 r0 *1 158.46,229.6
X$20429 12168 12227 12276 219 320 12281 MUX2_X1
* cell instance $20430 r0 *1 159.79,229.6
X$20430 10496 12277 320 219 12279 AND2_X1
* cell instance $20432 r0 *1 160.74,229.6
X$20432 12281 12278 219 320 12280 NAND2_X1
* cell instance $20434 m0 *1 162.64,229.6
X$20434 219 12320 12185 12189 12230 320 DFF_X2
* cell instance $20436 m0 *1 166.25,229.6
X$20436 12187 12283 12230 219 320 12270 MUX2_X1
* cell instance $20437 m0 *1 167.58,229.6
X$20437 12272 12232 12231 219 12321 320 AOI21_X1
* cell instance $20438 m0 *1 168.34,229.6
X$20438 12186 12131 12175 320 219 12285 HA_X1
* cell instance $20439 m0 *1 170.24,229.6
X$20439 12191 12132 12188 12221 219 320 12287 NAND4_X1
* cell instance $20440 m0 *1 171.19,229.6
X$20440 12131 12217 12188 12134 219 320 12267 AOI22_X1
* cell instance $20442 m0 *1 172.33,229.6
X$20442 12283 12191 12324 219 320 12323 MUX2_X1
* cell instance $20443 m0 *1 173.66,229.6
X$20443 12323 12216 219 320 12290 NAND2_X1
* cell instance $20446 m0 *1 175.18,229.6
X$20446 12235 219 320 12132 BUF_X2
* cell instance $20450 m0 *1 178.41,229.6
X$20450 9383 219 320 12078 CLKBUF_X3
* cell instance $20451 m0 *1 179.36,229.6
X$20451 12078 219 320 CLKBUF_X1
* cell instance $20458 r0 *1 167.2,229.6
X$20458 12322 12283 12186 219 12231 320 AOI21_X1
* cell instance $20459 r0 *1 167.96,229.6
X$20459 12186 12284 12174 320 219 12286 HA_X1
* cell instance $20460 r0 *1 169.86,229.6
X$20460 12285 12286 12283 219 320 12322 NOR3_X1
* cell instance $20461 r0 *1 170.62,229.6
X$20461 12133 12130 12287 320 12269 219 OAI21_X1
* cell instance $20462 r0 *1 171.38,229.6
X$20462 12232 219 320 12288 INV_X1
* cell instance $20463 r0 *1 171.76,229.6
X$20463 12283 12288 12267 219 320 12289 OR3_X1
* cell instance $20464 r0 *1 172.71,229.6
X$20464 219 12235 12216 12364 12078 320 DFF_X1
* cell instance $20470 r0 *1 178.22,229.6
X$20470 12292 10064 219 320 12363 NOR2_X1
* cell instance $20472 r0 *1 178.98,229.6
X$20472 12297 10064 219 320 12291 NOR2_X1
* cell instance $20474 r0 *1 180.31,229.6
X$20474 12293 12236 12294 219 320 12365 MUX2_X1
* cell instance $20475 m0 *1 181.26,229.6
X$20475 12317 12243 12295 219 12292 320 AOI21_X1
* cell instance $20477 m0 *1 182.02,229.6
X$20477 12314 12236 12237 219 12295 320 AOI21_X1
* cell instance $20478 m0 *1 182.78,229.6
X$20478 12238 219 320 12319 INV_X1
* cell instance $20479 m0 *1 183.16,229.6
X$20479 12256 12312 12210 12241 320 219 12317 OAI22_X1
* cell instance $20480 m0 *1 184.11,229.6
X$20480 12239 12299 219 320 12312 NAND2_X1
* cell instance $20482 m0 *1 184.87,229.6
X$20482 12239 12244 219 320 12241 NAND2_X1
* cell instance $20483 m0 *1 185.44,229.6
X$20483 10496 12310 320 219 12245 AND2_X1
* cell instance $20484 m0 *1 186.2,229.6
X$20484 12236 12309 12308 219 320 12300 OR3_X1
* cell instance $20485 m0 *1 187.15,229.6
X$20485 12245 12300 12195 12297 219 320 12136 NAND4_X1
* cell instance $20486 m0 *1 188.1,229.6
X$20486 12245 12300 12195 219 320 12307 NAND3_X1
* cell instance $20488 m0 *1 191.9,229.6
X$20488 219 12305 12302 12144 12304 320 DFF_X2
* cell instance $20492 r0 *1 182.59,229.6
X$20492 12296 12319 12338 320 12293 219 OAI21_X1
* cell instance $20494 r0 *1 183.54,229.6
X$20494 12238 12312 12241 12193 320 219 12298 OAI22_X2
* cell instance $20495 r0 *1 185.25,229.6
X$20495 12239 12244 12299 320 219 12243 OAI21_X2
* cell instance $20496 r0 *1 186.58,229.6
X$20496 219 12306 12244 12307 12081 320 DFF_X1
* cell instance $20497 r0 *1 189.81,229.6
X$20497 12306 219 320 12299 BUF_X2
* cell instance $20499 r0 *1 191.33,229.6
X$20499 10642 219 320 12344 CLKBUF_X2
* cell instance $20502 m0 *1 197.79,229.6
X$20502 12144 12246 12198 320 219 12303 HA_X1
* cell instance $20503 m0 *1 195.89,229.6
X$20503 12304 12196 12530 320 219 12249 HA_X1
* cell instance $20504 m0 *1 199.69,229.6
X$20504 12303 219 320 12151 BUF_X2
* cell instance $20505 m0 *1 200.45,229.6
X$20505 12091 12248 12090 12250 219 320 12092 AOI22_X1
* cell instance $20506 m0 *1 201.4,229.6
X$20506 12160 12249 320 219 12250 XNOR2_X1
* cell instance $20517 r0 *1 197.41,229.6
X$20517 12246 219 320 12206 INV_X1
* cell instance $20518 r0 *1 197.79,229.6
X$20518 9818 219 320 12302 CLKBUF_X3
* cell instance $20519 r0 *1 198.74,229.6
X$20519 12302 219 320 CLKBUF_X1
* cell instance $20522 r0 *1 201.02,229.6
X$20522 219 12348 12302 12508 8709 320 DFF_X2
* cell instance $20599 m0 *1 148.01,226.8
X$20599 12067 219 320 CLKBUF_X1
* cell instance $20600 m0 *1 147.06,226.8
X$20600 9425 219 320 12067 CLKBUF_X3
* cell instance $20602 m0 *1 150.1,226.8
X$20602 219 12164 12067 12183 12179 320 DFF_X2
* cell instance $20605 m0 *1 156.94,226.8
X$20605 12181 12209 12213 219 12166 320 AOI21_X1
* cell instance $20607 m0 *1 157.89,226.8
X$20607 12183 12012 12262 320 219 12215 HA_X1
* cell instance $20608 m0 *1 159.79,226.8
X$20608 12184 12168 12183 219 12213 320 AOI21_X1
* cell instance $20612 r0 *1 152.57,226.8
X$20612 12179 12313 12547 320 219 12255 HA_X1
* cell instance $20613 r0 *1 154.47,226.8
X$20613 12180 12274 12223 320 12222 219 OAI21_X1
* cell instance $20614 r0 *1 155.23,226.8
X$20614 12180 12127 219 320 12223 NAND2_X1
* cell instance $20615 r0 *1 155.8,226.8
X$20615 12127 12257 12224 12327 219 320 12261 AOI22_X1
* cell instance $20616 r0 *1 156.75,226.8
X$20616 12262 12225 12182 12226 320 219 12181 OAI22_X1
* cell instance $20617 r0 *1 157.7,226.8
X$20617 12183 12127 12182 320 219 12265 HA_X1
* cell instance $20618 r0 *1 159.6,226.8
X$20618 12209 219 320 12266 INV_X1
* cell instance $20619 r0 *1 159.98,226.8
X$20619 12265 12215 12168 219 320 12184 NOR3_X1
* cell instance $20620 r0 *1 160.74,226.8
X$20620 12012 219 320 12224 CLKBUF_X2
* cell instance $20622 m0 *1 162.64,226.8
X$20622 219 12229 12185 12186 12218 320 DFF_X2
* cell instance $20624 m0 *1 166.25,226.8
X$20624 12218 12230 12532 320 219 12135 HA_X1
* cell instance $20625 m0 *1 168.15,226.8
X$20625 12188 219 320 12219 INV_X1
* cell instance $20626 m0 *1 168.53,226.8
X$20626 12186 12189 12221 320 219 12220 HA_X1
* cell instance $20627 m0 *1 170.43,226.8
X$20627 12220 219 320 12191 BUF_X2
* cell instance $20628 m0 *1 171.19,226.8
X$20628 12132 12190 320 219 12217 XNOR2_X1
* cell instance $20629 m0 *1 172.33,226.8
X$20629 12191 12135 12132 12188 219 320 12233 NAND4_X1
* cell instance $20632 r0 *1 163.4,226.8
X$20632 12264 10002 219 320 12320 NOR2_X1
* cell instance $20633 r0 *1 163.97,226.8
X$20633 12321 10002 219 320 12229 NOR2_X1
* cell instance $20636 r0 *1 166.44,226.8
X$20636 12186 12189 12549 320 219 12190 HA_X1
* cell instance $20637 r0 *1 168.34,226.8
X$20637 12189 219 320 12271 INV_X1
* cell instance $20638 r0 *1 168.72,226.8
X$20638 12270 12232 12269 12268 12271 12264 320 219 AOI221_X2
* cell instance $20639 r0 *1 170.81,226.8
X$20639 12188 12176 12133 12131 320 219 12268 OAI22_X2
* cell instance $20640 r0 *1 172.52,226.8
X$20640 10496 12233 320 219 12234 AND2_X1
* cell instance $20641 r0 *1 173.28,226.8
X$20641 12190 12131 219 320 12263 NAND2_X1
* cell instance $20642 m0 *1 173.85,226.8
X$20642 12191 12216 219 320 12133 NAND2_X1
* cell instance $20647 m0 *1 179.74,226.8
X$20647 12079 12214 12518 320 219 12254 HA_X1
* cell instance $20648 m0 *1 181.64,226.8
X$20648 12138 12212 219 320 12211 NOR2_X1
* cell instance $20650 m0 *1 182.4,226.8
X$20650 12237 12193 12210 320 219 12253 HA_X1
* cell instance $20653 m0 *1 188.86,226.8
X$20653 219 13223 12208 12177 12081 320 DFF_X1
* cell instance $20654 m0 *1 192.09,226.8
X$20654 12208 219 320 12085 INV_X1
* cell instance $20656 m0 *1 192.66,226.8
X$20656 12142 9745 219 320 12305 NOR2_X1
* cell instance $20658 m0 *1 193.42,226.8
X$20658 12205 12143 12196 219 320 12207 MUX2_X1
* cell instance $20660 m0 *1 194.94,226.8
X$20660 12207 12146 12203 12204 12206 12093 320 219 AOI221_X2
* cell instance $20662 m0 *1 197.22,226.8
X$20662 12150 12197 12149 320 12205 219 OAI21_X1
* cell instance $20663 m0 *1 197.98,226.8
X$20663 12148 12149 12202 320 12203 219 OAI21_X1
* cell instance $20664 m0 *1 198.74,226.8
X$20664 12198 219 320 12150 INV_X1
* cell instance $20665 m0 *1 199.12,226.8
X$20665 12151 12160 12090 12198 219 320 12202 NAND4_X1
* cell instance $20666 m0 *1 200.07,226.8
X$20666 12160 12251 219 320 12199 XOR2_X1
* cell instance $20668 r0 *1 173.85,226.8
X$20668 12132 12263 219 320 12324 XOR2_X1
* cell instance $20669 r0 *1 174.99,226.8
X$20669 12191 12216 12132 320 219 12232 OAI21_X2
* cell instance $20674 r0 *1 176.7,226.8
X$20674 219 14656 12258 12260 12078 320 DFF_X1
* cell instance $20675 r0 *1 179.93,226.8
X$20675 12136 12292 219 320 12260 NOR2_X1
* cell instance $20676 r0 *1 180.5,226.8
X$20676 12258 219 320 12212 INV_X1
* cell instance $20677 r0 *1 180.88,226.8
X$20677 12137 219 320 12236 BUF_X1
* cell instance $20678 r0 *1 181.45,226.8
X$20678 12254 219 320 12238 CLKBUF_X2
* cell instance $20679 r0 *1 182.21,226.8
X$20679 12237 12254 12256 320 219 12240 HA_X1
* cell instance $20680 r0 *1 184.11,226.8
X$20680 12253 12240 12236 219 320 12314 NOR3_X1
* cell instance $20681 r0 *1 184.87,226.8
X$20681 12236 12239 12242 219 320 12194 MUX2_X1
* cell instance $20682 r0 *1 186.2,226.8
X$20682 12243 219 320 12309 INV_X1
* cell instance $20683 r0 *1 186.58,226.8
X$20683 12194 12244 219 320 12195 NAND2_X1
* cell instance $20688 r0 *1 192.85,226.8
X$20688 219 12252 12302 12246 12196 320 DFF_X2
* cell instance $20689 r0 *1 196.46,226.8
X$20689 12093 9745 219 320 12252 NOR2_X1
* cell instance $20691 r0 *1 197.22,226.8
X$20691 12090 219 320 12197 INV_X1
* cell instance $20692 r0 *1 197.6,226.8
X$20692 12144 12246 12551 320 219 12247 HA_X1
* cell instance $20693 r0 *1 199.5,226.8
X$20693 12160 12247 320 219 12248 XNOR2_X1
* cell instance $20694 r0 *1 200.64,226.8
X$20694 12247 12091 219 320 12251 NAND2_X1
* cell instance $20721 m0 *1 132.43,33.6
X$20721 895 1011 897 219 320 896 MUX2_X1
* cell instance $20722 m0 *1 133.76,33.6
X$20722 219 12826 898 942 339 320 DFF_X1
* cell instance $20750 r0 *1 129.01,33.6
X$20750 219 14260 983 1013 339 320 DFF_X1
* cell instance $20751 r0 *1 132.24,33.6
X$20751 981 1012 983 219 320 1013 MUX2_X1
* cell instance $20754 r0 *1 134.52,33.6
X$20754 895 1012 898 219 320 942 MUX2_X1
* cell instance $20756 r0 *1 136.04,33.6
X$20756 895 1035 899 219 320 944 MUX2_X1
* cell instance $20758 m0 *1 137.56,33.6
X$20758 219 13595 899 944 847 320 DFF_X1
* cell instance $20760 m0 *1 140.79,33.6
X$20760 947 541 219 320 1017 NAND2_X1
* cell instance $20761 m0 *1 141.36,33.6
X$20761 1017 499 951 320 219 950 OAI21_X4
* cell instance $20762 m0 *1 143.83,33.6
X$20762 399 900 901 219 320 956 MUX2_X1
* cell instance $20763 m0 *1 145.16,33.6
X$20763 219 12691 901 956 847 320 DFF_X1
* cell instance $20764 m0 *1 148.39,33.6
X$20764 901 621 852 219 320 959 MUX2_X1
* cell instance $20766 r0 *1 137.56,33.6
X$20766 895 1041 1014 219 320 1015 MUX2_X1
* cell instance $20768 r0 *1 139.08,33.6
X$20768 219 14279 1014 1015 847 320 DFF_X1
* cell instance $20771 r0 *1 142.88,33.6
X$20771 293 219 320 847 CLKBUF_X3
* cell instance $20772 r0 *1 143.83,33.6
X$20772 847 219 320 CLKBUF_X1
* cell instance $20775 r0 *1 146.3,33.6
X$20775 577 320 902 219 BUF_X4
* cell instance $20779 m0 *1 150.29,33.6
X$20779 959 219 320 1021 INV_X1
* cell instance $20783 r0 *1 150.1,33.6
X$20783 399 903 986 219 320 985 MUX2_X1
* cell instance $20785 r0 *1 151.81,33.6
X$20785 1021 627 219 320 1022 NAND2_X1
* cell instance $20787 m0 *1 152.76,33.6
X$20787 399 902 904 219 320 962 MUX2_X1
* cell instance $20789 m0 *1 154.09,33.6
X$20789 219 13452 904 962 907 320 DFF_X1
* cell instance $20791 m0 *1 158.08,33.6
X$20791 219 13371 987 908 907 320 DFF_X1
* cell instance $20792 m0 *1 161.31,33.6
X$20792 328 851 1028 219 320 989 MUX2_X1
* cell instance $20794 m0 *1 163.4,33.6
X$20794 358 801 974 219 320 990 MUX2_X1
* cell instance $20800 r0 *1 153.33,33.6
X$20800 986 670 904 219 320 1024 MUX2_X1
* cell instance $20804 r0 *1 157.13,33.6
X$20804 907 219 320 14760 INV_X1
* cell instance $20805 r0 *1 157.51,33.6
X$20805 328 900 987 219 320 908 MUX2_X1
* cell instance $20806 r0 *1 158.84,33.6
X$20806 219 14364 988 1026 907 320 DFF_X1
* cell instance $20807 r0 *1 162.07,33.6
X$20807 219 14013 1028 989 907 320 DFF_X1
* cell instance $20809 m0 *1 170.62,33.6
X$20809 910 911 913 219 320 992 MUX2_X1
* cell instance $20815 r0 *1 171.95,33.6
X$20815 992 219 320 1032 INV_X1
* cell instance $20817 m0 *1 173.28,33.6
X$20817 219 920 670 320 BUF_X16
* cell instance $20820 m0 *1 178.22,33.6
X$20820 453 680 914 219 320 977 MUX2_X1
* cell instance $20822 m0 *1 179.74,33.6
X$20822 1033 915 573 320 219 3734 MUX2_X2
* cell instance $20823 m0 *1 181.45,33.6
X$20823 219 12680 994 978 863 320 DFF_X1
* cell instance $20824 m0 *1 184.68,33.6
X$20824 219 918 916 320 BUF_X16
* cell instance $20826 m0 *1 189.62,33.6
X$20826 219 13126 921 971 863 320 DFF_X1
* cell instance $20827 m0 *1 192.85,33.6
X$20827 219 969 686 320 BUF_X16
* cell instance $20829 m0 *1 198.36,33.6
X$20829 965 219 320 997 INV_X1
* cell instance $20830 m0 *1 198.74,33.6
X$20830 966 884 995 320 219 1019 MUX2_X2
* cell instance $20831 m0 *1 200.45,33.6
X$20831 924 867 869 219 320 1018 MUX2_X1
* cell instance $20834 m0 *1 206.34,33.6
X$20834 219 12999 1016 953 926 320 DFF_X1
* cell instance $20835 m0 *1 209.57,33.6
X$20835 404 927 928 219 320 949 MUX2_X1
* cell instance $20836 m0 *1 210.9,33.6
X$20836 219 12608 928 949 930 320 DFF_X1
* cell instance $20838 m0 *1 214.89,33.6
X$20838 530 929 931 219 320 943 MUX2_X1
* cell instance $20839 m0 *1 216.22,33.6
X$20839 219 13015 931 943 930 320 DFF_X1
* cell instance $20840 m0 *1 219.45,33.6
X$20840 941 932 931 219 320 1000 MUX2_X1
* cell instance $20841 m0 *1 220.78,33.6
X$20841 933 927 934 219 320 940 MUX2_X1
* cell instance $20843 m0 *1 222.3,33.6
X$20843 933 929 935 219 320 939 MUX2_X1
* cell instance $20844 m0 *1 223.63,33.6
X$20844 934 932 935 219 320 1009 MUX2_X1
* cell instance $20846 m0 *1 226.48,33.6
X$20846 875 219 320 14705 INV_X2
* cell instance $20847 m0 *1 227.05,33.6
X$20847 380 219 320 875 CLKBUF_X3
* cell instance $20849 m0 *1 228.19,33.6
X$20849 1003 929 937 219 320 936 MUX2_X1
* cell instance $20852 r0 *1 175.75,33.6
X$20852 859 916 976 219 320 1034 MUX2_X1
* cell instance $20856 r0 *1 179.55,33.6
X$20856 914 916 861 219 320 1033 MUX2_X1
* cell instance $20860 r0 *1 182.21,33.6
X$20860 435 808 1029 219 320 1031 MUX2_X1
* cell instance $20861 r0 *1 183.54,33.6
X$20861 219 13679 1029 1031 863 320 DFF_X1
* cell instance $20862 r0 *1 186.77,33.6
X$20862 545 219 320 863 CLKBUF_X3
* cell instance $20863 r0 *1 187.72,33.6
X$20863 921 920 864 219 320 1027 MUX2_X1
* cell instance $20864 r0 *1 189.05,33.6
X$20864 219 918 867 320 BUF_X16
* cell instance $20866 r0 *1 193.99,33.6
X$20866 219 918 920 320 BUF_X32
* cell instance $20870 r0 *1 207.48,33.6
X$20870 928 932 1016 219 320 1288 MUX2_X1
* cell instance $20871 r0 *1 208.81,33.6
X$20871 404 929 1016 219 320 953 MUX2_X1
* cell instance $20873 r0 *1 216.22,33.6
X$20873 380 219 320 930 CLKBUF_X3
* cell instance $20874 r0 *1 217.17,33.6
X$20874 999 219 320 380 CLKBUF_X3
* cell instance $20879 r0 *1 228.95,33.6
X$20879 1003 927 1005 219 320 1006 MUX2_X1
* cell instance $20880 m0 *1 230.09,33.6
X$20880 1005 932 937 219 320 1007 MUX2_X1
* cell instance $20886 r0 *1 230.28,33.6
X$20886 219 14131 1005 1006 875 320 DFF_X1
* cell instance $20969 m0 *1 29.07,44.8
X$20969 1299 1261 1223 219 320 1157 MUX2_X1
* cell instance $20970 m0 *1 30.4,44.8
X$20970 1224 1261 1225 219 320 1262 MUX2_X1
* cell instance $20971 m0 *1 31.73,44.8
X$20971 219 12668 1225 1262 1306 320 DFF_X1
* cell instance $20999 r0 *1 21.47,44.8
X$20999 219 14250 1372 1418 1158 320 DFF_X1
* cell instance $21002 r0 *1 26.41,44.8
X$21002 219 14253 1420 1301 1302 320 DFF_X1
* cell instance $21005 r0 *1 35.91,44.8
X$21005 219 14579 1379 1347 1306 320 DFF_X1
* cell instance $21009 r0 *1 46.93,44.8
X$21009 219 14572 1428 1309 1310 320 DFF_X1
* cell instance $21013 r0 *1 51.49,44.8
X$21013 219 14530 1311 1351 1310 320 DFF_X1
* cell instance $21038 m0 *1 130.34,44.8
X$21038 219 12712 1226 1266 982 320 DFF_X1
* cell instance $21039 m0 *1 135.09,44.8
X$21039 219 13623 1315 1269 1088 320 DFF_X1
* cell instance $21041 m0 *1 138.51,44.8
X$21041 1271 219 320 1200 INV_X1
* cell instance $21043 m0 *1 139.08,44.8
X$21043 219 13013 1229 1270 1088 320 DFF_X1
* cell instance $21047 r0 *1 132.81,44.8
X$21047 471 1011 1313 219 320 1358 MUX2_X1
* cell instance $21048 r0 *1 134.14,44.8
X$21048 219 14404 1313 1358 1088 320 DFF_X1
* cell instance $21049 r0 *1 137.37,44.8
X$21049 471 1012 1315 219 320 1269 MUX2_X1
* cell instance $21054 r0 *1 143.07,44.8
X$21054 1230 1274 1165 219 320 1316 MUX2_X1
* cell instance $21056 m0 *1 144.21,44.8
X$21056 1229 969 1231 219 320 1230 MUX2_X1
* cell instance $21059 m0 *1 148.01,44.8
X$21059 1167 1274 1166 219 320 1278 MUX2_X1
* cell instance $21062 m0 *1 150.29,44.8
X$21062 1091 219 320 CLKBUF_X1
* cell instance $21067 r0 *1 145.35,44.8
X$21067 1165 219 320 1362 INV_X1
* cell instance $21070 r0 *1 146.3,44.8
X$21070 1362 501 219 320 1364 NAND2_X1
* cell instance $21071 r0 *1 146.87,44.8
X$21071 1364 714 1230 320 219 1365 OAI21_X4
* cell instance $21074 r0 *1 149.91,44.8
X$21074 219 14582 1232 1280 1091 320 DFF_X1
* cell instance $21076 m0 *1 152,44.8
X$21076 489 900 1232 219 320 1280 MUX2_X1
* cell instance $21079 m0 *1 157.32,44.8
X$21079 1282 219 320 826 CLKBUF_X3
* cell instance $21080 m0 *1 158.27,44.8
X$21080 364 219 320 1233 CLKBUF_X3
* cell instance $21083 m0 *1 162.45,44.8
X$21083 358 802 1234 219 320 1285 MUX2_X1
* cell instance $21084 m0 *1 163.78,44.8
X$21084 219 13320 1234 1285 991 320 DFF_X1
* cell instance $21085 m0 *1 167.01,44.8
X$21085 1234 1084 1235 219 320 1236 MUX2_X1
* cell instance $21086 m0 *1 168.34,44.8
X$21086 219 13063 1237 1289 991 320 DFF_X1
* cell instance $21087 m0 *1 171.57,44.8
X$21087 291 802 1237 219 320 1289 MUX2_X1
* cell instance $21090 r0 *1 153.14,44.8
X$21090 1232 969 1318 219 320 1317 MUX2_X1
* cell instance $21092 r0 *1 155.99,44.8
X$21092 413 903 1320 219 320 1319 MUX2_X1
* cell instance $21093 r0 *1 157.32,44.8
X$21093 1233 219 320 14719 INV_X2
* cell instance $21094 r0 *1 157.89,44.8
X$21094 413 900 1321 219 320 1369 MUX2_X1
* cell instance $21095 r0 *1 159.22,44.8
X$21095 219 13906 1321 1369 1233 320 DFF_X1
* cell instance $21099 r0 *1 167.77,44.8
X$21099 219 13951 1322 1367 991 320 DFF_X1
* cell instance $21101 r0 *1 171.38,44.8
X$21101 1237 1084 1322 219 320 1464 MUX2_X1
* cell instance $21103 r0 *1 172.9,44.8
X$21103 219 13911 1324 1366 1323 320 DFF_X1
* cell instance $21105 m0 *1 174.04,44.8
X$21105 344 803 1238 219 320 1293 MUX2_X1
* cell instance $21106 m0 *1 175.56,44.8
X$21106 219 13397 1238 1293 1085 320 DFF_X1
* cell instance $21113 r0 *1 176.51,44.8
X$21113 1324 1084 1238 219 320 1462 MUX2_X1
* cell instance $21116 r0 *1 178.79,44.8
X$21116 219 13910 1326 1361 1085 320 DFF_X1
* cell instance $21118 m0 *1 179.93,44.8
X$21118 219 13392 1175 1239 1052 320 DFF_X1
* cell instance $21120 m0 *1 184.11,44.8
X$21120 219 12741 1177 1240 1052 320 DFF_X1
* cell instance $21123 m0 *1 188.29,44.8
X$21123 219 13090 1359 1297 1328 320 DFF_X1
* cell instance $21125 m0 *1 192.28,44.8
X$21125 329 1241 1242 219 320 1296 MUX2_X1
* cell instance $21128 m0 *1 195.32,44.8
X$21128 416 1241 1294 219 320 1243 MUX2_X1
* cell instance $21131 r0 *1 182.02,44.8
X$21131 327 802 1326 219 320 1361 MUX2_X1
* cell instance $21135 r0 *1 190,44.8
X$21135 329 1330 1359 219 320 1297 MUX2_X1
* cell instance $21138 r0 *1 193.23,44.8
X$21138 416 1330 1332 219 320 1455 MUX2_X1
* cell instance $21140 r0 *1 194.94,44.8
X$21140 219 14154 1294 1243 1053 320 DFF_X1
* cell instance $21174 r0 *1 9.31,39.2
X$21174 664 219 320 1224 CLKBUF_X2
* cell instance $21207 r0 *1 133.19,39.2
X$21207 472 1035 1133 219 320 1132 MUX2_X1
* cell instance $21208 r0 *1 134.52,39.2
X$21208 219 14274 1133 1132 982 320 DFF_X1
* cell instance $21210 m0 *1 135.66,39.2
X$21210 1042 1043 522 320 219 1134 MUX2_X2
* cell instance $21215 m0 *1 140.03,39.2
X$21215 219 12664 1089 1135 1088 320 DFF_X1
* cell instance $21217 m0 *1 145.54,39.2
X$21217 346 851 1139 219 320 1138 MUX2_X1
* cell instance $21219 m0 *1 147.63,39.2
X$21219 1044 1040 1139 219 320 1166 MUX2_X1
* cell instance $21220 m0 *1 148.96,39.2
X$21220 346 903 1092 219 320 1090 MUX2_X1
* cell instance $21224 r0 *1 142.69,39.2
X$21224 1089 1040 984 219 320 1165 MUX2_X1
* cell instance $21226 r0 *1 144.21,39.2
X$21226 219 14190 1139 1138 1088 320 DFF_X1
* cell instance $21227 r0 *1 147.44,39.2
X$21227 627 320 541 219 BUF_X4
* cell instance $21228 r0 *1 148.77,39.2
X$21228 219 14177 1092 1090 1091 320 DFF_X1
* cell instance $21229 m0 *1 150.86,39.2
X$21229 346 902 1168 219 320 1143 MUX2_X1
* cell instance $21231 m0 *1 152.19,39.2
X$21231 219 12764 1168 1143 1091 320 DFF_X1
* cell instance $21232 m0 *1 155.42,39.2
X$21232 1145 320 624 219 BUF_X4
* cell instance $21234 m0 *1 156.94,39.2
X$21234 328 903 1093 219 320 1147 MUX2_X1
* cell instance $21235 m0 *1 158.27,39.2
X$21235 219 13316 1093 1147 907 320 DFF_X1
* cell instance $21238 m0 *1 162.45,39.2
X$21238 219 13248 1047 1086 991 320 DFF_X1
* cell instance $21239 m0 *1 165.68,39.2
X$21239 1153 995 219 320 1094 NAND2_X1
* cell instance $21240 m0 *1 166.25,39.2
X$21240 1149 573 219 320 1214 NAND2_X1
* cell instance $21241 m0 *1 166.82,39.2
X$21241 1048 219 320 1153 INV_X1
* cell instance $21242 m0 *1 167.2,39.2
X$21242 1095 219 320 1096 INV_X1
* cell instance $21244 m0 *1 169.1,39.2
X$21244 291 801 1097 219 320 1152 MUX2_X1
* cell instance $21246 m0 *1 170.62,39.2
X$21246 291 808 1098 219 320 1155 MUX2_X1
* cell instance $21250 r0 *1 155.8,39.2
X$21250 219 969 918 320 BUF_X32
* cell instance $21251 r0 *1 165.11,39.2
X$21251 219 1084 320 918 BUF_X8
* cell instance $21253 r0 *1 167.77,39.2
X$21253 1096 995 219 320 1171 NAND2_X1
* cell instance $21254 r0 *1 168.34,39.2
X$21254 991 219 320 14782 INV_X1
* cell instance $21257 r0 *1 169.86,39.2
X$21257 219 13697 1098 1155 1085 320 DFF_X1
* cell instance $21259 m0 *1 172.33,39.2
X$21259 1098 911 1097 219 320 1156 MUX2_X1
* cell instance $21260 r0 *1 173.09,39.2
X$21260 1156 219 320 1172 INV_X2
* cell instance $21262 m0 *1 174.23,39.2
X$21262 219 13395 1101 1100 1085 320 DFF_X1
* cell instance $21264 m0 *1 177.46,39.2
X$21264 219 13394 1103 1102 1085 320 DFF_X1
* cell instance $21265 m0 *1 180.69,39.2
X$21265 1103 867 1050 219 320 1174 MUX2_X1
* cell instance $21267 m0 *1 182.21,39.2
X$21267 219 12743 1105 1176 1052 320 DFF_X1
* cell instance $21268 m0 *1 185.44,39.2
X$21268 545 219 320 1052 CLKBUF_X3
* cell instance $21271 r0 *1 174.42,39.2
X$21271 344 808 1101 219 320 1100 MUX2_X1
* cell instance $21276 r0 *1 175.94,39.2
X$21276 1101 911 1049 219 320 1220 MUX2_X1
* cell instance $21279 r0 *1 178.22,39.2
X$21279 327 808 1103 219 320 1102 MUX2_X1
* cell instance $21281 r0 *1 179.74,39.2
X$21281 435 802 1104 219 320 1222 MUX2_X1
* cell instance $21282 r0 *1 181.07,39.2
X$21282 219 13744 1104 1222 1052 320 DFF_X1
* cell instance $21283 r0 *1 184.3,39.2
X$21283 1104 1084 1105 219 320 1221 MUX2_X1
* cell instance $21284 r0 *1 185.63,39.2
X$21284 1221 1051 573 320 219 1154 MUX2_X2
* cell instance $21285 r0 *1 187.34,39.2
X$21285 1052 219 320 CLKBUF_X1
* cell instance $21290 r0 *1 188.29,39.2
X$21290 1218 573 219 320 1178 NAND2_X1
* cell instance $21291 r0 *1 188.86,39.2
X$21291 1217 219 320 1218 INV_X1
* cell instance $21292 r0 *1 189.24,39.2
X$21292 1107 686 1106 219 320 1217 MUX2_X1
* cell instance $21296 m0 *1 192.28,39.2
X$21296 219 918 911 320 BUF_X32
* cell instance $21298 r0 *1 192.85,39.2
X$21298 416 1182 1054 219 320 1108 MUX2_X1
* cell instance $21299 r0 *1 194.18,39.2
X$21299 416 1181 1146 219 320 1109 MUX2_X1
* cell instance $21300 r0 *1 195.51,39.2
X$21300 1146 1112 1054 219 320 1331 MUX2_X1
* cell instance $21303 r0 *1 200.26,39.2
X$21303 682 1182 1110 219 320 1076 MUX2_X1
* cell instance $21306 r0 *1 202.16,39.2
X$21306 1183 1112 1110 219 320 1184 MUX2_X1
* cell instance $21307 m0 *1 205.96,39.2
X$21307 404 1057 1055 219 320 1144 MUX2_X1
* cell instance $21308 m0 *1 202.73,39.2
X$21308 219 13002 1211 1111 926 320 DFF_X1
* cell instance $21310 m0 *1 208.05,39.2
X$21310 219 13014 1142 1141 1248 320 DFF_X1
* cell instance $21312 m0 *1 212.04,39.2
X$21312 1072 1113 1058 219 320 1115 MUX2_X1
* cell instance $21314 m0 *1 214.13,39.2
X$21314 219 13381 1116 1140 930 320 DFF_X1
* cell instance $21315 m0 *1 217.36,39.2
X$21315 1116 1069 1060 219 320 1207 MUX2_X1
* cell instance $21318 r0 *1 203.49,39.2
X$21318 404 1120 1211 219 320 1111 MUX2_X1
* cell instance $21321 r0 *1 205.96,39.2
X$21321 1211 1113 1055 219 320 1186 MUX2_X1
* cell instance $21325 r0 *1 209.95,39.2
X$21325 1142 1112 1114 219 320 1210 MUX2_X1
* cell instance $21326 r0 *1 211.28,39.2
X$21326 1056 929 1114 219 320 1208 MUX2_X1
* cell instance $21327 r0 *1 212.61,39.2
X$21327 219 14034 1114 1208 1188 320 DFF_X1
* cell instance $21329 r0 *1 217.36,39.2
X$21329 1205 1119 1207 320 219 1206 OAI21_X4
* cell instance $21331 m0 *1 220.78,39.2
X$21331 933 1057 1117 219 320 1137 MUX2_X1
* cell instance $21333 m0 *1 222.11,39.2
X$21333 1062 1113 1117 219 320 1118 MUX2_X1
* cell instance $21337 r0 *1 221.73,39.2
X$21337 1061 1119 1118 320 219 1203 OAI21_X4
* cell instance $21340 m0 *1 224.58,39.2
X$21340 933 1120 1062 219 320 1136 MUX2_X1
* cell instance $21341 m0 *1 227.43,39.2
X$21341 1003 1120 1064 219 320 1070 MUX2_X1
* cell instance $21343 m0 *1 228.95,39.2
X$21343 1063 1119 1121 320 219 1131 OAI21_X4
* cell instance $21345 m0 *1 231.61,39.2
X$21345 1122 1069 1128 219 320 1130 MUX2_X1
* cell instance $21347 m0 *1 233.13,39.2
X$21347 219 12748 1122 1123 1124 320 DFF_X1
* cell instance $21349 r0 *1 224.96,39.2
X$21349 380 219 320 1001 CLKBUF_X3
* cell instance $21352 r0 *1 230.47,39.2
X$21352 1066 1119 1130 320 219 1198 OAI21_X4
* cell instance $21356 r0 *1 232.94,39.2
X$21356 1125 1120 1122 219 320 1123 MUX2_X1
* cell instance $21357 r0 *1 234.27,39.2
X$21357 1125 1057 1128 219 320 1129 MUX2_X1
* cell instance $21360 r0 *1 236.55,39.2
X$21360 1125 927 1127 219 320 1126 MUX2_X1
* cell instance $21362 m0 *1 236.74,39.2
X$21362 219 12758 1127 1126 1124 320 DFF_X1
* cell instance $21364 r0 *1 237.88,39.2
X$21364 1127 932 1067 219 320 1068 MUX2_X1
* cell instance $21389 m0 *1 127.68,36.4
X$21389 981 1011 1037 219 320 1010 MUX2_X1
* cell instance $21390 m0 *1 129.01,36.4
X$21390 219 12710 1037 1010 982 320 DFF_X1
* cell instance $21391 m0 *1 132.24,36.4
X$21391 219 12828 1039 1038 982 320 DFF_X1
* cell instance $21394 m0 *1 137.75,36.4
X$21394 577 320 1041 219 BUF_X4
* cell instance $21395 m0 *1 139.08,36.4
X$21395 624 320 1035 219 BUF_X4
* cell instance $21397 m0 *1 144.78,36.4
X$21397 624 320 903 219 BUF_X4
* cell instance $21400 m0 *1 147.82,36.4
X$21400 512 320 900 219 BUF_X4
* cell instance $21403 m0 *1 150.1,36.4
X$21403 219 13265 986 985 1091 320 DFF_X1
* cell instance $21404 m0 *1 153.33,36.4
X$21404 1022 627 1024 320 219 1025 OAI21_X4
* cell instance $21407 m0 *1 158.08,36.4
X$21407 219 13533 1045 1080 907 320 DFF_X1
* cell instance $21408 m0 *1 161.31,36.4
X$21408 332 851 988 219 320 1026 MUX2_X1
* cell instance $21409 m0 *1 162.64,36.4
X$21409 987 918 1028 219 320 1082 MUX2_X1
* cell instance $21411 m0 *1 164.73,36.4
X$21411 219 13372 974 990 991 320 DFF_X1
* cell instance $21449 r0 *1 126.92,36.4
X$21449 981 1035 1036 219 320 1071 MUX2_X1
* cell instance $21450 r0 *1 128.25,36.4
X$21450 219 14256 1036 1071 982 320 DFF_X1
* cell instance $21451 r0 *1 131.48,36.4
X$21451 981 1041 1039 219 320 1038 MUX2_X1
* cell instance $21452 r0 *1 132.81,36.4
X$21452 1036 1040 1039 219 320 1042 MUX2_X1
* cell instance $21453 r0 *1 134.14,36.4
X$21453 1037 1040 983 219 320 1043 MUX2_X1
* cell instance $21458 r0 *1 140.98,36.4
X$21458 219 13650 984 1074 1088 320 DFF_X1
* cell instance $21459 r0 *1 144.21,36.4
X$21459 219 14165 1044 1075 847 320 DFF_X1
* cell instance $21460 r0 *1 147.44,36.4
X$21460 346 900 1044 219 320 1075 MUX2_X1
* cell instance $21465 r0 *1 153.9,36.4
X$21465 1078 320 577 219 BUF_X4
* cell instance $21468 r0 *1 158.46,36.4
X$21468 332 900 1045 219 320 1080 MUX2_X1
* cell instance $21470 r0 *1 159.98,36.4
X$21470 328 902 1046 219 320 1148 MUX2_X1
* cell instance $21473 r0 *1 161.88,36.4
X$21473 1082 219 320 1149 INV_X1
* cell instance $21474 r0 *1 162.26,36.4
X$21474 1093 1084 1046 219 320 1087 MUX2_X1
* cell instance $21475 r0 *1 163.59,36.4
X$21475 1045 911 988 219 320 1095 MUX2_X1
* cell instance $21476 r0 *1 164.92,36.4
X$21476 358 808 1047 219 320 1086 MUX2_X1
* cell instance $21477 r0 *1 166.25,36.4
X$21477 1047 686 974 219 320 1048 MUX2_X1
* cell instance $21478 r0 *1 167.58,36.4
X$21478 219 13957 1097 1152 1085 320 DFF_X1
* cell instance $21480 m0 *1 168.34,36.4
X$21480 826 219 320 364 CLKBUF_X3
* cell instance $21482 m0 *1 170.24,36.4
X$21482 219 993 320 573 BUF_X8
* cell instance $21483 m0 *1 172.71,36.4
X$21483 1032 993 219 320 1083 NAND2_X1
* cell instance $21484 m0 *1 173.28,36.4
X$21484 1083 993 1034 320 219 1023 OAI21_X4
* cell instance $21487 m0 *1 177.46,36.4
X$21487 624 320 802 219 BUF_X4
* cell instance $21492 r0 *1 174.23,36.4
X$21492 219 13741 1049 1099 1085 320 DFF_X1
* cell instance $21499 r0 *1 179.93,36.4
X$21499 327 801 1050 219 320 1081 MUX2_X1
* cell instance $21500 r0 *1 181.26,36.4
X$21500 219 13750 1050 1081 1052 320 DFF_X1
* cell instance $21502 m0 *1 185.44,36.4
X$21502 1029 916 994 219 320 1051 MUX2_X1
* cell instance $21506 r0 *1 186.2,36.4
X$21506 219 14417 1106 1151 1052 320 DFF_X1
* cell instance $21507 m0 *1 187.34,36.4
X$21507 863 219 320 CLKBUF_X1
* cell instance $21512 m0 *1 189.05,36.4
X$21512 996 1027 995 320 219 1079 MUX2_X2
* cell instance $21514 m0 *1 191.71,36.4
X$21514 999 219 320 545 CLKBUF_X3
* cell instance $21515 m0 *1 192.66,36.4
X$21515 922 920 923 219 320 966 MUX2_X1
* cell instance $21517 m0 *1 194.18,36.4
X$21517 219 12917 1146 1109 1053 320 DFF_X1
* cell instance $21520 m0 *1 198.36,36.4
X$21520 1077 995 1018 320 219 1020 OAI21_X4
* cell instance $21521 m0 *1 200.83,36.4
X$21521 997 995 219 320 1077 NAND2_X1
* cell instance $21525 r0 *1 189.43,36.4
X$21525 219 13848 1107 1150 1052 320 DFF_X1
* cell instance $21528 r0 *1 193.61,36.4
X$21528 219 14447 1054 1108 1053 320 DFF_X1
* cell instance $21530 r0 *1 197.03,36.4
X$21530 573 320 995 219 BUF_X4
* cell instance $21533 r0 *1 199.5,36.4
X$21533 219 14028 1110 1076 926 320 DFF_X1
* cell instance $21536 r0 *1 203.3,36.4
X$21536 219 14683 1055 1144 926 320 DFF_X1
* cell instance $21538 m0 *1 204.06,36.4
X$21538 545 219 320 926 CLKBUF_X3
* cell instance $21544 r0 *1 208.81,36.4
X$21544 1056 927 1142 219 320 1141 MUX2_X1
* cell instance $21546 r0 *1 210.52,36.4
X$21546 1056 1120 1072 219 320 998 MUX2_X1
* cell instance $21548 m0 *1 210.71,36.4
X$21548 219 12632 1072 998 930 320 DFF_X1
* cell instance $21550 r0 *1 211.85,36.4
X$21550 1056 1057 1058 219 320 1073 MUX2_X1
* cell instance $21551 r0 *1 213.18,36.4
X$21551 219 14038 1058 1073 930 320 DFF_X1
* cell instance $21552 m0 *1 216.41,36.4
X$21552 219 13058 1060 1059 930 320 DFF_X1
* cell instance $21553 m0 *1 215.08,36.4
X$21553 530 1057 1060 219 320 1059 MUX2_X1
* cell instance $21555 r0 *1 216.41,36.4
X$21555 530 1120 1116 219 320 1140 MUX2_X1
* cell instance $21556 r0 *1 217.74,36.4
X$21556 380 219 320 12516 INV_X4
* cell instance $21558 r0 *1 219.45,36.4
X$21558 219 13892 1117 1137 930 320 DFF_X1
* cell instance $21560 m0 *1 220.02,36.4
X$21560 1065 1000 219 320 1205 OR2_X1
* cell instance $21562 r0 *1 222.68,36.4
X$21562 219 14668 1062 1136 1001 320 DFF_X1
* cell instance $21563 m0 *1 222.87,36.4
X$21563 1065 1009 219 320 1061 OR2_X1
* cell instance $21566 m0 *1 225.15,36.4
X$21566 219 13050 1002 1008 1001 320 DFF_X1
* cell instance $21567 m0 *1 228.38,36.4
X$21567 1003 1057 1002 219 320 1008 MUX2_X1
* cell instance $21568 m0 *1 229.71,36.4
X$21568 1065 1007 219 320 1063 OR2_X1
* cell instance $21572 r0 *1 226.67,36.4
X$21572 219 13913 1064 1070 1001 320 DFF_X1
* cell instance $21573 r0 *1 229.9,36.4
X$21573 1064 1069 1002 219 320 1121 MUX2_X1
* cell instance $21577 r0 *1 231.23,36.4
X$21577 1065 1068 219 320 1066 OR2_X1
* cell instance $21579 r0 *1 232.75,36.4
X$21579 219 13900 1128 1129 1124 320 DFF_X1
* cell instance $21581 r0 *1 236.36,36.4
X$21581 1125 929 1067 219 320 1004 MUX2_X1
* cell instance $21583 m0 *1 236.93,36.4
X$21583 219 12759 1067 1004 1124 320 DFF_X1
* cell instance $21592 m0 *1 15.96,156.8
X$21592 8205 8262 8304 219 320 8213 MUX2_X1
* cell instance $21594 m0 *1 17.48,156.8
X$21594 219 12654 8306 8305 7913 320 DFF_X1
* cell instance $21603 r0 *1 8.93,156.8
X$21603 7578 7171 8358 219 320 8403 MUX2_X1
* cell instance $21604 r0 *1 10.26,156.8
X$21604 219 14305 8358 8403 7910 320 DFF_X1
* cell instance $21606 r0 *1 13.87,156.8
X$21606 8358 8145 8359 219 320 8304 MUX2_X1
* cell instance $21609 m0 *1 21.09,156.8
X$21609 8306 6207 7805 219 320 8305 MUX2_X1
* cell instance $21612 m0 *1 22.8,156.8
X$21612 8148 8262 8146 219 320 8264 MUX2_X1
* cell instance $21615 m0 *1 24.51,156.8
X$21615 219 12557 8211 8263 7913 320 DFF_X1
* cell instance $21616 m0 *1 27.93,156.8
X$21616 7969 8149 5946 320 219 8289 MUX2_X2
* cell instance $21617 m0 *1 29.64,156.8
X$21617 219 12894 8307 8404 7914 320 DFF_X1
* cell instance $21621 r0 *1 24.89,156.8
X$21621 7913 219 320 CLKBUF_X1
* cell instance $21626 r0 *1 30.97,156.8
X$21626 7805 6046 8307 219 320 8404 MUX2_X1
* cell instance $21629 r0 *1 33.25,156.8
X$21629 8151 5864 7805 219 320 8150 MUX2_X1
* cell instance $21631 m0 *1 34.01,156.8
X$21631 219 13110 8309 8406 7914 320 DFF_X1
* cell instance $21632 m0 *1 37.43,156.8
X$21632 8217 2719 8264 219 320 8265 MUX2_X1
* cell instance $21634 m0 *1 38.95,156.8
X$21634 219 13116 8267 8266 7914 320 DFF_X1
* cell instance $21636 r0 *1 34.58,156.8
X$21636 8151 7482 8309 219 320 8405 MUX2_X1
* cell instance $21637 r0 *1 35.91,156.8
X$21637 7805 5804 8309 219 320 8406 MUX2_X1
* cell instance $21638 r0 *1 37.24,156.8
X$21638 6606 219 320 7914 CLKBUF_X3
* cell instance $21639 r0 *1 38.19,156.8
X$21639 8090 8265 5946 320 219 8363 MUX2_X2
* cell instance $21642 r0 *1 41.8,156.8
X$21642 8360 8145 8267 219 320 8154 MUX2_X1
* cell instance $21644 m0 *1 42.56,156.8
X$21644 7805 6270 8267 219 320 8266 MUX2_X1
* cell instance $21645 m0 *1 44.08,156.8
X$21645 219 12865 8360 8408 7915 320 DFF_X1
* cell instance $21649 r0 *1 43.7,156.8
X$21649 7805 5808 8360 219 320 8408 MUX2_X1
* cell instance $21653 r0 *1 47.5,156.8
X$21653 8020 6002 8269 219 320 8268 MUX2_X1
* cell instance $21655 m0 *1 47.69,156.8
X$21655 219 13093 8269 8268 7915 320 DFF_X1
* cell instance $21657 m0 *1 51.87,156.8
X$21657 219 13129 8312 8409 7915 320 DFF_X1
* cell instance $21658 m0 *1 55.1,156.8
X$21658 8270 6042 8361 219 320 8271 MUX2_X1
* cell instance $21659 m0 *1 56.43,156.8
X$21659 8020 219 320 8270 CLKBUF_X2
* cell instance $21661 m0 *1 57.95,156.8
X$21661 8224 5801 8270 219 320 8313 MUX2_X1
* cell instance $21666 r0 *1 51.11,156.8
X$21666 6606 219 320 7915 CLKBUF_X3
* cell instance $21670 r0 *1 53.39,156.8
X$21670 8312 6207 8270 219 320 8409 MUX2_X1
* cell instance $21673 r0 *1 55.29,156.8
X$21673 219 14294 8361 8271 7915 320 DFF_X1
* cell instance $21675 m0 *1 61.75,156.8
X$21675 8156 2095 8272 219 320 8319 MUX2_X1
* cell instance $21676 m0 *1 60.42,156.8
X$21676 8361 6165 8443 219 320 8272 MUX2_X1
* cell instance $21677 m0 *1 63.08,156.8
X$21677 8270 5804 8157 219 320 8316 MUX2_X1
* cell instance $21678 m0 *1 64.41,156.8
X$21678 219 12984 8317 8362 8022 320 DFF_X1
* cell instance $21686 r0 *1 64.22,156.8
X$21686 8317 5864 8270 219 320 8362 MUX2_X1
* cell instance $21687 r0 *1 65.55,156.8
X$21687 8317 6165 8157 219 320 8414 MUX2_X1
* cell instance $21698 r0 *1 5.89,106.4
X$21698 4984 219 320 4987 BUF_X1
* cell instance $21706 r0 *1 13.87,106.4
X$21706 4987 4238 5170 219 320 5169 MUX2_X1
* cell instance $21708 r0 *1 15.39,106.4
X$21708 5171 2957 5170 219 320 5174 MUX2_X1
* cell instance $21709 m0 *1 15.77,106.4
X$21709 219 13459 4986 4985 4143 320 DFF_X1
* cell instance $21715 r0 *1 18.62,106.4
X$21715 5092 2659 5174 219 320 5059 MUX2_X1
* cell instance $21717 m0 *1 24.13,106.4
X$21717 4900 4361 4700 219 320 5053 MUX2_X1
* cell instance $21718 m0 *1 20.9,106.4
X$21718 219 13523 4900 5053 4541 320 DFF_X1
* cell instance $21722 r0 *1 23.56,106.4
X$21722 4900 4058 4899 219 320 5175 MUX2_X1
* cell instance $21723 r0 *1 24.89,106.4
X$21723 4700 4237 5054 219 320 4901 MUX2_X1
* cell instance $21724 m0 *1 26.03,106.4
X$21724 5054 2842 4902 219 320 5176 MUX2_X1
* cell instance $21728 r0 *1 26.41,106.4
X$21728 5175 3126 5176 219 320 5056 MUX2_X1
* cell instance $21729 r0 *1 27.74,106.4
X$21729 4987 219 320 5094 BUF_X2
* cell instance $21730 m0 *1 30.97,106.4
X$21730 4051 219 320 4802 CLKBUF_X3
* cell instance $21731 m0 *1 27.74,106.4
X$21731 219 12882 4902 4903 4802 320 DFF_X1
* cell instance $21734 m0 *1 32.87,106.4
X$21734 4799 3990 4988 219 320 5057 MUX2_X1
* cell instance $21738 r0 *1 31.54,106.4
X$21738 219 14057 4988 5057 5097 320 DFF_X1
* cell instance $21741 m0 *1 37.62,106.4
X$21741 4700 3993 4991 219 320 4989 MUX2_X1
* cell instance $21742 r0 *1 37.81,106.4
X$21742 219 14107 4991 4989 4990 320 DFF_X1
* cell instance $21743 m0 *1 39.52,106.4
X$21743 4905 2888 4991 219 320 4954 MUX2_X1
* cell instance $21747 m0 *1 41.42,106.4
X$21747 5056 4992 219 320 4955 NAND2_X1
* cell instance $21750 m0 *1 42.75,106.4
X$21750 4993 4279 4994 320 219 4402 OAI21_X4
* cell instance $21752 r0 *1 41.42,106.4
X$21752 5178 4906 219 320 5180 NAND2_X1
* cell instance $21755 r0 *1 43.13,106.4
X$21755 5181 3758 5059 219 320 4994 MUX2_X1
* cell instance $21757 r0 *1 44.84,106.4
X$21757 219 13977 4995 5060 4990 320 DFF_X1
* cell instance $21758 m0 *1 48.83,106.4
X$21758 4995 4702 4908 219 320 5184 MUX2_X1
* cell instance $21759 m0 *1 45.6,106.4
X$21759 219 12782 4908 4959 4990 320 DFF_X1
* cell instance $21761 m0 *1 53.2,106.4
X$21761 5102 320 2787 219 BUF_X4
* cell instance $21762 m0 *1 54.53,106.4
X$21762 5063 4765 4960 219 320 4907 MUX2_X1
* cell instance $21763 m0 *1 55.86,106.4
X$21763 4996 320 3848 219 BUF_X4
* cell instance $21764 m0 *1 57.19,106.4
X$21764 4997 320 2892 219 BUF_X4
* cell instance $21768 r0 *1 48.45,106.4
X$21768 4995 3948 5094 219 320 5060 MUX2_X1
* cell instance $21769 r0 *1 49.78,106.4
X$21769 5184 4765 5101 219 320 5181 MUX2_X1
* cell instance $21771 r0 *1 52.63,106.4
X$21771 4702 320 5005 219 BUF_X4
* cell instance $21774 r0 *1 54.91,106.4
X$21774 4997 320 2659 219 BUF_X4
* cell instance $21775 r0 *1 56.24,106.4
X$21775 219 2520 320 4996 BUF_X8
* cell instance $21779 m0 *1 59.66,106.4
X$21779 4996 320 2888 219 BUF_X4
* cell instance $21780 m0 *1 64.03,106.4
X$21780 5190 4992 219 320 5065 NAND2_X1
* cell instance $21783 r0 *1 59.66,106.4
X$21783 5103 4255 5188 219 320 5186 MUX2_X1
* cell instance $21785 r0 *1 61.75,106.4
X$21785 5104 3126 5191 219 320 5190 MUX2_X1
* cell instance $21792 r0 *1 64.41,106.4
X$21792 219 13884 4998 5192 5108 320 DFF_X1
* cell instance $21793 m0 *1 66.69,106.4
X$21793 5065 4910 2890 219 320 4964 NAND3_X2
* cell instance $21798 r0 *1 67.64,106.4
X$21798 5103 4485 4998 219 320 5192 MUX2_X1
* cell instance $21802 r0 *1 70.3,106.4
X$21802 3723 219 320 5108 CLKBUF_X3
* cell instance $21803 m0 *1 70.87,106.4
X$21803 4999 3758 5000 219 320 4911 MUX2_X1
* cell instance $21807 m0 *1 79.04,106.4
X$21807 4707 3860 5069 219 320 5068 MUX2_X1
* cell instance $21811 r0 *1 71.25,106.4
X$21811 5197 2659 5001 219 320 5000 MUX2_X1
* cell instance $21814 r0 *1 78.85,106.4
X$21814 219 13847 5069 5068 4966 320 DFF_X1
* cell instance $21817 m0 *1 84.36,106.4
X$21817 219 13193 5002 5071 4966 320 DFF_X1
* cell instance $21818 m0 *1 83.03,106.4
X$21818 4808 4617 5002 219 320 5071 MUX2_X1
* cell instance $21819 m0 *1 87.59,106.4
X$21819 5002 3214 5003 219 320 5006 MUX2_X1
* cell instance $21820 m0 *1 88.92,106.4
X$21820 219 13211 5004 4912 4966 320 DFF_X1
* cell instance $21821 m0 *1 92.15,106.4
X$21821 5006 5005 5116 219 320 5007 MUX2_X1
* cell instance $21824 m0 *1 94.43,106.4
X$21824 5206 4968 2750 219 320 5208 NAND3_X1
* cell instance $21827 m0 *1 96.9,106.4
X$21827 4488 4559 4915 219 320 4914 MUX2_X1
* cell instance $21829 m0 *1 98.42,106.4
X$21829 219 13043 5008 4972 4489 320 DFF_X1
* cell instance $21831 r0 *1 83.22,106.4
X$21831 4707 4497 5003 219 320 5201 MUX2_X1
* cell instance $21832 r0 *1 84.55,106.4
X$21832 219 13718 5003 5201 4966 320 DFF_X1
* cell instance $21833 r0 *1 87.78,106.4
X$21833 5004 3496 4707 219 320 4912 MUX2_X1
* cell instance $21834 r0 *1 89.11,106.4
X$21834 4966 219 320 CLKBUF_X1
* cell instance $21837 r0 *1 90.25,106.4
X$21837 5113 3214 5004 219 320 5115 MUX2_X1
* cell instance $21839 r0 *1 92.34,106.4
X$21839 4913 5117 5007 219 320 5207 MUX2_X1
* cell instance $21840 r0 *1 93.67,106.4
X$21840 5006 2904 2998 219 320 5118 NOR3_X1
* cell instance $21842 r0 *1 94.62,106.4
X$21842 5208 2750 5207 320 219 5023 OAI21_X4
* cell instance $21844 r0 *1 97.85,106.4
X$21844 4488 4617 5119 219 320 5209 MUX2_X1
* cell instance $21847 r0 *1 100.32,106.4
X$21847 5078 5120 5008 219 320 5121 MUX2_X1
* cell instance $21850 m0 *1 102.03,106.4
X$21850 219 13124 5078 5075 5009 320 DFF_X1
* cell instance $21851 m0 *1 105.45,106.4
X$21851 219 13627 4973 5010 5009 320 DFF_X1
* cell instance $21854 r0 *1 103.55,106.4
X$21854 3486 5077 219 320 4918 NAND2_X2
* cell instance $21855 r0 *1 104.5,106.4
X$21855 219 14252 5123 5079 5009 320 DFF_X1
* cell instance $21856 r0 *1 107.73,106.4
X$21856 3859 4492 5123 219 320 5079 MUX2_X1
* cell instance $21859 m0 *1 109.06,106.4
X$21859 219 13562 4916 5011 4620 320 DFF_X1
* cell instance $21864 r0 *1 110.39,106.4
X$21864 4488 4255 5124 219 320 5125 MUX2_X1
* cell instance $21866 r0 *1 114.76,106.4
X$21866 219 14614 5012 5080 5126 320 DFF_X1
* cell instance $21867 m0 *1 117.8,106.4
X$21867 4917 4161 5012 219 320 5080 MUX2_X1
* cell instance $21868 m0 *1 116.47,106.4
X$21868 4882 4076 5012 219 320 5082 MUX2_X1
* cell instance $21869 m0 *1 119.13,106.4
X$21869 1902 219 320 4620 CLKBUF_X3
* cell instance $21870 m0 *1 120.08,106.4
X$21870 5082 4367 4816 219 320 5083 MUX2_X1
* cell instance $21872 m0 *1 121.6,106.4
X$21872 219 13428 5013 5219 4620 320 DFF_X1
* cell instance $21883 r0 *1 119.32,106.4
X$21883 3686 2998 219 320 5215 NAND2_X1
* cell instance $21884 r0 *1 119.89,106.4
X$21884 219 5129 5215 5083 5216 4918 320 OAI22_X4
* cell instance $21885 r0 *1 123.12,106.4
X$21885 4917 3858 5013 219 320 5219 MUX2_X1
* cell instance $21889 r0 *1 125.21,106.4
X$21889 5130 3592 4917 219 320 5221 MUX2_X1
* cell instance $21890 r0 *1 126.54,106.4
X$21890 219 14542 5130 5221 5259 320 DFF_X1
* cell instance $21893 m0 *1 130.53,106.4
X$21893 5014 4351 5085 219 320 4977 MUX2_X1
* cell instance $21894 m0 *1 132.62,106.4
X$21894 5085 4584 4818 219 320 5086 MUX2_X1
* cell instance $21895 m0 *1 133.95,106.4
X$21895 5015 4383 5086 320 219 4737 OAI21_X4
* cell instance $21896 m0 *1 136.42,106.4
X$21896 219 13273 5016 5087 4506 320 DFF_X1
* cell instance $21899 m0 *1 140.6,106.4
X$21899 4382 5017 219 320 5018 OR2_X1
* cell instance $21900 m0 *1 141.36,106.4
X$21900 5017 4921 5224 219 320 5088 MUX2_X1
* cell instance $21903 m0 *1 144.4,106.4
X$21903 1902 219 320 4793 CLKBUF_X3
* cell instance $21904 m0 *1 145.35,106.4
X$21904 4793 219 320 14758 INV_X1
* cell instance $21908 m0 *1 148.2,106.4
X$21908 2477 4982 219 320 5019 XNOR2_X2
* cell instance $21912 r0 *1 135.09,106.4
X$21912 4377 320 4625 219 BUF_X4
* cell instance $21914 r0 *1 137.18,106.4
X$21914 1160 4625 5016 219 320 5087 MUX2_X1
* cell instance $21918 r0 *1 139.84,106.4
X$21918 5262 4718 5016 219 320 5224 MUX2_X1
* cell instance $21919 r0 *1 141.17,106.4
X$21919 5018 4383 5224 320 219 5625 OAI21_X4
* cell instance $21920 r0 *1 143.64,106.4
X$21920 2536 5088 219 320 5090 XNOR2_X2
* cell instance $21922 r0 *1 145.73,106.4
X$21922 5225 4890 5227 219 320 5134 MUX2_X1
* cell instance $21925 r0 *1 148.01,106.4
X$21925 219 5090 5019 5230 5228 5434 320 NAND4_X4
* cell instance $21927 m0 *1 150.48,106.4
X$21927 2206 5091 219 320 5230 XNOR2_X2
* cell instance $21928 m0 *1 152.57,106.4
X$21928 4895 4921 4823 219 320 5091 MUX2_X1
* cell instance $21934 r0 *1 153.14,106.4
X$21934 219 13694 5232 5135 4629 320 DFF_X1
* cell instance $21936 m0 *1 156.75,106.4
X$21936 4919 4268 219 320 4922 NOR2_X1
* cell instance $21938 m0 *1 157.32,106.4
X$21938 4922 4924 4923 219 320 4824 NOR3_X1
* cell instance $21939 m0 *1 158.08,106.4
X$21939 4511 2203 4387 4926 320 219 5020 OAI22_X1
* cell instance $21940 m0 *1 159.03,106.4
X$21940 4179 2542 3784 5021 320 219 4924 OAI22_X1
* cell instance $21941 m0 *1 159.98,106.4
X$21941 4983 5084 4925 219 320 4825 NOR3_X1
* cell instance $21942 m0 *1 160.74,106.4
X$21942 5022 5081 4927 320 3968 219 NOR3_X2
* cell instance $21944 r0 *1 157.13,106.4
X$21944 4919 4358 219 320 5136 NOR2_X1
* cell instance $21945 r0 *1 157.7,106.4
X$21945 5136 5233 5020 219 320 5089 NOR3_X1
* cell instance $21948 r0 *1 159.03,106.4
X$21948 4182 2542 3785 5021 320 219 5233 OAI22_X1
* cell instance $21949 r0 *1 159.98,106.4
X$21949 4919 4355 219 320 5022 NOR2_X1
* cell instance $21951 r0 *1 160.74,106.4
X$21951 5234 3054 219 320 419 NOR2_X2
* cell instance $21952 r0 *1 161.69,106.4
X$21952 5023 4081 219 320 5236 NOR2_X1
* cell instance $21954 r0 *1 162.45,106.4
X$21954 4389 2139 4400 5024 320 219 5139 OAI22_X1
* cell instance $21956 m0 *1 162.45,106.4
X$21956 4308 2542 3925 5021 320 219 5084 OAI22_X1
* cell instance $21957 m0 *1 164.16,106.4
X$21957 4087 2542 5021 3516 320 219 5081 OAI22_X2
* cell instance $21958 m0 *1 165.87,106.4
X$21958 4346 2542 3513 5021 320 219 4978 OAI22_X1
* cell instance $21961 r0 *1 163.4,106.4
X$21961 5140 3966 219 320 426 NOR2_X2
* cell instance $21963 r0 *1 164.73,106.4
X$21963 5143 4080 219 320 425 NOR2_X2
* cell instance $21964 r0 *1 165.68,106.4
X$21964 4083 2139 5024 4396 320 219 5238 OAI22_X2
* cell instance $21965 r0 *1 167.39,106.4
X$21965 4087 1542 5235 3516 320 219 5239 OAI22_X2
* cell instance $21967 m0 *1 170.43,106.4
X$21967 5336 4687 219 320 2833 NOR2_X2
* cell instance $21970 m0 *1 171.57,106.4
X$21970 4929 4306 219 320 5076 NOR2_X1
* cell instance $21975 r0 *1 171.95,106.4
X$21975 4736 5148 3347 2526 320 219 5025 OAI22_X1
* cell instance $21976 m0 *1 173.28,106.4
X$21976 4458 5026 3698 723 320 219 5074 OAI22_X1
* cell instance $21977 m0 *1 172.52,106.4
X$21977 5076 5025 5074 219 320 4928 NOR3_X1
* cell instance $21979 m0 *1 174.42,106.4
X$21979 4930 5073 5027 320 3226 219 NOR3_X2
* cell instance $21982 m0 *1 176.7,106.4
X$21982 4929 4464 219 320 5028 NOR2_X1
* cell instance $21983 m0 *1 177.27,106.4
X$21983 3730 5026 3217 723 320 219 5072 OAI22_X1
* cell instance $21984 m0 *1 178.22,106.4
X$21984 4932 5029 5072 219 320 5070 NOR3_X1
* cell instance $21986 r0 *1 172.9,106.4
X$21986 4523 5026 723 3470 320 219 5027 OAI22_X2
* cell instance $21987 r0 *1 174.61,106.4
X$21987 4929 4307 219 320 5146 NOR2_X1
* cell instance $21991 r0 *1 175.18,106.4
X$21991 4883 5148 2526 3660 320 219 5073 OAI22_X2
* cell instance $21993 r0 *1 177.08,106.4
X$21993 5028 5226 5149 219 320 5067 NOR3_X1
* cell instance $21994 r0 *1 177.84,106.4
X$21994 4828 5148 3940 2526 320 219 5029 OAI22_X1
* cell instance $21997 m0 *1 179.36,106.4
X$21997 5070 2922 219 320 4950 NOR2_X1
* cell instance $22000 r0 *1 182.59,106.4
X$22000 4182 1030 3979 1444 320 219 5218 OAI22_X1
* cell instance $22002 r0 *1 183.92,106.4
X$22002 5212 4080 219 320 273 NOR2_X2
* cell instance $22005 m0 *1 186.39,106.4
X$22005 5030 3054 219 320 385 NOR2_X2
* cell instance $22006 m0 *1 187.91,106.4
X$22006 3647 3703 219 320 5066 NOR2_X1
* cell instance $22012 r0 *1 188.86,106.4
X$22012 3782 4933 3784 4935 320 219 5152 OAI22_X1
* cell instance $22014 m0 *1 189.62,106.4
X$22014 3868 607 3869 1509 320 219 5031 OAI22_X1
* cell instance $22015 m0 *1 190.76,106.4
X$22015 3977 607 3978 1509 320 219 5064 OAI22_X1
* cell instance $22017 r0 *1 189.81,106.4
X$22017 5066 5152 5031 219 320 5062 NOR3_X1
* cell instance $22018 r0 *1 190.57,106.4
X$22018 4740 4933 3925 4935 320 219 5153 OAI22_X1
* cell instance $22021 m0 *1 192.09,106.4
X$22021 3647 3816 219 320 5203 NOR2_X1
* cell instance $22022 r0 *1 192.28,106.4
X$22022 5203 5153 5064 219 320 5202 NOR3_X1
* cell instance $22023 m0 *1 193.8,106.4
X$22023 5062 3792 219 320 5047 NOR2_X1
* cell instance $22024 m0 *1 193.04,106.4
X$22024 4833 4934 4936 219 320 5061 NOR3_X1
* cell instance $22030 m0 *1 195.7,106.4
X$22030 5061 3702 219 320 4949 NOR2_X1
* cell instance $22034 m0 *1 197.98,106.4
X$22034 219 12998 4868 4836 4557 320 DFF_X1
* cell instance $22036 m0 *1 204.25,106.4
X$22036 2362 219 320 4557 CLKBUF_X3
* cell instance $22039 r0 *1 195.7,106.4
X$22039 5202 3725 219 320 5049 NOR2_X1
* cell instance $22042 r0 *1 197.22,106.4
X$22042 2362 219 320 4834 CLKBUF_X3
* cell instance $22046 r0 *1 202.92,106.4
X$22046 219 14297 5156 5199 5314 320 DFF_X1
* cell instance $22048 m0 *1 207.29,106.4
X$22048 5032 4958 2072 320 219 5033 MUX2_X2
* cell instance $22055 m0 *1 210.9,106.4
X$22055 219 13638 5035 5195 4415 320 DFF_X1
* cell instance $22058 r0 *1 211.85,106.4
X$22058 5034 5036 5035 219 320 5195 MUX2_X1
* cell instance $22061 r0 *1 215.08,106.4
X$22061 3987 5036 5037 219 320 5194 MUX2_X1
* cell instance $22063 m0 *1 217.74,106.4
X$22063 219 12907 5038 5193 5158 320 DFF_X1
* cell instance $22065 m0 *1 220.97,106.4
X$22065 5039 4942 5058 219 320 4940 MUX2_X1
* cell instance $22067 r0 *1 219.45,106.4
X$22067 5039 4941 5038 219 320 5193 MUX2_X1
* cell instance $22068 r0 *1 220.78,106.4
X$22068 5058 4530 5038 219 320 5159 MUX2_X1
* cell instance $22070 m0 *1 222.87,106.4
X$22070 219 12940 5040 5189 4317 320 DFF_X1
* cell instance $22074 m0 *1 227.05,106.4
X$22074 3998 2831 5041 219 320 5055 MUX2_X1
* cell instance $22078 r0 *1 223.82,106.4
X$22078 5039 5160 5040 219 320 5189 MUX2_X1
* cell instance $22080 r0 *1 225.34,106.4
X$22080 5161 5183 219 320 4095 OR2_X1
* cell instance $22081 r0 *1 226.1,106.4
X$22081 219 13866 5041 5055 5043 320 DFF_X1
* cell instance $22082 r0 *1 229.33,106.4
X$22082 3998 3081 5042 219 320 5182 MUX2_X1
* cell instance $22087 r0 *1 231.42,106.4
X$22087 219 13876 5163 5179 5043 320 DFF_X1
* cell instance $22088 m0 *1 235.03,106.4
X$22088 4747 4941 5052 219 320 5050 MUX2_X1
* cell instance $22089 m0 *1 231.8,106.4
X$22089 219 12994 5052 5050 5043 320 DFF_X1
* cell instance $22091 r0 *1 234.65,106.4
X$22091 5163 3880 5052 219 320 5164 MUX2_X1
* cell instance $22092 r0 *1 235.98,106.4
X$22092 5051 219 320 5172 BUF_X1
* cell instance $22093 r0 *1 236.55,106.4
X$22093 219 13867 5048 5282 5043 320 DFF_X1
* cell instance $22094 m0 *1 236.93,106.4
X$22094 5168 219 320 5039 BUF_X1
* cell instance $22097 m0 *1 238.26,106.4
X$22097 5048 3071 5166 219 320 5283 MUX2_X1
* cell instance $22098 m0 *1 239.59,106.4
X$22098 5047 219 320 5046 BUF_X1
* cell instance $22099 m0 *1 240.16,106.4
X$22099 5049 219 320 5045 BUF_X1
* cell instance $22101 r0 *1 239.78,106.4
X$22101 5167 219 320 5173 BUF_X1
* cell instance $22110 r0 *1 6.08,103.6
X$22110 4897 219 320 4719 BUF_X2
* cell instance $22116 m0 *1 12.54,103.6
X$22116 4799 4445 4846 219 320 4800 MUX2_X1
* cell instance $22118 m0 *1 14.82,103.6
X$22118 4799 4238 4847 219 320 4801 MUX2_X1
* cell instance $22121 m0 *1 17.1,103.6
X$22121 4846 2957 4847 219 320 4947 MUX2_X1
* cell instance $22127 r0 *1 14.63,103.6
X$22127 219 14074 4847 4801 4143 320 DFF_X1
* cell instance $22131 r0 *1 19.95,103.6
X$22131 219 14166 4899 4948 4541 320 DFF_X1
* cell instance $22133 m0 *1 21.09,103.6
X$22133 4799 4359 4899 219 320 4948 MUX2_X1
* cell instance $22136 m0 *1 30.78,103.6
X$22136 4849 3955 4700 219 320 4850 MUX2_X1
* cell instance $22138 m0 *1 32.87,103.6
X$22138 4849 2787 4988 219 320 4803 MUX2_X1
* cell instance $22144 r0 *1 24.32,103.6
X$22144 219 13729 5054 4901 4802 320 DFF_X1
* cell instance $22145 r0 *1 27.55,103.6
X$22145 4799 4277 4902 219 320 4903 MUX2_X1
* cell instance $22147 r0 *1 29.26,103.6
X$22147 4802 219 320 CLKBUF_X1
* cell instance $22148 r0 *1 29.83,103.6
X$22148 219 14087 4849 4850 4802 320 DFF_X1
* cell instance $22149 r0 *1 33.06,103.6
X$22149 4799 219 320 4700 BUF_X2
* cell instance $22151 r0 *1 34.2,103.6
X$22151 4803 2892 4947 219 320 4855 MUX2_X1
* cell instance $22152 r0 *1 35.53,103.6
X$22152 4799 4278 4905 219 320 4952 MUX2_X1
* cell instance $22153 m0 *1 37.05,103.6
X$22153 4479 219 320 14730 INV_X1
* cell instance $22158 r0 *1 37.24,103.6
X$22158 219 14451 4905 4952 4479 320 DFF_X1
* cell instance $22160 m0 *1 39.33,103.6
X$22160 219 13278 4804 4852 4479 320 DFF_X1
* cell instance $22161 m0 *1 42.75,103.6
X$22161 4751 4992 219 320 4853 NAND2_X1
* cell instance $22163 r0 *1 40.47,103.6
X$22163 4699 4003 4954 219 320 4953 MUX2_X1
* cell instance $22164 r0 *1 41.8,103.6
X$22164 4953 4906 219 320 4805 NAND2_X1
* cell instance $22165 r0 *1 42.37,103.6
X$22165 4955 4805 4854 219 320 4956 NAND3_X2
* cell instance $22166 r0 *1 43.7,103.6
X$22166 4907 3758 4855 219 320 4957 MUX2_X1
* cell instance $22167 m0 *1 43.89,103.6
X$22167 4853 4701 4854 219 320 4856 NAND3_X2
* cell instance $22172 m0 *1 52.25,103.6
X$22172 4857 3948 4700 219 320 4858 MUX2_X1
* cell instance $22173 m0 *1 53.58,103.6
X$22173 4857 4702 4860 219 320 5063 MUX2_X1
* cell instance $22174 m0 *1 54.91,103.6
X$22174 4700 3947 4860 219 320 4909 MUX2_X1
* cell instance $22177 m0 *1 57.19,103.6
X$22177 219 13445 4806 4862 4436 320 DFF_X1
* cell instance $22181 m0 *1 65.17,103.6
X$22181 219 13525 4807 4867 4285 320 DFF_X1
* cell instance $22182 m0 *1 68.4,103.6
X$22182 4611 4161 4807 219 320 4867 MUX2_X1
* cell instance $22184 r0 *1 45.03,103.6
X$22184 4956 4279 4957 320 219 4929 OAI21_X4
* cell instance $22187 r0 *1 48.07,103.6
X$22187 5094 3947 4908 219 320 4959 MUX2_X1
* cell instance $22190 r0 *1 50.54,103.6
X$22190 219 13655 4857 4858 4281 320 DFF_X1
* cell instance $22193 r0 *1 54.91,103.6
X$22193 219 13762 4860 4909 4436 320 DFF_X1
* cell instance $22195 r0 *1 58.9,103.6
X$22195 4703 3950 4806 219 320 4960 MUX2_X1
* cell instance $22203 r0 *1 64.6,103.6
X$22203 4704 4003 4963 219 320 4962 MUX2_X1
* cell instance $22205 r0 *1 66.69,103.6
X$22205 4962 4906 219 320 4910 NAND2_X1
* cell instance $22206 r0 *1 67.26,103.6
X$22206 4998 2657 4807 219 320 4963 MUX2_X1
* cell instance $22210 m0 *1 70.11,103.6
X$22210 4777 4765 4869 219 320 4999 MUX2_X1
* cell instance $22212 m0 *1 72.39,103.6
X$22212 4871 3950 4870 219 320 4869 MUX2_X1
* cell instance $22213 m0 *1 73.72,103.6
X$22213 4611 4497 4871 219 320 4706 MUX2_X1
* cell instance $22214 m0 *1 75.05,103.6
X$22214 4611 4163 4870 219 320 4965 MUX2_X1
* cell instance $22215 m0 *1 76.38,103.6
X$22215 4808 4485 4809 219 320 4873 MUX2_X1
* cell instance $22216 m0 *1 77.71,103.6
X$22216 219 13147 4809 4873 4612 320 DFF_X1
* cell instance $22217 m0 *1 80.94,103.6
X$22217 4808 4490 4708 219 320 4782 MUX2_X1
* cell instance $22219 r0 *1 70.3,103.6
X$22219 4964 4279 4911 320 219 4633 OAI21_X4
* cell instance $22223 r0 *1 74.1,103.6
X$22223 219 13713 4870 4965 5108 320 DFF_X1
* cell instance $22225 r0 *1 77.52,103.6
X$22225 4810 219 320 3723 CLKBUF_X3
* cell instance $22228 m0 *1 82.84,103.6
X$22228 4780 3766 4809 219 320 4876 MUX2_X1
* cell instance $22234 m0 *1 92.72,103.6
X$22234 4876 2904 2998 219 320 4878 NOR3_X1
* cell instance $22235 m0 *1 93.48,103.6
X$22235 4712 4878 4877 320 4879 219 NOR3_X2
* cell instance $22237 m0 *1 96.33,103.6
X$22237 4810 219 320 3856 CLKBUF_X3
* cell instance $22245 r0 *1 84.36,103.6
X$22245 4808 219 320 4707 BUF_X2
* cell instance $22248 r0 *1 91.96,103.6
X$22248 4876 5005 4711 219 320 4913 MUX2_X1
* cell instance $22249 r0 *1 93.29,103.6
X$22249 4898 219 320 4160 BUF_X1
* cell instance $22250 r0 *1 93.86,103.6
X$22250 4714 4854 219 320 4968 NAND2_X1
* cell instance $22251 r0 *1 94.43,103.6
X$22251 3856 219 320 14798 CLKBUF_X3
* cell instance $22252 r0 *1 95.38,103.6
X$22252 4879 2244 320 4971 219 XOR2_X2
* cell instance $22253 r0 *1 97.09,103.6
X$22253 219 13795 4915 4914 4489 320 DFF_X1
* cell instance $22254 r0 *1 100.32,103.6
X$22254 4488 4072 5008 219 320 4972 MUX2_X1
* cell instance $22258 r0 *1 104.12,103.6
X$22258 5078 3659 3859 219 320 5075 MUX2_X1
* cell instance $22260 r0 *1 105.64,103.6
X$22260 4488 4490 4973 219 320 5010 MUX2_X1
* cell instance $22262 m0 *1 108.49,103.6
X$22262 4695 219 320 4812 BUF_X1
* cell instance $22266 m0 *1 112.29,103.6
X$22266 4302 2477 320 4811 219 XOR2_X2
* cell instance $22267 m0 *1 114,103.6
X$22267 4812 4490 4882 219 320 4813 MUX2_X1
* cell instance $22268 m0 *1 115.33,103.6
X$22268 4812 4485 4815 219 320 4814 MUX2_X1
* cell instance $22269 m0 *1 116.66,103.6
X$22269 219 12596 4815 4814 4620 320 DFF_X1
* cell instance $22270 m0 *1 119.89,103.6
X$22270 4975 4076 4815 219 320 4816 MUX2_X1
* cell instance $22274 r0 *1 109.63,103.6
X$22274 4916 3735 3859 219 320 5011 MUX2_X1
* cell instance $22277 r0 *1 113.24,103.6
X$22277 219 13740 4882 4813 4620 320 DFF_X1
* cell instance $22278 r0 *1 116.47,103.6
X$22278 219 14059 4975 4974 4620 320 DFF_X1
* cell instance $22282 r0 *1 119.7,103.6
X$22282 4917 4492 4975 219 320 4974 MUX2_X1
* cell instance $22283 r0 *1 121.03,103.6
X$22283 4620 219 320 CLKBUF_X1
* cell instance $22284 m0 *1 121.79,103.6
X$22284 219 13423 4976 4817 4376 320 DFF_X1
* cell instance $22289 r0 *1 121.6,103.6
X$22289 4976 3735 4917 219 320 4817 MUX2_X1
* cell instance $22296 r0 *1 129.77,103.6
X$22296 219 14433 5085 4977 4376 320 DFF_X1
* cell instance $22298 m0 *1 129.96,103.6
X$22298 219 12986 4818 4886 4376 320 DFF_X1
* cell instance $22300 m0 *1 134.9,103.6
X$22300 1160 4819 4820 219 320 4716 MUX2_X1
* cell instance $22301 m0 *1 136.23,103.6
X$22301 219 13272 4920 4888 4506 320 DFF_X1
* cell instance $22304 r0 *1 133,103.6
X$22304 5014 4377 4818 219 320 4886 MUX2_X1
* cell instance $22306 r0 *1 134.52,103.6
X$22306 4351 320 4890 219 BUF_X4
* cell instance $22309 r0 *1 136.99,103.6
X$22309 1160 4623 4920 219 320 4888 MUX2_X1
* cell instance $22313 r0 *1 139.65,103.6
X$22313 4820 4718 4920 219 320 5017 MUX2_X1
* cell instance $22314 m0 *1 140.79,103.6
X$22314 1161 4819 4717 219 320 4889 MUX2_X1
* cell instance $22316 m0 *1 142.12,103.6
X$22316 4717 4718 4626 219 320 4821 MUX2_X1
* cell instance $22317 m0 *1 143.45,103.6
X$22317 1161 4890 4892 219 320 4891 MUX2_X1
* cell instance $22321 m0 *1 146.11,103.6
X$22321 4892 4718 4627 219 320 4893 MUX2_X1
* cell instance $22327 r0 *1 147.63,103.6
X$22327 4821 4921 4893 219 320 4982 MUX2_X1
* cell instance $22328 m0 *1 149.91,103.6
X$22328 219 13040 4894 4822 4629 320 DFF_X1
* cell instance $22329 m0 *1 148.58,103.6
X$22329 4719 4890 4894 219 320 4822 MUX2_X1
* cell instance $22330 m0 *1 153.14,103.6
X$22330 4896 4383 4823 320 219 4518 OAI21_X2
* cell instance $22331 m0 *1 154.47,103.6
X$22331 1943 219 320 4629 CLKBUF_X3
* cell instance $22332 m0 *1 155.42,103.6
X$22332 4629 219 320 CLKBUF_X1
* cell instance $22333 m0 *1 155.99,103.6
X$22333 4824 4173 219 320 485 NOR2_X2
* cell instance $22336 m0 *1 159.22,103.6
X$22336 4825 3966 219 320 406 NOR2_X2
* cell instance $22344 r0 *1 151.81,103.6
X$22344 4382 4895 219 320 4896 OR2_X1
* cell instance $22346 r0 *1 152.95,103.6
X$22346 4894 4718 4720 219 320 4823 MUX2_X1
* cell instance $22350 r0 *1 156.37,103.6
X$22350 5089 4080 219 320 229 NOR2_X2
* cell instance $22352 r0 *1 157.51,103.6
X$22352 4470 2203 4459 4926 320 219 4923 OAI22_X1
* cell instance $22355 r0 *1 159.03,103.6
X$22355 4919 4081 219 320 4983 NOR2_X1
* cell instance $22356 r0 *1 159.6,103.6
X$22356 4389 2203 4400 4926 320 219 4925 OAI22_X1
* cell instance $22358 r0 *1 160.74,103.6
X$22358 3660 2203 4926 4396 320 219 4927 OAI22_X2
* cell instance $22361 r0 *1 163.02,103.6
X$22361 4472 2203 4521 4926 320 219 4980 OAI22_X1
* cell instance $22362 r0 *1 163.97,103.6
X$22362 4919 4721 219 320 4981 NOR2_X1
* cell instance $22364 r0 *1 164.92,103.6
X$22364 4981 4978 4980 219 320 4979 NOR3_X1
* cell instance $22365 m0 *1 165.3,103.6
X$22365 4979 4687 219 320 3303 NOR2_X2
* cell instance $22367 m0 *1 166.25,103.6
X$22367 4797 4687 219 320 4951 NOR2_X2
* cell instance $22370 m0 *1 167.77,103.6
X$22370 4728 4687 219 320 4865 NOR2_X2
* cell instance $22373 m0 *1 168.91,103.6
X$22373 4633 4355 219 320 4826 NOR2_X1
* cell instance $22375 m0 *1 169.67,103.6
X$22375 4633 4268 219 320 4731 NOR2_X1
* cell instance $22380 m0 *1 170.62,103.6
X$22380 4887 4885 4685 219 320 4827 NOR3_X1
* cell instance $22381 m0 *1 171.57,103.6
X$22381 4828 4729 4631 4676 320 219 4885 OAI22_X1
* cell instance $22383 m0 *1 173.28,103.6
X$22383 4634 4884 4730 219 320 4635 NOR3_X1
* cell instance $22387 r0 *1 171.57,103.6
X$22387 4928 2811 219 320 436 NOR2_X2
* cell instance $22402 r0 *1 7.79,120.4
X$22402 5922 219 320 5924 BUF_X1
* cell instance $22404 r0 *1 14.44,120.4
X$22404 5924 5923 5925 219 320 6090 MUX2_X1
* cell instance $22405 r0 *1 15.77,120.4
X$22405 219 14084 5927 5987 5287 320 DFF_X1
* cell instance $22407 m0 *1 16.34,120.4
X$22407 5926 2520 5925 219 320 5986 MUX2_X1
* cell instance $22409 r0 *1 19,120.4
X$22409 5927 6207 5803 219 320 5987 MUX2_X1
* cell instance $22410 m0 *1 22.8,120.4
X$22410 5802 5801 5803 219 320 5857 MUX2_X1
* cell instance $22411 m0 *1 19.57,120.4
X$22411 219 13353 5802 5857 5287 320 DFF_X1
* cell instance $22414 r0 *1 20.33,120.4
X$22414 6208 2659 5986 219 320 5996 MUX2_X1
* cell instance $22417 r0 *1 23.37,120.4
X$22417 219 14124 5861 5989 5290 320 DFF_X1
* cell instance $22418 m0 *1 26.22,120.4
X$22418 5803 6042 5861 219 320 5989 MUX2_X1
* cell instance $22420 m0 *1 27.55,120.4
X$22420 5861 2772 6037 219 320 6035 MUX2_X1
* cell instance $22427 r0 *1 29.26,120.4
X$22427 5924 5933 5928 219 320 5990 MUX2_X1
* cell instance $22428 r0 *1 30.59,120.4
X$22428 219 13998 5928 5990 5097 320 DFF_X1
* cell instance $22430 m0 *1 33.06,120.4
X$22430 5929 5864 5803 219 320 5709 MUX2_X1
* cell instance $22431 m0 *1 34.58,120.4
X$22431 219 12604 5991 5805 5097 320 DFF_X1
* cell instance $22433 m0 *1 38,120.4
X$22433 219 13114 5806 5993 5710 320 DFF_X1
* cell instance $22437 r0 *1 34.96,120.4
X$22437 5929 3848 5991 219 320 6108 MUX2_X1
* cell instance $22441 r0 *1 37.62,120.4
X$22441 5803 5930 5806 219 320 5993 MUX2_X1
* cell instance $22442 r0 *1 38.95,120.4
X$22442 219 14381 5931 5994 5710 320 DFF_X1
* cell instance $22444 m0 *1 41.61,120.4
X$22444 5931 2714 5806 219 320 5807 MUX2_X1
* cell instance $22445 m0 *1 43.13,120.4
X$22445 5807 4765 5869 219 320 5867 MUX2_X1
* cell instance $22448 r0 *1 42.37,120.4
X$22448 5867 3758 5996 219 320 5999 MUX2_X1
* cell instance $22450 r0 *1 44.08,120.4
X$22450 5998 5999 4279 320 219 5847 OAI21_X4
* cell instance $22452 m0 *1 44.84,120.4
X$22452 219 12801 5868 5809 5710 320 DFF_X1
* cell instance $22453 m0 *1 51.11,120.4
X$22453 219 12863 6003 6001 5388 320 DFF_X1
* cell instance $22454 m0 *1 54.34,120.4
X$22454 4364 320 5808 219 BUF_X4
* cell instance $22458 r0 *1 46.74,120.4
X$22458 5868 3950 6039 219 320 5869 MUX2_X1
* cell instance $22460 r0 *1 48.45,120.4
X$22460 5921 219 320 5932 BUF_X1
* cell instance $22464 r0 *1 51.49,120.4
X$22464 5932 6002 6003 219 320 6001 MUX2_X1
* cell instance $22468 r0 *1 57.57,120.4
X$22468 5932 219 320 5711 CLKBUF_X2
* cell instance $22469 m0 *1 57.76,120.4
X$22469 5711 6042 5772 219 320 5872 MUX2_X1
* cell instance $22475 r0 *1 59.09,120.4
X$22475 5932 5933 5606 219 320 6005 MUX2_X1
* cell instance $22476 r0 *1 60.42,120.4
X$22476 219 14155 5606 6005 5107 320 DFF_X1
* cell instance $22484 r0 *1 66.5,120.4
X$22484 219 13726 6045 6129 5716 320 DFF_X1
* cell instance $22486 m0 *1 67.07,120.4
X$22486 219 13402 5714 5873 5716 320 DFF_X1
* cell instance $22490 m0 *1 71.63,120.4
X$22490 5711 5930 5811 219 320 5875 MUX2_X1
* cell instance $22492 m0 *1 72.96,120.4
X$22492 3723 219 320 5716 CLKBUF_X3
* cell instance $22494 r0 *1 72.01,120.4
X$22494 219 14225 6048 6047 5716 320 DFF_X1
* cell instance $22496 m0 *1 74.29,120.4
X$22496 5717 1933 5811 219 320 6008 MUX2_X1
* cell instance $22498 r0 *1 75.24,120.4
X$22498 6008 2095 6135 219 320 6011 MUX2_X1
* cell instance $22500 m0 *1 77.71,120.4
X$22500 219 13361 5812 5877 5716 320 DFF_X1
* cell instance $22502 m0 *1 80.94,120.4
X$22502 5812 3659 5678 219 320 5877 MUX2_X1
* cell instance $22504 m0 *1 85.31,120.4
X$22504 219 13362 5813 5882 5315 320 DFF_X1
* cell instance $22505 m0 *1 88.54,120.4
X$22505 5511 4072 5813 219 320 5882 MUX2_X1
* cell instance $22506 m0 *1 89.87,120.4
X$22506 5814 5816 5813 219 320 5781 MUX2_X1
* cell instance $22509 r0 *1 78.28,120.4
X$22509 5920 219 320 5511 BUF_X1
* cell instance $22510 r0 *1 78.85,120.4
X$22510 6164 4072 6009 219 320 6136 MUX2_X1
* cell instance $22511 r0 *1 80.18,120.4
X$22511 5812 5120 6009 219 320 6010 MUX2_X1
* cell instance $22513 r0 *1 81.7,120.4
X$22513 6010 5077 6050 219 320 5934 MUX2_X1
* cell instance $22516 r0 *1 83.6,120.4
X$22516 219 2152 5935 6051 6011 2151 320 AOI22_X4
* cell instance $22518 r0 *1 87.59,120.4
X$22518 5511 4485 5937 219 320 5936 MUX2_X1
* cell instance $22521 r0 *1 89.87,120.4
X$22521 5511 4490 5939 219 320 6012 MUX2_X1
* cell instance $22522 r0 *1 91.2,120.4
X$22522 219 14249 5939 6012 5112 320 DFF_X1
* cell instance $22523 m0 *1 91.77,120.4
X$22523 5514 4492 5885 219 320 5938 MUX2_X1
* cell instance $22525 m0 *1 93.1,120.4
X$22525 219 12734 5885 5938 5426 320 DFF_X1
* cell instance $22528 r0 *1 94.43,120.4
X$22528 5937 5353 5887 219 320 6137 MUX2_X1
* cell instance $22529 r0 *1 95.76,120.4
X$22529 5885 5353 5939 219 320 6139 MUX2_X1
* cell instance $22530 r0 *1 97.09,120.4
X$22530 5940 2239 320 6013 219 XOR2_X2
* cell instance $22531 m0 *1 98.23,120.4
X$22531 4854 5940 320 219 5815 AND2_X1
* cell instance $22532 m0 *1 97.47,120.4
X$22532 5800 219 320 5941 CLKBUF_X2
* cell instance $22533 m0 *1 98.99,120.4
X$22533 219 12854 6014 5942 5426 320 DFF_X1
* cell instance $22534 m0 *1 102.22,120.4
X$22534 5787 5816 6014 219 320 5889 MUX2_X1
* cell instance $22535 m0 *1 103.55,120.4
X$22535 5889 4127 219 320 5893 NOR2_X1
* cell instance $22536 m0 *1 104.12,120.4
X$22536 5822 2206 320 5943 219 XOR2_X2
* cell instance $22538 m0 *1 106.02,120.4
X$22538 4854 5892 219 320 5894 OR2_X1
* cell instance $22539 m0 *1 106.78,120.4
X$22539 5787 3659 5820 219 320 5821 MUX2_X1
* cell instance $22540 m0 *1 108.11,120.4
X$22540 5894 5946 5822 320 219 4390 OAI21_X4
* cell instance $22541 m0 *1 110.58,120.4
X$22541 219 12681 5948 5895 5519 320 DFF_X1
* cell instance $22543 r0 *1 98.8,120.4
X$22543 5941 4072 6014 219 320 5942 MUX2_X1
* cell instance $22544 r0 *1 100.13,120.4
X$22544 5943 4971 5819 6013 320 5944 219 NOR4_X2
* cell instance $22546 r0 *1 102.6,120.4
X$22546 5479 5817 6167 219 6015 320 AOI21_X1
* cell instance $22547 r0 *1 103.36,120.4
X$22547 5818 6015 5421 219 320 5945 NOR3_X1
* cell instance $22550 r0 *1 105.26,120.4
X$22550 6016 4566 219 320 6017 NOR2_X1
* cell instance $22551 r0 *1 105.83,120.4
X$22551 6018 6055 6017 5893 320 5892 219 NOR4_X2
* cell instance $22553 r0 *1 107.73,120.4
X$22553 6019 5350 5515 219 320 6018 NOR3_X1
* cell instance $22555 r0 *1 108.87,120.4
X$22555 5948 6057 5947 219 320 6142 MUX2_X1
* cell instance $22556 r0 *1 110.2,120.4
X$22556 5820 3860 5947 219 320 5824 MUX2_X1
* cell instance $22557 r0 *1 111.53,120.4
X$22557 5948 3496 5820 219 320 5895 MUX2_X1
* cell instance $22562 m0 *1 114.19,120.4
X$22562 219 13077 5726 5825 5519 320 DFF_X1
* cell instance $22564 m0 *1 118.37,120.4
X$22564 219 13044 5897 5896 5519 320 DFF_X1
* cell instance $22565 m0 *1 121.6,120.4
X$22565 219 13357 5728 5899 5126 320 DFF_X1
* cell instance $22566 m0 *1 124.83,120.4
X$22566 219 12624 5953 5826 5729 320 DFF_X1
* cell instance $22570 m0 *1 130.53,120.4
X$22570 5428 219 320 5729 CLKBUF_X3
* cell instance $22571 m0 *1 131.48,120.4
X$22571 5729 219 320 CLKBUF_X1
* cell instance $22573 m0 *1 135.09,120.4
X$22573 5903 4890 5954 219 320 6024 MUX2_X1
* cell instance $22574 m0 *1 136.42,120.4
X$22574 5903 4625 5827 219 320 5955 MUX2_X1
* cell instance $22576 m0 *1 138.51,120.4
X$22576 5954 5828 5827 219 320 5905 MUX2_X1
* cell instance $22579 m0 *1 146.11,120.4
X$22579 5909 4890 5956 219 320 5907 MUX2_X1
* cell instance $22581 r0 *1 114.19,120.4
X$22581 5726 2904 5949 219 320 6016 MUX2_X1
* cell instance $22582 r0 *1 115.52,120.4
X$22582 219 13675 5949 5950 5519 320 DFF_X1
* cell instance $22587 r0 *1 119.13,120.4
X$22587 5727 3860 6144 219 320 5951 MUX2_X1
* cell instance $22589 r0 *1 120.65,120.4
X$22589 5897 5217 5728 219 320 6174 MUX2_X1
* cell instance $22591 r0 *1 122.74,120.4
X$22591 6021 219 320 1282 CLKBUF_X3
* cell instance $22592 r0 *1 123.69,120.4
X$22592 5727 4497 5952 219 320 6022 MUX2_X1
* cell instance $22594 r0 *1 125.21,120.4
X$22594 219 14539 5952 6022 5729 320 DFF_X1
* cell instance $22599 r0 *1 134.14,120.4
X$22599 219 14460 5954 6024 5729 320 DFF_X1
* cell instance $22600 r0 *1 137.37,120.4
X$22600 219 14574 5827 5955 5358 320 DFF_X1
* cell instance $22602 r0 *1 140.98,120.4
X$22602 3138 6060 219 320 6025 OR2_X1
* cell instance $22603 r0 *1 141.74,120.4
X$22603 6025 3262 5905 320 219 4388 OAI21_X4
* cell instance $22606 r0 *1 145.16,120.4
X$22606 219 14580 5956 5907 5531 320 DFF_X1
* cell instance $22607 m0 *1 149.15,120.4
X$22607 219 13553 6026 5910 5531 320 DFF_X1
* cell instance $22608 m0 *1 147.82,120.4
X$22608 5909 4625 6026 219 320 5910 MUX2_X1
* cell instance $22610 m0 *1 155.42,120.4
X$22610 5831 4890 5914 219 320 6029 MUX2_X1
* cell instance $22611 m0 *1 156.75,120.4
X$22611 5831 4625 5913 219 320 5916 MUX2_X1
* cell instance $22614 r0 *1 148.39,120.4
X$22614 5956 6027 6026 219 320 5957 MUX2_X1
* cell instance $22617 r0 *1 152.95,120.4
X$22617 6251 6027 6150 219 320 6064 MUX2_X1
* cell instance $22618 r0 *1 154.28,120.4
X$22618 219 14238 5914 6029 5619 320 DFF_X1
* cell instance $22619 r0 *1 157.51,120.4
X$22619 5914 5832 5913 219 320 6066 MUX2_X1
* cell instance $22622 m0 *1 159.22,120.4
X$22622 219 13504 5913 5916 5619 320 DFF_X1
* cell instance $22623 m0 *1 162.64,120.4
X$22623 4464 219 320 4268 CLKBUF_X3
* cell instance $22624 m0 *1 163.59,120.4
X$22624 5919 4355 219 320 6031 NOR2_X1
* cell instance $22627 r0 *1 159.98,120.4
X$22627 6254 5958 4074 219 320 NOR2_X4
* cell instance $22629 r0 *1 161.88,120.4
X$22629 4308 320 3977 219 BUF_X4
* cell instance $22630 r0 *1 163.21,120.4
X$22630 6031 5833 6033 320 4049 219 NOR3_X2
* cell instance $22631 m0 *1 164.73,120.4
X$22631 4087 1281 5834 4396 320 219 5833 OAI22_X2
* cell instance $22634 m0 *1 166.63,120.4
X$22634 5919 4268 219 320 5835 NOR2_X1
* cell instance $22637 r0 *1 164.73,120.4
X$22637 5617 5959 219 320 6153 NAND2_X1
* cell instance $22638 r0 *1 165.3,120.4
X$22638 6068 320 3666 219 BUF_X4
* cell instance $22640 r0 *1 166.82,120.4
X$22640 3660 2449 5960 3508 320 219 6033 OAI22_X2
* cell instance $22641 m0 *1 168.15,120.4
X$22641 219 244 3866 5918 5838 320 AOI21_X4
* cell instance $22642 m0 *1 167.58,120.4
X$22642 5696 5959 219 320 5789 NAND2_X1
* cell instance $22643 m0 *1 170.62,120.4
X$22643 5617 5793 219 320 5918 NAND2_X1
* cell instance $22645 r0 *1 168.53,120.4
X$22645 5835 5836 6032 219 320 6177 NOR3_X1
* cell instance $22646 r0 *1 169.29,120.4
X$22646 4470 2449 3382 5960 320 219 6032 OAI22_X1
* cell instance $22648 r0 *1 170.62,120.4
X$22648 6068 320 3940 219 BUF_X4
* cell instance $22650 m0 *1 171.57,120.4
X$22650 4883 320 5837 219 BUF_X4
* cell instance $22652 m0 *1 174.61,120.4
X$22652 5962 5839 219 320 5838 NOR2_X2
* cell instance $22655 m0 *1 177.27,120.4
X$22655 6020 5625 3457 5741 320 219 5906 OAI22_X1
* cell instance $22657 r0 *1 171.95,120.4
X$22657 6068 320 3158 219 BUF_X4
* cell instance $22659 r0 *1 173.47,120.4
X$22659 3508 6030 3470 891 320 219 6071 OAI22_X1
* cell instance $22660 r0 *1 174.42,120.4
X$22660 4396 5961 5964 3275 320 219 5839 OAI22_X2
* cell instance $22664 r0 *1 176.13,120.4
X$22664 6146 6028 219 320 6067 NOR2_X2
* cell instance $22665 r0 *1 177.08,120.4
X$22665 3393 2205 3271 2443 320 219 6180 OAI22_X1
* cell instance $22666 r0 *1 178.03,120.4
X$22666 4459 5961 3457 5964 320 219 5963 OAI22_X1
* cell instance $22667 m0 *1 178.79,120.4
X$22667 5908 5631 219 320 5965 NOR2_X1
* cell instance $22669 m0 *1 179.36,120.4
X$22669 5906 5840 219 320 5904 NOR2_X1
* cell instance $22671 r0 *1 178.98,120.4
X$22671 4387 5961 3608 5964 320 219 6023 OAI22_X1
* cell instance $22672 r0 *1 179.93,120.4
X$22672 6072 6023 219 320 6074 NOR2_X1
* cell instance $22673 m0 *1 180.5,120.4
X$22673 4307 219 320 3816 CLKBUF_X3
* cell instance $22675 m0 *1 181.45,120.4
X$22675 4725 219 320 3162 CLKBUF_X3
* cell instance $22676 m0 *1 182.4,120.4
X$22676 5901 320 3925 219 BUF_X4
* cell instance $22677 m0 *1 183.73,120.4
X$22677 5841 320 4241 219 BUF_X4
* cell instance $22681 r0 *1 182.21,120.4
X$22681 5617 5902 219 320 5966 NAND2_X1
* cell instance $22682 r0 *1 182.78,120.4
X$22682 6237 219 320 3869 CLKBUF_X3
* cell instance $22684 r0 *1 184.11,120.4
X$22684 5898 320 3508 219 BUF_X4
* cell instance $22685 r0 *1 185.44,120.4
X$22685 5901 320 3387 219 BUF_X4
* cell instance $22686 m0 *1 186.77,120.4
X$22686 3512 5842 3516 5843 320 219 5844 OAI22_X1
* cell instance $22687 m0 *1 185.44,120.4
X$22687 5898 320 3516 219 BUF_X4
* cell instance $22688 m0 *1 187.72,120.4
X$22688 5744 3398 219 320 5845 NOR2_X1
* cell instance $22689 m0 *1 188.29,120.4
X$22689 5845 5844 5846 219 320 5888 NOR3_X1
* cell instance $22691 m0 *1 189.24,120.4
X$22691 4740 5842 3925 5843 320 219 5890 OAI22_X1
* cell instance $22692 m0 *1 190.19,120.4
X$22692 5968 5890 5778 219 320 5886 NOR3_X1
* cell instance $22693 m0 *1 190.95,120.4
X$22693 5847 3703 219 320 5975 NOR2_X1
* cell instance $22694 m0 *1 191.52,120.4
X$22694 5847 3705 219 320 5973 NOR2_X1
* cell instance $22695 m0 *1 192.09,120.4
X$22695 4458 5970 3979 2518 320 219 5974 OAI22_X1
* cell instance $22696 m0 *1 193.04,120.4
X$22696 5886 5537 219 320 5849 NOR2_X1
* cell instance $22698 m0 *1 193.8,120.4
X$22698 5888 5977 219 320 5862 NOR2_X1
* cell instance $22699 m0 *1 194.37,120.4
X$22699 5884 6006 5538 5880 219 5978 320 NAND4_X2
* cell instance $22700 m0 *1 196.08,120.4
X$22700 2244 5878 320 219 5880 XNOR2_X1
* cell instance $22703 m0 *1 198.17,120.4
X$22703 5881 5979 219 320 5851 NOR2_X1
* cell instance $22708 r0 *1 187.15,120.4
X$22708 5847 3162 219 320 6076 NOR2_X1
* cell instance $22709 r0 *1 187.72,120.4
X$22709 3782 5967 3393 831 320 219 6134 OAI22_X1
* cell instance $22710 r0 *1 188.67,120.4
X$22710 4736 5967 3698 831 320 219 5972 OAI22_X1
* cell instance $22711 r0 *1 189.62,120.4
X$22711 5744 3816 219 320 5968 NOR2_X1
* cell instance $22712 r0 *1 190.19,120.4
X$22712 5847 3816 219 320 5969 NOR2_X1
* cell instance $22713 r0 *1 190.76,120.4
X$22713 4241 5970 3869 2518 320 219 5971 OAI22_X1
* cell instance $22714 r0 *1 191.71,120.4
X$22714 5847 3398 219 320 6133 NOR2_X1
* cell instance $22715 r0 *1 192.28,120.4
X$22715 5973 5972 5974 219 320 6007 NOR3_X1
* cell instance $22716 r0 *1 193.04,120.4
X$22716 6007 5979 219 320 5976 NOR2_X1
* cell instance $22718 r0 *1 193.8,120.4
X$22718 6128 5977 219 320 5982 NOR2_X1
* cell instance $22721 r0 *1 200.83,120.4
X$22721 6081 6116 6082 219 320 5878 MUX2_X1
* cell instance $22725 r0 *1 206.15,120.4
X$22725 219 5021 6118 3624 6084 320 AOI21_X4
* cell instance $22726 m0 *1 209.57,120.4
X$22726 5850 5639 5671 219 320 5674 MUX2_X1
* cell instance $22727 m0 *1 208.24,120.4
X$22727 5751 5198 5850 219 320 5874 MUX2_X1
* cell instance $22728 m0 *1 210.9,120.4
X$22728 219 12975 5871 5852 5752 320 DFF_X1
* cell instance $22735 m0 *1 217.74,120.4
X$22735 5642 5198 5754 219 320 5870 MUX2_X1
* cell instance $22736 m0 *1 216.79,120.4
X$22736 5567 219 320 5752 CLKBUF_X3
* cell instance $22738 m0 *1 219.26,120.4
X$22738 5645 5369 5853 219 320 5774 MUX2_X1
* cell instance $22742 r0 *1 217.55,120.4
X$22742 219 5964 6000 3419 5853 320 AOI21_X4
* cell instance $22744 r0 *1 220.78,120.4
X$22744 4322 5645 320 219 6000 AND2_X1
* cell instance $22745 m0 *1 224.2,120.4
X$22745 219 12936 5980 5997 5544 320 DFF_X1
* cell instance $22746 m0 *1 220.97,120.4
X$22746 219 13028 5755 5866 5752 320 DFF_X1
* cell instance $22750 m0 *1 232.75,120.4
X$22750 219 13074 5863 5865 5165 320 DFF_X1
* cell instance $22751 m0 *1 235.98,120.4
X$22751 5766 219 320 5855 BUF_X1
* cell instance $22752 m0 *1 236.55,120.4
X$22752 219 13127 5985 5988 5165 320 DFF_X1
* cell instance $22753 m0 *1 239.78,120.4
X$22753 5849 219 320 5859 BUF_X1
* cell instance $22757 r0 *1 223.82,120.4
X$22757 5647 5995 5980 219 320 5997 MUX2_X1
* cell instance $22758 r0 *1 225.15,120.4
X$22758 219 14342 6086 5981 5544 320 DFF_X1
* cell instance $22759 r0 *1 228.38,120.4
X$22759 6104 4532 6105 320 219 4935 OAI21_X4
* cell instance $22764 r0 *1 231.04,120.4
X$22764 5982 219 320 5983 BUF_X1
* cell instance $22766 r0 *1 231.99,120.4
X$22766 219 14600 6099 5992 5165 320 DFF_X1
* cell instance $22768 r0 *1 235.41,120.4
X$22768 6089 219 320 6198 BUF_X1
* cell instance $22770 r0 *1 236.17,120.4
X$22770 5758 5162 5985 219 320 5988 MUX2_X1
* cell instance $22772 r0 *1 237.69,120.4
X$22772 5758 5160 5759 219 320 5860 MUX2_X1
* cell instance $22773 r0 *1 239.02,120.4
X$22773 5976 219 320 5984 BUF_X1
* cell instance $22781 m0 *1 22.04,47.6
X$22781 219 12715 1373 1371 1158 320 DFF_X1
* cell instance $22783 m0 *1 26.03,47.6
X$22783 1299 219 320 1300 BUF_X2
* cell instance $22784 m0 *1 26.79,47.6
X$22784 1300 1303 1420 219 320 1301 MUX2_X1
* cell instance $22785 m0 *1 28.12,47.6
X$22785 1304 1303 1305 219 320 1421 MUX2_X1
* cell instance $22787 m0 *1 29.64,47.6
X$22787 1420 1374 1223 219 320 1511 MUX2_X1
* cell instance $22793 r0 *1 20.52,47.6
X$22793 1158 219 320 14779 INV_X1
* cell instance $22794 r0 *1 20.9,47.6
X$22794 1370 219 320 1158 CLKBUF_X3
* cell instance $22795 r0 *1 21.85,47.6
X$22795 1373 1507 1300 219 320 1371 MUX2_X1
* cell instance $22796 r0 *1 23.18,47.6
X$22796 1299 1553 1372 219 320 1418 MUX2_X1
* cell instance $22800 r0 *1 25.84,47.6
X$22800 1373 1377 1372 219 320 1513 MUX2_X1
* cell instance $22802 r0 *1 27.55,47.6
X$22802 219 14565 1305 1421 1302 320 DFF_X1
* cell instance $22804 r0 *1 30.97,47.6
X$22804 1299 1467 1376 219 320 1423 MUX2_X1
* cell instance $22806 m0 *1 31.35,47.6
X$22806 1305 1374 1225 219 320 1375 MUX2_X1
* cell instance $22808 r0 *1 32.49,47.6
X$22808 219 14182 1376 1423 1302 320 DFF_X1
* cell instance $22810 m0 *1 33.06,47.6
X$22810 219 13082 1378 1422 1306 320 DFF_X1
* cell instance $22812 r0 *1 35.91,47.6
X$22812 1304 1307 1378 219 320 1422 MUX2_X1
* cell instance $22814 m0 *1 36.67,47.6
X$22814 1300 1307 1379 219 320 1347 MUX2_X1
* cell instance $22816 m0 *1 39.71,47.6
X$22816 1306 219 320 CLKBUF_X1
* cell instance $22819 r0 *1 38,47.6
X$22819 1376 1377 1379 219 320 1380 MUX2_X1
* cell instance $22821 r0 *1 39.71,47.6
X$22821 1515 219 320 1306 CLKBUF_X3
* cell instance $22822 r0 *1 40.66,47.6
X$22822 1425 1469 1300 219 320 1308 MUX2_X1
* cell instance $22823 m0 *1 40.85,47.6
X$22823 219 13078 1425 1308 1306 320 DFF_X1
* cell instance $22829 r0 *1 42.56,47.6
X$22829 219 14132 1426 1381 1306 320 DFF_X1
* cell instance $22831 m0 *1 47.31,47.6
X$22831 219 13084 1427 1382 1310 320 DFF_X1
* cell instance $22832 m0 *1 45.98,47.6
X$22832 1428 1384 1304 219 320 1309 MUX2_X1
* cell instance $22837 r0 *1 47.12,47.6
X$22837 1304 1385 1427 219 320 1382 MUX2_X1
* cell instance $22841 r0 *1 49.78,47.6
X$22841 1428 1377 1427 219 320 1383 MUX2_X1
* cell instance $22843 m0 *1 53.01,47.6
X$22843 219 12677 1387 1386 1310 320 DFF_X1
* cell instance $22844 m0 *1 51.68,47.6
X$22844 1311 1384 1300 219 320 1351 MUX2_X1
* cell instance $22851 r0 *1 53.01,47.6
X$22851 1300 1385 1387 219 320 1386 MUX2_X1
* cell instance $22852 r0 *1 54.34,47.6
X$22852 1311 1374 1387 219 320 1527 MUX2_X1
* cell instance $22853 r0 *1 55.67,47.6
X$22853 1515 219 320 1310 CLKBUF_X3
* cell instance $22854 r0 *1 56.62,47.6
X$22854 1310 219 320 CLKBUF_X1
* cell instance $22861 r0 *1 62.32,47.6
X$22861 219 14127 1429 1472 1310 320 DFF_X1
* cell instance $22865 r0 *1 75.43,47.6
X$22865 1390 1389 1391 219 320 1431 MUX2_X1
* cell instance $22866 m0 *1 75.81,47.6
X$22866 219 12888 1391 1431 1432 320 DFF_X1
* cell instance $22879 m0 *1 128.25,47.6
X$22879 219 13544 1356 1357 982 320 DFF_X1
* cell instance $22880 m0 *1 131.48,47.6
X$22880 1441 1012 1356 219 320 1357 MUX2_X1
* cell instance $22883 m0 *1 134.52,47.6
X$22883 219 13556 1399 1312 1088 320 DFF_X1
* cell instance $22884 m0 *1 137.75,47.6
X$22884 1313 1314 1315 219 320 1488 MUX2_X1
* cell instance $22888 r0 *1 76.76,47.6
X$22888 219 13983 1477 1475 1432 320 DFF_X1
* cell instance $22889 r0 *1 79.99,47.6
X$22889 1391 1392 1531 219 320 1393 MUX2_X1
* cell instance $22892 r0 *1 83.03,47.6
X$22892 219 13961 1534 1533 1395 320 DFF_X1
* cell instance $22894 r0 *1 89.3,47.6
X$22894 219 14064 1535 1394 1395 320 DFF_X1
* cell instance $22895 r0 *1 92.53,47.6
X$22895 1479 1389 1437 219 320 1436 MUX2_X1
* cell instance $22896 r0 *1 93.86,47.6
X$22896 219 14115 1437 1436 1395 320 DFF_X1
* cell instance $22908 r0 *1 127.87,47.6
X$22908 219 14309 1397 1440 982 320 DFF_X1
* cell instance $22909 r0 *1 131.1,47.6
X$22909 1441 1011 1397 219 320 1440 MUX2_X1
* cell instance $22910 r0 *1 132.43,47.6
X$22910 471 1035 1398 219 320 1443 MUX2_X1
* cell instance $22911 r0 *1 133.76,47.6
X$22911 219 14160 1398 1443 1485 320 DFF_X1
* cell instance $22912 r0 *1 136.99,47.6
X$22912 471 1041 1399 219 320 1312 MUX2_X1
* cell instance $22915 r0 *1 139.46,47.6
X$22915 522 219 320 1274 CLKBUF_X3
* cell instance $22918 m0 *1 141.74,47.6
X$22918 219 1445 969 320 BUF_X16
* cell instance $22921 r0 *1 143.83,47.6
X$22921 219 714 320 627 BUF_X8
* cell instance $22922 r0 *1 146.3,47.6
X$22922 627 320 501 219 BUF_X4
* cell instance $22924 m0 *1 147.63,47.6
X$22924 219 13582 1451 1448 1091 320 DFF_X1
* cell instance $22925 r0 *1 147.63,47.6
X$22925 219 14471 1400 1452 1091 320 DFF_X1
* cell instance $22926 r0 *1 150.86,47.6
X$22926 489 903 1400 219 320 1452 MUX2_X1
* cell instance $22927 m0 *1 151.43,47.6
X$22927 219 12765 1318 1454 1233 320 DFF_X1
* cell instance $22931 m0 *1 155.61,47.6
X$22931 219 12731 1320 1319 1233 320 DFF_X1
* cell instance $22933 r0 *1 152.19,47.6
X$22933 489 902 1451 219 320 1448 MUX2_X1
* cell instance $22934 r0 *1 153.52,47.6
X$22934 489 851 1318 219 320 1454 MUX2_X1
* cell instance $22938 r0 *1 158.84,47.6
X$22938 219 14644 1457 1401 1233 320 DFF_X1
* cell instance $22940 m0 *1 159.22,47.6
X$22940 413 902 1457 219 320 1401 MUX2_X1
* cell instance $22941 m0 *1 161.12,47.6
X$22941 1320 1084 1457 219 320 1459 MUX2_X1
* cell instance $22945 m0 *1 163.02,47.6
X$22945 1321 1084 1490 219 320 1402 MUX2_X1
* cell instance $22948 m0 *1 164.54,47.6
X$22948 1459 1402 993 320 219 1460 MUX2_X2
* cell instance $22950 m0 *1 166.44,47.6
X$22950 219 733 320 993 BUF_X8
* cell instance $22954 m0 *1 169.29,47.6
X$22954 291 803 1322 219 320 1367 MUX2_X1
* cell instance $22956 m0 *1 171,47.6
X$22956 1292 1464 993 320 219 1463 OAI21_X4
* cell instance $22957 m0 *1 174.23,47.6
X$22957 344 802 1324 219 320 1366 MUX2_X1
* cell instance $22959 m0 *1 176.32,47.6
X$22959 1325 1462 993 320 219 1363 OAI21_X4
* cell instance $22962 m0 *1 179.36,47.6
X$22962 1461 993 1360 320 219 1449 OAI21_X4
* cell instance $22964 m0 *1 181.83,47.6
X$22964 1326 1084 1175 219 320 1360 MUX2_X1
* cell instance $22970 r0 *1 181.45,47.6
X$22970 219 14204 1404 1458 1328 320 DFF_X1
* cell instance $22971 r0 *1 184.68,47.6
X$22971 297 1403 1404 219 320 1458 MUX2_X1
* cell instance $22972 m0 *1 186.01,47.6
X$22972 219 12818 1456 1327 1328 320 DFF_X1
* cell instance $22976 m0 *1 191.52,47.6
X$22976 1359 1329 1242 219 320 1498 MUX2_X1
* cell instance $22978 m0 *1 193.61,47.6
X$22978 219 12822 1332 1455 1053 320 DFF_X1
* cell instance $22979 m0 *1 196.84,47.6
X$22979 1332 1329 1294 219 320 1447 MUX2_X1
* cell instance $22982 r0 *1 186.39,47.6
X$22982 297 1492 1456 219 320 1327 MUX2_X1
* cell instance $22983 r0 *1 187.72,47.6
X$22983 1404 1329 1456 219 320 1532 MUX2_X1
* cell instance $22988 r0 *1 194.75,47.6
X$22988 1450 1585 1331 320 219 1453 OAI21_X4
* cell instance $22989 r0 *1 197.22,47.6
X$22989 1405 1447 219 320 1450 OR2_X1
* cell instance $22991 m0 *1 198.74,47.6
X$22991 682 1330 1333 219 320 1355 MUX2_X1
* cell instance $22993 m0 *1 200.07,47.6
X$22993 1333 1329 1334 219 320 1446 MUX2_X1
* cell instance $22994 m0 *1 201.4,47.6
X$22994 682 1241 1334 219 320 1354 MUX2_X1
* cell instance $22996 m0 *1 202.92,47.6
X$22996 1248 219 320 14726 INV_X1
* cell instance $22997 m0 *1 203.3,47.6
X$22997 545 219 320 1248 CLKBUF_X3
* cell instance $22998 m0 *1 204.25,47.6
X$22998 1353 1407 1439 320 219 1616 OAI21_X4
* cell instance $22999 m0 *1 206.72,47.6
X$22999 219 12814 1349 1438 1248 320 DFF_X1
* cell instance $23000 m0 *1 209.95,47.6
X$23000 1337 1407 1345 320 219 1348 OAI21_X4
* cell instance $23001 m0 *1 212.42,47.6
X$23001 1330 320 927 219 BUF_X4
* cell instance $23007 r0 *1 199.31,47.6
X$23007 1405 1446 219 320 1406 OR2_X1
* cell instance $23008 r0 *1 200.07,47.6
X$23008 1406 1585 1184 320 219 1444 OAI21_X4
* cell instance $23012 r0 *1 203.87,47.6
X$23012 1282 219 320 999 CLKBUF_X3
* cell instance $23013 r0 *1 204.82,47.6
X$23013 1245 1407 1186 320 219 1442 OAI21_X4
* cell instance $23015 r0 *1 208.05,47.6
X$23015 1246 927 1349 219 320 1438 MUX2_X1
* cell instance $23018 r0 *1 212.61,47.6
X$23018 1330 320 1414 219 BUF_X4
* cell instance $23019 r0 *1 213.94,47.6
X$23019 1409 1408 1518 219 320 1517 MUX2_X1
* cell instance $23023 r0 *1 216.6,47.6
X$23023 380 219 320 1188 CLKBUF_X3
* cell instance $23026 r0 *1 219.83,47.6
X$23026 219 14534 1434 1435 1188 320 DFF_X1
* cell instance $23027 m0 *1 221.92,47.6
X$23027 1339 1119 1433 320 219 1344 OAI21_X4
* cell instance $23031 m0 *1 228.95,47.6
X$23031 219 13527 1413 1424 1256 320 DFF_X1
* cell instance $23035 r0 *1 226.29,47.6
X$23035 219 13873 1411 1430 1256 320 DFF_X1
* cell instance $23036 r0 *1 229.52,47.6
X$23036 1410 1408 1411 219 320 1430 MUX2_X1
* cell instance $23037 r0 *1 230.85,47.6
X$23037 1413 932 1411 219 320 1412 MUX2_X1
* cell instance $23038 r0 *1 232.18,47.6
X$23038 1410 1414 1413 219 320 1424 MUX2_X1
* cell instance $23039 m0 *1 235.79,47.6
X$23039 219 13537 1417 1416 1256 320 DFF_X1
* cell instance $23040 m0 *1 232.56,47.6
X$23040 219 13536 1415 1340 1256 320 DFF_X1
* cell instance $23044 r0 *1 233.51,47.6
X$23044 380 219 320 1256 CLKBUF_X3
* cell instance $23047 r0 *1 235.03,47.6
X$23047 1419 1408 1415 219 320 1340 MUX2_X1
* cell instance $23048 r0 *1 236.36,47.6
X$23048 1419 1414 1417 219 320 1416 MUX2_X1
* cell instance $23077 m0 *1 16.53,201.6
X$23077 219 13266 11126 11264 11038 320 DFF_X1
* cell instance $23080 m0 *1 22.8,201.6
X$23080 11303 6902 10433 219 320 11431 MUX2_X1
* cell instance $23081 m0 *1 24.13,201.6
X$23081 9526 219 320 11038 CLKBUF_X3
* cell instance $23082 m0 *1 25.08,201.6
X$23082 11349 7014 10433 219 320 11223 MUX2_X1
* cell instance $23083 m0 *1 26.41,201.6
X$23083 219 13584 11306 11224 11305 320 DFF_X1
* cell instance $23084 m0 *1 29.64,201.6
X$23084 11349 9101 11306 219 320 11225 MUX2_X1
* cell instance $23090 r0 *1 21.47,201.6
X$23090 219 14587 11303 11431 11038 320 DFF_X1
* cell instance $23091 r0 *1 24.7,201.6
X$23091 11303 8795 11304 219 320 11040 MUX2_X1
* cell instance $23094 r0 *1 27.17,201.6
X$23094 11183 7123 11306 219 320 11224 MUX2_X1
* cell instance $23097 r0 *1 31.92,201.6
X$23097 11308 6902 10032 219 320 11307 MUX2_X1
* cell instance $23099 m0 *1 32.11,201.6
X$23099 219 13032 11308 11307 11045 320 DFF_X1
* cell instance $23102 r0 *1 34.2,201.6
X$23102 219 13862 11383 11433 11045 320 DFF_X1
* cell instance $23103 m0 *1 37.05,201.6
X$23103 11045 219 320 CLKBUF_X1
* cell instance $23104 m0 *1 35.72,201.6
X$23104 11308 9287 11383 219 320 11044 MUX2_X1
* cell instance $23106 m0 *1 37.81,201.6
X$23106 11350 7014 10032 219 320 11309 MUX2_X1
* cell instance $23107 m0 *1 39.14,201.6
X$23107 219 13051 11228 11265 11045 320 DFF_X1
* cell instance $23110 m0 *1 44.08,201.6
X$23110 11311 6902 9531 219 320 11310 MUX2_X1
* cell instance $23112 m0 *1 46.93,201.6
X$23112 219 12931 11267 11268 11048 320 DFF_X1
* cell instance $23114 m0 *1 50.35,201.6
X$23114 219 12939 11230 11231 11048 320 DFF_X1
* cell instance $23115 m0 *1 53.58,201.6
X$23115 219 12949 11312 11352 11048 320 DFF_X1
* cell instance $23117 m0 *1 57,201.6
X$23117 11312 8788 11313 219 320 11233 MUX2_X1
* cell instance $23128 r0 *1 37.43,201.6
X$23128 9405 219 320 11045 CLKBUF_X3
* cell instance $23130 r0 *1 38.57,201.6
X$23130 219 14637 11350 11309 11045 320 DFF_X1
* cell instance $23134 r0 *1 43.89,201.6
X$23134 219 14302 11311 11310 11305 320 DFF_X1
* cell instance $23137 r0 *1 48.07,201.6
X$23137 11311 8795 11436 219 320 11131 MUX2_X1
* cell instance $23141 r0 *1 50.73,201.6
X$23141 11048 219 320 14794 INV_X1
* cell instance $23143 r0 *1 51.49,201.6
X$23143 11229 7171 11312 219 320 11352 MUX2_X1
* cell instance $23144 r0 *1 52.82,201.6
X$23144 11229 7121 11313 219 320 11437 MUX2_X1
* cell instance $23145 r0 *1 54.15,201.6
X$23145 219 14628 11313 11437 11048 320 DFF_X1
* cell instance $23154 r0 *1 82.08,201.6
X$23154 219 7251 320 7591 BUF_X8
* cell instance $23160 r0 *1 99.18,201.6
X$23160 11050 219 320 11384 INV_X2
* cell instance $23163 m0 *1 109.06,201.6
X$23163 11010 219 320 14746 INV_X1
* cell instance $23164 m0 *1 108.11,201.6
X$23164 8697 219 320 11010 CLKBUF_X3
* cell instance $23167 m0 *1 111.53,201.6
X$23167 219 13363 11135 11314 11010 320 DFF_X1
* cell instance $23169 m0 *1 114.76,201.6
X$23169 219 13366 11055 11235 11010 320 DFF_X1
* cell instance $23173 m0 *1 121.98,201.6
X$23173 219 13422 11315 11356 11057 320 DFF_X1
* cell instance $23185 m0 *1 125.59,201.6
X$23185 11237 9154 11315 219 320 11356 MUX2_X1
* cell instance $23188 r0 *1 126.54,201.6
X$23188 11315 10940 11385 219 320 11442 MUX2_X1
* cell instance $23189 m0 *1 127.49,201.6
X$23189 11237 8821 11279 219 320 11278 MUX2_X1
* cell instance $23194 r0 *1 128.44,201.6
X$23194 219 14697 11358 11357 11057 320 DFF_X1
* cell instance $23195 m0 *1 129.39,201.6
X$23195 11237 8699 11358 219 320 11357 MUX2_X1
* cell instance $23198 m0 *1 132.43,201.6
X$23198 219 7575 10940 320 BUF_X16
* cell instance $23199 m0 *1 131.1,201.6
X$23199 11279 11387 11358 219 320 11316 MUX2_X1
* cell instance $23200 m0 *1 137.18,201.6
X$23200 11317 8821 11447 219 320 11360 MUX2_X1
* cell instance $23201 m0 *1 138.51,201.6
X$23201 11317 8699 11318 219 320 11282 MUX2_X1
* cell instance $23204 r0 *1 131.67,201.6
X$23204 11442 10749 11316 219 320 11363 MUX2_X1
* cell instance $23206 r0 *1 133.76,201.6
X$23206 219 13802 11447 11360 10967 320 DFF_X1
* cell instance $23207 r0 *1 136.99,201.6
X$23207 219 14376 11318 11282 11319 320 DFF_X1
* cell instance $23209 m0 *1 141.17,201.6
X$23209 11139 10002 219 320 11238 NOR2_X1
* cell instance $23211 m0 *1 141.74,201.6
X$23211 219 13081 11140 11238 11319 320 DFF_X1
* cell instance $23212 m0 *1 144.97,201.6
X$23212 11292 11142 11290 219 320 11289 MUX2_X1
* cell instance $23213 m0 *1 146.3,201.6
X$23213 11215 11292 11140 219 320 11367 OR3_X1
* cell instance $23214 m0 *1 147.25,201.6
X$23214 11143 10002 219 320 11213 NOR2_X1
* cell instance $23221 r0 *1 144.59,201.6
X$23221 11288 11142 219 320 11283 NAND2_X1
* cell instance $23226 m0 *1 151.24,201.6
X$23226 11366 320 9873 219 BUF_X4
* cell instance $23227 m0 *1 150.48,201.6
X$23227 11320 11158 320 219 11366 AND2_X1
* cell instance $23228 m0 *1 152.57,201.6
X$23228 9929 219 320 10464 CLKBUF_X3
* cell instance $23230 m0 *1 154.28,201.6
X$23230 11367 219 320 9787 CLKBUF_X3
* cell instance $23232 r0 *1 150.86,201.6
X$23232 11158 11320 219 320 9929 NAND2_X1
* cell instance $23235 r0 *1 152,201.6
X$23235 11320 10892 219 320 11389 OR2_X1
* cell instance $23239 r0 *1 154.85,201.6
X$23239 11321 11064 11322 219 11531 320 AOI21_X1
* cell instance $23240 m0 *1 156.37,201.6
X$23240 11455 9479 11373 219 320 11295 OR3_X1
* cell instance $23241 m0 *1 155.61,201.6
X$23241 10888 10945 11372 320 11322 219 OAI21_X1
* cell instance $23243 m0 *1 158.08,201.6
X$23243 11206 11375 219 320 11321 OR2_X1
* cell instance $23245 r0 *1 155.61,201.6
X$23245 11321 11455 11064 11322 11533 320 219 AOI211_X2
* cell instance $23246 r0 *1 157.32,201.6
X$23246 219 11390 11455 11391 9479 320 AOI21_X4
* cell instance $23247 m0 *1 159.41,201.6
X$23247 11392 219 320 10894 BUF_X2
* cell instance $23254 r0 *1 161.69,201.6
X$23254 219 11459 11460 11066 11323 320 DFF_X1
* cell instance $23255 m0 *1 163.02,201.6
X$23255 11299 219 320 11297 INV_X1
* cell instance $23257 m0 *1 163.4,201.6
X$23257 11296 11490 11154 11219 11297 11376 219 320 OAI221_X2
* cell instance $23259 m0 *1 165.68,201.6
X$23259 11167 11299 219 320 11462 NAND2_X1
* cell instance $23260 m0 *1 166.25,201.6
X$23260 11240 10762 10888 219 320 11394 NOR3_X1
* cell instance $23261 m0 *1 167.01,201.6
X$23261 10762 10712 10757 9787 219 320 11324 AOI22_X1
* cell instance $23262 m0 *1 167.96,201.6
X$23262 11035 10123 10689 219 10690 320 AOI21_X2
* cell instance $23263 m0 *1 169.29,201.6
X$23263 219 10757 11381 11069 11378 10474 320 OAI22_X4
* cell instance $23264 m0 *1 172.52,201.6
X$23264 10151 10260 10152 11241 320 11380 219 NOR4_X2
* cell instance $23265 m0 *1 174.23,201.6
X$23265 11326 219 320 11379 INV_X1
* cell instance $23266 m0 *1 174.61,201.6
X$23266 11301 11379 10451 219 11327 320 AOI21_X1
* cell instance $23267 m0 *1 175.37,201.6
X$23267 10474 10712 10260 11329 219 320 11300 AOI22_X1
* cell instance $23270 m0 *1 178.03,201.6
X$23270 10482 10153 219 320 11400 OR2_X1
* cell instance $23272 m0 *1 178.98,201.6
X$23272 11374 11242 10307 11074 11245 219 320 OAI211_X2
* cell instance $23273 m0 *1 180.69,201.6
X$23273 7105 219 320 11243 INV_X1
* cell instance $23274 m0 *1 181.07,201.6
X$23274 219 5632 11371 11369 11165 320 NOR3_X4
* cell instance $23276 r0 *1 164.92,201.6
X$23276 219 11240 11246 11373 11376 11462 10888 10430 320 AOI222_X2
* cell instance $23278 r0 *1 167.77,201.6
X$23278 11324 11395 219 320 11463 NAND2_X1
* cell instance $23279 r0 *1 168.34,201.6
X$23279 8381 10762 10757 10889 219 320 11464 NOR4_X1
* cell instance $23281 r0 *1 169.48,201.6
X$23281 11380 10977 11465 11325 11299 11370 320 219 AOI221_X2
* cell instance $23282 r0 *1 171.57,201.6
X$23282 219 11326 11473 10661 10483 320 DFF_X1
* cell instance $23283 r0 *1 174.8,201.6
X$23283 7330 11377 11327 219 320 11035 OR3_X2
* cell instance $23287 r0 *1 175.94,201.6
X$23287 11473 219 320 11241 BUF_X2
* cell instance $23289 r0 *1 177.08,201.6
X$23289 10696 9787 10591 11158 219 320 11475 AOI22_X1
* cell instance $23291 r0 *1 178.79,201.6
X$23291 11476 11475 219 320 11328 NAND2_X1
* cell instance $23293 r0 *1 179.74,201.6
X$23293 11328 10700 10451 219 11369 320 AOI21_X2
* cell instance $23295 r0 *1 181.45,201.6
X$23295 11368 10712 10482 11329 219 320 11476 AOI22_X1
* cell instance $23298 r0 *1 182.97,201.6
X$23298 11298 11402 11370 320 219 10907 AND3_X2
* cell instance $23300 m0 *1 185.82,201.6
X$23300 11163 11245 320 219 11362 AND2_X1
* cell instance $23301 m0 *1 184.11,201.6
X$23301 11368 11165 11331 11024 11298 219 320 OAI211_X2
* cell instance $23303 m0 *1 186.77,201.6
X$23303 11165 11331 11024 320 219 11365 OAI21_X4
* cell instance $23304 m0 *1 189.24,201.6
X$23304 219 11250 11333 11332 11361 320 DFF_X2
* cell instance $23305 m0 *1 192.85,201.6
X$23305 11361 219 320 11110 BUF_X1
* cell instance $23307 m0 *1 193.61,201.6
X$23307 11212 9745 219 320 11334 NOR2_X1
* cell instance $23310 r0 *1 184.3,201.6
X$23310 11330 219 320 11368 INV_X1
* cell instance $23312 r0 *1 184.87,201.6
X$23312 11245 11163 219 320 11479 NAND2_X1
* cell instance $23313 r0 *1 185.44,201.6
X$23313 11212 7105 219 320 11163 NAND2_X1
* cell instance $23314 r0 *1 186.01,201.6
X$23314 11362 11365 11247 219 320 11075 MUX2_X1
* cell instance $23315 r0 *1 187.34,201.6
X$23315 11477 11479 11403 219 320 11364 MUX2_X1
* cell instance $23316 r0 *1 188.67,201.6
X$23316 11165 11332 219 320 11248 NOR2_X1
* cell instance $23317 r0 *1 189.24,201.6
X$23317 11362 11332 219 320 11249 NAND2_X1
* cell instance $23318 r0 *1 189.81,201.6
X$23318 11110 11332 219 320 11477 NAND2_X1
* cell instance $23320 r0 *1 190.76,201.6
X$23320 11332 219 320 11331 INV_X2
* cell instance $23323 r0 *1 193.23,201.6
X$23323 219 14314 11336 11334 11333 320 DFF_X1
* cell instance $23324 m0 *1 196.27,201.6
X$23324 11335 11251 219 320 11246 OR2_X2
* cell instance $23325 m0 *1 195.32,201.6
X$23325 11251 11335 219 320 11212 NOR2_X2
* cell instance $23327 m0 *1 197.41,201.6
X$23327 11293 11337 11253 320 219 11335 AND3_X1
* cell instance $23328 m0 *1 198.36,201.6
X$23328 219 13133 11285 11359 11254 320 DFF_X1
* cell instance $23329 m0 *1 201.59,201.6
X$23329 11285 11456 219 320 11286 XOR2_X1
* cell instance $23331 m0 *1 204.25,201.6
X$23331 11338 10326 219 320 11457 NOR2_X1
* cell instance $23333 m0 *1 205.58,201.6
X$23333 11417 10986 9677 219 11338 320 AOI21_X1
* cell instance $23337 m0 *1 213.37,201.6
X$23337 11354 10064 219 320 11355 NOR2_X1
* cell instance $23338 m0 *1 213.94,201.6
X$23338 219 13453 11341 11355 11004 320 DFF_X1
* cell instance $23339 m0 *1 217.17,201.6
X$23339 11341 11170 11343 320 11354 219 OAI21_X1
* cell instance $23341 m0 *1 220.97,201.6
X$23341 11353 11276 10377 320 219 8192 MUX2_X2
* cell instance $23344 m0 *1 223.63,201.6
X$23344 11258 10069 11344 219 320 11353 MUX2_X1
* cell instance $23345 m0 *1 224.96,201.6
X$23345 10828 6311 11344 219 320 11259 MUX2_X1
* cell instance $23346 m0 *1 226.29,201.6
X$23346 11171 219 320 CLKBUF_X1
* cell instance $23348 m0 *1 228.38,201.6
X$23348 219 13575 11270 11260 11171 320 DFF_X1
* cell instance $23349 m0 *1 231.61,201.6
X$23349 10379 6101 11345 219 320 11440 MUX2_X1
* cell instance $23351 m0 *1 233.7,201.6
X$23351 11424 5995 11439 219 320 11351 MUX2_X1
* cell instance $23352 m0 *1 235.03,201.6
X$23352 9755 219 320 11348 BUF_X1
* cell instance $23354 m0 *1 235.79,201.6
X$23354 10199 219 320 10914 BUF_X1
* cell instance $23356 m0 *1 236.55,201.6
X$23356 11084 219 320 CLKBUF_X1
* cell instance $23357 m0 *1 237.12,201.6
X$23357 11263 219 320 7752 BUF_X1
* cell instance $23358 m0 *1 237.69,201.6
X$23358 8774 219 320 11262 BUF_X1
* cell instance $23359 m0 *1 238.26,201.6
X$23359 10911 219 320 11347 BUF_X1
* cell instance $23361 m0 *1 239.02,201.6
X$23361 8536 219 320 11177 BUF_X1
* cell instance $23362 m0 *1 239.59,201.6
X$23362 10371 219 320 11087 BUF_X1
* cell instance $23363 m0 *1 240.16,201.6
X$23363 10192 219 320 11176 BUF_X1
* cell instance $23365 r0 *1 196.46,201.6
X$23365 11336 11466 11406 219 320 11251 MUX2_X1
* cell instance $23368 r0 *1 199.5,201.6
X$23368 11408 11293 9386 219 320 11410 NOR3_X1
* cell instance $23372 r0 *1 202.92,201.6
X$23372 11413 10986 9732 219 11412 320 AOI21_X1
* cell instance $23373 r0 *1 203.68,201.6
X$23373 219 14516 11415 11457 11014 320 DFF_X1
* cell instance $23376 r0 *1 208.62,201.6
X$23376 10907 10064 219 320 11419 NOR2_X1
* cell instance $23378 r0 *1 209.95,201.6
X$23378 219 11451 11339 11452 11004 320 DFF_X1
* cell instance $23379 r0 *1 213.18,201.6
X$23379 11339 11170 11451 219 320 11420 MUX2_X1
* cell instance $23381 r0 *1 214.89,201.6
X$23381 219 13789 11421 11448 11342 320 DFF_X1
* cell instance $23385 r0 *1 224.77,201.6
X$23385 219 14180 11344 11259 11171 320 DFF_X1
* cell instance $23387 r0 *1 229.52,201.6
X$23387 219 14661 11510 11423 11171 320 DFF_X1
* cell instance $23391 r0 *1 232.75,201.6
X$23391 219 13872 11345 11440 11084 320 DFF_X1
* cell instance $23392 r0 *1 235.98,201.6
X$23392 11424 6101 11425 219 320 11438 MUX2_X1
* cell instance $23393 r0 *1 237.31,201.6
X$23393 9447 219 320 11084 CLKBUF_X3
* cell instance $23395 r0 *1 238.64,201.6
X$23395 11424 6087 11346 219 320 11518 MUX2_X1
* cell instance $23396 r0 *1 239.97,201.6
X$23396 11427 219 320 6741 BUF_X2
* cell instance $23420 m0 *1 121.79,210
X$23420 7251 320 10892 219 BUF_X4
* cell instance $23421 m0 *1 123.12,210
X$23421 7596 320 10642 219 BUF_X4
* cell instance $23422 m0 *1 124.45,210
X$23422 219 13115 11624 11670 11546 320 DFF_X1
* cell instance $23423 m0 *1 127.68,210
X$23423 11545 10940 11624 219 320 11547 MUX2_X1
* cell instance $23425 m0 *1 132.05,210
X$23425 219 13132 11732 11730 11546 320 DFF_X1
* cell instance $23426 m0 *1 135.28,210
X$23426 11690 7612 11625 219 320 11672 MUX2_X1
* cell instance $23428 m0 *1 136.8,210
X$23428 11836 7251 219 320 10241 NOR2_X2
* cell instance $23429 m0 *1 137.75,210
X$23429 219 13100 11628 11626 11806 320 DFF_X1
* cell instance $23430 m0 *1 140.98,210
X$23430 11628 11387 11629 219 320 11630 MUX2_X1
* cell instance $23448 r0 *1 53.01,210
X$23448 11724 219 320 10341 CLKBUF_X2
* cell instance $23473 r0 *1 125.78,210
X$23473 11593 8038 11548 219 320 11727 MUX2_X1
* cell instance $23474 r0 *1 127.11,210
X$23474 11593 7612 11624 219 320 11670 MUX2_X1
* cell instance $23476 r0 *1 128.82,210
X$23476 9425 219 320 11546 CLKBUF_X3
* cell instance $23477 r0 *1 129.77,210
X$23477 11546 219 320 14771 INV_X1
* cell instance $23480 r0 *1 133.38,210
X$23480 11690 7691 11732 219 320 11730 MUX2_X1
* cell instance $23483 r0 *1 135.28,210
X$23483 11732 10940 11625 219 320 11733 MUX2_X1
* cell instance $23486 r0 *1 138.32,210
X$23486 11690 8038 11628 219 320 11626 MUX2_X1
* cell instance $23487 r0 *1 139.65,210
X$23487 11690 8040 11629 219 320 11627 MUX2_X1
* cell instance $23488 r0 *1 140.98,210
X$23488 11733 11630 10749 320 219 9678 MUX2_X2
* cell instance $23491 r0 *1 143.26,210
X$23491 219 14355 11633 11734 11319 320 DFF_X1
* cell instance $23492 m0 *1 143.64,210
X$23492 219 13098 11631 11553 11319 320 DFF_X1
* cell instance $23494 m0 *1 146.87,210
X$23494 11631 11692 320 219 11632 XNOR2_X1
* cell instance $23495 m0 *1 148.01,210
X$23495 11634 11631 11633 219 320 11483 NOR3_X1
* cell instance $23497 r0 *1 146.49,210
X$23497 9678 10464 219 320 11691 NOR2_X1
* cell instance $23499 r0 *1 147.44,210
X$23499 11693 11633 11749 219 320 11692 NOR3_X1
* cell instance $23500 r0 *1 148.2,210
X$23500 11551 11550 219 320 11734 NOR2_X1
* cell instance $23503 m0 *1 149.15,210
X$23503 11633 11634 219 320 11676 XOR2_X1
* cell instance $23504 m0 *1 151.05,210
X$23504 11605 11635 9745 219 320 11677 NOR3_X1
* cell instance $23505 m0 *1 151.81,210
X$23505 11678 10464 11636 219 11635 320 AOI21_X1
* cell instance $23507 r0 *1 151.81,210
X$23507 11635 11550 219 320 11694 NOR2_X1
* cell instance $23508 r0 *1 152.38,210
X$23508 11739 11789 219 320 11636 XOR2_X1
* cell instance $23509 m0 *1 156.18,210
X$23509 11154 11550 219 320 11741 NOR2_X1
* cell instance $23510 m0 *1 152.95,210
X$23510 219 12574 11681 11677 11323 320 DFF_X1
* cell instance $23511 m0 *1 156.75,210
X$23511 11638 11739 11681 219 320 11555 MUX2_X1
* cell instance $23517 r0 *1 154.09,210
X$23517 219 14135 11638 11741 11790 320 DFF_X1
* cell instance $23520 r0 *1 158.27,210
X$23520 11116 320 9745 219 BUF_X4
* cell instance $23521 r0 *1 159.6,210
X$23521 10892 320 11116 219 BUF_X4
* cell instance $23523 r0 *1 162.45,210
X$23523 7596 320 10496 219 BUF_X4
* cell instance $23525 m0 *1 163.02,210
X$23525 11639 320 4596 219 BUF_X4
* cell instance $23527 m0 *1 165.3,210
X$23527 11561 11642 11641 219 320 11640 NAND3_X1
* cell instance $23528 m0 *1 166.06,210
X$23528 11641 11642 320 219 11687 AND2_X1
* cell instance $23532 r0 *1 167.01,210
X$23532 11493 7596 11644 11643 10543 11743 320 219 AOI221_X2
* cell instance $23534 m0 *1 167.2,210
X$23534 219 11644 11493 11643 11543 11560 320 NOR4_X4
* cell instance $23536 r0 *1 170.62,210
X$23536 11643 219 320 11697 INV_X1
* cell instance $23537 r0 *1 171,210
X$23537 11493 10712 11543 11329 219 320 11698 AOI22_X1
* cell instance $23539 m0 *1 171,210
X$23539 11644 320 7944 219 BUF_X4
* cell instance $23540 m0 *1 173.09,210
X$23540 6685 11561 11696 219 320 11646 NAND3_X2
* cell instance $23543 r0 *1 171.95,210
X$23543 11698 11700 219 320 11699 NAND2_X1
* cell instance $23545 r0 *1 172.9,210
X$23545 11752 9787 11644 11158 219 320 11700 AOI22_X1
* cell instance $23552 m0 *1 175.56,210
X$23552 11643 11493 11646 11563 11538 11688 219 320 11689 OAI33_X1
* cell instance $23553 m0 *1 177.08,210
X$23553 11496 11647 219 320 11621 NOR2_X1
* cell instance $23555 m0 *1 179.17,210
X$23555 11689 11401 11648 219 320 NOR2_X4
* cell instance $23557 m0 *1 181.07,210
X$23557 11496 320 6835 219 BUF_X4
* cell instance $23560 r0 *1 175.94,210
X$23560 11492 11329 11645 9787 219 320 11701 AOI22_X1
* cell instance $23561 r0 *1 176.89,210
X$23561 11538 10712 11647 11158 219 320 11801 AOI22_X1
* cell instance $23562 r0 *1 177.84,210
X$23562 219 11703 11748 11746 11702 320 DFF_X1
* cell instance $23563 r0 *1 181.07,210
X$23563 11748 219 320 11496 CLKBUF_X3
* cell instance $23565 r0 *1 182.21,210
X$23565 11570 7949 10314 219 11800 320 AOI21_X1
* cell instance $23566 m0 *1 183.35,210
X$23566 11566 11651 219 320 11649 NOR2_X1
* cell instance $23567 m0 *1 182.78,210
X$23567 11565 10054 219 320 11654 NAND2_X1
* cell instance $23568 m0 *1 183.92,210
X$23568 11565 6835 219 320 11650 NOR2_X1
* cell instance $23569 m0 *1 184.49,210
X$23569 11686 11685 10654 11651 11652 11747 320 219 AOI221_X2
* cell instance $23570 m0 *1 186.58,210
X$23570 11015 7596 219 320 11652 NAND2_X2
* cell instance $23571 m0 *1 187.53,210
X$23571 10892 11684 11654 219 11653 320 AOI21_X1
* cell instance $23572 m0 *1 188.29,210
X$23572 11683 11652 11569 320 11682 219 OAI21_X1
* cell instance $23573 m0 *1 189.05,210
X$23573 11742 11655 11570 320 11679 219 OAI21_X1
* cell instance $23576 r0 *1 183.35,210
X$23576 11744 11747 11761 11649 320 11706 219 NOR4_X2
* cell instance $23578 r0 *1 185.44,210
X$23578 11480 320 11651 219 BUF_X4
* cell instance $23579 r0 *1 186.77,210
X$23579 11538 11015 11647 219 11745 320 AOI21_X2
* cell instance $23580 r0 *1 188.1,210
X$23580 11654 11652 11763 219 320 11744 NOR3_X1
* cell instance $23581 r0 *1 188.86,210
X$23581 11650 11652 11571 219 320 11742 NOR3_X1
* cell instance $23583 r0 *1 190,210
X$23583 11572 11079 219 320 11763 NOR2_X2
* cell instance $23585 m0 *1 190.19,210
X$23585 11079 11679 11572 11656 10693 11570 219 320 11498 OAI33_X1
* cell instance $23588 r0 *1 190.95,210
X$23588 11492 219 320 11656 INV_X1
* cell instance $23591 r0 *1 193.61,210
X$23591 11613 11648 11657 219 320 11708 MUX2_X1
* cell instance $23592 m0 *1 194.94,210
X$23592 11329 11658 219 10707 320 NAND2_X4
* cell instance $23593 m0 *1 194.18,210
X$23593 11658 10664 219 320 11657 OR2_X1
* cell instance $23595 r0 *1 194.94,210
X$23595 11658 11329 320 219 11709 AND2_X1
* cell instance $23596 r0 *1 195.7,210
X$23596 11709 320 10986 219 BUF_X4
* cell instance $23597 m0 *1 197.22,210
X$23597 219 11737 11675 11573 11254 320 DFF_X1
* cell instance $23599 m0 *1 200.45,210
X$23599 11466 11711 11712 219 320 11674 OR3_X1
* cell instance $23600 m0 *1 201.4,210
X$23600 11500 11659 11674 219 11468 320 AOI21_X1
* cell instance $23605 r0 *1 198.36,210
X$23605 11740 10986 8192 219 11710 320 AOI21_X1
* cell instance $23606 r0 *1 199.12,210
X$23606 11466 11771 11770 11329 11658 219 320 11740 AOI221_X1
* cell instance $23609 r0 *1 201.4,210
X$23609 11466 219 320 11738 INV_X1
* cell instance $23610 r0 *1 201.78,210
X$23610 11738 11675 11711 11712 219 320 11660 OR4_X1
* cell instance $23611 m0 *1 203.68,210
X$23611 9826 11079 219 320 11713 NOR2_X1
* cell instance $23612 m0 *1 202.54,210
X$23612 11661 11660 320 219 11500 XNOR2_X1
* cell instance $23618 r0 *1 203.3,210
X$23618 11712 11661 11735 219 320 11501 OR3_X1
* cell instance $23619 r0 *1 204.25,210
X$23619 11712 11735 320 219 11714 XNOR2_X1
* cell instance $23620 r0 *1 205.39,210
X$23620 11714 10986 219 320 11783 NOR2_X1
* cell instance $23625 r0 *1 208.81,210
X$23625 11731 10326 219 320 11782 NOR2_X1
* cell instance $23627 r0 *1 209.76,210
X$23627 11715 11648 12543 320 219 11577 HA_X1
* cell instance $23628 m0 *1 210.52,210
X$23628 7866 11648 11662 320 219 11576 HA_X1
* cell instance $23629 m0 *1 209.95,210
X$23629 11715 219 320 7866 INV_X2
* cell instance $23632 m0 *1 213.37,210
X$23632 219 13451 11671 11728 11342 320 DFF_X1
* cell instance $23635 m0 *1 224.2,210
X$23635 11664 10507 11578 219 320 11509 MUX2_X1
* cell instance $23636 m0 *1 225.53,210
X$23636 11422 6087 11664 219 320 11725 MUX2_X1
* cell instance $23639 r0 *1 211.66,210
X$23639 11577 11729 320 219 11716 XNOR2_X1
* cell instance $23640 r0 *1 212.8,210
X$23640 219 11671 11729 11717 11663 11774 320 FA_X1
* cell instance $23642 r0 *1 216.22,210
X$23642 3243 11726 320 219 11718 AND2_X1
* cell instance $23643 r0 *1 216.98,210
X$23643 11774 11662 11779 219 320 11726 MUX2_X1
* cell instance $23648 r0 *1 222.68,210
X$23648 219 13645 11664 11725 11579 320 DFF_X1
* cell instance $23652 r0 *1 230.09,210
X$23652 219 14560 11665 11719 11579 320 DFF_X1
* cell instance $23654 m0 *1 230.28,210
X$23654 11580 6087 11665 219 320 11719 MUX2_X1
* cell instance $23658 m0 *1 232.18,210
X$23658 9811 219 320 11666 BUF_X1
* cell instance $23664 r0 *1 233.89,210
X$23664 8338 219 320 11721 BUF_X1
* cell instance $23666 m0 *1 236.36,210
X$23666 9281 219 320 11668 BUF_X1
* cell instance $23668 m0 *1 236.93,210
X$23668 9759 219 320 11514 BUF_X1
* cell instance $23669 m0 *1 237.5,210
X$23669 8438 219 320 11585 BUF_X1
* cell instance $23670 m0 *1 238.07,210
X$23670 9072 219 320 11722 BUF_X1
* cell instance $23672 r0 *1 237.5,210
X$23672 9601 219 320 11723 BUF_X1
* cell instance $23674 m0 *1 239.59,210
X$23674 8779 219 320 11426 BUF_X1
* cell instance $23675 m0 *1 239.02,210
X$23675 7328 219 320 11667 BUF_X1
* cell instance $23676 m0 *1 240.16,210
X$23676 11584 219 320 11424 BUF_X1
* cell instance $23686 m0 *1 16.72,207.2
X$23686 11623 219 320 11183 BUF_X1
* cell instance $23699 m0 *1 28.12,207.2
X$23699 219 13249 11588 11587 11305 320 DFF_X1
* cell instance $23700 m0 *1 26.79,207.2
X$23700 11183 7121 11588 219 320 11587 MUX2_X1
* cell instance $23706 r0 *1 27.93,207.2
X$23706 11586 219 320 11227 BUF_X1
* cell instance $23712 m0 *1 38.57,207.2
X$23712 11227 7121 11590 219 320 11589 MUX2_X1
* cell instance $23724 r0 *1 38.95,207.2
X$23724 219 14693 11590 11589 11305 320 DFF_X1
* cell instance $23737 m0 *1 93.67,207.2
X$23737 219 11482 11521 11910 11010 320 DFF_X1
* cell instance $23745 m0 *1 123.5,207.2
X$23745 11593 7691 11545 219 320 11591 MUX2_X1
* cell instance $23747 m0 *1 125.02,207.2
X$23747 219 13109 11523 11594 11057 320 DFF_X1
* cell instance $23749 m0 *1 128.44,207.2
X$23749 11548 10940 11523 219 320 11595 MUX2_X1
* cell instance $23751 m0 *1 129.96,207.2
X$23751 11547 11595 8284 320 219 9680 MUX2_X2
* cell instance $23766 r0 *1 121.79,207.2
X$23766 219 14048 11545 11591 11546 320 DFF_X1
* cell instance $23770 r0 *1 126.16,207.2
X$23770 219 14648 11548 11727 11546 320 DFF_X1
* cell instance $23775 r0 *1 132.24,207.2
X$23775 10051 219 320 11387 CLKBUF_X3
* cell instance $23778 r0 *1 134.14,207.2
X$23778 219 13852 11625 11672 11546 320 DFF_X1
* cell instance $23781 r0 *1 138.51,207.2
X$23781 219 14372 11629 11627 11319 320 DFF_X1
* cell instance $23785 m0 *1 143.45,207.2
X$23785 9425 219 320 11319 CLKBUF_X3
* cell instance $23788 m0 *1 146.87,207.2
X$23788 11600 11483 320 219 11527 XNOR2_X1
* cell instance $23790 m0 *1 148.2,207.2
X$23790 11602 9873 9571 219 11552 320 AOI21_X1
* cell instance $23791 m0 *1 148.96,207.2
X$23791 11552 11550 219 320 11553 NOR2_X1
* cell instance $23793 r0 *1 144.02,207.2
X$23793 219 14357 11600 11549 11319 320 DFF_X1
* cell instance $23794 r0 *1 147.25,207.2
X$23794 11484 11550 219 320 11549 NOR2_X1
* cell instance $23795 r0 *1 147.82,207.2
X$23795 11632 9873 219 320 11602 NOR2_X1
* cell instance $23796 r0 *1 148.39,207.2
X$23796 11551 11552 11484 11736 219 320 11605 NAND4_X1
* cell instance $23797 r0 *1 149.34,207.2
X$23797 11554 9873 9680 219 11551 320 AOI21_X1
* cell instance $23798 m0 *1 150.86,207.2
X$23798 11116 320 7820 219 BUF_X4
* cell instance $23799 m0 *1 149.91,207.2
X$23799 11486 11487 11488 320 219 11556 AND3_X1
* cell instance $23803 m0 *1 159.98,207.2
X$23803 11323 219 320 CLKBUF_X1
* cell instance $23807 r0 *1 150.1,207.2
X$23807 11676 9873 219 320 11554 NOR2_X1
* cell instance $23808 r0 *1 150.67,207.2
X$23808 11485 10464 11636 219 320 11637 MUX2_X1
* cell instance $23809 r0 *1 152,207.2
X$23809 11605 11637 10642 320 11604 219 OAI21_X1
* cell instance $23811 r0 *1 152.95,207.2
X$23811 7201 10464 219 320 11678 NOR2_X1
* cell instance $23815 r0 *1 157.13,207.2
X$23815 11556 11555 11154 219 320 NOR2_X4
* cell instance $23817 r0 *1 159.03,207.2
X$23817 11555 11556 219 320 11559 OR2_X1
* cell instance $23818 r0 *1 159.79,207.2
X$23818 9383 219 320 11323 CLKBUF_X3
* cell instance $23819 r0 *1 160.74,207.2
X$23819 219 14171 11557 11608 11323 320 DFF_X1
* cell instance $23820 m0 *1 163.4,207.2
X$23820 11557 9556 11489 219 320 11558 MUX2_X1
* cell instance $23823 m0 *1 164.92,207.2
X$23823 9749 11558 219 320 11490 NOR2_X2
* cell instance $23825 m0 *1 166.06,207.2
X$23825 11558 9749 219 320 11216 OR2_X2
* cell instance $23828 m0 *1 169.29,207.2
X$23828 11482 219 320 10849 CLKBUF_X2
* cell instance $23832 r0 *1 164.16,207.2
X$23832 11490 10326 219 320 11608 NOR2_X1
* cell instance $23835 r0 *1 165.87,207.2
X$23835 11490 11560 219 320 11642 NAND2_X1
* cell instance $23837 r0 *1 167.2,207.2
X$23837 11560 11644 11559 219 11610 320 AOI21_X1
* cell instance $23838 r0 *1 167.96,207.2
X$23838 11611 11610 10307 11697 11641 219 320 OAI211_X2
* cell instance $23839 r0 *1 169.67,207.2
X$23839 4596 11560 320 219 7469 AND2_X2
* cell instance $23841 r0 *1 170.81,207.2
X$23841 219 11561 11560 11612 10977 11156 11645 11562 320 AOI222_X2
* cell instance $23843 m0 *1 171.19,207.2
X$23843 11467 219 320 11325 BUF_X1
* cell instance $23844 m0 *1 173.85,207.2
X$23844 11491 219 320 11397 INV_X1
* cell instance $23845 m0 *1 172.14,207.2
X$23845 11543 11246 11161 11493 219 320 11611 AOI22_X2
* cell instance $23849 r0 *1 173.85,207.2
X$23849 11644 11561 11495 11562 219 320 11491 AOI22_X1
* cell instance $23854 r0 *1 175.18,207.2
X$23854 11495 11538 11161 219 11617 320 AOI21_X1
* cell instance $23855 m0 *1 175.94,207.2
X$23855 219 11618 11616 11620 11154 11495 320 AOI22_X4
* cell instance $23856 m0 *1 175.37,207.2
X$23856 10430 11563 219 320 11616 NAND2_X1
* cell instance $23859 r0 *1 176.32,207.2
X$23859 11494 11617 320 219 11618 AND2_X1
* cell instance $23860 r0 *1 177.08,207.2
X$23860 11621 11562 219 320 11688 NAND2_X2
* cell instance $23862 r0 *1 178.22,207.2
X$23862 219 11563 11492 11538 11496 11495 320 NOR4_X4
* cell instance $23863 m0 *1 179.74,207.2
X$23863 7462 11495 320 219 11564 AND2_X1
* cell instance $23865 m0 *1 180.5,207.2
X$23865 219 3866 320 11564 BUF_X8
* cell instance $23866 m0 *1 182.97,207.2
X$23866 11563 9384 320 219 11565 AND2_X1
* cell instance $23868 m0 *1 185.25,207.2
X$23868 9384 11492 219 320 11567 NAND2_X1
* cell instance $23870 r0 *1 181.64,207.2
X$23870 11621 11562 11622 219 320 11402 NAND3_X1
* cell instance $23871 r0 *1 182.4,207.2
X$23871 11492 11563 219 320 11622 NOR2_X1
* cell instance $23872 r0 *1 182.97,207.2
X$23872 6835 11565 10849 219 11566 320 AOI21_X1
* cell instance $23874 r0 *1 183.92,207.2
X$23874 10849 11538 219 320 11569 NAND2_X1
* cell instance $23877 r0 *1 185.06,207.2
X$23877 11572 10054 11496 219 320 11686 NAND3_X1
* cell instance $23878 r0 *1 185.82,207.2
X$23878 11567 11615 320 219 11685 AND2_X1
* cell instance $23879 m0 *1 186.96,207.2
X$23879 11651 7949 219 320 11683 NAND2_X1
* cell instance $23880 m0 *1 186.2,207.2
X$23880 11567 10654 3280 320 11619 219 OAI21_X1
* cell instance $23881 m0 *1 187.53,207.2
X$23881 10054 10707 11496 219 320 11615 NAND3_X1
* cell instance $23886 r0 *1 186.58,207.2
X$23886 11647 219 320 11684 INV_X1
* cell instance $23888 r0 *1 187.34,207.2
X$23888 11653 11619 11680 219 11568 320 AOI21_X1
* cell instance $23889 r0 *1 188.1,207.2
X$23889 11614 11568 11570 11569 320 219 11497 OAI22_X1
* cell instance $23890 r0 *1 189.05,207.2
X$23890 10641 11570 219 320 11614 NAND2_X1
* cell instance $23891 r0 *1 189.62,207.2
X$23891 11571 10693 219 320 11680 NOR2_X1
* cell instance $23893 r0 *1 190.57,207.2
X$23893 6835 320 7949 219 BUF_X4
* cell instance $23897 r0 *1 194.37,207.2
X$23897 10664 11529 219 320 11613 OR2_X1
* cell instance $23900 r0 *1 196.27,207.2
X$23900 10707 320 11079 219 BUF_X4
* cell instance $23901 m0 *1 197.79,207.2
X$23901 11573 219 320 11528 INV_X1
* cell instance $23902 m0 *1 197.03,207.2
X$23902 10496 11499 320 219 11573 AND2_X1
* cell instance $23903 m0 *1 198.17,207.2
X$23903 11252 11079 11609 219 320 11499 MUX2_X1
* cell instance $23906 m0 *1 202.73,207.2
X$23906 11500 10986 219 320 11574 NOR2_X1
* cell instance $23907 m0 *1 203.3,207.2
X$23907 9825 11079 219 320 11607 NOR2_X1
* cell instance $23909 m0 *1 204.63,207.2
X$23909 11502 11415 11418 219 320 11456 NOR3_X1
* cell instance $23911 m0 *1 206.15,207.2
X$23911 11418 11502 219 320 11504 XOR2_X1
* cell instance $23914 m0 *1 214.13,207.2
X$23914 3243 11522 320 219 11603 AND2_X1
* cell instance $23915 m0 *1 214.89,207.2
X$23915 219 11507 11506 11603 11342 320 DFF_X1
* cell instance $23919 m0 *1 220.59,207.2
X$23919 219 13586 11599 11601 11342 320 DFF_X1
* cell instance $23920 m0 *1 223.82,207.2
X$23920 11422 5995 11599 219 320 11601 MUX2_X1
* cell instance $23921 m0 *1 225.15,207.2
X$23921 11509 11508 10377 320 219 9826 MUX2_X2
* cell instance $23923 m0 *1 227.62,207.2
X$23923 219 13570 11597 11596 11171 320 DFF_X1
* cell instance $23924 m0 *1 230.85,207.2
X$23924 11580 5995 11597 219 320 11596 MUX2_X1
* cell instance $23925 m0 *1 232.18,207.2
X$23925 11581 11511 10377 320 219 11252 MUX2_X2
* cell instance $23926 m0 *1 233.89,207.2
X$23926 10383 219 320 11515 BUF_X1
* cell instance $23931 r0 *1 198.93,207.2
X$23931 11466 11675 219 320 11609 XOR2_X1
* cell instance $23932 r0 *1 200.07,207.2
X$23932 219 14296 11661 11606 11254 320 DFF_X1
* cell instance $23933 r0 *1 203.3,207.2
X$23933 11574 11607 9386 219 320 11606 NOR3_X1
* cell instance $23934 r0 *1 204.06,207.2
X$23934 11661 11411 11660 219 320 11502 OR3_X1
* cell instance $23939 r0 *1 210.71,207.2
X$23939 11648 219 320 11673 INV_X1
* cell instance $23940 r0 *1 211.09,207.2
X$23940 7866 11673 12546 320 219 11575 HA_X1
* cell instance $23941 r0 *1 212.99,207.2
X$23941 11576 11575 219 320 7418 NOR2_X2
* cell instance $23942 r0 *1 213.94,207.2
X$23942 11577 219 320 11663 INV_X1
* cell instance $23943 r0 *1 214.32,207.2
X$23943 11577 11576 219 320 11505 NOR2_X1
* cell instance $23946 r0 *1 218.31,207.2
X$23946 9447 219 320 11342 CLKBUF_X3
* cell instance $23947 r0 *1 219.26,207.2
X$23947 11342 219 320 14785 INV_X1
* cell instance $23950 r0 *1 221.54,207.2
X$23950 219 13667 11578 11598 11579 320 DFF_X1
* cell instance $23951 r0 *1 224.77,207.2
X$23951 11422 6311 11578 219 320 11598 MUX2_X1
* cell instance $23955 r0 *1 228.76,207.2
X$23955 219 14663 11582 11669 11579 320 DFF_X1
* cell instance $23959 r0 *1 231.99,207.2
X$23959 11665 10820 11582 219 320 11581 MUX2_X1
* cell instance $23961 r0 *1 233.51,207.2
X$23961 11580 6311 11582 219 320 11669 MUX2_X1
* cell instance $23963 m0 *1 236.55,207.2
X$23963 219 13578 11512 11513 11084 320 DFF_X1
* cell instance $23964 m0 *1 234.84,207.2
X$23964 11520 11592 10377 320 219 9825 MUX2_X2
* cell instance $23966 r0 *1 235.03,207.2
X$23966 11439 10820 11425 219 320 11592 MUX2_X1
* cell instance $23968 r0 *1 236.55,207.2
X$23968 11424 6311 11512 219 320 11513 MUX2_X1
* cell instance $23969 r0 *1 237.88,207.2
X$23969 9100 219 320 11428 BUF_X1
* cell instance $23970 r0 *1 238.45,207.2
X$23970 11516 219 320 9189 BUF_X1
* cell instance $23971 r0 *1 239.02,207.2
X$23971 11583 219 320 9448 BUF_X1
* cell instance $23973 r0 *1 239.78,207.2
X$23973 10389 219 320 11429 BUF_X1
* cell instance $23975 m0 *1 240.16,207.2
X$23975 10021 219 320 11261 BUF_X1
* cell instance $23983 m0 *1 22.04,204.4
X$23983 219 13274 11304 11430 11038 320 DFF_X1
* cell instance $23984 m0 *1 25.27,204.4
X$23984 11183 7232 11304 219 320 11430 MUX2_X1
* cell instance $23985 m0 *1 26.6,204.4
X$23985 219 13572 11382 11432 11305 320 DFF_X1
* cell instance $24000 r0 *1 26.22,204.4
X$24000 11183 7171 11382 219 320 11432 MUX2_X1
* cell instance $24003 r0 *1 29.83,204.4
X$24003 11382 8788 11588 219 320 11226 MUX2_X1
* cell instance $24005 r0 *1 34.2,204.4
X$24005 11305 219 320 14718 INV_X2
* cell instance $24006 r0 *1 34.77,204.4
X$24006 9405 219 320 11305 CLKBUF_X3
* cell instance $24007 m0 *1 35.72,204.4
X$24007 11227 7232 11383 219 320 11433 MUX2_X1
* cell instance $24012 r0 *1 35.72,204.4
X$24012 11227 7171 11481 219 320 11517 MUX2_X1
* cell instance $24013 r0 *1 37.05,204.4
X$24013 219 14557 11481 11517 11305 320 DFF_X1
* cell instance $24014 r0 *1 40.28,204.4
X$24014 11481 8788 11590 219 320 11434 MUX2_X1
* cell instance $24016 m0 *1 45.22,204.4
X$24016 11229 7232 11436 219 320 11435 MUX2_X1
* cell instance $24018 m0 *1 46.55,204.4
X$24018 219 12929 11436 11435 11048 320 DFF_X1
* cell instance $24037 r0 *1 52.44,204.4
X$24037 11519 219 320 11229 BUF_X1
* cell instance $24048 r0 *1 85.12,204.4
X$24048 11521 219 320 7591 CLKBUF_X3
* cell instance $24062 r0 *1 125.21,204.4
X$24062 11593 8040 11523 219 320 11594 MUX2_X1
* cell instance $24063 m0 *1 125.59,204.4
X$24063 11237 9157 11385 219 320 11441 MUX2_X1
* cell instance $24065 m0 *1 126.92,204.4
X$24065 219 13108 11385 11441 11057 320 DFF_X1
* cell instance $24068 m0 *1 132.43,204.4
X$24068 219 13038 11386 11443 10967 320 DFF_X1
* cell instance $24069 m0 *1 135.66,204.4
X$24069 219 12928 11388 11444 10967 320 DFF_X1
* cell instance $24070 m0 *1 138.89,204.4
X$24070 11447 11387 11318 219 320 11525 MUX2_X1
* cell instance $24077 r0 *1 131.48,204.4
X$24077 10749 320 8284 219 BUF_X4
* cell instance $24079 r0 *1 133.19,204.4
X$24079 11317 9154 11386 219 320 11443 MUX2_X1
* cell instance $24081 r0 *1 135.28,204.4
X$24081 11317 9157 11388 219 320 11444 MUX2_X1
* cell instance $24083 r0 *1 137.37,204.4
X$24083 11386 11387 11388 219 320 11524 MUX2_X1
* cell instance $24085 r0 *1 139.46,204.4
X$24085 11524 11525 10749 320 219 9571 MUX2_X2
* cell instance $24090 r0 *1 146.68,204.4
X$24090 7782 10464 11527 219 320 11484 MUX2_X1
* cell instance $24092 m0 *1 147.44,204.4
X$24092 11363 219 320 7782 INV_X2
* cell instance $24094 m0 *1 150.29,204.4
X$24094 219 13076 11320 11453 10975 320 DFF_X1
* cell instance $24096 m0 *1 154.28,204.4
X$24096 219 11454 11323 11391 11372 320 DFF_X2
* cell instance $24098 r0 *1 148.01,204.4
X$24098 9828 9680 219 320 11487 NOR2_X1
* cell instance $24100 r0 *1 148.96,204.4
X$24100 11363 8194 11485 9571 219 320 11488 NOR4_X1
* cell instance $24103 r0 *1 150.48,204.4
X$24103 9678 9998 9929 219 320 11486 NOR3_X1
* cell instance $24104 r0 *1 151.24,204.4
X$24104 11485 219 320 7201 INV_X2
* cell instance $24106 r0 *1 152,204.4
X$24106 11604 11471 11389 219 320 11453 MUX2_X1
* cell instance $24109 r0 *1 155.61,204.4
X$24109 11531 11530 11534 11533 11532 320 219 11454 OAI221_X1
* cell instance $24110 r0 *1 156.75,204.4
X$24110 11372 11239 11535 219 320 11530 OR3_X1
* cell instance $24111 r0 *1 157.7,204.4
X$24111 7596 11391 219 320 11535 NAND2_X1
* cell instance $24112 m0 *1 158.46,204.4
X$24112 11372 11390 11373 219 320 11392 MUX2_X1
* cell instance $24116 m0 *1 163.02,204.4
X$24116 11458 219 320 11455 INV_X1
* cell instance $24119 r0 *1 158.65,204.4
X$24119 11391 10664 11373 219 320 11532 OR3_X1
* cell instance $24120 r0 *1 159.6,204.4
X$24120 11373 11372 3222 219 320 11534 NAND3_X1
* cell instance $24122 r0 *1 160.74,204.4
X$24122 219 14169 11489 10760 11323 320 DFF_X1
* cell instance $24123 m0 *1 163.97,204.4
X$24123 11461 11393 11153 219 320 11458 NOR3_X1
* cell instance $24125 m0 *1 164.73,204.4
X$24125 11460 219 320 11240 BUF_X2
* cell instance $24126 m0 *1 165.49,204.4
X$24126 11463 10888 10451 219 11461 320 AOI21_X1
* cell instance $24128 m0 *1 166.44,204.4
X$24128 11394 11390 219 320 11381 NAND2_X2
* cell instance $24129 m0 *1 167.39,204.4
X$24129 11381 10889 219 320 11542 NOR2_X1
* cell instance $24131 m0 *1 168.15,204.4
X$24131 11396 11329 10889 11158 219 320 11395 AOI22_X1
* cell instance $24132 m0 *1 169.1,204.4
X$24132 11464 11390 320 11469 219 AND2_X4
* cell instance $24133 m0 *1 170.81,204.4
X$24133 11155 10977 11467 11396 219 320 11399 AOI22_X2
* cell instance $24134 m0 *1 172.52,204.4
X$24134 219 11474 11397 11378 11471 320 NOR3_X4
* cell instance $24135 m0 *1 175.18,204.4
X$24135 11398 11365 10700 320 11474 219 NOR3_X2
* cell instance $24136 m0 *1 176.51,204.4
X$24136 10696 11216 11559 10591 219 320 11374 AOI22_X2
* cell instance $24137 m0 *1 178.22,204.4
X$24137 10696 11400 219 320 11398 OR2_X1
* cell instance $24138 m0 *1 178.98,204.4
X$24138 11399 11243 11365 320 219 11401 OAI21_X2
* cell instance $24140 m0 *1 181.83,204.4
X$24140 219 11330 11478 10810 11333 320 DFF_X1
* cell instance $24144 r0 *1 165.49,204.4
X$24144 219 11539 11541 11542 11146 320 NOR3_X4
* cell instance $24145 r0 *1 168.15,204.4
X$24145 11459 219 320 11396 INV_X1
* cell instance $24146 r0 *1 168.53,204.4
X$24146 11612 219 320 11541 INV_X2
* cell instance $24147 r0 *1 169.1,204.4
X$24147 11390 320 11467 219 BUF_X4
* cell instance $24149 r0 *1 170.62,204.4
X$24149 219 11472 11469 11544 11050 320 NOR3_X4
* cell instance $24151 r0 *1 173.47,204.4
X$24151 11538 11688 11492 11326 11035 11033 219 320 11472 OAI33_X1
* cell instance $24157 r0 *1 175.37,204.4
X$24157 11398 11365 10591 11646 11543 11493 219 320 11544 OAI33_X1
* cell instance $24158 r0 *1 176.7,204.4
X$24158 11496 11216 11492 11246 219 320 11494 AOI22_X1
* cell instance $24159 r0 *1 177.65,204.4
X$24159 11540 11365 219 320 11539 NOR2_X2
* cell instance $24160 r0 *1 178.6,204.4
X$24160 10591 10700 11400 219 320 11540 OR3_X1
* cell instance $24163 r0 *1 180.12,204.4
X$24163 10849 219 320 10314 CLKBUF_X3
* cell instance $24166 r0 *1 181.64,204.4
X$24166 10054 219 320 11480 BUF_X1
* cell instance $24168 r0 *1 185.25,204.4
X$24168 11496 219 320 6073 INV_X4
* cell instance $24169 r0 *1 186.2,204.4
X$24169 11537 219 320 11538 CLKBUF_X3
* cell instance $24171 m0 *1 186.96,204.4
X$24171 11245 11247 219 320 11210 NOR2_X1
* cell instance $24172 m0 *1 187.72,204.4
X$24172 11247 11331 219 320 11403 NAND2_X1
* cell instance $24175 r0 *1 187.15,204.4
X$24175 219 11404 11537 11497 11333 320 DFF_X1
* cell instance $24176 m0 *1 189.62,204.4
X$24176 11333 219 320 14736 INV_X1
* cell instance $24178 m0 *1 190,204.4
X$24178 11404 320 7735 219 BUF_X4
* cell instance $24179 m0 *1 191.33,204.4
X$24179 9818 219 320 11333 CLKBUF_X3
* cell instance $24181 m0 *1 192.47,204.4
X$24181 11405 320 7845 219 BUF_X4
* cell instance $24183 r0 *1 190.38,204.4
X$24183 219 11405 11536 11498 11333 320 DFF_X1
* cell instance $24184 r0 *1 193.61,204.4
X$24184 11536 219 320 11492 CLKBUF_X3
* cell instance $24185 m0 *1 194.37,204.4
X$24185 219 13321 11406 11470 11254 320 DFF_X1
* cell instance $24188 m0 *1 197.79,204.4
X$24188 11468 11408 11337 11293 219 320 11407 AOI22_X2
* cell instance $24189 m0 *1 199.5,204.4
X$24189 219 13135 11411 11410 11254 320 DFF_X1
* cell instance $24190 m0 *1 202.73,204.4
X$24190 11412 11338 219 320 11409 NAND2_X1
* cell instance $24191 m0 *1 203.3,204.4
X$24191 219 13165 11418 11414 11254 320 DFF_X1
* cell instance $24197 r0 *1 197.03,204.4
X$24197 11409 11287 11407 11499 219 320 11529 NOR4_X1
* cell instance $24198 r0 *1 197.98,204.4
X$24198 11528 11409 11287 11407 219 320 11470 NOR4_X1
* cell instance $24200 r0 *1 199.12,204.4
X$24200 9825 9826 8192 320 11337 219 NOR3_X2
* cell instance $24201 r0 *1 200.45,204.4
X$24201 9818 219 320 11254 CLKBUF_X3
* cell instance $24203 r0 *1 201.59,204.4
X$24203 11526 10986 219 320 11408 NOR2_X1
* cell instance $24204 r0 *1 202.16,204.4
X$24204 11411 11501 320 219 11526 XNOR2_X1
* cell instance $24206 r0 *1 203.68,204.4
X$24206 11412 10326 219 320 11414 NOR2_X1
* cell instance $24207 r0 *1 204.25,204.4
X$24207 11501 11418 11411 219 320 11503 NOR3_X1
* cell instance $24208 r0 *1 205.01,204.4
X$24208 11415 11503 320 219 11416 XNOR2_X1
* cell instance $24209 r0 *1 206.15,204.4
X$24209 11416 10986 219 320 11417 NOR2_X1
* cell instance $24211 r0 *1 206.91,204.4
X$24211 11504 10986 219 320 11413 NOR2_X1
* cell instance $24213 m0 *1 207.86,204.4
X$24213 219 13157 11168 11419 11004 320 DFF_X1
* cell instance $24216 m0 *1 211.28,204.4
X$24216 1954 11420 320 219 11452 AND2_X1
* cell instance $24218 m0 *1 212.61,204.4
X$24218 11450 320 10712 219 BUF_X4
* cell instance $24220 m0 *1 213.94,204.4
X$24220 11341 11339 11421 219 320 11450 OR3_X1
* cell instance $24221 m0 *1 214.89,204.4
X$24221 11421 11340 219 320 11449 XOR2_X1
* cell instance $24222 m0 *1 216.03,204.4
X$24222 11449 10064 219 320 11448 NOR2_X1
* cell instance $24228 r0 *1 215.27,204.4
X$24228 11505 11506 219 320 11277 NAND2_X1
* cell instance $24229 r0 *1 215.84,204.4
X$24229 11506 11505 11507 219 320 11522 MUX2_X1
* cell instance $24230 r0 *1 217.17,204.4
X$24230 11507 11505 219 320 11192 XOR2_X1
* cell instance $24232 m0 *1 220.97,204.4
X$24232 219 13617 11445 11446 11342 320 DFF_X1
* cell instance $24234 m0 *1 224.2,204.4
X$24234 11422 6101 11445 219 320 11446 MUX2_X1
* cell instance $24239 r0 *1 224.01,204.4
X$24239 11599 10069 11445 219 320 11508 MUX2_X1
* cell instance $24241 m0 *1 226.1,204.4
X$24241 9447 219 320 11171 CLKBUF_X3
* cell instance $24244 m0 *1 227.81,204.4
X$24244 219 10507 9340 320 BUF_X32
* cell instance $24245 m0 *1 237.12,204.4
X$24245 219 13576 11425 11438 11084 320 DFF_X1
* cell instance $24248 r0 *1 229.9,204.4
X$24248 11580 6101 11510 219 320 11423 MUX2_X1
* cell instance $24252 r0 *1 231.23,204.4
X$24252 11597 10820 11510 219 320 11511 MUX2_X1
* cell instance $24253 r0 *1 232.56,204.4
X$24253 219 13874 11439 11351 11084 320 DFF_X1
* cell instance $24255 r0 *1 236.17,204.4
X$24255 11346 10820 11512 219 320 11520 MUX2_X1
* cell instance $24256 r0 *1 237.5,204.4
X$24256 219 14352 11346 11518 11084 320 DFF_X1
* cell instance $24264 m0 *1 20.71,134.4
X$24264 219 13329 6801 6850 6092 320 DFF_X1
* cell instance $24265 m0 *1 23.94,134.4
X$24265 6801 4058 7124 219 320 6751 MUX2_X1
* cell instance $24266 m0 *1 25.27,134.4
X$24266 6806 6802 6803 219 320 6903 MUX2_X1
* cell instance $24267 m0 *1 26.6,134.4
X$24267 6803 2772 7234 219 320 6702 MUX2_X1
* cell instance $24278 r0 *1 12.35,134.4
X$24278 219 13850 6900 6898 6899 320 DFF_X1
* cell instance $24279 r0 *1 15.58,134.4
X$24279 6900 2957 6901 219 320 6750 MUX2_X1
* cell instance $24280 r0 *1 16.91,134.4
X$24280 7172 219 320 6899 CLKBUF_X3
* cell instance $24281 r0 *1 17.86,134.4
X$24281 6899 219 320 14706 INV_X2
* cell instance $24284 r0 *1 19,134.4
X$24284 6800 2731 7015 219 320 6849 MUX2_X1
* cell instance $24287 r0 *1 21.47,134.4
X$24287 6801 6902 6806 219 320 6850 MUX2_X1
* cell instance $24290 r0 *1 24.51,134.4
X$24290 219 14445 6803 6903 6455 320 DFF_X1
* cell instance $24294 r0 *1 29.07,134.4
X$24294 6806 6853 6905 219 320 6904 MUX2_X1
* cell instance $24296 m0 *1 33.82,134.4
X$24296 6805 6906 6806 219 320 6851 MUX2_X1
* cell instance $24297 m0 *1 30.59,134.4
X$24297 219 12842 6805 6851 6455 320 DFF_X1
* cell instance $24300 r0 *1 31.35,134.4
X$24300 219 13944 6907 6971 6455 320 DFF_X1
* cell instance $24302 m0 *1 35.72,134.4
X$24302 6806 7082 6807 219 320 6852 MUX2_X1
* cell instance $24304 m0 *1 37.05,134.4
X$24304 219 13406 6807 6852 6908 320 DFF_X1
* cell instance $24305 m0 *1 40.28,134.4
X$24305 6808 2714 6807 219 320 6809 MUX2_X1
* cell instance $24306 m0 *1 41.61,134.4
X$24306 6809 4765 6854 219 320 6608 MUX2_X1
* cell instance $24307 m0 *1 42.94,134.4
X$24307 219 13153 6811 6810 6908 320 DFF_X1
* cell instance $24308 m0 *1 46.17,134.4
X$24308 6811 3950 6910 219 320 6854 MUX2_X1
* cell instance $24311 m0 *1 49.78,134.4
X$24311 6370 5923 6704 219 320 6855 MUX2_X1
* cell instance $24315 r0 *1 37.24,134.4
X$24315 219 13772 6808 6973 6908 320 DFF_X1
* cell instance $24316 r0 *1 40.47,134.4
X$24316 6808 6909 6806 219 320 6973 MUX2_X1
* cell instance $24319 r0 *1 42.37,134.4
X$24319 6806 6974 6811 219 320 6810 MUX2_X1
* cell instance $24321 r0 *1 43.89,134.4
X$24321 219 13840 6910 6975 6908 320 DFF_X1
* cell instance $24324 r0 *1 49.4,134.4
X$24324 5810 320 1564 219 BUF_X4
* cell instance $24326 m0 *1 51.68,134.4
X$24326 219 13426 6704 6855 6267 320 DFF_X1
* cell instance $24329 m0 *1 60.99,134.4
X$24329 219 12709 6706 6857 6267 320 DFF_X1
* cell instance $24330 m0 *1 64.22,134.4
X$24330 6706 6856 6612 219 320 6857 MUX2_X1
* cell instance $24334 m0 *1 68.02,134.4
X$24334 6858 1640 6985 219 320 6771 MUX2_X1
* cell instance $24335 m0 *1 69.35,134.4
X$24335 219 12835 6813 6862 6325 320 DFF_X1
* cell instance $24336 m0 *1 72.58,134.4
X$24336 6813 1552 6865 219 320 6864 MUX2_X1
* cell instance $24338 r0 *1 51.49,134.4
X$24338 3955 320 6207 219 BUF_X4
* cell instance $24339 r0 *1 52.82,134.4
X$24339 4361 320 5801 219 BUF_X4
* cell instance $24342 r0 *1 61.75,134.4
X$24342 7088 1562 6978 219 320 6985 MUX2_X1
* cell instance $24347 r0 *1 63.84,134.4
X$24347 6911 1567 6912 219 320 6812 MUX2_X1
* cell instance $24350 r0 *1 66.88,134.4
X$24350 4006 320 6662 219 BUF_X4
* cell instance $24352 r0 *1 68.59,134.4
X$24352 3910 320 6710 219 BUF_X4
* cell instance $24353 r0 *1 69.92,134.4
X$24353 6986 1562 6864 219 320 6858 MUX2_X1
* cell instance $24354 r0 *1 71.25,134.4
X$24354 6612 7025 6813 219 320 6862 MUX2_X1
* cell instance $24355 r0 *1 72.58,134.4
X$24355 6913 1377 6988 219 320 6986 MUX2_X1
* cell instance $24356 r0 *1 73.91,134.4
X$24356 219 14526 6988 6989 6914 320 DFF_X1
* cell instance $24357 m0 *1 74.48,134.4
X$24357 219 13079 6865 6990 6914 320 DFF_X1
* cell instance $24361 m0 *1 79.42,134.4
X$24361 219 12872 6815 6814 6427 320 DFF_X1
* cell instance $24366 m0 *1 92.72,134.4
X$24366 5678 4161 6867 219 320 6816 MUX2_X1
* cell instance $24368 r0 *1 77.14,134.4
X$24368 5816 320 6917 219 BUF_X4
* cell instance $24370 r0 *1 79.23,134.4
X$24370 6815 6856 6915 219 320 6814 MUX2_X1
* cell instance $24373 r0 *1 81.7,134.4
X$24373 6994 6662 6915 219 320 6916 MUX2_X1
* cell instance $24375 r0 *1 83.79,134.4
X$24375 6815 3370 6994 219 320 6993 MUX2_X1
* cell instance $24376 r0 *1 85.12,134.4
X$24376 6993 4289 219 320 6918 NOR2_X1
* cell instance $24380 r0 *1 91.01,134.4
X$24380 6917 320 2792 219 BUF_X4
* cell instance $24381 r0 *1 92.34,134.4
X$24381 219 13898 6867 6816 6775 320 DFF_X1
* cell instance $24383 m0 *1 94.43,134.4
X$24383 6172 320 3365 219 BUF_X4
* cell instance $24385 m0 *1 97.47,134.4
X$24385 219 13573 6712 6817 6273 320 DFF_X1
* cell instance $24386 m0 *1 96.14,134.4
X$24386 6818 3592 5678 219 320 6996 MUX2_X1
* cell instance $24387 m0 *1 100.7,134.4
X$24387 6712 5217 6818 219 320 6872 MUX2_X1
* cell instance $24388 m0 *1 102.03,134.4
X$24388 6872 6873 219 320 6781 NOR2_X1
* cell instance $24391 r0 *1 96.52,134.4
X$24391 219 13672 6818 6996 6273 320 DFF_X1
* cell instance $24394 r0 *1 101.46,134.4
X$24394 6616 320 2669 219 BUF_X4
* cell instance $24397 m0 *1 102.98,134.4
X$24397 4367 320 2665 219 BUF_X4
* cell instance $24399 r0 *1 103.55,134.4
X$24399 219 14186 6920 6999 6273 320 DFF_X1
* cell instance $24401 m0 *1 106.21,134.4
X$24401 6874 6873 219 320 6875 NOR2_X1
* cell instance $24403 r0 *1 106.97,134.4
X$24403 5820 4161 6920 219 320 6999 MUX2_X1
* cell instance $24405 m0 *1 107.16,134.4
X$24405 219 6875 6819 6820 6921 5822 320 NOR4_X4
* cell instance $24407 r0 *1 108.49,134.4
X$24407 7034 4076 6920 219 320 7000 MUX2_X1
* cell instance $24409 r0 *1 110.2,134.4
X$24409 5941 219 320 5820 BUF_X2
* cell instance $24410 m0 *1 111.15,134.4
X$24410 6822 3592 5820 219 320 6821 MUX2_X1
* cell instance $24413 m0 *1 112.67,134.4
X$24413 6714 3595 6822 219 320 6874 MUX2_X1
* cell instance $24417 m0 *1 117.99,134.4
X$24417 5727 4161 6881 219 320 6880 MUX2_X1
* cell instance $24418 m0 *1 119.32,134.4
X$24418 6923 6590 6881 219 320 6823 MUX2_X1
* cell instance $24419 m0 *1 120.65,134.4
X$24419 219 13415 6717 6882 6466 320 DFF_X1
* cell instance $24420 m0 *1 123.88,134.4
X$24420 6717 3592 5727 219 320 6882 MUX2_X1
* cell instance $24423 m0 *1 126.16,134.4
X$24423 6718 6724 6824 219 320 6883 MUX2_X1
* cell instance $24424 m0 *1 127.49,134.4
X$24424 219 13521 6824 6883 6379 320 DFF_X1
* cell instance $24425 m0 *1 130.72,134.4
X$24425 6824 3260 6924 219 320 6690 MUX2_X1
* cell instance $24426 m0 *1 132.05,134.4
X$24426 6884 6724 6825 219 320 6885 MUX2_X1
* cell instance $24427 m0 *1 133.38,134.4
X$24427 219 13496 6825 6885 6379 320 DFF_X1
* cell instance $24428 m0 *1 136.61,134.4
X$24428 6884 6691 6887 219 320 6788 MUX2_X1
* cell instance $24430 m0 *1 138.13,134.4
X$24430 6825 5828 6887 219 320 6827 MUX2_X1
* cell instance $24433 r0 *1 111.34,134.4
X$24433 219 14517 6822 6821 6466 320 DFF_X1
* cell instance $24436 r0 *1 115.14,134.4
X$24436 6285 4490 6923 219 320 6922 MUX2_X1
* cell instance $24439 r0 *1 117.04,134.4
X$24439 219 14397 6881 6880 6466 320 DFF_X1
* cell instance $24444 r0 *1 120.65,134.4
X$24444 7005 2904 6823 219 320 6682 MUX2_X1
* cell instance $24447 r0 *1 123.12,134.4
X$24447 6285 219 320 5727 BUF_X2
* cell instance $24453 r0 *1 126.35,134.4
X$24453 6718 6691 6924 219 320 7007 MUX2_X1
* cell instance $24454 r0 *1 127.68,134.4
X$24454 219 13742 6924 7007 6379 320 DFF_X1
* cell instance $24458 r0 *1 135.09,134.4
X$24458 219 14421 6926 7010 6925 320 DFF_X1
* cell instance $24460 m0 *1 140.6,134.4
X$24460 6826 4921 6827 219 320 6596 MUX2_X1
* cell instance $24461 m0 *1 139.84,134.4
X$24461 3605 6826 219 320 6888 OR2_X1
* cell instance $24462 m0 *1 141.93,134.4
X$24462 6888 3746 6827 320 219 6295 OAI21_X4
* cell instance $24464 m0 *1 147.44,134.4
X$24464 219 13349 6723 6890 6291 320 DFF_X1
* cell instance $24465 m0 *1 150.67,134.4
X$24465 6626 6724 6723 219 320 6890 MUX2_X1
* cell instance $24472 r0 *1 142.69,134.4
X$24472 6928 219 320 6289 BUF_X1
* cell instance $24475 r0 *1 147.82,134.4
X$24475 7009 219 320 7011 BUF_X1
* cell instance $24476 r0 *1 148.39,134.4
X$24476 7011 219 320 6027 BUF_X2
* cell instance $24477 r0 *1 149.15,134.4
X$24477 219 6928 320 6931 BUF_X8
* cell instance $24478 r0 *1 151.62,134.4
X$24478 6928 219 320 5832 BUF_X1
* cell instance $24480 r0 *1 152.57,134.4
X$24480 219 13811 6932 7008 6726 320 DFF_X1
* cell instance $24481 m0 *1 154.85,134.4
X$24481 6932 6027 6828 219 320 6629 MUX2_X1
* cell instance $24483 m0 *1 156.18,134.4
X$24483 219 13632 6727 6829 6726 320 DFF_X1
* cell instance $24486 m0 *1 162.64,134.4
X$24486 6633 5488 219 320 6894 NOR2_X2
* cell instance $24488 r0 *1 155.8,134.4
X$24488 219 14627 7006 6933 6726 320 DFF_X1
* cell instance $24492 m0 *1 166.44,134.4
X$24492 6673 320 4346 219 BUF_X4
* cell instance $24493 m0 *1 163.97,134.4
X$24493 219 6895 5623 6893 6298 320 AOI21_X4
* cell instance $24496 r0 *1 164.73,134.4
X$24496 6892 4687 219 320 7003 NOR2_X2
* cell instance $24497 r0 *1 165.68,134.4
X$24497 6877 7044 5584 219 6892 320 AOI21_X1
* cell instance $24498 r0 *1 166.44,134.4
X$24498 7002 6891 219 320 6934 NOR2_X1
* cell instance $24499 r0 *1 167.01,134.4
X$24499 3443 6939 3335 1025 320 219 7002 OAI22_X1
* cell instance $24500 r0 *1 167.96,134.4
X$24500 3781 6830 3507 6937 320 219 6935 OAI22_X1
* cell instance $24501 m0 *1 169.48,134.4
X$24501 3866 320 5958 219 BUF_X4
* cell instance $24502 m0 *1 168.15,134.4
X$24502 5736 320 3443 219 BUF_X4
* cell instance $24504 r0 *1 168.91,134.4
X$24504 3940 6938 3693 6940 320 219 6891 OAI22_X1
* cell instance $24505 r0 *1 169.86,134.4
X$24505 3660 6938 3275 6940 320 219 6998 OAI22_X1
* cell instance $24507 r0 *1 171,134.4
X$24507 3277 6889 3383 6831 320 219 6943 OAI22_X1
* cell instance $24508 m0 *1 171.38,134.4
X$24508 3273 6889 6831 3470 320 219 6886 OAI22_X2
* cell instance $24510 m0 *1 173.09,134.4
X$24510 6634 320 3335 219 BUF_X4
* cell instance $24512 r0 *1 171.95,134.4
X$24512 6938 219 320 6992 BUF_X2
* cell instance $24513 r0 *1 172.71,134.4
X$24513 3660 6942 6941 3275 320 219 6945 OAI22_X2
* cell instance $24514 r0 *1 174.42,134.4
X$24514 6886 6945 219 320 6995 NOR2_X2
* cell instance $24515 m0 *1 174.99,134.4
X$24515 4458 320 3608 219 BUF_X4
* cell instance $24517 m0 *1 176.32,134.4
X$24517 6187 2532 6876 6790 5837 320 219 6832 OAI221_X1
* cell instance $24519 m0 *1 178.22,134.4
X$24519 6353 6833 219 320 6792 NAND2_X1
* cell instance $24520 m0 *1 178.79,134.4
X$24520 4596 219 320 6730 INV_X1
* cell instance $24523 m0 *1 180.12,134.4
X$24523 6879 4173 219 320 6878 NOR2_X1
* cell instance $24525 m0 *1 180.88,134.4
X$24525 6835 1769 6950 6731 219 320 6876 AOI22_X1
* cell instance $24527 m0 *1 182.02,134.4
X$24527 6637 6728 6638 5736 6834 6877 219 320 OAI221_X2
* cell instance $24532 r0 *1 175.37,134.4
X$24532 3609 6942 3565 6941 320 219 6946 OAI22_X1
* cell instance $24533 r0 *1 176.32,134.4
X$24533 3609 6992 3565 6948 320 219 6947 OAI22_X1
* cell instance $24537 r0 *1 178.6,134.4
X$24537 6987 320 4308 219 BUF_X4
* cell instance $24538 r0 *1 179.93,134.4
X$24538 6977 1769 6979 6731 219 320 6984 AOI22_X1
* cell instance $24539 r0 *1 180.88,134.4
X$24539 6730 320 6982 219 BUF_X4
* cell instance $24540 r0 *1 182.21,134.4
X$24540 7054 1134 6474 6949 219 320 6834 AOI22_X2
* cell instance $24541 r0 *1 183.92,134.4
X$24541 6977 1134 6979 6474 219 320 6871 AOI22_X1
* cell instance $24543 m0 *1 184.49,134.4
X$24543 6186 6638 6871 6637 4389 320 219 6869 OAI221_X1
* cell instance $24544 r0 *1 184.87,134.4
X$24544 4306 219 320 6954 INV_X1
* cell instance $24545 r0 *1 185.25,134.4
X$24545 5584 6955 219 320 6953 NAND2_X1
* cell instance $24548 m0 *1 186.01,134.4
X$24548 6869 6870 5584 219 6868 320 AOI21_X1
* cell instance $24549 r0 *1 186.2,134.4
X$24549 6954 320 5902 219 BUF_X4
* cell instance $24551 m0 *1 187.15,134.4
X$24551 6868 3966 219 320 6838 NOR2_X1
* cell instance $24552 m0 *1 188.48,134.4
X$24552 6538 320 3781 219 BUF_X4
* cell instance $24559 r0 *1 188.1,134.4
X$24559 6955 219 320 6833 CLKBUF_X3
* cell instance $24561 r0 *1 189.43,134.4
X$24561 6955 320 2813 219 BUF_X4
* cell instance $24564 m0 *1 195.51,134.4
X$24564 6305 320 6836 219 BUF_X4
* cell instance $24565 m0 *1 197.03,134.4
X$24565 6224 6836 219 320 6841 NOR2_X1
* cell instance $24569 m0 *1 200.07,134.4
X$24569 6837 6843 6545 219 320 6663 MUX2_X1
* cell instance $24570 m0 *1 201.4,134.4
X$24570 5567 219 320 6190 CLKBUF_X3
* cell instance $24571 m0 *1 202.35,134.4
X$24571 6866 6184 6680 219 6544 320 AOI21_X1
* cell instance $24574 m0 *1 204.82,134.4
X$24574 6837 6861 6863 219 320 6774 MUX2_X1
* cell instance $24577 m0 *1 209.95,134.4
X$24577 6736 6861 6739 219 320 6859 MUX2_X1
* cell instance $24578 m0 *1 211.28,134.4
X$24578 219 13401 6739 6859 6642 320 DFF_X1
* cell instance $24579 m0 *1 214.51,134.4
X$24579 6736 6740 6840 219 320 6839 MUX2_X1
* cell instance $24584 r0 *1 201.02,134.4
X$24584 6190 219 320 14707 INV_X2
* cell instance $24590 r0 *1 210.52,134.4
X$24590 6961 219 320 5277 CLKBUF_X3
* cell instance $24591 r0 *1 211.47,134.4
X$24591 6972 219 320 5567 CLKBUF_X3
* cell instance $24592 r0 *1 212.42,134.4
X$24592 5567 219 320 14708 INV_X2
* cell instance $24594 r0 *1 213.37,134.4
X$24594 219 14078 6840 6839 6642 320 DFF_X1
* cell instance $24595 m0 *1 216.41,134.4
X$24595 5567 219 320 6642 CLKBUF_X3
* cell instance $24600 m0 *1 218.69,134.4
X$24600 6741 6861 6550 219 320 6769 MUX2_X1
* cell instance $24604 m0 *1 220.97,134.4
X$24604 6842 4530 6844 219 320 6742 MUX2_X1
* cell instance $24605 m0 *1 222.3,134.4
X$24605 6741 6843 6844 219 320 6743 MUX2_X1
* cell instance $24608 m0 *1 225.34,134.4
X$24608 219 12605 6744 6845 6401 320 DFF_X1
* cell instance $24612 m0 *1 233.32,134.4
X$24612 6846 5995 6758 219 320 6760 MUX2_X1
* cell instance $24613 m0 *1 234.65,134.4
X$24613 6846 6101 6644 219 320 6647 MUX2_X1
* cell instance $24614 m0 *1 235.98,134.4
X$24614 6846 6087 6753 219 320 6757 MUX2_X1
* cell instance $24615 m0 *1 237.31,134.4
X$24615 6846 6311 6752 219 320 6746 MUX2_X1
* cell instance $24616 m0 *1 238.64,134.4
X$24616 6753 3071 6752 219 320 6556 MUX2_X1
* cell instance $24618 m0 *1 240.16,134.4
X$24618 6748 219 320 6736 BUF_X1
* cell instance $24621 r0 *1 221.16,134.4
X$24621 6741 6860 6842 219 320 6970 MUX2_X1
* cell instance $24622 r0 *1 222.49,134.4
X$24622 219 14630 6842 6970 6642 320 DFF_X1
* cell instance $24630 r0 *1 233.89,134.4
X$24630 6841 219 320 6747 BUF_X1
* cell instance $24631 r0 *1 234.46,134.4
X$24631 6420 219 320 6847 BUF_X1
* cell instance $24632 r0 *1 235.03,134.4
X$24632 6878 219 320 6965 BUF_X1
* cell instance $24635 r0 *1 237.31,134.4
X$24635 6587 219 320 6966 BUF_X1
* cell instance $24638 r0 *1 238.45,134.4
X$24638 6729 219 320 6967 BUF_X1
* cell instance $24641 r0 *1 239.59,134.4
X$24641 6838 219 320 6749 BUF_X1
* cell instance $24703 r0 *1 125.21,212.8
X$24703 11853 8040 11831 219 320 11830 MUX2_X1
* cell instance $24704 r0 *1 126.54,212.8
X$24704 11912 10940 11831 219 320 11803 MUX2_X1
* cell instance $24706 r0 *1 128.06,212.8
X$24706 11942 10940 11804 219 320 11805 MUX2_X1
* cell instance $24710 r0 *1 130.72,212.8
X$24710 219 14703 11808 11854 11806 320 DFF_X1
* cell instance $24711 r0 *1 133.95,212.8
X$24711 11808 10940 11807 219 320 11834 MUX2_X1
* cell instance $24712 r0 *1 135.28,212.8
X$24712 219 14311 11857 11890 11806 320 DFF_X1
* cell instance $24714 m0 *1 137.18,212.8
X$24714 9425 219 320 11806 CLKBUF_X3
* cell instance $24717 r0 *1 138.51,212.8
X$24717 11806 219 320 CLKBUF_X1
* cell instance $24719 r0 *1 139.27,212.8
X$24719 219 14564 11893 11837 11806 320 DFF_X1
* cell instance $24722 r0 *1 144.21,212.8
X$24722 219 14356 11749 11785 11319 320 DFF_X1
* cell instance $24724 m0 *1 146.11,212.8
X$24724 11786 11691 9745 219 320 11785 NOR3_X1
* cell instance $24725 m0 *1 148.39,212.8
X$24725 11750 9873 219 320 11786 NOR2_X1
* cell instance $24726 m0 *1 147.25,212.8
X$24726 11749 11693 320 219 11750 XNOR2_X1
* cell instance $24727 m0 *1 148.96,212.8
X$24727 11749 219 320 11787 INV_X1
* cell instance $24729 m0 *1 150.1,212.8
X$24729 11751 11840 11787 219 320 11634 NAND3_X1
* cell instance $24730 m0 *1 150.86,212.8
X$24730 11751 11788 11739 219 320 11693 NAND3_X1
* cell instance $24731 m0 *1 151.62,212.8
X$24731 219 11791 11789 11694 11790 320 DFF_X1
* cell instance $24732 m0 *1 154.85,212.8
X$24732 11116 320 10002 219 BUF_X4
* cell instance $24737 r0 *1 148.58,212.8
X$24737 11486 11786 11863 219 11839 320 AOI21_X1
* cell instance $24739 r0 *1 149.53,212.8
X$24739 11839 11897 11810 219 320 11736 NOR3_X1
* cell instance $24741 r0 *1 150.48,212.8
X$24741 11864 11809 219 320 11751 NOR2_X1
* cell instance $24742 r0 *1 151.05,212.8
X$24742 11809 11842 320 219 11841 XNOR2_X1
* cell instance $24743 r0 *1 152.19,212.8
X$24743 11788 11739 219 320 11842 NAND2_X1
* cell instance $24745 r0 *1 152.95,212.8
X$24745 11809 11844 11789 11811 219 320 11843 NOR4_X1
* cell instance $24747 r0 *1 154.09,212.8
X$24747 11844 11789 11811 219 320 11840 NOR3_X1
* cell instance $24748 r0 *1 154.85,212.8
X$24748 11791 11812 11899 320 219 11788 HA_X1
* cell instance $24751 m0 *1 157.32,212.8
X$24751 11116 320 10064 219 BUF_X4
* cell instance $24753 r0 *1 157.51,212.8
X$24753 11146 10002 219 320 11956 NOR2_X1
* cell instance $24756 m0 *1 159.98,212.8
X$24756 219 11639 11793 11794 11323 320 DFF_X1
* cell instance $24759 r0 *1 159.98,212.8
X$24759 11116 219 320 11550 CLKBUF_X3
* cell instance $24762 r0 *1 161.88,212.8
X$24762 11915 219 320 9556 BUF_X2
* cell instance $24763 r0 *1 162.64,212.8
X$24763 11847 11813 9386 219 320 11848 NOR3_X1
* cell instance $24764 r0 *1 163.4,212.8
X$24764 11813 11795 11848 11905 219 320 11794 AOI22_X1
* cell instance $24766 m0 *1 163.59,212.8
X$24766 11793 219 320 11752 CLKBUF_X2
* cell instance $24767 r0 *1 164.35,212.8
X$24767 11116 11752 10314 219 11795 320 AOI21_X1
* cell instance $24768 m0 *1 164.92,212.8
X$24768 11640 11797 320 219 11796 AND2_X1
* cell instance $24771 m0 *1 165.87,212.8
X$24771 10892 11797 11640 219 11753 320 AOI21_X1
* cell instance $24773 r0 *1 165.11,212.8
X$24773 11796 219 320 11813 BUF_X2
* cell instance $24775 r0 *1 166.06,212.8
X$24775 10218 11644 219 320 11814 NOR2_X1
* cell instance $24776 r0 *1 166.63,212.8
X$24776 9390 11743 11814 10574 11758 11850 219 320 11847 OAI33_X1
* cell instance $24777 m0 *1 167.2,212.8
X$24777 10543 11753 10333 219 320 11695 NAND3_X1
* cell instance $24779 m0 *1 167.96,212.8
X$24779 11753 10333 219 320 11798 NAND2_X1
* cell instance $24780 m0 *1 168.53,212.8
X$24780 11754 11643 219 320 11755 NOR2_X1
* cell instance $24781 m0 *1 169.1,212.8
X$24781 11493 219 320 11756 INV_X1
* cell instance $24783 m0 *1 169.67,212.8
X$24783 7251 11756 219 320 11815 NOR2_X1
* cell instance $24785 m0 *1 170.43,212.8
X$24785 11752 219 320 11696 INV_X1
* cell instance $24786 m0 *1 170.81,212.8
X$24786 11757 8380 219 320 11817 NAND2_X1
* cell instance $24787 m0 *1 171.38,212.8
X$24787 11699 11643 10451 219 11799 320 AOI21_X1
* cell instance $24788 m0 *1 172.14,212.8
X$24788 11644 320 8380 219 BUF_X4
* cell instance $24789 m0 *1 173.47,212.8
X$24789 11644 219 320 6685 INV_X2
* cell instance $24793 r0 *1 168.34,212.8
X$24793 11695 11755 11849 11756 11798 320 219 11851 OAI221_X1
* cell instance $24794 r0 *1 169.48,212.8
X$24794 11867 11815 7944 10543 219 320 11850 AOI22_X1
* cell instance $24795 r0 *1 170.43,212.8
X$24795 11813 10314 8380 219 320 11849 NAND3_X1
* cell instance $24796 r0 *1 171.19,212.8
X$24796 11817 11758 11816 320 11869 219 OAI21_X1
* cell instance $24798 r0 *1 172.14,212.8
X$24798 10574 10693 219 320 11852 NOR2_X1
* cell instance $24800 r0 *1 172.9,212.8
X$24800 11871 10333 6685 320 11898 219 OAI21_X1
* cell instance $24801 r0 *1 173.66,212.8
X$24801 11705 10746 11752 320 11868 219 OAI21_X1
* cell instance $24802 r0 *1 174.42,212.8
X$24802 11705 10746 219 320 11758 NOR2_X1
* cell instance $24807 m0 *1 175.37,212.8
X$24807 10892 219 320 10664 CLKBUF_X3
* cell instance $24810 m0 *1 177.08,212.8
X$24810 11701 11801 219 320 11802 NAND2_X1
* cell instance $24812 m0 *1 178.41,212.8
X$24812 11802 11563 10451 219 11846 320 AOI21_X1
* cell instance $24815 m0 *1 180.12,212.8
X$24815 11703 219 320 11645 INV_X1
* cell instance $24818 r0 *1 177.27,212.8
X$24818 11116 320 10326 219 BUF_X4
* cell instance $24819 r0 *1 178.6,212.8
X$24819 10314 320 10472 219 BUF_X4
* cell instance $24822 m0 *1 181.07,212.8
X$24822 11492 11759 10547 320 11704 219 OAI21_X1
* cell instance $24825 m0 *1 182.02,212.8
X$24825 11704 11762 11800 11760 11570 219 320 11746 AOI221_X1
* cell instance $24827 m0 *1 183.35,212.8
X$24827 11707 10642 219 320 11760 NAND2_X1
* cell instance $24829 m0 *1 184.11,212.8
X$24829 11761 11563 219 320 11762 NOR2_X1
* cell instance $24831 m0 *1 184.87,212.8
X$24831 9384 219 320 11707 INV_X1
* cell instance $24833 m0 *1 185.44,212.8
X$24833 11745 11763 10892 320 11759 219 NOR3_X2
* cell instance $24834 m0 *1 186.77,212.8
X$24834 10641 11763 10654 11707 219 320 11877 OR4_X1
* cell instance $24835 m0 *1 187.91,212.8
X$24835 11745 10892 219 320 11655 NOR2_X1
* cell instance $24836 m0 *1 188.48,212.8
X$24836 11763 219 320 11792 INV_X1
* cell instance $24838 m0 *1 189.05,212.8
X$24838 11792 11682 3222 11765 219 320 11833 AOI22_X1
* cell instance $24840 m0 *1 190.19,212.8
X$24840 11763 11766 11656 320 11765 219 OAI21_X1
* cell instance $24841 m0 *1 190.95,212.8
X$24841 11572 11079 11492 219 320 11767 NOR3_X1
* cell instance $24842 m0 *1 191.71,212.8
X$24842 11709 10708 10985 320 219 11705 OAI21_X2
* cell instance $24843 m0 *1 193.04,212.8
X$24843 10708 10985 219 320 11768 NOR2_X1
* cell instance $24845 r0 *1 180.88,212.8
X$24845 11647 10314 320 219 11819 AND2_X1
* cell instance $24846 r0 *1 181.64,212.8
X$24846 11845 11759 11570 11819 11818 219 320 OAI211_X2
* cell instance $24847 r0 *1 183.35,212.8
X$24847 11707 10654 219 320 11845 NOR2_X1
* cell instance $24850 r0 *1 185.06,212.8
X$24850 6835 9384 11820 11651 11647 320 219 11821 OAI221_X1
* cell instance $24852 r0 *1 186.39,212.8
X$24852 11538 11015 11888 11563 10547 320 219 11838 OAI221_X1
* cell instance $24853 r0 *1 187.53,212.8
X$24853 10654 11570 219 320 11764 NAND2_X1
* cell instance $24854 r0 *1 188.1,212.8
X$24854 10472 11563 219 320 11835 NAND2_X1
* cell instance $24857 r0 *1 189.24,212.8
X$24857 11015 11647 219 320 11766 NAND2_X1
* cell instance $24858 r0 *1 189.81,212.8
X$24858 11570 11835 11833 11764 320 219 11822 OAI22_X1
* cell instance $24860 r0 *1 191.52,212.8
X$24860 11832 219 320 11563 CLKBUF_X3
* cell instance $24861 r0 *1 192.47,212.8
X$24861 11880 320 4304 219 BUF_X4
* cell instance $24862 r0 *1 193.8,212.8
X$24862 11079 10746 11768 219 320 11887 OR3_X2
* cell instance $24863 m0 *1 197.6,212.8
X$24863 219 11784 11711 11769 11823 320 DFF_X1
* cell instance $24864 m0 *1 193.99,212.8
X$24864 219 11708 11823 12492 11658 320 DFF_X2
* cell instance $24865 m0 *1 200.83,212.8
X$24865 11737 11784 11771 320 219 11772 HA_X1
* cell instance $24866 m0 *1 202.73,212.8
X$24866 11772 11466 219 320 11735 NAND2_X1
* cell instance $24871 r0 *1 196.27,212.8
X$24871 9818 219 320 11823 CLKBUF_X3
* cell instance $24872 r0 *1 197.22,212.8
X$24872 11648 10326 219 320 11886 NOR2_X1
* cell instance $24873 r0 *1 197.79,212.8
X$24873 11823 219 320 CLKBUF_X1
* cell instance $24874 r0 *1 198.36,212.8
X$24874 11710 10326 219 320 11769 NOR2_X1
* cell instance $24877 r0 *1 200.07,212.8
X$24877 11711 11466 219 320 11770 NOR2_X1
* cell instance $24879 r0 *1 200.83,212.8
X$24879 11829 11771 11466 219 320 11659 NAND3_X1
* cell instance $24882 r0 *1 202.16,212.8
X$24882 11772 11712 320 219 11829 XNOR2_X1
* cell instance $24888 m0 *1 15.2,179.2
X$24888 9396 6802 9636 219 320 9807 MUX2_X1
* cell instance $24899 r0 *1 9.88,179.2
X$24899 219 14335 9851 9894 9936 320 DFF_X1
* cell instance $24900 r0 *1 13.11,179.2
X$24900 9851 7014 9852 219 320 9894 MUX2_X1
* cell instance $24904 r0 *1 21.09,179.2
X$24904 219 14414 9940 9939 9941 320 DFF_X1
* cell instance $24905 r0 *1 24.32,179.2
X$24905 9854 6909 9852 219 320 9809 MUX2_X1
* cell instance $24906 m0 *1 25.46,179.2
X$24906 219 12913 9854 9809 9941 320 DFF_X1
* cell instance $24911 r0 *1 25.65,179.2
X$24911 9852 7082 9896 219 320 9853 MUX2_X1
* cell instance $24914 r0 *1 27.55,179.2
X$24914 9854 8913 9896 219 320 9855 MUX2_X1
* cell instance $24918 r0 *1 30.97,179.2
X$24918 9640 7082 9856 219 320 9988 MUX2_X1
* cell instance $24920 m0 *1 31.35,179.2
X$24920 1282 219 320 9762 CLKBUF_X3
* cell instance $24922 r0 *1 32.3,179.2
X$24922 219 13715 9900 9897 9942 320 DFF_X1
* cell instance $24923 r0 *1 35.53,179.2
X$24923 9900 8799 9856 219 320 9857 MUX2_X1
* cell instance $24924 r0 *1 36.86,179.2
X$24924 9857 8920 9901 219 320 9858 MUX2_X1
* cell instance $24927 m0 *1 38.76,179.2
X$24927 9641 8791 9642 219 320 9901 MUX2_X1
* cell instance $24932 r0 *1 41.61,179.2
X$24932 219 13771 9860 9902 9859 320 DFF_X1
* cell instance $24935 m0 *1 45.79,179.2
X$24935 5810 320 9763 219 BUF_X4
* cell instance $24937 r0 *1 46.36,179.2
X$24937 9862 6909 9944 219 320 9904 MUX2_X1
* cell instance $24938 r0 *1 47.69,179.2
X$24938 219 14136 9862 9904 9861 320 DFF_X1
* cell instance $24939 m0 *1 50.73,179.2
X$24939 5810 320 8729 219 BUF_X4
* cell instance $24944 m0 *1 64.41,179.2
X$24944 219 12592 9764 9645 9413 320 DFF_X1
* cell instance $24947 r0 *1 51.3,179.2
X$24947 9862 5005 9945 219 320 9906 MUX2_X1
* cell instance $24950 r0 *1 53.58,179.2
X$24950 9906 9207 10090 219 320 9863 MUX2_X1
* cell instance $24951 r0 *1 54.91,179.2
X$24951 9863 4992 10344 219 320 9864 MUX2_X1
* cell instance $24954 r0 *1 59.47,179.2
X$24954 219 13767 9866 9908 9865 320 DFF_X1
* cell instance $24955 r0 *1 62.7,179.2
X$24955 9866 7492 9537 219 320 9908 MUX2_X1
* cell instance $24962 r0 *1 66.12,179.2
X$24962 9867 6662 9947 219 320 9992 MUX2_X1
* cell instance $24965 r0 *1 68.02,179.2
X$24965 219 14316 9948 9909 9413 320 DFF_X1
* cell instance $24966 m0 *1 69.35,179.2
X$24966 219 12637 9765 9646 9413 320 DFF_X1
* cell instance $24967 m0 *1 68.02,179.2
X$24967 9764 8145 9765 219 320 10037 MUX2_X1
* cell instance $24971 r0 *1 71.44,179.2
X$24971 9910 8867 9993 219 320 9868 MUX2_X1
* cell instance $24974 m0 *1 74.67,179.2
X$24974 9537 7025 9817 219 320 9766 MUX2_X1
* cell instance $24976 m0 *1 76,179.2
X$24976 219 13577 9820 9819 9767 320 DFF_X1
* cell instance $24977 m0 *1 79.23,179.2
X$24977 219 12619 9821 9768 9770 320 DFF_X1
* cell instance $24979 m0 *1 83.22,179.2
X$24979 9915 219 320 9297 CLKBUF_X2
* cell instance $24980 m0 *1 83.98,179.2
X$24980 219 12565 9823 9769 9770 320 DFF_X1
* cell instance $24985 r0 *1 75.05,179.2
X$24985 9911 8920 9912 219 320 9910 MUX2_X1
* cell instance $24986 r0 *1 76.38,179.2
X$24986 9817 8799 9820 219 320 9912 MUX2_X1
* cell instance $24987 r0 *1 77.71,179.2
X$24987 9537 7026 9820 219 320 9819 MUX2_X1
* cell instance $24988 r0 *1 79.04,179.2
X$24988 9537 7027 9821 219 320 9768 MUX2_X1
* cell instance $24989 r0 *1 80.37,179.2
X$24989 9648 8913 9821 219 320 9911 MUX2_X1
* cell instance $24990 r0 *1 81.7,179.2
X$24990 9302 219 320 8926 CLKBUF_X3
* cell instance $24992 r0 *1 82.84,179.2
X$24992 9823 6662 9869 219 320 9769 MUX2_X1
* cell instance $24993 r0 *1 84.17,179.2
X$24993 9869 6710 9995 219 320 9994 MUX2_X1
* cell instance $24997 r0 *1 89.49,179.2
X$24997 9869 7025 9916 219 320 9917 MUX2_X1
* cell instance $24998 r0 *1 90.82,179.2
X$24998 219 14142 9916 9917 9770 320 DFF_X1
* cell instance $25000 m0 *1 97.66,179.2
X$25000 219 13287 9539 9771 9772 320 DFF_X1
* cell instance $25002 m0 *1 100.89,179.2
X$25002 219 13285 9918 9824 9772 320 DFF_X1
* cell instance $25011 r0 *1 100.51,179.2
X$25011 9918 6856 9415 219 320 9824 MUX2_X1
* cell instance $25015 r0 *1 106.78,179.2
X$25015 9302 219 320 8697 CLKBUF_X3
* cell instance $25016 r0 *1 107.73,179.2
X$25016 8697 219 320 14800 CLKBUF_X3
* cell instance $25018 r0 *1 109.44,179.2
X$25018 219 14490 10001 10000 9920 320 DFF_X1
* cell instance $25025 r0 *1 120.65,179.2
X$25025 9870 8278 10109 219 320 10108 MUX2_X1
* cell instance $25027 r0 *1 122.17,179.2
X$25027 9870 8166 9921 219 320 10006 MUX2_X1
* cell instance $25031 m0 *1 128.25,179.2
X$25031 9505 8699 9659 219 320 9658 MUX2_X1
* cell instance $25034 m0 *1 129.77,179.2
X$25034 4351 320 8121 219 BUF_X4
* cell instance $25035 m0 *1 131.1,179.2
X$25035 4505 320 8242 219 BUF_X4
* cell instance $25037 m0 *1 135.47,179.2
X$25037 9773 7606 9662 320 219 8480 OAI21_X4
* cell instance $25039 m0 *1 138.13,179.2
X$25039 219 7606 320 9827 BUF_X8
* cell instance $25041 m0 *1 141.36,179.2
X$25041 9829 9731 9832 219 9774 320 AOI21_X1
* cell instance $25042 m0 *1 142.12,179.2
X$25042 7399 9830 9831 320 219 9832 HA_X1
* cell instance $25043 m0 *1 144.02,179.2
X$25043 9664 9774 9776 320 9775 219 OAI21_X1
* cell instance $25044 m0 *1 144.78,179.2
X$25044 9833 219 320 9776 INV_X1
* cell instance $25045 m0 *1 145.16,179.2
X$25045 7614 9834 9733 320 219 9833 HA_X1
* cell instance $25046 m0 *1 147.06,179.2
X$25046 7840 219 320 9834 INV_X1
* cell instance $25050 r0 *1 129.01,179.2
X$25050 4377 320 8166 219 BUF_X4
* cell instance $25051 r0 *1 130.34,179.2
X$25051 4294 320 8278 219 BUF_X4
* cell instance $25053 r0 *1 134.71,179.2
X$25053 5131 9924 320 219 9622 AND2_X1
* cell instance $25057 r0 *1 138.13,179.2
X$25057 9957 9871 8284 320 219 9064 MUX2_X2
* cell instance $25059 r0 *1 140.03,179.2
X$25059 4921 219 320 9827 INV_X2
* cell instance $25061 r0 *1 142.12,179.2
X$25061 9064 9329 9958 9925 9550 219 320 OAI211_X2
* cell instance $25062 r0 *1 143.83,179.2
X$25062 7440 9959 9872 320 219 10010 HA_X1
* cell instance $25064 r0 *1 147.25,179.2
X$25064 9064 9329 219 320 9835 OR2_X1
* cell instance $25065 r0 *1 148.01,179.2
X$25065 9835 9668 9388 219 320 9961 NOR3_X1
* cell instance $25066 m0 *1 149.15,179.2
X$25066 9835 9427 9668 219 320 9665 NOR3_X1
* cell instance $25067 m0 *1 148.58,179.2
X$25067 9550 9474 219 320 9962 NAND2_X1
* cell instance $25069 m0 *1 150.1,179.2
X$25069 9429 9427 219 320 9927 OR2_X1
* cell instance $25070 m0 *1 150.86,179.2
X$25070 9668 9329 9777 219 320 9836 NAND3_X1
* cell instance $25072 r0 *1 148.77,179.2
X$25072 219 9873 9963 6450 9930 9874 320 OAI211_X4
* cell instance $25073 m0 *1 152.19,179.2
X$25073 6450 9778 7901 219 10016 320 AOI21_X2
* cell instance $25077 r0 *1 152,179.2
X$25077 9836 9927 219 320 9778 OR2_X1
* cell instance $25078 r0 *1 152.76,179.2
X$25078 9836 6522 9560 320 10014 219 NOR3_X2
* cell instance $25080 m0 *1 155.61,179.2
X$25080 219 9840 9779 9875 10115 320 DFF_X1
* cell instance $25082 m0 *1 158.84,179.2
X$25082 9780 9840 9931 320 219 9553 HA_X1
* cell instance $25083 m0 *1 160.74,179.2
X$25083 9841 9781 9779 9555 219 320 9783 OR4_X1
* cell instance $25084 m0 *1 161.88,179.2
X$25084 9669 9783 320 219 9670 XNOR2_X1
* cell instance $25086 m0 *1 163.21,179.2
X$25086 9784 9785 320 219 9842 XNOR2_X1
* cell instance $25087 m0 *1 164.35,179.2
X$25087 9786 9787 320 219 9051 AND2_X2
* cell instance $25088 m0 *1 165.3,179.2
X$25088 9787 9786 219 320 9382 NAND2_X1
* cell instance $25093 m0 *1 174.42,179.2
X$25093 219 9849 9058 9848 6995 320 AOI21_X4
* cell instance $25098 r0 *1 156.56,179.2
X$25098 9741 10002 219 320 9875 NOR2_X1
* cell instance $25101 r0 *1 158.27,179.2
X$25101 9779 9556 219 320 9876 NOR2_X1
* cell instance $25102 r0 *1 158.84,179.2
X$25102 9556 9931 9876 9787 9786 219 320 9742 AOI221_X1
* cell instance $25103 r0 *1 159.98,179.2
X$25103 9553 9555 320 219 9877 XNOR2_X1
* cell instance $25104 r0 *1 161.12,179.2
X$25104 9877 9931 9556 219 320 9932 NAND3_X1
* cell instance $25105 r0 *1 161.88,179.2
X$25105 9670 9932 9782 219 9878 320 AOI21_X1
* cell instance $25106 r0 *1 162.64,179.2
X$25106 9843 9878 9557 219 9964 320 AOI21_X1
* cell instance $25107 r0 *1 163.4,179.2
X$25107 9669 9784 9783 219 320 9934 OR3_X1
* cell instance $25108 r0 *1 164.35,179.2
X$25108 9575 7838 9933 219 320 9935 MUX2_X1
* cell instance $25110 r0 *1 165.87,179.2
X$25110 9879 9934 219 320 9933 XOR2_X1
* cell instance $25112 r0 *1 167.2,179.2
X$25112 9785 9879 9784 219 320 9880 NOR3_X1
* cell instance $25115 r0 *1 169.86,179.2
X$25115 219 10219 9965 9753 9881 320 DFF_X2
* cell instance $25121 r0 *1 177.27,179.2
X$25121 9672 320 2810 219 BUF_X4
* cell instance $25122 m0 *1 178.22,179.2
X$25122 9672 320 6870 219 BUF_X4
* cell instance $25125 m0 *1 179.74,179.2
X$25125 219 10312 9058 9850 9565 320 AOI21_X4
* cell instance $25126 m0 *1 182.21,179.2
X$25126 9066 3609 9668 6186 9928 9846 219 320 OAI221_X2
* cell instance $25129 m0 *1 185.25,179.2
X$25129 9674 6950 9673 9055 7949 9844 320 219 AOI221_X2
* cell instance $25131 m0 *1 187.53,179.2
X$25131 9058 9845 9844 219 10021 320 AOI21_X2
* cell instance $25133 m0 *1 190.38,179.2
X$25133 6395 9575 9681 8674 320 219 9791 OAI22_X2
* cell instance $25134 m0 *1 192.09,179.2
X$25134 6395 9574 9573 8674 320 219 9839 OAI22_X2
* cell instance $25136 m0 *1 193.99,179.2
X$25136 9571 7102 9839 9677 7106 9837 320 219 AOI221_X2
* cell instance $25139 m0 *1 197.79,179.2
X$25139 8052 219 320 9794 INV_X1
* cell instance $25140 m0 *1 198.17,179.2
X$25140 9794 320 6979 219 BUF_X4
* cell instance $25141 m0 *1 199.5,179.2
X$25141 6950 9826 9828 8421 219 320 9736 AOI22_X2
* cell instance $25142 m0 *1 201.21,179.2
X$25142 6950 9825 8421 9998 219 320 9795 AOI22_X1
* cell instance $25143 m0 *1 202.16,179.2
X$25143 4083 9886 9795 9738 6075 320 219 9796 OAI221_X1
* cell instance $25144 m0 *1 203.3,179.2
X$25144 9570 9793 8421 9678 219 320 9822 AOI22_X1
* cell instance $25145 m0 *1 204.25,179.2
X$25145 9676 9793 8380 9678 219 320 9722 AOI22_X1
* cell instance $25146 m0 *1 205.2,179.2
X$25146 9794 9732 8220 9680 219 320 9682 AOI22_X1
* cell instance $25147 m0 *1 206.15,179.2
X$25147 6187 9725 9822 9789 6075 320 219 9816 OAI221_X1
* cell instance $25148 m0 *1 207.29,179.2
X$25148 9796 7884 9797 219 9903 320 AOI21_X1
* cell instance $25150 m0 *1 208.24,179.2
X$25150 9818 219 320 8102 CLKBUF_X3
* cell instance $25151 m0 *1 209.19,179.2
X$25151 9815 5977 219 320 9798 NOR2_X2
* cell instance $25152 m0 *1 210.14,179.2
X$25152 9816 7884 9233 219 9799 320 AOI21_X1
* cell instance $25155 r0 *1 178.6,179.2
X$25155 4596 219 320 8324 CLKBUF_X3
* cell instance $25156 r0 *1 179.55,179.2
X$25156 7945 320 6538 219 BUF_X4
* cell instance $25157 r0 *1 180.88,179.2
X$25157 8595 320 4301 219 BUF_X4
* cell instance $25159 r0 *1 182.59,179.2
X$25159 8049 9055 6949 9674 219 320 9882 AOI22_X1
* cell instance $25160 r0 *1 183.54,179.2
X$25160 6977 9055 9674 6979 219 320 9928 AOI22_X2
* cell instance $25161 r0 *1 185.25,179.2
X$25161 9846 6870 9546 219 9883 320 AOI21_X2
* cell instance $25162 r0 *1 186.58,179.2
X$25162 4301 9066 9788 9668 6020 320 219 10022 OAI221_X1
* cell instance $25165 r0 *1 190,179.2
X$25165 6634 9575 9884 9681 6728 320 219 9926 OAI221_X1
* cell instance $25166 r0 *1 191.14,179.2
X$25166 8381 9732 8060 9680 219 320 9884 AOI22_X1
* cell instance $25167 r0 *1 192.09,179.2
X$25167 9680 7102 9791 9732 7106 9922 320 219 AOI221_X2
* cell instance $25168 r0 *1 194.18,179.2
X$25168 2811 9792 9922 219 9923 320 AOI21_X2
* cell instance $25169 r0 *1 195.51,179.2
X$25169 8381 9793 8060 9678 219 320 9885 AOI22_X1
* cell instance $25170 r0 *1 196.46,179.2
X$25170 7737 9793 7102 9678 219 320 9974 AOI22_X1
* cell instance $25172 r0 *1 197.6,179.2
X$25172 8381 9826 8060 9828 219 320 9975 AOI22_X1
* cell instance $25174 r0 *1 198.74,179.2
X$25174 7737 9826 7102 9828 219 320 9919 AOI22_X1
* cell instance $25175 r0 *1 199.69,179.2
X$25175 7058 9739 9919 9683 3347 320 219 10003 OAI221_X1
* cell instance $25177 r0 *1 201.02,179.2
X$25177 6979 9826 8220 9828 219 320 9914 AOI22_X1
* cell instance $25179 r0 *1 202.35,179.2
X$25179 4180 9683 9914 9739 3787 320 219 9913 OAI221_X1
* cell instance $25181 r0 *1 203.87,179.2
X$25181 9676 9732 8380 9680 219 320 9907 AOI22_X1
* cell instance $25184 r0 *1 205.39,179.2
X$25184 4301 9681 9907 9575 8324 320 219 9905 OAI221_X1
* cell instance $25187 r0 *1 208.24,179.2
X$25187 8102 219 320 14715 INV_X2
* cell instance $25190 r0 *1 209.76,179.2
X$25190 9799 5977 219 320 9898 NOR2_X1
* cell instance $25191 r0 *1 210.33,179.2
X$25191 9903 5977 219 320 9811 NOR2_X1
* cell instance $25193 r0 *1 211.66,179.2
X$25193 219 14489 10091 9887 9978 320 DFF_X1
* cell instance $25194 m0 *1 212.23,179.2
X$25194 2371 219 320 9725 INV_X1
* cell instance $25201 r0 *1 221.35,179.2
X$25201 219 14222 9684 9899 9888 320 DFF_X1
* cell instance $25202 m0 *1 222.3,179.2
X$25202 219 12696 9800 9814 9888 320 DFF_X1
* cell instance $25204 m0 *1 225.53,179.2
X$25204 9812 7165 9800 219 320 9814 MUX2_X1
* cell instance $25206 r0 *1 224.58,179.2
X$25206 9812 7176 9684 219 320 9899 MUX2_X1
* cell instance $25208 r0 *1 226.1,179.2
X$25208 9812 7291 9889 219 320 9895 MUX2_X1
* cell instance $25209 m0 *1 227.43,179.2
X$25209 9802 9801 9889 219 320 9707 MUX2_X1
* cell instance $25213 r0 *1 227.43,179.2
X$25213 219 14112 9889 9895 9979 320 DFF_X1
* cell instance $25215 m0 *1 229.9,179.2
X$25215 9812 7166 9802 219 320 9803 MUX2_X1
* cell instance $25217 m0 *1 232.94,179.2
X$25217 9686 7166 9685 219 320 9810 MUX2_X1
* cell instance $25220 m0 *1 236.55,179.2
X$25220 9891 7176 9890 219 320 9808 MUX2_X1
* cell instance $25221 m0 *1 237.88,179.2
X$25221 8496 219 320 9586 BUF_X1
* cell instance $25223 r0 *1 230.66,179.2
X$25223 219 13997 9802 9803 9979 320 DFF_X1
* cell instance $25229 r0 *1 234.46,179.2
X$25229 9806 219 320 10068 BUF_X1
* cell instance $25231 r0 *1 235.41,179.2
X$25231 219 14077 9890 9808 9979 320 DFF_X1
* cell instance $25232 r0 *1 238.64,179.2
X$25232 9891 7165 10072 219 320 9983 MUX2_X1
* cell instance $25233 m0 *1 239.02,179.2
X$25233 9761 219 320 9804 BUF_X1
* cell instance $25243 m0 *1 12.16,151.2
X$25243 7578 219 320 7345 BUF_X2
* cell instance $25251 r0 *1 8.36,151.2
X$25251 8011 219 320 7911 BUF_X1
* cell instance $25255 r0 *1 11.02,151.2
X$25255 219 14645 8013 7909 7910 320 DFF_X1
* cell instance $25257 r0 *1 14.44,151.2
X$25257 219 14149 8014 8082 7910 320 DFF_X1
* cell instance $25259 m0 *1 14.82,151.2
X$25259 7578 7177 7801 219 320 7857 MUX2_X1
* cell instance $25263 m0 *1 18.05,151.2
X$25263 219 13611 7803 7802 7910 320 DFF_X1
* cell instance $25268 r0 *1 20.14,151.2
X$25268 7765 219 320 7172 CLKBUF_X3
* cell instance $25269 r0 *1 21.09,151.2
X$25269 7172 219 320 14801 CLKBUF_X3
* cell instance $25272 m0 *1 23.94,151.2
X$25272 219 13555 7859 7804 7913 320 DFF_X1
* cell instance $25273 m0 *1 28.69,151.2
X$25273 219 12895 7806 7912 7913 320 DFF_X1
* cell instance $25275 m0 *1 32.68,151.2
X$25275 7861 1639 7807 219 320 7976 MUX2_X1
* cell instance $25279 r0 *1 25.27,151.2
X$25279 7911 219 320 7805 BUF_X2
* cell instance $25281 r0 *1 26.79,151.2
X$25281 7973 1639 8015 219 320 8016 MUX2_X1
* cell instance $25284 m0 *1 35.34,151.2
X$25284 219 13491 7711 7863 7914 320 DFF_X1
* cell instance $25289 m0 *1 39.14,151.2
X$25289 7350 5930 7978 219 320 7808 MUX2_X1
* cell instance $25294 r0 *1 39.71,151.2
X$25294 7805 5930 8092 219 320 8091 MUX2_X1
* cell instance $25296 m0 *1 41.8,151.2
X$25296 7583 6917 7978 219 320 7656 MUX2_X1
* cell instance $25299 m0 *1 43.32,151.2
X$25299 7350 5808 7657 219 320 7864 MUX2_X1
* cell instance $25300 m0 *1 44.65,151.2
X$25300 6606 219 320 7487 CLKBUF_X3
* cell instance $25305 r0 *1 42.75,151.2
X$25305 6458 320 1639 219 BUF_X4
* cell instance $25308 r0 *1 45.79,151.2
X$25308 7576 219 320 8020 BUF_X1
* cell instance $25311 m0 *1 49.97,151.2
X$25311 219 13464 7916 7981 7915 320 DFF_X1
* cell instance $25313 m0 *1 53.2,151.2
X$25313 219 13199 7917 7982 7918 320 DFF_X1
* cell instance $25314 m0 *1 56.43,151.2
X$25314 7917 5864 7489 219 320 7982 MUX2_X1
* cell instance $25316 m0 *1 57.95,151.2
X$25316 7917 7582 7919 219 320 7867 MUX2_X1
* cell instance $25317 m0 *1 59.28,151.2
X$25317 7489 5804 7919 219 320 7811 MUX2_X1
* cell instance $25319 m0 *1 62.13,151.2
X$25319 219 12777 7813 7920 7918 320 DFF_X1
* cell instance $25320 m0 *1 65.36,151.2
X$25320 219 12720 7814 7875 8022 320 DFF_X1
* cell instance $25321 m0 *1 68.59,151.2
X$25321 7814 7582 8024 219 320 7816 MUX2_X1
* cell instance $25325 r0 *1 51.3,151.2
X$25325 7489 6046 7916 219 320 7981 MUX2_X1
* cell instance $25329 r0 *1 57.38,151.2
X$25329 219 13880 7919 7811 7918 320 DFF_X1
* cell instance $25332 r0 *1 62.51,151.2
X$25332 219 13779 7873 7812 7918 320 DFF_X1
* cell instance $25337 r0 *1 66.5,151.2
X$25337 7489 6270 8024 219 320 8023 MUX2_X1
* cell instance $25339 m0 *1 72.58,151.2
X$25339 7590 7818 7713 219 320 7984 MUX2_X1
* cell instance $25340 m0 *1 71.82,151.2
X$25340 3264 7984 320 219 7817 AND2_X1
* cell instance $25341 m0 *1 73.91,151.2
X$25341 7495 7818 7592 219 320 7921 MUX2_X1
* cell instance $25343 m0 *1 76,151.2
X$25343 7367 7882 219 320 7985 XOR2_X1
* cell instance $25344 m0 *1 77.14,151.2
X$25344 7985 7820 219 320 7922 NOR2_X1
* cell instance $25345 m0 *1 77.71,151.2
X$25345 7986 219 320 7367 BUF_X2
* cell instance $25346 m0 *1 78.47,151.2
X$25346 219 13112 7821 7987 7822 320 DFF_X1
* cell instance $25348 r0 *1 73.91,151.2
X$25348 3264 7921 320 219 7880 AND2_X1
* cell instance $25352 r0 *1 76.76,151.2
X$25352 219 14595 7986 7922 8326 320 DFF_X1
* cell instance $25356 m0 *1 82.08,151.2
X$25356 219 13125 7989 7988 7822 320 DFF_X1
* cell instance $25359 m0 *1 90.63,151.2
X$25359 7379 7192 7925 219 320 7992 MUX2_X1
* cell instance $25361 r0 *1 82.27,151.2
X$25361 7252 7129 7989 219 320 7988 MUX2_X1
* cell instance $25363 r0 *1 83.79,151.2
X$25363 6915 7026 7923 219 320 8025 MUX2_X1
* cell instance $25365 r0 *1 85.31,151.2
X$25365 7989 5350 7923 219 320 7371 MUX2_X1
* cell instance $25370 r0 *1 89.49,151.2
X$25370 219 14188 7925 7992 7822 320 DFF_X1
* cell instance $25371 m0 *1 92.53,151.2
X$25371 7924 219 320 7379 BUF_X2
* cell instance $25373 m0 *1 93.29,151.2
X$25373 219 12617 7995 7996 7926 320 DFF_X1
* cell instance $25374 m0 *1 96.52,151.2
X$25374 7995 7492 7379 219 320 7996 MUX2_X1
* cell instance $25375 m0 *1 97.85,151.2
X$25375 5254 320 5816 219 BUF_X4
* cell instance $25380 r0 *1 93.48,151.2
X$25380 7925 4076 8026 219 320 7994 MUX2_X1
* cell instance $25384 r0 *1 96.14,151.2
X$25384 7995 5120 8108 219 320 7927 MUX2_X1
* cell instance $25387 r0 *1 100.89,151.2
X$25387 8027 5350 2998 219 320 8113 NOR3_X1
* cell instance $25390 r0 *1 102.22,151.2
X$25390 5122 320 5517 219 BUF_X4
* cell instance $25392 m0 *1 104.31,151.2
X$25392 7886 5819 7879 219 320 7824 MUX2_X1
* cell instance $25394 m0 *1 105.64,151.2
X$25394 7879 5421 219 320 7998 NOR2_X1
* cell instance $25395 m0 *1 106.21,151.2
X$25395 7886 5117 219 320 8116 NOR2_X1
* cell instance $25398 m0 *1 110.01,151.2
X$25398 219 7826 7827 7999 7928 320 DFF_X1
* cell instance $25400 m0 *1 113.43,151.2
X$25400 3264 7828 320 219 7999 AND2_X1
* cell instance $25402 m0 *1 114.38,151.2
X$25402 7827 7830 7930 320 219 7931 HA_X1
* cell instance $25403 m0 *1 116.28,151.2
X$25403 7825 7931 219 320 7719 NAND2_X1
* cell instance $25409 r0 *1 107.73,151.2
X$25409 219 8116 7998 8119 7865 8118 320 NOR4_X4
* cell instance $25411 r0 *1 111.53,151.2
X$25411 219 14672 7830 7929 7928 320 DFF_X1
* cell instance $25412 r0 *1 114.76,151.2
X$25412 1954 7829 320 219 7929 AND2_X1
* cell instance $25414 r0 *1 117.04,151.2
X$25414 219 13817 8120 8031 7928 320 DFF_X1
* cell instance $25420 m0 *1 124.26,151.2
X$25420 7607 7722 219 320 7603 OR2_X1
* cell instance $25425 m0 *1 127.49,151.2
X$25425 7932 4584 7933 219 320 8003 MUX2_X1
* cell instance $25426 m0 *1 128.82,151.2
X$25426 219 7610 7723 320 BUF_X32
* cell instance $25429 m0 *1 139.84,151.2
X$25429 219 13150 7936 7935 7726 320 DFF_X1
* cell instance $25430 m0 *1 143.07,151.2
X$25430 7936 3775 8039 219 320 7690 MUX2_X1
* cell instance $25436 r0 *1 125.78,151.2
X$25436 219 13698 7932 8032 8033 320 DFF_X1
* cell instance $25439 r0 *1 129.96,151.2
X$25439 219 13879 8035 8034 8033 320 DFF_X1
* cell instance $25440 r0 *1 133.19,151.2
X$25440 219 13681 8037 8036 7934 320 DFF_X1
* cell instance $25441 r0 *1 136.42,151.2
X$25441 8128 4383 8003 320 219 5534 OAI21_X4
* cell instance $25442 r0 *1 138.89,151.2
X$25442 4382 8127 219 8129 320 OR2_X4
* cell instance $25444 r0 *1 140.98,151.2
X$25444 219 14608 8039 8130 7726 320 DFF_X1
* cell instance $25446 m0 *1 144.97,151.2
X$25446 219 13137 8132 7937 7726 320 DFF_X1
* cell instance $25450 m0 *1 151.43,151.2
X$25450 7833 7900 8007 219 8008 320 AOI21_X1
* cell instance $25452 m0 *1 152.38,151.2
X$25452 219 8009 7615 7938 7728 9429 320 NAND4_X4
* cell instance $25453 m0 *1 155.8,151.2
X$25453 7796 8008 7902 320 219 7901 OAI21_X2
* cell instance $25457 r0 *1 144.97,151.2
X$25457 7611 8040 8132 219 320 7937 MUX2_X1
* cell instance $25461 r0 *1 147.63,151.2
X$25461 8133 3775 8132 219 320 7394 MUX2_X1
* cell instance $25464 r0 *1 149.91,151.2
X$25464 8134 8136 8010 320 8007 219 OAI21_X1
* cell instance $25466 r0 *1 151.05,151.2
X$25466 8135 219 320 8136 INV_X1
* cell instance $25467 r0 *1 151.43,151.2
X$25467 8247 219 320 8010 INV_X1
* cell instance $25468 r0 *1 151.81,151.2
X$25468 8042 8172 7900 7899 320 219 8009 AND4_X2
* cell instance $25470 r0 *1 153.33,151.2
X$25470 7210 8179 7938 320 219 8137 HA_X1
* cell instance $25474 r0 *1 159.22,151.2
X$25474 7451 7948 8045 320 219 8047 HA_X1
* cell instance $25476 m0 *1 159.79,151.2
X$25476 6956 7941 8044 320 219 8006 HA_X1
* cell instance $25477 m0 *1 167.77,151.2
X$25477 7903 8049 7940 7736 7679 8005 320 219 AOI221_X2
* cell instance $25478 m0 *1 169.86,151.2
X$25478 7397 219 320 8004 BUF_X1
* cell instance $25481 m0 *1 174.23,151.2
X$25481 1023 219 320 7841 INV_X1
* cell instance $25482 m0 *1 174.61,151.2
X$25482 7944 7729 6982 7505 219 320 7943 AOI22_X1
* cell instance $25483 m0 *1 175.56,151.2
X$25483 8002 6636 7840 219 7904 320 AOI21_X1
* cell instance $25487 r0 *1 167.39,151.2
X$25487 8356 7605 8004 7939 320 219 7940 OAI22_X2
* cell instance $25489 r0 *1 169.29,151.2
X$25489 7939 7941 7942 6673 320 219 8144 OAI22_X2
* cell instance $25491 r0 *1 171.76,151.2
X$25491 7939 320 3730 219 BUF_X4
* cell instance $25493 r0 *1 173.85,151.2
X$25493 1023 219 320 8178 BUF_X1
* cell instance $25494 r0 *1 174.42,151.2
X$25494 7522 8051 7943 7207 4470 320 219 8141 OAI221_X1
* cell instance $25498 r0 *1 175.56,151.2
X$25498 8052 8051 7207 6540 320 219 8143 OAI22_X2
* cell instance $25500 m0 *1 176.7,151.2
X$25500 7945 7605 7397 8001 320 219 8000 OAI22_X2
* cell instance $25501 m0 *1 178.6,151.2
X$25501 7895 6951 8000 7736 7151 7997 320 219 AOI221_X2
* cell instance $25503 r0 *1 177.27,151.2
X$25503 7397 219 320 7843 BUF_X1
* cell instance $25504 r0 *1 177.84,151.2
X$25504 8052 7941 7521 6987 320 219 8139 OAI22_X2
* cell instance $25505 r0 *1 179.55,151.2
X$25505 8220 8179 7406 7841 219 320 8055 AOI22_X1
* cell instance $25507 r0 *1 180.69,151.2
X$25507 7058 8054 8057 7941 4239 320 219 8058 OAI221_X1
* cell instance $25509 m0 *1 181.07,151.2
X$25509 219 7892 7148 7844 7997 320 AOI21_X4
* cell instance $25512 r0 *1 182.78,151.2
X$25512 6635 320 8115 219 BUF_X4
* cell instance $25513 m0 *1 185.63,151.2
X$25513 7891 5533 219 320 7871 NOR2_X1
* cell instance $25514 m0 *1 183.92,151.2
X$25514 7462 7832 7948 7845 320 219 7991 OAI22_X2
* cell instance $25515 m0 *1 186.2,151.2
X$25515 7944 7946 6982 7947 219 320 7993 AOI22_X1
* cell instance $25519 r0 *1 186.39,151.2
X$25519 7832 219 320 7946 INV_X1
* cell instance $25520 r0 *1 186.77,151.2
X$25520 7522 7948 7993 7410 4470 320 219 8181 OAI221_X1
* cell instance $25521 m0 *1 189.62,151.2
X$25521 6540 7410 7948 5901 320 219 7847 OAI22_X2
* cell instance $25522 m0 *1 187.53,151.2
X$25522 4938 7628 7991 7947 7949 7990 320 219 AOI221_X2
* cell instance $25524 m0 *1 192.09,151.2
X$25524 7846 5033 7949 1079 219 320 7950 AOI22_X1
* cell instance $25525 m0 *1 193.04,151.2
X$25525 7845 320 5898 219 BUF_X4
* cell instance $25526 m0 *1 194.37,151.2
X$25526 7845 320 4523 219 BUF_X4
* cell instance $25530 r0 *1 187.91,151.2
X$25530 6068 7410 7948 7939 320 219 8126 OAI22_X2
* cell instance $25531 r0 *1 189.62,151.2
X$25531 7946 8123 7847 7947 7406 8061 320 219 AOI221_X2
* cell instance $25532 r0 *1 191.71,151.2
X$25532 8052 320 5901 219 BUF_X4
* cell instance $25535 r0 *1 193.99,151.2
X$25535 8056 320 7102 219 BUF_X4
* cell instance $25536 r0 *1 195.32,151.2
X$25536 7522 7952 7983 7782 6020 320 219 8111 OAI221_X1
* cell instance $25537 r0 *1 196.46,151.2
X$25537 6982 693 7849 2967 219 320 7983 AOI22_X1
* cell instance $25538 r0 *1 197.41,151.2
X$25538 8111 8115 6713 219 7980 320 AOI21_X1
* cell instance $25542 m0 *1 200.83,151.2
X$25542 8066 3725 219 320 7862 NOR2_X1
* cell instance $25544 m0 *1 201.4,151.2
X$25544 8067 7884 6680 219 7872 320 AOI21_X1
* cell instance $25548 r0 *1 201.02,151.2
X$25548 8106 6394 6680 219 8066 320 AOI21_X1
* cell instance $25549 r0 *1 201.78,151.2
X$25549 8103 7884 2293 219 7979 320 AOI21_X1
* cell instance $25551 m0 *1 205.77,151.2
X$25551 7979 5977 219 320 7078 NOR2_X1
* cell instance $25555 r0 *1 205.77,151.2
X$25555 7980 6328 219 320 7954 NOR2_X1
* cell instance $25557 m0 *1 206.91,151.2
X$25557 219 13304 7853 7869 6063 320 DFF_X1
* cell instance $25559 m0 *1 210.14,151.2
X$25559 7853 6398 7953 219 320 7745 MUX2_X1
* cell instance $25564 m0 *1 216.98,151.2
X$25564 7974 7957 7956 320 219 7397 OAI21_X4
* cell instance $25567 r0 *1 207.86,151.2
X$25567 219 14416 7953 7977 8102 320 DFF_X1
* cell instance $25568 r0 *1 211.09,151.2
X$25568 7852 6843 7953 219 320 7977 MUX2_X1
* cell instance $25571 r0 *1 214.32,151.2
X$25571 219 13984 7955 8069 7162 320 DFF_X1
* cell instance $25572 r0 *1 217.55,151.2
X$25572 7955 7539 8099 219 320 7956 MUX2_X1
* cell instance $25574 r0 *1 220.4,151.2
X$25574 219 14576 8071 8097 7958 320 DFF_X1
* cell instance $25576 m0 *1 220.59,151.2
X$25576 219 13551 7959 7975 7958 320 DFF_X1
* cell instance $25577 m0 *1 224.01,151.2
X$25577 6410 7972 219 320 7974 OR2_X1
* cell instance $25580 r0 *1 223.63,151.2
X$25580 8071 7420 7959 219 320 7972 MUX2_X1
* cell instance $25582 r0 *1 225.72,151.2
X$25582 219 13841 8074 7971 7958 320 DFF_X1
* cell instance $25583 m0 *1 228.38,151.2
X$25583 219 13503 7960 7970 7958 320 DFF_X1
* cell instance $25586 r0 *1 228.95,151.2
X$25586 8072 7750 8074 219 320 7971 MUX2_X1
* cell instance $25588 r0 *1 230.47,151.2
X$25588 8072 7751 7960 219 320 7970 MUX2_X1
* cell instance $25593 m0 *1 235.22,151.2
X$25593 7961 7751 7967 219 320 7968 MUX2_X1
* cell instance $25594 m0 *1 231.99,151.2
X$25594 219 13164 7967 7968 8086 320 DFF_X1
* cell instance $25596 m0 *1 237.31,151.2
X$25596 7862 219 320 7854 BUF_X1
* cell instance $25597 m0 *1 237.88,151.2
X$25597 7850 219 320 7755 BUF_X1
* cell instance $25598 m0 *1 238.45,151.2
X$25598 7285 219 320 7964 BUF_X1
* cell instance $25599 m0 *1 239.02,151.2
X$25599 8068 219 320 7856 BUF_X1
* cell instance $25600 m0 *1 239.59,151.2
X$25600 7951 219 320 7533 BUF_X1
* cell instance $25601 m0 *1 240.16,151.2
X$25601 7535 219 320 6846 BUF_X1
* cell instance $25603 r0 *1 232.18,151.2
X$25603 7961 7750 8077 219 320 8087 MUX2_X1
* cell instance $25605 r0 *1 233.89,151.2
X$25605 6410 8076 219 320 8075 OR2_X2
* cell instance $25607 r0 *1 235.6,151.2
X$25607 7961 7753 7962 219 320 8084 MUX2_X1
* cell instance $25608 r0 *1 236.93,151.2
X$25608 7961 7749 7963 219 320 8078 MUX2_X1
* cell instance $25611 r0 *1 238.83,151.2
X$25611 7954 219 320 7965 BUF_X1
* cell instance $25614 r0 *1 239.97,151.2
X$25614 8081 219 320 7224 BUF_X2
* cell instance $25621 m0 *1 13.87,148.4
X$25621 219 13567 7580 7579 7427 320 DFF_X1
* cell instance $25625 m0 *1 19.57,148.4
X$25625 7483 1639 7704 219 320 7705 MUX2_X1
* cell instance $25626 m0 *1 20.9,148.4
X$25626 7705 2719 7651 219 320 7969 MUX2_X1
* cell instance $25627 m0 *1 22.23,148.4
X$25627 219 13554 7707 7706 7299 320 DFF_X1
* cell instance $25630 m0 *1 26.41,148.4
X$25630 7484 7482 7581 219 320 7973 MUX2_X1
* cell instance $25641 r0 *1 14.06,148.4
X$25641 219 14093 7801 7857 7427 320 DFF_X1
* cell instance $25643 r0 *1 18.05,148.4
X$25643 7345 6853 7803 219 320 7802 MUX2_X1
* cell instance $25645 r0 *1 19.57,148.4
X$25645 7801 7482 7803 219 320 7704 MUX2_X1
* cell instance $25647 r0 *1 21.66,148.4
X$25647 7707 5801 7805 219 320 7706 MUX2_X1
* cell instance $25650 r0 *1 23.94,148.4
X$25650 7911 6156 7859 219 320 7804 MUX2_X1
* cell instance $25653 r0 *1 26.22,148.4
X$25653 7707 7482 7859 219 320 7861 MUX2_X1
* cell instance $25657 r0 *1 28.88,148.4
X$25657 7911 6121 7806 219 320 7912 MUX2_X1
* cell instance $25659 m0 *1 29.64,148.4
X$25659 219 12839 7708 7759 7299 320 DFF_X1
* cell instance $25661 m0 *1 33.82,148.4
X$25661 219 13387 7710 7709 7236 320 DFF_X1
* cell instance $25663 m0 *1 37.24,148.4
X$25663 7710 6917 7711 219 320 7762 MUX2_X1
* cell instance $25665 r0 *1 30.21,148.4
X$25665 7805 6042 7708 219 320 7759 MUX2_X1
* cell instance $25668 r0 *1 32.11,148.4
X$25668 7708 7482 7806 219 320 7807 MUX2_X1
* cell instance $25671 r0 *1 34.58,148.4
X$25671 7710 5864 7350 219 320 7709 MUX2_X1
* cell instance $25674 r0 *1 37.05,148.4
X$25674 7350 5804 7711 219 320 7863 MUX2_X1
* cell instance $25677 m0 *1 38.95,148.4
X$25677 219 13364 7583 7763 7487 320 DFF_X1
* cell instance $25678 r0 *1 39.14,148.4
X$25678 219 14220 7978 7808 7487 320 DFF_X1
* cell instance $25680 m0 *1 42.75,148.4
X$25680 219 13365 7585 7584 7487 320 DFF_X1
* cell instance $25682 m0 *1 45.98,148.4
X$25682 7765 219 320 6606 CLKBUF_X3
* cell instance $25684 r0 *1 42.75,148.4
X$25684 7487 219 320 14789 INV_X1
* cell instance $25685 r0 *1 43.13,148.4
X$25685 219 13855 7657 7864 7487 320 DFF_X1
* cell instance $25687 m0 *1 47.5,148.4
X$25687 7661 7712 5819 320 219 7865 MUX2_X2
* cell instance $25690 m0 *1 50.73,148.4
X$25690 7587 5801 7489 219 320 7766 MUX2_X1
* cell instance $25691 m0 *1 52.06,148.4
X$25691 7017 5933 7809 219 320 7767 MUX2_X1
* cell instance $25695 r0 *1 49.78,148.4
X$25695 219 13691 7809 7767 7240 320 DFF_X1
* cell instance $25696 r0 *1 53.01,148.4
X$25696 7809 7582 7916 219 320 7868 MUX2_X1
* cell instance $25699 m0 *1 56.62,148.4
X$25699 7703 219 320 7024 BUF_X1
* cell instance $25700 m0 *1 55.29,148.4
X$25700 7768 4997 7770 219 320 7771 MUX2_X1
* cell instance $25705 m0 *1 71.06,148.4
X$25705 219 7817 6914 7556 7590 320 DFF_X2
* cell instance $25709 r0 *1 55.67,148.4
X$25709 7867 4997 7868 219 320 7810 MUX2_X1
* cell instance $25710 r0 *1 57,148.4
X$25710 7810 5517 7771 219 320 7886 MUX2_X1
* cell instance $25714 r0 *1 61.94,148.4
X$25714 7813 6110 7489 219 320 7920 MUX2_X1
* cell instance $25719 r0 *1 63.46,148.4
X$25719 7489 5930 7873 219 320 7812 MUX2_X1
* cell instance $25721 r0 *1 64.98,148.4
X$25721 7813 7582 7873 219 320 7876 MUX2_X1
* cell instance $25722 r0 *1 66.31,148.4
X$25722 7489 5808 7814 219 320 7875 MUX2_X1
* cell instance $25723 r0 *1 67.64,148.4
X$25723 7876 4997 7816 219 320 7815 MUX2_X1
* cell instance $25724 r0 *1 68.97,148.4
X$25724 7815 6337 7189 219 320 7879 MUX2_X1
* cell instance $25726 r0 *1 70.68,148.4
X$25726 219 7880 6914 7592 7495 320 DFF_X2
* cell instance $25727 r0 *1 74.29,148.4
X$25727 7495 7590 12552 320 219 7714 HA_X1
* cell instance $25729 m0 *1 75.81,148.4
X$25729 7714 219 320 7250 BUF_X1
* cell instance $25732 r0 *1 76.19,148.4
X$25732 7818 7495 7590 7368 219 320 7882 NAND4_X1
* cell instance $25733 r0 *1 77.14,148.4
X$25733 7818 7250 219 320 7883 NAND2_X1
* cell instance $25734 r0 *1 77.71,148.4
X$25734 7597 7883 320 219 7819 XNOR2_X1
* cell instance $25735 r0 *1 78.85,148.4
X$25735 7819 7820 219 320 7987 NOR2_X1
* cell instance $25737 m0 *1 79.04,148.4
X$25737 7591 219 320 7596 INV_X4
* cell instance $25741 m0 *1 84.36,148.4
X$25741 6915 7027 7777 219 320 7776 MUX2_X1
* cell instance $25742 m0 *1 81.13,148.4
X$25742 219 13106 7598 7669 7254 320 DFF_X1
* cell instance $25745 r0 *1 81.32,148.4
X$25745 7821 219 320 7368 BUF_X2
* cell instance $25747 r0 *1 83.6,148.4
X$25747 219 13856 7777 7776 7254 320 DFF_X1
* cell instance $25751 r0 *1 88.92,148.4
X$25751 7924 7356 7780 219 320 7715 MUX2_X1
* cell instance $25753 m0 *1 89.11,148.4
X$25753 219 13531 7780 7715 7822 320 DFF_X1
* cell instance $25754 m0 *1 93.1,148.4
X$25754 219 12585 7885 7716 6919 320 DFF_X1
* cell instance $25758 r0 *1 91.2,148.4
X$25758 5117 320 1643 219 BUF_X4
* cell instance $25759 r0 *1 92.53,148.4
X$25759 7924 7089 7885 219 320 7716 MUX2_X1
* cell instance $25761 r0 *1 94.62,148.4
X$25761 7994 6917 5515 219 320 7375 NOR3_X1
* cell instance $25765 r0 *1 96.71,148.4
X$25765 7885 4076 7717 219 320 7498 MUX2_X1
* cell instance $25767 m0 *1 96.71,148.4
X$25767 219 12997 7717 7674 7378 320 DFF_X1
* cell instance $25771 m0 *1 105.45,148.4
X$25771 7379 7027 7785 219 320 7888 MUX2_X1
* cell instance $25773 m0 *1 106.97,148.4
X$25773 7718 7312 7379 219 320 7600 MUX2_X1
* cell instance $25775 m0 *1 108.49,148.4
X$25775 7718 6057 7785 219 320 7461 MUX2_X1
* cell instance $25779 r0 *1 98.04,148.4
X$25779 7927 5077 7823 219 320 6280 MUX2_X1
* cell instance $25782 r0 *1 101.27,148.4
X$25782 5819 320 5117 219 BUF_X4
* cell instance $25783 r0 *1 102.6,148.4
X$25783 219 5946 320 5117 BUF_X8
* cell instance $25785 r0 *1 105.83,148.4
X$25785 219 13662 7785 7888 7378 320 DFF_X1
* cell instance $25789 r0 *1 111.53,148.4
X$25789 7826 7825 219 320 7890 XOR2_X1
* cell instance $25791 m0 *1 112.48,148.4
X$25791 7890 3238 219 320 7786 NOR2_X1
* cell instance $25793 m0 *1 114,148.4
X$25793 7602 7719 219 320 7720 XOR2_X1
* cell instance $25795 m0 *1 115.33,148.4
X$25795 7682 7893 219 320 7787 XOR2_X1
* cell instance $25798 r0 *1 112.67,148.4
X$25798 7827 7825 7826 219 320 7828 MUX2_X1
* cell instance $25799 r0 *1 114,148.4
X$25799 7830 7825 7930 219 320 7829 MUX2_X1
* cell instance $25800 r0 *1 115.33,148.4
X$25800 7825 7827 7830 7602 219 320 7893 NAND4_X1
* cell instance $25806 m0 *1 120.08,148.4
X$25806 7265 6622 7831 219 320 7894 MUX2_X1
* cell instance $25809 m0 *1 121.6,148.4
X$25809 7335 6622 7721 219 320 7788 MUX2_X1
* cell instance $25812 r0 *1 120.46,148.4
X$25812 219 14051 7831 7894 7037 320 DFF_X1
* cell instance $25814 m0 *1 123.31,148.4
X$25814 7721 7723 7790 219 320 7722 MUX2_X1
* cell instance $25815 m0 *1 124.83,148.4
X$25815 219 13472 7790 7896 6925 320 DFF_X1
* cell instance $25816 m0 *1 128.06,148.4
X$25816 219 13465 7791 7724 6925 320 DFF_X1
* cell instance $25818 r0 *1 123.69,148.4
X$25818 7335 6719 7790 219 320 7896 MUX2_X1
* cell instance $25822 r0 *1 127.11,148.4
X$25822 7265 6719 7791 219 320 7724 MUX2_X1
* cell instance $25823 r0 *1 128.44,148.4
X$25823 7831 7723 7791 219 320 7685 MUX2_X1
* cell instance $25825 r0 *1 130.53,148.4
X$25825 4294 320 7691 219 BUF_X4
* cell instance $25826 m0 *1 133,148.4
X$25826 219 7501 4584 320 BUF_X16
* cell instance $25827 m0 *1 131.67,148.4
X$25827 7723 320 2909 219 BUF_X4
* cell instance $25828 m0 *1 137.75,148.4
X$25828 7725 7387 5359 320 219 7729 MUX2_X2
* cell instance $25831 m0 *1 140.41,148.4
X$25831 219 13152 7388 7793 7384 320 DFF_X1
* cell instance $25832 m0 *1 143.64,148.4
X$25832 219 13134 7573 7795 7726 320 DFF_X1
* cell instance $25833 m0 *1 146.87,148.4
X$25833 5359 320 4382 219 BUF_X4
* cell instance $25837 m0 *1 150.67,148.4
X$25837 7399 7405 7899 320 219 7727 HA_X1
* cell instance $25839 m0 *1 152.76,148.4
X$25839 7274 6830 7728 320 219 7836 HA_X1
* cell instance $25845 m0 *1 166.25,148.4
X$25845 7799 7569 219 320 7906 NAND2_X1
* cell instance $25847 r0 *1 131.86,148.4
X$25847 7607 219 320 3138 CLKBUF_X3
* cell instance $25848 r0 *1 132.81,148.4
X$25848 219 7610 7501 320 BUF_X16
* cell instance $25850 r0 *1 138.32,148.4
X$25850 219 3262 320 7606 BUF_X8
* cell instance $25854 r0 *1 150.29,148.4
X$25854 7451 7832 7900 320 219 7834 HA_X1
* cell instance $25855 r0 *1 152.19,148.4
X$25855 7727 7834 7836 219 320 7833 OR3_X1
* cell instance $25856 r0 *1 153.14,148.4
X$25856 7727 7899 7728 320 7835 219 OAI21_X1
* cell instance $25857 r0 *1 153.9,148.4
X$25857 7835 219 320 7837 INV_X1
* cell instance $25858 r0 *1 154.28,148.4
X$25858 7836 7837 7615 320 7902 219 OAI21_X1
* cell instance $25864 r0 *1 166.25,148.4
X$25864 7620 7906 7730 320 7907 219 OAI21_X1
* cell instance $25865 r0 *1 167.01,148.4
X$25865 7620 7906 7839 320 7908 219 OAI21_X1
* cell instance $25866 m0 *1 167.39,148.4
X$25866 7700 7507 219 320 7730 NOR2_X1
* cell instance $25868 m0 *1 167.96,148.4
X$25868 7508 7472 219 320 7799 NAND2_X1
* cell instance $25870 m0 *1 168.72,148.4
X$25870 7798 7800 7506 7731 320 219 7702 AND4_X2
* cell instance $25872 m0 *1 170.24,148.4
X$25872 7210 7841 7800 320 219 7732 HA_X1
* cell instance $25874 m0 *1 172.33,148.4
X$25874 7622 7513 7733 219 7621 320 AOI21_X1
* cell instance $25875 m0 *1 173.09,148.4
X$25875 1463 219 320 7521 BUF_X1
* cell instance $25876 m0 *1 173.66,148.4
X$25876 7798 219 320 7518 BUF_X1
* cell instance $25879 r0 *1 167.77,148.4
X$25879 7838 7507 219 320 7839 NOR2_X1
* cell instance $25884 r0 *1 171.19,148.4
X$25884 1463 219 320 7942 BUF_X1
* cell instance $25886 r0 *1 172.14,148.4
X$25886 7732 219 320 7733 INV_X1
* cell instance $25888 r0 *1 173.28,148.4
X$25888 7516 219 320 7903 BUF_X1
* cell instance $25894 r0 *1 175.75,148.4
X$25894 5898 7843 7842 7605 5837 320 219 8002 OAI221_X1
* cell instance $25895 m0 *1 177.84,148.4
X$25895 7736 7314 7734 7516 7406 7898 320 219 AOI221_X2
* cell instance $25896 m0 *1 176.13,148.4
X$25896 6186 7605 7843 5901 320 219 7734 OAI22_X2
* cell instance $25897 m0 *1 179.93,148.4
X$25897 3058 7792 7680 219 7794 320 AOI21_X2
* cell instance $25903 r0 *1 177.46,148.4
X$25903 7843 219 320 7683 BUF_X1
* cell instance $25904 r0 *1 178.03,148.4
X$25904 7051 7897 7898 219 7860 320 AOI21_X2
* cell instance $25905 r0 *1 179.36,148.4
X$25905 7840 6539 219 320 7897 NAND2_X1
* cell instance $25906 r0 *1 179.93,148.4
X$25906 7846 7736 6835 7516 219 320 7842 AOI22_X1
* cell instance $25907 r0 *1 180.88,148.4
X$25907 7516 219 320 7895 BUF_X1
* cell instance $25908 r0 *1 181.45,148.4
X$25908 7840 6184 219 320 7792 NAND2_X1
* cell instance $25909 r0 *1 182.02,148.4
X$25909 7840 6833 219 320 7844 NAND2_X1
* cell instance $25911 m0 *1 184.11,148.4
X$25911 3058 7677 7525 219 7761 320 AOI21_X2
* cell instance $25914 m0 *1 186.2,148.4
X$25914 7738 5533 219 320 7757 NOR2_X1
* cell instance $25915 m0 *1 186.77,148.4
X$25915 6538 7832 7789 1298 3698 320 219 7739 OAI221_X1
* cell instance $25916 m0 *1 187.91,148.4
X$25916 7740 4938 7106 7887 219 320 7789 AOI22_X1
* cell instance $25919 r0 *1 184.11,148.4
X$25919 7626 6955 7676 219 7891 320 AOI21_X1
* cell instance $25922 r0 *1 186.01,148.4
X$25922 7739 6955 7889 219 7738 320 AOI21_X1
* cell instance $25923 r0 *1 186.77,148.4
X$25923 1298 219 320 7947 INV_X2
* cell instance $25926 r0 *1 188.48,148.4
X$25926 7948 219 320 7887 INV_X1
* cell instance $25928 r0 *1 189.24,148.4
X$25928 7735 219 320 7846 INV_X1
* cell instance $25930 r0 *1 190,148.4
X$25930 7846 320 7628 219 BUF_X4
* cell instance $25932 r0 *1 191.71,148.4
X$25932 7848 320 6636 219 BUF_X4
* cell instance $25933 m0 *1 192.85,148.4
X$25933 6835 689 7628 1970 219 320 7784 AOI22_X1
* cell instance $25934 m0 *1 192.28,148.4
X$25934 7741 5958 219 320 7951 NOR2_X1
* cell instance $25935 m0 *1 193.8,148.4
X$25935 6951 693 7740 2967 219 320 7783 AOI22_X1
* cell instance $25936 m0 *1 194.75,148.4
X$25936 4736 7782 7783 7952 4239 320 219 7417 OAI221_X1
* cell instance $25937 m0 *1 195.89,148.4
X$25937 7522 7315 7742 7201 6020 320 219 7781 OAI221_X1
* cell instance $25938 m0 *1 197.03,148.4
X$25938 7781 6184 6586 219 7779 320 AOI21_X1
* cell instance $25939 m0 *1 197.79,148.4
X$25939 7627 5958 219 320 7769 NOR2_X1
* cell instance $25941 m0 *1 199.12,148.4
X$25941 7527 219 320 7778 BUF_X1
* cell instance $25942 m0 *1 199.69,148.4
X$25942 7778 219 320 7667 BUF_X1
* cell instance $25943 m0 *1 200.26,148.4
X$25943 7779 3792 219 320 7772 NOR2_X1
* cell instance $25948 r0 *1 193.23,148.4
X$25948 4304 219 320 7848 INV_X1
* cell instance $25950 r0 *1 193.8,148.4
X$25950 4523 7315 7784 7201 5837 320 219 7881 OAI221_X1
* cell instance $25952 r0 *1 195.13,148.4
X$25952 7848 219 320 7884 CLKBUF_X3
* cell instance $25953 r0 *1 196.08,148.4
X$25953 6982 689 7849 1970 219 320 7742 AOI22_X1
* cell instance $25955 r0 *1 197.22,148.4
X$25955 7881 7884 6586 219 7877 320 AOI21_X1
* cell instance $25959 r0 *1 200.45,148.4
X$25959 7878 5979 219 320 7850 NOR2_X1
* cell instance $25960 r0 *1 201.02,148.4
X$25960 7877 3282 219 320 7851 NOR2_X1
* cell instance $25961 r0 *1 201.59,148.4
X$25961 7872 3282 219 320 7758 NOR2_X1
* cell instance $25964 m0 *1 205.96,148.4
X$25964 219 13302 7743 7870 6190 320 DFF_X1
* cell instance $25966 m0 *1 209.19,148.4
X$25966 7743 6398 7744 219 320 7746 MUX2_X1
* cell instance $25968 m0 *1 210.71,148.4
X$25968 7745 7746 6477 320 219 6731 MUX2_X2
* cell instance $25970 m0 *1 213.18,148.4
X$25970 3243 7774 320 219 7775 AND2_X1
* cell instance $25971 m0 *1 213.94,148.4
X$25971 7636 7418 7635 219 320 7774 MUX2_X1
* cell instance $25972 m0 *1 215.27,148.4
X$25972 7419 7636 12528 320 219 7773 HA_X1
* cell instance $25973 m0 *1 217.17,148.4
X$25973 7530 7773 219 320 7747 NAND2_X1
* cell instance $25974 m0 *1 217.74,148.4
X$25974 7747 320 4941 219 BUF_X4
* cell instance $25975 m0 *1 219.07,148.4
X$25975 7530 7637 219 320 7748 NAND2_X1
* cell instance $25976 m0 *1 219.64,148.4
X$25976 7748 320 5162 219 BUF_X4
* cell instance $25977 m0 *1 220.97,148.4
X$25977 7162 219 320 14734 INV_X1
* cell instance $25980 r0 *1 206.91,148.4
X$25980 7852 6861 7743 219 320 7870 MUX2_X1
* cell instance $25981 r0 *1 208.24,148.4
X$25981 7852 6740 7744 219 320 7665 MUX2_X1
* cell instance $25982 r0 *1 209.57,148.4
X$25982 7852 6860 7853 219 320 7869 MUX2_X1
* cell instance $25984 r0 *1 211.66,148.4
X$25984 7866 7251 219 320 7530 NOR2_X2
* cell instance $25988 r0 *1 219.26,148.4
X$25988 5757 219 320 7162 CLKBUF_X3
* cell instance $25991 m0 *1 221.73,148.4
X$25991 7957 320 5445 219 BUF_X4
* cell instance $25992 m0 *1 223.25,148.4
X$25992 7639 7749 7541 219 320 7660 MUX2_X1
* cell instance $25994 m0 *1 225.15,148.4
X$25994 219 13593 7290 7764 7292 320 DFF_X1
* cell instance $25996 m0 *1 228.38,148.4
X$25996 7639 7751 7290 219 320 7764 MUX2_X1
* cell instance $26000 m0 *1 231.04,148.4
X$26000 4941 219 320 7751 CLKBUF_X3
* cell instance $26002 m0 *1 231.99,148.4
X$26002 5162 320 7749 219 BUF_X4
* cell instance $26003 m0 *1 233.32,148.4
X$26003 7752 7750 7642 219 320 7760 MUX2_X1
* cell instance $26004 m0 *1 234.65,148.4
X$26004 7752 7751 7426 219 320 7641 MUX2_X1
* cell instance $26005 m0 *1 235.98,148.4
X$26005 5160 320 7753 219 BUF_X4
* cell instance $26006 m0 *1 237.31,148.4
X$26006 7752 7749 7649 219 320 7537 MUX2_X1
* cell instance $26008 m0 *1 238.83,148.4
X$26008 7758 219 320 7297 BUF_X1
* cell instance $26009 m0 *1 239.4,148.4
X$26009 7645 219 320 6796 BUF_X2
* cell instance $26010 m0 *1 240.16,148.4
X$26010 7534 219 320 7155 BUF_X1
* cell instance $26017 r0 *1 234.08,148.4
X$26017 7761 219 320 7756 BUF_X1
* cell instance $26019 r0 *1 234.84,148.4
X$26019 7794 219 320 7643 BUF_X1
* cell instance $26021 r0 *1 236.17,148.4
X$26021 7464 219 320 7423 BUF_X1
* cell instance $26022 r0 *1 236.74,148.4
X$26022 7851 219 320 7855 BUF_X1
* cell instance $26024 r0 *1 237.69,148.4
X$26024 7752 7753 7296 219 320 7858 MUX2_X1
* cell instance $26026 r0 *1 239.21,148.4
X$26026 7757 219 320 7644 BUF_X1
* cell instance $26027 r0 *1 239.78,148.4
X$26027 7208 219 320 7754 BUF_X1
* cell instance $26041 r0 *1 9.5,142.8
X$26041 7646 219 320 6897 BUF_X1
* cell instance $26045 r0 *1 11.4,142.8
X$26045 7480 6902 7345 219 320 7536 MUX2_X1
* cell instance $26047 m0 *1 15.01,142.8
X$26047 219 13565 7346 7424 7427 320 DFF_X1
* cell instance $26049 m0 *1 18.24,142.8
X$26049 219 13589 7347 7425 7427 320 DFF_X1
* cell instance $26052 m0 *1 23.75,142.8
X$26052 3990 320 6154 219 BUF_X4
* cell instance $26053 m0 *1 25.08,142.8
X$26053 6897 7348 7234 219 320 7233 MUX2_X1
* cell instance $26055 m0 *1 29.45,142.8
X$26055 7182 6002 7237 219 320 7235 MUX2_X1
* cell instance $26056 m0 *1 30.78,142.8
X$26056 7182 5923 7349 219 320 7428 MUX2_X1
* cell instance $26058 m0 *1 32.3,142.8
X$26058 219 13355 7125 7178 7236 320 DFF_X1
* cell instance $26060 m0 *1 35.72,142.8
X$26060 7238 5801 7350 219 320 7300 MUX2_X1
* cell instance $26063 r0 *1 15.96,142.8
X$26063 7345 6802 7481 219 320 7538 MUX2_X1
* cell instance $26065 r0 *1 18.81,142.8
X$26065 7346 6906 7345 219 320 7424 MUX2_X1
* cell instance $26066 r0 *1 20.14,142.8
X$26066 7345 7081 7347 219 320 7425 MUX2_X1
* cell instance $26070 r0 *1 26.79,142.8
X$26070 4277 320 7348 219 BUF_X4
* cell instance $26073 r0 *1 30.4,142.8
X$26073 219 14000 7349 7428 7236 320 DFF_X1
* cell instance $26075 r0 *1 34.01,142.8
X$26075 7237 7582 7349 219 320 7485 MUX2_X1
* cell instance $26078 m0 *1 37.43,142.8
X$26078 7182 219 320 7350 CLKBUF_X2
* cell instance $26079 m0 *1 38.38,142.8
X$26079 219 13507 7352 7351 6908 320 DFF_X1
* cell instance $26082 m0 *1 43.32,142.8
X$26082 219 13217 7353 7239 7487 320 DFF_X1
* cell instance $26086 r0 *1 38.38,142.8
X$26086 7350 6046 7352 219 320 7351 MUX2_X1
* cell instance $26088 r0 *1 40.09,142.8
X$26088 7127 6917 7352 219 320 7486 MUX2_X1
* cell instance $26091 r0 *1 43.13,142.8
X$26091 7350 6042 7353 219 320 7239 MUX2_X1
* cell instance $26092 r0 *1 44.46,142.8
X$26092 7184 2752 7433 219 320 7586 MUX2_X1
* cell instance $26093 r0 *1 45.79,142.8
X$26093 7353 7582 7185 219 320 7433 MUX2_X1
* cell instance $26098 r0 *1 51.49,142.8
X$26098 7240 219 320 CLKBUF_X1
* cell instance $26099 r0 *1 52.06,142.8
X$26099 6606 219 320 7240 CLKBUF_X3
* cell instance $26100 r0 *1 53.01,142.8
X$26100 7017 6121 7434 219 320 7435 MUX2_X1
* cell instance $26102 m0 *1 53.77,142.8
X$26102 7242 6207 7489 219 320 7304 MUX2_X1
* cell instance $26104 m0 *1 61.37,142.8
X$26104 7354 1374 7355 219 320 7088 MUX2_X1
* cell instance $26107 r0 *1 54.34,142.8
X$26107 219 13754 7434 7435 7240 320 DFF_X1
* cell instance $26110 r0 *1 59.85,142.8
X$26110 219 14050 7355 7437 7023 320 DFF_X1
* cell instance $26115 r0 *1 63.46,142.8
X$26115 7024 7356 7357 219 320 7491 MUX2_X1
* cell instance $26116 m0 *1 64.03,142.8
X$26116 7024 219 320 6612 BUF_X2
* cell instance $26118 m0 *1 64.79,142.8
X$26118 4237 320 7192 219 BUF_X4
* cell instance $26120 m0 *1 66.88,142.8
X$26120 4359 320 7089 219 BUF_X4
* cell instance $26121 m0 *1 68.21,142.8
X$26121 7358 320 4237 219 BUF_X4
* cell instance $26122 m0 *1 69.54,142.8
X$26122 7362 7360 219 320 7130 NAND2_X1
* cell instance $26123 m0 *1 70.11,142.8
X$26123 7359 320 4278 219 BUF_X4
* cell instance $26124 m0 *1 71.44,142.8
X$26124 7362 7361 219 320 7311 NAND2_X1
* cell instance $26125 m0 *1 72.01,142.8
X$26125 6373 219 320 6914 CLKBUF_X3
* cell instance $26127 m0 *1 73.15,142.8
X$26127 7362 7250 219 320 7249 NAND2_X1
* cell instance $26128 m0 *1 73.72,142.8
X$26128 7444 320 3955 219 BUF_X4
* cell instance $26129 m0 *1 75.05,142.8
X$26129 7364 7365 219 320 7246 NOR2_X1
* cell instance $26131 r0 *1 64.79,142.8
X$26131 4277 320 7356 219 BUF_X4
* cell instance $26132 r0 *1 66.12,142.8
X$26132 3955 320 7492 219 BUF_X4
* cell instance $26133 r0 *1 67.45,142.8
X$26133 7493 320 4359 219 BUF_X4
* cell instance $26135 r0 *1 68.97,142.8
X$26135 7443 7361 219 320 7442 NAND2_X1
* cell instance $26136 r0 *1 69.54,142.8
X$26136 7246 7360 219 320 7359 NAND2_X1
* cell instance $26138 r0 *1 70.3,142.8
X$26138 7443 7360 219 320 7248 NAND2_X1
* cell instance $26139 r0 *1 70.87,142.8
X$26139 7442 320 3990 219 BUF_X4
* cell instance $26140 r0 *1 72.2,142.8
X$26140 6914 219 320 CLKBUF_X1
* cell instance $26142 r0 *1 73.15,142.8
X$26142 7366 7364 219 320 7363 NOR2_X1
* cell instance $26143 r0 *1 73.72,142.8
X$26143 7363 320 3948 219 BUF_X4
* cell instance $26144 r0 *1 75.05,142.8
X$26144 7365 7367 7251 320 7494 219 NOR3_X2
* cell instance $26145 m0 *1 76.19,142.8
X$26145 7366 7367 7251 219 320 7444 NOR3_X1
* cell instance $26148 m0 *1 78.47,142.8
X$26148 7252 7089 7255 219 320 7253 MUX2_X1
* cell instance $26149 m0 *1 79.8,142.8
X$26149 219 13087 7256 7447 7254 320 DFF_X1
* cell instance $26150 m0 *1 83.03,142.8
X$26150 6915 7091 7256 219 320 7447 MUX2_X1
* cell instance $26153 m0 *1 85.31,142.8
X$26153 7369 3365 7370 219 320 7319 MUX2_X1
* cell instance $26156 m0 *1 90.44,142.8
X$26156 7258 7356 7372 219 320 7452 MUX2_X1
* cell instance $26158 r0 *1 76.38,142.8
X$26158 7368 7367 7251 7557 320 7131 219 NOR4_X2
* cell instance $26161 r0 *1 78.66,142.8
X$26161 7252 7356 7496 219 320 7559 MUX2_X1
* cell instance $26166 r0 *1 82.84,142.8
X$26166 6915 7025 7370 219 320 7448 MUX2_X1
* cell instance $26167 r0 *1 84.17,142.8
X$26167 219 13854 7370 7448 7254 320 DFF_X1
* cell instance $26170 r0 *1 89.68,142.8
X$26170 219 13899 7372 7452 6919 320 DFF_X1
* cell instance $26171 m0 *1 95.38,142.8
X$26171 7372 3365 7373 219 320 7259 MUX2_X1
* cell instance $26172 m0 *1 92.15,142.8
X$26172 219 13542 7373 7453 6919 320 DFF_X1
* cell instance $26174 r0 *1 92.91,142.8
X$26174 7139 7091 7373 219 320 7453 MUX2_X1
* cell instance $26176 r0 *1 94.62,142.8
X$26176 7561 2669 219 320 7374 NOR2_X1
* cell instance $26178 r0 *1 96.71,142.8
X$26178 6284 219 320 6919 CLKBUF_X3
* cell instance $26179 m0 *1 97.28,142.8
X$26179 219 12959 7325 7261 6919 320 DFF_X1
* cell instance $26183 r0 *1 97.85,142.8
X$26183 7564 7375 7374 7454 320 6231 219 NOR4_X2
* cell instance $26184 r0 *1 99.56,142.8
X$26184 6057 219 320 4367 INV_X4
* cell instance $26186 r0 *1 100.7,142.8
X$26186 7376 6873 219 320 7454 NOR2_X1
* cell instance $26187 m0 *1 101.08,142.8
X$26187 219 12572 7327 7326 7378 320 DFF_X1
* cell instance $26191 m0 *1 105.26,142.8
X$26191 219 12754 7459 7380 7378 320 DFF_X1
* cell instance $26192 m0 *1 108.49,142.8
X$26192 7461 5253 7460 219 320 6462 MUX2_X1
* cell instance $26195 r0 *1 101.27,142.8
X$26195 7377 3595 7456 219 320 7376 MUX2_X1
* cell instance $26196 r0 *1 102.6,142.8
X$26196 7497 219 320 6284 CLKBUF_X3
* cell instance $26197 r0 *1 103.55,142.8
X$26197 6284 219 320 12514 INV_X4
* cell instance $26200 r0 *1 105.07,142.8
X$26200 7379 7026 7459 219 320 7380 MUX2_X1
* cell instance $26201 r0 *1 106.4,142.8
X$26201 219 13774 7500 7567 7378 320 DFF_X1
* cell instance $26203 m0 *1 111.15,142.8
X$26203 219 13097 7263 7601 7262 320 DFF_X1
* cell instance $26206 m0 *1 114.57,142.8
X$26206 7264 219 320 5520 INV_X2
* cell instance $26207 m0 *1 115.14,142.8
X$26207 219 6172 320 6590 BUF_X8
* cell instance $26208 m0 *1 117.61,142.8
X$26208 6590 320 3595 219 BUF_X4
* cell instance $26209 m0 *1 118.94,142.8
X$26209 7037 219 320 14733 INV_X1
* cell instance $26210 m0 *1 119.32,142.8
X$26210 6284 219 320 7037 CLKBUF_X3
* cell instance $26212 m0 *1 120.46,142.8
X$26212 6590 320 4076 219 BUF_X4
* cell instance $26213 m0 *1 121.79,142.8
X$26213 219 13440 7381 7334 6925 320 DFF_X1
* cell instance $26214 m0 *1 125.02,142.8
X$26214 7265 6691 7382 219 320 7463 MUX2_X1
* cell instance $26215 m0 *1 126.35,142.8
X$26215 7265 6724 7383 219 320 7465 MUX2_X1
* cell instance $26216 m0 *1 127.68,142.8
X$26216 219 13202 7383 7465 6925 320 DFF_X1
* cell instance $26222 r0 *1 112.1,142.8
X$26222 219 13886 7264 7786 7262 320 DFF_X1
* cell instance $26230 r0 *1 119.7,142.8
X$26230 7570 320 6590 219 BUF_X4
* cell instance $26231 r0 *1 121.03,142.8
X$26231 219 5217 320 6590 BUF_X8
* cell instance $26235 r0 *1 125.4,142.8
X$26235 219 13770 7382 7463 6925 320 DFF_X1
* cell instance $26236 r0 *1 128.63,142.8
X$26236 7383 7501 7382 219 320 7687 MUX2_X1
* cell instance $26237 r0 *1 129.96,142.8
X$26237 5428 219 320 6925 CLKBUF_X3
* cell instance $26240 r0 *1 133.19,142.8
X$26240 219 13788 7385 7572 7384 320 DFF_X1
* cell instance $26242 m0 *1 133.57,142.8
X$26242 7266 6691 7267 219 320 7340 MUX2_X1
* cell instance $26243 m0 *1 135.47,142.8
X$26243 7266 6724 7386 219 320 7468 MUX2_X1
* cell instance $26245 m0 *1 136.8,142.8
X$26245 219 13160 7386 7468 7384 320 DFF_X1
* cell instance $26248 m0 *1 143.83,142.8
X$26248 7390 3746 7690 320 219 3696 OAI21_X4
* cell instance $26250 m0 *1 147.82,142.8
X$26250 5732 219 320 7268 CLKBUF_X3
* cell instance $26251 m0 *1 148.77,142.8
X$26251 7268 219 320 CLKBUF_X1
* cell instance $26254 m0 *1 150.29,142.8
X$26254 219 13228 7269 7343 7268 320 DFF_X1
* cell instance $26256 r0 *1 136.42,142.8
X$26256 7386 7501 7267 219 320 7387 MUX2_X1
* cell instance $26257 r0 *1 137.75,142.8
X$26257 5428 219 320 7384 CLKBUF_X3
* cell instance $26258 r0 *1 138.7,142.8
X$26258 7384 219 320 CLKBUF_X1
* cell instance $26260 r0 *1 139.46,142.8
X$26260 6928 219 320 7502 BUF_X2
* cell instance $26261 r0 *1 140.22,142.8
X$26261 7502 219 320 7575 BUF_X1
* cell instance $26264 r0 *1 141.36,142.8
X$26264 7395 219 320 5428 CLKBUF_X3
* cell instance $26266 r0 *1 142.5,142.8
X$26266 7388 2909 7573 219 320 7389 MUX2_X1
* cell instance $26267 r0 *1 143.83,142.8
X$26267 3605 7389 219 320 7390 OR2_X1
* cell instance $26270 r0 *1 146.3,142.8
X$26270 219 13803 7392 7391 7268 320 DFF_X1
* cell instance $26271 r0 *1 149.53,142.8
X$26271 7393 4383 7394 320 219 4399 OAI21_X4
* cell instance $26274 m0 *1 153.9,142.8
X$26274 4382 7476 219 320 7474 OR2_X1
* cell instance $26275 m0 *1 154.85,142.8
X$26275 7474 4383 7225 320 219 6939 OAI21_X4
* cell instance $26278 m0 *1 160.55,142.8
X$26278 219 7273 7339 7396 7271 7503 320 NAND4_X4
* cell instance $26279 m0 *1 163.97,142.8
X$26279 7479 7272 7398 320 7571 219 OAI21_X1
* cell instance $26281 m0 *1 164.92,142.8
X$26281 7338 7475 7273 219 7272 320 AOI21_X1
* cell instance $26283 m0 *1 165.87,142.8
X$26283 7399 7400 7339 320 219 7475 HA_X1
* cell instance $26284 m0 *1 167.77,142.8
X$26284 1213 219 320 7473 BUF_X1
* cell instance $26285 m0 *1 168.34,142.8
X$26285 1215 219 320 7403 BUF_X1
* cell instance $26286 m0 *1 168.91,142.8
X$26286 7399 1215 7277 320 219 7471 HA_X1
* cell instance $26287 m0 *1 170.81,142.8
X$26287 7401 219 320 7472 INV_X1
* cell instance $26288 m0 *1 171.19,142.8
X$26288 7276 7277 320 219 7402 AND2_X1
* cell instance $26292 m0 *1 174.42,142.8
X$26292 7469 320 6239 219 BUF_X4
* cell instance $26293 m0 *1 175.75,142.8
X$26293 219 7328 6239 7467 7331 320 AOI21_X4
* cell instance $26299 r0 *1 159.41,142.8
X$26299 7478 219 320 7617 BUF_X1
* cell instance $26300 r0 *1 159.98,142.8
X$26300 7396 219 320 7478 BUF_X2
* cell instance $26301 r0 *1 160.74,142.8
X$26301 7440 6948 7396 320 219 7504 HA_X1
* cell instance $26302 r0 *1 162.64,142.8
X$26302 7271 219 320 7479 INV_X1
* cell instance $26303 r0 *1 163.02,142.8
X$26303 7614 7397 7271 320 219 7477 HA_X1
* cell instance $26304 r0 *1 164.92,142.8
X$26304 7477 219 320 7398 INV_X1
* cell instance $26308 r0 *1 166.63,142.8
X$26308 7473 219 320 7505 INV_X2
* cell instance $26309 r0 *1 167.2,142.8
X$26309 7274 1213 7506 320 219 7509 HA_X1
* cell instance $26310 r0 *1 169.1,142.8
X$26310 7401 7509 7471 219 320 7568 OR3_X1
* cell instance $26312 r0 *1 170.24,142.8
X$26312 7451 1298 7276 320 219 7566 HA_X1
* cell instance $26313 r0 *1 172.14,142.8
X$26313 7277 219 320 7512 BUF_X1
* cell instance $26314 r0 *1 172.71,142.8
X$26314 1460 219 320 7511 INV_X1
* cell instance $26315 r0 *1 173.09,142.8
X$26315 7470 219 320 7514 INV_X1
* cell instance $26317 r0 *1 174.23,142.8
X$26317 7522 320 3382 219 BUF_X4
* cell instance $26321 r0 *1 175.56,142.8
X$26321 3382 7400 3503 7403 320 219 7458 OAI22_X1
* cell instance $26322 r0 *1 176.51,142.8
X$26322 3058 7519 7466 219 7464 320 AOI21_X2
* cell instance $26323 r0 *1 177.84,142.8
X$26323 7404 219 320 7520 INV_X1
* cell instance $26325 r0 *1 178.41,142.8
X$26325 7522 320 3457 219 BUF_X4
* cell instance $26327 r0 *1 180.12,142.8
X$26327 5736 7405 7403 6673 320 219 7558 OAI22_X2
* cell instance $26328 m0 *1 182.97,142.8
X$26328 6020 7405 3271 7278 320 219 7407 OAI22_X1
* cell instance $26329 m0 *1 181.64,142.8
X$26329 6977 320 7406 219 BUF_X4
* cell instance $26330 m0 *1 183.92,142.8
X$26330 6186 7405 7403 6987 320 219 7457 OAI22_X2
* cell instance $26334 r0 *1 182.21,142.8
X$26334 7462 7405 7403 6073 320 219 7552 OAI22_X2
* cell instance $26335 r0 *1 183.92,142.8
X$26335 7407 7458 219 320 7525 NOR2_X1
* cell instance $26336 r0 *1 184.49,142.8
X$26336 7408 6979 7457 7455 7314 7630 320 219 AOI221_X2
* cell instance $26337 r0 *1 186.58,142.8
X$26337 7400 219 320 7408 INV_X2
* cell instance $26338 m0 *1 186.96,142.8
X$26338 6540 219 320 7314 INV_X4
* cell instance $26340 m0 *1 187.91,142.8
X$26340 7399 7278 7412 320 219 7279 HA_X1
* cell instance $26341 m0 *1 189.81,142.8
X$26341 7279 7449 7316 320 7409 219 OAI21_X1
* cell instance $26343 m0 *1 190.76,142.8
X$26343 7282 7279 7411 219 320 7317 OR3_X1
* cell instance $26345 m0 *1 191.9,142.8
X$26345 7282 219 320 7413 INV_X1
* cell instance $26347 m0 *1 192.47,142.8
X$26347 7283 7284 219 320 7445 NAND2_X1
* cell instance $26349 m0 *1 193.23,142.8
X$26349 7317 7446 7415 219 7414 320 AOI21_X1
* cell instance $26350 m0 *1 193.99,142.8
X$26350 7414 7445 7204 320 219 7441 OAI21_X2
* cell instance $26353 r0 *1 188.67,142.8
X$26353 4938 219 320 7410 INV_X2
* cell instance $26354 r0 *1 189.24,142.8
X$26354 7451 7410 7284 320 219 7411 HA_X1
* cell instance $26355 r0 *1 191.14,142.8
X$26355 7412 219 320 7449 BUF_X1
* cell instance $26357 r0 *1 192.09,142.8
X$26357 4567 7450 7283 320 219 7415 HA_X1
* cell instance $26358 r0 *1 193.99,142.8
X$26358 7284 219 320 7446 BUF_X1
* cell instance $26360 r0 *1 194.75,142.8
X$26360 7445 7416 7280 219 320 7546 OR3_X4
* cell instance $26361 m0 *1 195.89,142.8
X$26361 7406 689 7314 1970 219 320 7286 AOI22_X1
* cell instance $26365 r0 *1 196.84,142.8
X$26365 7417 5902 6713 219 7439 320 AOI21_X1
* cell instance $26369 r0 *1 198.93,142.8
X$26369 7440 2426 7527 320 219 7548 HA_X1
* cell instance $26371 m0 *1 200.26,142.8
X$26371 7439 5979 219 320 7302 NOR2_X1
* cell instance $26377 m0 *1 209,142.8
X$26377 7065 6740 7287 219 320 7436 MUX2_X1
* cell instance $26378 m0 *1 205.77,142.8
X$26378 219 13305 7287 7436 7061 320 DFF_X1
* cell instance $26380 m0 *1 213.37,142.8
X$26380 5567 219 320 7157 CLKBUF_X3
* cell instance $26382 m0 *1 220.4,142.8
X$26382 5162 320 6860 219 BUF_X4
* cell instance $26383 m0 *1 221.73,142.8
X$26383 5160 320 6843 219 BUF_X4
* cell instance $26387 r0 *1 206.72,142.8
X$26387 219 14450 6958 7438 7157 320 DFF_X1
* cell instance $26391 r0 *1 214.13,142.8
X$26391 7419 7418 7529 219 320 7545 MUX2_X1
* cell instance $26394 r0 *1 218.69,142.8
X$26394 4942 320 6861 219 BUF_X4
* cell instance $26398 r0 *1 222.49,142.8
X$26398 219 7420 4530 320 BUF_X16
* cell instance $26399 m0 *1 224.39,142.8
X$26399 7432 7430 3419 320 219 7542 OAI21_X4
* cell instance $26400 m0 *1 223.44,142.8
X$26400 5161 7429 219 320 7432 OR2_X2
* cell instance $26401 m0 *1 226.86,142.8
X$26401 7540 3171 7290 219 320 7430 MUX2_X1
* cell instance $26403 r0 *1 227.24,142.8
X$26403 7541 4530 7431 219 320 7429 MUX2_X1
* cell instance $26405 m0 *1 228.76,142.8
X$26405 7420 320 4531 219 BUF_X4
* cell instance $26407 m0 *1 230.09,142.8
X$26407 7420 320 3071 219 BUF_X4
* cell instance $26409 m0 *1 231.61,142.8
X$26409 4941 320 7291 219 BUF_X4
* cell instance $26410 m0 *1 232.94,142.8
X$26410 7067 219 320 CLKBUF_X1
* cell instance $26412 m0 *1 234.27,142.8
X$26412 6799 219 320 7298 BUF_X1
* cell instance $26414 m0 *1 235.03,142.8
X$26414 7167 7291 7070 219 320 7293 MUX2_X1
* cell instance $26415 m0 *1 236.36,142.8
X$26415 5160 320 7165 219 BUF_X4
* cell instance $26416 m0 *1 237.69,142.8
X$26416 7167 7165 7294 219 320 7295 MUX2_X1
* cell instance $26417 m0 *1 239.02,142.8
X$26417 7649 3071 7296 219 320 6555 MUX2_X1
* cell instance $26420 r0 *1 230.28,142.8
X$26420 4942 320 7166 219 BUF_X4
* cell instance $26425 r0 *1 232.37,142.8
X$26425 7324 219 320 7422 BUF_X1
* cell instance $26426 r0 *1 232.94,142.8
X$26426 219 7539 3171 320 BUF_X16
* cell instance $26427 r0 *1 237.69,142.8
X$26427 7642 3880 7426 219 320 6481 MUX2_X1
* cell instance $26428 r0 *1 239.02,142.8
X$26428 5162 320 7176 219 BUF_X4
* cell instance $26434 m0 *1 13.11,140
X$26434 4445 320 7171 219 BUF_X4
* cell instance $26435 m0 *1 14.44,140
X$26435 4238 320 5923 219 BUF_X4
* cell instance $26436 m0 *1 15.77,140
X$26436 4238 320 7121 219 BUF_X4
* cell instance $26437 m0 *1 17.1,140
X$26437 6897 7123 7015 219 320 7122 MUX2_X1
* cell instance $26439 m0 *1 18.62,140
X$26439 3990 320 7123 219 BUF_X4
* cell instance $26450 m0 *1 24.32,140
X$26450 6897 7177 6804 219 320 7175 MUX2_X1
* cell instance $26451 m0 *1 21.09,140
X$26451 219 13585 7124 7174 7299 320 DFF_X1
* cell instance $26452 m0 *1 25.65,140
X$26452 219 13571 6804 7175 7236 320 DFF_X1
* cell instance $26457 r0 *1 22.99,140
X$26457 6897 7232 7124 219 320 7174 MUX2_X1
* cell instance $26459 r0 *1 25.08,140
X$26459 219 14541 7234 7233 7299 320 DFF_X1
* cell instance $26460 r0 *1 28.31,140
X$26460 4359 320 7232 219 BUF_X4
* cell instance $26465 m0 *1 12.92,56
X$26465 1299 1547 1787 219 320 1788 MUX2_X1
* cell instance $26470 m0 *1 25.65,56
X$26470 219 12849 1737 1735 1789 320 DFF_X1
* cell instance $26472 m0 *1 29.07,56
X$26472 219 13094 1739 1794 1915 320 DFF_X1
* cell instance $26473 m0 *1 32.3,56
X$26473 219 12733 1795 1741 1302 320 DFF_X1
* cell instance $26475 m0 *1 36.29,56
X$26475 1738 1307 1796 219 320 1742 MUX2_X1
* cell instance $26485 r0 *1 8.55,56
X$26485 1828 219 320 2015 CLKBUF_X2
* cell instance $26488 r0 *1 11.59,56
X$26488 1733 219 320 14790 INV_X1
* cell instance $26489 r0 *1 11.97,56
X$26489 1740 1599 1829 219 320 1873 MUX2_X1
* cell instance $26490 r0 *1 13.3,56
X$26490 1370 219 320 1733 CLKBUF_X3
* cell instance $26496 r0 *1 25.84,56
X$26496 1737 1507 1738 219 320 1735 MUX2_X1
* cell instance $26499 r0 *1 28.31,56
X$26499 1737 1567 1736 219 320 1876 MUX2_X1
* cell instance $26501 r0 *1 31.16,56
X$26501 1876 1510 1877 219 320 1878 MUX2_X1
* cell instance $26503 r0 *1 33.25,56
X$26503 1740 1467 1831 219 320 1830 MUX2_X1
* cell instance $26505 r0 *1 36.1,56
X$26505 219 13773 1796 1742 1744 320 DFF_X1
* cell instance $26507 r0 *1 39.52,56
X$26507 1831 1567 1796 219 320 1973 MUX2_X1
* cell instance $26508 m0 *1 40.47,56
X$26508 219 12768 1743 1797 1744 320 DFF_X1
* cell instance $26510 m0 *1 43.7,56
X$26510 219 13102 1832 1883 1744 320 DFF_X1
* cell instance $26514 r0 *1 40.85,56
X$26514 1743 1520 1832 219 320 1881 MUX2_X1
* cell instance $26517 r0 *1 43.32,56
X$26517 1738 1523 1832 219 320 1883 MUX2_X1
* cell instance $26520 r0 *1 46.36,56
X$26520 219 13959 1921 1919 1744 320 DFF_X1
* cell instance $26522 r0 *1 51.11,56
X$26522 1833 1384 1738 219 320 1885 MUX2_X1
* cell instance $26523 m0 *1 52.82,56
X$26523 1738 1385 1799 219 320 1886 MUX2_X1
* cell instance $26524 m0 *1 51.87,56
X$26524 1515 219 320 1559 CLKBUF_X3
* cell instance $26525 m0 *1 54.15,56
X$26525 1833 1377 1799 219 320 1801 MUX2_X1
* cell instance $26531 r0 *1 52.82,56
X$26531 1559 219 320 14783 INV_X1
* cell instance $26532 r0 *1 53.2,56
X$26532 219 13875 1799 1886 1559 320 DFF_X1
* cell instance $26533 r0 *1 56.43,56
X$26533 1801 1562 1887 219 320 1834 MUX2_X1
* cell instance $26536 m0 *1 61.37,56
X$26536 1565 1841 1749 219 320 1804 MUX2_X1
* cell instance $26538 m0 *1 62.7,56
X$26538 1388 1746 1745 219 320 1748 MUX2_X1
* cell instance $26540 m0 *1 64.22,56
X$26540 1644 219 320 14725 INV_X1
* cell instance $26545 r0 *1 62.7,56
X$26545 219 14153 1745 1748 1644 320 DFF_X1
* cell instance $26549 r0 *1 65.93,56
X$26549 1570 219 320 1644 CLKBUF_X3
* cell instance $26551 m0 *1 67.45,56
X$26551 1388 219 320 1749 BUF_X2
* cell instance $26555 m0 *1 75.05,56
X$26555 219 12889 1752 1751 1753 320 DFF_X1
* cell instance $26556 m0 *1 78.28,56
X$26556 219 12845 1755 1754 1753 320 DFF_X1
* cell instance $26557 m0 *1 81.51,56
X$26557 1570 219 320 1753 CLKBUF_X3
* cell instance $26563 r0 *1 69.73,56
X$26563 1889 1640 1648 219 320 1982 MUX2_X1
* cell instance $26564 r0 *1 71.06,56
X$26564 219 14259 1891 1838 1929 320 DFF_X1
* cell instance $26567 r0 *1 75.24,56
X$26567 1390 219 320 1842 CLKBUF_X2
* cell instance $26570 r0 *1 77.71,56
X$26570 1390 1478 1755 219 320 1754 MUX2_X1
* cell instance $26571 r0 *1 79.04,56
X$26571 219 13976 1892 1839 1753 320 DFF_X1
* cell instance $26572 r0 *1 82.27,56
X$26572 1840 1841 1842 219 320 1894 MUX2_X1
* cell instance $26574 r0 *1 83.79,56
X$26574 219 13994 1840 1894 1753 320 DFF_X1
* cell instance $26576 r0 *1 88.54,56
X$26576 219 13968 1843 1896 1481 320 DFF_X1
* cell instance $26577 m0 *1 89.87,56
X$26577 219 12791 1758 1810 1481 320 DFF_X1
* cell instance $26578 m0 *1 88.92,56
X$26578 1578 219 320 1481 CLKBUF_X3
* cell instance $26580 m0 *1 93.86,56
X$26580 1159 1476 1759 219 320 1812 MUX2_X1
* cell instance $26581 m0 *1 95.19,56
X$26581 219 12802 1759 1812 1395 320 DFF_X1
* cell instance $26582 m0 *1 98.42,56
X$26582 1654 1576 1759 219 320 1760 MUX2_X1
* cell instance $26590 r0 *1 91.77,56
X$26590 1758 1844 1843 219 320 2033 MUX2_X1
* cell instance $26594 r0 *1 103.74,56
X$26594 1652 1898 1845 219 320 1899 MUX2_X1
* cell instance $26595 r0 *1 105.07,56
X$26595 219 14069 1845 1899 1935 320 DFF_X1
* cell instance $26604 r0 *1 125.21,56
X$26604 387 1035 1936 219 320 1900 MUX2_X1
* cell instance $26605 r0 *1 126.54,56
X$26605 1902 219 320 1485 CLKBUF_X3
* cell instance $26606 r0 *1 127.49,56
X$26606 387 1011 1846 219 320 1904 MUX2_X1
* cell instance $26607 m0 *1 128.44,56
X$26607 219 12927 1761 1816 1485 320 DFF_X1
* cell instance $26611 r0 *1 128.82,56
X$26611 219 14315 1846 1904 1763 320 DFF_X1
* cell instance $26612 r0 *1 132.05,56
X$26612 1846 1629 1761 219 320 1847 MUX2_X1
* cell instance $26614 r0 *1 134.9,56
X$26614 1763 219 320 CLKBUF_X1
* cell instance $26616 m0 *1 135.09,56
X$26616 527 1011 1817 219 320 1762 MUX2_X1
* cell instance $26618 r0 *1 135.47,56
X$26618 219 14651 1940 1906 1763 320 DFF_X1
* cell instance $26619 m0 *1 137.75,56
X$26619 1817 1314 1655 219 320 1764 MUX2_X1
* cell instance $26628 r0 *1 142.69,56
X$26628 219 14670 1848 1910 1656 320 DFF_X1
* cell instance $26630 r0 *1 146.3,56
X$26630 1943 219 320 1656 CLKBUF_X3
* cell instance $26633 r0 *1 148.39,56
X$26633 351 903 1944 219 320 1909 MUX2_X1
* cell instance $26635 m0 *1 149.34,56
X$26635 1767 1765 1731 219 320 1768 MUX2_X1
* cell instance $26640 r0 *1 150.29,56
X$26640 351 902 1849 219 320 1850 MUX2_X1
* cell instance $26643 m0 *1 158.08,56
X$26643 354 1493 1773 219 320 1771 MUX2_X1
* cell instance $26644 m0 *1 154.85,56
X$26644 219 13636 1905 1907 1660 320 DFF_X1
* cell instance $26645 m0 *1 159.41,56
X$26645 1729 1772 1773 219 320 1948 MUX2_X1
* cell instance $26648 m0 *1 162.45,56
X$26648 219 12639 1774 1901 1661 320 DFF_X1
* cell instance $26649 m0 *1 165.68,56
X$26649 1827 1772 1726 219 320 1949 MUX2_X1
* cell instance $26654 m0 *1 183.73,56
X$26654 322 1403 1821 219 320 1822 MUX2_X1
* cell instance $26655 m0 *1 185.06,56
X$26655 219 12732 1777 1820 1668 320 DFF_X1
* cell instance $26656 m0 *1 188.29,56
X$26656 322 1492 1777 219 320 1820 MUX2_X1
* cell instance $26658 m0 *1 191.14,56
X$26658 1778 1868 1669 219 320 2251 MUX2_X1
* cell instance $26660 m0 *1 192.66,56
X$26660 1182 320 1493 219 BUF_X4
* cell instance $26661 m0 *1 193.99,56
X$26661 1775 320 1596 219 BUF_X4
* cell instance $26665 m0 *1 200.07,56
X$26665 545 219 320 1670 CLKBUF_X3
* cell instance $26666 m0 *1 201.02,56
X$26666 1814 1585 1672 320 219 1815 OAI21_X4
* cell instance $26669 m0 *1 205.2,56
X$26669 1954 1673 320 219 1808 AND2_X1
* cell instance $26670 m0 *1 205.96,56
X$26670 380 219 320 1500 CLKBUF_X3
* cell instance $26671 m0 *1 206.91,56
X$26671 219 1807 1780 1808 1500 320 DFF_X1
* cell instance $26672 m0 *1 210.14,56
X$26672 1780 1779 12522 320 219 1861 HA_X1
* cell instance $26674 m0 *1 212.23,56
X$26674 1181 320 1781 219 BUF_X4
* cell instance $26677 r0 *1 155.61,56
X$26677 354 1492 1905 219 320 1907 MUX2_X1
* cell instance $26679 r0 *1 157.32,56
X$26679 1770 1772 1905 219 320 1903 MUX2_X1
* cell instance $26683 r0 *1 162.83,56
X$26683 437 1403 1774 219 320 1901 MUX2_X1
* cell instance $26687 r0 *1 165.49,56
X$26687 1774 1772 1633 219 320 2004 MUX2_X1
* cell instance $26695 r0 *1 176.89,56
X$26695 334 1852 1897 219 320 1951 MUX2_X1
* cell instance $26696 r0 *1 178.22,56
X$26696 1823 1853 1854 219 320 1855 MUX2_X1
* cell instance $26697 r0 *1 179.55,56
X$26697 1185 1823 219 320 1856 OR2_X1
* cell instance $26701 r0 *1 184.49,56
X$26701 322 1493 1995 219 320 1895 MUX2_X1
* cell instance $26703 r0 *1 186.58,56
X$26703 1821 1893 1777 219 320 2121 MUX2_X1
* cell instance $26706 r0 *1 194.18,56
X$26706 1181 320 1662 219 BUF_X4
* cell instance $26709 r0 *1 198.74,56
X$26709 1670 219 320 14772 INV_X1
* cell instance $26710 r0 *1 199.12,56
X$26710 1953 1852 1858 219 320 1890 MUX2_X1
* cell instance $26711 r0 *1 200.45,56
X$26711 219 13995 1858 1890 1670 320 DFF_X1
* cell instance $26715 r0 *1 206.15,56
X$26715 1500 219 320 CLKBUF_X1
* cell instance $26717 r0 *1 207.1,56
X$26717 219 1860 1779 1888 1500 320 DFF_X1
* cell instance $26718 r0 *1 210.33,56
X$26718 1807 1860 1978 320 219 1863 HA_X1
* cell instance $26719 r0 *1 212.23,56
X$26719 1780 1860 12556 320 219 1862 HA_X1
* cell instance $26721 m0 *1 213.94,56
X$26721 1182 320 1677 219 BUF_X4
* cell instance $26726 r0 *1 214.7,56
X$26726 219 14030 1864 1803 1501 320 DFF_X1
* cell instance $26727 r0 *1 217.93,56
X$26727 1864 1329 1865 219 320 1866 MUX2_X1
* cell instance $26729 m0 *1 217.93,56
X$26729 1782 1414 1864 219 320 1803 MUX2_X1
* cell instance $26730 m0 *1 219.45,56
X$26730 219 12652 1879 1884 1501 320 DFF_X1
* cell instance $26732 m0 *1 228.76,56
X$26732 219 13538 1783 1798 1698 320 DFF_X1
* cell instance $26733 m0 *1 231.99,56
X$26733 1678 1677 1783 219 320 1798 MUX2_X1
* cell instance $26734 m0 *1 233.32,56
X$26734 219 13488 1679 1793 1680 320 DFF_X1
* cell instance $26735 m0 *1 236.55,56
X$26735 1681 1596 1679 219 320 1790 MUX2_X1
* cell instance $26736 m0 *1 237.88,56
X$26736 1872 219 320 1251 BUF_X1
* cell instance $26742 r0 *1 220.4,56
X$26742 1782 1781 1879 219 320 1884 MUX2_X1
* cell instance $26743 r0 *1 221.73,56
X$26743 1782 1677 1867 219 320 1880 MUX2_X1
* cell instance $26747 r0 *1 226.67,56
X$26747 1869 219 320 1698 CLKBUF_X3
* cell instance $26748 r0 *1 227.62,56
X$26748 1698 219 320 CLKBUF_X1
* cell instance $26752 r0 *1 230.28,56
X$26752 1871 1868 1783 219 320 1870 MUX2_X1
* cell instance $26756 r0 *1 231.61,56
X$26756 1678 1781 1871 219 320 1875 MUX2_X1
* cell instance $26757 r0 *1 232.94,56
X$26757 219 13673 1871 1875 1680 320 DFF_X1
* cell instance $26759 r0 *1 236.55,56
X$26759 1503 1790 2072 320 219 1874 MUX2_X2
* cell instance $26768 m0 *1 12.35,50.4
X$26768 219 12703 1548 1505 1733 320 DFF_X1
* cell instance $26778 r0 *1 10.26,50.4
X$26778 1224 1547 1635 219 320 1684 MUX2_X1
* cell instance $26781 r0 *1 13.3,50.4
X$26781 1299 1599 1548 219 320 1505 MUX2_X1
* cell instance $26783 r0 *1 16.15,50.4
X$26783 1787 1564 1548 219 320 1601 MUX2_X1
* cell instance $26785 m0 *1 17.67,50.4
X$26785 219 12869 1465 1549 1158 320 DFF_X1
* cell instance $26787 m0 *1 20.9,50.4
X$26787 1551 1552 1465 219 320 1466 MUX2_X1
* cell instance $26790 r0 *1 17.86,50.4
X$26790 219 14110 1551 1600 1158 320 DFF_X1
* cell instance $26791 r0 *1 21.09,50.4
X$26791 1551 1550 1300 219 320 1600 MUX2_X1
* cell instance $26792 r0 *1 22.42,50.4
X$26792 1466 1639 1601 219 320 1604 MUX2_X1
* cell instance $26794 m0 *1 23.37,50.4
X$26794 1224 219 320 1304 BUF_X2
* cell instance $26795 m0 *1 25.65,50.4
X$26795 219 12804 1554 1555 1302 320 DFF_X1
* cell instance $26800 r0 *1 24.89,50.4
X$26800 1554 1507 1304 219 320 1555 MUX2_X1
* cell instance $26803 r0 *1 27.17,50.4
X$26803 1224 1553 1556 219 320 1690 MUX2_X1
* cell instance $26806 r0 *1 29.07,50.4
X$26806 1554 1567 1556 219 320 1603 MUX2_X1
* cell instance $26807 m0 *1 31.35,50.4
X$26807 1224 1467 1468 219 320 1514 MUX2_X1
* cell instance $26808 m0 *1 30.02,50.4
X$26808 1513 1510 1511 219 320 1521 MUX2_X1
* cell instance $26809 m0 *1 32.68,50.4
X$26809 219 12688 1468 1514 1302 320 DFF_X1
* cell instance $26811 m0 *1 36.1,50.4
X$26811 1468 1377 1378 219 320 1519 MUX2_X1
* cell instance $26814 r0 *1 30.4,50.4
X$26814 1370 219 320 1302 CLKBUF_X3
* cell instance $26817 r0 *1 31.92,50.4
X$26817 1603 1510 1375 219 320 1691 MUX2_X1
* cell instance $26819 m0 *1 39.52,50.4
X$26819 1516 1510 1380 219 320 1522 MUX2_X1
* cell instance $26821 m0 *1 40.85,50.4
X$26821 1557 1520 1470 219 320 1558 MUX2_X1
* cell instance $26822 m0 *1 42.18,50.4
X$26822 1425 1520 1426 219 320 1516 MUX2_X1
* cell instance $26823 m0 *1 43.51,50.4
X$26823 1304 1523 1470 219 320 1525 MUX2_X1
* cell instance $26824 m0 *1 44.84,50.4
X$26824 219 13117 1470 1525 1306 320 DFF_X1
* cell instance $26828 m0 *1 53.39,50.4
X$26828 1300 1609 1471 219 320 1526 MUX2_X1
* cell instance $26829 m0 *1 54.72,50.4
X$26829 219 12726 1471 1526 1310 320 DFF_X1
* cell instance $26834 r0 *1 40.09,50.4
X$26834 1557 1469 1304 219 320 1607 MUX2_X1
* cell instance $26835 r0 *1 41.42,50.4
X$26835 1558 1510 1519 219 320 1692 MUX2_X1
* cell instance $26836 r0 *1 42.75,50.4
X$26836 1300 1523 1426 219 320 1381 MUX2_X1
* cell instance $26838 r0 *1 44.27,50.4
X$26838 1522 1640 1521 219 320 1608 MUX2_X1
* cell instance $26840 r0 *1 46.36,50.4
X$26840 1304 1609 1560 219 320 1610 MUX2_X1
* cell instance $26841 r0 *1 47.69,50.4
X$26841 219 13682 1560 1610 1559 320 DFF_X1
* cell instance $26842 r0 *1 50.92,50.4
X$26842 1383 1562 1561 219 320 1611 MUX2_X1
* cell instance $26845 r0 *1 53.39,50.4
X$26845 1300 1695 1563 219 320 1613 MUX2_X1
* cell instance $26846 r0 *1 54.72,50.4
X$26846 219 13668 1563 1613 1310 320 DFF_X1
* cell instance $26847 r0 *1 57.95,50.4
X$26847 1471 1564 1563 219 320 1705 MUX2_X1
* cell instance $26848 r0 *1 59.28,50.4
X$26848 1388 1480 1566 219 320 1615 MUX2_X1
* cell instance $26849 r0 *1 60.61,50.4
X$26849 219 14016 1566 1615 1644 320 DFF_X1
* cell instance $26850 m0 *1 64.22,50.4
X$26850 219 12666 1568 1473 1432 320 DFF_X1
* cell instance $26851 m0 *1 62.89,50.4
X$26851 1388 1389 1429 219 320 1472 MUX2_X1
* cell instance $26856 r0 *1 63.84,50.4
X$26856 1565 1567 1566 219 320 1805 MUX2_X1
* cell instance $26858 r0 *1 66.69,50.4
X$26858 1388 1478 1568 219 320 1473 MUX2_X1
* cell instance $26859 m0 *1 69.16,50.4
X$26859 219 12701 1474 1530 1432 320 DFF_X1
* cell instance $26860 m0 *1 67.83,50.4
X$26860 1388 1476 1474 219 320 1530 MUX2_X1
* cell instance $26863 r0 *1 68.02,50.4
X$26863 1568 1564 1474 219 320 1710 MUX2_X1
* cell instance $26864 r0 *1 69.35,50.4
X$26864 219 14138 1650 1569 1432 320 DFF_X1
* cell instance $26866 r0 *1 72.96,50.4
X$26866 1570 219 320 1432 CLKBUF_X3
* cell instance $26867 r0 *1 73.91,50.4
X$26867 1432 219 320 CLKBUF_X1
* cell instance $26869 r0 *1 74.86,50.4
X$26869 1390 1480 1617 219 320 1618 MUX2_X1
* cell instance $26870 m0 *1 77.14,50.4
X$26870 1617 1392 1477 219 320 1620 MUX2_X1
* cell instance $26871 m0 *1 75.81,50.4
X$26871 1390 1571 1477 219 320 1475 MUX2_X1
* cell instance $26872 m0 *1 78.47,50.4
X$26872 219 12855 1531 1621 1753 320 DFF_X1
* cell instance $26875 r0 *1 76.19,50.4
X$26875 219 14101 1617 1618 1432 320 DFF_X1
* cell instance $26876 r0 *1 79.42,50.4
X$26876 1390 1476 1531 219 320 1621 MUX2_X1
* cell instance $26879 r0 *1 81.32,50.4
X$26879 219 13985 1572 1622 1395 320 DFF_X1
* cell instance $26881 m0 *1 83.6,50.4
X$26881 1479 1478 1534 219 320 1533 MUX2_X1
* cell instance $26883 m0 *1 88.73,50.4
X$26883 1479 1480 1535 219 320 1394 MUX2_X1
* cell instance $26884 m0 *1 90.06,50.4
X$26884 219 12790 1482 1575 1481 320 DFF_X1
* cell instance $26885 m0 *1 93.29,50.4
X$26885 1437 1576 1484 219 320 1483 MUX2_X1
* cell instance $26886 m0 *1 94.62,50.4
X$26886 1479 1476 1484 219 320 1537 MUX2_X1
* cell instance $26888 r0 *1 84.55,50.4
X$26888 1572 1392 1534 219 320 1714 MUX2_X1
* cell instance $26889 r0 *1 85.88,50.4
X$26889 1573 1392 1653 219 320 1715 MUX2_X1
* cell instance $26890 r0 *1 87.21,50.4
X$26890 219 14226 1573 1574 1481 320 DFF_X1
* cell instance $26891 r0 *1 90.44,50.4
X$26891 1479 1571 1482 219 320 1575 MUX2_X1
* cell instance $26893 r0 *1 92.15,50.4
X$26893 1535 1576 1482 219 320 1577 MUX2_X1
* cell instance $26894 r0 *1 93.48,50.4
X$26894 1578 219 320 1395 CLKBUF_X3
* cell instance $26895 r0 *1 94.43,50.4
X$26895 1395 219 320 CLKBUF_X1
* cell instance $26897 m0 *1 96.52,50.4
X$26897 219 12867 1484 1537 1395 320 DFF_X1
* cell instance $26918 m0 *1 127.3,50.4
X$26918 219 12910 1486 1543 1485 320 DFF_X1
* cell instance $26919 m0 *1 125.97,50.4
X$26919 1441 1035 1579 219 320 1627 MUX2_X1
* cell instance $26920 m0 *1 130.53,50.4
X$26920 1441 1041 1486 219 320 1543 MUX2_X1
* cell instance $26921 m0 *1 131.86,50.4
X$26921 1397 1629 1356 219 320 1545 MUX2_X1
* cell instance $26925 r0 *1 126.35,50.4
X$26925 219 13804 1579 1627 1485 320 DFF_X1
* cell instance $26927 r0 *1 129.96,50.4
X$26927 1579 1629 1486 219 320 1580 MUX2_X1
* cell instance $26929 m0 *1 137.56,50.4
X$26929 1398 1445 1399 219 320 1487 MUX2_X1
* cell instance $26935 r0 *1 138.51,50.4
X$26935 1580 1274 1545 219 320 1908 MUX2_X1
* cell instance $26936 r0 *1 139.84,50.4
X$26936 1545 219 320 1632 INV_X1
* cell instance $26937 m0 *1 140.22,50.4
X$26937 1487 1274 1488 219 320 1489 MUX2_X1
* cell instance $26939 m0 *1 141.55,50.4
X$26939 1488 219 320 1544 INV_X1
* cell instance $26941 m0 *1 142.12,50.4
X$26941 1544 627 219 320 1541 NAND2_X1
* cell instance $26942 m0 *1 142.69,50.4
X$26942 1541 733 1487 320 219 1542 OAI21_X4
* cell instance $26947 m0 *1 150.67,50.4
X$26947 1400 1629 1451 219 320 1540 MUX2_X1
* cell instance $26950 r0 *1 140.22,50.4
X$26950 1632 627 219 320 1581 NAND2_X1
* cell instance $26953 r0 *1 144.21,50.4
X$26953 288 851 1658 219 320 1730 MUX2_X1
* cell instance $26957 m0 *1 153.14,50.4
X$26957 1540 1317 522 320 219 1769 MUX2_X2
* cell instance $26960 m0 *1 158.84,50.4
X$26960 413 851 1490 219 320 1539 MUX2_X1
* cell instance $26961 m0 *1 160.17,50.4
X$26961 219 12622 1490 1539 1660 320 DFF_X1
* cell instance $26965 m0 *1 171.76,50.4
X$26965 336 1493 1582 219 320 1538 MUX2_X1
* cell instance $26969 m0 *1 177.08,50.4
X$26969 219 12979 1491 1536 1323 320 DFF_X1
* cell instance $26970 m0 *1 180.31,50.4
X$26970 304 1492 1491 219 320 1536 MUX2_X1
* cell instance $26976 r0 *1 163.02,50.4
X$26976 219 14558 1633 1634 1660 320 DFF_X1
* cell instance $26977 r0 *1 166.25,50.4
X$26977 437 1492 1633 219 320 1634 MUX2_X1
* cell instance $26980 r0 *1 169.86,50.4
X$26980 219 14419 1582 1538 1323 320 DFF_X1
* cell instance $26981 r0 *1 173.09,50.4
X$26981 336 1492 1722 219 320 1631 MUX2_X1
* cell instance $26982 r0 *1 174.42,50.4
X$26982 364 219 320 1323 CLKBUF_X3
* cell instance $26986 r0 *1 175.37,50.4
X$26986 1323 219 320 14763 INV_X1
* cell instance $26989 r0 *1 177.65,50.4
X$26989 219 14371 1583 1630 1323 320 DFF_X1
* cell instance $26993 r0 *1 184.49,50.4
X$26993 219 13657 1495 1494 1328 320 DFF_X1
* cell instance $26994 m0 *1 185.25,50.4
X$26994 297 1493 1495 219 320 1494 MUX2_X1
* cell instance $26997 m0 *1 187.72,50.4
X$26997 545 219 320 1328 CLKBUF_X3
* cell instance $26998 m0 *1 186.96,50.4
X$26998 1405 1532 219 320 1496 OR2_X1
* cell instance $26999 m0 *1 188.67,50.4
X$26999 1717 1069 1495 219 320 1497 MUX2_X1
* cell instance $27001 m0 *1 190.76,50.4
X$27001 1241 320 1492 219 BUF_X4
* cell instance $27002 m0 *1 192.09,50.4
X$27002 219 12760 1499 1529 1328 320 DFF_X1
* cell instance $27003 m0 *1 195.32,50.4
X$27003 329 1182 1499 219 320 1529 MUX2_X1
* cell instance $27006 m0 *1 198.93,50.4
X$27006 219 12813 1619 1528 1248 320 DFF_X1
* cell instance $27009 r0 *1 187.72,50.4
X$27009 1496 1585 1497 320 219 1628 OAI21_X4
* cell instance $27011 r0 *1 190.38,50.4
X$27011 1330 320 1403 219 BUF_X4
* cell instance $27012 r0 *1 191.71,50.4
X$27012 219 13764 1626 1625 1328 320 DFF_X1
* cell instance $27013 r0 *1 194.94,50.4
X$27013 329 1181 1626 219 320 1625 MUX2_X1
* cell instance $27015 r0 *1 197.79,50.4
X$27015 1584 1330 1619 219 320 1528 MUX2_X1
* cell instance $27016 r0 *1 199.12,50.4
X$27016 1584 1181 1671 219 320 1623 MUX2_X1
* cell instance $27019 r0 *1 201.02,50.4
X$27019 1584 1241 1586 219 320 1587 MUX2_X1
* cell instance $27020 r0 *1 202.35,50.4
X$27020 1619 1329 1586 219 320 1588 MUX2_X1
* cell instance $27022 m0 *1 208.81,50.4
X$27022 1246 929 1336 219 320 1524 MUX2_X1
* cell instance $27023 m0 *1 205.58,50.4
X$27023 219 12784 1336 1524 1500 320 DFF_X1
* cell instance $27027 r0 *1 206.91,50.4
X$27027 1405 1614 219 320 1589 OR2_X1
* cell instance $27031 r0 *1 210.14,50.4
X$27031 1185 1512 219 320 1590 OR2_X1
* cell instance $27033 m0 *1 215.27,50.4
X$27033 1409 1414 1591 219 320 1612 MUX2_X1
* cell instance $27034 m0 *1 212.04,50.4
X$27034 219 13385 1518 1517 1501 320 DFF_X1
* cell instance $27038 m0 *1 219.07,50.4
X$27038 1434 932 1502 219 320 1512 MUX2_X1
* cell instance $27044 r0 *1 212.8,50.4
X$27044 1591 1329 1518 219 320 1614 MUX2_X1
* cell instance $27046 r0 *1 214.32,50.4
X$27046 1241 320 1408 219 BUF_X4
* cell instance $27047 r0 *1 215.65,50.4
X$27047 219 14216 1591 1612 1188 320 DFF_X1
* cell instance $27048 r0 *1 218.88,50.4
X$27048 1592 1414 1434 219 320 1435 MUX2_X1
* cell instance $27049 r0 *1 220.21,50.4
X$27049 1592 1408 1502 219 320 1606 MUX2_X1
* cell instance $27050 r0 *1 221.54,50.4
X$27050 219 14552 1502 1606 1698 320 DFF_X1
* cell instance $27052 r0 *1 225.15,50.4
X$27052 219 14521 1676 1605 1256 320 DFF_X1
* cell instance $27054 r0 *1 229.14,50.4
X$27054 1693 1069 1594 219 320 1602 MUX2_X1
* cell instance $27055 m0 *1 231.61,50.4
X$27055 1065 1412 219 320 1508 OR2_X1
* cell instance $27056 m0 *1 229.14,50.4
X$27056 1508 1119 1602 320 219 1509 OAI21_X4
* cell instance $27059 m0 *1 235.6,50.4
X$27059 1417 1596 1415 219 320 1503 MUX2_X1
* cell instance $27063 r0 *1 230.66,50.4
X$27063 219 14181 1594 1593 1256 320 DFF_X1
* cell instance $27068 r0 *1 234.27,50.4
X$27068 219 14323 1686 1595 1256 320 DFF_X1
* cell instance $27070 r0 *1 237.88,50.4
X$27070 1419 1781 1681 219 320 1597 MUX2_X1
* cell instance $27071 m0 *1 238.26,50.4
X$27071 1506 219 320 1056 BUF_X1
* cell instance $27076 r0 *1 239.59,50.4
X$27076 1598 219 320 1254 BUF_X1
* cell instance $27078 m0 *1 239.97,50.4
X$27078 1504 219 320 1190 BUF_X1
* cell instance $27093 r0 *1 9.12,92.4
X$27093 4142 219 320 4144 BUF_X1
* cell instance $27096 r0 *1 10.26,92.4
X$27096 219 14207 4145 4210 4143 320 DFF_X1
* cell instance $27097 r0 *1 13.49,92.4
X$27097 4238 219 320 1599 CLKBUF_X3
* cell instance $27098 r0 *1 14.44,92.4
X$27098 219 14095 4146 4211 4143 320 DFF_X1
* cell instance $27099 m0 *1 18.05,92.4
X$27099 4050 1550 3945 219 320 4098 MUX2_X1
* cell instance $27100 m0 *1 14.82,92.4
X$27100 219 12707 4050 4098 3353 320 DFF_X1
* cell instance $27103 r0 *1 17.67,92.4
X$27103 4144 1734 4146 219 320 4211 MUX2_X1
* cell instance $27104 r0 *1 19,92.4
X$27104 4050 2957 4146 219 320 4325 MUX2_X1
* cell instance $27107 r0 *1 20.9,92.4
X$27107 4144 219 320 3945 BUF_X2
* cell instance $27109 m0 *1 21.28,92.4
X$27109 219 12717 4217 4100 3944 320 DFF_X1
* cell instance $27111 r0 *1 21.66,92.4
X$27111 219 13753 4327 4216 3944 320 DFF_X1
* cell instance $27112 r0 *1 24.89,92.4
X$27112 4217 1507 3945 219 320 4100 MUX2_X1
* cell instance $27114 r0 *1 26.41,92.4
X$27114 4361 219 320 1507 CLKBUF_X3
* cell instance $27115 r0 *1 27.36,92.4
X$27115 3945 1303 4220 219 320 4328 MUX2_X1
* cell instance $27116 m0 *1 28.12,92.4
X$27116 4051 219 320 3944 CLKBUF_X3
* cell instance $27121 r0 *1 28.69,92.4
X$27121 4218 2963 4221 219 320 4102 MUX2_X1
* cell instance $27122 r0 *1 30.02,92.4
X$27122 4220 3848 4276 219 320 4221 MUX2_X1
* cell instance $27124 r0 *1 31.54,92.4
X$27124 4144 1467 4052 219 320 4222 MUX2_X1
* cell instance $27125 r0 *1 32.87,92.4
X$27125 219 14410 4052 4222 3944 320 DFF_X1
* cell instance $27126 m0 *1 34.2,92.4
X$27126 219 12841 3992 4101 3244 320 DFF_X1
* cell instance $27129 m0 *1 37.62,92.4
X$27129 219 12858 4055 4054 3946 320 DFF_X1
* cell instance $27130 m0 *1 40.85,92.4
X$27130 4055 2888 4148 219 320 4103 MUX2_X1
* cell instance $27131 m0 *1 42.18,92.4
X$27131 219 12856 4056 4106 3946 320 DFF_X1
* cell instance $27132 m0 *1 45.41,92.4
X$27132 4056 1384 3945 219 320 4106 MUX2_X1
* cell instance $27134 m0 *1 46.93,92.4
X$27134 3945 1695 4150 219 320 4107 MUX2_X1
* cell instance $27136 m0 *1 48.45,92.4
X$27136 4056 3950 3996 219 320 4057 MUX2_X1
* cell instance $27138 m0 *1 49.97,92.4
X$27138 4057 2892 4109 219 320 4229 MUX2_X1
* cell instance $27140 m0 *1 51.49,92.4
X$27140 3948 320 1384 219 BUF_X4
* cell instance $27142 r0 *1 36.1,92.4
X$27142 4052 1520 3992 219 320 4053 MUX2_X1
* cell instance $27143 r0 *1 37.43,92.4
X$27143 4055 1469 3945 219 320 4054 MUX2_X1
* cell instance $27144 r0 *1 38.76,92.4
X$27144 219 14589 4148 4104 3946 320 DFF_X1
* cell instance $27145 r0 *1 41.99,92.4
X$27145 3945 1523 4148 219 320 4104 MUX2_X1
* cell instance $27146 r0 *1 43.32,92.4
X$27146 3946 219 320 14769 INV_X1
* cell instance $27148 r0 *1 43.89,92.4
X$27148 219 14056 4150 4107 3946 320 DFF_X1
* cell instance $27151 r0 *1 48.07,92.4
X$27151 4229 2149 4147 219 320 4231 MUX2_X1
* cell instance $27153 r0 *1 49.78,92.4
X$27153 4228 3044 4231 320 219 3279 OAI21_X4
* cell instance $27156 m0 *1 53.2,92.4
X$27156 219 12862 3951 3949 3313 320 DFF_X1
* cell instance $27158 m0 *1 58.71,92.4
X$27158 3952 219 320 3759 BUF_X2
* cell instance $27159 m0 *1 59.47,92.4
X$27159 3953 2086 3759 219 320 4002 MUX2_X1
* cell instance $27165 r0 *1 58.14,92.4
X$27165 4335 1841 3759 219 320 4334 MUX2_X1
* cell instance $27168 r0 *1 60.04,92.4
X$27168 3759 1647 4283 219 320 4151 MUX2_X1
* cell instance $27169 m0 *1 62.51,92.4
X$27169 4059 4003 4112 219 320 4235 MUX2_X1
* cell instance $27170 m0 *1 61.18,92.4
X$27170 3953 2888 3757 219 320 4059 MUX2_X1
* cell instance $27171 m0 *1 63.84,92.4
X$27171 3909 2657 3954 219 320 4112 MUX2_X1
* cell instance $27172 m0 *1 65.17,92.4
X$27172 3759 1898 3954 219 320 4004 MUX2_X1
* cell instance $27173 m0 *1 66.5,92.4
X$27173 3993 320 1898 219 BUF_X4
* cell instance $27180 r0 *1 63.65,92.4
X$27180 4235 2777 219 320 4337 NAND2_X1
* cell instance $27183 r0 *1 64.79,92.4
X$27183 4237 320 1647 219 BUF_X4
* cell instance $27184 r0 *1 66.12,92.4
X$27184 4238 320 1476 219 BUF_X4
* cell instance $27186 r0 *1 67.64,92.4
X$27186 3952 1476 4153 219 320 4152 MUX2_X1
* cell instance $27187 m0 *1 68.4,92.4
X$27187 3952 1571 4009 219 320 4008 MUX2_X1
* cell instance $27189 m0 *1 69.73,92.4
X$27189 3819 2731 4009 219 320 4243 MUX2_X1
* cell instance $27190 m0 *1 71.06,92.4
X$27190 3948 320 3496 219 BUF_X4
* cell instance $27191 m0 *1 72.39,92.4
X$27191 219 13433 4060 4113 3680 320 DFF_X1
* cell instance $27192 m0 *1 75.62,92.4
X$27192 3947 320 3860 219 BUF_X4
* cell instance $27193 m0 *1 76.95,92.4
X$27193 3822 2892 4061 219 320 4062 MUX2_X1
* cell instance $27196 m0 *1 80.56,92.4
X$27196 219 13312 4064 4114 3761 320 DFF_X1
* cell instance $27197 m0 *1 83.79,92.4
X$27197 3584 1476 4064 219 320 4114 MUX2_X1
* cell instance $27200 r0 *1 69.35,92.4
X$27200 4443 2520 4153 219 320 4242 MUX2_X1
* cell instance $27201 r0 *1 70.68,92.4
X$27201 4243 2659 4242 219 320 4244 MUX2_X1
* cell instance $27204 r0 *1 73.15,92.4
X$27204 3759 1983 4060 219 320 4113 MUX2_X1
* cell instance $27206 r0 *1 75.24,92.4
X$27206 3759 1999 4287 219 320 4286 MUX2_X1
* cell instance $27208 r0 *1 76.76,92.4
X$27208 4060 2787 4287 219 320 4061 MUX2_X1
* cell instance $27210 r0 *1 78.47,92.4
X$27210 219 14396 4288 4246 4121 320 DFF_X1
* cell instance $27212 r0 *1 82.46,92.4
X$27212 3202 1647 4154 219 320 4063 MUX2_X1
* cell instance $27214 r0 *1 84.17,92.4
X$27214 219 13797 4065 4117 4121 320 DFF_X1
* cell instance $27216 m0 *1 85.5,92.4
X$27216 3202 1999 4065 219 320 4117 MUX2_X1
* cell instance $27218 m0 *1 88.54,92.4
X$27218 3202 1983 4118 219 320 4066 MUX2_X1
* cell instance $27219 m0 *1 89.87,92.4
X$27219 3202 1898 4067 219 320 4120 MUX2_X1
* cell instance $27220 m0 *1 91.2,92.4
X$27220 219 13486 4067 4120 4121 320 DFF_X1
* cell instance $27225 r0 *1 88.16,92.4
X$27225 3584 1478 4156 219 320 4155 MUX2_X1
* cell instance $27226 r0 *1 89.49,92.4
X$27226 3584 1389 4158 219 320 4119 MUX2_X1
* cell instance $27227 r0 *1 90.82,92.4
X$27227 219 14191 4158 4119 4121 320 DFF_X1
* cell instance $27228 r0 *1 94.05,92.4
X$27228 4158 3595 4067 219 320 4159 MUX2_X1
* cell instance $27231 m0 *1 100.32,92.4
X$27231 4068 2327 3956 219 320 4125 MUX2_X1
* cell instance $27232 m0 *1 97.09,92.4
X$27232 219 13435 4068 4123 3589 320 DFF_X1
* cell instance $27235 m0 *1 102.6,92.4
X$27235 4125 2665 219 320 4021 NOR2_X1
* cell instance $27238 r0 *1 97.85,92.4
X$27238 4160 4072 3956 219 320 4124 MUX2_X1
* cell instance $27239 r0 *1 99.18,92.4
X$27239 4160 4255 4068 219 320 4123 MUX2_X1
* cell instance $27240 r0 *1 100.51,92.4
X$27240 4160 219 320 3684 BUF_X2
* cell instance $27242 r0 *1 102.79,92.4
X$27242 219 14353 4162 4259 4453 320 DFF_X1
* cell instance $27244 m0 *1 103.55,92.4
X$27244 4021 3957 4127 4069 3958 4126 219 320 4070 OAI33_X1
* cell instance $27245 m0 *1 105.07,92.4
X$27245 3684 3858 4022 219 320 4130 MUX2_X1
* cell instance $27246 m0 *1 106.4,92.4
X$27246 219 13399 4022 4130 3589 320 DFF_X1
* cell instance $27248 m0 *1 110.39,92.4
X$27248 3942 219 320 4131 BUF_X1
* cell instance $27250 r0 *1 106.02,92.4
X$27250 3684 4163 4162 219 320 4259 MUX2_X1
* cell instance $27254 r0 *1 109.44,92.4
X$27254 2669 4257 4571 3923 320 219 4164 OAI22_X2
* cell instance $27255 r0 *1 111.15,92.4
X$27255 4166 3491 4165 219 320 4257 MUX2_X1
* cell instance $27256 m0 *1 111.53,92.4
X$27256 219 13437 4166 4071 3493 320 DFF_X1
* cell instance $27261 r0 *1 112.67,92.4
X$27261 3859 4161 4166 219 320 4071 MUX2_X1
* cell instance $27264 r0 *1 115.71,92.4
X$27264 4131 4072 4132 219 320 4073 MUX2_X1
* cell instance $27265 m0 *1 119.13,92.4
X$27265 4075 3686 4134 219 320 3770 MUX2_X1
* cell instance $27266 m0 *1 115.9,92.4
X$27266 219 13413 4132 4073 3495 320 DFF_X1
* cell instance $27270 r0 *1 118.18,92.4
X$27270 4132 4076 3861 219 320 4075 MUX2_X1
* cell instance $27274 r0 *1 119.51,92.4
X$27274 4131 4255 4028 219 320 3960 MUX2_X1
* cell instance $27276 m0 *1 122.17,92.4
X$27276 219 13430 3961 4029 3134 320 DFF_X1
* cell instance $27277 m0 *1 120.84,92.4
X$27277 4028 4076 3961 219 320 4134 MUX2_X1
* cell instance $27285 m0 *1 128.25,92.4
X$27285 219 13482 3963 3962 3134 320 DFF_X1
* cell instance $27287 m0 *1 131.48,92.4
X$27287 3963 4136 4032 219 320 4077 MUX2_X1
* cell instance $27292 m0 *1 133.19,92.4
X$27292 3138 4077 219 320 4078 OR2_X1
* cell instance $27294 m0 *1 138.51,92.4
X$27294 219 13480 4034 3964 4079 320 DFF_X1
* cell instance $27295 m0 *1 141.74,92.4
X$27295 219 13481 3965 4035 4079 320 DFF_X1
* cell instance $27299 m0 *1 155.61,92.4
X$27299 4138 4080 219 320 402 NOR2_X2
* cell instance $27301 m0 *1 158.08,92.4
X$27301 4141 4081 219 320 3967 NOR2_X1
* cell instance $27302 m0 *1 158.65,92.4
X$27302 3967 4270 4139 219 320 4040 NOR3_X1
* cell instance $27303 m0 *1 159.41,92.4
X$27303 3977 2241 3387 4082 320 219 4139 OAI22_X1
* cell instance $27304 m0 *1 160.36,92.4
X$27304 4137 3973 4133 219 320 4138 NOR3_X1
* cell instance $27305 m0 *1 161.12,92.4
X$27305 4083 2528 3273 4084 320 219 3970 OAI22_X1
* cell instance $27306 m0 *1 162.07,92.4
X$27306 3650 2241 3508 4082 320 219 3971 OAI22_X1
* cell instance $27307 m0 *1 163.02,92.4
X$27307 4135 2528 3278 4084 320 219 3973 OAI22_X1
* cell instance $27308 m0 *1 163.97,92.4
X$27308 3871 2241 3384 4082 320 219 4133 OAI22_X1
* cell instance $27311 m0 *1 167.2,92.4
X$27311 4083 2681 3508 4128 320 219 4042 OAI22_X1
* cell instance $27312 m0 *1 168.15,92.4
X$27312 4129 4085 4042 219 320 4041 NOR3_X1
* cell instance $27316 m0 *1 171.38,92.4
X$27316 4086 3054 219 320 264 NOR2_X2
* cell instance $27319 m0 *1 173.28,92.4
X$27319 4122 4080 219 320 263 NOR2_X2
* cell instance $27322 m0 *1 176.51,92.4
X$27322 4258 2808 219 320 262 NOR2_X2
* cell instance $27323 m0 *1 177.46,92.4
X$27323 4115 3792 219 320 257 NOR2_X2
* cell instance $27325 m0 *1 178.6,92.4
X$27325 3976 4256 4116 219 320 4115 NOR3_X1
* cell instance $27328 r0 *1 133.57,92.4
X$27328 4078 3262 4030 320 219 4248 OAI21_X4
* cell instance $27332 r0 *1 138.7,92.4
X$27332 219 14202 4168 4261 4079 320 DFF_X1
* cell instance $27333 r0 *1 141.93,92.4
X$27333 4034 3775 3965 219 320 4169 MUX2_X1
* cell instance $27335 r0 *1 144.02,92.4
X$27335 1902 219 320 4079 CLKBUF_X3
* cell instance $27337 r0 *1 145.35,92.4
X$27337 219 13813 4170 4263 4079 320 DFF_X1
* cell instance $27339 r0 *1 149.34,92.4
X$27339 219 14148 4356 4264 4079 320 DFF_X1
* cell instance $27344 r0 *1 155.42,92.4
X$27344 4269 4173 219 320 345 NOR2_X2
* cell instance $27345 r0 *1 156.37,92.4
X$27345 4175 4080 219 320 938 NOR2_X2
* cell instance $27346 r0 *1 157.32,92.4
X$27346 4141 4268 219 320 4176 NOR2_X1
* cell instance $27347 r0 *1 157.89,92.4
X$27347 4176 4267 4272 219 320 4269 NOR3_X1
* cell instance $27348 r0 *1 158.65,92.4
X$27348 4177 4081 219 320 4178 NOR2_X1
* cell instance $27349 r0 *1 159.22,92.4
X$27349 4178 4300 4271 219 320 4140 NOR3_X1
* cell instance $27350 r0 *1 159.98,92.4
X$27350 4179 2241 3382 4082 320 219 4272 OAI22_X1
* cell instance $27352 r0 *1 161.12,92.4
X$27352 4083 2870 3273 4388 320 219 4045 OAI22_X1
* cell instance $27354 r0 *1 162.26,92.4
X$27354 3650 1727 3508 4273 320 219 4043 OAI22_X1
* cell instance $27356 r0 *1 163.59,92.4
X$27356 4180 2528 3277 4084 320 219 4270 OAI22_X1
* cell instance $27358 r0 *1 164.73,92.4
X$27358 4180 2681 3277 4171 320 219 4266 OAI22_X1
* cell instance $27360 r0 *1 165.87,92.4
X$27360 4181 4266 4265 219 320 4047 NOR3_X1
* cell instance $27361 r0 *1 166.63,92.4
X$27361 3977 1228 3387 4128 320 219 4265 OAI22_X1
* cell instance $27363 r0 *1 167.77,92.4
X$27363 4087 1228 3273 4171 320 219 4085 OAI22_X1
* cell instance $27364 r0 *1 168.72,92.4
X$27364 4182 1228 3278 4171 320 219 4184 OAI22_X1
* cell instance $27365 r0 *1 169.67,92.4
X$27365 4183 4184 4262 219 320 4122 NOR3_X1
* cell instance $27367 r0 *1 170.81,92.4
X$27367 4087 883 1453 3660 320 219 4185 OAI22_X2
* cell instance $27368 r0 *1 172.52,92.4
X$27368 4182 883 3347 1453 320 219 4260 OAI22_X1
* cell instance $27370 r0 *1 174.99,92.4
X$27370 4188 4260 4190 219 320 4189 NOR3_X1
* cell instance $27375 r0 *1 176.13,92.4
X$27375 4189 4080 219 320 227 NOR2_X2
* cell instance $27377 r0 *1 177.46,92.4
X$27377 4087 857 3660 1709 320 219 4192 OAI22_X1
* cell instance $27378 r0 *1 178.41,92.4
X$27378 4179 857 4193 1709 320 219 4256 OAI22_X1
* cell instance $27380 r0 *1 179.55,92.4
X$27380 2912 3398 219 320 4253 NOR2_X1
* cell instance $27381 r0 *1 180.12,92.4
X$27381 4182 857 1709 3347 320 219 4196 OAI22_X2
* cell instance $27383 m0 *1 180.5,92.4
X$27383 2912 3816 219 320 4195 NOR2_X1
* cell instance $27384 m0 *1 181.64,92.4
X$27384 2912 3705 219 320 4089 NOR2_X1
* cell instance $27389 m0 *1 189.24,92.4
X$27389 3782 3374 3393 706 320 219 4090 OAI22_X1
* cell instance $27390 m0 *1 190.19,92.4
X$27390 3781 3374 3698 706 320 219 4091 OAI22_X1
* cell instance $27395 r0 *1 181.83,92.4
X$27395 4088 4250 4251 219 320 4247 NOR3_X1
* cell instance $27400 r0 *1 185.44,92.4
X$27400 4247 3163 219 320 3530 NOR2_X1
* cell instance $27404 r0 *1 188.48,92.4
X$27404 3720 3398 219 320 4198 NOR2_X1
* cell instance $27406 r0 *1 189.24,92.4
X$27406 3193 3703 219 320 4200 NOR2_X1
* cell instance $27407 r0 *1 189.81,92.4
X$27407 4200 4090 4240 219 320 4236 NOR3_X1
* cell instance $27408 r0 *1 190.57,92.4
X$27408 4241 3613 3869 1131 320 219 4240 OAI22_X1
* cell instance $27409 r0 *1 191.52,92.4
X$27409 4239 3613 3979 1131 320 219 4311 OAI22_X1
* cell instance $27410 r0 *1 192.47,92.4
X$27410 3193 3705 219 320 4234 NOR2_X1
* cell instance $27418 m0 *1 200.64,92.4
X$27418 2482 219 320 3981 INV_X4
* cell instance $27420 m0 *1 201.59,92.4
X$27420 4013 3981 2941 320 219 4016 OAI21_X4
* cell instance $27421 m0 *1 204.06,92.4
X$27421 219 2933 320 3981 BUF_X8
* cell instance $27423 m0 *1 206.72,92.4
X$27423 4110 2933 3983 320 219 4007 OAI21_X4
* cell instance $27424 m0 *1 209.19,92.4
X$27424 2259 4108 219 320 4110 OR2_X1
* cell instance $27429 m0 *1 213.18,92.4
X$27429 219 13021 4093 4105 3615 320 DFF_X1
* cell instance $27430 m0 *1 211.85,92.4
X$27430 4092 2368 3984 219 320 4005 MUX2_X1
* cell instance $27434 r0 *1 213.75,92.4
X$27434 4092 2261 4093 219 320 4105 MUX2_X1
* cell instance $27436 r0 *1 215.46,92.4
X$27436 4093 3096 4094 219 320 3873 MUX2_X1
* cell instance $27437 r0 *1 216.79,92.4
X$27437 219 14411 4094 4202 4226 320 DFF_X1
* cell instance $27439 m0 *1 216.79,92.4
X$27439 4092 2169 4094 219 320 4202 MUX2_X1
* cell instance $27443 m0 *1 227.81,92.4
X$27443 219 13017 3898 3997 3521 320 DFF_X1
* cell instance $27444 m0 *1 225.34,92.4
X$27444 4095 3419 3902 320 219 3452 OAI21_X4
* cell instance $27446 m0 *1 231.23,92.4
X$27446 219 13016 3994 3995 3521 320 DFF_X1
* cell instance $27447 m0 *1 234.46,92.4
X$27447 4209 219 320 3998 BUF_X1
* cell instance $27450 m0 *1 237.31,92.4
X$27450 3985 2831 3991 219 320 3989 MUX2_X1
* cell instance $27454 r0 *1 227.81,92.4
X$27454 219 13846 4319 4224 4317 320 DFF_X1
* cell instance $27459 r0 *1 231.8,92.4
X$27459 4223 219 320 4208 BUF_X1
* cell instance $27462 r0 *1 236.17,92.4
X$27462 4207 219 320 4320 BUF_X1
* cell instance $27463 r0 *1 236.74,92.4
X$27463 4324 219 320 4219 BUF_X1
* cell instance $27464 r0 *1 237.31,92.4
X$27464 4203 3081 4205 219 320 4204 MUX2_X1
* cell instance $27489 m0 *1 139.08,30.8
X$27489 219 12671 850 848 847 320 DFF_X1
* cell instance $27490 m0 *1 142.31,30.8
X$27490 849 733 952 320 219 883 OAI21_X4
* cell instance $27520 r0 *1 132.24,30.8
X$27520 219 14266 897 896 339 320 DFF_X1
* cell instance $27522 r0 *1 136.23,30.8
X$27522 897 350 898 219 320 945 MUX2_X1
* cell instance $27525 r0 *1 139.84,30.8
X$27525 945 219 320 947 INV_X1
* cell instance $27527 r0 *1 140.6,30.8
X$27527 899 621 1014 219 320 951 MUX2_X1
* cell instance $27531 r0 *1 143.26,30.8
X$27531 570 320 851 219 BUF_X4
* cell instance $27532 r0 *1 144.59,30.8
X$27532 219 14150 852 954 847 320 DFF_X1
* cell instance $27534 m0 *1 146.68,30.8
X$27534 399 851 852 219 320 954 MUX2_X1
* cell instance $27536 r0 *1 147.82,30.8
X$27536 219 14152 960 958 669 320 DFF_X1
* cell instance $27537 m0 *1 151.24,30.8
X$27537 960 447 853 219 320 854 MUX2_X1
* cell instance $27538 m0 *1 149.91,30.8
X$27538 342 851 853 219 320 887 MUX2_X1
* cell instance $27540 m0 *1 152.76,30.8
X$27540 219 12700 906 905 669 320 DFF_X1
* cell instance $27541 m0 *1 155.99,30.8
X$27541 961 625 855 320 219 891 OAI21_X4
* cell instance $27545 r0 *1 151.05,30.8
X$27545 342 900 960 219 320 958 MUX2_X1
* cell instance $27547 r0 *1 153.14,30.8
X$27547 342 903 906 219 320 905 MUX2_X1
* cell instance $27548 r0 *1 154.47,30.8
X$27548 342 902 892 219 320 963 MUX2_X1
* cell instance $27549 r0 *1 155.8,30.8
X$27549 906 670 892 219 320 855 MUX2_X1
* cell instance $27552 r0 *1 160.55,30.8
X$27552 364 219 320 907 CLKBUF_X3
* cell instance $27554 m0 *1 162.83,30.8
X$27554 867 320 447 219 BUF_X4
* cell instance $27557 m0 *1 164.92,30.8
X$27557 894 627 219 320 970 NAND2_X2
* cell instance $27558 m0 *1 165.87,30.8
X$27558 968 219 320 894 INV_X2
* cell instance $27559 m0 *1 166.44,30.8
X$27559 856 670 804 219 320 909 MUX2_X1
* cell instance $27562 r0 *1 164.92,30.8
X$27562 970 909 627 320 219 972 OAI21_X4
* cell instance $27563 r0 *1 167.39,30.8
X$27563 219 14173 910 973 732 320 DFF_X1
* cell instance $27565 m0 *1 168.15,30.8
X$27565 300 808 910 219 320 973 MUX2_X1
* cell instance $27567 m0 *1 169.86,30.8
X$27567 300 801 913 219 320 912 MUX2_X1
* cell instance $27568 m0 *1 171.38,30.8
X$27568 300 802 859 219 320 858 MUX2_X1
* cell instance $27569 m0 *1 172.71,30.8
X$27569 300 803 976 219 320 975 MUX2_X1
* cell instance $27572 m0 *1 174.99,30.8
X$27572 219 12676 979 980 735 320 DFF_X1
* cell instance $27573 m0 *1 178.22,30.8
X$27573 453 632 979 219 320 980 MUX2_X1
* cell instance $27575 m0 *1 181.07,30.8
X$27575 453 684 861 219 320 917 MUX2_X1
* cell instance $27577 r0 *1 170.62,30.8
X$27577 219 14236 913 912 732 320 DFF_X1
* cell instance $27578 r0 *1 173.85,30.8
X$27578 219 14246 976 975 735 320 DFF_X1
* cell instance $27579 r0 *1 177.08,30.8
X$27579 219 14224 914 977 735 320 DFF_X1
* cell instance $27580 r0 *1 180.31,30.8
X$27580 979 916 860 219 320 915 MUX2_X1
* cell instance $27581 r0 *1 181.64,30.8
X$27581 219 14203 861 917 863 320 DFF_X1
* cell instance $27583 m0 *1 182.78,30.8
X$27583 435 801 994 219 320 978 MUX2_X1
* cell instance $27584 m0 *1 185.63,30.8
X$27584 219 13502 919 862 863 320 DFF_X1
* cell instance $27586 r0 *1 184.87,30.8
X$27586 373 802 919 219 320 862 MUX2_X1
* cell instance $27587 r0 *1 186.2,30.8
X$27587 219 911 621 320 BUF_X16
* cell instance $27588 m0 *1 192.47,30.8
X$27588 867 320 350 219 BUF_X4
* cell instance $27589 m0 *1 189.24,30.8
X$27589 219 13508 864 865 863 320 DFF_X1
* cell instance $27591 r0 *1 190.95,30.8
X$27591 919 920 809 219 320 996 MUX2_X1
* cell instance $27592 r0 *1 192.28,30.8
X$27592 373 808 921 219 320 971 MUX2_X1
* cell instance $27594 r0 *1 193.8,30.8
X$27594 321 680 922 219 320 967 MUX2_X1
* cell instance $27595 m0 *1 194.37,30.8
X$27595 219 13506 923 964 813 320 DFF_X1
* cell instance $27597 m0 *1 197.6,30.8
X$27597 813 219 320 CLKBUF_X1
* cell instance $27599 r0 *1 195.13,30.8
X$27599 219 14015 922 967 813 320 DFF_X1
* cell instance $27600 r0 *1 198.36,30.8
X$27600 321 684 923 219 320 964 MUX2_X1
* cell instance $27601 m0 *1 198.74,30.8
X$27601 868 867 870 219 320 965 MUX2_X1
* cell instance $27603 m0 *1 200.07,30.8
X$27603 386 680 924 219 320 925 MUX2_X1
* cell instance $27605 r0 *1 199.69,30.8
X$27605 219 14002 924 925 926 320 DFF_X1
* cell instance $27606 m0 *1 201.97,30.8
X$27606 386 684 869 219 320 957 MUX2_X1
* cell instance $27609 m0 *1 203.49,30.8
X$27609 219 13514 870 871 926 320 DFF_X1
* cell instance $27611 m0 *1 206.91,30.8
X$27611 323 680 873 219 320 955 MUX2_X1
* cell instance $27613 m0 *1 208.43,30.8
X$27613 219 13368 873 955 748 320 DFF_X1
* cell instance $27615 m0 *1 211.85,30.8
X$27615 815 488 876 219 320 946 MUX2_X1
* cell instance $27616 m0 *1 213.18,30.8
X$27616 219 13378 876 948 748 320 DFF_X1
* cell instance $27618 m0 *1 216.6,30.8
X$27618 219 13497 941 874 930 320 DFF_X1
* cell instance $27623 r0 *1 203.49,30.8
X$27623 219 14134 869 957 926 320 DFF_X1
* cell instance $27627 r0 *1 211.66,30.8
X$27627 877 946 522 320 219 9267 MUX2_X2
* cell instance $27630 r0 *1 216.79,30.8
X$27630 530 927 941 219 320 874 MUX2_X1
* cell instance $27632 m0 *1 221.16,30.8
X$27632 219 13499 934 940 875 320 DFF_X1
* cell instance $27640 r0 *1 221.54,30.8
X$27640 219 14001 935 939 875 320 DFF_X1
* cell instance $27644 r0 *1 228.76,30.8
X$27644 219 14025 937 936 875 320 DFF_X1
* cell instance $27670 m0 *1 26.79,126
X$27670 6157 219 320 CLKBUF_X1
* cell instance $27681 r0 *1 13.3,126
X$27681 6362 6002 6363 219 320 6361 MUX2_X1
* cell instance $27682 r0 *1 14.63,126
X$27682 6362 5923 6405 219 320 6559 MUX2_X1
* cell instance $27683 r0 *1 15.96,126
X$27683 6363 2520 6405 219 320 6407 MUX2_X1
* cell instance $27684 r0 *1 17.29,126
X$27684 4051 219 320 6092 CLKBUF_X3
* cell instance $27688 r0 *1 21.85,126
X$27688 219 14319 6489 6409 6157 320 DFF_X1
* cell instance $27690 r0 *1 25.46,126
X$27690 4051 219 320 6157 CLKBUF_X3
* cell instance $27691 r0 *1 26.41,126
X$27691 6416 6042 6364 219 320 6562 MUX2_X1
* cell instance $27693 r0 *1 27.93,126
X$27693 6362 6121 6454 219 320 6491 MUX2_X1
* cell instance $27694 r0 *1 29.26,126
X$27694 6412 2963 6563 219 320 6317 MUX2_X1
* cell instance $27696 r0 *1 30.78,126
X$27696 219 14099 6365 6565 6455 320 DFF_X1
* cell instance $27697 r0 *1 34.01,126
X$27697 219 13686 6366 6415 6455 320 DFF_X1
* cell instance $27699 m0 *1 36.86,126
X$27699 6263 4003 6264 219 320 6318 MUX2_X1
* cell instance $27701 m0 *1 39.9,126
X$27701 6317 4992 219 320 6320 NAND2_X1
* cell instance $27702 m0 *1 40.47,126
X$27702 6318 2777 219 320 6319 NAND2_X1
* cell instance $27704 m0 *1 41.23,126
X$27704 6320 6319 2890 219 320 6321 NAND3_X2
* cell instance $27707 m0 *1 43.51,126
X$27707 6321 4279 6265 320 219 5744 OAI21_X4
* cell instance $27708 m0 *1 45.98,126
X$27708 6115 219 320 14756 INV_X1
* cell instance $27710 m0 *1 47.88,126
X$27710 219 3044 320 4854 BUF_X8
* cell instance $27714 r0 *1 37.81,126
X$27714 219 13756 6369 6368 6115 320 DFF_X1
* cell instance $27716 r0 *1 41.23,126
X$27716 6417 2714 6369 219 320 6494 MUX2_X1
* cell instance $27717 r0 *1 42.56,126
X$27717 6416 5808 6419 219 320 6422 MUX2_X1
* cell instance $27719 r0 *1 44.08,126
X$27719 219 13877 6419 6422 6115 320 DFF_X1
* cell instance $27720 r0 *1 47.31,126
X$27720 3679 219 320 6115 CLKBUF_X3
* cell instance $27722 m0 *1 50.92,126
X$27722 5932 6154 6266 219 320 6324 MUX2_X1
* cell instance $27724 m0 *1 52.25,126
X$27724 219 13439 6266 6324 6159 320 DFF_X1
* cell instance $27732 r0 *1 54.15,126
X$27732 3948 320 6110 219 BUF_X4
* cell instance $27734 r0 *1 55.67,126
X$27734 6370 219 320 6043 BUF_X2
* cell instance $27735 r0 *1 56.43,126
X$27735 6370 6121 6424 219 320 6423 MUX2_X1
* cell instance $27736 r0 *1 57.76,126
X$27736 219 14210 6424 6423 6267 320 DFF_X1
* cell instance $27737 m0 *1 58.33,126
X$27737 219 12879 6161 6160 6267 320 DFF_X1
* cell instance $27740 r0 *1 60.99,126
X$27740 6370 5933 6044 219 320 6268 MUX2_X1
* cell instance $27742 m0 *1 61.94,126
X$27742 219 12836 6044 6268 6267 320 DFF_X1
* cell instance $27743 m0 *1 65.36,126
X$27743 219 12825 6269 6326 6325 320 DFF_X1
* cell instance $27751 m0 *1 68.97,126
X$27751 6269 6110 6043 219 320 6326 MUX2_X1
* cell instance $27757 r0 *1 70.87,126
X$27757 6043 5804 6371 219 320 6507 MUX2_X1
* cell instance $27759 r0 *1 72.58,126
X$27759 6043 6046 6372 219 320 6426 MUX2_X1
* cell instance $27760 r0 *1 73.91,126
X$27760 219 14621 6372 6426 6427 320 DFF_X1
* cell instance $27762 r0 *1 77.33,126
X$27762 6373 219 320 6427 CLKBUF_X3
* cell instance $27763 r0 *1 78.28,126
X$27763 6427 219 320 CLKBUF_X1
* cell instance $27764 r0 *1 78.85,126
X$27764 6262 219 320 6164 BUF_X1
* cell instance $27765 m0 *1 80.37,126
X$27765 219 12853 6330 6329 6053 320 DFF_X1
* cell instance $27766 m0 *1 79.04,126
X$27766 6164 4559 6330 219 320 6329 MUX2_X1
* cell instance $27773 m0 *1 84.93,126
X$27773 6277 320 1651 219 BUF_X4
* cell instance $27777 r0 *1 85.12,126
X$27777 5350 2672 219 320 6374 NAND2_X1
* cell instance $27778 r0 *1 85.69,126
X$27778 5350 2792 219 320 6430 NAND2_X1
* cell instance $27781 r0 *1 86.83,126
X$27781 6373 219 320 6053 CLKBUF_X3
* cell instance $27783 m0 *1 87.4,126
X$27783 219 12663 6271 6225 6053 320 DFF_X1
* cell instance $27784 r0 *1 87.78,126
X$27784 219 14269 6375 6432 6053 320 DFF_X1
* cell instance $27785 r0 *1 91.01,126
X$27785 6375 3735 5514 219 320 6432 MUX2_X1
* cell instance $27787 m0 *1 91.01,126
X$27787 6375 5816 6271 219 320 6227 MUX2_X1
* cell instance $27788 m0 *1 93.1,126
X$27788 219 13622 6274 6272 6273 320 DFF_X1
* cell instance $27791 r0 *1 92.53,126
X$27791 6274 3592 5514 219 320 6272 MUX2_X1
* cell instance $27792 r0 *1 93.86,126
X$27792 219 14473 6275 6435 6273 320 DFF_X1
* cell instance $27793 m0 *1 98.04,126
X$27793 6276 5122 6277 219 320 6278 NOR3_X1
* cell instance $27794 m0 *1 96.71,126
X$27794 6274 5254 6275 219 320 6276 MUX2_X1
* cell instance $27795 m0 *1 98.8,126
X$27795 4854 6231 320 219 6436 AND2_X1
* cell instance $27796 m0 *1 99.56,126
X$27796 2471 6279 219 320 6334 XOR2_X1
* cell instance $27797 m0 *1 100.7,126
X$27797 6334 5819 219 320 6054 NOR2_X1
* cell instance $27799 m0 *1 101.46,126
X$27799 2438 6280 320 219 6167 XNOR2_X1
* cell instance $27800 m0 *1 102.6,126
X$27800 6337 320 2776 219 BUF_X4
* cell instance $27801 m0 *1 103.93,126
X$27801 6440 5946 6279 320 219 5410 OAI21_X4
* cell instance $27803 m0 *1 107.16,126
X$27803 219 6338 6282 5823 6143 6341 320 NOR4_X4
* cell instance $27804 m0 *1 110.58,126
X$27804 6283 4811 219 320 6338 NAND2_X1
* cell instance $27805 m0 *1 111.15,126
X$27805 5941 4559 6339 219 320 6343 MUX2_X1
* cell instance $27806 m0 *1 112.48,126
X$27806 219 13243 6339 6343 6145 320 DFF_X1
* cell instance $27807 m0 *1 115.71,126
X$27807 6285 4072 6173 219 320 6240 MUX2_X1
* cell instance $27808 m0 *1 117.04,126
X$27808 6284 219 320 6145 CLKBUF_X3
* cell instance $27811 m0 *1 122.55,126
X$27811 6285 4559 6286 219 320 6346 MUX2_X1
* cell instance $27813 m0 *1 124.07,126
X$27813 6378 5217 5952 219 320 6345 MUX2_X1
* cell instance $27815 r0 *1 97.09,126
X$27815 5514 3858 6275 219 320 6435 MUX2_X1
* cell instance $27816 r0 *1 98.42,126
X$27816 219 6259 6436 5946 6376 320 AOI21_X4
* cell instance $27817 r0 *1 100.89,126
X$27817 219 6287 6437 3044 6377 320 AOI21_X4
* cell instance $27819 r0 *1 103.55,126
X$27819 2338 6377 219 320 6439 XOR2_X1
* cell instance $27820 r0 *1 104.69,126
X$27820 6439 5117 219 320 6441 NOR2_X1
* cell instance $27822 r0 *1 106.02,126
X$27822 219 6441 6514 6171 6282 6337 320 OAI22_X4
* cell instance $27823 r0 *1 109.25,126
X$27823 2342 6442 320 219 5725 XNOR2_X1
* cell instance $27824 r0 *1 110.39,126
X$27824 5941 4617 6238 219 320 6340 MUX2_X1
* cell instance $27827 r0 *1 115.52,126
X$27827 6145 219 320 14713 INV_X2
* cell instance $27830 r0 *1 117.04,126
X$27830 6285 4255 6444 219 320 6443 MUX2_X1
* cell instance $27831 r0 *1 118.37,126
X$27831 219 14562 6444 6443 6466 320 DFF_X1
* cell instance $27838 r0 *1 123.69,126
X$27838 6285 4617 6378 219 320 6445 MUX2_X1
* cell instance $27840 r0 *1 125.21,126
X$27840 219 13975 6378 6445 6379 320 DFF_X1
* cell instance $27842 m0 *1 125.78,126
X$27842 219 13374 6286 6346 6379 320 DFF_X1
* cell instance $27843 m0 *1 129.2,126
X$27843 219 13517 6288 6347 5729 320 DFF_X1
* cell instance $27845 m0 *1 132.62,126
X$27845 6245 4351 6288 219 320 6347 MUX2_X1
* cell instance $27846 m0 *1 133.95,126
X$27846 6288 4584 6246 219 320 6350 MUX2_X1
* cell instance $27849 m0 *1 136.23,126
X$27849 5359 6349 219 320 6348 OR2_X1
* cell instance $27853 r0 *1 130.72,126
X$27853 219 14195 6380 6446 6058 320 DFF_X1
* cell instance $27854 r0 *1 133.95,126
X$27854 6245 4294 6380 219 320 6446 MUX2_X1
* cell instance $27855 r0 *1 135.28,126
X$27855 6380 4136 6381 219 320 6349 MUX2_X1
* cell instance $27856 r0 *1 136.61,126
X$27856 5428 219 320 6058 CLKBUF_X3
* cell instance $27857 m0 *1 137.56,126
X$27857 6348 4383 6350 320 219 5148 OAI21_X4
* cell instance $27862 m0 *1 142.5,126
X$27862 6289 320 4718 219 BUF_X4
* cell instance $27865 m0 *1 144.78,126
X$27865 219 13347 6292 6290 6291 320 DFF_X1
* cell instance $27867 m0 *1 148.2,126
X$27867 6292 6027 6175 219 320 6351 MUX2_X1
* cell instance $27869 m0 *1 149.72,126
X$27869 6351 5957 4921 320 219 6335 MUX2_X2
* cell instance $27870 m0 *1 151.43,126
X$27870 219 12806 6251 6250 6063 320 DFF_X1
* cell instance $27875 r0 *1 145.35,126
X$27875 2342 6447 320 219 6382 XNOR2_X1
* cell instance $27876 r0 *1 146.49,126
X$27876 6382 5830 219 320 6383 NAND2_X2
* cell instance $27878 r0 *1 148.96,126
X$27878 219 6450 6383 6448 6468 5434 320 OR4_X4
* cell instance $27881 r0 *1 154.85,126
X$27881 219 6451 6065 6293 6384 6448 320 NAND4_X4
* cell instance $27883 m0 *1 155.04,126
X$27883 2674 6335 219 320 6293 XNOR2_X2
* cell instance $27885 m0 *1 160.17,126
X$27885 6287 4081 219 320 6356 NOR2_X1
* cell instance $27886 m0 *1 160.74,126
X$27886 4083 2545 6295 4396 320 219 6294 OAI22_X2
* cell instance $27887 m0 *1 162.45,126
X$27887 4389 2545 4400 6295 320 219 6360 OAI22_X1
* cell instance $27888 m0 *1 163.4,126
X$27888 4083 2543 6296 4396 320 219 6358 OAI22_X2
* cell instance $27889 m0 *1 165.11,126
X$27889 3977 1365 3565 6257 320 219 6359 OAI22_X1
* cell instance $27891 m0 *1 167.58,126
X$27891 6259 4081 219 320 6357 NOR2_X1
* cell instance $27892 m0 *1 168.15,126
X$27892 3977 2158 3565 6297 320 219 6355 OAI22_X1
* cell instance $27893 m0 *1 169.1,126
X$27893 6357 6354 6355 219 320 6392 NOR3_X1
* cell instance $27894 m0 *1 169.86,126
X$27894 4389 2543 4400 6296 320 219 6354 OAI22_X1
* cell instance $27899 r0 *1 160.36,126
X$27899 6287 4721 219 320 6385 NOR2_X1
* cell instance $27902 r0 *1 161.88,126
X$27902 4472 2545 4521 6295 320 219 6449 OAI22_X1
* cell instance $27903 r0 *1 162.83,126
X$27903 4472 2543 4521 6296 320 219 6387 OAI22_X1
* cell instance $27905 r0 *1 164.16,126
X$27905 6356 6360 6359 219 320 6301 NOR3_X1
* cell instance $27908 r0 *1 165.49,126
X$27908 4346 1281 4521 5834 320 219 6389 OAI22_X1
* cell instance $27910 r0 *1 166.82,126
X$27910 4182 1281 3278 5834 320 219 6391 OAI22_X1
* cell instance $27913 r0 *1 168.34,126
X$27913 4135 2543 4387 6296 320 219 6471 OAI22_X1
* cell instance $27915 r0 *1 169.48,126
X$27915 4470 2543 4459 6296 320 219 6438 OAI22_X1
* cell instance $27918 r0 *1 171,126
X$27918 3384 6030 891 3276 320 219 6434 OAI22_X2
* cell instance $27919 m0 *1 171.38,126
X$27919 6352 6299 219 320 6298 NOR2_X2
* cell instance $27921 m0 *1 172.33,126
X$27921 6353 5793 219 320 6300 NAND2_X1
* cell instance $27923 r0 *1 172.71,126
X$27923 5739 5958 219 320 6336 NOR2_X2
* cell instance $27925 m0 *1 173.28,126
X$27925 5837 6179 3506 2105 320 219 6070 OAI22_X1
* cell instance $27926 r0 *1 173.66,126
X$27926 6020 6179 3503 891 320 219 6433 OAI22_X1
* cell instance $27927 m0 *1 174.8,126
X$27927 4193 2105 3457 6030 320 219 6344 OAI22_X1
* cell instance $27929 m0 *1 175.75,126
X$27929 3387 6030 3383 891 320 219 6302 OAI22_X1
* cell instance $27931 m0 *1 176.89,126
X$27931 6342 6302 219 320 6303 NOR2_X1
* cell instance $27934 r0 *1 174.8,126
X$27934 6433 6344 219 320 6429 NOR2_X1
* cell instance $27939 r0 *1 175.56,126
X$27939 6538 320 3278 219 BUF_X4
* cell instance $27940 r0 *1 176.89,126
X$27940 6305 6589 6303 219 6408 320 AOI21_X2
* cell instance $27941 m0 *1 178.03,126
X$27941 6180 5963 219 320 6333 NOR2_X1
* cell instance $27943 m0 *1 178.6,126
X$27943 6182 6181 219 320 6304 NOR2_X1
* cell instance $27944 m0 *1 179.17,126
X$27944 6305 6428 6304 219 6331 320 AOI21_X2
* cell instance $27945 m0 *1 180.5,126
X$27945 5696 6184 219 320 6183 NAND2_X1
* cell instance $27946 m0 *1 181.07,126
X$27946 219 6308 6239 6185 6333 320 AOI21_X4
* cell instance $27947 m0 *1 183.54,126
X$27947 6237 320 4193 219 BUF_X4
* cell instance $27948 m0 *1 184.87,126
X$27948 6186 320 3788 219 BUF_X4
* cell instance $27951 r0 *1 178.6,126
X$27951 6353 6184 219 320 6506 NAND2_X1
* cell instance $27953 r0 *1 179.55,126
X$27953 5617 6394 219 320 6428 NAND2_X1
* cell instance $27956 r0 *1 180.69,126
X$27956 5696 6394 219 320 6425 NAND2_X1
* cell instance $27957 r0 *1 181.26,126
X$27957 6305 6425 5965 219 6332 320 AOI21_X2
* cell instance $27958 r0 *1 182.59,126
X$27958 6395 320 4182 219 BUF_X4
* cell instance $27960 r0 *1 184.11,126
X$27960 4883 320 3512 219 BUF_X4
* cell instance $27963 r0 *1 186.39,126
X$27963 6392 5537 219 320 6420 NOR2_X1
* cell instance $27964 m0 *1 186.77,126
X$27964 6073 320 3650 219 BUF_X4
* cell instance $27967 m0 *1 188.29,126
X$27967 6305 320 2808 219 BUF_X4
* cell instance $27971 r0 *1 187.15,126
X$27971 219 3058 320 6239 BUF_X8
* cell instance $27973 m0 *1 190.95,126
X$27973 6305 320 3725 219 BUF_X4
* cell instance $27975 m0 *1 192.28,126
X$27975 6239 320 5570 219 BUF_X4
* cell instance $27977 m0 *1 196.65,126
X$27977 6126 6328 219 320 6306 NOR2_X1
* cell instance $27978 m0 *1 197.22,126
X$27978 6198 5447 6189 219 320 6327 MUX2_X1
* cell instance $27979 m0 *1 198.55,126
X$27979 6198 5448 6079 219 320 6125 MUX2_X1
* cell instance $27980 m0 *1 199.88,126
X$27980 6198 5198 6192 219 320 6220 MUX2_X1
* cell instance $27981 m0 *1 201.21,126
X$27981 6192 6080 6193 219 320 6082 MUX2_X1
* cell instance $27982 m0 *1 202.54,126
X$27982 6198 5036 6193 219 320 6219 MUX2_X1
* cell instance $27983 m0 *1 203.87,126
X$27983 219 13336 6194 6217 6191 320 DFF_X1
* cell instance $27988 r0 *1 191.71,126
X$27988 6301 5537 219 320 6421 NOR2_X1
* cell instance $27991 r0 *1 193.99,126
X$27991 6305 320 5537 219 BUF_X4
* cell instance $27995 r0 *1 203.3,126
X$27995 5567 219 320 6191 CLKBUF_X3
* cell instance $27996 r0 *1 204.25,126
X$27996 219 13815 6216 6418 6191 320 DFF_X1
* cell instance $27999 m0 *1 209.19,126
X$27999 219 13383 6196 6307 6197 320 DFF_X1
* cell instance $28001 m0 *1 212.42,126
X$28001 6398 219 320 5639 BUF_X1
* cell instance $28004 m0 *1 213.94,126
X$28004 5567 219 320 6197 CLKBUF_X3
* cell instance $28005 m0 *1 214.89,126
X$28005 219 12829 6399 6323 6197 320 DFF_X1
* cell instance $28006 m0 *1 218.12,126
X$28006 219 12950 6413 6322 6197 320 DFF_X1
* cell instance $28007 m0 *1 221.35,126
X$28007 6309 5447 6199 219 320 6214 MUX2_X1
* cell instance $28008 m0 *1 222.68,126
X$28008 219 12638 6200 6316 6310 320 DFF_X1
* cell instance $28009 m0 *1 225.91,126
X$28009 5647 6311 6200 219 320 6316 MUX2_X1
* cell instance $28011 m0 *1 227.43,126
X$28011 219 13512 6201 6315 6310 320 DFF_X1
* cell instance $28015 r0 *1 209.95,126
X$28015 219 6397 6398 320 BUF_X16
* cell instance $28018 r0 *1 215.84,126
X$28018 6309 5198 6399 219 320 6323 MUX2_X1
* cell instance $28019 r0 *1 217.17,126
X$28019 6399 6398 6111 219 320 6400 MUX2_X1
* cell instance $28022 r0 *1 219.07,126
X$28022 6199 6398 6413 219 320 6414 MUX2_X1
* cell instance $28023 r0 *1 220.4,126
X$28023 6309 5448 6413 219 320 6322 MUX2_X1
* cell instance $28028 r0 *1 226.86,126
X$28028 6410 219 320 4322 BUF_X2
* cell instance $28033 r0 *1 230.47,126
X$28033 4942 320 5995 219 BUF_X4
* cell instance $28037 m0 *1 231.99,126
X$28037 5160 320 6311 219 BUF_X4
* cell instance $28041 m0 *1 234.27,126
X$28041 6564 4532 6745 320 219 5970 OAI21_X4
* cell instance $28042 m0 *1 236.74,126
X$28042 6306 219 320 6313 BUF_X1
* cell instance $28044 m0 *1 237.5,126
X$28044 219 13067 6204 6203 6401 320 DFF_X1
* cell instance $28049 r0 *1 234.46,126
X$28049 4941 320 6101 219 BUF_X4
* cell instance $28050 r0 *1 235.79,126
X$28050 4322 6406 219 320 6314 OR2_X1
* cell instance $28051 r0 *1 236.55,126
X$28051 219 13925 6095 6209 6401 320 DFF_X1
* cell instance $28052 r0 *1 239.78,126
X$28052 6331 219 320 6404 BUF_X1
* cell instance $28061 m0 *1 16.91,131.6
X$28061 219 13286 6524 6561 6092 320 DFF_X1
* cell instance $28074 r0 *1 19.95,131.6
X$28074 6849 2659 6750 219 320 6761 MUX2_X1
* cell instance $28077 m0 *1 22.8,131.6
X$28077 219 13331 6490 6525 6157 320 DFF_X1
* cell instance $28078 m0 *1 32.11,131.6
X$28078 6606 219 320 6455 CLKBUF_X3
* cell instance $28079 m0 *1 33.06,131.6
X$28079 6455 219 320 14724 INV_X1
* cell instance $28082 m0 *1 34.39,131.6
X$28082 6756 4003 6755 219 320 6649 MUX2_X1
* cell instance $28086 m0 *1 40.47,131.6
X$28086 6649 4906 219 320 6652 NAND2_X1
* cell instance $28087 m0 *1 41.04,131.6
X$28087 6607 6652 2890 219 320 6651 NAND3_X2
* cell instance $28088 m0 *1 42.37,131.6
X$28088 6608 3758 6761 219 320 6653 MUX2_X1
* cell instance $28089 m0 *1 43.7,131.6
X$28089 6651 4279 6653 320 219 5737 OAI21_X4
* cell instance $28094 r0 *1 26.79,131.6
X$28094 6751 3126 6702 219 320 6759 MUX2_X1
* cell instance $28097 r0 *1 31.92,131.6
X$28097 6804 2657 6905 219 320 6755 MUX2_X1
* cell instance $28099 r0 *1 33.44,131.6
X$28099 6805 3848 6907 219 320 6756 MUX2_X1
* cell instance $28103 r0 *1 40.09,131.6
X$28103 6759 4992 219 320 6607 NAND2_X1
* cell instance $28104 r0 *1 40.66,131.6
X$28104 3993 320 6853 219 BUF_X4
* cell instance $28106 r0 *1 45.03,131.6
X$28106 5810 320 1552 219 BUF_X4
* cell instance $28108 m0 *1 46.74,131.6
X$28108 6605 219 320 6370 BUF_X1
* cell instance $28114 r0 *1 47.5,131.6
X$28114 6458 320 1562 219 BUF_X4
* cell instance $28115 r0 *1 48.83,131.6
X$28115 6370 6002 6703 219 320 6763 MUX2_X1
* cell instance $28116 m0 *1 50.16,131.6
X$28116 219 13389 6571 6527 6159 320 DFF_X1
* cell instance $28118 m0 *1 53.39,131.6
X$28118 219 13388 6609 6657 6159 320 DFF_X1
* cell instance $28120 r0 *1 50.16,131.6
X$28120 219 14233 6703 6763 6159 320 DFF_X1
* cell instance $28122 r0 *1 53.77,131.6
X$28122 6703 5816 6704 219 320 6767 MUX2_X1
* cell instance $28123 r0 *1 55.1,131.6
X$28123 6609 5816 6571 219 320 6766 MUX2_X1
* cell instance $28126 m0 *1 57,131.6
X$28126 6370 6156 6459 219 320 6765 MUX2_X1
* cell instance $28128 m0 *1 59.28,131.6
X$28128 4997 320 3126 219 BUF_X4
* cell instance $28129 m0 *1 60.61,131.6
X$28129 6373 219 320 6267 CLKBUF_X3
* cell instance $28131 m0 *1 63.08,131.6
X$28131 6575 6662 6612 219 320 6610 MUX2_X1
* cell instance $28132 m0 *1 64.41,131.6
X$28132 6528 1835 6812 219 320 6611 MUX2_X1
* cell instance $28133 m0 *1 65.74,131.6
X$28133 219 12785 6576 6664 6325 320 DFF_X1
* cell instance $28136 m0 *1 70.68,131.6
X$28136 3947 320 5930 219 BUF_X4
* cell instance $28138 m0 *1 73.53,131.6
X$28138 4282 320 6270 219 BUF_X4
* cell instance $28143 m0 *1 83.41,131.6
X$28143 5678 4492 6613 219 320 6668 MUX2_X1
* cell instance $28144 m0 *1 84.74,131.6
X$28144 6164 4485 6669 219 320 6772 MUX2_X1
* cell instance $28148 r0 *1 57.38,131.6
X$28148 219 14042 6459 6765 6267 320 DFF_X1
* cell instance $28149 r0 *1 60.61,131.6
X$28149 6766 6767 5077 320 219 6585 MUX2_X2
* cell instance $28151 r0 *1 62.51,131.6
X$28151 6706 1567 6705 219 320 6707 MUX2_X1
* cell instance $28155 r0 *1 63.84,131.6
X$28155 6707 1510 6708 219 320 6709 MUX2_X1
* cell instance $28157 r0 *1 65.55,131.6
X$28157 6611 2149 6709 219 320 6770 MUX2_X1
* cell instance $28159 r0 *1 67.07,131.6
X$28159 6612 6710 6576 219 320 6664 MUX2_X1
* cell instance $28161 r0 *1 68.59,131.6
X$28161 6770 6771 1643 320 219 6353 MUX2_X2
* cell instance $28165 r0 *1 82.84,131.6
X$28165 6277 320 2752 219 BUF_X4
* cell instance $28166 r0 *1 84.17,131.6
X$28166 6164 219 320 5678 BUF_X2
* cell instance $28168 r0 *1 85.12,131.6
X$28168 219 14081 6669 6772 6775 320 DFF_X1
* cell instance $28170 m0 *1 87.97,131.6
X$28170 6613 6172 6669 219 320 6670 MUX2_X1
* cell instance $28173 m0 *1 97.66,131.6
X$28173 6273 219 320 14722 INV_X1
* cell instance $28174 m0 *1 98.04,131.6
X$28174 6584 4367 5253 320 6672 219 NOR3_X2
* cell instance $28175 m0 *1 99.37,131.6
X$28175 6284 219 320 6273 CLKBUF_X3
* cell instance $28176 m0 *1 100.32,131.6
X$28176 6614 6616 219 320 6615 NOR2_X1
* cell instance $28179 r0 *1 88.54,131.6
X$28179 6164 4490 6711 219 320 6777 MUX2_X1
* cell instance $28180 r0 *1 89.87,131.6
X$28180 219 13918 6711 6777 6775 320 DFF_X1
* cell instance $28182 r0 *1 93.29,131.6
X$28182 6711 6172 6867 219 320 6614 MUX2_X1
* cell instance $28183 r0 *1 94.62,131.6
X$28183 6670 6917 5515 320 6780 219 NOR3_X2
* cell instance $28186 r0 *1 96.52,131.6
X$28186 6712 3735 5678 219 320 6817 MUX2_X1
* cell instance $28190 r0 *1 99.18,131.6
X$28190 219 6780 6615 6781 6672 5518 320 NOR4_X4
* cell instance $28191 m0 *1 101.46,131.6
X$28191 5816 5253 219 320 6616 NAND2_X1
* cell instance $28194 m0 *1 102.98,131.6
X$28194 5122 5421 219 320 6618 NAND2_X1
* cell instance $28195 m0 *1 102.41,131.6
X$28195 2994 4906 219 320 6676 NOR2_X1
* cell instance $28197 r0 *1 102.6,131.6
X$28197 6431 6617 6713 219 320 NOR2_X4
* cell instance $28198 m0 *1 106.02,131.6
X$28198 219 6680 6783 4906 2757 320 AOI21_X4
* cell instance $28199 m0 *1 103.93,131.6
X$28199 6431 6617 6677 6678 6140 6675 219 320 OAI221_X2
* cell instance $28200 m0 *1 108.49,131.6
X$28200 2867 2757 5479 219 320 6619 NAND3_X1
* cell instance $28203 r0 *1 104.31,131.6
X$28203 5479 2861 2994 219 320 6784 OR3_X1
* cell instance $28205 r0 *1 105.64,131.6
X$28205 2861 5479 219 320 6783 NOR2_X1
* cell instance $28207 r0 *1 106.4,131.6
X$28207 6138 6713 6619 6784 6785 320 219 AOI211_X2
* cell instance $28209 r0 *1 108.49,131.6
X$28209 6679 4367 6277 320 6819 219 NOR3_X2
* cell instance $28212 r0 *1 110.77,131.6
X$28212 219 14513 6714 6786 6466 320 DFF_X1
* cell instance $28213 m0 *1 111.34,131.6
X$28213 6588 6172 6681 219 320 6679 MUX2_X1
* cell instance $28216 m0 *1 112.86,131.6
X$28216 219 13251 6681 6530 6466 320 DFF_X1
* cell instance $28219 r0 *1 114,131.6
X$28219 6714 3735 5820 219 320 6786 MUX2_X1
* cell instance $28222 r0 *1 116.28,131.6
X$28222 6284 219 320 6466 CLKBUF_X3
* cell instance $28223 r0 *1 117.23,131.6
X$28223 6716 3735 5727 219 320 6715 MUX2_X1
* cell instance $28224 r0 *1 118.56,131.6
X$28224 219 14403 6716 6715 6466 320 DFF_X1
* cell instance $28228 m0 *1 119.7,131.6
X$28228 6682 6683 2998 320 219 6169 MUX2_X2
* cell instance $28230 m0 *1 121.41,131.6
X$28230 6687 2904 6591 219 320 6683 MUX2_X1
* cell instance $28234 r0 *1 121.79,131.6
X$28234 6716 6590 6717 219 320 6687 MUX2_X1
* cell instance $28239 m0 *1 125.59,131.6
X$28239 6718 6622 6621 219 320 6620 MUX2_X1
* cell instance $28241 m0 *1 126.92,131.6
X$28241 219 13518 6621 6620 6379 320 DFF_X1
* cell instance $28242 m0 *1 130.15,131.6
X$28242 6379 219 320 CLKBUF_X1
* cell instance $28244 m0 *1 130.91,131.6
X$28244 6621 2909 6721 219 320 6689 MUX2_X1
* cell instance $28246 m0 *1 133,131.6
X$28246 3605 6689 219 320 6688 OR2_X1
* cell instance $28247 m0 *1 133.76,131.6
X$28247 6688 3746 6690 320 219 6179 OAI21_X4
* cell instance $28249 m0 *1 137.75,131.6
X$28249 6623 6622 6532 219 320 6592 MUX2_X1
* cell instance $28252 r0 *1 126.92,131.6
X$28252 6718 6719 6721 219 320 6720 MUX2_X1
* cell instance $28253 r0 *1 128.25,131.6
X$28253 219 13748 6721 6720 6379 320 DFF_X1
* cell instance $28254 r0 *1 131.48,131.6
X$28254 5428 219 320 6379 CLKBUF_X3
* cell instance $28258 r0 *1 134.52,131.6
X$28258 219 14158 6887 6788 6058 320 DFF_X1
* cell instance $28261 r0 *1 139.46,131.6
X$28261 6623 6724 6722 219 320 6791 MUX2_X1
* cell instance $28262 m0 *1 139.65,131.6
X$28262 6623 6691 6624 219 320 6692 MUX2_X1
* cell instance $28264 m0 *1 140.98,131.6
X$28264 219 13345 6624 6692 6291 320 DFF_X1
* cell instance $28265 m0 *1 144.21,131.6
X$28265 6722 5828 6624 219 320 6533 MUX2_X1
* cell instance $28266 m0 *1 145.54,131.6
X$28266 6291 219 320 14735 INV_X1
* cell instance $28268 m0 *1 146.11,131.6
X$28268 2439 6794 219 320 6695 XNOR2_X2
* cell instance $28269 m0 *1 148.01,131.6
X$28269 2471 6697 219 320 6598 XNOR2_X2
* cell instance $28271 m0 *1 150.1,131.6
X$28271 6625 4921 6534 219 320 6697 MUX2_X1
* cell instance $28273 r0 *1 140.79,131.6
X$28273 219 14090 6722 6791 6291 320 DFF_X1
* cell instance $28275 r0 *1 145.54,131.6
X$28275 5732 219 320 6291 CLKBUF_X3
* cell instance $28279 r0 *1 149.15,131.6
X$28279 6723 5828 6725 219 320 6534 MUX2_X1
* cell instance $28280 r0 *1 150.48,131.6
X$28280 6626 6691 6725 219 320 6795 MUX2_X1
* cell instance $28281 m0 *1 152,131.6
X$28281 6626 6622 6627 219 320 6535 MUX2_X1
* cell instance $28283 m0 *1 153.33,131.6
X$28283 6627 4718 6628 219 320 6625 MUX2_X1
* cell instance $28284 m0 *1 154.66,131.6
X$28284 6626 6719 6628 219 320 6630 MUX2_X1
* cell instance $28285 m0 *1 155.99,131.6
X$28285 6629 4921 6632 219 320 6631 MUX2_X1
* cell instance $28287 m0 *1 157.51,131.6
X$28287 3138 6629 219 320 6701 OR2_X1
* cell instance $28289 m0 *1 158.46,131.6
X$28289 6701 3262 6632 320 219 6296 OAI21_X4
* cell instance $28291 r0 *1 151.81,131.6
X$28291 219 13805 6725 6795 6726 320 DFF_X1
* cell instance $28292 r0 *1 155.04,131.6
X$28292 6796 6724 6727 219 320 6829 MUX2_X1
* cell instance $28295 r0 *1 157.51,131.6
X$28295 6727 5832 7006 219 320 6632 MUX2_X1
* cell instance $28300 m0 *1 161.31,131.6
X$28300 6673 320 4522 219 BUF_X4
* cell instance $28301 m0 *1 162.83,131.6
X$28301 4470 2545 4459 6295 320 219 6700 OAI22_X1
* cell instance $28303 m0 *1 163.97,131.6
X$28303 6699 6700 6603 219 320 6694 NOR3_X1
* cell instance $28305 r0 *1 161.31,131.6
X$28305 6797 5488 219 320 6798 NOR2_X2
* cell instance $28306 r0 *1 162.26,131.6
X$28306 4308 320 3383 219 BUF_X4
* cell instance $28307 r0 *1 163.59,131.6
X$28307 6536 5533 219 320 6729 NOR2_X2
* cell instance $28310 r0 *1 165.11,131.6
X$28310 6353 5959 219 320 6893 NAND2_X1
* cell instance $28311 m0 *1 165.3,131.6
X$28311 6698 4687 219 320 6696 NOR2_X2
* cell instance $28314 m0 *1 167.01,131.6
X$28314 5732 219 320 6063 CLKBUF_X3
* cell instance $28315 m0 *1 167.96,131.6
X$28315 6793 5958 219 320 494 NOR2_X2
* cell instance $28317 r0 *1 165.68,131.6
X$28317 5623 320 4687 219 BUF_X4
* cell instance $28319 r0 *1 167.2,131.6
X$28319 6063 219 320 14720 INV_X2
* cell instance $28320 r0 *1 167.77,131.6
X$28320 6694 4173 219 320 6799 NOR2_X2
* cell instance $28322 r0 *1 168.91,131.6
X$28322 4135 320 3507 219 BUF_X4
* cell instance $28323 m0 *1 170.24,131.6
X$28323 4883 320 3273 219 BUF_X4
* cell instance $28324 m0 *1 169.29,131.6
X$28324 6537 5533 219 320 6693 NOR2_X2
* cell instance $28325 m0 *1 171.57,131.6
X$28325 219 6686 6305 6684 6178 320 AOI21_X4
* cell instance $28326 m0 *1 174.04,131.6
X$28326 6442 6539 219 320 6684 NAND2_X1
* cell instance $28327 m0 *1 174.61,131.6
X$28327 6685 320 4735 219 BUF_X4
* cell instance $28329 m0 *1 176.13,131.6
X$28329 4735 320 4459 219 BUF_X4
* cell instance $28330 m0 *1 177.46,131.6
X$28330 6540 320 3609 219 BUF_X4
* cell instance $28331 m0 *1 178.79,131.6
X$28331 6673 320 6634 219 BUF_X4
* cell instance $28333 m0 *1 180.31,131.6
X$28333 6237 2532 6671 6790 3782 320 219 6787 OAI221_X1
* cell instance $28334 m0 *1 181.45,131.6
X$28334 6541 320 6635 219 BUF_X4
* cell instance $28336 m0 *1 182.97,131.6
X$28336 6237 6637 6733 6638 3782 320 219 6639 OAI221_X1
* cell instance $28337 m0 *1 184.11,131.6
X$28337 6638 3512 6637 6187 6734 6640 219 320 OAI221_X2
* cell instance $28338 m0 *1 186.2,131.6
X$28338 6636 320 5793 219 BUF_X4
* cell instance $28340 r0 *1 170.24,131.6
X$28340 6068 320 6728 219 BUF_X4
* cell instance $28343 r0 *1 172.14,131.6
X$28343 6186 320 3277 219 BUF_X4
* cell instance $28345 r0 *1 174.23,131.6
X$28345 4458 320 3384 219 BUF_X4
* cell instance $28350 r0 *1 175.94,131.6
X$28350 6832 6636 6516 219 6793 320 AOI21_X1
* cell instance $28351 r0 *1 176.7,131.6
X$28351 6538 320 4387 219 BUF_X4
* cell instance $28352 r0 *1 178.03,131.6
X$28352 219 6789 5632 6792 6674 320 AOI21_X4
* cell instance $28353 r0 *1 180.5,131.6
X$28353 6787 6635 6516 219 6879 320 AOI21_X1
* cell instance $28354 r0 *1 181.26,131.6
X$28354 6730 1769 6732 6731 219 320 6671 AOI22_X1
* cell instance $28355 r0 *1 182.21,131.6
X$28355 2292 219 320 6637 INV_X1
* cell instance $28356 r0 *1 182.59,131.6
X$28356 6730 1134 6732 6474 219 320 6733 AOI22_X1
* cell instance $28357 r0 *1 183.54,131.6
X$28357 6335 219 320 6638 INV_X1
* cell instance $28358 r0 *1 183.92,131.6
X$28358 6639 6635 5584 219 6782 320 AOI21_X1
* cell instance $28359 r0 *1 184.68,131.6
X$28359 6835 1134 6474 6950 219 320 6734 AOI22_X2
* cell instance $28360 r0 *1 186.39,131.6
X$28360 6635 320 2807 219 BUF_X4
* cell instance $28361 r0 *1 187.72,131.6
X$28361 6782 3054 219 320 6764 NOR2_X2
* cell instance $28362 m0 *1 189.24,131.6
X$28362 6239 320 3792 219 BUF_X4
* cell instance $28363 m0 *1 187.91,131.6
X$28363 6634 320 3217 219 BUF_X4
* cell instance $28364 m0 *1 190.57,131.6
X$28364 3866 320 3282 219 BUF_X4
* cell instance $28368 r0 *1 188.67,131.6
X$28368 6636 320 2814 219 BUF_X4
* cell instance $28370 r0 *1 190.19,131.6
X$28370 5632 219 320 5979 CLKBUF_X3
* cell instance $28373 r0 *1 192.85,131.6
X$28373 3866 320 5977 219 BUF_X4
* cell instance $28379 m0 *1 13.68,190.4
X$28379 219 13280 10432 10516 10127 320 DFF_X1
* cell instance $28380 m0 *1 16.91,190.4
X$28380 219 12623 10561 10615 10127 320 DFF_X1
* cell instance $28381 m0 *1 20.14,190.4
X$28381 9640 7081 10561 219 320 10615 MUX2_X1
* cell instance $28383 m0 *1 24.51,190.4
X$28383 219 12662 10520 10434 10562 320 DFF_X1
* cell instance $28396 r0 *1 18.43,190.4
X$28396 219 14643 10666 10720 9936 320 DFF_X1
* cell instance $28397 r0 *1 21.66,190.4
X$28397 10666 6906 9640 219 320 10720 MUX2_X1
* cell instance $28399 r0 *1 26.03,190.4
X$28399 10722 6906 10433 219 320 10723 MUX2_X1
* cell instance $28400 r0 *1 27.36,190.4
X$28400 10433 7081 10726 219 320 10725 MUX2_X1
* cell instance $28402 r0 *1 28.88,190.4
X$28402 10722 8729 10726 219 320 10861 MUX2_X1
* cell instance $28404 r0 *1 33.25,190.4
X$28404 219 14245 10831 10830 9942 320 DFF_X1
* cell instance $28408 r0 *1 40.47,190.4
X$28408 219 14247 10669 10668 9859 320 DFF_X1
* cell instance $28409 m0 *1 42.75,190.4
X$28409 219 12857 10563 10621 9859 320 DFF_X1
* cell instance $28410 m0 *1 41.8,190.4
X$28410 9762 219 320 9405 CLKBUF_X3
* cell instance $28412 m0 *1 46.17,190.4
X$28412 10563 9763 10670 219 320 10624 MUX2_X1
* cell instance $28413 m0 *1 47.5,190.4
X$28413 219 12815 10438 10623 9861 320 DFF_X1
* cell instance $28414 m0 *1 50.73,190.4
X$28414 10624 9527 10439 219 320 10625 MUX2_X1
* cell instance $28416 r0 *1 43.7,190.4
X$28416 9405 219 320 9859 CLKBUF_X3
* cell instance $28417 r0 *1 44.65,190.4
X$28417 9859 219 320 14768 INV_X1
* cell instance $28418 r0 *1 45.03,190.4
X$28418 10341 7232 10670 219 320 10729 MUX2_X1
* cell instance $28419 r0 *1 46.36,190.4
X$28419 219 13722 10670 10729 9859 320 DFF_X1
* cell instance $28421 m0 *1 53.77,190.4
X$28421 219 12875 10626 10628 10671 320 DFF_X1
* cell instance $28422 m0 *1 52.44,190.4
X$28422 10341 7123 10626 219 320 10628 MUX2_X1
* cell instance $28424 m0 *1 58.52,190.4
X$28424 10185 7129 10442 219 320 10629 MUX2_X1
* cell instance $28428 m0 *1 63.84,190.4
X$28428 10443 219 320 9947 BUF_X2
* cell instance $28437 r0 *1 58.14,190.4
X$28437 219 13745 10442 10629 10671 320 DFF_X1
* cell instance $28445 r0 *1 64.22,190.4
X$28445 10775 6856 9537 219 320 10733 MUX2_X1
* cell instance $28447 r0 *1 65.93,190.4
X$28447 9537 7192 10735 219 320 10672 MUX2_X1
* cell instance $28449 r0 *1 67.45,190.4
X$28449 10776 8860 10872 219 320 10039 MUX2_X1
* cell instance $28451 r0 *1 69.16,190.4
X$28451 10736 8860 10838 219 320 10737 MUX2_X1
* cell instance $28453 r0 *1 70.87,190.4
X$28453 10673 8908 10839 219 320 10736 MUX2_X1
* cell instance $28455 r0 *1 72.58,190.4
X$28455 10673 6856 9947 219 320 10738 MUX2_X1
* cell instance $28457 r0 *1 74.67,190.4
X$28457 9947 7192 10777 219 320 10779 MUX2_X1
* cell instance $28461 r0 *1 78.47,190.4
X$28461 219 13982 10564 10739 9767 320 DFF_X1
* cell instance $28462 m0 *1 81.13,190.4
X$28462 10781 8913 10564 219 320 10632 MUX2_X1
* cell instance $28465 r0 *1 81.7,190.4
X$28465 10529 7356 10564 219 320 10739 MUX2_X1
* cell instance $28466 m0 *1 83.03,190.4
X$28466 10565 9527 10632 219 320 10566 MUX2_X1
* cell instance $28474 r0 *1 83.03,190.4
X$28474 10529 7089 10875 219 320 10876 MUX2_X1
* cell instance $28476 r0 *1 85.12,190.4
X$28476 10529 219 320 9869 BUF_X2
* cell instance $28477 r0 *1 85.88,190.4
X$28477 219 13972 10782 10842 10347 320 DFF_X1
* cell instance $28481 m0 *1 105.45,190.4
X$28481 219 13375 10635 10637 9772 320 DFF_X1
* cell instance $28486 m0 *1 110.01,190.4
X$28486 10307 10002 219 320 10637 NOR2_X1
* cell instance $28488 m0 *1 110.58,190.4
X$28488 219 13226 10567 10448 10143 320 DFF_X1
* cell instance $28492 m0 *1 116.66,190.4
X$28492 10429 10568 320 219 10640 XNOR2_X1
* cell instance $28493 m0 *1 114.95,190.4
X$28493 10674 10568 10638 10567 320 10351 219 NOR4_X2
* cell instance $28494 m0 *1 117.8,190.4
X$28494 219 10744 10568 10639 10143 320 DFF_X1
* cell instance $28495 m0 *1 121.03,190.4
X$28495 10537 219 320 10643 INV_X1
* cell instance $28496 m0 *1 121.41,190.4
X$28496 10238 10643 10642 320 10569 219 OAI21_X1
* cell instance $28498 m0 *1 122.36,190.4
X$28498 9147 219 320 10043 CLKBUF_X3
* cell instance $28499 m0 *1 123.31,190.4
X$28499 219 10426 10453 10570 10050 320 DFF_X1
* cell instance $28500 m0 *1 126.54,190.4
X$28500 219 10240 10454 10645 10050 320 DFF_X1
* cell instance $28504 r0 *1 114.95,190.4
X$28504 219 10675 10674 10450 10143 320 DFF_X1
* cell instance $28505 r0 *1 118.18,190.4
X$28505 10744 10675 10743 320 219 10536 HA_X1
* cell instance $28509 r0 *1 120.08,190.4
X$28509 10537 7820 219 320 10639 NOR2_X1
* cell instance $28516 r0 *1 125.59,190.4
X$28516 10453 10678 10677 219 320 10644 MUX2_X1
* cell instance $28517 r0 *1 126.92,190.4
X$28517 10454 10678 10240 219 320 10455 MUX2_X1
* cell instance $28519 m0 *1 132.62,190.4
X$28519 10571 9154 10572 219 320 10648 MUX2_X1
* cell instance $28521 m0 *1 133.95,190.4
X$28521 219 13069 10572 10648 10112 320 DFF_X1
* cell instance $28522 m0 *1 137.18,190.4
X$28522 10571 9157 10573 219 320 10650 MUX2_X1
* cell instance $28523 m0 *1 138.51,190.4
X$28523 10572 10051 10573 219 320 10653 MUX2_X1
* cell instance $28524 m0 *1 139.84,190.4
X$28524 9425 219 320 10112 CLKBUF_X3
* cell instance $28525 m0 *1 140.79,190.4
X$28525 10112 219 320 CLKBUF_X1
* cell instance $28529 r0 *1 138.13,190.4
X$28529 219 14350 10573 10650 10112 320 DFF_X1
* cell instance $28531 m0 *1 142.69,190.4
X$28531 10459 10545 6341 320 219 10654 MUX2_X2
* cell instance $28532 m0 *1 141.74,190.4
X$28532 10653 10749 219 320 9925 NOR2_X2
* cell instance $28535 m0 *1 146.68,190.4
X$28535 10460 10463 6341 320 219 10574 MUX2_X2
* cell instance $28536 m0 *1 148.39,190.4
X$28536 10656 10465 9522 320 10655 219 OAI21_X1
* cell instance $28537 m0 *1 149.15,190.4
X$28537 10043 9474 219 320 10656 NOR2_X1
* cell instance $28538 m0 *1 149.72,190.4
X$28538 10043 10576 219 320 10681 OR2_X1
* cell instance $28542 m0 *1 155.23,190.4
X$28542 219 8939 10578 10577 10115 320 DFF_X1
* cell instance $28546 r0 *1 142.31,190.4
X$28546 219 10749 320 4921 BUF_X8
* cell instance $28547 r0 *1 144.78,190.4
X$28547 219 4921 320 10786 BUF_X8
* cell instance $28548 r0 *1 147.25,190.4
X$28548 10655 10575 6341 320 219 10679 MUX2_X2
* cell instance $28549 r0 *1 148.96,190.4
X$28549 10466 10043 219 320 10751 NOR2_X1
* cell instance $28550 r0 *1 149.53,190.4
X$28550 10576 10043 219 320 10680 NOR2_X1
* cell instance $28551 r0 *1 150.1,190.4
X$28551 10680 6341 10751 219 320 10752 MUX2_X1
* cell instance $28555 r0 *1 155.04,190.4
X$28555 9474 9522 219 9560 320 NAND2_X4
* cell instance $28556 r0 *1 156.75,190.4
X$28556 10790 10682 10754 320 10577 219 OAI21_X1
* cell instance $28557 r0 *1 157.51,190.4
X$28557 9318 219 320 10684 INV_X1
* cell instance $28559 r0 *1 158.08,190.4
X$28559 10578 320 10757 219 BUF_X4
* cell instance $28561 m0 *1 159.79,190.4
X$28561 219 10758 10115 9028 10685 320 DFF_X2
* cell instance $28564 m0 *1 169.48,190.4
X$28564 10413 10470 9672 219 320 10796 NOR3_X1
* cell instance $28565 m0 *1 170.24,190.4
X$28565 10579 219 320 10580 INV_X1
* cell instance $28566 m0 *1 170.62,190.4
X$28566 10692 10473 10558 219 10323 320 AOI21_X1
* cell instance $28567 m0 *1 171.38,190.4
X$28567 10217 10477 10322 9561 219 320 10691 NAND4_X1
* cell instance $28568 m0 *1 172.33,190.4
X$28568 10151 10123 10579 320 10581 219 OAI21_X1
* cell instance $28569 m0 *1 173.09,190.4
X$28569 10478 10220 10665 320 10663 219 OAI21_X1
* cell instance $28571 m0 *1 174.04,190.4
X$28571 10664 10473 10659 219 320 10660 OR3_X1
* cell instance $28572 m0 *1 174.99,190.4
X$28572 10324 10660 10662 320 10661 219 OAI21_X1
* cell instance $28573 m0 *1 175.75,190.4
X$28573 10474 10663 10582 219 10659 320 AOI21_X1
* cell instance $28575 r0 *1 160.17,190.4
X$28575 10762 10794 6949 219 10683 320 AOI21_X1
* cell instance $28578 r0 *1 162.83,190.4
X$28578 10685 219 320 10762 CLKBUF_X3
* cell instance $28581 r0 *1 166.06,190.4
X$28581 10763 320 4725 219 BUF_X4
* cell instance $28582 r0 *1 167.39,190.4
X$28582 10689 10579 10686 219 320 10765 OR3_X1
* cell instance $28583 r0 *1 168.34,190.4
X$28583 10686 10579 10689 219 320 10687 NAND3_X1
* cell instance $28584 r0 *1 169.1,190.4
X$28584 10687 10766 10765 3222 219 320 10688 NAND4_X1
* cell instance $28586 r0 *1 170.24,190.4
X$28586 10580 10686 10690 219 10767 320 AOI21_X1
* cell instance $28587 r0 *1 171,190.4
X$28587 10689 219 320 10799 INV_X1
* cell instance $28589 r0 *1 171.76,190.4
X$28589 9561 10220 10581 320 10853 219 OAI21_X1
* cell instance $28590 r0 *1 172.52,190.4
X$28590 10474 10582 219 320 10768 OR2_X1
* cell instance $28591 r0 *1 173.28,190.4
X$28591 10477 10123 9672 219 320 10899 NAND3_X1
* cell instance $28593 r0 *1 174.23,190.4
X$28593 10693 10694 219 320 10583 NOR2_X1
* cell instance $28594 r0 *1 174.8,190.4
X$28594 10316 10220 10694 219 320 10584 NOR3_X1
* cell instance $28599 r0 *1 175.75,190.4
X$28599 10152 10584 10642 320 10764 219 OAI21_X1
* cell instance $28602 m0 *1 176.89,190.4
X$28602 9562 9381 219 320 10585 NOR2_X2
* cell instance $28603 m0 *1 178.03,190.4
X$28603 9562 9381 7251 10586 219 320 10695 NOR4_X1
* cell instance $28604 m0 *1 178.98,190.4
X$28604 10591 219 320 10586 INV_X1
* cell instance $28606 m0 *1 180.12,190.4
X$28606 10481 10587 10586 320 10657 219 OAI21_X1
* cell instance $28609 r0 *1 177.46,190.4
X$28609 10585 10015 10700 219 320 10759 NAND3_X1
* cell instance $28611 r0 *1 178.41,190.4
X$28611 10696 219 320 10761 INV_X1
* cell instance $28612 r0 *1 178.79,190.4
X$28612 10664 10761 10759 219 10753 320 AOI21_X1
* cell instance $28613 r0 *1 179.55,190.4
X$28613 10696 10695 10596 320 10755 219 OAI21_X1
* cell instance $28616 m0 *1 181.45,190.4
X$28616 10590 10596 219 320 10589 OR2_X1
* cell instance $28619 m0 *1 182.4,190.4
X$28619 10590 10472 7151 219 320 10699 NAND3_X1
* cell instance $28621 m0 *1 184.68,190.4
X$28621 10488 219 320 10591 CLKBUF_X3
* cell instance $28622 m0 *1 185.63,190.4
X$28622 10590 10592 10593 320 10486 219 OAI21_X1
* cell instance $28623 m0 *1 186.39,190.4
X$28623 10590 10472 10591 219 320 10593 NAND3_X1
* cell instance $28624 m0 *1 187.15,190.4
X$28624 219 10594 10651 10748 10483 320 DFF_X1
* cell instance $28625 m0 *1 190.38,190.4
X$28625 10649 10647 6582 320 219 10477 MUX2_X2
* cell instance $28626 m0 *1 192.09,190.4
X$28626 9674 9183 8991 320 10985 219 NOR3_X2
* cell instance $28627 m0 *1 193.42,190.4
X$28627 10489 9183 9336 8292 219 320 10647 NAND4_X1
* cell instance $28628 m0 *1 194.37,190.4
X$28628 8292 6582 320 219 10745 AND2_X1
* cell instance $28629 m0 *1 195.13,190.4
X$28629 9674 10595 10707 320 10489 219 NOR3_X2
* cell instance $28630 m0 *1 196.46,190.4
X$28630 10489 219 320 10646 INV_X1
* cell instance $28631 m0 *1 196.84,190.4
X$28631 9336 8292 219 10813 320 NAND2_X4
* cell instance $28632 m0 *1 198.55,190.4
X$28632 10595 219 320 8991 INV_X2
* cell instance $28634 r0 *1 181.45,190.4
X$28634 10753 10657 10697 219 10698 320 AOI21_X1
* cell instance $28635 r0 *1 182.21,190.4
X$28635 10589 10698 10699 320 10810 219 OAI21_X1
* cell instance $28639 r0 *1 184.3,190.4
X$28639 10015 10664 219 320 10750 NOR2_X1
* cell instance $28640 r0 *1 184.87,190.4
X$28640 10700 10701 10750 320 10592 219 OAI21_X1
* cell instance $28641 r0 *1 185.63,190.4
X$28641 219 10651 10488 10700 10153 7105 320 NOR4_X4
* cell instance $28643 r0 *1 189.24,190.4
X$28643 6582 7701 10812 320 219 10935 OAI21_X4
* cell instance $28645 r0 *1 191.9,190.4
X$28645 10704 6582 10702 219 10703 320 AOI21_X2
* cell instance $28646 r0 *1 193.23,190.4
X$28646 219 10746 10704 10745 10706 320 AOI21_X4
* cell instance $28647 r0 *1 195.7,190.4
X$28647 9231 6498 9388 219 320 10708 MUX2_X1
* cell instance $28648 r0 *1 197.03,190.4
X$28648 10905 10376 8991 219 320 10705 NAND3_X2
* cell instance $28653 m0 *1 11.4,137.2
X$28653 6897 7171 6900 219 320 6898 MUX2_X1
* cell instance $28654 m0 *1 12.73,137.2
X$28654 219 13631 6901 7077 6899 320 DFF_X1
* cell instance $28664 r0 *1 14.63,137.2
X$28664 6897 7121 6901 219 320 7077 MUX2_X1
* cell instance $28670 m0 *1 12.92,193.2
X$28670 10769 7014 9640 219 320 10826 MUX2_X1
* cell instance $28671 m0 *1 14.25,193.2
X$28671 219 13277 10769 10826 10127 320 DFF_X1
* cell instance $28676 r0 *1 6.46,193.2
X$28676 219 14308 10952 10993 10857 320 DFF_X1
* cell instance $28681 r0 *1 11.21,193.2
X$28681 219 13706 10858 10915 10857 320 DFF_X1
* cell instance $28682 r0 *1 14.44,193.2
X$28682 10769 9101 10858 219 320 10859 MUX2_X1
* cell instance $28683 r0 *1 15.77,193.2
X$28683 10859 9207 10997 219 320 10281 MUX2_X1
* cell instance $28684 r0 *1 17.1,193.2
X$28684 219 14519 10770 10827 10857 320 DFF_X1
* cell instance $28685 m0 *1 18.05,193.2
X$28685 9640 6853 10770 219 320 10827 MUX2_X1
* cell instance $28689 r0 *1 20.33,193.2
X$28689 10917 8860 10918 219 320 10919 MUX2_X1
* cell instance $28690 m0 *1 20.71,193.2
X$28690 10666 8729 10561 219 320 10917 MUX2_X1
* cell instance $28693 m0 *1 23.56,193.2
X$28693 219 12578 10722 10723 10562 320 DFF_X1
* cell instance $28694 m0 *1 26.79,193.2
X$28694 219 12573 10726 10725 10562 320 DFF_X1
* cell instance $28698 r0 *1 23.37,193.2
X$28698 10919 8927 10999 219 320 10284 MUX2_X1
* cell instance $28702 r0 *1 27.36,193.2
X$28702 10433 6853 10920 219 320 10860 MUX2_X1
* cell instance $28704 r0 *1 29.07,193.2
X$28704 10955 9287 10920 219 320 10863 MUX2_X1
* cell instance $28705 r0 *1 30.4,193.2
X$28705 10861 8860 10863 219 320 10829 MUX2_X1
* cell instance $28707 m0 *1 30.4,193.2
X$28707 10829 8927 10862 219 320 10226 MUX2_X1
* cell instance $28708 m0 *1 32.49,193.2
X$28708 10032 7081 10771 219 320 10864 MUX2_X1
* cell instance $28710 m0 *1 34.58,193.2
X$28710 10831 6906 10032 219 320 10830 MUX2_X1
* cell instance $28713 r0 *1 32.49,193.2
X$28713 219 13734 10771 10864 10562 320 DFF_X1
* cell instance $28714 r0 *1 35.72,193.2
X$28714 10032 6853 10921 219 320 10865 MUX2_X1
* cell instance $28715 m0 *1 36.48,193.2
X$28715 10831 8729 10771 219 320 10922 MUX2_X1
* cell instance $28720 r0 *1 37.43,193.2
X$28720 10922 8860 10924 219 320 10866 MUX2_X1
* cell instance $28721 r0 *1 38.76,193.2
X$28721 10866 8927 10923 219 320 10340 MUX2_X1
* cell instance $28724 m0 *1 41.23,193.2
X$28724 10669 6906 9531 219 320 10668 MUX2_X1
* cell instance $28725 m0 *1 42.75,193.2
X$28725 9531 7081 10833 219 320 10832 MUX2_X1
* cell instance $28727 m0 *1 44.27,193.2
X$28727 10669 8729 10833 219 320 10772 MUX2_X1
* cell instance $28731 r0 *1 41.99,193.2
X$28731 219 13725 10833 10832 9859 320 DFF_X1
* cell instance $28733 r0 *1 45.6,193.2
X$28733 10772 8860 11002 219 320 10926 MUX2_X1
* cell instance $28735 m0 *1 47.69,193.2
X$28735 10341 7348 10835 219 320 10836 MUX2_X1
* cell instance $28737 m0 *1 49.02,193.2
X$28737 219 12874 10835 10836 9861 320 DFF_X1
* cell instance $28739 r0 *1 49.97,193.2
X$28739 10926 8927 10867 219 320 10034 MUX2_X1
* cell instance $28741 r0 *1 52.06,193.2
X$28741 10341 7171 10868 219 320 10773 MUX2_X1
* cell instance $28743 m0 *1 52.63,193.2
X$28743 219 12799 10868 10773 10671 320 DFF_X1
* cell instance $28746 r0 *1 53.39,193.2
X$28746 10341 7121 10927 219 320 10956 MUX2_X1
* cell instance $28748 r0 *1 54.91,193.2
X$28748 10868 5005 10927 219 320 10869 MUX2_X1
* cell instance $28751 r0 *1 57.38,193.2
X$28751 9405 219 320 10671 CLKBUF_X3
* cell instance $28752 r0 *1 58.33,193.2
X$28752 10443 7129 10957 219 320 10870 MUX2_X1
* cell instance $28753 m0 *1 58.71,193.2
X$28753 219 12817 10871 10774 10671 320 DFF_X1
* cell instance $28755 m0 *1 61.94,193.2
X$28755 219 13446 10775 10733 10135 320 DFF_X1
* cell instance $28759 r0 *1 60.23,193.2
X$28759 10443 7243 10871 219 320 10774 MUX2_X1
* cell instance $28760 r0 *1 61.56,193.2
X$28760 10871 8788 10957 219 320 10346 MUX2_X1
* cell instance $28765 r0 *1 63.08,193.2
X$28765 10185 7089 10928 219 320 11005 MUX2_X1
* cell instance $28767 m0 *1 68.78,193.2
X$28767 10777 8795 10778 219 320 10838 MUX2_X1
* cell instance $28768 m0 *1 65.55,193.2
X$28768 219 13467 10735 10672 10780 320 DFF_X1
* cell instance $28769 m0 *1 70.11,193.2
X$28769 10443 7089 10839 219 320 10873 MUX2_X1
* cell instance $28770 m0 *1 71.44,193.2
X$28770 219 13204 10673 10738 10780 320 DFF_X1
* cell instance $28771 m0 *1 74.67,193.2
X$28771 219 13169 10777 10779 10780 320 DFF_X1
* cell instance $28775 r0 *1 66.12,193.2
X$28775 10775 8908 10928 219 320 10776 MUX2_X1
* cell instance $28776 r0 *1 67.45,193.2
X$28776 10735 8795 11007 219 320 10872 MUX2_X1
* cell instance $28779 r0 *1 69.35,193.2
X$28779 10443 7356 10778 219 320 11008 MUX2_X1
* cell instance $28780 r0 *1 70.68,193.2
X$28780 219 13777 10839 10873 10780 320 DFF_X1
* cell instance $28783 r0 *1 77.71,193.2
X$28783 219 14100 10781 10930 10780 320 DFF_X1
* cell instance $28784 m0 *1 79.99,193.2
X$28784 9869 7192 10781 219 320 10930 MUX2_X1
* cell instance $28786 m0 *1 81.32,193.2
X$28786 219 13351 10874 10931 10347 320 DFF_X1
* cell instance $28788 r0 *1 80.94,193.2
X$28788 10874 6856 9869 219 320 10931 MUX2_X1
* cell instance $28789 r0 *1 82.27,193.2
X$28789 10874 9763 10875 219 320 10565 MUX2_X1
* cell instance $28790 r0 *1 83.6,193.2
X$28790 219 14062 10875 10876 10347 320 DFF_X1
* cell instance $28791 m0 *1 85.12,193.2
X$28791 10529 7243 10782 219 320 10842 MUX2_X1
* cell instance $28793 m0 *1 86.45,193.2
X$28793 10529 7129 10783 219 320 10932 MUX2_X1
* cell instance $28795 r0 *1 86.83,193.2
X$28795 219 14094 10783 10932 10347 320 DFF_X1
* cell instance $28796 m0 *1 88.35,193.2
X$28796 10782 5005 10783 219 320 10530 MUX2_X1
* cell instance $28798 m0 *1 89.68,193.2
X$28798 8926 219 320 10347 CLKBUF_X3
* cell instance $28799 m0 *1 90.63,193.2
X$28799 10347 219 320 CLKBUF_X1
* cell instance $28808 m0 *1 104.5,193.2
X$28808 11196 219 320 10429 CLKBUF_X3
* cell instance $28816 r0 *1 109.63,193.2
X$28816 10877 10879 219 320 10878 NAND2_X1
* cell instance $28819 r0 *1 113.62,193.2
X$28819 219 13780 10880 10936 10143 320 DFF_X1
* cell instance $28820 r0 *1 116.85,193.2
X$28820 10937 7820 219 320 10936 NOR2_X1
* cell instance $28822 m0 *1 117.23,193.2
X$28822 10674 10429 219 320 10784 NOR2_X1
* cell instance $28825 m0 *1 124.83,193.2
X$28825 219 13034 10785 10844 10050 320 DFF_X1
* cell instance $28829 m0 *1 132.81,193.2
X$28829 10845 10749 10881 219 320 10325 MUX2_X1
* cell instance $28838 r0 *1 125.21,193.2
X$28838 10964 9154 10785 219 320 10844 MUX2_X1
* cell instance $28840 r0 *1 127.3,193.2
X$28840 10785 10051 11022 219 320 10845 MUX2_X1
* cell instance $28843 r0 *1 129.77,193.2
X$28843 10964 8821 10966 219 320 11023 MUX2_X1
* cell instance $28845 r0 *1 131.86,193.2
X$28845 10966 10940 11058 219 320 10881 MUX2_X1
* cell instance $28849 r0 *1 135.66,193.2
X$28849 219 14377 10882 11026 10967 320 DFF_X1
* cell instance $28850 r0 *1 138.89,193.2
X$28850 10883 10940 10882 219 320 9871 MUX2_X1
.ENDS dynamic_node_top_wrap

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell AND4_X4
* pin PWELL,VSS
* pin A4
* pin A3
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT AND4_X4 1 2 3 4 6 7 14
* net 1 PWELL,VSS
* net 2 A4
* net 3 A3
* net 4 A2
* net 6 A1
* net 7 ZN
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 14 3 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 5 4 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 14 6 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 7 5 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.375,0.2975 NMOS_VTL
M$14 9 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.565,0.2975 NMOS_VTL
M$15 10 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.755,0.2975 NMOS_VTL
M$16 5 6 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 12 6 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 11 4 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 13 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 2 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 7 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND4_X4

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell OR2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT OR2_X4 1 2 3 5 6
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 4 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 4 3 3 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR2_X4

* cell AND2_X4
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT AND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 3 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 8 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.55,0.2975 NMOS_VTL
M$11 7 2 3 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.74,0.2975 NMOS_VTL
M$12 6 1 7 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 3 6 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND2_X4

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell AOI222_X2
* pin PWELL,VSS
* pin C2
* pin C1
* pin ZN
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT AOI222_X2 1 2 3 4 5 6 8 9 16
* net 1 PWELL,VSS
* net 2 C2
* net 3 C1
* net 4 ZN
* net 5 B2
* net 6 B1
* net 8 A1
* net 9 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 17 5 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 15 6 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 4 8 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $11 r0 *1 2.255,0.995 PMOS_VTL
M$11 4 9 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 10 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 4 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.31,0.2975 NMOS_VTL
M$19 14 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.5,0.2975 NMOS_VTL
M$20 1 5 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 4 8 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $22 r0 *1 2.065,0.2975 NMOS_VTL
M$22 11 8 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.255,0.2975 NMOS_VTL
M$23 1 9 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.445,0.2975 NMOS_VTL
M$24 7 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI222_X2

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell BUF_X16
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X16 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.3528P PS=6.86U PD=6.16U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 4 3 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.7056P AD=0.72765P PS=12.32U PD=13.02U
* device instance $25 r0 *1 0.185,0.2975 NMOS_VTL
M$25 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.2324P PS=4.925U PD=4.44U
* device instance $33 r0 *1 1.705,0.2975 NMOS_VTL
M$33 4 3 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4648P AD=0.479325P PS=8.88U PD=9.365U
.ENDS BUF_X16

* cell BUF_X32
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X32 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.729225P AD=0.707175P PS=13.025U
+ PD=12.325U
* device instance $17 r0 *1 3.215,0.995 PMOS_VTL
M$17 4 3 5 5 PMOS_VTL L=0.05U W=20.16U AS=1.4175P AD=1.43955P PS=24.66U
+ PD=25.36U
* device instance $49 r0 *1 0.17,0.2975 NMOS_VTL
M$49 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4803625P AD=0.4658375P PS=9.37U
+ PD=8.885U
* device instance $65 r0 *1 3.215,0.2975 NMOS_VTL
M$65 4 3 1 1 NMOS_VTL L=0.05U W=13.28U AS=0.93375P AD=0.948275P PS=17.78U
+ PD=18.265U
.ENDS BUF_X32

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell FA_X1
* pin PWELL,VSS
* pin B
* pin CO
* pin S
* pin CI
* pin A
* pin NWELL,VDD
.SUBCKT FA_X1 1 2 3 8 11 12 14
* net 1 PWELL,VSS
* net 2 B
* net 3 CO
* net 8 S
* net 11 CI
* net 12 A
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.385,1.0275 PMOS_VTL
M$1 17 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $2 r0 *1 0.575,1.0275 PMOS_VTL
M$2 4 12 17 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.765,1.0275 PMOS_VTL
M$3 15 11 4 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02265P PS=0.455U
+ PD=0.535U
* device instance $4 r0 *1 0.96,1.1025 PMOS_VTL
M$4 14 12 15 14 PMOS_VTL L=0.05U W=0.315U AS=0.02265P AD=0.02205P PS=0.535U
+ PD=0.455U
* device instance $5 r0 *1 1.15,1.1025 PMOS_VTL
M$5 15 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $6 r0 *1 0.195,0.995 PMOS_VTL
M$6 14 4 3 14 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.033075P PS=1.47U
+ PD=0.77U
* device instance $7 r0 *1 1.49,1.1525 PMOS_VTL
M$7 16 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $8 r0 *1 1.68,1.1525 PMOS_VTL
M$8 14 11 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 1.87,1.1525 PMOS_VTL
M$9 16 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $10 r0 *1 2.06,1.1525 PMOS_VTL
M$10 7 4 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.023625P PS=0.455U
+ PD=0.465U
* device instance $11 r0 *1 2.26,1.1525 PMOS_VTL
M$11 18 11 7 14 PMOS_VTL L=0.05U W=0.315U AS=0.023625P AD=0.02205P PS=0.465U
+ PD=0.455U
* device instance $12 r0 *1 2.45,1.1525 PMOS_VTL
M$12 19 2 18 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $13 r0 *1 2.64,1.1525 PMOS_VTL
M$13 19 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $14 r0 *1 2.83,0.995 PMOS_VTL
M$14 8 7 14 14 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $15 r0 *1 0.385,0.32 NMOS_VTL
M$15 13 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.0147P PS=0.555U
+ PD=0.35U
* device instance $16 r0 *1 0.575,0.32 NMOS_VTL
M$16 4 12 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $17 r0 *1 0.765,0.32 NMOS_VTL
M$17 5 11 4 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.015225P PS=0.35U
+ PD=0.355U
* device instance $18 r0 *1 0.96,0.32 NMOS_VTL
M$18 1 12 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.015225P AD=0.0147P PS=0.355U
+ PD=0.35U
* device instance $19 r0 *1 1.15,0.32 NMOS_VTL
M$19 5 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $20 r0 *1 0.195,0.2975 NMOS_VTL
M$20 1 4 3 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.021875P PS=1.04U
+ PD=0.555U
* device instance $21 r0 *1 1.49,0.195 NMOS_VTL
M$21 6 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $22 r0 *1 1.68,0.195 NMOS_VTL
M$22 1 11 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $23 r0 *1 1.87,0.195 NMOS_VTL
M$23 6 12 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $24 r0 *1 2.06,0.195 NMOS_VTL
M$24 7 4 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.01575P PS=0.35U PD=0.36U
* device instance $25 r0 *1 2.26,0.195 NMOS_VTL
M$25 9 11 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.01575P AD=0.0147P PS=0.36U PD=0.35U
* device instance $26 r0 *1 2.45,0.195 NMOS_VTL
M$26 10 2 9 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 2.64,0.195 NMOS_VTL
M$27 1 12 10 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $28 r0 *1 2.83,0.2975 NMOS_VTL
M$28 8 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS FA_X1

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell OAI222_X2
* pin PWELL,VSS
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT OAI222_X2 1 4 5 6 7 8 9 10 11
* net 1 PWELL,VSS
* net 4 C1
* net 5 C2
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 ZN
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 12 4 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.405,0.995 PMOS_VTL
M$2 11 5 12 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.595,0.995 PMOS_VTL
M$3 13 5 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.785,0.995 PMOS_VTL
M$4 10 4 13 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 14 6 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.165,0.995 PMOS_VTL
M$6 11 7 14 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.355,0.995 PMOS_VTL
M$7 15 7 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.545,0.995 PMOS_VTL
M$8 10 6 15 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0945P PS=0.77U PD=0.93U
* device instance $9 r0 *1 1.895,0.995 PMOS_VTL
M$9 16 8 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0945P AD=0.0441P PS=0.93U PD=0.77U
* device instance $10 r0 *1 2.085,0.995 PMOS_VTL
M$10 11 9 16 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.275,0.995 PMOS_VTL
M$11 17 9 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.465,0.995 PMOS_VTL
M$12 10 8 17 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0693P PS=0.77U PD=1.48U
* device instance $13 r0 *1 1.895,0.2975 NMOS_VTL
M$13 10 8 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $14 r0 *1 2.085,0.2975 NMOS_VTL
M$14 3 9 10 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 0.215,0.2975 NMOS_VTL
M$17 1 4 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $18 r0 *1 0.405,0.2975 NMOS_VTL
M$18 2 5 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 0.975,0.2975 NMOS_VTL
M$21 3 6 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $22 r0 *1 1.165,0.2975 NMOS_VTL
M$22 2 7 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI222_X2

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell OAI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X2 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 12 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 4 12 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 11 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 6 3 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 7 1 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 5 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 8 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.12,0.2975 NMOS_VTL
M$14 5 4 8 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI22_X2

* cell OAI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin A2
* pin ZN
* pin A1
* pin NWELL,VDD
.SUBCKT OAI22_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 4 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 8 3 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 3 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 14 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 8 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 15 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 15 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 8 5 16 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 1 3 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 2 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI22_X4

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell MUX2_X2
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin Z
.SUBCKT MUX2_X2 1 2 3 6 7 8
* net 1 A
* net 2 B
* net 3 S
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 Z
* device instance $1 r0 *1 1.16,0.995 PMOS_VTL
M$1 8 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.077175P PS=2.24U PD=1.54U
* device instance $3 r0 *1 1.54,1.1525 PMOS_VTL
M$3 9 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $4 r0 *1 0.215,0.995 PMOS_VTL
M$4 6 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $5 r0 *1 0.405,0.995 PMOS_VTL
M$5 5 9 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 0.595,0.995 PMOS_VTL
M$6 4 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.045675P PS=0.77U PD=0.775U
* device instance $7 r0 *1 0.79,0.995 PMOS_VTL
M$7 5 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.045675P AD=0.0693P PS=0.775U PD=1.48U
* device instance $8 r0 *1 1.54,0.195 NMOS_VTL
M$8 9 3 7 7 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.02205P PS=0.555U PD=0.63U
* device instance $9 r0 *1 1.16,0.2975 NMOS_VTL
M$9 8 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.050925P PS=1.595U
+ PD=1.11U
* device instance $11 r0 *1 0.215,0.2975 NMOS_VTL
M$11 11 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.405,0.2975 NMOS_VTL
M$12 7 9 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.595,0.2975 NMOS_VTL
M$13 10 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $14 r0 *1 0.79,0.2975 NMOS_VTL
M$14 4 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.043575P PS=0.56U
+ PD=1.04U
.ENDS MUX2_X2

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8
