* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_uart_tx clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] rst_n
+ tx tx_busy tx_start
X_095_ clk_counter\[1\] _090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_096_ bit_index\[0\] _054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_097_ state\[2\] state\[0\] _055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_098_ state\[2\] _056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_099_ _056_ state\[0\] _088_ bit_index\[0\] _057_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
X_100_ clk_counter\[3\] clk_counter\[2\] clk_counter\[1\]
+ _091_ _058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_101_ clk_counter\[5\] clk_counter\[4\] _058_ _059_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_102_ _059_ _060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_103_ _054_ _057_ _060_ _061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_104_ state\[1\] _062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_105_ _054_ _055_ _061_ _062_ _000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_106_ bit_index\[1\] _063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_107_ _087_ _055_ _064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_108_ _063_ _064_ _059_ _065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_109_ _063_ _055_ _065_ _062_ _001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_110_ bit_index\[2\] _066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_111_ _089_ _055_ _067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_112_ _066_ _067_ _059_ _068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_113_ _066_ _055_ _068_ _062_ _002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_114_ state\[1\] state\[0\] _069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_115_ clk_counter\[0\] _069_ _070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_116_ clk_counter\[0\] _069_ _071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_117_ _060_ _070_ _071_ _072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_118_ state\[1\] state\[0\] _073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_119_ clk_counter\[0\] _060_ _073_ _074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_120_ state\[2\] _075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_121_ _072_ _074_ _075_ _003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_122_ _092_ _060_ _073_ _076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_123_ clk_counter\[1\] _069_ _077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_124_ _092_ _060_ _069_ _077_ _078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_125_ _076_ _078_ _056_ _004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_126_ clk_counter\[2\] _079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_127_ state\[1\] state\[0\] _056_ _080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_128_ _056_ _079_ _069_ _081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_129_ _075_ _073_ _082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_130_ clk_counter\[2\] _093_ _083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_131_ _060_ _081_ _082_ _083_ _084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_132_ _079_ _080_ _084_ _005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_133_ clk_counter\[3\] _085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_134_ _056_ _085_ _069_ _022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_135_ clk_counter\[2\] clk_counter\[1\] clk_counter\[0\]
+ _023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_136_ clk_counter\[3\] _023_ _024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_137_ clk_counter\[3\] clk_counter\[2\] clk_counter\[1\]
+ clk_counter\[0\] _025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_138_ _082_ _022_ _024_ _025_ _026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_139_ _085_ _080_ _026_ _060_ _006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_140_ clk_counter\[3\] clk_counter\[2\] _093_ _027_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_141_ clk_counter\[4\] _027_ _028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_142_ clk_counter\[4\] _027_ _029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_143_ _080_ _028_ _029_ _030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_144_ clk_counter\[4\] _031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_145_ _060_ _082_ _030_ _080_ _031_ _007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_146_ clk_counter\[5\] clk_counter\[4\] _058_ _032_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_147_ _032_ _069_ _033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_148_ clk_counter\[4\] _080_ _025_ _034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_149_ _032_ _069_ _034_ clk_counter\[5\] _035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_150_ _075_ _033_ _035_ _008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_151_ _075_ net11 _073_ _036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_152_ data_reg\[0\] net2 _036_ _009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_153_ data_reg\[1\] net3 _036_ _010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_154_ data_reg\[2\] net4 _036_ _011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_155_ data_reg\[3\] net5 _036_ _012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_156_ data_reg\[4\] net6 _036_ _013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_157_ data_reg\[5\] net7 _036_ _014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_158_ data_reg\[6\] net8 _036_ _015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_159_ data_reg\[7\] net9 _036_ _016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_160_ state\[0\] _032_ _073_ net11 _037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_161_ _056_ _037_ _017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_162_ state\[0\] _088_ _038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_163_ clk_counter\[5\] clk_counter\[4\] _058_ _038_ _039_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_164_ _062_ state\[0\] _040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_165_ state\[1\] _039_ _040_ _060_ _041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_166_ _056_ _041_ _018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_167_ _056_ _062_ _039_ _042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_168_ _075_ _060_ _069_ _042_ _019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_169_ data_reg\[2\] data_reg\[3\] data_reg\[6\] data_reg\[7\]
+ bit_index\[0\] bit_index\[2\] _043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_170_ _063_ _043_ _044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_171_ data_reg\[4\] data_reg\[5\] bit_index\[0\] _045_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_172_ bit_index\[1\] _066_ _045_ _046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_173_ data_reg\[0\] data_reg\[1\] bit_index\[0\] _047_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_174_ bit_index\[1\] bit_index\[2\] _047_ _048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_175_ _055_ _044_ _046_ _048_ _049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_176_ _056_ net12 _050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_177_ _073_ _049_ _050_ _020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_178_ net11 net13 _069_ _051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_179_ _075_ _051_ _052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_180_ _056_ net13 _032_ _073_ _053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_181_ _052_ _053_ _021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_182_ bit_index\[0\] bit_index\[1\] _086_ _087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_183_ bit_index\[2\] _086_ _088_ _089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_184_ clk_counter\[0\] _090_ _091_ _092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_185_ clk_counter\[0\] clk_counter\[1\] _093_ _094_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__addh_1
Xbit_index\[0\]$_DFFE_PN0P_ _000_ net1 clknet_1_0__leaf_clk
+ bit_index\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_index\[1\]$_DFFE_PN0P_ _001_ net1 clknet_1_0__leaf_clk
+ bit_index\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xbit_index\[2\]$_DFFE_PN0P_ _002_ net1 clknet_1_1__leaf_clk
+ bit_index\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[0\]$_DFFE_PN0P_ _003_ net1 clknet_1_0__leaf_clk
+ clk_counter\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[1\]$_DFFE_PN0P_ _004_ net1 clknet_1_0__leaf_clk
+ clk_counter\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[2\]$_DFFE_PN0P_ _005_ net1 clknet_1_1__leaf_clk
+ clk_counter\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[3\]$_DFFE_PN0P_ _006_ net1 clknet_1_1__leaf_clk
+ clk_counter\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[4\]$_DFFE_PN0P_ _007_ net1 clknet_1_1__leaf_clk
+ clk_counter\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xclk_counter\[5\]$_DFFE_PN0P_ _008_ net1 clknet_1_1__leaf_clk
+ clk_counter\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[0\]$_DFFE_PN0P_ _009_ net1 clknet_1_0__leaf_clk
+ data_reg\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[1\]$_DFFE_PN0P_ _010_ net1 clknet_1_0__leaf_clk
+ data_reg\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[2\]$_DFFE_PN0P_ _011_ net1 clknet_1_1__leaf_clk
+ data_reg\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[3\]$_DFFE_PN0P_ _012_ net1 clknet_1_1__leaf_clk
+ data_reg\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[4\]$_DFFE_PN0P_ _013_ net1 clknet_1_0__leaf_clk
+ data_reg\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[5\]$_DFFE_PN0P_ _014_ net1 clknet_1_0__leaf_clk
+ data_reg\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[6\]$_DFFE_PN0P_ _015_ net1 clknet_1_0__leaf_clk
+ data_reg\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xdata_reg\[7\]$_DFFE_PN0P_ _016_ net1 clknet_1_1__leaf_clk
+ data_reg\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[0\]$_DFFE_PN0P_ _017_ net1 clknet_1_0__leaf_clk state\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xstate\[1\]$_DFFE_PN0P_ _018_ net1 clknet_1_0__leaf_clk state\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xstate\[2\]$_DFFE_PN0P_ _019_ net1 clknet_1_0__leaf_clk state\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xtx$_DFFE_PN1P_ _020_ net10 clknet_1_1__leaf_clk net12 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xtx_busy$_DFFE_PN0P_ _021_ net1 clknet_1_0__leaf_clk net13
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net10 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 data_in[0] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput2 data_in[1] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 data_in[2] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 data_in[3] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 data_in[4] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 data_in[5] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 data_in[6] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 data_in[7] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 rst_n net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlya_2
Xinput10 tx_start net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput11 net12 tx VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net13 tx_busy VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
.ENDS parameterized_uart_tx
