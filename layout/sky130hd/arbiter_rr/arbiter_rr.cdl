* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT arbiter_rr active clk grant[0] grant[1] grant[2] grant[3]
+ request[0] request[1] request[2] request[3] rst_n
X_056_ _049_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__buf_2
X_057_ net5 net4 net3 net2 priority_ptr\[0\] _006_ VSS VSS
+ VDD VDD _007_ sky130_fd_sc_hd__mux4_4
X_058_ priority_ptr\[0\] VSS VSS VDD VDD _008_ sky130_fd_sc_hd__buf_6
X_059_ net4 net5 net2 net3 _008_ priority_ptr\[1\] VSS VSS
+ VDD VDD _009_ sky130_fd_sc_hd__mux4_1
X_060_ _007_ _009_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__nor2b_1
X_061_ net2 net3 net4 net5 _008_ priority_ptr\[1\] VSS VSS
+ VDD VDD _011_ sky130_fd_sc_hd__mux4_1
X_062_ _011_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__buf_6
X_063_ _052_ _007_ _010_ _050_ _012_ VSS VSS VDD VDD _013_
+ sky130_fd_sc_hd__a221oi_1
X_064_ _048_ _012_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__nor2b_1
X_065_ net3 net5 net2 net4 _006_ _008_ VSS VSS VDD VDD _015_
+ sky130_fd_sc_hd__mux4_1
X_066_ _012_ _007_ _009_ _015_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__nor4b_2
X_067_ _054_ _016_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nand2_1
X_068_ _013_ _014_ _017_ VSS VSS VDD VDD _000_ sky130_fd_sc_hd__o21ai_0
X_069_ _050_ _007_ _010_ _054_ _012_ VSS VSS VDD VDD _018_
+ sky130_fd_sc_hd__a221oi_1
X_070_ _052_ _012_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__nor2b_1
X_071_ _048_ _016_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__nand2_1
X_072_ _018_ _019_ _020_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o21ai_0
X_073_ _054_ _007_ _010_ _048_ _012_ VSS VSS VDD VDD _021_
+ sky130_fd_sc_hd__a221oi_1
X_074_ _050_ _012_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__nor2b_1
X_075_ _052_ _016_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nand2_1
X_076_ _021_ _022_ _023_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__o21ai_0
X_077_ _048_ _007_ _010_ _052_ _012_ VSS VSS VDD VDD _024_
+ sky130_fd_sc_hd__a221oi_1
X_078_ _054_ _012_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor2b_1
X_079_ _050_ _016_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__nand2_1
X_080_ _024_ _025_ _026_ VSS VSS VDD VDD _003_ sky130_fd_sc_hd__o21ai_0
X_081_ _008_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__inv_1
X_082_ priority_ptr\[1\] VSS VSS VDD VDD _047_ sky130_fd_sc_hd__inv_1
X_083_ _012_ _010_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__nor2_1
X_084_ _008_ _027_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__xnor2_1
X_085_ net5 net3 _006_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__mux2_1
X_086_ net4 net2 _006_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__mux2i_1
X_087_ net5 priority_ptr\[1\] _008_ VSS VSS VDD VDD _030_
+ sky130_fd_sc_hd__nor3b_1
X_088_ _046_ _028_ _029_ _030_ _011_ VSS VSS VDD VDD _031_
+ sky130_fd_sc_hd__a221oi_2
X_089_ net2 net3 net4 net5 VSS VSS VDD VDD _032_ sky130_fd_sc_hd__or4_1
X_090_ _006_ _032_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__nand2_1
X_091_ _031_ _033_ VSS VSS VDD VDD _034_ sky130_fd_sc_hd__nor2_1
X_092_ _006_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__inv_1
X_093_ priority_ptr\[1\] _032_ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor2_1
X_094_ net3 _035_ _031_ _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__a31o_1
X_095_ _008_ net5 VSS VSS VDD VDD _038_ sky130_fd_sc_hd__and2b_1
X_096_ _008_ _035_ _038_ _047_ net2 VSS VSS VDD VDD _039_
+ sky130_fd_sc_hd__a2111o_1
X_097_ net4 _006_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor2_1
X_098_ _008_ net4 net5 priority_ptr\[1\] VSS VSS VDD VDD _041_
+ sky130_fd_sc_hd__nor4_1
X_099_ _008_ priority_ptr\[1\] _040_ _041_ VSS VSS VDD VDD
+ _042_ sky130_fd_sc_hd__a31oi_1
X_100_ net3 _006_ _032_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand3b_1
X_101_ _039_ _042_ _043_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__a21oi_1
X_102_ _035_ _031_ _039_ _042_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand4_1
X_103_ _034_ _037_ _044_ _045_ VSS VSS VDD VDD _005_ sky130_fd_sc_hd__nor4b_1
X_104_ net9 net8 net11 net10 VSS VSS VDD VDD net7 sky130_fd_sc_hd__or4_1
X_105_ _046_ _047_ VSS VSS VDD VDD _048_ _049_ sky130_fd_sc_hd__ha_1
X_106_ _046_ priority_ptr\[1\] VSS VSS VDD VDD _050_ _051_
+ sky130_fd_sc_hd__ha_1
X_107_ priority_ptr\[0\] _047_ VSS VSS VDD VDD _052_ _053_
+ sky130_fd_sc_hd__ha_1
X_108_ priority_ptr\[0\] priority_ptr\[1\] VSS VSS VDD VDD
+ _054_ _055_ sky130_fd_sc_hd__ha_1
Xgrant\[0\]$_DFF_PN0_ clknet_1_1__leaf_clk _000_ net1 VSS
+ VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_1
Xgrant\[1\]$_DFF_PN0_ clknet_1_1__leaf_clk _001_ net1 VSS
+ VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xgrant\[2\]$_DFF_PN0_ clknet_1_0__leaf_clk _002_ net1 VSS
+ VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xgrant\[3\]$_DFF_PN0_ clknet_1_1__leaf_clk _003_ net1 VSS
+ VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xpriority_ptr\[0\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _004_
+ net6 VSS VSS VDD VDD priority_ptr\[0\] sky130_fd_sc_hd__dfstp_1
Xpriority_ptr\[1\]$_DFFE_PN1P_ clknet_1_0__leaf_clk _005_
+ net6 VSS VSS VDD VDD priority_ptr\[1\] sky130_fd_sc_hd__dfstp_2
Xhold1 net6 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 request[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 request[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 request[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 request[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xinput5 net12 VSS VSS VDD VDD net6 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput6 net7 VSS VSS VDD VDD active sky130_fd_sc_hd__clkbuf_1
Xoutput7 net8 VSS VSS VDD VDD grant[0] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD grant[1] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD grant[2] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD grant[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net12 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS arbiter_rr
