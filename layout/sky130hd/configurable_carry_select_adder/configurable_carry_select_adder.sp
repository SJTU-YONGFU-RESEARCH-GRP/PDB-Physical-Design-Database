* cell configurable_carry_select_adder
* pin sum[26]
* pin b[26]
* pin a[28]
* pin sum[27]
* pin b[27]
* pin sum[28]
* pin a[27]
* pin b[28]
* pin sum[17]
* pin sum[18]
* pin b[18]
* pin a[17]
* pin a[18]
* pin b[16]
* pin sum[16]
* pin a[16]
* pin sum[19]
* pin b[33]
* pin a[33]
* pin a[19]
* pin b[19]
* pin sum[20]
* pin b[20]
* pin a[20]
* pin a[14]
* pin b[14]
* pin b[21]
* pin sum[21]
* pin a[21]
* pin a[23]
* pin b[23]
* pin sum[22]
* pin sum[23]
* pin b[22]
* pin sum[8]
* pin a[22]
* pin sum[12]
* pin sum[9]
* pin sum[7]
* pin b[34]
* pin a[26]
* pin b[17]
* pin sum[11]
* pin b[11]
* pin a[13]
* pin a[11]
* pin a[24]
* pin a[10]
* pin sum[34]
* pin a[25]
* pin b[12]
* pin sum[25]
* pin b[10]
* pin sum[56]
* pin b[25]
* pin b[8]
* pin a[12]
* pin sum[24]
* pin sum[29]
* pin a[15]
* pin sum[14]
* pin a[56]
* pin sum[10]
* pin b[24]
* pin b[13]
* pin a[29]
* pin b[30]
* pin sum[35]
* pin sum[13]
* pin b[31]
* pin b[56]
* pin b[9]
* pin b[15]
* pin a[31]
* pin b[29]
* pin a[9]
* pin sum[15]
* pin a[57]
* pin sum[57]
* pin a[34]
* pin a[8]
* pin b[57]
* pin b[35]
* pin a[32]
* pin a[7]
* pin sum[33]
* pin a[30]
* pin b[7]
* pin a[35]
* pin sum[31]
* pin sum[30]
* pin a[36]
* pin sum[36]
* pin b[32]
* pin a[6]
* pin a[58]
* pin b[6]
* pin b[58]
* pin sum[32]
* pin sum[37]
* pin b[36]
* pin sum[55]
* pin a[39]
* pin b[55]
* pin sum[39]
* pin sum[59]
* pin b[37]
* pin b[59]
* pin b[5]
* pin a[59]
* pin sum[5]
* pin a[55]
* pin a[5]
* pin sum[58]
* pin a[54]
* pin a[38]
* pin a[37]
* pin sum[54]
* pin sum[38]
* pin b[60]
* pin sum[4]
* pin b[54]
* pin b[38]
* pin b[4]
* pin a[60]
* pin b[3]
* pin sum[6]
* pin sum[60]
* pin a[1]
* pin b[39]
* pin sum[62]
* pin sum[3]
* pin b[61]
* pin b[62]
* pin b[2]
* pin sum[1]
* pin cin
* pin a[3]
* pin a[4]
* pin sum[0]
* pin a[62]
* pin a[0]
* pin sum[2]
* pin sum[61]
* pin b[1]
* pin b[0]
* pin a[47]
* pin a[61]
* pin cout
* pin sum[48]
* pin b[63]
* pin a[51]
* pin a[40]
* pin a[2]
* pin a[48]
* pin b[47]
* pin a[49]
* pin a[63]
* pin b[46]
* pin a[46]
* pin b[44]
* pin a[45]
* pin b[43]
* pin sum[43]
* pin a[43]
* pin sum[42]
* pin sum[49]
* pin sum[63]
* pin b[52]
* pin sum[52]
* pin b[53]
* pin sum[53]
* pin a[53]
* pin a[52]
* pin b[48]
* pin b[51]
* pin sum[51]
* pin sum[47]
* pin sum[46]
* pin b[49]
* pin b[50]
* pin sum[50]
* pin a[50]
* pin b[45]
* pin sum[44]
* pin a[44]
* pin sum[45]
* pin sum[40]
* pin b[40]
* pin b[42]
* pin a[42]
* pin b[41]
* pin a[41]
* pin sum[41]
.SUBCKT configurable_carry_select_adder 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16
+ 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42
+ 43 49 64 86 98 108 109 120 136 142 150 157 158 167 170 183 184 191 193 206
+ 214 221 232 235 236 244 245 269 270 279 280 289 290 297 307 316 317 323 324
+ 331 337 345 353 358 359 365 379 382 383 391 392 403 407 415 419 427 428 433
+ 434 440 449 453 458 463 467 472 475 489 498 502 509 513 514 519 520 532 539
+ 548 555 562 570 571 578 582 583 589 596 597 607 616 627 628 638 639 646 647
+ 648 649 657 668 669 680 689 694 698 703 704 716 727 731 733 734 742 743 751
+ 753 756 757 758 759 760 761 762 763 768 770 771 772 773 774 775 776 777 778
+ 779 780 781 782 783 784 786 787 788 789 790 791 792 793 794 795 796 797
* net 1 sum[26]
* net 2 b[26]
* net 3 a[28]
* net 4 sum[27]
* net 5 b[27]
* net 6 sum[28]
* net 7 a[27]
* net 8 b[28]
* net 9 sum[17]
* net 10 sum[18]
* net 11 b[18]
* net 12 a[17]
* net 13 a[18]
* net 14 b[16]
* net 15 sum[16]
* net 16 a[16]
* net 17 sum[19]
* net 18 b[33]
* net 19 a[33]
* net 20 a[19]
* net 21 b[19]
* net 22 sum[20]
* net 23 b[20]
* net 24 a[20]
* net 25 a[14]
* net 26 b[14]
* net 27 b[21]
* net 28 sum[21]
* net 29 a[21]
* net 30 a[23]
* net 31 b[23]
* net 32 sum[22]
* net 33 sum[23]
* net 34 b[22]
* net 35 sum[8]
* net 36 a[22]
* net 37 sum[12]
* net 38 sum[9]
* net 39 sum[7]
* net 40 b[34]
* net 41 a[26]
* net 42 b[17]
* net 43 sum[11]
* net 49 b[11]
* net 64 a[13]
* net 86 a[11]
* net 98 a[24]
* net 108 a[10]
* net 109 sum[34]
* net 120 a[25]
* net 136 b[12]
* net 142 sum[25]
* net 150 b[10]
* net 157 sum[56]
* net 158 b[25]
* net 167 b[8]
* net 170 a[12]
* net 183 sum[24]
* net 184 sum[29]
* net 191 a[15]
* net 193 sum[14]
* net 206 a[56]
* net 214 sum[10]
* net 221 b[24]
* net 232 b[13]
* net 235 a[29]
* net 236 b[30]
* net 244 sum[35]
* net 245 sum[13]
* net 269 b[31]
* net 270 b[56]
* net 279 b[9]
* net 280 b[15]
* net 289 a[31]
* net 290 b[29]
* net 297 a[9]
* net 307 sum[15]
* net 316 a[57]
* net 317 sum[57]
* net 323 a[34]
* net 324 a[8]
* net 331 b[57]
* net 337 b[35]
* net 345 a[32]
* net 353 a[7]
* net 358 sum[33]
* net 359 a[30]
* net 365 b[7]
* net 379 a[35]
* net 382 sum[31]
* net 383 sum[30]
* net 391 a[36]
* net 392 sum[36]
* net 403 b[32]
* net 407 a[6]
* net 415 a[58]
* net 419 b[6]
* net 427 b[58]
* net 428 sum[32]
* net 433 sum[37]
* net 434 b[36]
* net 440 sum[55]
* net 449 a[39]
* net 453 b[55]
* net 458 sum[39]
* net 463 sum[59]
* net 467 b[37]
* net 472 b[59]
* net 475 b[5]
* net 489 a[59]
* net 498 sum[5]
* net 502 a[55]
* net 509 a[5]
* net 513 sum[58]
* net 514 a[54]
* net 519 a[38]
* net 520 a[37]
* net 532 sum[54]
* net 539 sum[38]
* net 548 b[60]
* net 555 sum[4]
* net 562 b[54]
* net 570 b[38]
* net 571 b[4]
* net 578 a[60]
* net 582 b[3]
* net 583 sum[6]
* net 589 sum[60]
* net 596 a[1]
* net 597 b[39]
* net 607 sum[62]
* net 616 sum[3]
* net 627 b[61]
* net 628 b[62]
* net 638 b[2]
* net 639 sum[1]
* net 646 cin
* net 647 a[3]
* net 648 a[4]
* net 649 sum[0]
* net 657 a[62]
* net 668 a[0]
* net 669 sum[2]
* net 680 sum[61]
* net 689 b[1]
* net 694 b[0]
* net 698 a[47]
* net 703 a[61]
* net 704 cout
* net 716 sum[48]
* net 727 b[63]
* net 731 a[51]
* net 733 a[40]
* net 734 a[2]
* net 742 a[48]
* net 743 b[47]
* net 751 a[49]
* net 753 a[63]
* net 756 b[46]
* net 757 a[46]
* net 758 b[44]
* net 759 a[45]
* net 760 b[43]
* net 761 sum[43]
* net 762 a[43]
* net 763 sum[42]
* net 768 sum[49]
* net 770 sum[63]
* net 771 b[52]
* net 772 sum[52]
* net 773 b[53]
* net 774 sum[53]
* net 775 a[53]
* net 776 a[52]
* net 777 b[48]
* net 778 b[51]
* net 779 sum[51]
* net 780 sum[47]
* net 781 sum[46]
* net 782 b[49]
* net 783 b[50]
* net 784 sum[50]
* net 786 a[50]
* net 787 b[45]
* net 788 sum[44]
* net 789 a[44]
* net 790 sum[45]
* net 791 sum[40]
* net 792 b[40]
* net 793 b[42]
* net 794 a[42]
* net 795 b[41]
* net 796 a[41]
* net 797 sum[41]
* cell instance $3 m0 *1 8.28,8.16
X$3 88 110 1 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $6 m0 *1 14.26,8.16
X$6 88 2 81 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $9 r0 *1 21.62,8.16
X$9 88 3 145 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $11 r0 *1 20.24,8.16
X$11 88 126 4 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $15 r0 *1 13.8,2.72
X$15 88 5 71 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $18 m0 *1 24.38,8.16
X$18 88 73 6 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $21 r0 *1 19.78,2.72
X$21 88 7 74 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $23 r0 *1 23,8.16
X$23 88 8 146 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $27 r0 *1 24.38,8.16
X$27 88 97 9 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $30 r0 *1 26.68,8.16
X$30 88 127 10 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $33 r0 *1 27.6,2.72
X$33 88 11 45 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $36 r0 *1 22.08,2.72
X$36 88 12 56 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $39 r0 *1 29.44,2.72
X$39 88 13 53 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $42 r0 *1 26.22,2.72
X$42 88 14 46 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $46 r0 *1 24.84,2.72
X$46 88 57 15 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $50 r0 *1 30.82,2.72
X$50 88 16 77 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $53 r0 *1 32.2,2.72
X$53 88 58 17 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $56 r0 *1 33.58,2.72
X$56 50 79 18 88 88 50 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $59 r0 *1 38.18,2.72
X$59 50 163 19 88 88 50 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $62 r0 *1 45.08,2.72
X$62 88 20 59 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $67 r0 *1 46.46,2.72
X$67 88 21 83 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $71 r0 *1 47.84,2.72
X$71 88 60 22 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $75 r0 *1 49.22,2.72
X$75 88 23 78 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $80 r0 *1 50.6,2.72
X$80 88 24 76 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $83 r0 *1 51.98,2.72
X$83 88 25 190 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $86 m0 *1 48.76,13.6
X$86 88 26 189 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $89 r0 *1 49.68,8.16
X$89 88 27 131 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $92 r0 *1 57.04,2.72
X$92 88 61 28 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $95 m0 *1 54.28,8.16
X$95 88 29 103 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $98 r0 *1 70.84,2.72
X$98 88 30 51 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $101 r0 *1 58.42,2.72
X$101 88 31 75 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $104 r0 *1 63.02,2.72
X$104 88 62 32 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $107 r0 *1 56.58,13.6
X$107 88 156 33 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $112 m0 *1 70.38,8.16
X$112 88 34 84 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $115 m0 *1 57.5,19.04
X$115 88 210 35 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $118 r0 *1 65.32,8.16
X$118 88 36 105 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $122 r0 *1 62.56,13.6
X$122 88 68 37 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $126 m0 *1 65.32,19.04
X$126 88 211 38 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $133 r0 *1 63.94,13.6
X$133 88 355 39 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $136 r0 *1 72.22,2.72
X$136 50 44 40 88 88 50 sky130_fd_sc_hd__dlymetal6s2s_1
* cell instance $140 r0 *1 9.66,2.72
X$140 88 41 54 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $143 r0 *1 23.46,2.72
X$143 88 42 82 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $147 r0 *1 58.42,13.6
X$147 88 90 43 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $156 m0 *1 51.06,29.92
X$156 50 328 330 304 44 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $158 r0 *1 52.9,29.92
X$158 88 304 44 342 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $164 r0 *1 30.82,13.6
X$164 88 53 45 187 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $167 m0 *1 29.44,13.6
X$167 50 178 148 53 45 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $169 r0 *1 32.2,13.6
X$169 88 53 45 116 88 180 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $176 m0 *1 29.44,19.04
X$176 50 802 209 77 46 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $180 r0 *1 29.44,19.04
X$180 88 46 88 50 224 50 sky130_fd_sc_hd__inv_1
* cell instance $184 r0 *1 36.8,8.16
X$184 88 83 59 47 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $187 r0 *1 43.24,2.72
X$187 88 52 47 129 50 88 80 50 sky130_fd_sc_hd__a21oi_1
* cell instance $193 r0 *1 71.76,8.16
X$193 50 134 151 149 168 63 48 88 88 50 sky130_fd_sc_hd__o32a_1
* cell instance $196 m0 *1 72.22,8.16
X$196 50 106 107 63 48 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $198 r0 *1 67.62,2.72
X$198 88 48 63 111 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $200 r0 *1 66.24,13.6
X$200 88 49 48 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $216 r0 *1 1.84,2.72
X$216 88 66 87 65 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $219 r0 *1 5.98,2.72
X$219 88 100 67 110 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $221 r0 *1 11.04,2.72
X$221 88 54 81 69 55 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $226 r0 *1 16.1,2.72
X$226 88 137 72 73 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $232 r0 *1 53.36,2.72
X$232 88 104 94 88 61 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $234 r0 *1 59.8,2.72
X$234 88 132 92 62 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $235 r0 *1 64.4,2.72
X$235 88 91 70 68 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $245 m0 *1 1.38,8.16
X$245 88 65 142 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $247 m0 *1 3.68,8.16
X$247 50 87 89 99 122 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $248 m0 *1 9.66,8.16
X$248 50 67 69 54 81 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $249 m0 *1 15.64,8.16
X$249 88 69 125 71 74 112 50 88 50 sky130_fd_sc_hd__o22a_1
* cell instance $250 m0 *1 18.86,8.16
X$250 50 113 96 74 71 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $252 m0 *1 25.76,8.16
X$252 88 101 115 97 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $254 m0 *1 29.44,8.16
X$254 50 115 116 56 82 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $256 m0 *1 34.96,8.16
X$256 50 139 52 59 83 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $258 m0 *1 40.02,8.16
X$258 88 80 119 60 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $259 m0 *1 43.24,8.16
X$259 50 119 117 76 78 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $260 m0 *1 47.84,8.16
X$260 88 76 78 117 118 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $261 m0 *1 49.68,8.16
X$261 50 94 95 103 131 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $266 m0 *1 58.42,8.16
X$266 88 51 75 84 105 93 50 88 50 sky130_fd_sc_hd__o22ai_1
* cell instance $267 m0 *1 60.72,8.16
X$267 50 92 114 105 84 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $268 m0 *1 65.32,8.16
X$268 88 85 106 88 90 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $269 m0 *1 68.54,8.16
X$269 88 107 111 85 50 88 91 50 sky130_fd_sc_hd__a21oi_1
* cell instance $271 r0 *1 1.38,8.16
X$271 88 120 99 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $272 r0 *1 2.76,8.16
X$272 88 98 143 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $274 r0 *1 5.06,8.16
X$274 88 121 66 123 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $275 r0 *1 6.44,8.16
X$275 88 99 122 121 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $277 r0 *1 8.28,8.16
X$277 88 89 123 100 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $280 r0 *1 11.04,8.16
X$280 88 124 100 125 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $281 r0 *1 12.42,8.16
X$281 88 54 81 124 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $282 r0 *1 13.8,8.16
X$282 88 69 125 138 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $285 r0 *1 15.64,8.16
X$285 88 96 112 137 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $286 r0 *1 17.02,8.16
X$286 88 138 113 126 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $288 r0 *1 28.06,8.16
X$288 88 116 101 128 147 88 50 50 sky130_fd_sc_hd__o21ba_1
* cell instance $289 r0 *1 31.74,8.16
X$289 88 56 82 128 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $290 r0 *1 33.12,8.16
X$290 88 129 139 88 58 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $292 r0 *1 39.1,8.16
X$292 88 52 83 59 117 50 102 88 50 sky130_fd_sc_hd__nor4_1
* cell instance $297 r0 *1 43.24,8.16
X$297 50 104 117 52 129 130 88 88 50 sky130_fd_sc_hd__o31a_1
* cell instance $298 r0 *1 46.46,8.16
X$298 88 102 118 130 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $301 r0 *1 51.52,8.16
X$301 88 131 103 141 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $302 r0 *1 53.82,8.16
X$302 88 95 141 104 50 88 132 50 sky130_fd_sc_hd__a21oi_1
* cell instance $303 r0 *1 55.66,8.16
X$303 88 133 155 88 156 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $304 r0 *1 58.88,8.16
X$304 88 114 140 132 88 50 133 50 sky130_fd_sc_hd__o21bai_1
* cell instance $305 r0 *1 61.64,8.16
X$305 88 86 63 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $306 r0 *1 63.02,8.16
X$306 88 105 84 140 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $309 r0 *1 67.16,8.16
X$309 88 107 134 153 135 212 50 88 50 sky130_fd_sc_hd__o22a_1
* cell instance $321 m0 *1 1.38,13.6
X$321 88 171 157 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $322 m0 *1 2.76,13.6
X$322 88 158 122 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $323 m0 *1 4.14,13.6
X$323 88 172 183 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $325 m0 *1 5.98,13.6
X$325 88 143 88 50 173 50 sky130_fd_sc_hd__inv_1
* cell instance $327 m0 *1 7.82,13.6
X$327 88 99 122 89 144 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $328 m0 *1 9.66,13.6
X$328 88 99 122 152 88 161 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $330 m0 *1 11.96,13.6
X$330 88 124 144 159 160 88 50 154 50 sky130_fd_sc_hd__o31ai_1
* cell instance $331 m0 *1 14.72,13.6
X$331 88 96 69 160 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $332 m0 *1 16.1,13.6
X$332 88 69 89 175 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $334 m0 *1 18.4,13.6
X$334 50 176 74 71 96 145 146 88 88 50 sky130_fd_sc_hd__o32a_1
* cell instance $336 m0 *1 25.76,13.6
X$336 88 147 178 127 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $338 m0 *1 34.04,13.6
X$338 50 129 148 147 187 88 88 50 sky130_fd_sc_hd__o21bai_2
* cell instance $340 m0 *1 38.64,13.6
X$340 88 117 52 148 162 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $344 m0 *1 45.54,13.6
X$344 88 118 102 93 141 50 182 88 50 sky130_fd_sc_hd__nor4b_1
* cell instance $346 m0 *1 51.06,13.6
X$346 88 95 88 50 181 50 sky130_fd_sc_hd__inv_1
* cell instance $347 m0 *1 52.44,13.6
X$347 88 165 109 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $349 m0 *1 54.74,13.6
X$349 88 51 75 114 88 164 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $351 m0 *1 57.04,13.6
X$351 50 155 179 51 75 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $352 m0 *1 61.64,13.6
X$352 88 108 151 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $354 m0 *1 63.48,13.6
X$354 50 70 177 135 153 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $355 m0 *1 68.08,13.6
X$355 88 136 153 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $356 m0 *1 69.46,13.6
X$356 50 174 168 151 149 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $357 m0 *1 74.06,13.6
X$357 88 195 193 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $358 m0 *1 75.44,13.6
X$358 88 170 135 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $360 r0 *1 2.3,13.6
X$360 50 805 152 143 185 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $362 r0 *1 7.36,13.6
X$362 50 196 152 197 88 66 88 50 sky130_fd_sc_hd__mux2i_2
* cell instance $363 r0 *1 12.42,13.6
X$363 88 89 207 159 50 88 50 sky130_fd_sc_hd__nor2b_1
* cell instance $369 r0 *1 15.64,13.6
X$369 88 161 175 55 199 50 186 88 50 sky130_fd_sc_hd__a211oi_1
* cell instance $371 r0 *1 19.32,13.6
X$371 88 145 146 71 74 199 50 88 50 sky130_fd_sc_hd__o22ai_1
* cell instance $372 r0 *1 21.62,13.6
X$372 88 145 146 96 88 200 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $377 r0 *1 36.8,13.6
X$377 50 201 202 180 187 128 162 88 88 50 sky130_fd_sc_hd__o311ai_0
* cell instance $387 r0 *1 51.52,13.6
X$387 88 181 93 164 204 203 88 50 50 sky130_fd_sc_hd__o211ai_1
* cell instance $389 r0 *1 54.74,13.6
X$389 88 179 88 50 204 50 sky130_fd_sc_hd__inv_1
* cell instance $392 r0 *1 59.8,13.6
X$392 88 150 149 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $393 r0 *1 61.18,13.6
X$393 88 151 149 166 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $395 r0 *1 67.62,13.6
X$395 88 168 166 192 88 50 85 50 sky130_fd_sc_hd__o21bai_1
* cell instance $401 r0 *1 71.3,13.6
X$401 88 192 174 169 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $403 r0 *1 75.44,13.6
X$403 88 169 214 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $404 m0 *1 1.38,19.04
X$404 88 221 185 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $405 m0 *1 2.76,19.04
X$405 88 185 88 50 194 50 sky130_fd_sc_hd__inv_1
* cell instance $406 m0 *1 4.14,19.04
X$406 50 247 207 173 194 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $409 m0 *1 11.5,19.04
X$409 88 207 88 50 197 50 sky130_fd_sc_hd__inv_1
* cell instance $413 m0 *1 17.94,19.04
X$413 88 208 176 154 50 88 198 50 sky130_fd_sc_hd__a21oi_1
* cell instance $414 m0 *1 19.78,19.04
X$414 50 72 208 145 146 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $420 m0 *1 35.42,19.04
X$420 88 209 88 50 201 50 sky130_fd_sc_hd__inv_1
* cell instance $421 m0 *1 36.8,19.04
X$421 50 217 188 180 187 128 162 88 88 50 sky130_fd_sc_hd__o311ai_0
* cell instance $422 m0 *1 40.02,19.04
X$422 88 203 182 188 50 88 256 50 sky130_fd_sc_hd__a21oi_1
* cell instance $425 m0 *1 43.24,19.04
X$425 88 203 182 202 50 88 258 50 sky130_fd_sc_hd__a21oi_1
* cell instance $429 m0 *1 48.3,19.04
X$429 50 218 220 190 189 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $431 m0 *1 53.36,19.04
X$431 88 219 218 88 195 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $434 m0 *1 58.88,19.04
X$434 88 191 261 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $435 m0 *1 60.26,19.04
X$435 88 177 242 216 88 229 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $436 m0 *1 63.02,19.04
X$436 88 167 215 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $438 m0 *1 66.7,19.04
X$438 50 212 213 231 107 205 168 88 88 50 sky130_fd_sc_hd__o41ai_4
* cell instance $440 r0 *1 2.3,19.04
X$440 88 206 246 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $441 r0 *1 3.68,19.04
X$441 88 196 247 88 172 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $443 r0 *1 7.82,19.04
X$443 88 222 184 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $446 r0 *1 11.5,19.04
X$446 88 237 264 88 222 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $454 r0 *1 18.4,19.04
X$454 50 237 186 248 196 286 88 88 50 sky130_fd_sc_hd__o31a_1
* cell instance $455 r0 *1 21.62,19.04
X$455 88 238 200 248 88 50 50 sky130_fd_sc_hd__nand2_1
* cell instance $456 r0 *1 23,19.04
X$456 88 208 88 50 238 50 sky130_fd_sc_hd__inv_1
* cell instance $458 r0 *1 26.22,19.04
X$458 88 225 223 57 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $459 r0 *1 30.82,19.04
X$459 50 223 217 267 224 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $460 r0 *1 35.42,19.04
X$460 88 234 209 225 50 88 101 50 sky130_fd_sc_hd__a21oi_1
* cell instance $461 r0 *1 37.26,19.04
X$461 88 217 225 234 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $469 r0 *1 43.7,19.04
X$469 88 239 250 205 50 88 225 50 sky130_fd_sc_hd__o21a_2
* cell instance $471 r0 *1 47.38,19.04
X$471 88 226 227 240 88 239 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $472 r0 *1 50.14,19.04
X$472 88 190 189 241 88 227 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $473 r0 *1 51.98,19.04
X$473 88 190 189 251 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $475 r0 *1 54.28,19.04
X$475 88 260 220 241 88 226 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $476 r0 *1 56.12,19.04
X$476 88 228 240 205 88 50 219 50 sky130_fd_sc_hd__o21ai_1
* cell instance $478 r0 *1 58.42,19.04
X$478 88 230 229 240 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $479 r0 *1 59.8,19.04
X$479 50 233 230 216 242 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $480 r0 *1 64.4,19.04
X$480 88 64 216 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $481 r0 *1 65.78,19.04
X$481 88 177 249 263 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $483 r0 *1 67.62,19.04
X$483 88 232 242 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $487 r0 *1 69,19.04
X$487 88 231 213 192 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $489 r0 *1 70.84,19.04
X$489 50 249 212 213 231 168 107 88 88 50 sky130_fd_sc_hd__o41a_1
* cell instance $490 r0 *1 74.98,19.04
X$490 88 262 245 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $492 m0 *1 1.38,24.48
X$492 88 270 252 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $493 m0 *1 2.76,24.48
X$493 50 804 318 246 252 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $494 m0 *1 7.36,24.48
X$494 88 246 88 50 281 50 sky130_fd_sc_hd__inv_1
* cell instance $495 m0 *1 8.74,24.48
X$495 88 235 254 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $496 m0 *1 10.12,24.48
X$496 88 269 282 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $497 m0 *1 11.5,24.48
X$497 50 264 255 254 253 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $498 m0 *1 16.1,24.48
X$498 88 253 254 285 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $499 m0 *1 18.4,24.48
X$499 88 255 285 237 50 88 265 50 sky130_fd_sc_hd__a21oi_1
* cell instance $500 m0 *1 20.24,24.48
X$500 88 198 196 286 88 50 50 sky130_fd_sc_hd__nand2_1
* cell instance $501 m0 *1 21.62,24.48
X$501 88 238 273 200 287 88 50 50 sky130_fd_sc_hd__nand3_1
* cell instance $502 m0 *1 23.46,24.48
X$502 50 50 198 275 273 88 88 sky130_fd_sc_hd__nand2_2
* cell instance $509 m0 *1 30.82,24.48
X$509 88 276 268 225 88 196 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $510 m0 *1 33.58,24.48
X$510 88 77 88 50 267 50 sky130_fd_sc_hd__inv_1
* cell instance $512 m0 *1 38.64,24.48
X$512 88 256 88 50 268 50 sky130_fd_sc_hd__inv_1
* cell instance $514 m0 *1 40.48,24.48
X$514 88 257 241 256 277 88 50 50 sky130_fd_sc_hd__nand3_1
* cell instance $515 m0 *1 42.32,24.48
X$515 50 276 205 258 239 250 88 88 50 sky130_fd_sc_hd__o211ai_2
* cell instance $516 m0 *1 46.92,24.48
X$516 88 241 259 250 88 50 50 sky130_fd_sc_hd__nand2_1
* cell instance $518 m0 *1 49.22,24.48
X$518 88 251 228 259 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $519 m0 *1 50.6,24.48
X$519 88 251 240 266 88 278 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $520 m0 *1 52.44,24.48
X$520 88 260 220 266 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $522 m0 *1 54.74,24.48
X$522 88 220 288 219 50 88 301 50 sky130_fd_sc_hd__a21oi_1
* cell instance $526 m0 *1 58.42,24.48
X$526 88 261 243 260 241 88 50 50 sky130_fd_sc_hd__or3_1
* cell instance $529 m0 *1 62.1,24.48
X$529 88 216 242 228 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $531 m0 *1 64.4,24.48
X$531 88 263 233 262 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $532 m0 *1 67.62,24.48
X$532 88 280 243 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $533 m0 *1 69,24.48
X$533 88 283 284 88 211 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $535 m0 *1 74.06,24.48
X$535 88 279 295 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $536 m0 *1 75.44,24.48
X$536 88 297 296 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $537 r0 *1 1.38,24.48
X$537 88 271 298 171 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $538 r0 *1 4.6,24.48
X$538 50 298 303 281 308 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $539 r0 *1 9.2,24.48
X$539 88 289 311 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $540 r0 *1 10.58,24.48
X$540 88 236 272 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $541 r0 *1 11.96,24.48
X$541 88 290 253 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $547 r0 *1 15.64,24.48
X$547 88 255 253 254 291 50 313 88 50 sky130_fd_sc_hd__nor4_1
* cell instance $550 r0 *1 19.32,24.48
X$550 88 292 291 255 273 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $551 r0 *1 21.16,24.48
X$551 88 292 88 50 314 50 sky130_fd_sc_hd__inv_1
* cell instance $552 r0 *1 22.54,24.48
X$552 88 274 287 186 88 257 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $555 r0 *1 27.6,24.48
X$555 50 274 268 315 276 275 225 88 88 50 sky130_fd_sc_hd__o2111ai_4
* cell instance $556 r0 *1 37.26,24.48
X$556 50 376 275 257 293 277 88 88 50 sky130_fd_sc_hd__a2bb2oi_2
* cell instance $561 r0 *1 43.24,24.48
X$561 88 257 275 293 277 88 312 50 50 sky130_fd_sc_hd__o2bb2ai_1
* cell instance $563 r0 *1 48.3,24.48
X$563 88 278 249 259 50 88 293 50 sky130_fd_sc_hd__a21oi_1
* cell instance $565 r0 *1 51.98,24.48
X$565 88 251 88 50 288 50 sky130_fd_sc_hd__inv_1
* cell instance $566 r0 *1 53.36,24.48
X$566 88 301 300 294 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $567 r0 *1 56.58,24.48
X$567 50 300 260 261 243 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $570 r0 *1 63.48,24.48
X$570 88 294 307 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $572 r0 *1 65.78,24.48
X$572 88 329 244 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $574 r0 *1 67.62,24.48
X$574 88 324 305 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $578 r0 *1 69,24.48
X$578 88 299 310 283 88 50 50 sky130_fd_sc_hd__nand2_1
* cell instance $581 r0 *1 71.3,24.48
X$581 50 284 231 296 295 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $583 m0 *1 1.38,29.92
X$583 88 302 317 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $584 m0 *1 2.76,29.92
X$584 88 316 325 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $587 m0 *1 5.52,29.92
X$587 88 252 88 50 308 50 sky130_fd_sc_hd__inv_1
* cell instance $588 m0 *1 6.9,29.92
X$588 88 303 271 326 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $592 m0 *1 11.5,29.92
X$592 88 311 282 319 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $593 m0 *1 12.88,29.92
X$593 50 397 292 311 282 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $594 m0 *1 17.48,29.92
X$594 50 319 327 313 274 314 88 88 50 sky130_fd_sc_hd__o31ai_2
* cell instance $604 m0 *1 40.94,29.92
X$604 88 257 258 225 320 88 50 50 sky130_fd_sc_hd__nand3_1
* cell instance $605 m0 *1 42.78,29.92
X$605 50 258 344 257 225 88 88 50 sky130_fd_sc_hd__and3_1
* cell instance $614 m0 *1 63.02,29.92
X$614 50 801 306 305 215 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $616 m0 *1 68.08,29.92
X$616 88 306 321 310 50 88 50 sky130_fd_sc_hd__nand2b_1
* cell instance $617 m0 *1 70.38,29.92
X$617 88 299 309 310 88 213 50 50 sky130_fd_sc_hd__a21oi_2
* cell instance $618 m0 *1 73.6,29.92
X$618 88 296 295 309 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $619 m0 *1 74.98,29.92
X$619 88 323 304 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $621 r0 *1 1.38,29.92
X$621 88 332 354 302 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $622 r0 *1 4.6,29.92
X$622 88 331 333 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $623 r0 *1 5.98,29.92
X$623 88 326 318 271 50 88 332 50 sky130_fd_sc_hd__a21oi_1
* cell instance $625 r0 *1 8.28,29.92
X$625 88 325 333 318 88 394 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $633 r0 *1 18.4,29.92
X$633 88 340 272 291 327 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $641 r0 *1 38.18,29.92
X$641 88 163 79 334 88 343 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $646 r0 *1 43.24,29.92
X$646 88 312 344 334 315 50 369 88 50 sky130_fd_sc_hd__nor4b_1
* cell instance $650 r0 *1 49.68,29.92
X$650 88 350 328 165 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $652 r0 *1 56.12,29.92
X$652 88 351 356 329 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $654 r0 *1 60.26,29.92
X$654 88 215 88 50 335 50 sky130_fd_sc_hd__inv_1
* cell instance $655 r0 *1 61.64,29.92
X$655 50 341 336 339 335 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $656 r0 *1 66.24,29.92
X$656 88 305 88 50 339 50 sky130_fd_sc_hd__inv_1
* cell instance $658 r0 *1 68.08,29.92
X$658 88 321 336 299 50 88 50 sky130_fd_sc_hd__nand2b_1
* cell instance $663 r0 *1 73.14,29.92
X$663 88 353 338 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $665 r0 *1 74.98,29.92
X$665 88 337 322 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $673 m0 *1 1.38,35.36
X$673 88 345 346 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $674 m0 *1 2.76,35.36
X$674 50 354 372 325 333 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $675 m0 *1 7.36,35.36
X$675 88 325 333 380 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $676 m0 *1 8.74,35.36
X$676 88 359 340 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $677 m0 *1 10.12,35.36
X$677 88 347 358 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $679 m0 *1 12.42,35.36
X$679 88 265 366 371 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $680 m0 *1 15.64,35.36
X$680 50 366 291 340 272 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $683 m0 *1 21.62,35.36
X$683 50 800 334 346 357 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $686 m0 *1 27.6,35.36
X$686 88 346 88 50 381 50 sky130_fd_sc_hd__inv_1
* cell instance $689 m0 *1 29.9,35.36
X$689 88 348 368 347 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $690 m0 *1 33.12,35.36
X$690 50 368 360 163 79 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $691 m0 *1 37.72,35.36
X$691 88 375 163 79 88 50 377 50 sky130_fd_sc_hd__o21bai_1
* cell instance $692 m0 *1 40.48,35.36
X$692 88 349 369 348 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $693 m0 *1 42.78,35.36
X$693 50 350 370 369 349 361 88 88 50 sky130_fd_sc_hd__o31a_1
* cell instance $695 m0 *1 46.46,35.36
X$695 88 342 361 343 50 88 367 50 sky130_fd_sc_hd__a21oi_1
* cell instance $698 m0 *1 49.68,35.36
X$698 88 330 350 342 351 88 50 50 sky130_fd_sc_hd__o21ba_1
* cell instance $703 m0 *1 57.04,35.36
X$703 50 356 378 362 322 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $704 m0 *1 61.64,35.36
X$704 88 341 321 88 210 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $705 m0 *1 64.86,35.36
X$705 88 363 355 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $706 m0 *1 66.24,35.36
X$706 88 352 88 50 363 50 sky130_fd_sc_hd__inv_1
* cell instance $707 m0 *1 67.62,35.36
X$707 50 321 352 338 396 364 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $708 m0 *1 74.98,35.36
X$708 88 365 364 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $710 r0 *1 1.38,35.36
X$710 88 384 382 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $711 r0 *1 2.76,35.36
X$711 88 371 383 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $713 r0 *1 5.98,35.36
X$713 88 372 303 380 88 50 411 50 sky130_fd_sc_hd__o21bai_1
* cell instance $714 r0 *1 8.74,35.36
X$714 88 394 372 395 50 88 50 sky130_fd_sc_hd__nand2b_1
* cell instance $716 r0 *1 11.96,35.36
X$716 88 398 397 384 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $721 r0 *1 15.64,35.36
X$721 88 291 373 398 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $722 r0 *1 17.02,35.36
X$722 88 374 265 373 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $723 r0 *1 18.4,35.36
X$723 88 340 272 374 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $727 r0 *1 24.84,35.36
X$727 88 357 88 50 400 50 sky130_fd_sc_hd__inv_1
* cell instance $728 r0 *1 26.22,35.36
X$728 50 399 375 381 400 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $732 r0 *1 35.88,35.36
X$732 88 375 88 50 401 50 sky130_fd_sc_hd__inv_1
* cell instance $734 r0 *1 38.18,35.36
X$734 88 163 79 370 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $735 r0 *1 39.56,35.36
X$735 88 315 376 320 401 50 88 349 50 sky130_fd_sc_hd__a31oi_1
* cell instance $741 r0 *1 43.24,35.36
X$741 88 360 88 50 361 50 sky130_fd_sc_hd__inv_1
* cell instance $744 r0 *1 46,35.36
X$744 88 342 361 377 50 88 387 50 sky130_fd_sc_hd__a21oi_1
* cell instance $747 r0 *1 50.14,35.36
X$747 88 330 387 413 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $749 r0 *1 52.44,35.36
X$749 88 330 367 412 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $752 r0 *1 56.58,35.36
X$752 50 389 378 351 388 88 88 50 sky130_fd_sc_hd__o21bai_2
* cell instance $754 r0 *1 61.18,35.36
X$754 88 362 322 388 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $755 r0 *1 62.56,35.36
X$755 88 379 362 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $756 r0 *1 63.94,35.36
X$756 88 389 402 88 390 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $758 r0 *1 67.62,35.36
X$758 88 390 392 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $768 m0 *1 1.38,40.8
X$768 88 415 385 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $770 m0 *1 3.68,40.8
X$770 88 404 385 405 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $771 m0 *1 5.98,40.8
X$771 88 408 405 411 50 88 499 50 sky130_fd_sc_hd__a21oi_1
* cell instance $772 m0 *1 7.82,40.8
X$772 50 416 395 411 271 88 88 50 sky130_fd_sc_hd__mux2_1
* cell instance $778 m0 *1 25.76,40.8
X$778 88 386 399 438 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $784 m0 *1 39.1,40.8
X$784 50 376 386 320 315 88 88 50 sky130_fd_sc_hd__and3_1
* cell instance $787 m0 *1 44.16,40.8
X$787 50 483 315 376 320 414 88 88 50 sky130_fd_sc_hd__a31o_1
* cell instance $789 m0 *1 49.22,40.8
X$789 88 378 388 413 88 50 426 50 sky130_fd_sc_hd__o21bai_1
* cell instance $790 m0 *1 51.98,40.8
X$790 88 378 388 412 88 50 425 50 sky130_fd_sc_hd__o21bai_1
* cell instance $796 m0 *1 63.48,40.8
X$796 50 402 409 406 410 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $797 m0 *1 68.08,40.8
X$797 88 391 406 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $798 m0 *1 69.46,40.8
X$798 50 396 420 422 393 421 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $799 r0 *1 1.38,40.8
X$799 50 429 408 385 404 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $800 r0 *1 5.98,40.8
X$800 88 408 405 416 50 88 435 50 sky130_fd_sc_hd__a21oi_1
* cell instance $801 r0 *1 7.82,40.8
X$801 88 408 405 395 50 88 437 50 sky130_fd_sc_hd__a21oi_1
* cell instance $804 r0 *1 12.42,40.8
X$804 88 403 357 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $805 r0 *1 13.8,40.8
X$805 88 438 428 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $819 r0 *1 43.24,40.8
X$819 50 430 315 376 320 88 484 88 50 sky130_fd_sc_hd__nand4_2
* cell instance $820 r0 *1 47.84,40.8
X$820 88 424 426 417 50 88 414 50 sky130_fd_sc_hd__a21o_1
* cell instance $823 r0 *1 51.98,40.8
X$823 88 417 424 425 50 88 430 50 sky130_fd_sc_hd__a21oi_1
* cell instance $826 r0 *1 56.12,40.8
X$826 88 418 439 461 50 88 417 50 sky130_fd_sc_hd__a21o_1
* cell instance $828 r0 *1 59.8,40.8
X$828 88 418 431 389 50 88 452 50 sky130_fd_sc_hd__a21oi_1
* cell instance $831 r0 *1 63.94,40.8
X$831 88 406 410 443 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $832 r0 *1 65.32,40.8
X$832 88 409 423 389 50 88 445 50 sky130_fd_sc_hd__a21oi_1
* cell instance $833 r0 *1 67.16,40.8
X$833 88 410 406 423 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $837 r0 *1 70.84,40.8
X$837 88 434 410 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $838 r0 *1 72.22,40.8
X$838 88 420 88 50 436 50 sky130_fd_sc_hd__inv_1
* cell instance $839 r0 *1 73.6,40.8
X$839 88 407 422 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $840 r0 *1 74.98,40.8
X$840 88 419 421 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $848 m0 *1 1.38,46.24
X$848 88 416 429 88 450 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $849 m0 *1 4.6,46.24
X$849 88 427 404 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $854 m0 *1 12.88,46.24
X$854 88 441 440 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $855 m0 *1 14.26,46.24
X$855 50 459 455 451 464 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $868 m0 *1 53.36,46.24
X$868 88 452 462 448 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $871 m0 *1 57.5,46.24
X$871 88 442 88 50 439 50 sky130_fd_sc_hd__inv_1
* cell instance $873 m0 *1 59.34,46.24
X$873 88 443 432 444 442 50 424 88 50 sky130_fd_sc_hd__nor4_1
* cell instance $875 m0 *1 62.1,46.24
X$875 88 444 432 443 431 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $877 m0 *1 64.86,46.24
X$877 88 445 460 446 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $879 m0 *1 69.92,46.24
X$879 88 446 433 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $880 m0 *1 71.3,46.24
X$880 88 449 447 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $881 m0 *1 72.68,46.24
X$881 88 436 572 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $884 m0 *1 75.44,46.24
X$884 88 448 458 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $885 r0 *1 1.38,46.24
X$885 88 435 468 477 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $886 r0 *1 4.6,46.24
X$886 50 468 491 469 478 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $887 r0 *1 9.2,46.24
X$887 88 473 437 500 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $888 r0 *1 10.58,46.24
X$888 88 453 464 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $889 r0 *1 11.96,46.24
X$889 88 454 459 441 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $894 r0 *1 15.64,46.24
X$894 88 451 464 455 479 50 88 50 sky130_fd_sc_hd__nor3_1
* cell instance $895 r0 *1 17.48,46.24
X$895 88 456 481 465 50 88 454 50 sky130_fd_sc_hd__a21o_1
* cell instance $896 r0 *1 20.24,46.24
X$896 88 457 456 465 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $897 r0 *1 21.62,46.24
X$897 50 471 271 455 457 456 88 88 50 sky130_fd_sc_hd__o31ai_4
* cell instance $898 r0 *1 29.44,46.24
X$898 50 470 456 88 88 50 sky130_fd_sc_hd__buf_6
* cell instance $909 r0 *1 54.28,46.24
X$909 50 462 461 447 466 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $910 r0 *1 58.88,46.24
X$910 88 447 466 442 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $913 r0 *1 63.02,46.24
X$913 88 474 432 445 88 50 573 50 sky130_fd_sc_hd__o21bai_1
* cell instance $914 r0 *1 65.78,46.24
X$914 50 460 474 497 486 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $921 r0 *1 72.22,46.24
X$921 88 511 476 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $925 m0 *1 1.38,51.68
X$925 88 477 463 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $926 m0 *1 2.76,51.68
X$926 88 472 478 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $927 m0 *1 4.14,51.68
X$927 88 469 478 473 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $929 m0 *1 5.98,51.68
X$929 88 473 499 490 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $931 m0 *1 7.82,51.68
X$931 88 491 490 480 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $932 m0 *1 9.2,51.68
X$932 88 491 500 503 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $934 m0 *1 11.04,51.68
X$934 50 510 455 457 456 471 480 88 88 50 sky130_fd_sc_hd__o311a_1
* cell instance $937 m0 *1 17.48,51.68
X$937 50 479 482 494 471 481 492 88 88 50 sky130_fd_sc_hd__a41oi_4
* cell instance $938 m0 *1 27.6,51.68
X$938 88 495 455 492 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $940 m0 *1 29.44,51.68
X$940 50 482 470 493 494 88 88 50 sky130_fd_sc_hd__and3_1
* cell instance $941 m0 *1 31.74,51.68
X$941 88 495 88 50 493 50 sky130_fd_sc_hd__inv_1
* cell instance $943 m0 *1 33.58,51.68
X$943 88 501 526 504 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $945 m0 *1 36.8,51.68
X$945 50 494 483 484 529 88 88 50 sky130_fd_sc_hd__nand3_2
* cell instance $949 m0 *1 46.46,51.68
X$949 88 483 484 512 88 50 50 sky130_fd_sc_hd__and2_0
* cell instance $957 m0 *1 60.26,51.68
X$957 88 488 444 485 88 50 418 50 sky130_fd_sc_hd__o21bai_1
* cell instance $958 m0 *1 63.02,51.68
X$958 88 474 496 485 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $960 m0 *1 64.86,51.68
X$960 88 409 486 497 88 496 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $961 m0 *1 67.62,51.68
X$961 88 497 486 432 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $963 m0 *1 69.46,51.68
X$963 50 393 508 560 487 507 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $964 r0 *1 1.38,51.68
X$964 88 450 513 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $966 r0 *1 4.6,51.68
X$966 88 489 469 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $967 r0 *1 5.98,51.68
X$967 88 502 451 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $968 r0 *1 7.36,51.68
X$968 88 510 271 503 50 88 521 50 sky130_fd_sc_hd__a21oi_1
* cell instance $978 r0 *1 18.4,51.68
X$978 88 558 535 565 88 481 50 50 sky130_fd_sc_hd__a21oi_2
* cell instance $982 r0 *1 29.9,51.68
X$982 88 482 525 493 494 88 527 50 50 sky130_fd_sc_hd__nand4_1
* cell instance $983 r0 *1 32.2,51.68
X$983 50 528 495 501 526 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $985 r0 *1 37.26,51.68
X$985 88 516 504 483 484 88 482 50 50 sky130_fd_sc_hd__a211o_1
* cell instance $987 r0 *1 40.94,51.68
X$987 88 504 505 530 50 88 529 50 sky130_fd_sc_hd__a21oi_1
* cell instance $992 r0 *1 43.24,51.68
X$992 88 530 505 506 517 50 88 531 50 sky130_fd_sc_hd__a31oi_1
* cell instance $993 r0 *1 45.54,51.68
X$993 88 506 516 517 50 88 50 sky130_fd_sc_hd__nor2b_1
* cell instance $994 r0 *1 47.84,51.68
X$994 88 512 88 50 506 50 sky130_fd_sc_hd__clkbuf_2
* cell instance $995 r0 *1 49.68,51.68
X$995 88 518 483 484 523 88 50 50 sky130_fd_sc_hd__nand3_1
* cell instance $997 r0 *1 51.98,51.68
X$997 50 524 518 522 545 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1001 r0 *1 63.02,51.68
X$1001 88 538 537 444 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1009 r0 *1 70.84,51.68
X$1009 88 467 486 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1011 r0 *1 72.68,51.68
X$1011 88 476 498 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1012 r0 *1 74.06,51.68
X$1012 88 508 88 50 511 50 sky130_fd_sc_hd__inv_1
* cell instance $1013 r0 *1 75.44,51.68
X$1013 88 475 507 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1014 m0 *1 1.38,57.12
X$1014 88 521 533 88 541 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1015 m0 *1 4.6,57.12
X$1015 88 514 515 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1016 m0 *1 5.98,57.12
X$1016 50 556 542 510 271 503 88 88 50 sky130_fd_sc_hd__a211oi_2
* cell instance $1017 m0 *1 10.58,57.12
X$1017 50 557 535 515 534 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1018 m0 *1 15.18,57.12
X$1018 88 534 515 558 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $1019 m0 *1 17.48,57.12
X$1019 88 558 549 535 50 88 457 50 sky130_fd_sc_hd__a21o_1
* cell instance $1023 m0 *1 23.46,57.12
X$1023 88 543 88 50 561 50 sky130_fd_sc_hd__inv_1
* cell instance $1029 m0 *1 34.96,57.12
X$1029 88 531 528 88 546 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1032 m0 *1 42.32,57.12
X$1032 88 505 551 547 88 516 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $1036 m0 *1 50.14,57.12
X$1036 88 506 524 88 799 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1037 m0 *1 53.36,57.12
X$1037 88 536 88 50 545 50 sky130_fd_sc_hd__inv_1
* cell instance $1038 m0 *1 54.74,57.12
X$1038 88 544 88 50 522 50 sky130_fd_sc_hd__inv_1
* cell instance $1043 m0 *1 61.18,57.12
X$1043 50 575 488 538 537 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1044 m0 *1 65.78,57.12
X$1044 88 519 538 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1047 m0 *1 69.46,57.12
X$1047 50 487 554 580 540 559 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $1049 r0 *1 2.3,57.12
X$1049 50 533 590 563 564 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1050 r0 *1 6.9,57.12
X$1050 88 563 564 542 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1051 r0 *1 8.28,57.12
X$1051 88 574 557 584 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1057 r0 *1 17.48,57.12
X$1057 50 574 549 565 456 88 88 50 sky130_fd_sc_hd__mux2i_1
* cell instance $1059 r0 *1 22.08,57.12
X$1059 88 456 576 695 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1061 r0 *1 25.76,57.12
X$1061 50 576 566 561 586 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1063 r0 *1 30.82,57.12
X$1063 88 566 527 456 88 50 550 50 sky130_fd_sc_hd__o21ai_1
* cell instance $1066 r0 *1 35.42,57.12
X$1066 88 550 588 88 752 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1073 r0 *1 45.08,57.12
X$1073 88 547 552 567 88 50 530 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1074 r0 *1 47.84,57.12
X$1074 88 552 567 603 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1075 r0 *1 49.22,57.12
X$1075 88 552 577 551 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1078 r0 *1 51.98,57.12
X$1078 50 806 553 544 536 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1080 r0 *1 57.04,57.12
X$1080 88 595 568 553 88 587 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $1081 r0 *1 58.88,57.12
X$1081 88 553 523 506 88 50 650 50 sky130_fd_sc_hd__o21ai_1
* cell instance $1083 r0 *1 64.4,57.12
X$1083 88 573 575 88 569 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1084 r0 *1 67.62,57.12
X$1084 88 569 539 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1087 r0 *1 69,57.12
X$1087 88 520 497 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1089 r0 *1 70.84,57.12
X$1089 88 509 560 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1090 r0 *1 72.22,57.12
X$1090 88 572 583 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1091 r0 *1 73.6,57.12
X$1091 88 571 559 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1093 r0 *1 75.44,57.12
X$1093 88 554 88 50 581 50 sky130_fd_sc_hd__inv_1
* cell instance $1097 m0 *1 1.38,62.56
X$1097 88 541 589 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1098 m0 *1 2.76,62.56
X$1098 88 578 563 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1100 m0 *1 5.06,62.56
X$1100 88 630 590 556 641 88 50 599 50 sky130_fd_sc_hd__o31ai_1
* cell instance $1101 m0 *1 7.82,62.56
X$1101 88 599 600 619 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1106 m0 *1 17.94,62.56
X$1106 88 601 659 602 88 50 549 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1108 m0 *1 22.54,62.56
X$1108 50 803 525 543 591 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1109 m0 *1 27.14,62.56
X$1109 88 591 88 50 586 50 sky130_fd_sc_hd__inv_1
* cell instance $1114 m0 *1 30.82,62.56
X$1114 88 592 566 653 50 88 50 sky130_fd_sc_hd__nand2b_1
* cell instance $1116 m0 *1 33.58,62.56
X$1116 88 579 592 550 50 88 606 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1117 m0 *1 35.42,62.56
X$1117 50 588 579 604 605 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1120 m0 *1 44.16,62.56
X$1120 50 506 551 603 88 626 88 50 sky130_fd_sc_hd__mux2i_2
* cell instance $1121 m0 *1 49.22,62.56
X$1121 88 593 625 654 50 88 567 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1122 m0 *1 51.06,62.56
X$1122 88 593 625 594 50 88 577 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1124 m0 *1 53.82,62.56
X$1124 88 518 595 568 88 50 623 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1128 m0 *1 58.42,62.56
X$1128 50 622 667 595 568 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1129 m0 *1 63.02,62.56
X$1129 88 570 537 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1130 m0 *1 64.4,62.56
X$1130 50 540 618 621 598 620 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $1131 m0 *1 71.76,62.56
X$1131 88 596 671 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1132 m0 *1 73.14,62.56
X$1132 88 689 585 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1134 m0 *1 75.44,62.56
X$1134 88 581 617 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1135 r0 *1 1.38,62.56
X$1135 88 562 534 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1136 r0 *1 2.76,62.56
X$1136 88 548 564 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1137 r0 *1 4.14,62.56
X$1137 88 584 532 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1138 r0 *1 5.52,62.56
X$1138 88 590 556 640 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1139 r0 *1 6.9,62.56
X$1139 88 608 630 590 643 88 50 50 sky130_fd_sc_hd__or3_1
* cell instance $1140 r0 *1 9.2,62.56
X$1140 50 600 608 645 711 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1146 r0 *1 17.48,62.56
X$1146 88 601 602 673 88 50 565 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1150 r0 *1 28.06,62.56
X$1150 88 609 632 679 633 651 50 88 50 sky130_fd_sc_hd__o22a_1
* cell instance $1151 r0 *1 31.28,62.56
X$1151 88 682 634 653 50 88 632 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1152 r0 *1 33.12,62.56
X$1152 88 579 88 50 634 50 sky130_fd_sc_hd__inv_1
* cell instance $1153 r0 *1 34.5,62.56
X$1153 88 604 605 525 88 610 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $1154 r0 *1 36.34,62.56
X$1154 88 605 604 592 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $1160 r0 *1 43.7,62.56
X$1160 50 655 552 612 611 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1161 r0 *1 48.3,62.56
X$1161 88 612 611 593 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1164 r0 *1 51.06,62.56
X$1164 88 656 88 50 625 50 sky130_fd_sc_hd__inv_1
* cell instance $1165 r0 *1 52.44,62.56
X$1165 88 613 635 636 88 654 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $1166 r0 *1 54.28,62.56
X$1166 88 614 624 623 50 88 635 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1167 r0 *1 56.12,62.56
X$1167 88 613 652 636 88 594 50 50 sky130_fd_sc_hd__o21ai_0
* cell instance $1169 r0 *1 58.42,62.56
X$1169 88 650 622 615 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1170 r0 *1 61.64,62.56
X$1170 88 597 466 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1171 r0 *1 63.02,62.56
X$1171 88 637 649 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1173 r0 *1 64.86,62.56
X$1173 88 648 580 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1175 r0 *1 67.16,62.56
X$1175 88 647 621 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1176 r0 *1 68.54,62.56
X$1176 88 582 620 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1180 r0 *1 70.84,62.56
X$1180 88 646 696 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1181 r0 *1 72.22,62.56
X$1181 88 618 88 50 642 50 sky130_fd_sc_hd__inv_1
* cell instance $1182 r0 *1 73.6,62.56
X$1182 88 642 670 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1184 r0 *1 75.44,62.56
X$1184 88 617 555 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1192 m0 *1 1.84,68
X$1192 50 690 630 658 629 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1193 m0 *1 6.44,68
X$1193 88 658 629 630 641 88 50 50 sky130_fd_sc_hd__or3_1
* cell instance $1194 m0 *1 8.74,68
X$1194 88 556 643 691 608 644 50 88 50 sky130_fd_sc_hd__o22ai_1
* cell instance $1195 m0 *1 11.04,68
X$1195 88 657 645 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1198 m0 *1 15.18,68
X$1198 50 693 659 673 456 88 88 50 sky130_fd_sc_hd__mux2i_1
* cell instance $1199 m0 *1 18.86,68
X$1199 88 674 631 681 673 88 50 50 sky130_fd_sc_hd__o21ba_1
* cell instance $1200 m0 *1 22.54,68
X$1200 50 675 660 631 456 88 88 50 sky130_fd_sc_hd__mux2i_1
* cell instance $1201 m0 *1 26.22,68
X$1201 88 661 651 660 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1202 m0 *1 27.6,68
X$1202 88 661 662 631 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1204 m0 *1 29.44,68
X$1204 88 609 663 679 633 662 50 88 50 sky130_fd_sc_hd__o22a_1
* cell instance $1205 m0 *1 32.66,68
X$1205 88 682 634 610 50 88 663 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1209 m0 *1 40.94,68
X$1209 88 678 677 665 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $1212 m0 *1 44.62,68
X$1212 88 665 664 547 88 50 50 sky130_fd_sc_hd__nand2_1
* cell instance $1216 m0 *1 49.22,68
X$1216 88 724 655 701 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1217 m0 *1 52.44,68
X$1217 88 667 88 50 624 50 sky130_fd_sc_hd__inv_1
* cell instance $1218 m0 *1 53.82,68
X$1218 88 676 637 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1219 m0 *1 55.2,68
X$1219 88 686 721 614 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1221 m0 *1 57.04,68
X$1221 88 614 624 587 50 88 652 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1222 m0 *1 58.88,68
X$1222 88 624 650 666 88 687 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $1223 m0 *1 61.64,68
X$1223 88 595 568 666 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1224 m0 *1 63.02,68
X$1224 88 668 699 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1225 m0 *1 64.4,68
X$1225 88 734 697 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1226 m0 *1 65.78,68
X$1226 50 718 736 671 672 585 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $1227 m0 *1 73.14,68
X$1227 88 670 616 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1229 m0 *1 75.44,68
X$1229 88 714 669 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1230 r0 *1 1.38,68
X$1230 88 640 690 705 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1231 r0 *1 4.6,68
X$1231 88 627 629 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1232 r0 *1 5.98,68
X$1232 88 628 711 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1233 r0 *1 7.36,68
X$1233 88 619 607 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1235 r0 *1 9.2,68
X$1235 88 641 711 645 88 691 50 50 sky130_fd_sc_hd__o21a_1
* cell instance $1236 r0 *1 11.96,68
X$1236 88 693 692 88 713 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1241 r0 *1 15.64,68
X$1241 50 692 601 715 712 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1242 r0 *1 20.24,68
X$1242 88 674 681 660 659 88 50 50 sky130_fd_sc_hd__o21ba_1
* cell instance $1243 r0 *1 23.92,68
X$1243 88 695 716 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1245 r0 *1 25.76,68
X$1245 50 732 661 633 679 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1246 r0 *1 30.36,68
X$1246 88 609 682 606 88 50 748 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1248 r0 *1 33.58,68
X$1248 88 698 501 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1249 r0 *1 34.96,68
X$1249 88 707 700 723 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1250 r0 *1 38.18,68
X$1250 50 700 683 677 678 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1255 r0 *1 43.24,68
X$1255 88 683 684 665 50 88 505 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1256 r0 *1 45.08,68
X$1256 88 684 664 626 50 88 707 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1257 r0 *1 46.92,68
X$1257 88 626 746 88 725 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1258 r0 *1 50.14,68
X$1258 88 685 702 88 726 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1259 r0 *1 53.36,68
X$1259 88 656 636 685 50 88 724 50 sky130_fd_sc_hd__a21oi_1
* cell instance $1260 r0 *1 55.2,68
X$1260 88 613 614 687 88 50 685 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1261 r0 *1 57.96,68
X$1261 88 687 722 720 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1263 r0 *1 61.64,68
X$1263 88 699 88 50 719 50 sky130_fd_sc_hd__inv_1
* cell instance $1264 r0 *1 63.02,68
X$1264 50 598 709 697 718 688 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $1269 r0 *1 70.84,68
X$1269 88 696 88 50 717 50 sky130_fd_sc_hd__inv_1
* cell instance $1270 r0 *1 72.22,68
X$1270 88 694 738 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1271 r0 *1 73.6,68
X$1271 88 638 688 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1273 r0 *1 75.44,68
X$1273 88 709 88 50 710 50 sky130_fd_sc_hd__inv_1
* cell instance $1274 m0 *1 1.38,73.44
X$1274 88 705 680 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1275 m0 *1 2.76,73.44
X$1275 88 703 658 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1276 m0 *1 4.14,73.44
X$1276 50 737 765 739 728 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1277 m0 *1 8.74,73.44
X$1277 88 644 737 798 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1278 m0 *1 11.96,73.44
X$1278 88 675 740 88 741 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1279 m0 *1 15.18,73.44
X$1279 50 740 674 730 729 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1280 m0 *1 19.78,73.44
X$1280 88 715 712 602 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1283 m0 *1 22.54,73.44
X$1283 88 730 729 681 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1285 m0 *1 24.38,73.44
X$1285 88 742 543 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1287 m0 *1 26.22,73.44
X$1287 88 743 526 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1288 m0 *1 27.6,73.44
X$1288 88 731 633 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1290 m0 *1 29.44,73.44
X$1290 88 748 732 88 747 50 50 sky130_fd_sc_hd__xor2_1
* cell instance $1291 m0 *1 32.66,73.44
X$1291 50 767 609 706 755 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1292 m0 *1 37.26,73.44
X$1292 88 752 768 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1294 m0 *1 39.56,73.44
X$1294 88 786 706 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1295 m0 *1 40.94,73.44
X$1295 88 751 604 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1296 m0 *1 42.32,73.44
X$1296 50 746 684 749 750 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1297 m0 *1 46.92,73.44
X$1297 88 750 749 664 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $1298 m0 *1 49.22,73.44
X$1298 50 702 656 744 745 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1299 m0 *1 53.82,73.44
X$1299 88 745 744 636 50 88 50 sky130_fd_sc_hd__or2_0
* cell instance $1302 m0 *1 57.04,73.44
X$1302 88 733 544 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1304 m0 *1 59.34,73.44
X$1304 50 722 613 686 721 88 88 50 sky130_fd_sc_hd__ha_1
* cell instance $1305 m0 *1 63.94,73.44
X$1305 50 766 676 719 717 708 88 88 50 sky130_fd_sc_hd__fa_1
* cell instance $1306 m0 *1 71.3,73.44
X$1306 88 738 88 50 708 50 sky130_fd_sc_hd__inv_1
* cell instance $1307 m0 *1 72.68,73.44
X$1307 88 736 88 50 735 50 sky130_fd_sc_hd__inv_1
* cell instance $1308 m0 *1 74.06,73.44
X$1308 88 735 764 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1309 m0 *1 75.44,73.44
X$1309 88 710 714 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1310 r0 *1 1.38,73.44
X$1310 88 727 728 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1311 r0 *1 2.76,73.44
X$1311 88 769 704 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1312 r0 *1 4.14,73.44
X$1312 88 753 739 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1313 r0 *1 5.52,73.44
X$1313 88 739 728 754 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1314 r0 *1 6.9,73.44
X$1314 88 765 644 754 88 50 769 50 sky130_fd_sc_hd__o21bai_1
* cell instance $1315 r0 *1 9.66,73.44
X$1315 88 798 770 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1318 r0 *1 13.8,73.44
X$1318 88 713 774 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1321 r0 *1 15.64,73.44
X$1321 88 741 772 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1322 r0 *1 17.02,73.44
X$1322 88 771 729 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1323 r0 *1 18.4,73.44
X$1323 88 773 712 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1324 r0 *1 19.78,73.44
X$1324 88 775 715 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1326 r0 *1 21.62,73.44
X$1326 88 776 730 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1327 r0 *1 23,73.44
X$1327 88 777 591 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1329 r0 *1 25.3,73.44
X$1329 88 747 779 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1331 r0 *1 27.6,73.44
X$1331 88 778 679 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1333 r0 *1 29.44,73.44
X$1333 88 606 767 785 88 50 50 sky130_fd_sc_hd__xnor2_1
* cell instance $1334 r0 *1 32.66,73.44
X$1334 88 706 755 682 50 88 50 sky130_fd_sc_hd__nor2_1
* cell instance $1335 r0 *1 34.04,73.44
X$1335 88 546 780 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1336 r0 *1 35.42,73.44
X$1336 88 723 781 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1337 r0 *1 36.8,73.44
X$1337 88 782 605 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1338 r0 *1 38.18,73.44
X$1338 88 783 755 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1339 r0 *1 39.56,73.44
X$1339 88 785 784 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1340 r0 *1 40.94,73.44
X$1340 88 756 678 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1344 r0 *1 43.24,73.44
X$1344 88 757 677 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1345 r0 *1 44.62,73.44
X$1345 88 787 750 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1346 r0 *1 46,73.44
X$1346 88 758 611 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1347 r0 *1 47.38,73.44
X$1347 88 759 749 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1348 r0 *1 48.76,73.44
X$1348 88 789 612 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1349 r0 *1 50.14,73.44
X$1349 88 725 790 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1350 r0 *1 51.52,73.44
X$1350 88 726 761 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1351 r0 *1 52.9,73.44
X$1351 88 799 791 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1352 r0 *1 54.28,73.44
X$1352 88 760 745 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1355 r0 *1 57.04,73.44
X$1355 88 762 744 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1356 r0 *1 58.42,73.44
X$1356 88 701 788 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1357 r0 *1 59.8,73.44
X$1357 88 792 536 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1358 r0 *1 61.18,73.44
X$1358 88 720 763 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1359 r0 *1 62.56,73.44
X$1359 88 794 686 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1360 r0 *1 63.94,73.44
X$1360 88 793 721 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1361 r0 *1 65.32,73.44
X$1361 88 615 797 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1362 r0 *1 66.7,73.44
X$1362 88 795 568 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1363 r0 *1 68.08,73.44
X$1363 88 796 595 50 88 50 sky130_fd_sc_hd__clkbuf_1
* cell instance $1367 r0 *1 70.84,73.44
X$1367 88 766 88 50 672 50 sky130_fd_sc_hd__inv_1
* cell instance $1369 r0 *1 74.06,73.44
X$1369 88 764 639 50 88 50 sky130_fd_sc_hd__clkbuf_1
.ENDS configurable_carry_select_adder

* cell sky130_fd_sc_hd__o41ai_4
* pin VGND
* pin B1
* pin A4
* pin A3
* pin A1
* pin Y
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o41ai_4 1 2 3 4 5 7 8 9 13 14
* net 1 VGND
* net 2 B1
* net 3 A4
* net 4 A3
* net 5 A1
* net 7 Y
* net 8 A2
* net 9 VPWR
* net 13 VPB
* device instance $1 r0 *1 6.55,1.985 pfet_01v8_hvt
M$1 11 8 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 8.23,1.985 pfet_01v8_hvt
M$5 9 5 12 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=685000000000P PS=5080000U PD=6370000U
* device instance $9 r0 *1 0.47,1.985 pfet_01v8_hvt
M$9 7 2 9 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $13 r0 *1 2.67,1.985 pfet_01v8_hvt
M$13 7 3 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $17 r0 *1 4.35,1.985 pfet_01v8_hvt
M$17 11 4 10 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $21 r0 *1 6.55,0.56 nfet_01v8
M$21 1 8 6 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 8.23,0.56 nfet_01v8
M$25 1 5 6 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=445250000000P
+ PS=3680000U PD=4620000U
* device instance $29 r0 *1 0.47,0.56 nfet_01v8
M$29 7 2 6 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
* device instance $33 r0 *1 2.67,0.56 nfet_01v8
M$33 1 3 6 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 4.35,0.56 nfet_01v8
M$37 1 4 6 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o41ai_4

* cell sky130_fd_sc_hd__o211ai_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin C1
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 C1
* net 7 Y
* net 8 VPWR
* net 9 VGND
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=105000000000P PS=2530000U PD=1210000U
* device instance $2 r0 *1 0.835,1.985 pfet_01v8_hvt
M$2 7 3 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=195000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 8 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $4 r0 *1 1.915,1.985 pfet_01v8_hvt
M$4 7 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=635000000000P PS=1390000U PD=3270000U
* device instance $5 r0 *1 0.475,0.56 nfet_01v8
M$5 9 2 6 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=126750000000P
+ PS=1830000U PD=1040000U
* device instance $6 r0 *1 1.015,0.56 nfet_01v8
M$6 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $7 r0 *1 1.555,0.56 nfet_01v8
M$7 12 4 6 10 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=68250000000P
+ PS=1040000U PD=860000U
* device instance $8 r0 *1 1.915,0.56 nfet_01v8
M$8 7 5 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=393250000000P
+ PS=860000U PD=2510000U
.ENDS sky130_fd_sc_hd__o211ai_1

* cell sky130_fd_sc_hd__o2bb2ai_1
* pin VPB
* pin A1_N
* pin A2_N
* pin B2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 1 2 3 4 5 6 8 10 11
* net 1 VPB
* net 2 A1_N
* net 3 A2_N
* net 4 B2
* net 5 B1
* net 6 VPWR
* net 8 Y
* net 10 VGND
* device instance $1 r0 *1 0.485,1.985 pfet_01v8_hvt
M$1 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=275000000000P
+ AD=135000000000P PS=2550000U PD=1270000U
* device instance $2 r0 *1 0.905,1.985 pfet_01v8_hvt
M$2 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=420000000000P PS=1270000U PD=1840000U
* device instance $3 r0 *1 1.895,1.985 pfet_01v8_hvt
M$3 8 7 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=420000000000P
+ AD=135000000000P PS=1840000U PD=1270000U
* device instance $4 r0 *1 2.315,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 2.735,1.985 pfet_01v8_hvt
M$5 6 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=275000000000P PS=1270000U PD=2550000U
* device instance $6 r0 *1 1.895,0.56 nfet_01v8
M$6 9 7 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.315,0.56 nfet_01v8
M$7 10 4 9 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 2.735,0.56 nfet_01v8
M$8 9 5 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.485,0.56 nfet_01v8
M$9 13 2 10 11 nfet_01v8 L=150000U W=650000U AS=178750000000P AD=68250000000P
+ PS=1850000U PD=860000U
* device instance $10 r0 *1 0.845,0.56 nfet_01v8
M$10 7 3 13 11 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=240500000000P
+ PS=860000U PD=2040000U
.ENDS sky130_fd_sc_hd__o2bb2ai_1

* cell sky130_fd_sc_hd__o211ai_2
* pin VGND
* pin Y
* pin A1
* pin C1
* pin B1
* pin A2
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o211ai_2 1 3 5 6 7 8 9 11 12
* net 1 VGND
* net 3 Y
* net 5 A1
* net 6 C1
* net 7 B1
* net 8 A2
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.775,1.985 pfet_01v8_hvt
M$1 3 8 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.635,1.985 pfet_01v8_hvt
M$3 9 5 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.495,1.985 pfet_01v8_hvt
M$5 3 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.355,1.985 pfet_01v8_hvt
M$7 3 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.775,0.56 nfet_01v8
M$9 4 8 1 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $11 r0 *1 3.635,0.56 nfet_01v8
M$11 4 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
* device instance $13 r0 *1 0.495,0.56 nfet_01v8
M$13 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=276250000000P AD=182000000000P
+ PS=2800000U PD=1860000U
* device instance $15 r0 *1 1.355,0.56 nfet_01v8
M$15 4 7 2 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=276250000000P
+ PS=1860000U PD=2800000U
.ENDS sky130_fd_sc_hd__o211ai_2

* cell sky130_fd_sc_hd__nor4b_1
* pin VPB
* pin C
* pin B
* pin A
* pin D_N
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4b_1 1 2 3 4 5 6 7 8 10
* net 1 VPB
* net 2 C
* net 3 B
* net 4 A
* net 5 D_N
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 2.535,1.89 pfet_01v8_hvt
M$1 9 5 8 1 pfet_01v8_hvt L=150000U W=420000U AS=145750000000P AD=109200000000P
+ PS=1335000U PD=1360000U
* device instance $2 r0 *1 0.73,1.985 pfet_01v8_hvt
M$2 13 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=520000000000P
+ AD=135000000000P PS=3040000U PD=1270000U
* device instance $3 r0 *1 1.15,1.985 pfet_01v8_hvt
M$3 12 2 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.63,1.985 pfet_01v8_hvt
M$4 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=135000000000P PS=1330000U PD=1270000U
* device instance $5 r0 *1 2.05,1.985 pfet_01v8_hvt
M$5 8 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=145750000000P PS=1270000U PD=1335000U
* device instance $6 r0 *1 0.73,0.56 nfet_01v8
M$6 7 9 6 10 nfet_01v8 L=150000U W=650000U AS=182000000000P AD=87750000000P
+ PS=1860000U PD=920000U
* device instance $7 r0 *1 1.15,0.56 nfet_01v8
M$7 6 2 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.63,0.56 nfet_01v8
M$8 7 3 6 10 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $9 r0 *1 2.05,0.56 nfet_01v8
M$9 6 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=100250000000P
+ PS=920000U PD=985000U
* device instance $10 r0 *1 2.535,0.675 nfet_01v8
M$10 9 5 6 10 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__nor4b_1

* cell sky130_fd_sc_hd__o41a_1
* pin VGND
* pin X
* pin B1
* pin A4
* pin A3
* pin A2
* pin A1
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o41a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 B1
* net 6 A4
* net 7 A3
* net 8 A2
* net 9 A1
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 0.8,1.985 pfet_01v8_hvt
M$1 11 3 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=425000000000P
+ AD=135000000000P PS=2850000U PD=1270000U
* device instance $2 r0 *1 1.22,1.985 pfet_01v8_hvt
M$2 3 5 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=1520000U
* device instance $3 r0 *1 1.89,1.985 pfet_01v8_hvt
M$3 12 6 3 10 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=220000000000P PS=1520000U PD=1440000U
* device instance $4 r0 *1 2.48,1.985 pfet_01v8_hvt
M$4 13 7 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=220000000000P
+ AD=195000000000P PS=1440000U PD=1390000U
* device instance $5 r0 *1 3.02,1.985 pfet_01v8_hvt
M$5 14 8 13 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $6 r0 *1 3.56,1.985 pfet_01v8_hvt
M$6 11 9 14 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=280000000000P PS=1390000U PD=2560000U
* device instance $7 r0 *1 1.53,0.56 nfet_01v8
M$7 4 5 3 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.95,0.56 nfet_01v8
M$8 1 6 4 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=123500000000P
+ PS=920000U PD=1030000U
* device instance $9 r0 *1 2.48,0.56 nfet_01v8
M$9 4 7 1 15 nfet_01v8 L=150000U W=650000U AS=123500000000P AD=126750000000P
+ PS=1030000U PD=1040000U
* device instance $10 r0 *1 3.02,0.56 nfet_01v8
M$10 1 8 4 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 3.56,0.56 nfet_01v8
M$11 4 9 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=195000000000P
+ PS=1040000U PD=1900000U
* device instance $12 r0 *1 0.59,0.56 nfet_01v8
M$12 1 3 2 15 nfet_01v8 L=150000U W=650000U AS=247000000000P AD=169000000000P
+ PS=2060000U PD=1820000U
.ENDS sky130_fd_sc_hd__o41a_1

* cell sky130_fd_sc_hd__o21a_2
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__o21a_2 1 3 4 5 6 7 8 10
* net 1 VPB
* net 3 B1
* net 4 A2
* net 5 A1
* net 6 VGND
* net 7 VPWR
* net 8 X
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 2 7 1 pfet_01v8_hvt L=150000U W=2000000U AS=397500000000P
+ AD=537500000000P PS=3795000U PD=3075000U
* device instance $3 r0 *1 1.845,1.985 pfet_01v8_hvt
M$3 2 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=400000000000P
+ AD=140000000000P PS=1800000U PD=1280000U
* device instance $4 r0 *1 2.275,1.985 pfet_01v8_hvt
M$4 11 4 2 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=160000000000P PS=1280000U PD=1320000U
* device instance $5 r0 *1 2.745,1.985 pfet_01v8_hvt
M$5 7 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=265000000000P PS=1320000U PD=2530000U
* device instance $6 r0 *1 1.845,0.56 nfet_01v8
M$6 9 3 2 10 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $7 r0 *1 2.275,0.56 nfet_01v8
M$7 6 4 9 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=104000000000P
+ PS=930000U PD=970000U
* device instance $8 r0 *1 2.745,0.56 nfet_01v8
M$8 9 5 6 10 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=172250000000P
+ PS=970000U PD=1830000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 8 2 6 10 nfet_01v8 L=150000U W=1300000U AS=258375000000P AD=261625000000P
+ PS=2745000U PD=2755000U
.ENDS sky130_fd_sc_hd__o21a_2

* cell sky130_fd_sc_hd__o21bai_2
* pin VGND
* pin Y
* pin B1_N
* pin A2
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_2 1 4 5 6 7 8 10 11
* net 1 VGND
* net 4 Y
* net 5 B1_N
* net 6 A2
* net 7 A1
* net 8 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.475,1.695 pfet_01v8_hvt
M$1 8 5 2 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=145750000000P PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.96,1.985 pfet_01v8_hvt
M$2 4 2 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280750000000P
+ AD=395000000000P PS=2605000U PD=3790000U
* device instance $4 r0 *1 2.32,1.985 pfet_01v8_hvt
M$4 4 6 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $6 r0 *1 3.16,1.985 pfet_01v8_hvt
M$6 8 7 9 10 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $8 r0 *1 1.48,0.56 nfet_01v8
M$8 4 2 3 11 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $10 r0 *1 2.32,0.56 nfet_01v8
M$10 1 6 3 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $12 r0 *1 3.16,0.56 nfet_01v8
M$12 1 7 3 11 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
* device instance $14 r0 *1 0.475,0.675 nfet_01v8
M$14 2 5 1 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_2

* cell sky130_fd_sc_hd__a211oi_1
* pin VPB
* pin A2
* pin A1
* pin C1
* pin B1
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A2
* net 3 A1
* net 4 C1
* net 5 B1
* net 6 VGND
* net 7 Y
* net 9 VPWR
* device instance $1 r0 *1 0.62,1.985 pfet_01v8_hvt
M$1 9 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.05,1.985 pfet_01v8_hvt
M$2 8 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 1.48,1.985 pfet_01v8_hvt
M$3 11 5 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 1.94,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.62,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=266500000000P AD=91000000000P
+ PS=2120000U PD=930000U
* device instance $6 r0 *1 1.05,0.56 nfet_01v8
M$6 7 3 12 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $7 r0 *1 1.48,0.56 nfet_01v8
M$7 6 5 7 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $8 r0 *1 1.94,0.56 nfet_01v8
M$8 7 4 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211oi_1

* cell sky130_fd_sc_hd__o2111ai_4
* pin VGND
* pin D1
* pin A2
* pin Y
* pin C1
* pin B1
* pin A1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o2111ai_4 1 2 3 4 6 9 10 11 13 14
* net 1 VGND
* net 2 D1
* net 3 A2
* net 4 Y
* net 6 C1
* net 9 B1
* net 10 A1
* net 11 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=540000000000P PS=6330000U PD=5080000U
* device instance $5 r0 *1 2.15,1.985 pfet_01v8_hvt
M$5 11 6 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=642500000000P PS=5080000U PD=5285000U
* device instance $9 r0 *1 4.035,1.985 pfet_01v8_hvt
M$9 11 9 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=642500000000P
+ AD=552500000000P PS=5285000U PD=5105000U
* device instance $13 r0 *1 5.74,1.985 pfet_01v8_hvt
M$13 12 3 4 13 pfet_01v8_hvt L=150000U W=4000000U AS=552500000000P
+ AD=658350000000P PS=5105000U PD=6330000U
* device instance $17 r0 *1 7.93,1.985 pfet_01v8_hvt
M$17 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=657850000000P
+ AD=665000000000P PS=6330000U PD=6330000U
* device instance $21 r0 *1 4.35,0.56 nfet_01v8
M$21 7 9 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=359125000000P
+ PS=4580000U PD=3705000U
* device instance $25 r0 *1 6.055,0.56 nfet_01v8
M$25 1 3 8 14 nfet_01v8 L=150000U W=2600000U AS=365625000000P AD=365625000000P
+ PS=3725000U PD=3725000U
* device instance $29 r0 *1 7.78,0.56 nfet_01v8
M$29 1 10 8 14 nfet_01v8 L=150000U W=2600000U AS=359125000000P AD=448500000000P
+ PS=3705000U PD=4630000U
* device instance $33 r0 *1 0.47,0.56 nfet_01v8
M$33 4 2 5 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $37 r0 *1 2.15,0.56 nfet_01v8
M$37 7 6 5 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o2111ai_4

* cell sky130_fd_sc_hd__nand2_2
* pin VGND
* pin
* pin B
* pin Y
* pin A
* pin VPB
* pin VPWR
.SUBCKT sky130_fd_sc_hd__nand2_2 1 2 4 5 6 7 8
* net 1 VGND
* net 4 B
* net 5 Y
* net 6 A
* net 7 VPB
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 5 6 8 7 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 1 4 3 2 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 5 6 3 2 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand2_2

* cell sky130_fd_sc_hd__o32a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B2
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o32a_1 1 2 5 6 7 8 9 10 11 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B2
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.64,1.985 pfet_01v8_hvt
M$1 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=335000000000P
+ AD=135000000000P PS=2670000U PD=1270000U
* device instance $2 r0 *1 1.06,1.985 pfet_01v8_hvt
M$2 13 5 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.54,1.985 pfet_01v8_hvt
M$3 12 6 13 11 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=195000000000P PS=1330000U PD=1390000U
* device instance $4 r0 *1 2.08,1.985 pfet_01v8_hvt
M$4 4 7 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=195000000000P PS=1390000U PD=1390000U
* device instance $5 r0 *1 2.62,1.985 pfet_01v8_hvt
M$5 14 8 4 11 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=205000000000P PS=1390000U PD=1410000U
* device instance $6 r0 *1 3.18,1.985 pfet_01v8_hvt
M$6 10 9 14 11 pfet_01v8_hvt L=150000U W=1000000U AS=205000000000P
+ AD=290000000000P PS=1410000U PD=2580000U
* device instance $7 r0 *1 0.64,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 1.06,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 1.54,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=126750000000P
+ PS=980000U PD=1040000U
* device instance $10 r0 *1 2.08,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=126750000000P
+ PS=1040000U PD=1040000U
* device instance $11 r0 *1 2.62,0.56 nfet_01v8
M$11 4 8 3 15 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=133250000000P
+ PS=1040000U PD=1060000U
* device instance $12 r0 *1 3.18,0.56 nfet_01v8
M$12 3 9 4 15 nfet_01v8 L=150000U W=650000U AS=133250000000P AD=188500000000P
+ PS=1060000U PD=1880000U
.ENDS sky130_fd_sc_hd__o32a_1

* cell sky130_fd_sc_hd__o31ai_2
* pin VGND
* pin A1
* pin A2
* pin A3
* pin Y
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_2 1 3 4 5 6 7 9 11 12
* net 1 VGND
* net 3 A1
* net 4 A2
* net 5 A3
* net 6 Y
* net 7 B1
* net 9 VPWR
* net 11 VPB
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 10 5 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $3 r0 *1 3.55,1.985 pfet_01v8_hvt
M$3 9 7 6 11 pfet_01v8_hvt L=150000U W=2000000U AS=330000000000P
+ AD=455000000000P PS=2660000U PD=3910000U
* device instance $5 r0 *1 0.49,1.985 pfet_01v8_hvt
M$5 9 3 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=270000000000P PS=3830000U PD=2540000U
* device instance $7 r0 *1 1.33,1.985 pfet_01v8_hvt
M$7 10 4 8 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $9 r0 *1 0.49,0.56 nfet_01v8
M$9 1 3 2 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 1.33,0.56 nfet_01v8
M$11 1 4 2 12 nfet_01v8 L=150000U W=1300000U AS=286000000000P AD=325000000000P
+ PS=2180000U PD=2300000U
* device instance $13 r0 *1 2.63,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=240500000000P AD=201500000000P
+ PS=2040000U PD=1920000U
* device instance $15 r0 *1 3.55,0.56 nfet_01v8
M$15 6 7 2 12 nfet_01v8 L=150000U W=1300000U AS=214500000000P AD=295750000000P
+ PS=1960000U PD=2860000U
.ENDS sky130_fd_sc_hd__o31ai_2

* cell sky130_fd_sc_hd__o31a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31a_1 1 2 5 6 7 8 9 10 13
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.65,1.985 pfet_01v8_hvt
M$1 9 4 2 10 pfet_01v8_hvt L=150000U W=1000000U AS=360000000000P
+ AD=195000000000P PS=2720000U PD=1390000U
* device instance $2 r0 *1 1.19,1.985 pfet_01v8_hvt
M$2 12 5 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=135000000000P PS=1390000U PD=1270000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 11 6 12 10 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 2.09,1.985 pfet_01v8_hvt
M$4 4 7 11 10 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=212500000000P PS=1330000U PD=1425000U
* device instance $5 r0 *1 2.665,1.985 pfet_01v8_hvt
M$5 9 8 4 10 pfet_01v8_hvt L=150000U W=1000000U AS=212500000000P
+ AD=345000000000P PS=1425000U PD=2690000U
* device instance $6 r0 *1 0.65,0.56 nfet_01v8
M$6 1 4 2 13 nfet_01v8 L=150000U W=650000U AS=234000000000P AD=126750000000P
+ PS=2020000U PD=1040000U
* device instance $7 r0 *1 1.19,0.56 nfet_01v8
M$7 3 5 1 13 nfet_01v8 L=150000U W=650000U AS=126750000000P AD=87750000000P
+ PS=1040000U PD=920000U
* device instance $8 r0 *1 1.61,0.56 nfet_01v8
M$8 1 6 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $9 r0 *1 2.09,0.56 nfet_01v8
M$9 3 7 1 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.57,0.56 nfet_01v8
M$10 4 8 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=201500000000P
+ PS=980000U PD=1920000U
.ENDS sky130_fd_sc_hd__o31a_1

* cell sky130_fd_sc_hd__o31ai_4
* pin VGND
* pin B1
* pin Y
* pin A1
* pin A2
* pin A3
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_4 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 B1
* net 4 Y
* net 5 A1
* net 6 A2
* net 7 A3
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 4.385,1.985 pfet_01v8_hvt
M$1 9 7 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=667800000000P
+ AD=540000000000P PS=6380000U PD=5080000U
* device instance $5 r0 *1 6.065,1.985 pfet_01v8_hvt
M$5 10 2 4 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665000000000P PS=5080000U PD=6330000U
* device instance $9 r0 *1 0.49,1.985 pfet_01v8_hvt
M$9 10 5 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=685000000000P
+ AD=540000000000P PS=6370000U PD=5080000U
* device instance $13 r0 *1 2.17,1.985 pfet_01v8_hvt
M$13 9 6 8 11 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=665500000000P PS=5080000U PD=6370000U
* device instance $17 r0 *1 0.49,0.56 nfet_01v8
M$17 1 5 3 12 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $21 r0 *1 2.17,0.56 nfet_01v8
M$21 1 6 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=351000000000P
+ PS=3680000U PD=3680000U
* device instance $25 r0 *1 3.85,0.56 nfet_01v8
M$25 1 7 3 12 nfet_01v8 L=150000U W=2600000U AS=524875000000P AD=524875000000P
+ PS=4215000U PD=4215000U
* device instance $29 r0 *1 6.065,0.56 nfet_01v8
M$29 4 2 3 12 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
.ENDS sky130_fd_sc_hd__o31ai_4

* cell sky130_fd_sc_hd__nand4_1
* pin VPB
* pin C
* pin A
* pin B
* pin D
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 C
* net 3 A
* net 4 B
* net 5 D
* net 6 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 5 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $4 r0 *1 1.79,1.985 pfet_01v8_hvt
M$4 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=300000000000P PS=1330000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 5 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 11 2 12 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 10 4 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $8 r0 *1 1.79,0.56 nfet_01v8
M$8 7 3 10 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=195000000000P
+ PS=980000U PD=1900000U
.ENDS sky130_fd_sc_hd__nand4_1

* cell sky130_fd_sc_hd__buf_6
* pin VGND
* pin A
* pin X
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__buf_6 1 2 4 5 6 7
* net 1 VGND
* net 2 A
* net 4 X
* net 5 VPWR
* net 6 VPB
* device instance $1 r0 *1 0.73,1.985 pfet_01v8_hvt
M$1 3 2 5 6 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.57,1.985 pfet_01v8_hvt
M$3 4 3 5 6 pfet_01v8_hvt L=150000U W=6000000U AS=810000000000P
+ AD=935000000000P PS=7620000U PD=8870000U
* device instance $9 r0 *1 0.73,0.56 nfet_01v8
M$9 3 2 1 7 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.57,0.56 nfet_01v8
M$11 4 3 1 7 nfet_01v8 L=150000U W=3900000U AS=526500000000P AD=607750000000P
+ PS=5520000U PD=6420000U
.ENDS sky130_fd_sc_hd__buf_6

* cell sky130_fd_sc_hd__a211oi_2
* pin VGND
* pin Y
* pin C1
* pin B1
* pin A1
* pin A2
* pin VPB
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__a211oi_2 1 2 4 5 6 7 10 11 12
* net 1 VGND
* net 2 Y
* net 4 C1
* net 5 B1
* net 6 A1
* net 7 A2
* net 10 VPB
* net 11 VPWR
* device instance $1 r0 *1 2.765,1.985 pfet_01v8_hvt
M$1 9 6 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $3 r0 *1 3.625,1.985 pfet_01v8_hvt
M$3 9 7 11 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $5 r0 *1 0.525,1.985 pfet_01v8_hvt
M$5 2 4 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=405000000000P
+ AD=280000000000P PS=3810000U PD=2560000U
* device instance $7 r0 *1 1.385,1.985 pfet_01v8_hvt
M$7 9 5 8 10 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=405000000000P PS=2560000U PD=3810000U
* device instance $9 r0 *1 2.765,0.56 nfet_01v8
M$9 2 6 3 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $11 r0 *1 3.625,0.56 nfet_01v8
M$11 1 7 3 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
* device instance $13 r0 *1 0.525,0.56 nfet_01v8
M$13 2 4 1 12 nfet_01v8 L=150000U W=1300000U AS=263250000000P AD=182000000000P
+ PS=2760000U PD=1860000U
* device instance $15 r0 *1 1.385,0.56 nfet_01v8
M$15 2 5 1 12 nfet_01v8 L=150000U W=1300000U AS=182000000000P AD=263250000000P
+ PS=1860000U PD=2760000U
.ENDS sky130_fd_sc_hd__a211oi_2

* cell sky130_fd_sc_hd__o311a_1
* pin VGND
* pin X
* pin A1
* pin A2
* pin A3
* pin B1
* pin C1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311a_1 1 2 5 6 7 8 9 11 12 15
* net 1 VGND
* net 2 X
* net 5 A1
* net 6 A2
* net 7 A3
* net 8 B1
* net 9 C1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.48,1.985 pfet_01v8_hvt
M$1 11 4 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=312500000000P PS=2520000U PD=1625000U
* device instance $2 r0 *1 1.255,1.985 pfet_01v8_hvt
M$2 14 5 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=312500000000P
+ AD=180000000000P PS=1625000U PD=1360000U
* device instance $3 r0 *1 1.765,1.985 pfet_01v8_hvt
M$3 13 6 14 12 pfet_01v8_hvt L=150000U W=1000000U AS=180000000000P
+ AD=210000000000P PS=1360000U PD=1420000U
* device instance $4 r0 *1 2.335,1.985 pfet_01v8_hvt
M$4 4 7 13 12 pfet_01v8_hvt L=150000U W=1000000U AS=210000000000P
+ AD=137500000000P PS=1420000U PD=1275000U
* device instance $5 r0 *1 2.76,1.985 pfet_01v8_hvt
M$5 11 8 4 12 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=150000000000P PS=1275000U PD=1300000U
* device instance $6 r0 *1 3.21,1.985 pfet_01v8_hvt
M$6 4 9 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=150000000000P
+ AD=260000000000P PS=1300000U PD=2520000U
* device instance $7 r0 *1 0.48,0.56 nfet_01v8
M$7 1 4 2 15 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=203125000000P
+ PS=1820000U PD=1275000U
* device instance $8 r0 *1 1.255,0.56 nfet_01v8
M$8 3 5 1 15 nfet_01v8 L=150000U W=650000U AS=203125000000P AD=117000000000P
+ PS=1275000U PD=1010000U
* device instance $9 r0 *1 1.765,0.56 nfet_01v8
M$9 1 6 3 15 nfet_01v8 L=150000U W=650000U AS=117000000000P AD=136500000000P
+ PS=1010000U PD=1070000U
* device instance $10 r0 *1 2.335,0.56 nfet_01v8
M$10 3 7 1 15 nfet_01v8 L=150000U W=650000U AS=136500000000P AD=118625000000P
+ PS=1070000U PD=1015000U
* device instance $11 r0 *1 2.85,0.56 nfet_01v8
M$11 10 8 3 15 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=68250000000P
+ PS=1015000U PD=860000U
* device instance $12 r0 *1 3.21,0.56 nfet_01v8
M$12 4 9 10 15 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=169000000000P
+ PS=860000U PD=1820000U
.ENDS sky130_fd_sc_hd__o311a_1

* cell sky130_fd_sc_hd__o22ai_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22ai_1 1 2 3 4 5 7 8 9 10
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 7 Y
* net 8 VGND
* net 9 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=112500000000P PS=2520000U PD=1225000U
* device instance $2 r0 *1 0.845,1.985 pfet_01v8_hvt
M$2 7 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=112500000000P
+ AD=232500000000P PS=1225000U PD=1465000U
* device instance $3 r0 *1 1.46,1.985 pfet_01v8_hvt
M$3 11 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=232500000000P
+ AD=105000000000P PS=1465000U PD=1210000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=270000000000P PS=1210000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=92625000000P
+ PS=1820000U PD=935000U
* device instance $6 r0 *1 0.905,0.56 nfet_01v8
M$6 6 3 7 10 nfet_01v8 L=150000U W=650000U AS=92625000000P AD=115375000000P
+ PS=935000U PD=1005000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 8 4 6 10 nfet_01v8 L=150000U W=650000U AS=115375000000P AD=87750000000P
+ PS=1005000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 5 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22ai_1

* cell sky130_fd_sc_hd__or3_1
* pin VPB
* pin A
* pin B
* pin C
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__or3_1 1 2 3 4 5 6 7 9
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.48,1.695 pfet_01v8_hvt
M$1 11 4 8 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 0.84,1.695 pfet_01v8_hvt
M$2 10 3 11 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $3 r0 *1 1.32,1.695 pfet_01v8_hvt
M$3 6 2 10 1 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P AD=148250000000P
+ PS=750000U PD=1340000U
* device instance $4 r0 *1 1.81,1.985 pfet_01v8_hvt
M$4 5 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=148250000000P
+ AD=280000000000P PS=1340000U PD=2560000U
* device instance $5 r0 *1 0.48,0.475 nfet_01v8
M$5 7 4 8 9 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $6 r0 *1 0.9,0.475 nfet_01v8
M$6 8 3 7 9 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $7 r0 *1 1.32,0.475 nfet_01v8
M$7 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=101875000000P AD=56700000000P
+ PS=990000U PD=690000U
* device instance $8 r0 *1 1.81,0.56 nfet_01v8
M$8 5 8 7 9 nfet_01v8 L=150000U W=650000U AS=101875000000P AD=182000000000P
+ PS=990000U PD=1860000U
.ENDS sky130_fd_sc_hd__or3_1

* cell sky130_fd_sc_hd__o31ai_1
* pin VPB
* pin A1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o31ai_1 1 2 3 4 5 6 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 B1
* net 6 VPWR
* net 7 VGND
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 12 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 11 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 9 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=392500000000P PS=1270000U PD=1785000U
* device instance $4 r0 *1 2.245,1.985 pfet_01v8_hvt
M$4 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=392500000000P
+ AD=300000000000P PS=1785000U PD=2600000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 8 2 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $6 r0 *1 0.89,0.56 nfet_01v8
M$6 7 3 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $7 r0 *1 1.31,0.56 nfet_01v8
M$7 8 4 7 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=198250000000P
+ PS=920000U PD=1260000U
* device instance $8 r0 *1 2.07,0.56 nfet_01v8
M$8 9 5 8 10 nfet_01v8 L=150000U W=650000U AS=198250000000P AD=221000000000P
+ PS=1260000U PD=1980000U
.ENDS sky130_fd_sc_hd__o31ai_1

* cell sky130_fd_sc_hd__o22a_1
* pin VPB
* pin B1
* pin B2
* pin A2
* pin A1
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__o22a_1 1 2 3 4 5 6 7 10 11
* net 1 VPB
* net 2 B1
* net 3 B2
* net 4 A2
* net 5 A1
* net 6 X
* net 7 VGND
* net 10 VPWR
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 10 8 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=372500000000P PS=2560000U PD=1745000U
* device instance $2 r0 *1 1.385,1.985 pfet_01v8_hvt
M$2 13 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=372500000000P
+ AD=117500000000P PS=1745000U PD=1235000U
* device instance $3 r0 *1 1.77,1.985 pfet_01v8_hvt
M$3 8 3 13 1 pfet_01v8_hvt L=150000U W=1000000U AS=117500000000P
+ AD=235000000000P PS=1235000U PD=1470000U
* device instance $4 r0 *1 2.39,1.985 pfet_01v8_hvt
M$4 12 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=235000000000P
+ AD=105000000000P PS=1470000U PD=1210000U
* device instance $5 r0 *1 2.75,1.985 pfet_01v8_hvt
M$5 10 5 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $6 r0 *1 1.41,0.56 nfet_01v8
M$6 8 2 9 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 1.83,0.56 nfet_01v8
M$7 9 3 8 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=113750000000P
+ PS=920000U PD=1000000U
* device instance $8 r0 *1 2.33,0.56 nfet_01v8
M$8 7 4 9 11 nfet_01v8 L=150000U W=650000U AS=113750000000P AD=87750000000P
+ PS=1000000U PD=920000U
* device instance $9 r0 *1 2.75,0.56 nfet_01v8
M$9 9 5 7 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $10 r0 *1 0.47,0.56 nfet_01v8
M$10 7 8 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o22a_1

* cell sky130_fd_sc_hd__nand2b_1
* pin VPB
* pin B
* pin A_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nand2b_1 1 2 4 5 6 7 8
* net 1 VPB
* net 2 B
* net 4 A_N
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.695 pfet_01v8_hvt
M$1 7 4 3 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=145750000000P
+ PS=1360000U PD=1335000U
* device instance $2 r0 *1 0.955,1.985 pfet_01v8_hvt
M$2 5 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=145750000000P
+ AD=135000000000P PS=1335000U PD=1270000U
* device instance $3 r0 *1 1.375,1.985 pfet_01v8_hvt
M$3 7 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=265000000000P PS=1270000U PD=2530000U
* device instance $4 r0 *1 0.47,0.675 nfet_01v8
M$4 3 4 6 8 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
* device instance $5 r0 *1 0.955,0.56 nfet_01v8
M$5 9 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.375,0.56 nfet_01v8
M$6 5 3 9 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2b_1

* cell sky130_fd_sc_hd__mux2i_1
* pin VGND
* pin Y
* pin A0
* pin A1
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_1 1 3 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 6 A0
* net 7 A1
* net 8 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.21,1.985 pfet_01v8_hvt
M$1 10 8 5 11 pfet_01v8_hvt L=150000U W=1000000U AS=290000000000P
+ AD=260000000000P PS=2580000U PD=2520000U
* device instance $2 r0 *1 0.49,1.985 pfet_01v8_hvt
M$2 3 6 9 11 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=152500000000P PS=2560000U PD=1305000U
* device instance $3 r0 *1 0.945,1.985 pfet_01v8_hvt
M$3 12 7 3 11 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=197500000000P PS=1305000U PD=1395000U
* device instance $4 r0 *1 1.49,1.985 pfet_01v8_hvt
M$4 10 5 12 11 pfet_01v8_hvt L=150000U W=1000000U AS=197500000000P
+ AD=300000000000P PS=1395000U PD=1600000U
* device instance $5 r0 *1 2.24,1.985 pfet_01v8_hvt
M$5 9 8 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=260000000000P PS=1600000U PD=2520000U
* device instance $6 r0 *1 3.21,0.56 nfet_01v8
M$6 1 8 5 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
* device instance $7 r0 *1 1.85,0.56 nfet_01v8
M$7 1 5 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $8 r0 *1 2.27,0.56 nfet_01v8
M$8 4 8 1 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 6 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $10 r0 *1 0.89,0.56 nfet_01v8
M$10 4 7 3 13 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=182000000000P
+ PS=920000U PD=1860000U
.ENDS sky130_fd_sc_hd__mux2i_1

* cell sky130_fd_sc_hd__a41oi_4
* pin VGND
* pin B1
* pin A1
* pin A2
* pin Y
* pin A3
* pin A4
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a41oi_4 1 2 3 4 5 9 10 12 13 14
* net 1 VGND
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 Y
* net 9 A3
* net 10 A4
* net 12 VPWR
* net 13 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 2 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=665000000000P
+ AD=695000000000P PS=6330000U PD=5390000U
* device instance $5 r0 *1 2.46,1.985 pfet_01v8_hvt
M$5 12 3 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=865000000000P
+ AD=757500000000P PS=5730000U PD=5515000U
* device instance $9 r0 *1 4.575,1.985 pfet_01v8_hvt
M$9 12 4 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=790000000000P
+ AD=752500000000P PS=5580000U PD=5505000U
* device instance $13 r0 *1 6.68,1.985 pfet_01v8_hvt
M$13 12 9 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=550000000000P
+ AD=540000000000P PS=5100000U PD=5080000U
* device instance $17 r0 *1 8.36,1.985 pfet_01v8_hvt
M$17 12 10 11 13 pfet_01v8_hvt L=150000U W=4000000U AS=540000000000P
+ AD=695000000000P PS=5080000U PD=6390000U
* device instance $21 r0 *1 6.68,0.56 nfet_01v8
M$21 7 9 8 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $25 r0 *1 8.36,0.56 nfet_01v8
M$25 1 10 8 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=451750000000P
+ PS=3680000U PD=4640000U
* device instance $29 r0 *1 2.8,0.56 nfet_01v8
M$29 5 3 6 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=351000000000P
+ PS=4580000U PD=3680000U
* device instance $33 r0 *1 4.48,0.56 nfet_01v8
M$33 7 4 6 14 nfet_01v8 L=150000U W=2600000U AS=351000000000P AD=432250000000P
+ PS=3680000U PD=4580000U
* device instance $37 r0 *1 0.47,0.56 nfet_01v8
M$37 5 2 1 14 nfet_01v8 L=150000U W=2600000U AS=432250000000P AD=432250000000P
+ PS=4580000U PD=4580000U
.ENDS sky130_fd_sc_hd__a41oi_4

* cell sky130_fd_sc_hd__a21oi_2
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_2 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 Y
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=415000000000P
+ AD=275000000000P PS=3830000U PD=2550000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 6 2 5 1 pfet_01v8_hvt L=150000U W=2000000U AS=280000000000P
+ AD=275000000000P PS=2560000U PD=2550000U
* device instance $5 r0 *1 2.19,1.985 pfet_01v8_hvt
M$5 7 3 6 1 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=495000000000P PS=2540000U PD=3990000U
* device instance $7 r0 *1 0.495,0.56 nfet_01v8
M$7 10 4 8 9 nfet_01v8 L=150000U W=650000U AS=185250000000P AD=89375000000P
+ PS=1870000U PD=925000U
* device instance $8 r0 *1 0.92,0.56 nfet_01v8
M$8 7 2 10 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $9 r0 *1 1.35,0.56 nfet_01v8
M$9 11 2 7 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=68250000000P
+ PS=930000U PD=860000U
* device instance $10 r0 *1 1.71,0.56 nfet_01v8
M$10 8 4 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=107250000000P
+ PS=860000U PD=980000U
* device instance $11 r0 *1 2.19,0.56 nfet_01v8
M$11 7 3 8 9 nfet_01v8 L=150000U W=1300000U AS=195000000000P AD=347750000000P
+ PS=1900000U PD=3020000U
.ENDS sky130_fd_sc_hd__a21oi_2

* cell sky130_fd_sc_hd__o21ba_1
* pin VPB
* pin B1_N
* pin A2
* pin A1
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ba_1 1 2 3 4 8 9 10 11
* net 1 VPB
* net 2 B1_N
* net 3 A2
* net 4 A1
* net 8 X
* net 9 VPWR
* net 10 VGND
* device instance $1 r0 *1 2.165,1.985 pfet_01v8_hvt
M$1 6 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=165000000000P PS=2600000U PD=1330000U
* device instance $2 r0 *1 2.645,1.985 pfet_01v8_hvt
M$2 12 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=105000000000P PS=1330000U PD=1210000U
* device instance $3 r0 *1 3.005,1.985 pfet_01v8_hvt
M$3 9 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=280000000000P PS=1210000U PD=2560000U
* device instance $4 r0 *1 1.035,1.695 pfet_01v8_hvt
M$4 5 2 9 1 pfet_01v8_hvt L=150000U W=420000U AS=185750000000P AD=117600000000P
+ PS=1415000U PD=1400000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 9 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=185750000000P PS=2520000U PD=1415000U
* device instance $6 r0 *1 2.165,0.56 nfet_01v8
M$6 7 5 6 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $7 r0 *1 2.645,0.56 nfet_01v8
M$7 10 3 7 11 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $8 r0 *1 3.065,0.56 nfet_01v8
M$8 7 4 10 11 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=172250000000P
+ PS=920000U PD=1830000U
* device instance $9 r0 *1 0.55,0.56 nfet_01v8
M$9 10 6 8 11 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100250000000P
+ PS=1820000U PD=985000U
* device instance $10 r0 *1 1.035,0.675 nfet_01v8
M$10 5 2 10 11 nfet_01v8 L=150000U W=420000U AS=100250000000P AD=109200000000P
+ PS=985000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21ba_1

* cell sky130_fd_sc_hd__clkbuf_2
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_2 1 2 3 4 6 7
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 6 X
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 3 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=162500000000P PS=2530000U PD=1325000U
* device instance $2 r0 *1 0.95,1.985 pfet_01v8_hvt
M$2 6 5 3 1 pfet_01v8_hvt L=150000U W=2000000U AS=297500000000P
+ AD=395000000000P PS=2595000U PD=3790000U
* device instance $4 r0 *1 0.475,0.445 nfet_01v8
M$4 4 2 5 7 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=68250000000P
+ PS=1370000U PD=745000U
* device instance $5 r0 *1 0.95,0.445 nfet_01v8
M$5 6 5 4 7 nfet_01v8 L=150000U W=840000U AS=124950000000P AD=165900000000P
+ PS=1435000U PD=2050000U
.ENDS sky130_fd_sc_hd__clkbuf_2

* cell sky130_fd_sc_hd__and2_0
* pin VPB
* pin A
* pin B
* pin X
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__and2_0 1 2 3 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 5 X
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.54,2.275 pfet_01v8_hvt
M$1 4 2 6 1 pfet_01v8_hvt L=150000U W=420000U AS=111300000000P AD=60900000000P
+ PS=1370000U PD=710000U
* device instance $2 r0 *1 0.98,2.275 pfet_01v8_hvt
M$2 4 3 6 1 pfet_01v8_hvt L=150000U W=420000U AS=184100000000P AD=60900000000P
+ PS=1260000U PD=710000U
* device instance $3 r0 *1 1.75,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=184100000000P AD=169600000000P
+ PS=1260000U PD=1810000U
* device instance $4 r0 *1 0.54,0.445 nfet_01v8
M$4 9 2 4 8 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=44100000000P
+ PS=1370000U PD=630000U
* device instance $5 r0 *1 0.9,0.445 nfet_01v8
M$5 7 3 9 8 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=96600000000P
+ PS=630000U PD=880000U
* device instance $6 r0 *1 1.51,0.445 nfet_01v8
M$6 5 4 7 8 nfet_01v8 L=150000U W=420000U AS=96600000000P AD=111300000000P
+ PS=880000U PD=1370000U
.ENDS sky130_fd_sc_hd__and2_0

* cell sky130_fd_sc_hd__a31oi_1
* pin VPB
* pin A3
* pin A2
* pin A1
* pin B1
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a31oi_1 1 2 3 4 5 6 8 9 10
* net 1 VPB
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 B1
* net 6 VGND
* net 8 VPWR
* net 9 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 7 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 8 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=152500000000P PS=1270000U PD=1305000U
* device instance $3 r0 *1 1.345,1.985 pfet_01v8_hvt
M$3 7 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=162500000000P PS=1305000U PD=1325000U
* device instance $4 r0 *1 1.82,1.985 pfet_01v8_hvt
M$4 9 5 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=162500000000P
+ AD=270000000000P PS=1325000U PD=2540000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 12 2 6 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $6 r0 *1 0.83,0.56 nfet_01v8
M$6 11 3 12 10 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=118625000000P
+ PS=860000U PD=1015000U
* device instance $7 r0 *1 1.345,0.56 nfet_01v8
M$7 9 4 11 10 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=105625000000P
+ PS=1015000U PD=975000U
* device instance $8 r0 *1 1.82,0.56 nfet_01v8
M$8 6 5 9 10 nfet_01v8 L=150000U W=650000U AS=105625000000P AD=175500000000P
+ PS=975000U PD=1840000U
.ENDS sky130_fd_sc_hd__a31oi_1

* cell sky130_fd_sc_hd__nand4_2
* pin VGND
* pin D
* pin C
* pin B
* pin A
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand4_2 1 5 6 7 8 9 10 11 12
* net 1 VGND
* net 5 D
* net 6 C
* net 7 B
* net 8 A
* net 9 VPWR
* net 10 Y
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 5 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 10 6 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=350000000000P PS=2540000U PD=2700000U
* device instance $5 r0 *1 2.31,1.985 pfet_01v8_hvt
M$5 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=350000000000P
+ AD=470000000000P PS=2700000U PD=2940000U
* device instance $7 r0 *1 3.55,1.985 pfet_01v8_hvt
M$7 10 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=470000000000P
+ AD=555000000000P PS=2940000U PD=4110000U
* device instance $9 r0 *1 2.71,0.56 nfet_01v8
M$9 3 7 4 12 nfet_01v8 L=150000U W=1300000U AS=269750000000P AD=175500000000P
+ PS=2780000U PD=1840000U
* device instance $11 r0 *1 3.55,0.56 nfet_01v8
M$11 10 8 4 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=321750000000P
+ PS=1840000U PD=2940000U
* device instance $13 r0 *1 0.47,0.56 nfet_01v8
M$13 1 5 2 12 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $15 r0 *1 1.31,0.56 nfet_01v8
M$15 3 6 2 12 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__nand4_2

* cell sky130_fd_sc_hd__nor2b_1
* pin VPB
* pin A
* pin B_N
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2b_1 1 2 3 4 6 7 8
* net 1 VPB
* net 2 A
* net 3 B_N
* net 4 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.71,1.695 pfet_01v8_hvt
M$1 7 3 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=157300000000P
+ PS=1360000U PD=1390000U
* device instance $2 r0 *1 1.25,1.985 pfet_01v8_hvt
M$2 9 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=157300000000P
+ AD=105000000000P PS=1390000U PD=1210000U
* device instance $3 r0 *1 1.61,1.985 pfet_01v8_hvt
M$3 4 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $4 r0 *1 0.705,0.445 nfet_01v8
M$4 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=100250000000P
+ PS=1360000U PD=985000U
* device instance $5 r0 *1 1.19,0.56 nfet_01v8
M$5 4 2 6 8 nfet_01v8 L=150000U W=650000U AS=100250000000P AD=87750000000P
+ PS=985000U PD=920000U
* device instance $6 r0 *1 1.61,0.56 nfet_01v8
M$6 6 5 4 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2b_1

* cell sky130_fd_sc_hd__nand3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 5 4 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 6 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=165000000000P PS=1270000U PD=1330000U
* device instance $3 r0 *1 1.37,1.985 pfet_01v8_hvt
M$3 5 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=260000000000P PS=1330000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 10 4 7 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 9 3 10 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=107250000000P
+ PS=920000U PD=980000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 5 2 9 8 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=169000000000P
+ PS=980000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand3_1

* cell sky130_fd_sc_hd__mux2i_2
* pin VGND
* pin S
* pin A0
* pin A1
* pin VPWR
* pin Y
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2i_2 1 2 6 7 8 11 12 13
* net 1 VGND
* net 2 S
* net 6 A0
* net 7 A1
* net 8 VPWR
* net 11 Y
* net 12 VPB
* device instance $1 r0 *1 3.09,1.985 pfet_01v8_hvt
M$1 9 6 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=290000000000P PS=3790000U PD=2580000U
* device instance $3 r0 *1 3.97,1.985 pfet_01v8_hvt
M$3 10 7 11 12 pfet_01v8_hvt L=150000U W=2000000U AS=292500000000P
+ AD=592500000000P PS=2585000U PD=4185000U
* device instance $5 r0 *1 0.47,1.985 pfet_01v8_hvt
M$5 8 2 3 12 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $6 r0 *1 0.89,1.985 pfet_01v8_hvt
M$6 9 2 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $8 r0 *1 1.73,1.985 pfet_01v8_hvt
M$8 10 3 8 12 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $10 r0 *1 3.09,0.56 nfet_01v8
M$10 5 6 11 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=188500000000P
+ PS=2740000U PD=1880000U
* device instance $12 r0 *1 3.97,0.56 nfet_01v8
M$12 4 7 11 13 nfet_01v8 L=150000U W=1300000U AS=190125000000P AD=385125000000P
+ PS=1885000U PD=3135000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 2 3 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $15 r0 *1 0.89,0.56 nfet_01v8
M$15 4 2 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $17 r0 *1 1.73,0.56 nfet_01v8
M$17 5 3 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__mux2i_2

* cell sky130_fd_sc_hd__nand2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__nand2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VPWR
* net 6 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 4 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.91,1.985 pfet_01v8_hvt
M$2 5 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $3 r0 *1 0.49,0.56 nfet_01v8
M$3 8 3 6 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.91,0.56 nfet_01v8
M$4 4 2 8 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nand2_1

* cell sky130_fd_sc_hd__o21a_1
* pin VPB
* pin B1
* pin A2
* pin A1
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21a_1 1 2 3 4 5 7 8 10
* net 1 VPB
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 5 9 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=280000000000P
+ AD=327500000000P PS=2560000U PD=1655000U
* device instance $2 r0 *1 1.295,1.985 pfet_01v8_hvt
M$2 9 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=327500000000P
+ AD=195000000000P PS=1655000U PD=1390000U
* device instance $3 r0 *1 1.835,1.985 pfet_01v8_hvt
M$3 11 3 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=195000000000P
+ AD=152500000000P PS=1390000U PD=1305000U
* device instance $4 r0 *1 2.29,1.985 pfet_01v8_hvt
M$4 5 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=260000000000P PS=1305000U PD=2520000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 2 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 3 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.56 nfet_01v8
M$8 8 9 7 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21a_1

* cell sky130_fd_sc_hd__o21ai_1
* pin VPB
* pin A1
* pin B1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 A1
* net 3 B1
* net 4 A2
* net 5 VPWR
* net 7 VGND
* net 8 Y
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 8 4 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=174000000000P PS=1210000U PD=1390000U
* device instance $3 r0 *1 1.37,2.135 pfet_01v8_hvt
M$3 5 3 8 1 pfet_01v8_hvt L=150000U W=700000U AS=174000000000P AD=182000000000P
+ PS=1390000U PD=1920000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=107250000000P
+ PS=1820000U PD=980000U
* device instance $5 r0 *1 0.95,0.56 nfet_01v8
M$5 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=87750000000P
+ PS=980000U PD=920000U
* device instance $6 r0 *1 1.37,0.56 nfet_01v8
M$6 8 3 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__o21ai_1

* cell sky130_fd_sc_hd__xor2_1
* pin VPB
* pin B
* pin A
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xor2_1 1 2 3 6 7 8 9
* net 1 VPB
* net 2 B
* net 3 A
* net 6 VPWR
* net 7 X
* net 8 VGND
* device instance $1 r0 *1 2.71,1.985 pfet_01v8_hvt
M$1 7 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=300000000000P PS=2520000U PD=2600000U
* device instance $2 r0 *1 0.51,1.985 pfet_01v8_hvt
M$2 10 2 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $3 r0 *1 0.93,1.985 pfet_01v8_hvt
M$3 6 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $4 r0 *1 1.35,1.985 pfet_01v8_hvt
M$4 5 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $5 r0 *1 1.77,1.985 pfet_01v8_hvt
M$5 6 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $6 r0 *1 0.51,0.56 nfet_01v8
M$6 4 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 0.93,0.56 nfet_01v8
M$7 8 3 4 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $8 r0 *1 1.35,0.56 nfet_01v8
M$8 11 3 8 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $9 r0 *1 1.77,0.56 nfet_01v8
M$9 7 2 11 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=250250000000P
+ PS=920000U PD=1420000U
* device instance $10 r0 *1 2.69,0.56 nfet_01v8
M$10 8 4 7 9 nfet_01v8 L=150000U W=650000U AS=250250000000P AD=208000000000P
+ PS=1420000U PD=1940000U
.ENDS sky130_fd_sc_hd__xor2_1

* cell sky130_fd_sc_hd__a21o_1
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VGND
* pin VPWR
* pin X
* pin
.SUBCKT sky130_fd_sc_hd__a21o_1 1 2 3 4 5 7 9 10
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VGND
* net 7 VPWR
* net 9 X
* device instance $1 r0 *1 1.42,1.985 pfet_01v8_hvt
M$1 6 4 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=137500000000P PS=2520000U PD=1275000U
* device instance $2 r0 *1 1.845,1.985 pfet_01v8_hvt
M$2 7 2 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=137500000000P
+ AD=140000000000P PS=1275000U PD=1280000U
* device instance $3 r0 *1 2.275,1.985 pfet_01v8_hvt
M$3 6 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=265000000000P PS=1280000U PD=2530000U
* device instance $4 r0 *1 0.48,1.985 pfet_01v8_hvt
M$4 7 8 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $5 r0 *1 0.48,0.56 nfet_01v8
M$5 5 8 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=256750000000P
+ PS=1820000U PD=1440000U
* device instance $6 r0 *1 1.42,0.56 nfet_01v8
M$6 8 4 5 10 nfet_01v8 L=150000U W=650000U AS=256750000000P AD=89375000000P
+ PS=1440000U PD=925000U
* device instance $7 r0 *1 1.845,0.56 nfet_01v8
M$7 11 2 8 10 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=91000000000P
+ PS=925000U PD=930000U
* device instance $8 r0 *1 2.275,0.56 nfet_01v8
M$8 5 3 11 10 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=172250000000P
+ PS=930000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21o_1

* cell sky130_fd_sc_hd__dlymetal6s2s_1
* pin VGND
* pin X
* pin A
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 1 3 8 9 10 11
* net 1 VGND
* net 3 X
* net 8 A
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 3.655,2.275 pfet_01v8_hvt
M$1 6 5 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $2 r0 *1 4.13,1.985 pfet_01v8_hvt
M$2 7 6 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $3 r0 *1 2.24,2.275 pfet_01v8_hvt
M$3 4 3 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $4 r0 *1 2.715,1.985 pfet_01v8_hvt
M$4 5 4 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $5 r0 *1 0.645,2.275 pfet_01v8_hvt
M$5 2 8 9 10 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=109200000000P PS=1325000U PD=1360000U
* device instance $6 r0 *1 1.12,1.985 pfet_01v8_hvt
M$6 3 2 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $7 r0 *1 3.655,0.445 nfet_01v8
M$7 1 5 6 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $8 r0 *1 4.13,0.56 nfet_01v8
M$8 7 6 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $9 r0 *1 0.645,0.445 nfet_01v8
M$9 1 8 2 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $10 r0 *1 1.12,0.56 nfet_01v8
M$10 3 2 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 2.24,0.445 nfet_01v8
M$11 1 3 4 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=97000000000P
+ PS=1360000U PD=975000U
* device instance $12 r0 *1 2.715,0.56 nfet_01v8
M$12 5 4 1 11 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
.ENDS sky130_fd_sc_hd__dlymetal6s2s_1

* cell sky130_fd_sc_hd__clkbuf_1
* pin VPB
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__clkbuf_1 1 3 4 5 6 7
* net 1 VPB
* net 3 A
* net 4 X
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,2.09 pfet_01v8_hvt
M$1 6 2 4 1 pfet_01v8_hvt L=150000U W=790000U AS=205400000000P AD=114550000000P
+ PS=2100000U PD=1080000U
* device instance $2 r0 *1 0.91,2.09 pfet_01v8_hvt
M$2 2 3 6 1 pfet_01v8_hvt L=150000U W=790000U AS=114550000000P AD=205400000000P
+ PS=1080000U PD=2100000U
* device instance $3 r0 *1 0.47,0.495 nfet_01v8
M$3 5 2 4 7 nfet_01v8 L=150000U W=520000U AS=135200000000P AD=75400000000P
+ PS=1560000U PD=810000U
* device instance $4 r0 *1 0.91,0.495 nfet_01v8
M$4 2 3 5 7 nfet_01v8 L=150000U W=520000U AS=75400000000P AD=135200000000P
+ PS=810000U PD=1560000U
.ENDS sky130_fd_sc_hd__clkbuf_1

* cell sky130_fd_sc_hd__ha_1
* pin VGND
* pin SUM
* pin COUT
* pin A
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__ha_1 1 2 5 8 9 10 11 13
* net 1 VGND
* net 2 SUM
* net 5 COUT
* net 8 A
* net 9 B
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 3 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=236050000000P PS=2520000U PD=1765000U
* device instance $2 r0 *1 1.385,2.275 pfet_01v8_hvt
M$2 3 7 10 11 pfet_01v8_hvt L=150000U W=420000U AS=236050000000P
+ AD=56700000000P PS=1765000U PD=690000U
* device instance $3 r0 *1 1.805,2.275 pfet_01v8_hvt
M$3 12 9 3 11 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=84000000000P
+ PS=690000U PD=820000U
* device instance $4 r0 *1 2.355,2.275 pfet_01v8_hvt
M$4 10 8 12 11 pfet_01v8_hvt L=150000U W=420000U AS=84000000000P
+ AD=149100000000P PS=820000U PD=1130000U
* device instance $5 r0 *1 3.215,2.275 pfet_01v8_hvt
M$5 7 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=149100000000P
+ AD=60900000000P PS=1130000U PD=710000U
* device instance $6 r0 *1 3.655,2.275 pfet_01v8_hvt
M$6 7 8 10 11 pfet_01v8_hvt L=150000U W=420000U AS=140750000000P
+ AD=60900000000P PS=1325000U PD=710000U
* device instance $7 r0 *1 4.13,1.985 pfet_01v8_hvt
M$7 5 7 10 11 pfet_01v8_hvt L=150000U W=1000000U AS=140750000000P
+ AD=260000000000P PS=1325000U PD=2520000U
* device instance $8 r0 *1 3.295,0.445 nfet_01v8
M$8 6 9 7 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $9 r0 *1 3.655,0.445 nfet_01v8
M$9 1 8 6 13 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=97000000000P
+ PS=630000U PD=975000U
* device instance $10 r0 *1 4.13,0.56 nfet_01v8
M$10 5 7 1 13 nfet_01v8 L=150000U W=650000U AS=97000000000P AD=169000000000P
+ PS=975000U PD=1820000U
* device instance $11 r0 *1 1.41,0.445 nfet_01v8
M$11 4 7 3 13 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $12 r0 *1 1.83,0.445 nfet_01v8
M$12 1 9 4 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $13 r0 *1 2.25,0.445 nfet_01v8
M$13 4 8 1 13 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $14 r0 *1 0.47,0.56 nfet_01v8
M$14 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__ha_1

* cell sky130_fd_sc_hd__fa_1
* pin VGND
* pin COUT
* pin SUM
* pin A
* pin CIN
* pin B
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__fa_1 1 2 7 11 12 13 16 17 21
* net 1 VGND
* net 2 COUT
* net 7 SUM
* net 11 A
* net 12 CIN
* net 13 B
* net 16 VPWR
* net 17 VPB
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 16 3 2 17 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=147850000000P PS=2520000U PD=1345000U
* device instance $2 r0 *1 0.965,2.275 pfet_01v8_hvt
M$2 18 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=63000000000P PS=1345000U PD=720000U
* device instance $3 r0 *1 1.415,2.275 pfet_01v8_hvt
M$3 3 13 18 17 pfet_01v8_hvt L=150000U W=420000U AS=63000000000P
+ AD=56700000000P PS=720000U PD=690000U
* device instance $4 r0 *1 1.835,2.275 pfet_01v8_hvt
M$4 14 12 3 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $5 r0 *1 2.255,2.275 pfet_01v8_hvt
M$5 16 11 14 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $6 r0 *1 2.675,2.275 pfet_01v8_hvt
M$6 14 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=109200000000P PS=690000U PD=1360000U
* device instance $7 r0 *1 3.615,2.275 pfet_01v8_hvt
M$7 15 13 16 17 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P
+ AD=56700000000P PS=1360000U PD=690000U
* device instance $8 r0 *1 4.035,2.275 pfet_01v8_hvt
M$8 16 12 15 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=56700000000P PS=690000U PD=690000U
* device instance $9 r0 *1 4.455,2.275 pfet_01v8_hvt
M$9 15 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P
+ AD=61950000000P PS=690000U PD=715000U
* device instance $10 r0 *1 4.9,2.275 pfet_01v8_hvt
M$10 6 3 15 17 pfet_01v8_hvt L=150000U W=420000U AS=61950000000P
+ AD=69300000000P PS=715000U PD=750000U
* device instance $11 r0 *1 5.38,2.275 pfet_01v8_hvt
M$11 19 12 6 17 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=44100000000P PS=750000U PD=630000U
* device instance $12 r0 *1 5.74,2.275 pfet_01v8_hvt
M$12 20 13 19 17 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $13 r0 *1 6.22,2.275 pfet_01v8_hvt
M$13 20 11 16 17 pfet_01v8_hvt L=150000U W=420000U AS=147850000000P
+ AD=69300000000P PS=1345000U PD=750000U
* device instance $14 r0 *1 6.715,1.985 pfet_01v8_hvt
M$14 7 6 16 17 pfet_01v8_hvt L=150000U W=1000000U AS=147850000000P
+ AD=260000000000P PS=1345000U PD=2520000U
* device instance $15 r0 *1 0.965,0.445 nfet_01v8
M$15 8 11 1 21 nfet_01v8 L=150000U W=420000U AS=102350000000P AD=63000000000P
+ PS=995000U PD=720000U
* device instance $16 r0 *1 1.415,0.445 nfet_01v8
M$16 3 13 8 21 nfet_01v8 L=150000U W=420000U AS=63000000000P AD=56700000000P
+ PS=720000U PD=690000U
* device instance $17 r0 *1 1.835,0.445 nfet_01v8
M$17 4 12 3 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $18 r0 *1 2.255,0.445 nfet_01v8
M$18 1 11 4 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $19 r0 *1 2.675,0.445 nfet_01v8
M$19 4 13 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=109200000000P
+ PS=690000U PD=1360000U
* device instance $20 r0 *1 0.47,0.56 nfet_01v8
M$20 1 3 2 21 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=102350000000P
+ PS=1820000U PD=995000U
* device instance $21 r0 *1 3.615,0.445 nfet_01v8
M$21 5 13 1 21 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $22 r0 *1 4.035,0.445 nfet_01v8
M$22 1 12 5 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $23 r0 *1 4.455,0.445 nfet_01v8
M$23 5 11 1 21 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=61950000000P
+ PS=690000U PD=715000U
* device instance $24 r0 *1 4.9,0.445 nfet_01v8
M$24 6 3 5 21 nfet_01v8 L=150000U W=420000U AS=61950000000P AD=69300000000P
+ PS=715000U PD=750000U
* device instance $25 r0 *1 5.38,0.445 nfet_01v8
M$25 10 12 6 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=44100000000P
+ PS=750000U PD=630000U
* device instance $26 r0 *1 5.74,0.445 nfet_01v8
M$26 9 13 10 21 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=69300000000P
+ PS=630000U PD=750000U
* device instance $27 r0 *1 6.22,0.445 nfet_01v8
M$27 1 11 9 21 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=102350000000P
+ PS=750000U PD=995000U
* device instance $28 r0 *1 6.715,0.56 nfet_01v8
M$28 7 6 1 21 nfet_01v8 L=150000U W=650000U AS=102350000000P AD=169000000000P
+ PS=995000U PD=1820000U
.ENDS sky130_fd_sc_hd__fa_1

* cell sky130_fd_sc_hd__mux2_1
* pin VGND
* pin X
* pin A1
* pin A0
* pin S
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__mux2_1 1 2 3 5 9 10 11 14
* net 1 VGND
* net 2 X
* net 3 A1
* net 5 A0
* net 9 S
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 1.015,2.08 pfet_01v8_hvt
M$1 12 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=158350000000P
+ AD=76650000000P PS=1395000U PD=785000U
* device instance $2 r0 *1 1.53,2.08 pfet_01v8_hvt
M$2 4 5 12 11 pfet_01v8_hvt L=150000U W=420000U AS=76650000000P
+ AD=193200000000P PS=785000U PD=1340000U
* device instance $3 r0 *1 2.6,2.08 pfet_01v8_hvt
M$3 13 3 4 11 pfet_01v8_hvt L=150000U W=420000U AS=193200000000P
+ AD=44100000000P PS=1340000U PD=630000U
* device instance $4 r0 *1 2.96,2.08 pfet_01v8_hvt
M$4 10 6 13 11 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P
+ AD=69300000000P PS=630000U PD=750000U
* device instance $5 r0 *1 3.44,2.08 pfet_01v8_hvt
M$5 6 9 10 11 pfet_01v8_hvt L=150000U W=420000U AS=69300000000P
+ AD=117600000000P PS=750000U PD=1400000U
* device instance $6 r0 *1 0.47,1.985 pfet_01v8_hvt
M$6 10 4 2 11 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=158350000000P PS=2520000U PD=1395000U
* device instance $7 r0 *1 1.015,0.445 nfet_01v8
M$7 7 9 1 14 nfet_01v8 L=150000U W=420000U AS=112850000000P AD=69300000000P
+ PS=1045000U PD=750000U
* device instance $8 r0 *1 1.495,0.445 nfet_01v8
M$8 4 3 7 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=99750000000P
+ PS=750000U PD=895000U
* device instance $9 r0 *1 2.12,0.445 nfet_01v8
M$9 8 5 4 14 nfet_01v8 L=150000U W=420000U AS=99750000000P AD=69300000000P
+ PS=895000U PD=750000U
* device instance $10 r0 *1 2.6,0.445 nfet_01v8
M$10 1 6 8 14 nfet_01v8 L=150000U W=420000U AS=69300000000P AD=144900000000P
+ PS=750000U PD=1110000U
* device instance $11 r0 *1 3.44,0.445 nfet_01v8
M$11 6 9 1 14 nfet_01v8 L=150000U W=420000U AS=144900000000P AD=109200000000P
+ PS=1110000U PD=1360000U
* device instance $12 r0 *1 0.47,0.56 nfet_01v8
M$12 1 4 2 14 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=112850000000P
+ PS=1820000U PD=1045000U
.ENDS sky130_fd_sc_hd__mux2_1

* cell sky130_fd_sc_hd__xnor2_1
* pin VPB
* pin B
* pin A
* pin Y
* pin VPWR
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__xnor2_1 1 2 3 4 5 7 9
* net 1 VPB
* net 2 B
* net 3 A
* net 4 Y
* net 5 VPWR
* net 7 VGND
* device instance $1 r0 *1 0.51,1.985 pfet_01v8_hvt
M$1 8 2 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=300000000000P
+ AD=135000000000P PS=2600000U PD=1270000U
* device instance $2 r0 *1 0.93,1.985 pfet_01v8_hvt
M$2 5 3 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=365000000000P PS=1270000U PD=1730000U
* device instance $3 r0 *1 1.81,1.985 pfet_01v8_hvt
M$3 10 3 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=365000000000P
+ AD=105000000000P PS=1730000U PD=1210000U
* device instance $4 r0 *1 2.17,1.985 pfet_01v8_hvt
M$4 4 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=165000000000P PS=1210000U PD=1330000U
* device instance $5 r0 *1 2.65,1.985 pfet_01v8_hvt
M$5 5 8 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=360000000000P PS=1330000U PD=2720000U
* device instance $6 r0 *1 2.29,0.56 nfet_01v8
M$6 6 2 7 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $7 r0 *1 2.71,0.56 nfet_01v8
M$7 4 8 6 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=195000000000P
+ PS=920000U PD=1900000U
* device instance $8 r0 *1 0.57,0.56 nfet_01v8
M$8 11 2 8 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=68250000000P
+ PS=1820000U PD=860000U
* device instance $9 r0 *1 0.93,0.56 nfet_01v8
M$9 7 3 11 9 nfet_01v8 L=150000U W=650000U AS=68250000000P AD=87750000000P
+ PS=860000U PD=920000U
* device instance $10 r0 *1 1.35,0.56 nfet_01v8
M$10 6 3 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__xnor2_1

* cell sky130_fd_sc_hd__and3_1
* pin VGND
* pin B
* pin X
* pin A
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__and3_1 1 2 3 6 7 9 10 11
* net 1 VGND
* net 2 B
* net 3 X
* net 6 A
* net 7 C
* net 9 VPWR
* net 10 VPB
* device instance $1 r0 *1 0.47,1.71 pfet_01v8_hvt
M$1 9 6 8 10 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $2 r0 *1 0.89,1.71 pfet_01v8_hvt
M$2 8 2 9 10 pfet_01v8_hvt L=150000U W=420000U AS=56700000000P AD=66150000000P
+ PS=690000U PD=735000U
* device instance $3 r0 *1 1.355,1.71 pfet_01v8_hvt
M$3 8 7 9 10 pfet_01v8_hvt L=150000U W=420000U AS=142225000000P AD=66150000000P
+ PS=1335000U PD=735000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 3 8 9 10 pfet_01v8_hvt L=150000U W=1000000U AS=142225000000P
+ AD=260000000000P PS=1335000U PD=2520000U
* device instance $5 r0 *1 0.47,0.445 nfet_01v8
M$5 5 6 8 11 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $6 r0 *1 0.83,0.445 nfet_01v8
M$6 4 2 5 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=44100000000P
+ PS=630000U PD=630000U
* device instance $7 r0 *1 1.19,0.445 nfet_01v8
M$7 1 7 4 11 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=131650000000P
+ PS=630000U PD=1140000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 3 8 1 11 nfet_01v8 L=150000U W=650000U AS=131650000000P AD=169000000000P
+ PS=1140000U PD=1820000U
.ENDS sky130_fd_sc_hd__and3_1

* cell sky130_fd_sc_hd__nand3_2
* pin VGND
* pin Y
* pin A
* pin B
* pin C
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__nand3_2 1 3 5 6 7 8 9 10
* net 1 VGND
* net 3 Y
* net 5 A
* net 6 B
* net 7 C
* net 8 VPWR
* net 9 VPB
* device instance $1 r0 *1 2.67,1.985 pfet_01v8_hvt
M$1 3 7 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=445000000000P PS=3790000U PD=3890000U
* device instance $3 r0 *1 0.47,1.985 pfet_01v8_hvt
M$3 3 5 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $5 r0 *1 1.31,1.985 pfet_01v8_hvt
M$5 3 6 8 9 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $7 r0 *1 2.67,0.56 nfet_01v8
M$7 4 7 1 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=289250000000P
+ PS=2740000U PD=2840000U
* device instance $9 r0 *1 0.47,0.56 nfet_01v8
M$9 3 5 2 10 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $11 r0 *1 1.31,0.56 nfet_01v8
M$11 4 6 2 10 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=256750000000P
+ PS=1840000U PD=2740000U
.ENDS sky130_fd_sc_hd__nand3_2

* cell sky130_fd_sc_hd__a211o_1
* pin VPB
* pin B1
* pin C1
* pin A1
* pin A2
* pin VPWR
* pin X
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__a211o_1 1 2 3 4 5 7 8 9 11
* net 1 VPB
* net 2 B1
* net 3 C1
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 X
* net 9 VGND
* device instance $1 r0 *1 1.425,1.985 pfet_01v8_hvt
M$1 7 5 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 1.855,1.985 pfet_01v8_hvt
M$2 10 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=140000000000P PS=1280000U PD=1280000U
* device instance $3 r0 *1 2.285,1.985 pfet_01v8_hvt
M$3 12 2 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=155000000000P PS=1280000U PD=1310000U
* device instance $4 r0 *1 2.745,1.985 pfet_01v8_hvt
M$4 6 3 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=155000000000P
+ AD=265000000000P PS=1310000U PD=2530000U
* device instance $5 r0 *1 0.475,1.985 pfet_01v8_hvt
M$5 7 6 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=265000000000P PS=2530000U PD=2530000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 9 6 8 11 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=260000000000P
+ PS=1830000U PD=1450000U
* device instance $7 r0 *1 1.425,0.56 nfet_01v8
M$7 13 5 9 11 nfet_01v8 L=150000U W=650000U AS=260000000000P AD=91000000000P
+ PS=1450000U PD=930000U
* device instance $8 r0 *1 1.855,0.56 nfet_01v8
M$8 6 4 13 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=91000000000P
+ PS=930000U PD=930000U
* device instance $9 r0 *1 2.285,0.56 nfet_01v8
M$9 9 2 6 11 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=100750000000P
+ PS=930000U PD=960000U
* device instance $10 r0 *1 2.745,0.56 nfet_01v8
M$10 6 3 9 11 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=172250000000P
+ PS=960000U PD=1830000U
.ENDS sky130_fd_sc_hd__a211o_1

* cell sky130_fd_sc_hd__a31o_1
* pin VGND
* pin X
* pin A3
* pin A2
* pin A1
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a31o_1 1 2 6 7 8 9 11 12 13
* net 1 VGND
* net 2 X
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 B1
* net 11 VPWR
* net 12 VPB
* device instance $1 r0 *1 0.475,1.985 pfet_01v8_hvt
M$1 11 3 2 12 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=172500000000P PS=2530000U PD=1345000U
* device instance $2 r0 *1 0.97,1.985 pfet_01v8_hvt
M$2 10 6 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=172500000000P
+ AD=160000000000P PS=1345000U PD=1320000U
* device instance $3 r0 *1 1.44,1.985 pfet_01v8_hvt
M$3 11 7 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=160000000000P
+ AD=165000000000P PS=1320000U PD=1330000U
* device instance $4 r0 *1 1.92,1.985 pfet_01v8_hvt
M$4 10 8 11 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=165000000000P PS=1330000U PD=1330000U
* device instance $5 r0 *1 2.4,1.985 pfet_01v8_hvt
M$5 3 9 10 12 pfet_01v8_hvt L=150000U W=1000000U AS=165000000000P
+ AD=320000000000P PS=1330000U PD=2640000U
* device instance $6 r0 *1 0.475,0.56 nfet_01v8
M$6 1 3 2 13 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=112125000000P
+ PS=1830000U PD=995000U
* device instance $7 r0 *1 0.97,0.56 nfet_01v8
M$7 4 6 1 13 nfet_01v8 L=150000U W=650000U AS=112125000000P AD=104000000000P
+ PS=995000U PD=970000U
* device instance $8 r0 *1 1.44,0.56 nfet_01v8
M$8 5 7 4 13 nfet_01v8 L=150000U W=650000U AS=104000000000P AD=107250000000P
+ PS=970000U PD=980000U
* device instance $9 r0 *1 1.92,0.56 nfet_01v8
M$9 3 8 5 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=107250000000P
+ PS=980000U PD=980000U
* device instance $10 r0 *1 2.4,0.56 nfet_01v8
M$10 1 9 3 13 nfet_01v8 L=150000U W=650000U AS=107250000000P AD=208000000000P
+ PS=980000U PD=1940000U
.ENDS sky130_fd_sc_hd__a31o_1

* cell sky130_fd_sc_hd__a2bb2oi_2
* pin VGND
* pin Y
* pin B1
* pin B2
* pin A1_N
* pin A2_N
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__a2bb2oi_2 1 3 5 6 7 8 10 11 13
* net 1 VGND
* net 3 Y
* net 5 B1
* net 6 B2
* net 7 A1_N
* net 8 A2_N
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 3.645,1.985 pfet_01v8_hvt
M$1 10 7 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $3 r0 *1 4.485,1.985 pfet_01v8_hvt
M$3 4 8 9 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=415000000000P PS=2540000U PD=3830000U
* device instance $5 r0 *1 0.605,1.985 pfet_01v8_hvt
M$5 10 5 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=395000000000P
+ AD=270000000000P PS=3790000U PD=2540000U
* device instance $6 r0 *1 1.025,1.985 pfet_01v8_hvt
M$6 12 6 10 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=270000000000P PS=2540000U PD=2540000U
* device instance $9 r0 *1 2.285,1.985 pfet_01v8_hvt
M$9 3 4 12 11 pfet_01v8_hvt L=150000U W=2000000U AS=270000000000P
+ AD=395000000000P PS=2540000U PD=3790000U
* device instance $11 r0 *1 0.605,0.56 nfet_01v8
M$11 2 5 1 13 nfet_01v8 L=150000U W=1300000U AS=256750000000P AD=175500000000P
+ PS=2740000U PD=1840000U
* device instance $12 r0 *1 1.025,0.56 nfet_01v8
M$12 3 6 2 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=175500000000P
+ PS=1840000U PD=1840000U
* device instance $15 r0 *1 2.285,0.56 nfet_01v8
M$15 3 4 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=344500000000P
+ PS=1840000U PD=2360000U
* device instance $17 r0 *1 3.645,0.56 nfet_01v8
M$17 4 7 1 13 nfet_01v8 L=150000U W=1300000U AS=344500000000P AD=175500000000P
+ PS=2360000U PD=1840000U
* device instance $19 r0 *1 4.485,0.56 nfet_01v8
M$19 4 8 1 13 nfet_01v8 L=150000U W=1300000U AS=175500000000P AD=269750000000P
+ PS=1840000U PD=2780000U
.ENDS sky130_fd_sc_hd__a2bb2oi_2

* cell sky130_fd_sc_hd__o311ai_0
* pin VGND
* pin A1
* pin Y
* pin C1
* pin A2
* pin A3
* pin B1
* pin VPWR
* pin VPB
* pin
.SUBCKT sky130_fd_sc_hd__o311ai_0 1 2 4 5 7 8 9 10 11 14
* net 1 VGND
* net 2 A1
* net 4 Y
* net 5 C1
* net 7 A2
* net 8 A3
* net 9 B1
* net 10 VPWR
* net 11 VPB
* device instance $1 r0 *1 0.615,2.165 pfet_01v8_hvt
M$1 12 2 10 11 pfet_01v8_hvt L=150000U W=640000U AS=179200000000P
+ AD=86400000000P PS=1840000U PD=910000U
* device instance $2 r0 *1 1.035,2.165 pfet_01v8_hvt
M$2 13 7 12 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=86400000000P PS=910000U PD=910000U
* device instance $3 r0 *1 1.455,2.165 pfet_01v8_hvt
M$3 4 8 13 11 pfet_01v8_hvt L=150000U W=640000U AS=86400000000P
+ AD=144000000000P PS=910000U PD=1090000U
* device instance $4 r0 *1 2.055,2.165 pfet_01v8_hvt
M$4 10 9 4 11 pfet_01v8_hvt L=150000U W=640000U AS=144000000000P
+ AD=118400000000P PS=1090000U PD=1010000U
* device instance $5 r0 *1 2.575,2.165 pfet_01v8_hvt
M$5 4 5 10 11 pfet_01v8_hvt L=150000U W=640000U AS=118400000000P
+ AD=198400000000P PS=1010000U PD=1900000U
* device instance $6 r0 *1 0.615,0.445 nfet_01v8
M$6 3 2 1 14 nfet_01v8 L=150000U W=420000U AS=117600000000P AD=56700000000P
+ PS=1400000U PD=690000U
* device instance $7 r0 *1 1.035,0.445 nfet_01v8
M$7 1 7 3 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=56700000000P
+ PS=690000U PD=690000U
* device instance $8 r0 *1 1.455,0.445 nfet_01v8
M$8 3 8 1 14 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=128100000000P
+ PS=690000U PD=1030000U
* device instance $9 r0 *1 2.215,0.445 nfet_01v8
M$9 6 9 3 14 nfet_01v8 L=150000U W=420000U AS=128100000000P AD=44100000000P
+ PS=1030000U PD=630000U
* device instance $10 r0 *1 2.575,0.445 nfet_01v8
M$10 4 5 6 14 nfet_01v8 L=150000U W=420000U AS=44100000000P AD=117600000000P
+ PS=630000U PD=1400000U
.ENDS sky130_fd_sc_hd__o311ai_0

* cell sky130_fd_sc_hd__nor4_1
* pin VPB
* pin D
* pin B
* pin A
* pin C
* pin VGND
* pin Y
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor4_1 1 2 3 4 5 6 7 8 9
* net 1 VPB
* net 2 D
* net 3 B
* net 4 A
* net 5 C
* net 6 VGND
* net 7 Y
* net 8 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 11 2 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=130000000000P PS=2520000U PD=1260000U
* device instance $2 r0 *1 0.88,1.985 pfet_01v8_hvt
M$2 10 5 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=130000000000P
+ AD=190000000000P PS=1260000U PD=1380000U
* device instance $3 r0 *1 1.41,1.985 pfet_01v8_hvt
M$3 12 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=190000000000P
+ AD=135000000000P PS=1380000U PD=1270000U
* device instance $4 r0 *1 1.83,1.985 pfet_01v8_hvt
M$4 8 4 12 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $5 r0 *1 0.47,0.56 nfet_01v8
M$5 7 2 6 9 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=118625000000P
+ PS=1820000U PD=1015000U
* device instance $6 r0 *1 0.985,0.56 nfet_01v8
M$6 6 5 7 9 nfet_01v8 L=150000U W=650000U AS=118625000000P AD=89375000000P
+ PS=1015000U PD=925000U
* device instance $7 r0 *1 1.41,0.56 nfet_01v8
M$7 7 3 6 9 nfet_01v8 L=150000U W=650000U AS=89375000000P AD=87750000000P
+ PS=925000U PD=920000U
* device instance $8 r0 *1 1.83,0.56 nfet_01v8
M$8 6 4 7 9 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor4_1

* cell sky130_fd_sc_hd__nor3_1
* pin VPB
* pin A
* pin B
* pin C
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor3_1 1 2 3 4 5 6 7 8
* net 1 VPB
* net 2 A
* net 3 B
* net 4 C
* net 5 Y
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 10 4 5 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=135000000000P PS=2520000U PD=1270000U
* device instance $2 r0 *1 0.89,1.985 pfet_01v8_hvt
M$2 9 3 10 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=135000000000P PS=1270000U PD=1270000U
* device instance $3 r0 *1 1.31,1.985 pfet_01v8_hvt
M$3 7 2 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=135000000000P
+ AD=260000000000P PS=1270000U PD=2520000U
* device instance $4 r0 *1 0.47,0.56 nfet_01v8
M$4 6 4 5 8 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $5 r0 *1 0.89,0.56 nfet_01v8
M$5 5 3 6 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=87750000000P
+ PS=920000U PD=920000U
* device instance $6 r0 *1 1.31,0.56 nfet_01v8
M$6 6 2 5 8 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor3_1

* cell sky130_fd_sc_hd__o21ai_0
* pin VPB
* pin A1
* pin A2
* pin B1
* pin VPWR
* pin Y
* pin VGND
* pin
.SUBCKT sky130_fd_sc_hd__o21ai_0 1 2 3 4 5 6 8 9
* net 1 VPB
* net 2 A1
* net 3 A2
* net 4 B1
* net 5 VPWR
* net 6 Y
* net 8 VGND
* device instance $1 r0 *1 0.525,2.165 pfet_01v8_hvt
M$1 10 2 5 1 pfet_01v8_hvt L=150000U W=640000U AS=169600000000P AD=76800000000P
+ PS=1810000U PD=880000U
* device instance $2 r0 *1 0.915,2.165 pfet_01v8_hvt
M$2 6 3 10 1 pfet_01v8_hvt L=150000U W=640000U AS=76800000000P AD=89600000000P
+ PS=880000U PD=920000U
* device instance $3 r0 *1 1.345,2.165 pfet_01v8_hvt
M$3 5 4 6 1 pfet_01v8_hvt L=150000U W=640000U AS=89600000000P AD=182400000000P
+ PS=920000U PD=1850000U
* device instance $4 r0 *1 0.5,0.445 nfet_01v8
M$4 8 2 7 9 nfet_01v8 L=150000U W=420000U AS=111300000000P AD=58800000000P
+ PS=1370000U PD=700000U
* device instance $5 r0 *1 0.93,0.445 nfet_01v8
M$5 7 3 8 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=58800000000P
+ PS=700000U PD=700000U
* device instance $6 r0 *1 1.36,0.445 nfet_01v8
M$6 6 4 7 9 nfet_01v8 L=150000U W=420000U AS=58800000000P AD=111300000000P
+ PS=700000U PD=1370000U
.ENDS sky130_fd_sc_hd__o21ai_0

* cell sky130_fd_sc_hd__o21bai_1
* pin VPB
* pin B1_N
* pin A1
* pin A2
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__o21bai_1 1 2 4 5 7 8 9 10
* net 1 VPB
* net 2 B1_N
* net 4 A1
* net 5 A2
* net 7 VPWR
* net 8 VGND
* net 9 Y
* device instance $1 r0 *1 0.86,1.97 pfet_01v8_hvt
M$1 3 2 7 1 pfet_01v8_hvt L=150000U W=420000U AS=178250000000P AD=109200000000P
+ PS=1400000U PD=1360000U
* device instance $2 r0 *1 1.41,1.985 pfet_01v8_hvt
M$2 9 3 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=178250000000P
+ AD=152500000000P PS=1400000U PD=1305000U
* device instance $3 r0 *1 1.865,1.985 pfet_01v8_hvt
M$3 11 5 9 1 pfet_01v8_hvt L=150000U W=1000000U AS=152500000000P
+ AD=127500000000P PS=1305000U PD=1255000U
* device instance $4 r0 *1 2.27,1.985 pfet_01v8_hvt
M$4 7 4 11 1 pfet_01v8_hvt L=150000U W=1000000U AS=127500000000P
+ AD=280000000000P PS=1255000U PD=2560000U
* device instance $5 r0 *1 1.41,0.56 nfet_01v8
M$5 6 3 9 10 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=100750000000P
+ PS=1820000U PD=960000U
* device instance $6 r0 *1 1.87,0.56 nfet_01v8
M$6 8 5 6 10 nfet_01v8 L=150000U W=650000U AS=100750000000P AD=87750000000P
+ PS=960000U PD=920000U
* device instance $7 r0 *1 2.29,0.56 nfet_01v8
M$7 6 4 8 10 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
* device instance $8 r0 *1 0.47,0.675 nfet_01v8
M$8 3 2 8 10 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=109200000000P
+ PS=1360000U PD=1360000U
.ENDS sky130_fd_sc_hd__o21bai_1

* cell sky130_fd_sc_hd__a21oi_1
* pin VPB
* pin B1
* pin A1
* pin A2
* pin VGND
* pin VPWR
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__a21oi_1 1 2 3 4 5 7 8 9
* net 1 VPB
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 VGND
* net 7 VPWR
* net 8 Y
* device instance $1 r0 *1 0.49,1.985 pfet_01v8_hvt
M$1 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=265000000000P
+ AD=140000000000P PS=2530000U PD=1280000U
* device instance $2 r0 *1 0.92,1.985 pfet_01v8_hvt
M$2 7 3 6 1 pfet_01v8_hvt L=150000U W=1000000U AS=140000000000P
+ AD=147500000000P PS=1280000U PD=1295000U
* device instance $3 r0 *1 1.365,1.985 pfet_01v8_hvt
M$3 6 4 7 1 pfet_01v8_hvt L=150000U W=1000000U AS=147500000000P
+ AD=265000000000P PS=1295000U PD=2530000U
* device instance $4 r0 *1 0.49,0.56 nfet_01v8
M$4 8 2 5 9 nfet_01v8 L=150000U W=650000U AS=172250000000P AD=91000000000P
+ PS=1830000U PD=930000U
* device instance $5 r0 *1 0.92,0.56 nfet_01v8
M$5 10 3 8 9 nfet_01v8 L=150000U W=650000U AS=91000000000P AD=95875000000P
+ PS=930000U PD=945000U
* device instance $6 r0 *1 1.365,0.56 nfet_01v8
M$6 5 4 10 9 nfet_01v8 L=150000U W=650000U AS=95875000000P AD=172250000000P
+ PS=945000U PD=1830000U
.ENDS sky130_fd_sc_hd__a21oi_1

* cell sky130_fd_sc_hd__nor2_1
* pin VPB
* pin A
* pin B
* pin Y
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__nor2_1 1 2 3 4 5 6 7
* net 1 VPB
* net 2 A
* net 3 B
* net 4 Y
* net 5 VGND
* net 6 VPWR
* device instance $1 r0 *1 0.47,1.985 pfet_01v8_hvt
M$1 8 3 4 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=105000000000P PS=2520000U PD=1210000U
* device instance $2 r0 *1 0.83,1.985 pfet_01v8_hvt
M$2 6 2 8 1 pfet_01v8_hvt L=150000U W=1000000U AS=105000000000P
+ AD=260000000000P PS=1210000U PD=2520000U
* device instance $3 r0 *1 0.47,0.56 nfet_01v8
M$3 4 3 5 7 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=87750000000P
+ PS=1820000U PD=920000U
* device instance $4 r0 *1 0.89,0.56 nfet_01v8
M$4 5 2 4 7 nfet_01v8 L=150000U W=650000U AS=87750000000P AD=169000000000P
+ PS=920000U PD=1820000U
.ENDS sky130_fd_sc_hd__nor2_1

* cell sky130_fd_sc_hd__or2_0
* pin VPB
* pin B
* pin A
* pin X
* pin VGND
* pin VPWR
* pin
.SUBCKT sky130_fd_sc_hd__or2_0 1 2 3 4 6 7 8
* net 1 VPB
* net 2 B
* net 3 A
* net 4 X
* net 6 VGND
* net 7 VPWR
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 9 2 5 1 pfet_01v8_hvt L=150000U W=420000U AS=109200000000P AD=44100000000P
+ PS=1360000U PD=630000U
* device instance $2 r0 *1 1.035,1.985 pfet_01v8_hvt
M$2 7 3 9 1 pfet_01v8_hvt L=150000U W=420000U AS=44100000000P AD=98950000000P
+ PS=630000U PD=975000U
* device instance $3 r0 *1 1.52,2.095 pfet_01v8_hvt
M$3 4 5 7 1 pfet_01v8_hvt L=150000U W=640000U AS=98950000000P AD=217600000000P
+ PS=975000U PD=1960000U
* device instance $4 r0 *1 0.615,0.675 nfet_01v8
M$4 5 2 6 8 nfet_01v8 L=150000U W=420000U AS=109200000000P AD=56700000000P
+ PS=1360000U PD=690000U
* device instance $5 r0 *1 1.035,0.675 nfet_01v8
M$5 6 3 5 8 nfet_01v8 L=150000U W=420000U AS=56700000000P AD=70350000000P
+ PS=690000U PD=755000U
* device instance $6 r0 *1 1.52,0.675 nfet_01v8
M$6 4 5 6 8 nfet_01v8 L=150000U W=420000U AS=70350000000P AD=109200000000P
+ PS=755000U PD=1360000U
.ENDS sky130_fd_sc_hd__or2_0

* cell sky130_fd_sc_hd__inv_1
* pin VPB
* pin A
* pin VPWR
* pin VGND
* pin Y
* pin
.SUBCKT sky130_fd_sc_hd__inv_1 1 2 3 4 5 6
* net 1 VPB
* net 2 A
* net 3 VPWR
* net 4 VGND
* net 5 Y
* device instance $1 r0 *1 0.675,1.985 pfet_01v8_hvt
M$1 5 2 3 1 pfet_01v8_hvt L=150000U W=1000000U AS=260000000000P
+ AD=260000000000P PS=2520000U PD=2520000U
* device instance $2 r0 *1 0.675,0.56 nfet_01v8
M$2 5 2 4 6 nfet_01v8 L=150000U W=650000U AS=169000000000P AD=169000000000P
+ PS=1820000U PD=1820000U
.ENDS sky130_fd_sc_hd__inv_1
