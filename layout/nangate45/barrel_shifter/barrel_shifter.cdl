* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT barrel_shifter data_in[0] data_in[10] data_in[11]
+ data_in[12] data_in[13] data_in[14] data_in[15] data_in[16]
+ data_in[17] data_in[18] data_in[19] data_in[1] data_in[20]
+ data_in[21] data_in[22] data_in[23] data_in[24] data_in[25]
+ data_in[26] data_in[27] data_in[28] data_in[29] data_in[2]
+ data_in[30] data_in[31] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] data_in[8] data_in[9] data_out[0] data_out[10]
+ data_out[11] data_out[12] data_out[13] data_out[14] data_out[15]
+ data_out[16] data_out[17] data_out[18] data_out[19] data_out[1]
+ data_out[20] data_out[21] data_out[22] data_out[23] data_out[24]
+ data_out[25] data_out[26] data_out[27] data_out[28] data_out[29]
+ data_out[2] data_out[30] data_out[31] data_out[3] data_out[4]
+ data_out[5] data_out[6] data_out[7] data_out[8] data_out[9]
+ rotate shift_amount[0] shift_amount[1] shift_amount[2] shift_amount[3]
+ shift_amount[4] shift_direction
X_0928_ shift_amount[0] _0677_ VDD VSS BUF_X32
X_0929_ _0677_ _0688_ VDD VSS INV_X32
X_0930_ _0688_ _0698_ VDD VSS BUF_X32
X_0931_ _0698_ _0709_ VDD VSS BUF_X32
Xclone7 _0698_ net44 VDD VSS BUF_X16
X_0933_ shift_amount[1] _0729_ VDD VSS BUF_X4
X_0934_ _0729_ _0739_ VDD VSS BUF_X8
Xclone3 _0041_ net3 VDD VSS BUF_X4
X_0936_ _0739_ _0925_ VDD VSS INV_X4
X_0937_ shift_direction _0769_ VDD VSS CLKBUF_X3
X_0938_ _0769_ _0780_ VDD VSS BUF_X4
X_0939_ data_in[0] _0790_ VDD VSS CLKBUF_X3
X_0940_ _0790_ net44 _0800_ VDD VSS NAND2_X1
X_0941_ shift_amount[4] _0811_ VDD VSS BUF_X4
X_0942_ shift_amount[3] _0821_ VDD VSS BUF_X4
X_0943_ net7 _0832_ VDD VSS BUF_X4
X_0944_ _0811_ _0821_ _0832_ _0729_ _0842_ VDD VSS OR4_X2
X_0945_ _0780_ _0800_ _0842_ _0853_ VDD VSS OAI21_X1
X_0946_ _0677_ _0863_ VDD VSS BUF_X4
X_0947_ net6 _0842_ _0863_ _0873_ VDD VSS OAI21_X2
X_0948_ _0873_ _0884_ VDD VSS BUF_X4
X_0949_ _0811_ _0894_ VDD VSS INV_X4
Xclone26 net69 net67 VDD VSS BUF_X4
X_0951_ _0926_ _0914_ VDD VSS BUF_X8
X_0952_ _0821_ _0832_ _0000_ VDD VSS NOR2_X2
X_0953_ _0894_ _0914_ _0000_ _0010_ VDD VSS AOI21_X4
X_0954_ _0832_ _0021_ VDD VSS BUF_X4
X_0955_ _0914_ _0031_ VDD VSS INV_X4
X_0956_ _0811_ _0821_ _0035_ VDD VSS OR2_X4
X_0957_ _0021_ _0031_ _0035_ _0036_ VDD VSS NOR3_X4
X_0958_ _0884_ _0010_ _0036_ _0037_ VDD VSS NOR3_X2
X_0959_ _0037_ _0038_ VDD VSS BUF_X4
X_0960_ data_in[28] _0039_ VDD VSS BUF_X2
X_0961_ data_in[30] _0040_ VDD VSS BUF_X2
X_0962_ _0927_ _0041_ VDD VSS BUF_X4
X_0963_ _0039_ _0040_ net69 _0042_ VDD VSS MUX2_X1
X_0964_ data_in[29] _0043_ VDD VSS BUF_X2
X_0965_ data_in[31] _0044_ VDD VSS CLKBUF_X3
X_0966_ _0041_ _0045_ VDD VSS BUF_X8
X_0967_ _0043_ _0044_ _0045_ _0046_ VDD VSS MUX2_X2
X_0968_ _0042_ _0046_ _0863_ _0047_ VDD VSS MUX2_X2
X_0969_ data_in[25] _0048_ VDD VSS BUF_X2
X_0970_ data_in[27] _0049_ VDD VSS BUF_X2
X_0971_ _0041_ _0050_ VDD VSS BUF_X8
X_0972_ _0048_ _0049_ _0050_ _0051_ VDD VSS MUX2_X1
X_0973_ data_in[24] _0052_ VDD VSS BUF_X2
X_0974_ data_in[26] _0053_ VDD VSS BUF_X2
X_0975_ _0041_ _0054_ VDD VSS BUF_X8
X_0976_ _0052_ _0053_ _0054_ _0055_ VDD VSS MUX2_X1
X_0977_ _0688_ _0056_ VDD VSS BUF_X4
X_0978_ _0051_ _0055_ _0056_ _0057_ VDD VSS MUX2_X1
X_0979_ _0832_ _0926_ _0058_ VDD VSS XOR2_X2
X_0980_ _0058_ _0059_ VDD VSS BUF_X4
X_0981_ _0047_ _0057_ _0059_ _0060_ VDD VSS MUX2_X1
X_0982_ data_in[21] _0061_ VDD VSS BUF_X2
X_0983_ data_in[23] _0062_ VDD VSS BUF_X2
X_0984_ _0061_ _0062_ _0050_ _0063_ VDD VSS MUX2_X1
X_0985_ data_in[20] _0064_ VDD VSS BUF_X2
X_0986_ data_in[22] _0065_ VDD VSS BUF_X2
X_0987_ _0064_ _0065_ _0054_ _0066_ VDD VSS MUX2_X1
X_0988_ _0063_ _0066_ _0056_ _0067_ VDD VSS MUX2_X2
X_0989_ data_in[17] _0068_ VDD VSS BUF_X2
X_0990_ data_in[19] _0069_ VDD VSS BUF_X2
X_0991_ _0068_ _0069_ _0050_ _0070_ VDD VSS MUX2_X1
X_0992_ data_in[16] _0071_ VDD VSS BUF_X2
X_0993_ data_in[18] _0072_ VDD VSS BUF_X2
X_0994_ _0071_ _0072_ _0054_ _0073_ VDD VSS MUX2_X1
X_0995_ _0070_ _0073_ _0056_ _0074_ VDD VSS MUX2_X1
X_0996_ _0058_ _0075_ VDD VSS BUF_X4
X_0997_ _0067_ _0074_ _0075_ _0076_ VDD VSS MUX2_X1
X_0998_ _0821_ _0077_ VDD VSS INV_X4
X_0999_ net7 _0677_ _0729_ _0078_ VDD VSS NOR3_X4
X_1000_ _0077_ _0078_ _0079_ VDD VSS XNOR2_X2
X_1001_ _0079_ _0080_ VDD VSS BUF_X4
X_1002_ _0060_ _0076_ _0080_ _0081_ VDD VSS MUX2_X1
X_1003_ _0821_ _0832_ _0082_ VDD VSS OR2_X1
X_1004_ _0811_ _0031_ _0082_ _0083_ VDD VSS OAI21_X4
X_1005_ _0832_ _0084_ VDD VSS INV_X2
X_1006_ _0811_ _0821_ _0085_ VDD VSS NOR2_X4
X_1007_ _0084_ _0914_ _0085_ _0086_ VDD VSS NAND3_X4
X_1008_ _0873_ _0083_ _0086_ _0087_ VDD VSS AOI21_X2
X_1009_ _0087_ _0088_ VDD VSS BUF_X4
X_1010_ _0088_ _0089_ VDD VSS BUF_X4
X_1011_ data_in[9] _0090_ VDD VSS BUF_X2
X_1012_ data_in[11] _0091_ VDD VSS BUF_X2
X_1013_ net69 _0092_ VDD VSS BUF_X8
X_1014_ _0090_ _0091_ net68 _0093_ VDD VSS MUX2_X1
X_1015_ data_in[8] _0094_ VDD VSS BUF_X2
X_1016_ data_in[10] _0095_ VDD VSS BUF_X2
X_1017_ _0094_ _0095_ net3 _0096_ VDD VSS MUX2_X1
X_1018_ _0093_ _0096_ net4 _0097_ VDD VSS MUX2_X1
X_1019_ data_in[3] _0098_ VDD VSS BUF_X2
X_1020_ _0050_ _0099_ VDD VSS BUF_X8
X_1021_ net5 _0098_ _0099_ _0100_ VDD VSS MUX2_X1
X_1022_ data_in[2] _0101_ VDD VSS BUF_X2
X_1023_ _0790_ _0101_ _0099_ _0102_ VDD VSS MUX2_X1
X_1024_ _0056_ _0103_ VDD VSS BUF_X4
X_1025_ _0100_ _0102_ _0103_ _0104_ VDD VSS MUX2_X1
X_1026_ _0079_ _0105_ VDD VSS BUF_X4
X_1027_ _0097_ _0104_ _0105_ _0106_ VDD VSS MUX2_X1
X_1028_ data_in[13] _0107_ VDD VSS BUF_X2
X_1029_ data_in[15] _0108_ VDD VSS BUF_X2
X_1030_ _0107_ _0108_ _0092_ _0109_ VDD VSS MUX2_X1
X_1031_ data_in[12] _0110_ VDD VSS BUF_X2
X_1032_ data_in[14] _0111_ VDD VSS BUF_X2
X_1033_ _0110_ _0111_ net56 _0112_ VDD VSS MUX2_X1
X_1034_ _0109_ _0112_ net4 _0113_ VDD VSS MUX2_X1
X_1035_ data_in[5] _0114_ VDD VSS BUF_X2
X_1036_ data_in[7] _0115_ VDD VSS BUF_X2
X_1037_ _0114_ _0115_ net68 _0116_ VDD VSS MUX2_X1
X_1038_ data_in[4] _0117_ VDD VSS BUF_X2
X_1039_ data_in[6] _0118_ VDD VSS BUF_X2
X_1040_ _0117_ _0118_ net3 _0119_ VDD VSS MUX2_X1
X_1041_ _0688_ _0120_ VDD VSS BUF_X4
X_1042_ _0116_ _0119_ _0120_ _0121_ VDD VSS MUX2_X1
X_1043_ _0113_ _0121_ _0079_ _0122_ VDD VSS MUX2_X1
X_1044_ _0832_ _0914_ _0123_ VDD VSS XNOR2_X2
X_1045_ _0123_ _0124_ VDD VSS BUF_X4
X_1046_ _0124_ _0125_ VDD VSS BUF_X4
X_1047_ _0106_ _0122_ _0125_ _0126_ VDD VSS MUX2_X1
X_1048_ _0853_ _0038_ _0081_ _0089_ _0126_ _0127_ VDD VSS
+ AOI221_X2
X_1049_ _0769_ _0128_ VDD VSS BUF_X4
X_1050_ _0128_ _0129_ VDD VSS BUF_X4
X_1051_ _0790_ _0130_ VDD VSS INV_X1
X_1052_ _0863_ _0131_ VDD VSS BUF_X4
X_1053_ _0131_ _0132_ VDD VSS BUF_X4
X_1054_ _0132_ _0133_ VDD VSS BUF_X4
X_1055_ _0130_ _0133_ _0134_ VDD VSS NOR2_X2
X_1056_ _0077_ _0078_ _0135_ VDD VSS NAND2_X2
X_1057_ _0031_ _0135_ _0136_ VDD VSS NOR2_X2
X_1058_ _0021_ _0031_ _0137_ VDD VSS NAND2_X2
X_1059_ _0863_ _0739_ _0138_ VDD VSS OR2_X1
X_1060_ _0084_ _0914_ _0138_ _0139_ VDD VSS NAND3_X2
X_1061_ _0077_ _0137_ _0139_ _0140_ VDD VSS AOI21_X4
X_1062_ _0136_ _0140_ _0141_ VDD VSS NOR2_X4
X_1063_ net6 _0142_ VDD VSS INV_X1
X_1064_ _0142_ _0078_ _0085_ _0143_ VDD VSS AOI21_X4
X_1065_ _0143_ _0010_ _0036_ _0144_ VDD VSS OAI21_X2
X_1066_ _0144_ _0145_ VDD VSS BUF_X4
X_1067_ _0099_ _0141_ _0145_ _0146_ VDD VSS NOR3_X4
X_1068_ _0129_ _0134_ _0146_ _0147_ VDD VSS AOI21_X1
X_1069_ _0739_ _0148_ VDD VSS CLKBUF_X3
X_1070_ _0048_ _0049_ _0148_ _0149_ VDD VSS MUX2_X1
X_1071_ _0739_ _0150_ VDD VSS CLKBUF_X3
X_1072_ _0052_ _0053_ _0150_ _0151_ VDD VSS MUX2_X1
X_1073_ _0056_ _0152_ VDD VSS BUF_X4
X_1074_ _0149_ _0151_ _0152_ _0153_ VDD VSS MUX2_X1
X_1075_ _0729_ _0154_ VDD VSS BUF_X4
X_1076_ _0043_ _0044_ _0154_ _0155_ VDD VSS MUX2_X1
X_1077_ _0039_ _0040_ _0154_ _0156_ VDD VSS MUX2_X1
X_1078_ _0688_ _0157_ VDD VSS BUF_X4
X_1079_ _0155_ _0156_ _0157_ _0158_ VDD VSS MUX2_X2
X_1080_ _0153_ _0158_ _0021_ _0159_ VDD VSS MUX2_X2
X_1081_ _0061_ _0062_ _0150_ _0160_ VDD VSS MUX2_X1
X_1082_ _0739_ _0161_ VDD VSS BUF_X4
X_1083_ _0064_ _0065_ _0161_ _0162_ VDD VSS MUX2_X1
X_1084_ _0160_ _0162_ _0103_ _0163_ VDD VSS MUX2_X1
X_1085_ _0068_ _0069_ _0150_ _0164_ VDD VSS MUX2_X1
X_1086_ _0071_ _0072_ _0154_ _0165_ VDD VSS MUX2_X1
X_1087_ _0164_ _0165_ _0103_ _0166_ VDD VSS MUX2_X1
X_1088_ _0084_ _0167_ VDD VSS BUF_X4
X_1089_ _0167_ _0168_ VDD VSS CLKBUF_X3
X_1090_ _0163_ _0166_ _0168_ _0169_ VDD VSS MUX2_X1
X_1091_ _0077_ _0170_ VDD VSS BUF_X4
X_1092_ _0159_ _0169_ _0170_ _0171_ VDD VSS MUX2_X1
X_1093_ _0739_ _0172_ VDD VSS CLKBUF_X3
X_1094_ _0107_ _0108_ _0172_ _0173_ VDD VSS MUX2_X1
X_1095_ _0110_ _0111_ _0161_ _0174_ VDD VSS MUX2_X1
X_1096_ _0173_ _0174_ net42 _0175_ VDD VSS MUX2_X1
X_1097_ _0090_ _0091_ _0172_ _0176_ VDD VSS MUX2_X1
X_1098_ _0094_ _0095_ _0172_ _0177_ VDD VSS MUX2_X1
X_1099_ _0176_ _0177_ net42 _0178_ VDD VSS MUX2_X1
X_1100_ _0167_ _0179_ VDD VSS CLKBUF_X3
X_1101_ _0175_ _0178_ _0179_ _0180_ VDD VSS MUX2_X1
X_1102_ _0114_ _0115_ _0739_ _0181_ VDD VSS MUX2_X1
X_1103_ _0117_ _0118_ _0739_ _0182_ VDD VSS MUX2_X1
X_1104_ _0698_ _0183_ VDD VSS BUF_X4
X_1105_ _0181_ _0182_ _0183_ _0184_ VDD VSS MUX2_X1
X_1106_ net5 _0098_ _0739_ _0185_ VDD VSS MUX2_X1
X_1107_ _0790_ _0101_ _0739_ _0186_ VDD VSS MUX2_X1
X_1108_ _0185_ _0186_ _0183_ _0187_ VDD VSS MUX2_X1
X_1109_ _0167_ _0188_ VDD VSS BUF_X4
X_1110_ _0184_ _0187_ _0188_ _0189_ VDD VSS MUX2_X1
X_1111_ _0077_ _0190_ VDD VSS BUF_X4
X_1112_ _0180_ _0189_ _0190_ _0191_ VDD VSS MUX2_X1
X_1113_ _0894_ _0192_ VDD VSS BUF_X4
X_1114_ _0171_ _0191_ _0192_ _0193_ VDD VSS MUX2_X1
X_1115_ _0193_ _0194_ VDD VSS INV_X1
X_1116_ _0127_ _0147_ _0194_ net8 VDD VSS AOI21_X2
X_1117_ _0769_ _0195_ VDD VSS INV_X2
X_1118_ _0195_ _0196_ VDD VSS BUF_X4
X_1119_ _0811_ _0197_ VDD VSS BUF_X4
X_1120_ _0077_ _0198_ VDD VSS BUF_X4
X_1121_ _0198_ _0199_ VDD VSS BUF_X4
X_1122_ _0114_ _0098_ _0739_ _0200_ VDD VSS MUX2_X1
X_1123_ _0118_ _0117_ _0150_ _0201_ VDD VSS MUX2_X1
X_1124_ _0056_ _0202_ VDD VSS BUF_X4
X_1125_ _0200_ _0201_ _0202_ _0203_ VDD VSS MUX2_X1
X_1126_ _0090_ _0115_ _0154_ _0204_ VDD VSS MUX2_X1
X_1127_ _0095_ _0094_ _0150_ _0205_ VDD VSS MUX2_X1
X_1128_ _0204_ _0205_ _0202_ _0206_ VDD VSS MUX2_X1
X_1129_ _0167_ _0207_ VDD VSS CLKBUF_X3
X_1130_ _0203_ _0206_ _0207_ _0208_ VDD VSS MUX2_X1
X_1131_ _0101_ _0790_ _0154_ _0209_ VDD VSS MUX2_X2
X_1132_ net5 _0863_ _0210_ VDD VSS AND2_X2
X_1133_ _0183_ _0209_ _0210_ _0925_ _0211_ VDD VSS AOI22_X4
X_1134_ _0211_ _0212_ VDD VSS INV_X1
X_1135_ _0021_ _0213_ VDD VSS BUF_X4
X_1136_ _0077_ _0213_ _0214_ VDD VSS NOR2_X1
X_1137_ _0199_ _0208_ _0212_ _0214_ _0215_ VDD VSS AOI22_X2
X_1138_ _0197_ _0215_ _0216_ VDD VSS NOR2_X2
X_1139_ _0059_ _0217_ VDD VSS CLKBUF_X3
X_1140_ _0217_ _0218_ VDD VSS BUF_X4
X_1141_ _0080_ _0219_ VDD VSS BUF_X4
X_1142_ _0062_ _0048_ _0054_ _0220_ VDD VSS MUX2_X1
X_1143_ _0065_ _0052_ _0092_ _0221_ VDD VSS MUX2_X1
X_1144_ _0220_ _0221_ net4 _0222_ VDD VSS MUX2_X1
X_1145_ _0219_ _0222_ _0223_ VDD VSS NOR2_X1
X_1146_ _0821_ _0224_ VDD VSS BUF_X4
X_1147_ _0224_ _0078_ _0225_ VDD VSS XNOR2_X2
X_1148_ _0225_ _0226_ VDD VSS BUF_X4
X_1149_ _0226_ _0227_ VDD VSS BUF_X4
X_1150_ _0108_ _0068_ _0045_ _0228_ VDD VSS MUX2_X1
X_1151_ _0111_ _0071_ net67 _0229_ VDD VSS MUX2_X1
X_1152_ _0228_ _0229_ _0056_ _0230_ VDD VSS MUX2_X1
X_1153_ _0227_ _0230_ _0231_ VDD VSS NOR2_X1
X_1154_ _0145_ _0218_ _0223_ _0231_ _0232_ VDD VSS NOR4_X2
X_1155_ _0083_ _0086_ _0233_ VDD VSS NAND2_X2
X_1156_ _0233_ _0234_ VDD VSS BUF_X4
X_1157_ _0069_ _0061_ _0054_ _0235_ VDD VSS MUX2_X1
X_1158_ _0072_ _0064_ net67 _0236_ VDD VSS MUX2_X1
X_1159_ _0235_ _0236_ net4 _0237_ VDD VSS MUX2_X1
X_1160_ _0091_ _0107_ _0045_ _0238_ VDD VSS MUX2_X1
Xclone17 _0041_ net56 VDD VSS BUF_X4
X_1162_ _0095_ _0110_ net54 _0240_ VDD VSS MUX2_X1
X_1163_ _0238_ _0240_ _0120_ _0241_ VDD VSS MUX2_X1
X_1164_ _0237_ _0241_ _0079_ _0242_ VDD VSS MUX2_X1
X_1165_ _0234_ _0218_ _0242_ _0243_ VDD VSS NAND3_X1
X_1166_ net54 _0244_ VDD VSS INV_X4
X_1167_ _0040_ _0044_ _0863_ _0245_ VDD VSS MUX2_X2
X_1168_ _0244_ _0245_ _0246_ VDD VSS AND2_X1
X_1169_ _0049_ _0043_ net1 _0247_ VDD VSS MUX2_X1
X_1170_ _0053_ _0039_ net67 _0248_ VDD VSS MUX2_X1
X_1171_ _0247_ _0248_ _0698_ _0249_ VDD VSS MUX2_X1
X_1172_ _0246_ _0249_ _0075_ _0250_ VDD VSS MUX2_X1
X_1173_ _0010_ _0036_ _0225_ _0251_ VDD VSS NOR3_X4
X_1174_ _0250_ _0251_ _0252_ VDD VSS NAND2_X1
X_1175_ _0884_ _0243_ _0252_ _0253_ VDD VSS AOI21_X1
X_1176_ _0253_ _0216_ _0232_ _0196_ _0254_ VDD VSS NOR4_X2
X_1177_ _0088_ _0255_ VDD VSS BUF_X4
X_1178_ _0105_ _0256_ VDD VSS BUF_X4
X_1179_ _0095_ _0094_ _0050_ _0257_ VDD VSS MUX2_X1
X_1180_ _0118_ _0117_ net67 _0258_ VDD VSS MUX2_X1
X_1181_ _0257_ _0258_ _0123_ _0259_ VDD VSS MUX2_X1
X_1182_ _0114_ _0098_ net1 _0260_ VDD VSS MUX2_X1
X_1183_ _0090_ _0115_ net1 _0261_ VDD VSS MUX2_X1
X_1184_ _0260_ _0261_ net105 _0262_ VDD VSS MUX2_X1
X_1185_ _0259_ _0262_ _0132_ _0263_ VDD VSS MUX2_X1
X_1186_ _0256_ _0263_ _0264_ VDD VSS NAND2_X1
X_1187_ _0832_ _0677_ _0729_ _0265_ VDD VSS OR3_X2
X_1188_ _0224_ _0265_ _0266_ VDD VSS NAND2_X1
X_1189_ _0135_ _0266_ _0075_ _0267_ VDD VSS NAND3_X2
X_1190_ _0101_ _0790_ net56 _0268_ VDD VSS MUX2_X1
X_1191_ _0244_ _0210_ _0268_ _0056_ _0269_ VDD VSS AOI22_X2
X_1192_ _0264_ _0267_ _0269_ _0270_ VDD VSS OAI21_X2
X_1193_ _0129_ _0255_ _0270_ _0271_ VDD VSS AOI21_X1
X_1194_ _0053_ _0039_ _0161_ _0272_ VDD VSS MUX2_X1
X_1195_ _0049_ _0043_ _0154_ _0273_ VDD VSS MUX2_X2
X_1196_ _0863_ _0274_ VDD VSS BUF_X4
X_1197_ _0272_ _0273_ _0274_ _0275_ VDD VSS MUX2_X2
X_1198_ _0167_ _0739_ _0276_ VDD VSS NOR2_X2
X_1199_ _0188_ _0275_ _0276_ _0245_ _0277_ VDD VSS AOI22_X4
X_1200_ _0811_ _0198_ _0278_ VDD VSS NAND2_X2
X_1201_ _0277_ _0278_ _0279_ VDD VSS NOR2_X1
X_1202_ _0062_ _0048_ _0161_ _0280_ VDD VSS MUX2_X1
X_1203_ _0065_ _0052_ _0150_ _0281_ VDD VSS MUX2_X1
X_1204_ _0280_ _0281_ _0157_ _0282_ VDD VSS MUX2_X1
X_1205_ _0069_ _0061_ _0161_ _0283_ VDD VSS MUX2_X1
X_1206_ _0072_ _0064_ _0150_ _0284_ VDD VSS MUX2_X1
X_1207_ _0283_ _0284_ _0157_ _0285_ VDD VSS MUX2_X1
X_1208_ _0282_ _0285_ _0168_ _0286_ VDD VSS MUX2_X1
X_1209_ _0108_ _0068_ _0154_ _0287_ VDD VSS MUX2_X1
X_1210_ _0111_ _0071_ _0150_ _0288_ VDD VSS MUX2_X1
X_1211_ _0287_ _0288_ _0157_ _0289_ VDD VSS MUX2_X1
X_1212_ _0091_ _0107_ _0161_ _0290_ VDD VSS MUX2_X1
X_1213_ _0095_ _0110_ _0172_ _0291_ VDD VSS MUX2_X1
X_1214_ _0290_ _0291_ net42 _0292_ VDD VSS MUX2_X1
X_1215_ _0289_ _0292_ _0188_ _0293_ VDD VSS MUX2_X1
X_1216_ _0190_ _0294_ VDD VSS BUF_X4
X_1217_ _0286_ _0293_ _0294_ _0295_ VDD VSS MUX2_X1
X_1218_ _0279_ _0295_ _0192_ _0296_ VDD VSS AOI21_X2
X_1219_ _0254_ _0271_ _0296_ net9 VDD VSS AOI21_X2
X_1220_ _0115_ _0114_ _0148_ _0297_ VDD VSS MUX2_X1
X_1221_ _0201_ _0297_ _0152_ _0298_ VDD VSS MUX2_X1
X_1222_ _0091_ _0090_ _0148_ _0299_ VDD VSS MUX2_X1
X_1223_ _0205_ _0299_ _0103_ _0300_ VDD VSS MUX2_X1
X_1224_ _0298_ _0300_ _0179_ _0301_ VDD VSS MUX2_X1
X_1225_ _0098_ net5 _0739_ _0302_ VDD VSS MUX2_X1
X_1226_ _0209_ _0302_ _0120_ _0303_ VDD VSS MUX2_X2
X_1227_ _0199_ _0301_ _0303_ _0214_ _0304_ VDD VSS AOI22_X1
X_1228_ _0197_ _0304_ _0305_ VDD VSS OR2_X1
X_1229_ _0195_ _0306_ VDD VSS BUF_X4
X_1230_ _0884_ _0105_ _0086_ _0083_ _0307_ VDD VSS AOI211_X2
X_1231_ _0055_ _0220_ net2 _0308_ VDD VSS MUX2_X1
X_1232_ _0066_ _0235_ net2 _0309_ VDD VSS MUX2_X1
X_1233_ _0308_ _0309_ _0059_ _0310_ VDD VSS MUX2_X1
X_1234_ _0306_ _0307_ _0310_ _0311_ VDD VSS AOI21_X1
X_1235_ _0884_ _0227_ _0312_ VDD VSS NOR2_X2
X_1236_ _0044_ _0313_ VDD VSS INV_X1
X_1237_ _0131_ _0313_ _0099_ _0314_ VDD VSS NOR3_X2
X_1238_ _0042_ _0247_ _0688_ _0315_ VDD VSS MUX2_X1
X_1239_ _0314_ _0315_ _0059_ _0316_ VDD VSS MUX2_X1
X_1240_ _0073_ _0228_ net2 _0317_ VDD VSS MUX2_X1
X_1241_ _0112_ _0238_ net2 _0318_ VDD VSS MUX2_X1
X_1242_ _0317_ _0318_ _0059_ _0319_ VDD VSS MUX2_X1
X_1243_ _0316_ _0319_ _0234_ _0320_ VDD VSS MUX2_X1
X_1244_ _0312_ _0320_ _0321_ VDD VSS NAND2_X1
X_1245_ _0305_ _0311_ _0321_ _0322_ VDD VSS AND3_X1
X_1246_ _0151_ _0280_ _0202_ _0323_ VDD VSS MUX2_X1
X_1247_ _0162_ _0283_ _0157_ _0324_ VDD VSS MUX2_X1
X_1248_ _0323_ _0324_ _0207_ _0325_ VDD VSS MUX2_X1
X_1249_ _0165_ _0287_ _0120_ _0326_ VDD VSS MUX2_X1
X_1250_ _0174_ _0290_ _0120_ _0327_ VDD VSS MUX2_X1
X_1251_ _0326_ _0327_ _0167_ _0328_ VDD VSS MUX2_X1
X_1252_ _0325_ _0328_ _0199_ _0329_ VDD VSS MUX2_X1
X_1253_ _0207_ _0133_ _0156_ _0330_ VDD VSS NAND3_X1
X_1254_ _0167_ _0273_ _0276_ _0044_ _0331_ VDD VSS AOI22_X4
X_1255_ _0330_ _0331_ _0133_ _0332_ VDD VSS OAI21_X4
X_1256_ _0894_ _0224_ _0333_ VDD VSS NOR2_X4
X_1257_ _0192_ _0329_ _0332_ _0333_ _0334_ VDD VSS AOI22_X2
X_1258_ _0769_ _0335_ VDD VSS BUF_X4
X_1259_ _0335_ _0336_ VDD VSS BUF_X4
X_1260_ _0098_ net5 net67 _0337_ VDD VSS MUX2_X1
X_1261_ _0268_ _0337_ _0698_ _0338_ VDD VSS MUX2_X2
X_1262_ _0227_ _0218_ net65 _0339_ VDD VSS NAND3_X1
X_1263_ _0115_ _0114_ _0092_ _0340_ VDD VSS MUX2_X1
X_1264_ _0258_ _0340_ _0120_ _0341_ VDD VSS MUX2_X1
X_1265_ _0217_ _0341_ _0342_ VDD VSS OR2_X1
X_1266_ _0091_ _0090_ _0092_ _0343_ VDD VSS MUX2_X1
X_1267_ _0257_ _0343_ _0157_ _0344_ VDD VSS MUX2_X1
X_1268_ _0342_ _0344_ _0124_ _0345_ VDD VSS OAI21_X1
X_1269_ _0339_ _0345_ _0227_ _0346_ VDD VSS OAI21_X1
X_1270_ _0336_ _0255_ _0346_ _0347_ VDD VSS AOI21_X1
X_1271_ _0322_ _0334_ _0347_ net10 VDD VSS AOI21_X2
X_1272_ _0010_ _0036_ _0348_ VDD VSS NOR2_X2
X_1273_ _0348_ _0349_ VDD VSS BUF_X4
X_1274_ _0349_ _0080_ _0350_ VDD VSS NOR2_X2
X_1275_ _0217_ _0057_ _0351_ VDD VSS OR2_X1
X_1276_ _0124_ _0352_ VDD VSS BUF_X4
X_1277_ _0351_ _0067_ _0352_ _0353_ VDD VSS OAI21_X1
X_1278_ _0884_ _0350_ _0353_ _0354_ VDD VSS AOI21_X1
X_1279_ _0083_ _0086_ _0079_ _0047_ _0355_ VDD VSS AND4_X1
X_1280_ _0355_ _0113_ _0233_ _0356_ VDD VSS AOI21_X1
X_1281_ _0226_ _0124_ _0074_ _0357_ VDD VSS AOI21_X1
X_1282_ _0125_ _0356_ _0357_ _0349_ _0358_ VDD VSS OAI22_X2
X_1283_ _0863_ _0739_ _0359_ VDD VSS NOR2_X2
X_1284_ _0213_ _0790_ _0359_ _0360_ VDD VSS NAND3_X1
X_1285_ _0168_ _0133_ _0302_ _0361_ VDD VSS NAND3_X1
X_1286_ _0117_ _0101_ _0739_ _0362_ VDD VSS MUX2_X1
X_1287_ _0168_ net44 _0362_ _0363_ VDD VSS NAND3_X1
X_1288_ _0360_ _0361_ _0363_ _0364_ VDD VSS NAND3_X1
X_1289_ _0094_ _0118_ _0154_ _0365_ VDD VSS MUX2_X1
X_1290_ _0297_ _0365_ _0202_ _0366_ VDD VSS MUX2_X1
X_1291_ _0110_ _0095_ _0154_ _0367_ VDD VSS MUX2_X1
X_1292_ _0299_ _0367_ _0152_ _0368_ VDD VSS MUX2_X1
X_1293_ _0366_ _0368_ _0168_ _0369_ VDD VSS MUX2_X1
X_1294_ _0364_ _0369_ _0198_ _0370_ VDD VSS MUX2_X1
X_1295_ _0894_ _0371_ VDD VSS BUF_X4
X_1296_ _0306_ _0354_ _0358_ _0370_ _0371_ _0372_ VDD VSS
+ AOI221_X2
X_1297_ _0153_ _0163_ _0179_ _0373_ VDD VSS MUX2_X1
X_1298_ _0188_ _0374_ VDD VSS CLKBUF_X3
X_1299_ _0166_ _0175_ _0374_ _0375_ VDD VSS MUX2_X1
X_1300_ _0373_ _0375_ _0294_ _0376_ VDD VSS MUX2_X1
X_1301_ _0192_ _0376_ _0377_ VDD VSS NAND2_X1
X_1302_ _0340_ _0343_ net105 _0378_ VDD VSS MUX2_X1
X_1303_ _0094_ _0118_ net1 _0379_ VDD VSS MUX2_X1
X_1304_ _0110_ _0095_ net56 _0380_ VDD VSS MUX2_X1
X_1305_ _0379_ _0380_ net105 _0381_ VDD VSS MUX2_X1
X_1306_ _0378_ _0381_ _0183_ _0382_ VDD VSS MUX2_X1
X_1307_ _0256_ _0382_ _0383_ VDD VSS NAND2_X1
X_1308_ _0130_ _0132_ _0099_ _0384_ VDD VSS NOR3_X1
X_1309_ _0021_ _0739_ _0385_ VDD VSS NOR2_X2
X_1310_ _0224_ _0385_ _0386_ VDD VSS XNOR2_X1
X_1311_ _0384_ _0386_ _0387_ VDD VSS NAND2_X1
X_1312_ _0117_ _0101_ net1 _0388_ VDD VSS MUX2_X1
X_1313_ _0337_ _0388_ _0183_ _0389_ VDD VSS MUX2_X1
X_1314_ _0217_ _0389_ _0390_ VDD VSS NAND2_X1
X_1315_ _0383_ _0387_ _0217_ _0256_ _0390_ _0391_ VDD VSS
+ OAI221_X2
X_1316_ _0213_ _0278_ _0392_ VDD VSS NOR2_X2
X_1317_ _0128_ _0391_ _0089_ _0392_ _0158_ _0393_ VDD VSS
+ AOI221_X2
X_1318_ _0372_ _0377_ _0393_ net11 VDD VSS AOI21_X2
X_1319_ net5 _0790_ _0863_ _0394_ VDD VSS MUX2_X2
X_1320_ _0244_ _0394_ _0395_ VDD VSS AND2_X2
X_1321_ _0260_ _0388_ _0131_ _0396_ VDD VSS MUX2_X1
X_1322_ _0395_ _0396_ _0059_ _0397_ VDD VSS MUX2_X1
X_1323_ _0261_ _0379_ _0131_ _0398_ VDD VSS MUX2_X1
X_1324_ _0107_ _0091_ net56 _0399_ VDD VSS MUX2_X1
X_1325_ _0380_ _0399_ _0698_ _0400_ VDD VSS MUX2_X1
X_1326_ _0398_ _0400_ _0075_ _0401_ VDD VSS MUX2_X1
X_1327_ _0397_ _0401_ _0080_ _0402_ VDD VSS MUX2_X2
X_1328_ _0160_ _0281_ _0274_ _0403_ VDD VSS MUX2_X1
X_1329_ _0149_ _0272_ _0274_ _0404_ VDD VSS MUX2_X1
X_1330_ _0403_ _0404_ _0213_ _0405_ VDD VSS MUX2_X1
X_1331_ _0197_ _0199_ _0406_ VDD VSS NOR2_X1
X_1332_ _0128_ _0402_ _0089_ _0405_ _0406_ _0407_ VDD VSS
+ AOI221_X2
X_1333_ _0164_ _0284_ _0274_ _0408_ VDD VSS MUX2_X1
X_1334_ _0173_ _0288_ _0132_ _0409_ VDD VSS MUX2_X1
X_1335_ _0408_ _0409_ _0179_ _0410_ VDD VSS MUX2_X1
X_1336_ net44 _0155_ _0411_ VDD VSS NAND2_X1
X_1337_ _0133_ _0925_ _0040_ _0412_ VDD VSS NAND3_X1
X_1338_ _0213_ _0411_ _0412_ _0413_ VDD VSS AOI21_X1
X_1339_ _0410_ _0413_ _0197_ _0414_ VDD VSS MUX2_X1
X_1340_ _0294_ _0414_ _0415_ VDD VSS NAND2_X1
X_1341_ _0109_ _0229_ _0274_ _0416_ VDD VSS MUX2_X2
X_1342_ _0863_ _0040_ _0417_ VDD VSS AND2_X1
X_1343_ _0157_ net41 _0417_ _0244_ _0418_ VDD VSS AOI22_X4
X_1344_ _0418_ _0419_ VDD VSS INV_X1
X_1345_ _0234_ _0416_ _0419_ _0251_ _0420_ VDD VSS AOI22_X4
X_1346_ _0070_ _0236_ _0274_ _0421_ VDD VSS MUX2_X2
X_1347_ _0227_ _0125_ _0421_ _0422_ VDD VSS AOI21_X2
X_1348_ _0125_ _0420_ _0422_ _0349_ _0423_ VDD VSS OAI22_X4
X_1349_ _0063_ _0221_ _0131_ _0424_ VDD VSS MUX2_X1
X_1350_ _0051_ _0248_ _0131_ _0425_ VDD VSS MUX2_X2
X_1351_ _0424_ _0425_ _0123_ _0426_ VDD VSS MUX2_X1
X_1352_ _0426_ _0427_ VDD VSS INV_X1
X_1353_ _0884_ _0350_ _0427_ _0428_ VDD VSS AOI21_X2
X_1354_ _0200_ _0362_ _0131_ _0429_ VDD VSS MUX2_X1
X_1355_ _0925_ _0394_ _0430_ VDD VSS AND2_X1
X_1356_ _0429_ _0430_ _0021_ _0431_ VDD VSS MUX2_X1
X_1357_ _0204_ _0365_ _0131_ _0432_ VDD VSS MUX2_X1
X_1358_ _0107_ _0091_ _0154_ _0433_ VDD VSS MUX2_X1
X_1359_ _0367_ _0433_ _0120_ _0434_ VDD VSS MUX2_X1
X_1360_ _0432_ _0434_ _0167_ _0435_ VDD VSS MUX2_X1
X_1361_ _0431_ _0435_ _0198_ _0436_ VDD VSS MUX2_X1
X_1362_ _0423_ _0428_ _0436_ _0192_ _0437_ VDD VSS AOI22_X4
X_1363_ _0407_ _0415_ _0437_ _0129_ net12 VDD VSS AOI22_X4
X_1364_ _0111_ _0110_ net3 _0438_ VDD VSS MUX2_X1
X_1365_ _0399_ _0438_ _0056_ _0439_ VDD VSS MUX2_X1
X_1366_ _0084_ _0914_ _0440_ VDD VSS NOR2_X1
X_1367_ _0021_ _0031_ _0359_ _0441_ VDD VSS NOR3_X2
X_1368_ _0224_ _0440_ _0441_ _0442_ VDD VSS OAI21_X4
X_1369_ _0821_ _0265_ _0443_ VDD VSS NOR2_X2
X_1370_ _0914_ _0443_ _0444_ VDD VSS NAND2_X2
X_1371_ _0439_ _0442_ _0444_ _0445_ VDD VSS AOI21_X2
X_1372_ _0257_ _0261_ _0131_ _0446_ VDD VSS MUX2_X1
X_1373_ _0832_ _0914_ _0447_ VDD VSS NAND2_X1
X_1374_ _0832_ _0914_ _0448_ VDD VSS OR2_X1
X_1375_ _0447_ _0448_ _0359_ _0449_ VDD VSS OAI21_X2
X_1376_ _0031_ _0443_ _0224_ _0449_ _0450_ VDD VSS AOI22_X4
X_1377_ _0087_ _0446_ _0450_ _0451_ VDD VSS OAI21_X2
X_1378_ _0059_ _0269_ _0452_ VDD VSS NOR2_X2
X_1379_ _0258_ _0260_ _0131_ _0453_ VDD VSS MUX2_X1
X_1380_ _0452_ _0453_ _0059_ _0454_ VDD VSS AOI21_X4
X_1381_ _0451_ _0445_ _0226_ _0454_ _0455_ VDD VSS AOI211_X2
X_1382_ _0385_ _0333_ _0456_ VDD VSS AND2_X1
X_1383_ _0769_ _0245_ _0456_ _0457_ VDD VSS AOI21_X1
X_1384_ _0457_ _0458_ VDD VSS INV_X1
X_1385_ _0282_ _0275_ _0021_ _0459_ VDD VSS MUX2_X1
X_1386_ _0285_ _0289_ _0207_ _0460_ VDD VSS MUX2_X1
X_1387_ _0459_ _0460_ _0198_ _0461_ VDD VSS MUX2_X1
X_1388_ _0455_ _0458_ _0461_ _0462_ VDD VSS NOR3_X1
X_1389_ _0237_ _0230_ _0075_ _0463_ VDD VSS MUX2_X1
X_1390_ _0463_ _0226_ _0349_ _0464_ VDD VSS NOR3_X4
X_1391_ _0780_ _0884_ _0464_ _0465_ VDD VSS OAI21_X4
X_1392_ _0224_ _0167_ _0914_ _0138_ _0466_ VDD VSS NAND4_X1
X_1393_ _0466_ _0137_ _0077_ _0894_ _0138_ _0467_ VDD VSS
+ OAI221_X2
X_1394_ _0233_ _0246_ _0467_ _0468_ VDD VSS AOI21_X1
X_1395_ _0249_ _0222_ _0075_ _0469_ VDD VSS MUX2_X1
X_1396_ _0469_ _0470_ VDD VSS INV_X1
X_1397_ _0468_ _0470_ _0350_ _0471_ VDD VSS AOI21_X2
X_1398_ _0465_ _0455_ _0458_ _0471_ _0195_ _0472_ VDD VSS
+ OAI221_X2
X_1399_ _0197_ _0473_ VDD VSS BUF_X4
X_1400_ _0465_ _0471_ _0306_ _0474_ VDD VSS OAI21_X1
X_1401_ _0224_ _0475_ VDD VSS CLKBUF_X3
X_1402_ _0213_ _0211_ _0476_ VDD VSS NAND2_X1
X_1403_ _0213_ _0203_ _0477_ VDD VSS OR2_X1
X_1404_ _0475_ _0476_ _0477_ _0478_ VDD VSS NAND3_X1
X_1405_ _0111_ _0110_ _0148_ _0479_ VDD VSS MUX2_X1
X_1406_ _0433_ _0479_ _0202_ _0480_ VDD VSS MUX2_X1
X_1407_ _0206_ _0480_ _0168_ _0481_ VDD VSS MUX2_X1
X_1408_ _0190_ _0481_ _0482_ VDD VSS NAND2_X1
X_1409_ _0478_ _0482_ _0483_ VDD VSS AND2_X1
X_1410_ _0462_ _0473_ _0472_ _0474_ _0483_ net13 VDD VSS AOI221_X2
X_1411_ _0308_ _0315_ _0123_ _0484_ VDD VSS MUX2_X1
X_1412_ _0349_ _0256_ _0484_ _0485_ VDD VSS NOR3_X2
X_1413_ _0234_ _0314_ _0467_ _0486_ VDD VSS AOI21_X2
X_1414_ _0309_ _0317_ _0075_ _0487_ VDD VSS MUX2_X1
X_1415_ _0349_ _0227_ _0487_ _0488_ VDD VSS NOR3_X2
X_1416_ _0884_ _0485_ _0486_ _0488_ _0489_ VDD VSS NOR4_X4
X_1417_ _0298_ _0303_ _0021_ _0490_ VDD VSS MUX2_X2
X_1418_ _0108_ _0107_ _0148_ _0491_ VDD VSS MUX2_X1
X_1419_ _0479_ _0491_ _0103_ _0492_ VDD VSS MUX2_X1
X_1420_ _0300_ _0492_ _0168_ _0493_ VDD VSS MUX2_X1
X_1421_ _0490_ _0493_ _0170_ _0494_ VDD VSS MUX2_X1
X_1422_ _0341_ _0338_ _0124_ _0495_ VDD VSS MUX2_X2
X_1423_ _0256_ _0495_ _0496_ VDD VSS NOR2_X2
X_1424_ _0108_ _0107_ _0092_ _0497_ VDD VSS MUX2_X1
X_1425_ _0438_ _0497_ _0120_ _0498_ VDD VSS MUX2_X2
X_1426_ _0498_ _0442_ _0444_ _0499_ VDD VSS AOI21_X2
X_1427_ _0344_ _0450_ _0500_ VDD VSS NOR2_X2
X_1428_ _0145_ _0496_ _0499_ _0500_ _0501_ VDD VSS NOR4_X2
X_1429_ _0133_ _0313_ _0502_ VDD VSS NOR2_X2
X_1430_ _0780_ _0502_ _0456_ _0503_ VDD VSS AOI21_X1
X_1431_ _0503_ _0504_ VDD VSS INV_X1
X_1432_ _0156_ _0273_ _0103_ _0505_ VDD VSS MUX2_X1
X_1433_ _0323_ _0505_ _0021_ _0506_ VDD VSS MUX2_X1
X_1434_ _0324_ _0326_ _0167_ _0507_ VDD VSS MUX2_X1
X_1435_ _0506_ _0507_ _0190_ _0508_ VDD VSS MUX2_X1
X_1436_ _0489_ _0196_ _0494_ _0501_ _0504_ _0508_ _0509_ VDD
+ VSS OAI33_X1
X_1437_ _0196_ _0489_ _0501_ _0504_ _0510_ VDD VSS OAI22_X2
X_1438_ _0197_ _0511_ VDD VSS BUF_X4
X_1439_ _0509_ _0510_ _0511_ net14 VDD VSS AOI21_X2
X_1440_ _0388_ _0379_ net105 _0512_ VDD VSS MUX2_X1
X_1441_ net44 _0135_ _0266_ _0513_ VDD VSS NAND3_X1
X_1442_ _0340_ _0337_ _0123_ _0514_ VDD VSS MUX2_X1
X_1443_ _0198_ _0133_ _0515_ VDD VSS NAND2_X1
X_1444_ _0512_ _0513_ _0514_ _0515_ _0516_ VDD VSS OAI22_X2
X_1445_ _0071_ _0111_ net3 _0517_ VDD VSS MUX2_X1
X_1446_ _0497_ _0517_ net4 _0518_ VDD VSS MUX2_X1
X_1447_ _0518_ _0442_ _0444_ _0519_ VDD VSS AOI21_X1
X_1448_ _0343_ _0380_ _0157_ _0520_ VDD VSS MUX2_X1
X_1449_ _0088_ _0450_ _0520_ _0521_ VDD VSS OAI21_X1
X_1450_ _0516_ _0519_ _0521_ _0522_ VDD VSS NOR3_X2
X_1451_ _0244_ _0134_ _0523_ VDD VSS NAND2_X1
X_1452_ _0038_ _0140_ _0136_ _0524_ VDD VSS OAI21_X1
X_1453_ _0306_ _0523_ _0524_ _0525_ VDD VSS OAI21_X2
X_1454_ _0089_ _0081_ _0526_ VDD VSS AND2_X4
X_1455_ _0456_ _0527_ VDD VSS INV_X1
X_1456_ _0335_ _0800_ _0527_ _0528_ VDD VSS OAI21_X1
X_1457_ _0302_ _0362_ _0183_ _0529_ VDD VSS MUX2_X1
X_1458_ _0529_ _0366_ _0179_ _0530_ VDD VSS MUX2_X1
X_1459_ _0071_ _0111_ _0161_ _0531_ VDD VSS MUX2_X1
X_1460_ _0491_ _0531_ _0152_ _0532_ VDD VSS MUX2_X1
X_1461_ _0368_ _0532_ _0179_ _0533_ VDD VSS MUX2_X1
X_1462_ _0530_ _0533_ _0190_ _0534_ VDD VSS MUX2_X1
X_1463_ _0171_ _0522_ _0525_ _0526_ _0528_ _0534_ _0535_ VDD
+ VSS OAI33_X1
X_1464_ _0522_ _0525_ _0526_ _0528_ _0536_ VDD VSS OAI22_X2
X_1465_ _0535_ _0536_ _0511_ net15 VDD VSS AOI21_X2
X_1466_ _0135_ _0266_ _0124_ _0418_ _0537_ VDD VSS NAND4_X1
X_1467_ _0537_ _0450_ _0424_ _0267_ _0425_ _0538_ VDD VSS
+ OAI221_X2
X_1468_ _0421_ _0442_ _0444_ _0539_ VDD VSS AOI21_X2
X_1469_ _0145_ _0538_ _0539_ _0540_ VDD VSS NOR3_X4
X_1470_ _0394_ _0456_ _0541_ VDD VSS NAND2_X1
X_1471_ _0780_ _0541_ _0542_ VDD VSS NAND2_X1
X_1472_ _0429_ _0432_ _0207_ _0543_ VDD VSS MUX2_X1
X_1473_ _0068_ _0108_ _0161_ _0544_ VDD VSS MUX2_X1
X_1474_ _0531_ _0544_ _0157_ _0545_ VDD VSS MUX2_X1
X_1475_ _0434_ _0545_ _0207_ _0546_ VDD VSS MUX2_X1
X_1476_ _0543_ _0546_ _0198_ _0547_ VDD VSS MUX2_X1
X_1477_ _0540_ _0542_ _0547_ _0548_ VDD VSS NOR3_X1
X_1478_ _0380_ _0517_ net105 _0549_ VDD VSS MUX2_X1
X_1479_ _0068_ _0108_ net56 _0550_ VDD VSS MUX2_X1
X_1480_ _0399_ _0550_ net105 _0551_ VDD VSS MUX2_X1
X_1481_ _0549_ _0551_ _0103_ _0552_ VDD VSS MUX2_X2
X_1482_ _0348_ _0226_ _0552_ _0553_ VDD VSS NOR3_X4
X_1483_ _0262_ _0512_ _0274_ _0554_ VDD VSS MUX2_X2
X_1484_ _0348_ _0080_ _0554_ _0555_ VDD VSS NOR3_X2
X_1485_ _0233_ _0395_ _0467_ _0556_ VDD VSS AOI21_X2
X_1486_ _0555_ _0553_ _0884_ _0556_ _0557_ VDD VSS NOR4_X4
X_1487_ _0557_ _0128_ _0540_ _0542_ _0558_ VDD VSS OAI22_X2
X_1488_ _0128_ _0557_ _0559_ VDD VSS NOR2_X1
X_1489_ _0403_ _0408_ _0207_ _0560_ VDD VSS MUX2_X1
X_1490_ _0170_ _0560_ _0561_ VDD VSS AND2_X1
X_1491_ _0411_ _0412_ _0562_ VDD VSS NAND2_X1
X_1492_ _0562_ _0404_ _0188_ _0563_ VDD VSS MUX2_X1
X_1493_ _0561_ _0563_ _0475_ _0564_ VDD VSS AOI21_X2
X_1494_ _0548_ _0473_ _0558_ _0559_ _0564_ net16 VDD VSS AOI221_X2
X_1495_ _0374_ _0333_ _0565_ VDD VSS NAND2_X1
X_1496_ _0780_ _0211_ _0565_ _0566_ VDD VSS OAI21_X1
X_1497_ _0237_ _0222_ _0123_ _0567_ VDD VSS MUX2_X1
X_1498_ _0250_ _0567_ _0080_ _0568_ VDD VSS MUX2_X2
X_1499_ _0072_ _0071_ _0148_ _0569_ VDD VSS MUX2_X1
X_1500_ _0544_ _0569_ _0202_ _0570_ VDD VSS MUX2_X1
X_1501_ _0480_ _0570_ _0207_ _0571_ VDD VSS MUX2_X1
X_1502_ _0208_ _0571_ _0198_ _0572_ VDD VSS MUX2_X1
X_1503_ _0566_ _0568_ _0088_ _0371_ _0572_ _0573_ VDD VSS
+ AOI221_X2
X_1504_ _0072_ _0071_ net68 _0574_ VDD VSS MUX2_X1
X_1505_ _0438_ _0574_ _0059_ _0575_ VDD VSS MUX2_X1
X_1506_ _0551_ _0575_ net44 _0576_ VDD VSS MUX2_X1
X_1507_ _0263_ _0576_ _0219_ _0577_ VDD VSS MUX2_X1
X_1508_ _0255_ _0577_ _0578_ VDD VSS NAND2_X1
X_1509_ _0244_ _0210_ _0579_ VDD VSS NAND2_X1
X_1510_ _0268_ _0580_ VDD VSS INV_X1
X_1511_ _0579_ _0580_ _0133_ _0581_ VDD VSS OAI21_X2
X_1512_ _0143_ _0349_ _0582_ VDD VSS NAND2_X2
X_1513_ _0141_ _0582_ _0583_ VDD VSS NOR2_X1
X_1514_ _0190_ _0286_ _0584_ VDD VSS NAND2_X1
X_1515_ _0584_ _0277_ _0199_ _0585_ VDD VSS OAI21_X2
X_1516_ _0128_ _0581_ _0583_ _0585_ _0371_ _0586_ VDD VSS
+ AOI221_X2
X_1517_ _0573_ _0578_ _0586_ net17 VDD VSS AOI21_X2
X_1518_ _0069_ _0068_ net68 _0587_ VDD VSS MUX2_X1
X_1519_ _0574_ _0587_ _0120_ _0588_ VDD VSS MUX2_X2
X_1520_ _0251_ net65 _0588_ _0233_ _0589_ VDD VSS AOI22_X2
X_1521_ _0226_ _0352_ _0498_ _0590_ VDD VSS AOI21_X1
X_1522_ _0125_ _0589_ _0590_ _0349_ _0591_ VDD VSS OAI22_X2
X_1523_ _0884_ _0345_ _0350_ _0592_ VDD VSS AOI21_X1
X_1524_ _0325_ _0332_ _0224_ _0593_ VDD VSS MUX2_X1
X_1525_ _0335_ _0591_ _0592_ _0593_ _0371_ _0594_ VDD VSS
+ AOI221_X2
X_1526_ _0069_ _0068_ _0148_ _0595_ VDD VSS MUX2_X1
X_1527_ _0569_ _0595_ _0709_ _0596_ VDD VSS MUX2_X1
X_1528_ _0492_ _0596_ _0188_ _0597_ VDD VSS MUX2_X1
X_1529_ _0301_ _0597_ _0294_ _0598_ VDD VSS MUX2_X1
X_1530_ _0192_ _0598_ _0599_ VDD VSS NAND2_X1
X_1531_ _0310_ _0316_ _0226_ _0600_ VDD VSS MUX2_X1
X_1532_ _0306_ _0303_ _0392_ net48 _0089_ _0601_ VDD VSS AOI221_X2
X_1533_ _0594_ _0601_ _0599_ net18 VDD VSS AOI21_X2
X_1534_ _0582_ _0538_ _0539_ _0602_ VDD VSS OR3_X1
X_1535_ _0385_ _0085_ _0603_ VDD VSS AND2_X1
X_1536_ _0101_ _0117_ net54 _0604_ VDD VSS MUX2_X1
X_1537_ _0100_ _0604_ _0132_ _0605_ VDD VSS MUX2_X1
X_1538_ _0093_ _0240_ _0274_ _0606_ VDD VSS MUX2_X1
X_1539_ _0605_ _0606_ _0226_ _0607_ VDD VSS MUX2_X1
X_1540_ _0118_ _0094_ net54 _0608_ VDD VSS MUX2_X1
X_1541_ _0116_ _0608_ _0132_ _0609_ VDD VSS MUX2_X1
X_1542_ _0416_ _0609_ _0105_ _0610_ VDD VSS MUX2_X1
X_1543_ _0607_ _0610_ _0125_ _0611_ VDD VSS MUX2_X1
X_1544_ _0306_ _0603_ _0394_ _0611_ _0089_ _0612_ VDD VSS
+ AOI221_X2
X_1545_ _0118_ _0094_ _0172_ _0613_ VDD VSS MUX2_X1
X_1546_ _0181_ _0613_ _0132_ _0614_ VDD VSS MUX2_X1
X_1547_ _0188_ _0614_ _0615_ VDD VSS NOR2_X1
X_1548_ _0101_ _0117_ _0739_ _0616_ VDD VSS MUX2_X1
X_1549_ _0185_ _0616_ _0132_ _0617_ VDD VSS MUX2_X1
X_1550_ _0213_ _0617_ _0618_ VDD VSS NOR2_X1
X_1551_ _0475_ _0615_ _0618_ _0619_ VDD VSS NOR3_X1
X_1552_ _0176_ _0291_ _0132_ _0620_ VDD VSS MUX2_X1
X_1553_ _0409_ _0620_ _0179_ _0621_ VDD VSS MUX2_X1
X_1554_ _0619_ _0621_ _0475_ _0622_ VDD VSS AOI21_X1
X_1555_ _0564_ _0622_ _0192_ _0623_ VDD VSS MUX2_X1
X_1556_ _0336_ _0146_ _0394_ _0624_ VDD VSS AOI21_X2
X_1557_ _0602_ _0612_ _0623_ _0624_ net19 VDD VSS AOI22_X4
X_1558_ _0780_ _0307_ _0382_ _0625_ VDD VSS AOI21_X2
X_1559_ _0352_ _0518_ _0626_ VDD VSS AND2_X1
X_1560_ _0064_ _0072_ net68 _0627_ VDD VSS MUX2_X1
X_1561_ _0587_ _0627_ _0120_ _0628_ VDD VSS MUX2_X1
X_1562_ _0626_ _0628_ _0218_ _0629_ VDD VSS AOI21_X2
X_1563_ _0088_ _0256_ _0630_ VDD VSS NAND2_X2
X_1564_ _0125_ _0384_ _0631_ VDD VSS NAND2_X1
X_1565_ _0390_ _0631_ _0632_ VDD VSS AND2_X1
X_1566_ _0256_ _0037_ _0633_ VDD VSS NAND2_X1
X_1567_ _0625_ _0629_ _0630_ _0632_ _0633_ _0634_ VDD VSS
+ OAI221_X2
X_1568_ _0190_ _0373_ _0635_ VDD VSS AND2_X1
X_1569_ _0158_ _0214_ _0636_ VDD VSS AND2_X1
X_1570_ _0135_ _0266_ _0217_ _0637_ VDD VSS AND3_X1
X_1571_ _0047_ _0637_ _0638_ VDD VSS NAND2_X1
X_1572_ _0067_ _0140_ _0136_ _0639_ VDD VSS OAI21_X1
X_1573_ _0145_ _0638_ _0639_ _0640_ VDD VSS AOI21_X1
X_1574_ _0360_ _0361_ _0363_ _0641_ VDD VSS AND3_X1
X_1575_ _0145_ _0450_ _0642_ VDD VSS OR2_X1
X_1576_ _0057_ _0643_ VDD VSS INV_X1
X_1577_ _0780_ _0278_ _0641_ _0642_ _0643_ _0644_ VDD VSS
+ OAI221_X2
X_1578_ _0064_ _0072_ _0161_ _0645_ VDD VSS MUX2_X1
X_1579_ _0595_ _0645_ _0152_ _0646_ VDD VSS MUX2_X1
X_1580_ _0532_ _0646_ _0168_ _0647_ VDD VSS MUX2_X1
X_1581_ _0369_ _0647_ _0190_ _0648_ VDD VSS MUX2_X1
X_1582_ _0634_ _0635_ _0636_ _0640_ _0644_ _0648_ _0649_ VDD
+ VSS OAI33_X1
X_1583_ _0634_ _0640_ _0644_ _0650_ VDD VSS OAI21_X1
X_1584_ _0649_ _0650_ _0511_ net20 VDD VSS AOI21_X2
X_1585_ _0080_ _0124_ _0418_ _0651_ VDD VSS NOR3_X1
X_1586_ _0651_ _0080_ _0426_ _0652_ VDD VSS AOI21_X2
X_1587_ _0780_ _0145_ _0652_ _0653_ VDD VSS OAI21_X2
X_1588_ _0061_ _0069_ _0161_ _0654_ VDD VSS MUX2_X1
X_1589_ _0645_ _0654_ _0157_ _0655_ VDD VSS MUX2_X1
X_1590_ _0545_ _0655_ _0207_ _0656_ VDD VSS MUX2_X1
X_1591_ _0435_ _0656_ _0198_ _0657_ VDD VSS MUX2_X1
X_1592_ _0653_ _0431_ _0333_ _0371_ _0657_ _0658_ VDD VSS
+ AOI221_X2
X_1593_ _0061_ _0069_ net54 _0659_ VDD VSS MUX2_X1
X_1594_ _0627_ _0659_ _0103_ _0660_ VDD VSS MUX2_X1
X_1595_ _0517_ _0550_ net42 _0661_ VDD VSS MUX2_X1
X_1596_ _0660_ _0661_ _0124_ _0662_ VDD VSS MUX2_X1
X_1597_ _0397_ _0662_ _0234_ _0663_ VDD VSS MUX2_X1
X_1598_ _0128_ _0307_ _0401_ _0663_ _0312_ _0664_ VDD VSS
+ AOI221_X2
X_1599_ _0405_ _0413_ _0475_ _0665_ VDD VSS MUX2_X1
X_1600_ _0192_ _0665_ _0666_ VDD VSS NAND2_X1
X_1601_ _0658_ _0664_ _0666_ net21 VDD VSS AOI21_X2
X_1602_ _0333_ _0476_ _0477_ _0667_ VDD VSS NAND3_X1
X_1603_ _0226_ _0075_ _0246_ _0668_ VDD VSS AND3_X1
X_1604_ _0668_ _0469_ _0080_ _0669_ VDD VSS AOI21_X2
X_1605_ _0667_ _0669_ _0145_ _0670_ VDD VSS OAI21_X1
X_1606_ _0129_ _0670_ _0671_ VDD VSS NAND2_X1
X_1607_ _0234_ _0227_ _0454_ _0672_ VDD VSS NOR3_X1
X_1608_ _0065_ _0064_ net54 _0673_ VDD VSS MUX2_X1
X_1609_ _0659_ _0673_ _0152_ _0674_ VDD VSS MUX2_X1
X_1610_ _0550_ _0574_ _0183_ _0675_ VDD VSS MUX2_X1
X_1611_ _0674_ _0675_ _0352_ _0676_ VDD VSS MUX2_X1
X_1612_ _0219_ _0676_ _0678_ VDD VSS NAND2_X1
X_1613_ _0439_ _0446_ _0352_ _0679_ VDD VSS MUX2_X1
X_1614_ _0227_ _0679_ _0680_ VDD VSS NAND2_X1
X_1615_ _0349_ _0678_ _0680_ _0681_ VDD VSS AOI21_X1
X_1616_ _0143_ _0672_ _0681_ _0682_ VDD VSS OAI21_X2
X_1617_ _0224_ _0385_ _0683_ VDD VSS AND2_X1
X_1618_ _0170_ _0459_ _0683_ _0245_ _0684_ VDD VSS AOI22_X2
X_1619_ _0128_ _0684_ _0685_ VDD VSS NOR2_X1
X_1620_ _0065_ _0064_ _0148_ _0686_ VDD VSS MUX2_X1
X_1621_ _0654_ _0686_ _0152_ _0687_ VDD VSS MUX2_X1
X_1622_ _0570_ _0687_ _0168_ _0689_ VDD VSS MUX2_X1
X_1623_ _0481_ _0689_ _0199_ _0690_ VDD VSS MUX2_X1
X_1624_ _0685_ _0690_ _0336_ _0691_ VDD VSS AOI21_X2
X_1625_ _0671_ _0682_ _0129_ _0511_ _0691_ net22 VDD VSS OAI221_X2
X_1626_ _0077_ _0313_ _0265_ _0692_ VDD VSS NOR3_X1
X_1627_ _0692_ _0506_ _0170_ _0693_ VDD VSS AOI21_X2
X_1628_ _0336_ _0693_ _0694_ VDD VSS NOR2_X1
X_1629_ _0062_ _0061_ _0172_ _0695_ VDD VSS MUX2_X1
X_1630_ _0686_ _0695_ _0709_ _0696_ VDD VSS MUX2_X1
X_1631_ _0596_ _0696_ _0179_ _0697_ VDD VSS MUX2_X1
X_1632_ _0493_ _0697_ _0199_ _0699_ VDD VSS MUX2_X1
X_1633_ _0694_ _0699_ _0129_ _0700_ VDD VSS AOI21_X2
X_1634_ _0062_ _0061_ net54 _0701_ VDD VSS MUX2_X1
X_1635_ _0673_ _0701_ _0202_ _0702_ VDD VSS MUX2_X1
X_1636_ _0498_ _0702_ _0105_ _0703_ VDD VSS MUX2_X1
X_1637_ _0344_ _0588_ _0105_ _0704_ VDD VSS MUX2_X1
X_1638_ _0703_ _0704_ _0352_ _0705_ VDD VSS MUX2_X1
X_1639_ _0219_ _0495_ _0706_ VDD VSS AND2_X1
X_1640_ _0705_ _0706_ _0349_ _0707_ VDD VSS MUX2_X1
X_1641_ _0336_ _0143_ _0707_ _0708_ VDD VSS AOI21_X4
X_1642_ _0217_ _0314_ _0710_ VDD VSS AND2_X1
X_1643_ _0484_ _0710_ _0227_ _0711_ VDD VSS MUX2_X1
X_1644_ _0195_ _0333_ _0490_ net51 _0089_ _0712_ VDD VSS AOI221_X2
X_1645_ _0511_ _0700_ _0708_ _0712_ net23 VDD VSS OAI22_X4
X_1646_ _0475_ _0134_ _0385_ _0713_ VDD VSS AND3_X1
X_1647_ _0713_ _0530_ _0294_ _0714_ VDD VSS AOI21_X2
X_1648_ _0473_ _0714_ _0715_ VDD VSS NAND2_X1
X_1649_ _0052_ _0065_ _0150_ _0716_ VDD VSS MUX2_X1
X_1650_ _0695_ _0716_ _0709_ _0717_ VDD VSS MUX2_X1
X_1651_ _0646_ _0717_ _0374_ _0718_ VDD VSS MUX2_X1
X_1652_ _0533_ _0718_ _0294_ _0719_ VDD VSS MUX2_X1
X_1653_ _0715_ _0719_ _0511_ _0720_ VDD VSS OAI21_X2
X_1654_ _0144_ _0226_ _0721_ VDD VSS NOR2_X4
X_1655_ _0196_ net40 _0721_ _0722_ VDD VSS AOI21_X2
X_1656_ _0352_ _0387_ _0723_ VDD VSS NOR2_X2
X_1657_ _0512_ _0514_ _0133_ _0724_ VDD VSS MUX2_X1
X_1658_ _0219_ _0724_ _0725_ VDD VSS AND2_X1
X_1659_ _0038_ _0723_ _0725_ _0726_ VDD VSS OAI21_X2
X_1660_ _0052_ _0065_ net54 _0727_ VDD VSS MUX2_X1
X_1661_ _0701_ _0727_ _0202_ _0728_ VDD VSS MUX2_X1
X_1662_ _0518_ _0728_ _0079_ _0730_ VDD VSS MUX2_X1
X_1663_ _0520_ _0628_ _0105_ _0731_ VDD VSS MUX2_X1
X_1664_ _0730_ _0731_ _0352_ _0732_ VDD VSS MUX2_X1
X_1665_ _0335_ _0159_ _0085_ _0732_ _0089_ _0733_ VDD VSS
+ AOI221_X2
X_1666_ _0720_ _0722_ _0726_ _0733_ net24 VDD VSS AOI22_X4
X_1667_ _0190_ _0543_ _0683_ _0394_ _0734_ VDD VSS AOI22_X2
X_1668_ _0473_ _0734_ _0735_ VDD VSS NAND2_X1
X_1669_ _0048_ _0062_ _0150_ _0736_ VDD VSS MUX2_X1
X_1670_ _0716_ _0736_ _0202_ _0737_ VDD VSS MUX2_X1
X_1671_ _0655_ _0737_ _0374_ _0738_ VDD VSS MUX2_X1
X_1672_ _0546_ _0738_ _0294_ _0740_ VDD VSS MUX2_X1
X_1673_ _0735_ _0740_ _0511_ _0741_ VDD VSS OAI21_X1
X_1674_ _0124_ _0418_ _0742_ VDD VSS NAND2_X1
X_1675_ _0742_ _0425_ _0124_ _0743_ VDD VSS OAI21_X2
X_1676_ _0336_ _0743_ _0630_ _0744_ VDD VSS OAI21_X1
X_1677_ _0744_ _0745_ VDD VSS INV_X1
X_1678_ _0336_ _0085_ _0563_ _0746_ VDD VSS AOI21_X1
X_1679_ _0637_ _0395_ _0554_ _0219_ _0747_ VDD VSS AOI22_X2
X_1680_ _0582_ _0747_ _0748_ VDD VSS NOR2_X1
X_1681_ _0048_ _0062_ _0099_ _0749_ VDD VSS MUX2_X1
X_1682_ _0727_ _0749_ _0709_ _0751_ VDD VSS MUX2_X1
X_1683_ _0660_ _0751_ _0217_ _0752_ VDD VSS MUX2_X1
X_1684_ _0552_ _0752_ _0219_ _0753_ VDD VSS MUX2_X1
X_1685_ _0748_ _0753_ _0255_ _0754_ VDD VSS AOI21_X2
X_1686_ _0741_ _0745_ _0746_ _0754_ net25 VDD VSS AOI22_X2
X_1687_ _0195_ _0035_ _0277_ _0755_ VDD VSS OAI21_X1
X_1688_ _0053_ _0052_ net54 _0756_ VDD VSS MUX2_X1
X_1689_ _0749_ _0756_ _0152_ _0757_ VDD VSS MUX2_X1
X_1690_ _0674_ _0757_ _0075_ _0758_ VDD VSS MUX2_X1
X_1691_ _0576_ _0758_ _0256_ _0759_ VDD VSS MUX2_X1
X_1692_ _0755_ _0270_ _0038_ _0759_ _0089_ _0760_ VDD VSS
+ AOI221_X2
X_1693_ _0196_ _0250_ _0721_ _0761_ VDD VSS AOI21_X1
X_1694_ _0473_ _0215_ _0762_ VDD VSS NAND2_X1
X_1695_ _0053_ _0052_ _0172_ _0763_ VDD VSS MUX2_X1
X_1696_ _0736_ _0763_ _0103_ _0764_ VDD VSS MUX2_X1
X_1697_ _0687_ _0764_ _0374_ _0765_ VDD VSS MUX2_X1
X_1698_ _0571_ _0765_ _0294_ _0766_ VDD VSS MUX2_X1
X_1699_ _0762_ _0766_ _0511_ _0767_ VDD VSS OAI21_X2
X_1700_ _0760_ _0761_ _0767_ net26 VDD VSS AOI21_X2
X_1701_ _0473_ _0304_ _0768_ VDD VSS NAND2_X1
X_1702_ _0049_ _0048_ _0172_ _0770_ VDD VSS MUX2_X1
X_1703_ _0763_ _0770_ _0183_ _0771_ VDD VSS MUX2_X1
X_1704_ _0696_ _0771_ _0374_ _0772_ VDD VSS MUX2_X1
X_1705_ _0597_ _0772_ _0199_ _0773_ VDD VSS MUX2_X1
X_1706_ _0768_ _0773_ _0473_ _0774_ VDD VSS OAI21_X2
X_1707_ _0196_ _0316_ _0721_ _0775_ VDD VSS AOI21_X2
X_1708_ _0335_ _0085_ _0332_ _0346_ _0038_ _0776_ VDD VSS
+ AOI221_X2
X_1709_ _0049_ _0048_ net54 _0777_ VDD VSS MUX2_X1
X_1710_ _0756_ _0777_ _0202_ _0778_ VDD VSS MUX2_X1
X_1711_ _0588_ _0778_ _0105_ _0779_ VDD VSS MUX2_X1
X_1712_ _0703_ _0779_ _0218_ _0781_ VDD VSS MUX2_X1
X_1713_ _0255_ _0781_ _0782_ VDD VSS NAND2_X2
X_1714_ _0774_ _0775_ _0776_ _0782_ net27 VDD VSS AOI22_X4
X_1715_ _0213_ _0035_ _0783_ VDD VSS NOR2_X2
X_1716_ _0335_ _0391_ _0038_ _0783_ _0158_ _0784_ VDD VSS
+ AOI221_X2
X_1717_ _0039_ _0053_ _0099_ _0785_ VDD VSS MUX2_X1
X_1718_ _0777_ _0785_ net44 _0786_ VDD VSS MUX2_X1
X_1719_ _0628_ _0786_ _0256_ _0787_ VDD VSS MUX2_X1
X_1720_ _0730_ _0787_ _0218_ _0788_ VDD VSS MUX2_X1
X_1721_ _0255_ _0788_ _0789_ VDD VSS NAND2_X1
X_1722_ _0039_ _0053_ _0148_ _0791_ VDD VSS MUX2_X1
X_1723_ _0770_ _0791_ _0709_ _0792_ VDD VSS MUX2_X1
X_1724_ _0717_ _0792_ _0179_ _0793_ VDD VSS MUX2_X1
X_1725_ _0647_ _0793_ _0170_ _0794_ VDD VSS MUX2_X1
X_1726_ _0370_ _0794_ _0371_ _0795_ VDD VSS MUX2_X1
X_1727_ _0795_ _0796_ VDD VSS INV_X1
X_1728_ _0141_ _0145_ _0797_ VDD VSS NOR2_X2
X_1729_ _0196_ _0797_ _0047_ _0798_ VDD VSS AOI21_X2
X_1730_ _0784_ _0789_ _0796_ _0798_ net28 VDD VSS AOI22_X4
X_1731_ _0043_ _0049_ _0148_ _0799_ VDD VSS MUX2_X1
X_1732_ _0791_ _0799_ _0152_ _0801_ VDD VSS MUX2_X1
X_1733_ _0737_ _0801_ _0207_ _0802_ VDD VSS MUX2_X1
X_1734_ _0656_ _0802_ _0198_ _0803_ VDD VSS MUX2_X1
X_1735_ _0436_ _0803_ _0371_ _0804_ VDD VSS MUX2_X1
X_1736_ _0125_ _0418_ _0630_ _0805_ VDD VSS NOR3_X1
X_1737_ _0196_ _0804_ _0805_ _0806_ VDD VSS NOR3_X2
X_1738_ _0043_ _0049_ _0099_ _0807_ VDD VSS MUX2_X1
X_1739_ _0785_ _0807_ net44 _0808_ VDD VSS MUX2_X1
X_1740_ _0751_ _0808_ _0217_ _0809_ VDD VSS MUX2_X1
X_1741_ _0662_ _0809_ _0219_ _0810_ VDD VSS MUX2_X1
X_1742_ _0038_ net57 _0810_ _0255_ _0812_ VDD VSS AOI22_X4
X_1743_ _0336_ _0783_ _0562_ _0813_ VDD VSS AOI21_X2
X_1744_ _0806_ _0812_ _0813_ net29 VDD VSS AOI21_X4
X_1745_ _0374_ _0085_ _0814_ VDD VSS NAND2_X1
X_1746_ _0780_ _0211_ _0814_ _0815_ VDD VSS OAI21_X1
X_1747_ _0098_ _0114_ net3 _0816_ VDD VSS MUX2_X1
X_1748_ _0604_ _0816_ _0274_ _0817_ VDD VSS MUX2_X1
X_1749_ _0241_ _0817_ _0079_ _0818_ VDD VSS MUX2_X1
X_1750_ _0115_ _0090_ _0045_ _0819_ VDD VSS MUX2_X1
X_1751_ _0608_ _0819_ _0274_ _0820_ VDD VSS MUX2_X1
X_1752_ _0230_ _0820_ _0079_ _0822_ VDD VSS MUX2_X1
X_1753_ _0818_ _0822_ _0352_ _0823_ VDD VSS MUX2_X1
X_1754_ _0815_ _0823_ _0088_ _0038_ _0568_ _0824_ VDD VSS
+ AOI221_X2
X_1755_ _0475_ _0293_ _0825_ VDD VSS NAND2_X1
X_1756_ _0115_ _0090_ _0172_ _0826_ VDD VSS MUX2_X1
X_1757_ _0613_ _0826_ _0132_ _0827_ VDD VSS MUX2_X1
X_1758_ _0098_ _0114_ _0739_ _0828_ VDD VSS MUX2_X1
X_1759_ _0616_ _0828_ _0133_ _0829_ VDD VSS MUX2_X1
X_1760_ _0827_ _0829_ _0374_ _0830_ VDD VSS MUX2_X1
X_1761_ _0294_ _0830_ _0831_ VDD VSS NAND2_X1
X_1762_ _0197_ _0825_ _0831_ _0833_ VDD VSS AOI21_X1
X_1763_ _0833_ _0585_ _0511_ _0834_ VDD VSS AOI21_X1
X_1764_ _0336_ _0797_ _0581_ _0835_ VDD VSS AOI21_X1
X_1765_ _0824_ _0834_ _0835_ net30 VDD VSS AOI21_X2
X_1766_ _0197_ _0478_ _0482_ _0836_ VDD VSS NAND3_X1
X_1767_ _0475_ _0689_ _0837_ VDD VSS NAND2_X1
X_1768_ _0040_ _0039_ _0172_ _0838_ VDD VSS MUX2_X1
X_1769_ _0799_ _0838_ net42 _0839_ VDD VSS MUX2_X1
X_1770_ _0764_ _0839_ _0168_ _0840_ VDD VSS MUX2_X1
X_1771_ _0190_ _0840_ _0841_ VDD VSS NAND2_X1
X_1772_ _0894_ _0837_ _0841_ _0843_ VDD VSS NAND3_X1
X_1773_ _0306_ _0146_ _0245_ _0836_ _0843_ _0844_ VDD VSS
+ AOI221_X2
X_1774_ _0040_ _0039_ _0099_ _0845_ VDD VSS MUX2_X1
X_1775_ _0807_ _0845_ _0709_ _0846_ VDD VSS MUX2_X1
X_1776_ _0757_ _0846_ _0218_ _0847_ VDD VSS MUX2_X1
X_1777_ _0676_ _0847_ _0219_ _0848_ VDD VSS MUX2_X1
X_1778_ _0446_ _0450_ _0849_ VDD VSS NOR2_X1
X_1779_ _0582_ _0849_ _0850_ VDD VSS NOR2_X1
X_1780_ _0445_ _0454_ _0227_ _0851_ VDD VSS AOI21_X1
X_1781_ _0848_ _0255_ _0850_ _0851_ _0852_ VDD VSS AOI22_X4
X_1782_ _0336_ _0603_ _0245_ _0854_ VDD VSS AOI21_X1
X_1783_ _0844_ _0852_ _0854_ net31 VDD VSS AOI21_X4
X_1784_ _0044_ _0043_ _0739_ _0855_ VDD VSS MUX2_X1
X_1785_ _0838_ _0855_ _0183_ _0856_ VDD VSS MUX2_X1
X_1786_ _0771_ _0856_ _0188_ _0857_ VDD VSS MUX2_X1
X_1787_ _0697_ _0857_ _0170_ _0858_ VDD VSS MUX2_X1
X_1788_ _0494_ _0858_ _0371_ _0859_ VDD VSS MUX2_X1
X_1789_ _0859_ _0860_ VDD VSS INV_X1
X_1790_ _0196_ _0146_ _0502_ _0861_ VDD VSS AOI21_X2
X_1791_ _0582_ _0496_ _0499_ _0500_ _0862_ VDD VSS OR4_X2
X_1792_ _0044_ _0043_ _0099_ _0864_ VDD VSS MUX2_X1
X_1793_ _0845_ _0864_ _0152_ _0865_ VDD VSS MUX2_X1
X_1794_ _0702_ _0865_ _0105_ _0866_ VDD VSS MUX2_X1
X_1795_ _0779_ _0866_ _0218_ _0867_ VDD VSS MUX2_X1
X_1796_ _0335_ _0603_ _0502_ _0089_ _0867_ _0868_ VDD VSS
+ AOI221_X2
X_1797_ _0860_ _0861_ _0868_ _0862_ net32 VDD VSS AOI22_X4
X_1798_ _0096_ _0819_ net2 _0869_ VDD VSS MUX2_X1
X_1799_ _0119_ _0816_ _0056_ _0870_ VDD VSS MUX2_X1
X_1800_ _0869_ _0870_ _0059_ _0871_ VDD VSS MUX2_X1
X_1801_ _0319_ _0871_ _0105_ _0872_ VDD VSS MUX2_X1
X_1802_ _0600_ _0872_ _0234_ _0874_ VDD VSS MUX2_X1
X_1803_ _0306_ _0303_ _0783_ _0143_ _0874_ _0875_ VDD VSS
+ AOI221_X2
X_1804_ _0129_ _0797_ net66 _0876_ VDD VSS AOI21_X1
X_1805_ _0177_ _0826_ _0103_ _0877_ VDD VSS MUX2_X1
X_1806_ _0374_ _0877_ _0878_ VDD VSS NOR2_X1
X_1807_ _0182_ _0828_ _0183_ _0879_ VDD VSS MUX2_X1
X_1808_ _0213_ _0879_ _0880_ VDD VSS NOR2_X1
X_1809_ _0035_ _0878_ _0880_ _0881_ VDD VSS NOR3_X2
X_1810_ _0328_ _0332_ _0811_ _0882_ VDD VSS MUX2_X1
X_1811_ _0881_ _0882_ _0475_ _0333_ _0325_ _0883_ VDD VSS
+ AOI221_X2
X_1812_ _0875_ _0876_ _0883_ net33 VDD VSS AOI21_X2
X_1813_ _0780_ _0035_ _0641_ _0885_ VDD VSS OAI21_X1
X_1814_ _0074_ _0097_ _0079_ _0886_ VDD VSS MUX2_X1
X_1815_ _0122_ _0886_ _0352_ _0887_ VDD VSS MUX2_X1
X_1816_ _0643_ _0450_ _0888_ VDD VSS OR2_X1
X_1817_ _0638_ _0639_ _0888_ _0889_ VDD VSS NAND3_X1
X_1818_ _0885_ _0887_ _0088_ _0038_ _0889_ _0890_ VDD VSS
+ AOI221_X2
X_1819_ _0632_ _0630_ _0891_ VDD VSS NOR2_X1
X_1820_ _0129_ _0891_ _0892_ VDD VSS NOR2_X1
X_1821_ _0371_ _0635_ _0636_ _0893_ VDD VSS OR3_X1
X_1822_ _0178_ _0184_ _0374_ _0895_ VDD VSS MUX2_X1
X_1823_ _0375_ _0895_ _0294_ _0896_ VDD VSS MUX2_X1
X_1824_ _0893_ _0896_ _0511_ _0897_ VDD VSS OAI21_X2
X_1825_ _0890_ _0892_ _0897_ net34 VDD VSS AOI21_X4
X_1826_ _0306_ _0085_ _0431_ _0898_ VDD VSS AOI21_X1
X_1827_ _0898_ _0652_ _0582_ _0899_ VDD VSS OAI21_X1
X_1828_ _0421_ _0606_ _0079_ _0900_ VDD VSS MUX2_X1
X_1829_ _0610_ _0900_ _0125_ _0901_ VDD VSS MUX2_X1
X_1830_ _0899_ _0901_ _0255_ _0902_ VDD VSS AOI21_X2
X_1831_ _0129_ _0397_ _0721_ _0903_ VDD VSS AOI21_X2
X_1832_ _0620_ _0614_ _0188_ _0905_ VDD VSS MUX2_X1
X_1833_ _0410_ _0905_ _0170_ _0906_ VDD VSS MUX2_X1
X_1834_ _0665_ _0906_ _0192_ _0907_ VDD VSS MUX2_X1
X_1835_ _0907_ _0908_ VDD VSS INV_X1
X_1836_ _0902_ _0903_ _0908_ net35 VDD VSS AOI21_X4
X_1837_ _0195_ _0454_ _0630_ _0909_ VDD VSS OAI21_X1
X_1838_ _0475_ _0460_ _0910_ VDD VSS NAND2_X1
X_1839_ _0292_ _0827_ _0188_ _0911_ VDD VSS MUX2_X1
X_1840_ _0199_ _0911_ _0912_ VDD VSS NAND2_X1
X_1841_ _0371_ _0910_ _0912_ _0913_ VDD VSS NAND3_X1
X_1842_ _0197_ _0684_ _0915_ VDD VSS NAND2_X1
X_1843_ _0909_ _0913_ _0915_ _0916_ VDD VSS AOI21_X2
X_1844_ _0085_ _0476_ _0477_ _0917_ VDD VSS NAND3_X1
X_1845_ _0335_ _0917_ _0918_ VDD VSS AND2_X1
X_1846_ _0234_ _0669_ _0919_ VDD VSS NOR2_X1
X_1847_ _0242_ _0822_ _0217_ _0920_ VDD VSS MUX2_X1
X_1848_ _0919_ _0920_ _0234_ _0921_ VDD VSS AOI21_X2
X_1849_ _0196_ _0143_ _0922_ VDD VSS NOR2_X1
X_1850_ _0916_ _0918_ _0921_ _0922_ _0917_ net36 VDD VSS AOI221_X2
X_1851_ _0197_ _0693_ _0923_ VDD VSS NAND2_X1
X_1852_ _0327_ _0877_ _0179_ _0001_ VDD VSS MUX2_X1
X_1853_ _0035_ _0001_ _0002_ VDD VSS NOR2_X1
X_1854_ _0811_ _0170_ _0507_ _0003_ VDD VSS NOR3_X1
X_1855_ _0002_ _0003_ _0004_ VDD VSS NOR2_X2
X_1856_ _0335_ _0495_ _0721_ _0923_ _0004_ _0005_ VDD VSS
+ AOI221_X2
X_1857_ _0318_ _0869_ _0075_ _0006_ VDD VSS MUX2_X1
X_1858_ _0487_ _0006_ _0256_ _0007_ VDD VSS MUX2_X1
X_1859_ _0711_ _0007_ _0234_ _0008_ VDD VSS MUX2_X1
X_1860_ _0085_ _0490_ _0008_ _0143_ _0009_ VDD VSS AOI22_X2
X_1861_ _0005_ _0009_ _0129_ net37 VDD VSS AOI21_X2
X_1862_ _0219_ _0060_ _0038_ _0011_ VDD VSS NAND3_X1
X_1863_ _0128_ _0011_ _0012_ VDD VSS AND2_X1
X_1864_ _0067_ _0113_ _0080_ _0013_ VDD VSS MUX2_X1
X_1865_ _0255_ _0218_ _0013_ _0097_ _0141_ _0014_ VDD VSS
+ OAI221_X1
X_1866_ _0074_ _0267_ _0015_ VDD VSS NOR2_X1
X_1867_ _0012_ _0014_ _0015_ _0473_ _0714_ _0016_ VDD VSS
+ OAI221_X1
X_1868_ _0159_ _0333_ _0017_ VDD VSS NAND2_X1
X_1869_ _0769_ _0088_ _0723_ _0724_ _0721_ _0018_ VDD VSS
+ AOI221_X2
X_1870_ _0169_ _0180_ _0199_ _0019_ VDD VSS MUX2_X1
X_1871_ _0019_ _0020_ VDD VSS INV_X1
X_1872_ _0017_ _0018_ _0020_ _0473_ _0022_ VDD VSS OAI211_X2
X_1873_ _0016_ _0022_ net38 VDD VSS AND2_X2
X_1874_ _0416_ _0424_ _0225_ _0023_ VDD VSS MUX2_X1
X_1875_ _0088_ _0125_ _0023_ _0024_ VDD VSS NAND3_X1
X_1876_ _0024_ _0633_ _0743_ _0025_ VDD VSS OAI21_X1
X_1877_ _0088_ _0218_ _0900_ _0026_ VDD VSS AND3_X2
X_1878_ _0335_ _0734_ _0027_ VDD VSS NAND2_X1
X_1879_ _0025_ _0026_ _0027_ _0028_ VDD VSS OR3_X1
X_1880_ _0128_ _0333_ _0563_ _0029_ VDD VSS AOI21_X1
X_1881_ _0560_ _0621_ _0170_ _0030_ VDD VSS MUX2_X1
X_1882_ _0030_ _0032_ VDD VSS INV_X1
X_1883_ _0029_ _0032_ _0473_ _0145_ _0747_ _0033_ VDD VSS
+ OAI221_X1
X_1884_ _0192_ _0306_ _0025_ _0026_ _0034_ VDD VSS OR4_X2
X_1885_ _0034_ _0033_ _0028_ net39 VDD VSS AND3_X4
X_1886_ _0709_ _0925_ _0926_ _0927_ VDD VSS HA_X1
Xclone1 _0927_ net1 VDD VSS BUF_X2
Xclone2 _0677_ net2 VDD VSS INV_X2
Xclone4 _0688_ net4 VDD VSS BUF_X4
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Right_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Right_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Right_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Right_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Right_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Right_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Right_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Right_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Right_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Right_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_213 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_214 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_215 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_216 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_217 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_218 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_219 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_220 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_221 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_222 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_223 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_107_Left_224 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_108_Left_225 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_109_Left_226 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_110_Left_227 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_111_Left_228 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_112_Left_229 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_113_Left_230 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_114_Left_231 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_115_Left_232 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_116_Left_233 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_234 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_235 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_236 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_237 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_238 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_239 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_240 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_241 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_242 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_243 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_244 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_245 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_246 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_247 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_248 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_249 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_250 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_251 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_252 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_253 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_254 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_255 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_256 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_257 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_258 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_259 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_260 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_261 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_262 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_263 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_264 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_265 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_266 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_267 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_268 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_269 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_270 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_271 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_272 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_273 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_274 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_275 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_276 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_277 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_278 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_279 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_280 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_281 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_282 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_283 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_284 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_285 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_286 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_287 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_108_288 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_110_289 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_112_290 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_114_291 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_116_292 VDD VSS TAPCELL_X1
Xinput1 data_in[1] net5 VDD VSS CLKBUF_X3
Xinput2 rotate net6 VDD VSS CLKBUF_X2
Xinput3 shift_amount[2] net7 VDD VSS BUF_X2
Xoutput4 net8 data_out[0] VDD VSS BUF_X1
Xoutput5 net9 data_out[10] VDD VSS BUF_X1
Xoutput6 net10 data_out[11] VDD VSS BUF_X1
Xoutput7 net11 data_out[12] VDD VSS BUF_X1
Xoutput8 net12 data_out[13] VDD VSS BUF_X2
Xoutput9 net13 data_out[14] VDD VSS BUF_X1
Xoutput10 net14 data_out[15] VDD VSS BUF_X1
Xoutput11 net15 data_out[16] VDD VSS BUF_X1
Xoutput12 net16 data_out[17] VDD VSS BUF_X1
Xoutput13 net17 data_out[18] VDD VSS BUF_X1
Xoutput14 net18 data_out[19] VDD VSS BUF_X1
Xoutput15 net19 data_out[1] VDD VSS BUF_X1
Xoutput16 net20 data_out[20] VDD VSS BUF_X1
Xoutput17 net21 data_out[21] VDD VSS BUF_X1
Xoutput18 net22 data_out[22] VDD VSS BUF_X1
Xoutput19 net23 data_out[23] VDD VSS BUF_X2
Xoutput20 net24 data_out[24] VDD VSS BUF_X1
Xoutput21 net25 data_out[25] VDD VSS BUF_X1
Xoutput22 net26 data_out[26] VDD VSS BUF_X1
Xoutput23 net27 data_out[27] VDD VSS BUF_X1
Xoutput24 net28 data_out[28] VDD VSS BUF_X1
Xoutput25 net29 data_out[29] VDD VSS BUF_X1
Xoutput26 net30 data_out[2] VDD VSS BUF_X1
Xoutput27 net31 data_out[30] VDD VSS BUF_X1
Xoutput28 net32 data_out[31] VDD VSS BUF_X2
Xoutput29 net33 data_out[3] VDD VSS BUF_X1
Xoutput30 net34 data_out[4] VDD VSS BUF_X1
Xoutput31 net35 data_out[5] VDD VSS BUF_X1
Xoutput32 net36 data_out[6] VDD VSS BUF_X1
Xoutput33 net37 data_out[7] VDD VSS BUF_X1
Xoutput34 net38 data_out[8] VDD VSS BUF_X1
Xoutput35 net39 data_out[9] VDD VSS BUF_X1
Xrebuffer1 _0060_ net40 VDD VSS BUF_X1
Xrebuffer2 _0046_ net41 VDD VSS BUF_X1
Xclone5 _0698_ net42 VDD VSS BUF_X16
Xrebuffer11 _0600_ net48 VDD VSS BUF_X2
Xrebuffer14 _0711_ net51 VDD VSS BUF_X1
Xrebuffer17 _0045_ net54 VDD VSS BUF_X8
Xrebuffer20 _0402_ net57 VDD VSS BUF_X2
Xrebuffer28 _0338_ net65 VDD VSS BUF_X1
Xrebuffer29 net65 net66 VDD VSS BUF_X1
Xrebuffer68 _0058_ net105 VDD VSS BUF_X4
Xclone27 net69 net68 VDD VSS BUF_X4
Xclone28 net70 net69 VDD VSS BUF_X4
Xrebuffer30 _0927_ net70 VDD VSS BUF_X1
.ENDS barrel_shifter
