* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT digital_thermometer_controller adc_valid adc_value[0]
+ adc_value[1] adc_value[2] adc_value[3] adc_value[4] adc_value[5]
+ adc_value[6] adc_value[7] adc_value[8] adc_value[9] alert
+ clk force_update rst_n status[0] status[1] status[2] temperature[0]
+ temperature[1] temperature[2] temperature[3] temperature[4]
+ temperature[5] temperature[6] temperature[7] units_select
+ update valid
X_129_ _087_ _093_ _029_ _030_ VDD VSS AOI21_X1
X_130_ _030_ celsius_value\[4\] _087_ _031_ VDD VSS AOI21_X1
X_131_ _078_ _031_ _022_ VDD VSS NOR2_X1
X_132_ net20 _091_ _032_ VDD VSS NAND2_X1
X_133_ _087_ _097_ _032_ _033_ VDD VSS AOI21_X1
X_134_ _082_ _033_ _023_ VDD VSS AND2_X1
X_135_ net10 _034_ VDD VSS INV_X1
X_136_ net8 net7 _034_ _083_ _035_ VDD VSS NAND4_X2
X_137_ net1 _036_ VDD VSS INV_X1
X_138_ net6 _037_ VDD VSS INV_X1
X_139_ _036_ net4 net3 _037_ _038_ VDD VSS NAND4_X2
X_140_ net2 net5 _035_ _038_ _039_ VDD VSS NOR4_X4
X_141_ input_count\[3\] input_count\[2\] _126_ _040_ VDD VSS
+ OR3_X1
X_142_ net22 _039_ _040_ _041_ VDD VSS AOI21_X1
X_143_ _078_ _041_ _026_ VDD VSS NOR2_X1
X_144_ net2 net5 _035_ _038_ _042_ VDD VSS OR4_X2
X_145_ net8 net7 _043_ VDD VSS NOR2_X1
X_146_ net6 net5 _043_ _044_ VDD VSS NAND3_X1
X_147_ net2 _034_ net9 _083_ _045_ VDD VSS NAND4_X2
X_148_ _036_ net4 net3 _046_ VDD VSS OR3_X1
X_149_ _044_ _045_ _046_ _047_ VDD VSS OR3_X1
X_150_ _074_ celsius_value\[0\] _042_ _047_ _048_ VDD VSS
+ NAND4_X1
X_151_ net9 _039_ _049_ VDD VSS NAND2_X1
X_152_ _074_ _050_ VDD VSS INV_X1
X_153_ _050_ _051_ VDD VSS CLKBUF_X3
X_154_ _048_ _049_ _051_ _003_ VDD VSS OAI21_X1
X_155_ _044_ _045_ _046_ _052_ VDD VSS NOR3_X2
X_156_ _052_ _042_ celsius_value\[1\] _053_ VDD VSS AOI21_X1
X_157_ _051_ _053_ _004_ VDD VSS NOR2_X1
X_158_ celsius_value\[2\] _054_ VDD VSS INV_X1
X_159_ _039_ _052_ _055_ VDD VSS NOR2_X1
X_160_ _051_ _054_ _055_ _005_ VDD VSS AOI21_X1
X_161_ celsius_value\[3\] _056_ VDD VSS INV_X1
X_162_ net9 _057_ VDD VSS INV_X1
X_163_ _050_ _056_ _055_ _039_ _057_ _006_ VDD VSS AOI221_X1
X_164_ celsius_value\[4\] _042_ _058_ VDD VSS NAND2_X1
X_165_ _052_ _039_ _057_ _059_ VDD VSS AOI21_X1
X_166_ _051_ _058_ _059_ _007_ VDD VSS AOI21_X1
X_167_ fahrenheit_value\[2\] _060_ VDD VSS INV_X1
X_168_ _051_ _060_ _059_ _008_ VDD VSS AOI21_X1
X_169_ fahrenheit_value\[1\] _042_ net9 _061_ VDD VSS OAI21_X1
X_170_ _051_ _047_ _061_ _009_ VDD VSS AOI21_X1
X_171_ initialized _062_ VDD VSS INV_X1
X_172_ _051_ _077_ _062_ _010_ VDD VSS AOI21_X1
X_173_ _083_ _000_ _063_ VDD VSS NAND2_X1
X_174_ _084_ input_count\[0\] _064_ VDD VSS NAND2_X1
X_175_ _050_ _063_ _064_ _011_ VDD VSS AOI21_X1
X_176_ _083_ _001_ _065_ VDD VSS NAND2_X1
X_177_ _084_ input_count\[1\] _066_ VDD VSS NAND2_X1
X_178_ _050_ _065_ _066_ _012_ VDD VSS AOI21_X1
X_179_ _083_ _126_ _067_ VDD VSS NAND2_X1
X_180_ _076_ _067_ _068_ VDD VSS XNOR2_X1
X_181_ _051_ _068_ _013_ VDD VSS NOR2_X1
X_182_ _083_ input_count\[2\] input_count\[1\] input_count\[0\]
+ _069_ VDD VSS NAND4_X1
X_183_ _075_ _069_ _070_ VDD VSS XNOR2_X1
X_184_ _051_ _070_ _014_ VDD VSS NOR2_X1
X_185_ seen_high_temp _071_ VDD VSS INV_X1
X_186_ _050_ _049_ _071_ _015_ VDD VSS AOI21_X1
X_187_ units_changed _090_ _089_ _072_ VDD VSS AOI21_X1
X_188_ _051_ _072_ _024_ VDD VSS NOR2_X1
X_189_ _074_ _083_ _090_ _073_ VDD VSS OAI21_X1
X_190_ _073_ _025_ VDD VSS INV_X1
X_191_ rst_n _074_ VDD VSS BUF_X2
X_192_ input_count\[3\] _075_ VDD VSS INV_X1
X_193_ input_count\[2\] _076_ VDD VSS INV_X1
X_194_ _075_ _076_ _125_ _077_ VDD VSS NAND3_X2
X_195_ _074_ _077_ initialized _078_ VDD VSS OAI21_X4
X_196_ _076_ _125_ _079_ VDD VSS NAND2_X1
X_197_ input_count\[3\] seen_high_temp _079_ _080_ VDD VSS
+ NAND3_X1
X_198_ net11 _081_ VDD VSS INV_X1
X_199_ _078_ _080_ _081_ _002_ VDD VSS AOI21_X1
X_200_ _078_ _082_ VDD VSS INV_X1
X_201_ adc_valid _083_ VDD VSS BUF_X4
X_202_ _083_ _084_ VDD VSS INV_X1
X_203_ _084_ net12 _080_ _085_ VDD VSS NAND3_X1
X_204_ _082_ _085_ _016_ VDD VSS NAND2_X1
X_205_ _084_ net13 _086_ VDD VSS NAND2_X1
X_206_ _078_ _080_ _086_ _017_ VDD VSS AOI21_X1
X_207_ units_select _087_ VDD VSS CLKBUF_X3
X_208_ _087_ celsius_value\[0\] _088_ VDD VSS NAND2_X1
X_209_ _087_ _089_ VDD VSS INV_X1
X_210_ force_update _090_ VDD VSS CLKBUF_X2
X_211_ units_changed _090_ _091_ VDD VSS NOR2_X2
X_212_ _089_ net19 _091_ _092_ VDD VSS NAND3_X1
X_213_ _078_ _088_ _092_ _018_ VDD VSS AOI21_X1
X_214_ fahrenheit_value\[1\] _090_ units_changed _093_ VDD
+ VSS OAI21_X1
X_215_ net15 _091_ _094_ VDD VSS NAND2_X1
X_216_ _087_ _093_ _094_ _095_ VDD VSS AOI21_X1
X_217_ _095_ celsius_value\[1\] _087_ _096_ VDD VSS AOI21_X1
X_218_ _078_ _096_ _019_ VDD VSS NOR2_X1
X_219_ fahrenheit_value\[2\] _090_ units_changed _097_ VDD
+ VSS OAI21_X1
X_220_ net16 _091_ _098_ VDD VSS NAND2_X1
X_221_ _087_ _097_ _098_ _099_ VDD VSS AOI21_X1
X_222_ _099_ celsius_value\[2\] _087_ _100_ VDD VSS AOI21_X1
X_223_ _078_ _100_ _020_ VDD VSS NOR2_X1
X_224_ _087_ celsius_value\[3\] _027_ VDD VSS NAND2_X1
X_225_ _089_ net17 _091_ _028_ VDD VSS NAND3_X1
X_226_ _078_ _027_ _028_ _021_ VDD VSS AOI21_X1
X_227_ net18 _091_ _029_ VDD VSS NAND2_X1
X_228_ _000_ _124_ _125_ _001_ VDD VSS HA_X1
X_229_ input_count\[0\] input_count\[1\] _126_ _127_ VDD VSS
+ HA_X1
Xclkbuf_0_clk clk clknet_0_clk VDD VSS CLKBUF_X3
X_231_ net23 status[1] VDD VSS BUF_X1
X_232_ net19 net14 VDD VSS BUF_X1
X_233_ net24 temperature[7] VDD VSS BUF_X1
Xalert$_SDFFE_PP0P_ _002_ clknet_1_0__leaf_clk net11 _123_
+ VDD VSS DFF_X1
Xcelsius_value\[0\]$_SDFFE_PN0P_ _003_ clknet_1_0__leaf_clk
+ celsius_value\[0\] _122_ VDD VSS DFF_X1
Xcelsius_value\[1\]$_SDFFE_PN0P_ _004_ clknet_1_1__leaf_clk
+ celsius_value\[1\] _121_ VDD VSS DFF_X1
Xcelsius_value\[2\]$_SDFFE_PN0P_ _005_ clknet_1_0__leaf_clk
+ celsius_value\[2\] _120_ VDD VSS DFF_X1
Xcelsius_value\[3\]$_SDFFE_PN0P_ _006_ clknet_1_0__leaf_clk
+ celsius_value\[3\] _119_ VDD VSS DFF_X1
Xcelsius_value\[4\]$_SDFFE_PN0P_ _007_ clknet_1_1__leaf_clk
+ celsius_value\[4\] _118_ VDD VSS DFF_X1
Xfahrenheit_value\[2\]$_SDFFE_PN0P_ _008_ clknet_1_1__leaf_clk
+ fahrenheit_value\[2\] _117_ VDD VSS DFF_X1
Xfahrenheit_value\[4\]$_SDFFE_PN0P_ _009_ clknet_1_1__leaf_clk
+ fahrenheit_value\[1\] _116_ VDD VSS DFF_X1
Xinitialized$_SDFFE_PN0P_ _010_ clknet_1_0__leaf_clk initialized
+ _115_ VDD VSS DFF_X1
Xinput_count\[0\]$_SDFFE_PN0P_ _011_ clknet_1_0__leaf_clk
+ input_count\[0\] _000_ VDD VSS DFF_X1
Xinput_count\[1\]$_SDFFE_PN0P_ _012_ clknet_1_0__leaf_clk
+ input_count\[1\] _124_ VDD VSS DFF_X1
Xinput_count\[2\]$_SDFFE_PN0P_ _013_ clknet_1_0__leaf_clk
+ input_count\[2\] _114_ VDD VSS DFF_X1
Xinput_count\[3\]$_SDFFE_PN0P_ _014_ clknet_1_0__leaf_clk
+ input_count\[3\] _113_ VDD VSS DFF_X1
Xseen_high_temp$_SDFFE_PN0P_ _015_ clknet_1_0__leaf_clk seen_high_temp
+ _112_ VDD VSS DFF_X1
Xstatus\[0\]$_SDFFE_PP1P_ _016_ clknet_1_0__leaf_clk net12
+ _111_ VDD VSS DFF_X1
Xstatus\[2\]$_SDFFE_PP0P_ _017_ clknet_1_0__leaf_clk net13
+ _110_ VDD VSS DFF_X1
Xtemperature\[0\]$_SDFFE_PP0P_ _018_ clknet_1_1__leaf_clk
+ net19 _109_ VDD VSS DFF_X1
Xtemperature\[1\]$_SDFFE_PP0P_ _019_ clknet_1_1__leaf_clk
+ net15 _108_ VDD VSS DFF_X1
Xtemperature\[2\]$_SDFFE_PP0P_ _020_ clknet_1_1__leaf_clk
+ net16 _107_ VDD VSS DFF_X1
Xtemperature\[3\]$_SDFFE_PP0P_ _021_ clknet_1_1__leaf_clk
+ net17 _106_ VDD VSS DFF_X1
Xtemperature\[4\]$_SDFFE_PP0P_ _022_ clknet_1_1__leaf_clk
+ net18 _105_ VDD VSS DFF_X1
Xtemperature\[6\]$_SDFFE_PP0P_ _023_ clknet_1_1__leaf_clk
+ net20 _104_ VDD VSS DFF_X1
Xunits_changed$_SDFFE_PN0P_ _024_ clknet_1_1__leaf_clk units_changed
+ _103_ VDD VSS DFF_X2
Xupdate$_SDFF_PN0_ _025_ clknet_1_0__leaf_clk net21 _102_
+ VDD VSS DFF_X1
Xvalid$_SDFFE_PP0P_ _026_ clknet_1_0__leaf_clk net22 _101_
+ VDD VSS DFF_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_53 VDD VSS TAPCELL_X1
Xinput1 adc_value[0] net1 VDD VSS BUF_X1
Xinput2 adc_value[1] net2 VDD VSS CLKBUF_X2
Xinput3 adc_value[2] net3 VDD VSS BUF_X1
Xinput4 adc_value[3] net4 VDD VSS BUF_X1
Xinput5 adc_value[4] net5 VDD VSS BUF_X1
Xinput6 adc_value[5] net6 VDD VSS BUF_X1
Xinput7 adc_value[6] net7 VDD VSS BUF_X1
Xinput8 adc_value[7] net8 VDD VSS BUF_X1
Xinput9 adc_value[8] net9 VDD VSS BUF_X1
Xinput10 adc_value[9] net10 VDD VSS BUF_X1
Xoutput11 net11 alert VDD VSS BUF_X1
Xoutput12 net12 status[0] VDD VSS BUF_X1
Xoutput13 net13 status[2] VDD VSS BUF_X1
Xoutput14 net14 temperature[0] VDD VSS BUF_X1
Xoutput15 net15 temperature[1] VDD VSS BUF_X1
Xoutput16 net16 temperature[2] VDD VSS BUF_X1
Xoutput17 net17 temperature[3] VDD VSS BUF_X1
Xoutput18 net18 temperature[4] VDD VSS BUF_X1
Xoutput19 net19 temperature[5] VDD VSS BUF_X1
Xoutput20 net20 temperature[6] VDD VSS BUF_X1
Xoutput21 net21 update VDD VSS BUF_X1
Xoutput22 net22 valid VDD VSS BUF_X1
X_231__23 net23 VDD VSS LOGIC0_X1
X_233__24 net24 VDD VSS LOGIC0_X1
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ CLKBUF_X3
Xclkload0 clknet_1_1__leaf_clk _unconnected_0 VDD VSS INV_X2
.ENDS digital_thermometer_controller
