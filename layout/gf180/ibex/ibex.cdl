* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT ibex_core alert_major_o alert_minor_o boot_addr_i[0]
+ boot_addr_i[10] boot_addr_i[11] boot_addr_i[12] boot_addr_i[13]
+ boot_addr_i[14] boot_addr_i[15] boot_addr_i[16] boot_addr_i[17]
+ boot_addr_i[18] boot_addr_i[19] boot_addr_i[1] boot_addr_i[20]
+ boot_addr_i[21] boot_addr_i[22] boot_addr_i[23] boot_addr_i[24]
+ boot_addr_i[25] boot_addr_i[26] boot_addr_i[27] boot_addr_i[28]
+ boot_addr_i[29] boot_addr_i[2] boot_addr_i[30] boot_addr_i[31]
+ boot_addr_i[3] boot_addr_i[4] boot_addr_i[5] boot_addr_i[6]
+ boot_addr_i[7] boot_addr_i[8] boot_addr_i[9] clk_i core_sleep_o
+ data_addr_o[0] data_addr_o[10] data_addr_o[11] data_addr_o[12]
+ data_addr_o[13] data_addr_o[14] data_addr_o[15] data_addr_o[16]
+ data_addr_o[17] data_addr_o[18] data_addr_o[19] data_addr_o[1]
+ data_addr_o[20] data_addr_o[21] data_addr_o[22] data_addr_o[23]
+ data_addr_o[24] data_addr_o[25] data_addr_o[26] data_addr_o[27]
+ data_addr_o[28] data_addr_o[29] data_addr_o[2] data_addr_o[30]
+ data_addr_o[31] data_addr_o[3] data_addr_o[4] data_addr_o[5]
+ data_addr_o[6] data_addr_o[7] data_addr_o[8] data_addr_o[9]
+ data_be_o[0] data_be_o[1] data_be_o[2] data_be_o[3] data_err_i
+ data_gnt_i data_rdata_i[0] data_rdata_i[10] data_rdata_i[11]
+ data_rdata_i[12] data_rdata_i[13] data_rdata_i[14] data_rdata_i[15]
+ data_rdata_i[16] data_rdata_i[17] data_rdata_i[18] data_rdata_i[19]
+ data_rdata_i[1] data_rdata_i[20] data_rdata_i[21] data_rdata_i[22]
+ data_rdata_i[23] data_rdata_i[24] data_rdata_i[25] data_rdata_i[26]
+ data_rdata_i[27] data_rdata_i[28] data_rdata_i[29] data_rdata_i[2]
+ data_rdata_i[30] data_rdata_i[31] data_rdata_i[3] data_rdata_i[4]
+ data_rdata_i[5] data_rdata_i[6] data_rdata_i[7] data_rdata_i[8]
+ data_rdata_i[9] data_req_o data_rvalid_i data_wdata_o[0] data_wdata_o[10]
+ data_wdata_o[11] data_wdata_o[12] data_wdata_o[13] data_wdata_o[14]
+ data_wdata_o[15] data_wdata_o[16] data_wdata_o[17] data_wdata_o[18]
+ data_wdata_o[19] data_wdata_o[1] data_wdata_o[20] data_wdata_o[21]
+ data_wdata_o[22] data_wdata_o[23] data_wdata_o[24] data_wdata_o[25]
+ data_wdata_o[26] data_wdata_o[27] data_wdata_o[28] data_wdata_o[29]
+ data_wdata_o[2] data_wdata_o[30] data_wdata_o[31] data_wdata_o[3]
+ data_wdata_o[4] data_wdata_o[5] data_wdata_o[6] data_wdata_o[7]
+ data_wdata_o[8] data_wdata_o[9] data_we_o debug_req_i fetch_enable_i
+ hart_id_i[0] hart_id_i[10] hart_id_i[11] hart_id_i[12] hart_id_i[13]
+ hart_id_i[14] hart_id_i[15] hart_id_i[16] hart_id_i[17] hart_id_i[18]
+ hart_id_i[19] hart_id_i[1] hart_id_i[20] hart_id_i[21] hart_id_i[22]
+ hart_id_i[23] hart_id_i[24] hart_id_i[25] hart_id_i[26] hart_id_i[27]
+ hart_id_i[28] hart_id_i[29] hart_id_i[2] hart_id_i[30] hart_id_i[31]
+ hart_id_i[3] hart_id_i[4] hart_id_i[5] hart_id_i[6] hart_id_i[7]
+ hart_id_i[8] hart_id_i[9] instr_addr_o[0] instr_addr_o[10]
+ instr_addr_o[11] instr_addr_o[12] instr_addr_o[13] instr_addr_o[14]
+ instr_addr_o[15] instr_addr_o[16] instr_addr_o[17] instr_addr_o[18]
+ instr_addr_o[19] instr_addr_o[1] instr_addr_o[20] instr_addr_o[21]
+ instr_addr_o[22] instr_addr_o[23] instr_addr_o[24] instr_addr_o[25]
+ instr_addr_o[26] instr_addr_o[27] instr_addr_o[28] instr_addr_o[29]
+ instr_addr_o[2] instr_addr_o[30] instr_addr_o[31] instr_addr_o[3]
+ instr_addr_o[4] instr_addr_o[5] instr_addr_o[6] instr_addr_o[7]
+ instr_addr_o[8] instr_addr_o[9] instr_err_i instr_gnt_i instr_rdata_i[0]
+ instr_rdata_i[10] instr_rdata_i[11] instr_rdata_i[12] instr_rdata_i[13]
+ instr_rdata_i[14] instr_rdata_i[15] instr_rdata_i[16] instr_rdata_i[17]
+ instr_rdata_i[18] instr_rdata_i[19] instr_rdata_i[1] instr_rdata_i[20]
+ instr_rdata_i[21] instr_rdata_i[22] instr_rdata_i[23] instr_rdata_i[24]
+ instr_rdata_i[25] instr_rdata_i[26] instr_rdata_i[27] instr_rdata_i[28]
+ instr_rdata_i[29] instr_rdata_i[2] instr_rdata_i[30] instr_rdata_i[31]
+ instr_rdata_i[3] instr_rdata_i[4] instr_rdata_i[5] instr_rdata_i[6]
+ instr_rdata_i[7] instr_rdata_i[8] instr_rdata_i[9] instr_req_o
+ instr_rvalid_i irq_external_i irq_fast_i[0] irq_fast_i[10]
+ irq_fast_i[11] irq_fast_i[12] irq_fast_i[13] irq_fast_i[14]
+ irq_fast_i[1] irq_fast_i[2] irq_fast_i[3] irq_fast_i[4] irq_fast_i[5]
+ irq_fast_i[6] irq_fast_i[7] irq_fast_i[8] irq_fast_i[9] irq_nm_i
+ irq_software_i irq_timer_i rst_ni test_en_i VSS VDD
X_11641_ load_store_unit_i.handle_misaligned_q _01354_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace2010 net2193 net2009 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2011 net2008 net2010 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace2012 net2008 net2011 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2013 net2008 net2012 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2014 net2008 net2013 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2015 net2005 net2014 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11648_ gen_regfile_ff.register_file_i.rf_reg\[908\] gen_regfile_ff.register_file_i.rf_reg\[940\]
+ gen_regfile_ff.register_file_i.rf_reg\[972\] gen_regfile_ff.register_file_i.rf_reg\[1004\]
+ net2001 net1968 _07516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11649_ gen_regfile_ff.register_file_i.rf_reg\[780\] gen_regfile_ff.register_file_i.rf_reg\[812\]
+ gen_regfile_ff.register_file_i.rf_reg\[844\] gen_regfile_ff.register_file_i.rf_reg\[876\]
+ net2001 net1968 _07517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11650_ gen_regfile_ff.register_file_i.raddr_a_i\[2\] _07518_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xplace1739 _08034_ net1738 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1738 _08191_ net1737 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11653_ _07516_ _07517_ net1884 _07521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2016 net2005 net2015 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_11655_ net1958 net1959 _07523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace2017 net2015 net2016 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace2018 net2005 net2017 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1737 _08448_ net1736 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11659_ gen_regfile_ff.register_file_i.rf_reg\[396\] gen_regfile_ff.register_file_i.rf_reg\[428\]
+ gen_regfile_ff.register_file_i.rf_reg\[460\] gen_regfile_ff.register_file_i.rf_reg\[492\]
+ net2001 net1968 _07527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11660_ gen_regfile_ff.register_file_i.rf_reg\[268\] gen_regfile_ff.register_file_i.rf_reg\[300\]
+ gen_regfile_ff.register_file_i.rf_reg\[332\] gen_regfile_ff.register_file_i.rf_reg\[364\]
+ net2001 net1968 _07528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11661_ gen_regfile_ff.register_file_i.rf_reg\[140\] gen_regfile_ff.register_file_i.rf_reg\[172\]
+ gen_regfile_ff.register_file_i.rf_reg\[204\] gen_regfile_ff.register_file_i.rf_reg\[236\]
+ net2001 net1968 _07529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11662_ gen_regfile_ff.register_file_i.rf_reg\[76\] gen_regfile_ff.register_file_i.rf_reg\[108\]
+ net2001 _07530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2019 net2005 net2018 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1736 _08486_ net1735 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11665_ gen_regfile_ff.register_file_i.rf_reg\[44\] net2001
+ _07533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11666_ gen_regfile_ff.register_file_i.raddr_a_i\[1\] _07534_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11667_ _07530_ _07533_ net1873 _07535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_24_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_24_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11669_ gen_regfile_ff.register_file_i.raddr_a_i\[3\] _07537_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkbuf_leaf_25_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_25_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11671_ _07527_ _07528_ _07529_ _07535_ net1884 net1867 _07539_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1735 _08606_ net1734 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace1734 _08669_ net1733 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1733 _08810_ net1732 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11675_ gen_regfile_ff.register_file_i.rf_reg\[652\] gen_regfile_ff.register_file_i.rf_reg\[684\]
+ gen_regfile_ff.register_file_i.rf_reg\[716\] gen_regfile_ff.register_file_i.rf_reg\[748\]
+ net2001 net1968 _07543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11676_ gen_regfile_ff.register_file_i.rf_reg\[524\] gen_regfile_ff.register_file_i.rf_reg\[556\]
+ gen_regfile_ff.register_file_i.rf_reg\[588\] gen_regfile_ff.register_file_i.rf_reg\[620\]
+ net2001 net1968 _07544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1732 _08870_ net1731 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11678_ _07543_ _07544_ net1884 _07546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11679_ net1958 net1867 _07547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11680_ _07546_ _07547_ _07548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11681_ _07521_ _07523_ _07539_ net1958 _07548_ _07549_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11682_ load_store_unit_i.ls_fsm_cs\[0\] load_store_unit_i.ls_fsm_cs\[1\]
+ _07550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_11683_ net2081 _07550_ _07551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11684_ load_store_unit_i.ls_fsm_cs\[0\] _07552_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11685_ load_store_unit_i.ls_fsm_cs\[2\] _07553_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11686_ _07552_ load_store_unit_i.handle_misaligned_q net2086
+ _07553_ _07554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_11687_ _07551_ _07554_ _07555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xplace1731 _08906_ net1730 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11689_ net1889 _07557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1730 _08945_ net1729 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11691_ net2144 _07557_ _07559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11692_ net2133 _07560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11693_ net1888 id_stage_i.controller_i.instr_i\[5\] _07561_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1729 _08962_ net1728 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11695_ net1888 id_stage_i.controller_i.instr_i\[5\] _07563_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11696_ _07560_ _07561_ _07563_ _07564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11697_ _07559_ _07564_ _07565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11698_ id_stage_i.controller_i.instr_i\[6\] _07566_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11699_ net2144 _07567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11700_ _07566_ id_stage_i.controller_i.instr_i\[5\] _07567_
+ _07568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1728 _08999_ net1727 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11702_ net2147 id_stage_i.controller_i.instr_i\[5\] _07570_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_11703_ net1889 _07570_ _07571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1727 _09059_ net1726 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_11705_ _07568_ _07571_ net2130 _07573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11706_ id_stage_i.controller_i.instr_i\[13\] id_stage_i.controller_i.instr_i\[14\]
+ _07574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_11707_ id_stage_i.controller_i.instr_i\[0\] id_stage_i.controller_i.instr_i\[1\]
+ net1893 _07575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11708_ _07560_ net1889 _07561_ _07575_ _07576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11709_ _07565_ _07573_ _07574_ _07576_ _07577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xplace1725 _09095_ net1724 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11711_ net2019 _07579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xplace1724 _09148_ net1723 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11713_ id_stage_i.controller_i.instr_i\[5\] _07581_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11714_ id_stage_i.controller_i.instr_i\[0\] id_stage_i.controller_i.instr_i\[1\]
+ _07582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11715_ net1893 net1890 _07583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_11716_ _07581_ _07582_ _07583_ _07584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11717_ net1888 net1889 _07585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11718_ id_stage_i.controller_i.instr_i\[0\] id_stage_i.controller_i.instr_i\[1\]
+ _07586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11719_ _07579_ _07584_ _07585_ _07586_ _07587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_11720_ net2130 _07570_ _07588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11721_ _07559_ _07588_ _07589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11722_ net1888 id_stage_i.controller_i.instr_i\[5\] _07590_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11723_ _07557_ _07590_ _07591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11724_ _07568_ _07591_ net2132 _07592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11725_ id_stage_i.controller_i.instr_i\[0\] id_stage_i.controller_i.instr_i\[1\]
+ net1893 _07593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11726_ net2132 _07557_ _07570_ _07593_ _07594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11727_ id_stage_i.controller_i.instr_i\[12\] _07595_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11728_ _07595_ _07574_ _07596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11729_ _07594_ net1831 _07597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11730_ _07560_ _07586_ _07598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11731_ id_stage_i.id_fsm_q _07599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11732_ id_stage_i.controller_i.instr_valid_i _07599_ net2170
+ _07563_ _07600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11733_ _07598_ net2183 _07601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11734_ _07589_ _07592_ _07597_ _07601_ _07602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11735_ _07602_ _07577_ _07587_ net1817 _07603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
Xplace1723 _09182_ net1722 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11737_ _07559_ _07564_ _07605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11738_ net2147 _07581_ net2144 _07606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11739_ net2170 net2149 _07607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11740_ _07606_ _07607_ _07560_ _07608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11741_ _07574_ _07576_ _07551_ _07554_ _07609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11742_ _07605_ _07608_ _07609_ _07587_ _07610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
Xplace1722 _09239_ net1721 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11744_ cs_registers_i.pc_id_i\[12\] net2064 _07612_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11745_ _07598_ net2183 _07613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1721 _09276_ net1720 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11747_ id_stage_i.controller_i.instr_i\[2\] id_stage_i.controller_i.instr_i\[3\]
+ _07615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11748_ id_stage_i.controller_i.instr_i\[5\] _07586_ _07615_
+ _07616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11749_ _07579_ _07585_ _07617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11750_ _07616_ _07617_ _07582_ _07618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_11751_ _07589_ _07592_ _07597_ _07618_ _07619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_11752_ _07551_ _07554_ _07620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1720 _09443_ net1719 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11754_ _07619_ _07613_ net1816 _07622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
Xplace1719 _09665_ net1718 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11756_ id_stage_i.controller_i.lsu_addr_last_i\[12\] net1818
+ _07624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11757_ net1803 net2126 _07612_ net1741 _07624_ _01226_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_11758_ net1704 _01222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1726 net1724 net1725 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1718 _09671_ net1717 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
Xclkbuf_leaf_26_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_26_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11763_ net1889 net1888 id_stage_i.controller_i.instr_i\[14\]
+ _07629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11764_ _07629_ _07582_ _07583_ _07581_ _07630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_11765_ net2130 _07557_ _07570_ _07631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11766_ net2021 _07574_ _07632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11767_ _07631_ _07632_ _07600_ _07633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_11768_ net2130 net2147 _07557_ _07634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11769_ _07630_ _07634_ _07635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11770_ _07575_ net2110 _07635_ _07633_ net2115 _07636_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_11771_ net1932 gen_regfile_ff.register_file_i.waddr_a_i\[0\]
+ net2069 _07637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11772_ _07560_ net2170 _07561_ _07638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
Xplace1717 _09689_ net1716 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_11774_ net2021 _07574_ _07640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1715 _09780_ net1714 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11776_ id_stage_i.controller_i.instr_valid_i _07642_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11777_ _07642_ id_stage_i.id_fsm_q _07590_ _07557_ _07643_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_11778_ _07640_ _07638_ _07643_ _07644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_11779_ _07557_ _07590_ _07645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11780_ net2130 _07593_ _07645_ _07646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11781_ _07593_ _07644_ _07646_ net1817 _07647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_11782_ _07616_ _07585_ net2117 _07648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11783_ net2144 _07566_ net1889 _07649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11784_ net2081 _07550_ _07650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1713 _09831_ net1712 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11786_ net2086 _07652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_11787_ net2099 _01354_ _07652_ net2081 _07653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11788_ _07598_ _07649_ _07653_ _07650_ _07654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11789_ _07648_ net2181 _07655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11790_ net2061 _07655_ _07656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11791_ gen_regfile_ff.register_file_i.raddr_b_i\[4\] _07657_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1712 _09851_ net1711 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1714 _09805_ net1713 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1716 net1714 net1715 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1711 _09861_ net1710 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1710 _09878_ net1709 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11797_ gen_regfile_ff.register_file_i.rf_reg\[512\] gen_regfile_ff.register_file_i.rf_reg\[576\]
+ gen_regfile_ff.register_file_i.rf_reg\[640\] gen_regfile_ff.register_file_i.rf_reg\[704\]
+ net2168 net1903 _07663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11798_ net1860 net1901 net2104 _07663_ _07664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11799_ gen_regfile_ff.register_file_i.raddr_b_i\[3\] _07665_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11800_ net2155 _07666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1709 _09946_ net1708 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11802_ gen_regfile_ff.register_file_i.rf_reg\[288\] gen_regfile_ff.register_file_i.rf_reg\[352\]
+ gen_regfile_ff.register_file_i.rf_reg\[416\] gen_regfile_ff.register_file_i.rf_reg\[480\]
+ net2168 net1903 _07668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11803_ net1899 net1858 net1856 _07668_ _07669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11804_ gen_regfile_ff.register_file_i.rf_reg\[256\] gen_regfile_ff.register_file_i.rf_reg\[320\]
+ gen_regfile_ff.register_file_i.rf_reg\[384\] gen_regfile_ff.register_file_i.rf_reg\[448\]
+ net1906 net1903 _07670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11805_ net1899 net1858 net2104 _07670_ _07671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11806_ gen_regfile_ff.register_file_i.rf_reg\[544\] gen_regfile_ff.register_file_i.rf_reg\[608\]
+ gen_regfile_ff.register_file_i.rf_reg\[672\] gen_regfile_ff.register_file_i.rf_reg\[736\]
+ net1906 net1903 _07672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11807_ net1860 net1901 net1856 _07672_ _07673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11808_ _07664_ _07669_ _07671_ _07673_ _07674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xplace1708 _03988_ net1707 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11810_ gen_regfile_ff.register_file_i.rf_reg\[128\] gen_regfile_ff.register_file_i.rf_reg\[192\]
+ net2078 _07676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11811_ gen_regfile_ff.register_file_i.rf_reg\[160\] gen_regfile_ff.register_file_i.rf_reg\[224\]
+ net2078 _07677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1707 _03992_ net1706 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11813_ gen_regfile_ff.register_file_i.rf_reg\[64\] net2078
+ _07679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11814_ gen_regfile_ff.register_file_i.rf_reg\[32\] gen_regfile_ff.register_file_i.rf_reg\[96\]
+ net2078 _07680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11815_ gen_regfile_ff.register_file_i.raddr_b_i\[2\] _07681_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1706 _00947_ net1705 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11817_ _07676_ _07677_ _07679_ _07680_ net2104 net1847 _07683_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11818_ net1861 net1859 _07684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11819_ _07683_ net1830 _07685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11820_ gen_regfile_ff.register_file_i.rf_reg\[800\] gen_regfile_ff.register_file_i.rf_reg\[864\]
+ gen_regfile_ff.register_file_i.rf_reg\[928\] gen_regfile_ff.register_file_i.rf_reg\[992\]
+ net2078 net1903 _07686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11821_ gen_regfile_ff.register_file_i.rf_reg\[768\] gen_regfile_ff.register_file_i.rf_reg\[832\]
+ gen_regfile_ff.register_file_i.rf_reg\[896\] gen_regfile_ff.register_file_i.rf_reg\[960\]
+ net2078 net1903 _07687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11822_ _07686_ _07687_ net1856 _07688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11823_ net1899 gen_regfile_ff.register_file_i.raddr_b_i\[3\]
+ _07689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11824_ _07688_ _07689_ _07690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11825_ _07674_ _07685_ _07690_ _07691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11826_ _07616_ _07585_ _07643_ net2117 _07692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
X_11827_ net2483 _07692_ _07693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_11828_ _07637_ _07656_ net1798 net1797 _07694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11829_ _07694_ _07695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xplace1705 _01226_ net1704 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1704 _07694_ net1703 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkbuf_leaf_27_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_27_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11833_ _07575_ net2110 _07633_ _07635_ _07697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_11834_ _07560_ _07575_ _07591_ _07698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11835_ _07575_ _07633_ _07698_ net1816 _07699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_11836_ id_stage_i.controller_i.instr_is_compressed_i _07697_
+ _07699_ _07700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xplace1703 net2299 net1702 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
Xplace1702 net2118 net1701 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11840_ _07584_ net2117 _07704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_11841_ _07630_ _07634_ _07705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11842_ _07593_ _07704_ _07644_ _07705_ _07620_ _07706_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_11843_ net1908 _07706_ _07707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11844_ _07700_ _07707_ _07655_ _07708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1701 _01173_ net1700 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11846_ net1816 _07692_ _07710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11847_ _07586_ _07615_ _07711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
Xclkbuf_leaf_28_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_28_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11849_ _07711_ net2183 _07713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11850_ _07654_ _07713_ _07714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_11851_ _07714_ _07636_ _07715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_11852_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] net2061
+ _07710_ _07715_ _07716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_4
Xclkbuf_leaf_29_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_29_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11854_ gen_regfile_ff.register_file_i.rf_reg\[513\] gen_regfile_ff.register_file_i.rf_reg\[577\]
+ gen_regfile_ff.register_file_i.rf_reg\[641\] gen_regfile_ff.register_file_i.rf_reg\[705\]
+ net1906 net1903 _07718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11855_ net1860 net1901 net2104 _07718_ _07719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
Xplace1700 _07925_ net1699 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11857_ gen_regfile_ff.register_file_i.rf_reg\[289\] gen_regfile_ff.register_file_i.rf_reg\[353\]
+ gen_regfile_ff.register_file_i.rf_reg\[417\] gen_regfile_ff.register_file_i.rf_reg\[481\]
+ net1906 net1903 _07721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11858_ net1899 net1858 net1856 _07721_ _07722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11859_ gen_regfile_ff.register_file_i.rf_reg\[257\] gen_regfile_ff.register_file_i.rf_reg\[321\]
+ gen_regfile_ff.register_file_i.rf_reg\[385\] gen_regfile_ff.register_file_i.rf_reg\[449\]
+ net1906 net1903 _07723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11860_ net1899 net1858 net2104 _07723_ _07724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11861_ gen_regfile_ff.register_file_i.rf_reg\[545\] gen_regfile_ff.register_file_i.rf_reg\[609\]
+ gen_regfile_ff.register_file_i.rf_reg\[673\] gen_regfile_ff.register_file_i.rf_reg\[737\]
+ net1906 net1903 _07725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11862_ net1860 net1901 net1856 _07725_ _07726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11863_ _07719_ _07722_ _07724_ _07726_ _07727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_11864_ gen_regfile_ff.register_file_i.rf_reg\[129\] gen_regfile_ff.register_file_i.rf_reg\[193\]
+ net2168 _07728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11865_ gen_regfile_ff.register_file_i.rf_reg\[161\] gen_regfile_ff.register_file_i.rf_reg\[225\]
+ net2168 _07729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1699 _07946_ net1698 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11867_ net2078 gen_regfile_ff.register_file_i.rf_reg\[65\]
+ _07731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11868_ gen_regfile_ff.register_file_i.rf_reg\[33\] gen_regfile_ff.register_file_i.rf_reg\[97\]
+ net2168 _07732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11869_ _07728_ _07729_ _07731_ _07732_ net2104 net1847 _07733_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11870_ net1830 _07733_ _07734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1698 _01208_ net1697 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11872_ gen_regfile_ff.register_file_i.rf_reg\[801\] gen_regfile_ff.register_file_i.rf_reg\[865\]
+ gen_regfile_ff.register_file_i.rf_reg\[929\] gen_regfile_ff.register_file_i.rf_reg\[993\]
+ net2168 net1903 _07736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11873_ gen_regfile_ff.register_file_i.rf_reg\[769\] gen_regfile_ff.register_file_i.rf_reg\[833\]
+ gen_regfile_ff.register_file_i.rf_reg\[897\] gen_regfile_ff.register_file_i.rf_reg\[961\]
+ net1906 net1903 _07737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11874_ _07736_ _07737_ net1856 _07738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11875_ _07689_ _07738_ _07739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_11876_ _07727_ _07734_ _07739_ _07740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11877_ _07693_ net1796 _07741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11878_ _07708_ _07716_ _07741_ _01135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_11879_ _01135_ _07742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_4
Xclkbuf_leaf_30_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_30_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace1697 _07996_ net1696 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1696 _01214_ net1695 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11883_ _07666_ net2184 _07745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
Xclkbuf_leaf_31_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_31_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11885_ gen_regfile_ff.register_file_i.rf_reg\[34\] gen_regfile_ff.register_file_i.rf_reg\[98\]
+ net1909 _07747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11886_ gen_regfile_ff.register_file_i.rf_reg\[66\] _07745_
+ _07747_ net2104 _07748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xclkbuf_leaf_33_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_33_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11888_ gen_regfile_ff.register_file_i.rf_reg\[130\] gen_regfile_ff.register_file_i.rf_reg\[162\]
+ gen_regfile_ff.register_file_i.rf_reg\[194\] gen_regfile_ff.register_file_i.rf_reg\[226\]
+ net1931 net1909 _07750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11889_ net1903 _07750_ _07751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11890_ net1903 _07748_ _07751_ _07752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_11891_ gen_regfile_ff.register_file_i.rf_reg\[290\] gen_regfile_ff.register_file_i.rf_reg\[354\]
+ gen_regfile_ff.register_file_i.rf_reg\[418\] gen_regfile_ff.register_file_i.rf_reg\[482\]
+ net1909 net1903 _07753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11892_ gen_regfile_ff.register_file_i.rf_reg\[258\] gen_regfile_ff.register_file_i.rf_reg\[322\]
+ gen_regfile_ff.register_file_i.rf_reg\[386\] gen_regfile_ff.register_file_i.rf_reg\[450\]
+ net1909 net1903 _07754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11893_ _07753_ _07754_ net1856 _07755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11894_ gen_regfile_ff.register_file_i.rf_reg\[642\] gen_regfile_ff.register_file_i.rf_reg\[674\]
+ gen_regfile_ff.register_file_i.rf_reg\[706\] gen_regfile_ff.register_file_i.rf_reg\[738\]
+ net2152 net1909 _07756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11895_ gen_regfile_ff.register_file_i.rf_reg\[514\] gen_regfile_ff.register_file_i.rf_reg\[546\]
+ gen_regfile_ff.register_file_i.rf_reg\[578\] gen_regfile_ff.register_file_i.rf_reg\[610\]
+ net2152 net1909 _07757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11896_ _07756_ _07757_ net1847 _07758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11897_ gen_regfile_ff.register_file_i.rf_reg\[802\] gen_regfile_ff.register_file_i.rf_reg\[866\]
+ gen_regfile_ff.register_file_i.rf_reg\[930\] gen_regfile_ff.register_file_i.rf_reg\[994\]
+ net1909 net1903 _07759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11898_ gen_regfile_ff.register_file_i.rf_reg\[770\] gen_regfile_ff.register_file_i.rf_reg\[834\]
+ gen_regfile_ff.register_file_i.rf_reg\[898\] gen_regfile_ff.register_file_i.rf_reg\[962\]
+ net1909 net1903 _07760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11899_ _07759_ _07760_ net1856 _07761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_32_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_32_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11901_ _07752_ _07755_ _07758_ _07761_ net1901 net1899 _07763_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkbuf_0_clk_i_regs clk_i_regs clknet_0_clk_i_regs VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11903_ net1740 _07765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1695 _08185_ net1694 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_11905_ _07654_ _07713_ _07767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11906_ net1848 net1800 _07767_ _07768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11907_ id_stage_i.controller_i.instr_is_compressed_i _07706_
+ net1799 _07767_ _07769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11908_ _07710_ _07768_ _07769_ _07770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_11909_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] net2061
+ _07715_ _07771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_11910_ net1797 _07765_ _07770_ _07771_ _07772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11911_ net1611 _07773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xclkbuf_2_0__f_clk_i_regs clknet_0_clk_i_regs clknet_2_0__leaf_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace1694 _08218_ net1693 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_11914_ gen_regfile_ff.register_file_i.waddr_a_i\[3\] net1799
+ _07774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11915_ _07648_ net2181 _07775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xclkbuf_2_1__f_clk_i_regs clknet_0_clk_i_regs clknet_2_1__leaf_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11917_ gen_regfile_ff.register_file_i.rf_reg\[803\] gen_regfile_ff.register_file_i.rf_reg\[867\]
+ gen_regfile_ff.register_file_i.rf_reg\[931\] gen_regfile_ff.register_file_i.rf_reg\[995\]
+ net1918 net1905 _07777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11918_ gen_regfile_ff.register_file_i.rf_reg\[771\] gen_regfile_ff.register_file_i.rf_reg\[835\]
+ gen_regfile_ff.register_file_i.rf_reg\[899\] gen_regfile_ff.register_file_i.rf_reg\[963\]
+ net1918 net1905 _07778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkbuf_2_2__f_clk_i_regs clknet_0_clk_i_regs clknet_2_2__leaf_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11920_ _07777_ _07778_ net1853 _07780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11921_ gen_regfile_ff.register_file_i.rf_reg\[131\] gen_regfile_ff.register_file_i.rf_reg\[195\]
+ net2184 _07781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11922_ gen_regfile_ff.register_file_i.rf_reg\[163\] gen_regfile_ff.register_file_i.rf_reg\[227\]
+ net1916 _07782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_2_3__f_clk_i_regs clknet_0_clk_i_regs clknet_2_3__leaf_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_11924_ net1916 gen_regfile_ff.register_file_i.rf_reg\[67\]
+ _07784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11925_ gen_regfile_ff.register_file_i.rf_reg\[35\] gen_regfile_ff.register_file_i.rf_reg\[99\]
+ net1916 _07785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11926_ _07781_ _07782_ _07784_ _07785_ net1957 net1847 _07786_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11927_ _07689_ _07780_ _07786_ _07684_ _07787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_4
Xplace1693 _01172_ net1692 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11929_ _07657_ gen_regfile_ff.register_file_i.raddr_b_i\[3\]
+ _07789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1692 _01179_ net1691 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1691 _01186_ net1690 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11932_ gen_regfile_ff.register_file_i.rf_reg\[291\] gen_regfile_ff.register_file_i.rf_reg\[355\]
+ gen_regfile_ff.register_file_i.rf_reg\[419\] gen_regfile_ff.register_file_i.rf_reg\[483\]
+ net1927 net1905 _07792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11933_ net1853 _07789_ _07792_ _07793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xclkload0 clknet_2_0__leaf_clk_i_regs _unconnected_0 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_20
Xplace1690 _01200_ net1689 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1689 _01207_ net1688 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1688 _08544_ net1687 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_11938_ gen_regfile_ff.register_file_i.rf_reg\[515\] gen_regfile_ff.register_file_i.rf_reg\[579\]
+ gen_regfile_ff.register_file_i.rf_reg\[643\] gen_regfile_ff.register_file_i.rf_reg\[707\]
+ net1927 net1905 _07798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11939_ net1860 net1900 net1939 _07798_ _07799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_11940_ gen_regfile_ff.register_file_i.rf_reg\[259\] gen_regfile_ff.register_file_i.rf_reg\[323\]
+ gen_regfile_ff.register_file_i.rf_reg\[387\] gen_regfile_ff.register_file_i.rf_reg\[451\]
+ net1927 net1905 _07800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11941_ gen_regfile_ff.register_file_i.rf_reg\[547\] gen_regfile_ff.register_file_i.rf_reg\[611\]
+ gen_regfile_ff.register_file_i.rf_reg\[675\] gen_regfile_ff.register_file_i.rf_reg\[739\]
+ net1927 net1905 _07801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11942_ _07657_ gen_regfile_ff.register_file_i.raddr_b_i\[3\]
+ _07666_ _07802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11943_ net1939 _07789_ _07800_ _07801_ _07802_ _07803_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_11944_ _07803_ _07793_ _07799_ _07787_ _07804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_11945_ net2483 _07692_ _07805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xclkload1 clknet_2_1__leaf_clk_i_regs _unconnected_1 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_20
X_11947_ net1858 _07697_ _07775_ _07804_ _07805_ _07807_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_11948_ net2066 _07774_ _07807_ _07808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload2 clknet_leaf_0_clk_i_regs _unconnected_2 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_11950_ net1702 _01159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_11951_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] net1799
+ _07809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11952_ gen_regfile_ff.register_file_i.rf_reg\[900\] gen_regfile_ff.register_file_i.rf_reg\[932\]
+ gen_regfile_ff.register_file_i.rf_reg\[964\] gen_regfile_ff.register_file_i.rf_reg\[996\]
+ net2152 net2078 _07810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11953_ gen_regfile_ff.register_file_i.rf_reg\[772\] gen_regfile_ff.register_file_i.rf_reg\[804\]
+ gen_regfile_ff.register_file_i.rf_reg\[836\] gen_regfile_ff.register_file_i.rf_reg\[868\]
+ net2152 net2078 _07811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11954_ _07810_ _07811_ net1847 _07812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11955_ gen_regfile_ff.register_file_i.rf_reg\[132\] gen_regfile_ff.register_file_i.rf_reg\[196\]
+ net1909 _07813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11956_ gen_regfile_ff.register_file_i.rf_reg\[164\] gen_regfile_ff.register_file_i.rf_reg\[228\]
+ net1909 _07814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11957_ net1909 gen_regfile_ff.register_file_i.rf_reg\[68\]
+ _07815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11958_ gen_regfile_ff.register_file_i.rf_reg\[36\] gen_regfile_ff.register_file_i.rf_reg\[100\]
+ net1909 _07816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11959_ _07813_ _07814_ _07815_ _07816_ net2142 net1847 _07817_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11960_ _07689_ _07812_ _07817_ _07684_ _07818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_11961_ gen_regfile_ff.register_file_i.rf_reg\[548\] gen_regfile_ff.register_file_i.rf_reg\[612\]
+ gen_regfile_ff.register_file_i.rf_reg\[676\] gen_regfile_ff.register_file_i.rf_reg\[740\]
+ net2089 net1903 _07819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclone2482 _09844_ net2481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11963_ gen_regfile_ff.register_file_i.rf_reg\[260\] gen_regfile_ff.register_file_i.rf_reg\[292\]
+ gen_regfile_ff.register_file_i.rf_reg\[324\] gen_regfile_ff.register_file_i.rf_reg\[356\]
+ net1933 net1909 _07821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11964_ net1899 net1859 net1903 _07821_ _07822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11965_ _07802_ _07819_ _07822_ _07823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1686 _01235_ net1685 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11967_ gen_regfile_ff.register_file_i.rf_reg\[388\] gen_regfile_ff.register_file_i.rf_reg\[420\]
+ gen_regfile_ff.register_file_i.rf_reg\[452\] gen_regfile_ff.register_file_i.rf_reg\[484\]
+ net2142 net2089 _07825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11968_ gen_regfile_ff.register_file_i.rf_reg\[516\] gen_regfile_ff.register_file_i.rf_reg\[580\]
+ gen_regfile_ff.register_file_i.rf_reg\[644\] gen_regfile_ff.register_file_i.rf_reg\[708\]
+ net1909 net1903 _07826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11969_ net1861 net1902 net1934 _07826_ _07827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_11970_ net1847 _07789_ _07825_ _07827_ _07828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_11971_ _07818_ _07823_ _07828_ _07829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_11972_ net1860 _07697_ _07775_ net1794 _07805_ _07830_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_11973_ net2066 _07809_ _07830_ _07831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1685 _01242_ net1684 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1684 _01249_ net1683 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_11976_ net1701 _01166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11977_ id_stage_i.controller_i.instr_i\[25\] _07833_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_11978_ _07638_ _07640_ _07634_ _07643_ _07834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11979_ _07593_ _07834_ _07704_ net1817 _07835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_11980_ net1799 _07655_ _07835_ _07805_ _07836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_11981_ gen_regfile_ff.register_file_i.rf_reg\[37\] gen_regfile_ff.register_file_i.rf_reg\[101\]
+ net1907 _07837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload3 clknet_leaf_25_clk_i_regs _unconnected_3 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_11983_ gen_regfile_ff.register_file_i.rf_reg\[69\] net1828
+ _07837_ net2112 net1904 _07839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_11984_ net1904 net1935 _07840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_11985_ gen_regfile_ff.register_file_i.rf_reg\[165\] gen_regfile_ff.register_file_i.rf_reg\[229\]
+ net1907 _07841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11986_ _07657_ _07665_ _07842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11987_ gen_regfile_ff.register_file_i.rf_reg\[133\] gen_regfile_ff.register_file_i.rf_reg\[197\]
+ net1907 _07843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11988_ net1934 net1847 _07843_ _07844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_11989_ _07840_ _07841_ _07842_ _07844_ _07845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_11990_ net1860 net1900 _07846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_11991_ gen_regfile_ff.register_file_i.rf_reg\[293\] gen_regfile_ff.register_file_i.rf_reg\[357\]
+ gen_regfile_ff.register_file_i.rf_reg\[421\] gen_regfile_ff.register_file_i.rf_reg\[485\]
+ net1907 net1903 _07847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11992_ gen_regfile_ff.register_file_i.rf_reg\[261\] gen_regfile_ff.register_file_i.rf_reg\[325\]
+ gen_regfile_ff.register_file_i.rf_reg\[389\] gen_regfile_ff.register_file_i.rf_reg\[453\]
+ net1907 net1903 _07848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11993_ _07847_ _07848_ net1857 _07849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_11994_ _07846_ _07849_ _07850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_11995_ gen_regfile_ff.register_file_i.rf_reg\[805\] gen_regfile_ff.register_file_i.rf_reg\[869\]
+ gen_regfile_ff.register_file_i.rf_reg\[933\] gen_regfile_ff.register_file_i.rf_reg\[997\]
+ net2184 net2101 _07851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11996_ gen_regfile_ff.register_file_i.rf_reg\[773\] gen_regfile_ff.register_file_i.rf_reg\[837\]
+ gen_regfile_ff.register_file_i.rf_reg\[901\] gen_regfile_ff.register_file_i.rf_reg\[965\]
+ net2184 net2101 _07852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11997_ gen_regfile_ff.register_file_i.rf_reg\[549\] gen_regfile_ff.register_file_i.rf_reg\[613\]
+ gen_regfile_ff.register_file_i.rf_reg\[677\] gen_regfile_ff.register_file_i.rf_reg\[741\]
+ net2184 net2101 _07853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11998_ gen_regfile_ff.register_file_i.rf_reg\[517\] gen_regfile_ff.register_file_i.rf_reg\[581\]
+ gen_regfile_ff.register_file_i.rf_reg\[645\] gen_regfile_ff.register_file_i.rf_reg\[709\]
+ net2184 net2101 _07854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_11999_ _07851_ _07852_ _07853_ _07854_ net1857 net1859 _07855_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12000_ net1899 _07855_ _07856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12001_ _07839_ _07845_ _07850_ _07856_ _07857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12002_ net1797 net1792 _07858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12003_ _07833_ _07836_ _07858_ _01173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12004_ net1700 _07859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1683 _01263_ net1682 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12006_ net1897 _07860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12007_ net1799 _07714_ _07835_ _07861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12008_ net1899 net1901 _07862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12009_ gen_regfile_ff.register_file_i.rf_reg\[806\] gen_regfile_ff.register_file_i.rf_reg\[870\]
+ gen_regfile_ff.register_file_i.rf_reg\[934\] gen_regfile_ff.register_file_i.rf_reg\[998\]
+ net2168 net1903 _07863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12010_ gen_regfile_ff.register_file_i.rf_reg\[774\] gen_regfile_ff.register_file_i.rf_reg\[838\]
+ gen_regfile_ff.register_file_i.rf_reg\[902\] gen_regfile_ff.register_file_i.rf_reg\[966\]
+ net2168 net1903 _07864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12011_ _07863_ _07864_ net1857 _07865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12012_ gen_regfile_ff.register_file_i.rf_reg\[646\] gen_regfile_ff.register_file_i.rf_reg\[678\]
+ gen_regfile_ff.register_file_i.rf_reg\[710\] gen_regfile_ff.register_file_i.rf_reg\[742\]
+ net2151 net2078 _07866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12013_ gen_regfile_ff.register_file_i.rf_reg\[518\] gen_regfile_ff.register_file_i.rf_reg\[550\]
+ gen_regfile_ff.register_file_i.rf_reg\[582\] gen_regfile_ff.register_file_i.rf_reg\[614\]
+ net2151 net2078 _07867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12014_ _07866_ _07867_ net1847 _07868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12015_ net1899 net1858 _07869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12016_ _07862_ _07865_ _07868_ _07869_ _07870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12017_ gen_regfile_ff.register_file_i.rf_reg\[134\] gen_regfile_ff.register_file_i.rf_reg\[198\]
+ net2168 _07871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12018_ gen_regfile_ff.register_file_i.rf_reg\[166\] gen_regfile_ff.register_file_i.rf_reg\[230\]
+ net2168 _07872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12019_ net2078 gen_regfile_ff.register_file_i.rf_reg\[70\]
+ _07873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12020_ gen_regfile_ff.register_file_i.rf_reg\[38\] gen_regfile_ff.register_file_i.rf_reg\[102\]
+ net2168 _07874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12021_ _07871_ _07872_ _07873_ _07874_ net2104 net1847 _07875_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12022_ gen_regfile_ff.register_file_i.rf_reg\[294\] gen_regfile_ff.register_file_i.rf_reg\[358\]
+ gen_regfile_ff.register_file_i.rf_reg\[422\] gen_regfile_ff.register_file_i.rf_reg\[486\]
+ net2078 net1903 _07876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12023_ gen_regfile_ff.register_file_i.rf_reg\[262\] gen_regfile_ff.register_file_i.rf_reg\[326\]
+ gen_regfile_ff.register_file_i.rf_reg\[390\] gen_regfile_ff.register_file_i.rf_reg\[454\]
+ net2078 net1903 _07877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12024_ _07876_ _07877_ net1857 _07878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12025_ net1827 _07875_ _07878_ _07846_ _07879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12026_ _07870_ _07879_ _07880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12027_ net1797 net1790 _07881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12028_ _07860_ net1797 _07861_ _07881_ _01180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_12029_ _01180_ _01184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1682 _01270_ net1681 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12031_ net1816 _07692_ _07883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12032_ _07699_ _07775_ _07883_ _07697_ _07884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12033_ gen_regfile_ff.register_file_i.rf_reg\[519\] gen_regfile_ff.register_file_i.rf_reg\[583\]
+ gen_regfile_ff.register_file_i.rf_reg\[647\] gen_regfile_ff.register_file_i.rf_reg\[711\]
+ net1914 net1904 _07885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12034_ net1860 net1900 net1936 _07885_ _07886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12035_ gen_regfile_ff.register_file_i.rf_reg\[295\] gen_regfile_ff.register_file_i.rf_reg\[359\]
+ gen_regfile_ff.register_file_i.rf_reg\[423\] gen_regfile_ff.register_file_i.rf_reg\[487\]
+ net1914 net1904 _07887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12036_ net1899 net1859 net1854 _07887_ _07888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12037_ gen_regfile_ff.register_file_i.rf_reg\[263\] gen_regfile_ff.register_file_i.rf_reg\[327\]
+ gen_regfile_ff.register_file_i.rf_reg\[391\] gen_regfile_ff.register_file_i.rf_reg\[455\]
+ net1914 net1904 _07889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12038_ net1899 net1859 net1936 _07889_ _07890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12039_ gen_regfile_ff.register_file_i.rf_reg\[551\] gen_regfile_ff.register_file_i.rf_reg\[615\]
+ gen_regfile_ff.register_file_i.rf_reg\[679\] gen_regfile_ff.register_file_i.rf_reg\[743\]
+ net1914 net1904 _07891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12040_ net1860 net1900 net1854 _07891_ _07892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12041_ _07886_ _07888_ _07890_ _07892_ _07893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12042_ gen_regfile_ff.register_file_i.rf_reg\[807\] gen_regfile_ff.register_file_i.rf_reg\[871\]
+ gen_regfile_ff.register_file_i.rf_reg\[935\] gen_regfile_ff.register_file_i.rf_reg\[999\]
+ net1914 net1904 _07894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12043_ gen_regfile_ff.register_file_i.rf_reg\[775\] gen_regfile_ff.register_file_i.rf_reg\[839\]
+ gen_regfile_ff.register_file_i.rf_reg\[903\] gen_regfile_ff.register_file_i.rf_reg\[967\]
+ net1914 net1904 _07895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12044_ _07894_ _07895_ net1854 _07896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12045_ net1846 _07896_ _07897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12046_ gen_regfile_ff.register_file_i.rf_reg\[135\] gen_regfile_ff.register_file_i.rf_reg\[199\]
+ net1914 _07898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12047_ gen_regfile_ff.register_file_i.rf_reg\[167\] gen_regfile_ff.register_file_i.rf_reg\[231\]
+ net1914 _07899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12048_ net1914 gen_regfile_ff.register_file_i.rf_reg\[71\]
+ _07900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12049_ gen_regfile_ff.register_file_i.rf_reg\[39\] gen_regfile_ff.register_file_i.rf_reg\[103\]
+ net1914 _07901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12050_ _07898_ _07899_ _07900_ _07901_ net1936 net1848 _07902_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12051_ _07684_ _07902_ _07903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12052_ _07893_ _07897_ _07903_ _07904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_12053_ net1896 _07884_ net1797 net1788 _01191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
X_12054_ net1895 _07905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12055_ gen_regfile_ff.register_file_i.rf_reg\[520\] gen_regfile_ff.register_file_i.rf_reg\[584\]
+ gen_regfile_ff.register_file_i.rf_reg\[648\] gen_regfile_ff.register_file_i.rf_reg\[712\]
+ net1922 net1905 _07906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12056_ net1860 net1900 net2112 _07906_ _07907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12057_ gen_regfile_ff.register_file_i.rf_reg\[296\] gen_regfile_ff.register_file_i.rf_reg\[360\]
+ gen_regfile_ff.register_file_i.rf_reg\[424\] gen_regfile_ff.register_file_i.rf_reg\[488\]
+ net1922 net1905 _07908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12058_ net1853 _07789_ _07908_ _07909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12059_ gen_regfile_ff.register_file_i.rf_reg\[264\] gen_regfile_ff.register_file_i.rf_reg\[328\]
+ gen_regfile_ff.register_file_i.rf_reg\[392\] gen_regfile_ff.register_file_i.rf_reg\[456\]
+ net1922 net1905 _07910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12060_ net1939 _07789_ _07910_ _07911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12061_ gen_regfile_ff.register_file_i.rf_reg\[552\] gen_regfile_ff.register_file_i.rf_reg\[616\]
+ gen_regfile_ff.register_file_i.rf_reg\[680\] gen_regfile_ff.register_file_i.rf_reg\[744\]
+ net1922 net1905 _07912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12062_ _07802_ _07912_ _07913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12063_ _07907_ _07909_ _07911_ _07913_ _07914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12064_ gen_regfile_ff.register_file_i.rf_reg\[808\] gen_regfile_ff.register_file_i.rf_reg\[872\]
+ gen_regfile_ff.register_file_i.rf_reg\[936\] gen_regfile_ff.register_file_i.rf_reg\[1000\]
+ net1922 net1905 _07915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12065_ gen_regfile_ff.register_file_i.rf_reg\[776\] gen_regfile_ff.register_file_i.rf_reg\[840\]
+ gen_regfile_ff.register_file_i.rf_reg\[904\] gen_regfile_ff.register_file_i.rf_reg\[968\]
+ net1922 net1905 _07916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12066_ _07915_ _07916_ net1854 _07917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12067_ net1846 _07917_ _07918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12068_ gen_regfile_ff.register_file_i.rf_reg\[40\] gen_regfile_ff.register_file_i.rf_reg\[104\]
+ net1922 _07919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12069_ gen_regfile_ff.register_file_i.rf_reg\[72\] net1829
+ _07919_ net1936 _07920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12070_ gen_regfile_ff.register_file_i.rf_reg\[136\] gen_regfile_ff.register_file_i.rf_reg\[168\]
+ gen_regfile_ff.register_file_i.rf_reg\[200\] gen_regfile_ff.register_file_i.rf_reg\[232\]
+ net1936 net1922 _07921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12071_ net1905 _07921_ _07922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12072_ net1905 _07920_ _07922_ _07842_ _07923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12073_ _07914_ _07918_ _07923_ _07924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12074_ _07905_ _07836_ _07924_ net1795 _07925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xclkload4 clknet_leaf_27_clk_i_regs _unconnected_4 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_12076_ net1699 _01198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12077_ net1894 _07926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12078_ gen_regfile_ff.register_file_i.rf_reg\[521\] gen_regfile_ff.register_file_i.rf_reg\[585\]
+ gen_regfile_ff.register_file_i.rf_reg\[649\] gen_regfile_ff.register_file_i.rf_reg\[713\]
+ net2089 net1903 _07927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12079_ net1862 net1902 net2114 _07927_ _07928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12080_ gen_regfile_ff.register_file_i.rf_reg\[297\] gen_regfile_ff.register_file_i.rf_reg\[361\]
+ gen_regfile_ff.register_file_i.rf_reg\[425\] gen_regfile_ff.register_file_i.rf_reg\[489\]
+ net1912 net1903 _07929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12081_ net1856 _07789_ _07929_ _07930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12082_ gen_regfile_ff.register_file_i.rf_reg\[265\] gen_regfile_ff.register_file_i.rf_reg\[329\]
+ gen_regfile_ff.register_file_i.rf_reg\[393\] gen_regfile_ff.register_file_i.rf_reg\[457\]
+ net1912 net1903 _07931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12083_ net2114 _07789_ _07931_ _07932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12084_ gen_regfile_ff.register_file_i.rf_reg\[553\] gen_regfile_ff.register_file_i.rf_reg\[617\]
+ gen_regfile_ff.register_file_i.rf_reg\[681\] gen_regfile_ff.register_file_i.rf_reg\[745\]
+ net2089 net1903 _07933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12085_ _07802_ _07933_ _07934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12086_ _07928_ _07930_ _07932_ _07934_ _07935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12087_ gen_regfile_ff.register_file_i.rf_reg\[809\] gen_regfile_ff.register_file_i.rf_reg\[873\]
+ gen_regfile_ff.register_file_i.rf_reg\[937\] gen_regfile_ff.register_file_i.rf_reg\[1001\]
+ net1910 net1903 _07936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12088_ gen_regfile_ff.register_file_i.rf_reg\[777\] gen_regfile_ff.register_file_i.rf_reg\[841\]
+ gen_regfile_ff.register_file_i.rf_reg\[905\] gen_regfile_ff.register_file_i.rf_reg\[969\]
+ net1910 net1903 _07937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12089_ _07936_ _07937_ net1856 _07938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12090_ _07689_ _07938_ _07939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12091_ gen_regfile_ff.register_file_i.rf_reg\[41\] gen_regfile_ff.register_file_i.rf_reg\[105\]
+ net1912 _07940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12092_ gen_regfile_ff.register_file_i.rf_reg\[73\] net1829
+ _07940_ net1945 _07941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12093_ gen_regfile_ff.register_file_i.rf_reg\[137\] gen_regfile_ff.register_file_i.rf_reg\[169\]
+ gen_regfile_ff.register_file_i.rf_reg\[201\] gen_regfile_ff.register_file_i.rf_reg\[233\]
+ net1945 net1912 _07942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12094_ net1903 _07942_ _07943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12095_ net1903 _07941_ _07943_ _07842_ _07944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12096_ _07935_ _07939_ _07944_ _07945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_12097_ _07926_ _07836_ _07945_ net1795 _07946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xclkload5 clknet_leaf_29_clk_i_regs _unconnected_5 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12099_ net1698 _01205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12100_ net1892 _07947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload6 clknet_leaf_30_clk_i_regs _unconnected_6 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12102_ gen_regfile_ff.register_file_i.rf_reg\[522\] gen_regfile_ff.register_file_i.rf_reg\[586\]
+ gen_regfile_ff.register_file_i.rf_reg\[650\] gen_regfile_ff.register_file_i.rf_reg\[714\]
+ net1912 net1905 _07949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12103_ net1862 net1902 net1951 _07949_ _07950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12104_ gen_regfile_ff.register_file_i.rf_reg\[298\] gen_regfile_ff.register_file_i.rf_reg\[362\]
+ gen_regfile_ff.register_file_i.rf_reg\[426\] gen_regfile_ff.register_file_i.rf_reg\[490\]
+ net1915 net1905 _07951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12105_ net1853 _07789_ _07951_ _07952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12106_ gen_regfile_ff.register_file_i.rf_reg\[266\] gen_regfile_ff.register_file_i.rf_reg\[330\]
+ gen_regfile_ff.register_file_i.rf_reg\[394\] gen_regfile_ff.register_file_i.rf_reg\[458\]
+ net1915 net1905 _07953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12107_ net1951 _07789_ _07953_ _07954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12108_ gen_regfile_ff.register_file_i.rf_reg\[554\] gen_regfile_ff.register_file_i.rf_reg\[618\]
+ gen_regfile_ff.register_file_i.rf_reg\[682\] gen_regfile_ff.register_file_i.rf_reg\[746\]
+ net1912 net1905 _07955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12109_ _07802_ _07955_ _07956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12110_ _07950_ _07952_ _07954_ _07956_ _07957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12111_ gen_regfile_ff.register_file_i.rf_reg\[810\] gen_regfile_ff.register_file_i.rf_reg\[874\]
+ gen_regfile_ff.register_file_i.rf_reg\[938\] gen_regfile_ff.register_file_i.rf_reg\[1002\]
+ net1917 net1905 _07958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12112_ gen_regfile_ff.register_file_i.rf_reg\[778\] gen_regfile_ff.register_file_i.rf_reg\[842\]
+ gen_regfile_ff.register_file_i.rf_reg\[906\] gen_regfile_ff.register_file_i.rf_reg\[970\]
+ net1917 net1905 _07959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12113_ _07958_ _07959_ net1853 _07960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12114_ net1846 _07960_ _07961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12115_ gen_regfile_ff.register_file_i.rf_reg\[42\] gen_regfile_ff.register_file_i.rf_reg\[106\]
+ net2179 _07962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12116_ gen_regfile_ff.register_file_i.rf_reg\[74\] net1829
+ _07962_ net1957 _07963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12117_ gen_regfile_ff.register_file_i.rf_reg\[138\] gen_regfile_ff.register_file_i.rf_reg\[170\]
+ gen_regfile_ff.register_file_i.rf_reg\[202\] gen_regfile_ff.register_file_i.rf_reg\[234\]
+ net1957 net1915 _07964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12118_ net1905 _07964_ _07965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12119_ net1905 _07963_ _07965_ _07842_ _07966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12120_ _07957_ _07961_ _07966_ _07967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_12121_ net1845 _07836_ _07967_ net1795 _01208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12122_ net1697 _01212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12123_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _07968_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12124_ net1891 net2181 _07713_ _07969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12125_ _07968_ net2069 _07714_ _07969_ _07970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12126_ net2061 _07710_ _07971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12127_ gen_regfile_ff.register_file_i.rf_reg\[523\] gen_regfile_ff.register_file_i.rf_reg\[555\]
+ gen_regfile_ff.register_file_i.rf_reg\[587\] gen_regfile_ff.register_file_i.rf_reg\[619\]
+ net1931 net2078 _07972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12128_ net1903 _07972_ _07973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12129_ gen_regfile_ff.register_file_i.rf_reg\[683\] gen_regfile_ff.register_file_i.rf_reg\[747\]
+ net2078 _07974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12130_ _07840_ _07974_ _07975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12131_ gen_regfile_ff.register_file_i.rf_reg\[651\] gen_regfile_ff.register_file_i.rf_reg\[715\]
+ net1906 _07976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12132_ net2104 net1847 _07976_ _07977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12133_ _07869_ _07973_ _07975_ _07977_ _07978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12134_ gen_regfile_ff.register_file_i.rf_reg\[811\] gen_regfile_ff.register_file_i.rf_reg\[875\]
+ gen_regfile_ff.register_file_i.rf_reg\[939\] gen_regfile_ff.register_file_i.rf_reg\[1003\]
+ net2078 net1903 _07979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12135_ gen_regfile_ff.register_file_i.rf_reg\[779\] gen_regfile_ff.register_file_i.rf_reg\[843\]
+ gen_regfile_ff.register_file_i.rf_reg\[907\] gen_regfile_ff.register_file_i.rf_reg\[971\]
+ net2078 net1903 _07980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12136_ _07979_ _07980_ net1857 _07981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12137_ _07862_ _07981_ _07982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12138_ gen_regfile_ff.register_file_i.rf_reg\[139\] gen_regfile_ff.register_file_i.rf_reg\[203\]
+ net1906 _07983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12139_ gen_regfile_ff.register_file_i.rf_reg\[171\] gen_regfile_ff.register_file_i.rf_reg\[235\]
+ net1906 _07984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12140_ net2078 gen_regfile_ff.register_file_i.rf_reg\[75\]
+ _07985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12141_ gen_regfile_ff.register_file_i.rf_reg\[43\] gen_regfile_ff.register_file_i.rf_reg\[107\]
+ net1906 _07986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12142_ _07983_ _07984_ _07985_ _07986_ net2151 net1847 _07987_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12143_ net1827 _07987_ _07988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12144_ gen_regfile_ff.register_file_i.rf_reg\[267\] gen_regfile_ff.register_file_i.rf_reg\[299\]
+ gen_regfile_ff.register_file_i.rf_reg\[395\] gen_regfile_ff.register_file_i.rf_reg\[427\]
+ net1931 net1903 _07989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12145_ gen_regfile_ff.register_file_i.rf_reg\[331\] gen_regfile_ff.register_file_i.rf_reg\[363\]
+ gen_regfile_ff.register_file_i.rf_reg\[459\] gen_regfile_ff.register_file_i.rf_reg\[491\]
+ net1931 net1903 _07990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12146_ _07989_ _07990_ net2078 _07991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12147_ _07846_ _07991_ _07992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12148_ _07982_ _07978_ _07988_ _07992_ _07993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_12149_ net1932 net1816 _07692_ _07994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12150_ _07706_ _07699_ _07714_ _07994_ _07995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12151_ _07970_ _07971_ net1787 net1797 _07995_ _07996_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12152_ _07996_ _07997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xplace1681 _01284_ net1680 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1680 _01291_ net1679 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1679 _01298_ net1678 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12156_ _07581_ _07582_ _07583_ _07585_ _07999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_12157_ net2020 _08000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xplace1678 _01305_ net1677 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload7 clknet_leaf_32_clk_i_regs _unconnected_7 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_12160_ net1958 net1959 net1962 net1975 _08003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12161_ net2005 _08003_ _08004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12162_ _08000_ _08004_ _08005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12163_ net2021 net1826 _08005_ _00946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12164_ _00946_ _00949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkload8 clknet_leaf_33_clk_i_regs _unconnected_8 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload9 clknet_leaf_1_clk_i_regs _unconnected_9 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12167_ net2020 net1826 _08004_ _08008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12168_ _08008_ _08009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1677 _01333_ net1676 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12170_ gen_regfile_ff.register_file_i.raddr_a_i\[4\] _08010_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1676 _01340_ net1675 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload10 clknet_leaf_2_clk_i_regs _unconnected_10 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_16
Xplace1675 _09674_ net1674 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1674 _09678_ net1673 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12175_ gen_regfile_ff.register_file_i.rf_reg\[907\] gen_regfile_ff.register_file_i.rf_reg\[939\]
+ gen_regfile_ff.register_file_i.rf_reg\[971\] gen_regfile_ff.register_file_i.rf_reg\[1003\]
+ net2004 net1964 _08015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1673 _09682_ net1672 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12177_ gen_regfile_ff.register_file_i.rf_reg\[779\] gen_regfile_ff.register_file_i.rf_reg\[811\]
+ gen_regfile_ff.register_file_i.rf_reg\[843\] gen_regfile_ff.register_file_i.rf_reg\[875\]
+ net2004 net1964 _08017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12178_ gen_regfile_ff.register_file_i.rf_reg\[651\] gen_regfile_ff.register_file_i.rf_reg\[683\]
+ gen_regfile_ff.register_file_i.rf_reg\[715\] gen_regfile_ff.register_file_i.rf_reg\[747\]
+ net2004 net1967 _08018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12179_ gen_regfile_ff.register_file_i.rf_reg\[523\] gen_regfile_ff.register_file_i.rf_reg\[555\]
+ gen_regfile_ff.register_file_i.rf_reg\[587\] gen_regfile_ff.register_file_i.rf_reg\[619\]
+ net2018 net1964 _08019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload11 clknet_leaf_4_clk_i_regs _unconnected_11 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xplace1671 _09751_ net1670 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_12182_ _08015_ _08017_ _08018_ _08019_ _07518_ net1865 _08022_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1672 net1670 net1671 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1669 _09755_ net1668 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12185_ gen_regfile_ff.register_file_i.rf_reg\[395\] gen_regfile_ff.register_file_i.rf_reg\[427\]
+ gen_regfile_ff.register_file_i.rf_reg\[459\] gen_regfile_ff.register_file_i.rf_reg\[491\]
+ net2018 net1964 _08025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12186_ gen_regfile_ff.register_file_i.rf_reg\[267\] gen_regfile_ff.register_file_i.rf_reg\[299\]
+ gen_regfile_ff.register_file_i.rf_reg\[331\] gen_regfile_ff.register_file_i.rf_reg\[363\]
+ net2018 net1964 _08026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1667 _09768_ net1666 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12188_ gen_regfile_ff.register_file_i.rf_reg\[139\] gen_regfile_ff.register_file_i.rf_reg\[171\]
+ gen_regfile_ff.register_file_i.rf_reg\[203\] gen_regfile_ff.register_file_i.rf_reg\[235\]
+ net2018 net1964 _08028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12189_ gen_regfile_ff.register_file_i.rf_reg\[75\] gen_regfile_ff.register_file_i.rf_reg\[107\]
+ net2018 _08029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12190_ net2018 gen_regfile_ff.register_file_i.rf_reg\[43\]
+ _08030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12191_ _08029_ _08030_ net1869 _08031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12192_ _08025_ _08026_ _08028_ _08031_ _07518_ net1865 _08032_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12193_ net1958 _08032_ _08033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12194_ net1842 _08022_ _08033_ _08034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12195_ cs_registers_i.pc_id_i\[11\] net2064 _08035_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12196_ id_stage_i.controller_i.lsu_addr_last_i\[11\] net2483
+ _08036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12197_ net2126 net1738 _08035_ net2052 _08036_ _01214_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12198_ net2159 _01218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12199_ id_stage_i.controller_i.lsu_addr_last_i\[1\] _08037_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12200_ _07559_ _07588_ _08038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12201_ _07606_ _07645_ _07560_ _08039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12202_ _08038_ _08039_ net1831 _07594_ _07587_ _08040_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_12203_ _08040_ _07601_ net1818 _08041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xplace1664 _09772_ net1663 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12205_ net1831 net1826 _08043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
Xplace1663 _09772_ net1662 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12207_ net1965 _08043_ _08045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12208_ _07613_ _07619_ _08045_ net1816 _08046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12209_ id_stage_i.controller_i.instr_i\[13\] id_stage_i.controller_i.instr_i\[14\]
+ _08047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12210_ _08047_ _07594_ _07650_ _07653_ _08048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12211_ _07565_ _07573_ _07618_ _08048_ _08049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12212_ _08037_ _08041_ _08046_ _08049_ _08050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xplace1659 _09782_ net1658 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1660 _09776_ net1659 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1658 _09784_ net1657 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12216_ gen_regfile_ff.register_file_i.rf_reg\[385\] gen_regfile_ff.register_file_i.rf_reg\[417\]
+ gen_regfile_ff.register_file_i.rf_reg\[449\] gen_regfile_ff.register_file_i.rf_reg\[481\]
+ net2137 net1964 _08054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1655 _09787_ net1654 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12218_ gen_regfile_ff.register_file_i.rf_reg\[257\] gen_regfile_ff.register_file_i.rf_reg\[289\]
+ gen_regfile_ff.register_file_i.rf_reg\[321\] gen_regfile_ff.register_file_i.rf_reg\[353\]
+ net2137 net1964 _08056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12219_ gen_regfile_ff.register_file_i.rf_reg\[129\] gen_regfile_ff.register_file_i.rf_reg\[161\]
+ gen_regfile_ff.register_file_i.rf_reg\[193\] gen_regfile_ff.register_file_i.rf_reg\[225\]
+ net2137 net1964 _08057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12220_ gen_regfile_ff.register_file_i.rf_reg\[65\] gen_regfile_ff.register_file_i.rf_reg\[97\]
+ net2002 _08058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1656 net1654 net1655 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12222_ net2137 gen_regfile_ff.register_file_i.rf_reg\[33\]
+ _08060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1653 _09792_ net1652 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12224_ _08058_ _08060_ net1869 _08062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1650 _09794_ net1649 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1649 _09798_ net1648 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12227_ _08054_ _08056_ _08057_ _08062_ _07518_ net1864 _08065_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1648 net1646 net1647 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12229_ gen_regfile_ff.register_file_i.rf_reg\[897\] gen_regfile_ff.register_file_i.rf_reg\[929\]
+ gen_regfile_ff.register_file_i.rf_reg\[961\] gen_regfile_ff.register_file_i.rf_reg\[993\]
+ net2002 net1964 _08067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1647 _09803_ net1646 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12231_ gen_regfile_ff.register_file_i.rf_reg\[769\] gen_regfile_ff.register_file_i.rf_reg\[801\]
+ gen_regfile_ff.register_file_i.rf_reg\[833\] gen_regfile_ff.register_file_i.rf_reg\[865\]
+ net2002 net1964 _08069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12232_ gen_regfile_ff.register_file_i.rf_reg\[641\] gen_regfile_ff.register_file_i.rf_reg\[673\]
+ gen_regfile_ff.register_file_i.rf_reg\[705\] gen_regfile_ff.register_file_i.rf_reg\[737\]
+ net2002 net1964 _08070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12233_ gen_regfile_ff.register_file_i.rf_reg\[513\] gen_regfile_ff.register_file_i.rf_reg\[545\]
+ gen_regfile_ff.register_file_i.rf_reg\[577\] gen_regfile_ff.register_file_i.rf_reg\[609\]
+ net2002 net1964 _08071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12234_ _08067_ _08069_ _08070_ _08071_ _07518_ net1864 _08072_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12235_ net1842 _08072_ _08073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12236_ net1958 _08065_ _08073_ _08074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12237_ _07613_ _07619_ cs_registers_i.pc_id_i\[1\] net1816
+ _08075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xplace1651 net1649 net1650 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12239_ net2100 net1786 _08075_ net2063 _08077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12240_ _08050_ _08077_ _01145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12241_ _01145_ _01149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1645 _09807_ net1644 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1643 _09810_ net1642 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12244_ net2007 _08049_ _08043_ _08080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12245_ id_stage_i.controller_i.lsu_addr_last_i\[0\] _08049_
+ _08081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12246_ _08080_ _08081_ _07622_ _08082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12247_ net1818 _07577_ _07587_ _07602_ _08083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
Xplace1642 _09814_ net1641 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12249_ gen_regfile_ff.register_file_i.rf_reg\[896\] gen_regfile_ff.register_file_i.rf_reg\[928\]
+ gen_regfile_ff.register_file_i.rf_reg\[960\] gen_regfile_ff.register_file_i.rf_reg\[992\]
+ net2002 net1964 _08085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12250_ gen_regfile_ff.register_file_i.rf_reg\[768\] gen_regfile_ff.register_file_i.rf_reg\[800\]
+ gen_regfile_ff.register_file_i.rf_reg\[832\] gen_regfile_ff.register_file_i.rf_reg\[864\]
+ net2002 net1964 _08086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1641 _09817_ net1640 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12252_ gen_regfile_ff.register_file_i.rf_reg\[640\] gen_regfile_ff.register_file_i.rf_reg\[672\]
+ gen_regfile_ff.register_file_i.rf_reg\[704\] gen_regfile_ff.register_file_i.rf_reg\[736\]
+ net2002 net1964 _08088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12253_ gen_regfile_ff.register_file_i.rf_reg\[512\] gen_regfile_ff.register_file_i.rf_reg\[544\]
+ gen_regfile_ff.register_file_i.rf_reg\[576\] gen_regfile_ff.register_file_i.rf_reg\[608\]
+ net2002 net1964 _08089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12254_ _08085_ _08086_ _08088_ _08089_ _07518_ net1864 _08090_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12255_ gen_regfile_ff.register_file_i.rf_reg\[384\] gen_regfile_ff.register_file_i.rf_reg\[416\]
+ gen_regfile_ff.register_file_i.rf_reg\[448\] gen_regfile_ff.register_file_i.rf_reg\[480\]
+ net2137 net1964 _08091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12256_ gen_regfile_ff.register_file_i.rf_reg\[256\] gen_regfile_ff.register_file_i.rf_reg\[288\]
+ gen_regfile_ff.register_file_i.rf_reg\[320\] gen_regfile_ff.register_file_i.rf_reg\[352\]
+ net2002 net1964 _08092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12257_ gen_regfile_ff.register_file_i.rf_reg\[128\] gen_regfile_ff.register_file_i.rf_reg\[160\]
+ gen_regfile_ff.register_file_i.rf_reg\[192\] gen_regfile_ff.register_file_i.rf_reg\[224\]
+ net2137 net1964 _08093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12258_ gen_regfile_ff.register_file_i.rf_reg\[64\] gen_regfile_ff.register_file_i.rf_reg\[96\]
+ net2002 _08094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12259_ net2137 gen_regfile_ff.register_file_i.rf_reg\[32\]
+ _08095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12260_ _08094_ _08095_ net1869 _08096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12261_ _08091_ _08092_ _08093_ _08096_ _07518_ net1864 _08097_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12262_ _08090_ _08097_ net1842 _08098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12263_ _08083_ net1784 _08099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12264_ _08082_ _08099_ _01139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12265_ _01139_ _01143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1644 net1642 net1643 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12267_ net2022 net2019 net1845 _08101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xplace1640 _09821_ net1639 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12269_ _07595_ _07579_ net1892 _08103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12270_ _08101_ _08103_ _08000_ _08104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12271_ net2020 _07595_ _08105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12272_ net1892 _08105_ _08106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12273_ _07566_ net2189 _08107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12274_ _07616_ _08107_ _08108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12275_ net1894 net1895 net1891 _08109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_12276_ net1898 net1896 net1897 _08110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_12277_ _08109_ _08110_ _08111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12278_ _08104_ _08106_ _08108_ _08111_ _08112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12279_ net2022 _07579_ _08113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12280_ _07557_ id_stage_i.controller_i.instr_valid_i _07599_
+ _07590_ _08114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_12281_ _07711_ _08114_ _08115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12282_ net1896 net1894 net1895 net1891 _08116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_12283_ _08000_ net2021 net2019 _07947_ _08117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12284_ net2020 _07595_ _08116_ _08117_ _08118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12285_ _07557_ _07561_ _07582_ _07583_ _08119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12286_ net2020 _08113_ _08115_ _08118_ _08119_ _08120_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_12287_ _08000_ net2022 _08121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12288_ _07566_ net1889 _08122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12289_ net2019 _07947_ _08109_ _08110_ _08123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12290_ net1896 net1894 net1895 net1891 _08124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12291_ net2019 _08124_ _08125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12292_ _07584_ _08122_ _08123_ _08125_ _08119_ _08126_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_12293_ _07711_ _07632_ _08114_ _08127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_12294_ _08121_ _08126_ _08127_ _08128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12295_ _08112_ _08120_ _08128_ _08129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12296_ _07567_ net1889 _07590_ _08130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12297_ net2130 _07570_ _07574_ _08131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12298_ net2146 _07581_ net2130 _08132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12299_ net2130 net2146 net2189 _08133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12300_ _07586_ _08133_ _08134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12301_ _08130_ _08131_ _08132_ net2144 _08134_ _08135_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12302_ net2020 _07579_ _08136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12303_ net2021 net2019 _08137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12304_ _08000_ _08124_ _08137_ _08138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12305_ _08136_ _08138_ _08119_ _08139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12306_ _08139_ _08135_ _08140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12307_ net2170 net2021 net2149 _08141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12308_ _08114_ _08141_ net2020 _07711_ _08142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12309_ net2021 net2019 _08143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12310_ _07711_ _08114_ _08143_ _08144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12311_ net1845 _08109_ _08110_ _08145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12312_ net2020 _08137_ _08146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12313_ _07584_ _08122_ _08145_ _08146_ _08147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12314_ _08142_ _08144_ _08147_ _08148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12315_ _08000_ _08124_ _08149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12316_ _07595_ _07579_ _08150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12317_ _08137_ _08149_ _08150_ _08119_ _08151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12318_ _08000_ net2022 _08152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12319_ _08000_ net2022 _07579_ _08153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12320_ _07711_ _08152_ _08114_ _08153_ _08154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12321_ _08135_ _08151_ _08154_ _08155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_12322_ _07616_ _08107_ _08156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12323_ net1898 _07947_ _08157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12324_ net2020 net2021 _08158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12325_ _07579_ _07947_ _08158_ _08159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12326_ _08000_ net2022 net2019 _07833_ _08160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_12327_ id_stage_i.controller_i.instr_i\[29\] id_stage_i.controller_i.instr_i\[28\]
+ id_stage_i.controller_i.instr_i\[31\] _08161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12328_ net1896 net1897 _08162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12329_ _08161_ _08162_ _08163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12330_ _08157_ _08159_ _08160_ _08163_ _08164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12331_ _07579_ net1892 _08158_ _08165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12332_ net2020 net1845 _08143_ _08166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12333_ _08109_ _08110_ _08167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12334_ _08165_ _08166_ _08167_ _08168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12335_ _08156_ _08164_ _08168_ _08169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12336_ _08155_ _08148_ _08140_ _08169_ _08170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_12337_ net2019 _08105_ _08145_ _08171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12338_ _07860_ _08171_ _08108_ _08172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12339_ _08157_ _08159_ _08160_ _08173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12340_ _07579_ _08047_ net2021 _08174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12341_ net2020 _07947_ _08143_ _08175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12342_ _07579_ net1892 _08158_ _08176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12343_ net1892 _08174_ _08175_ _08176_ _08177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12344_ _08163_ _08173_ _08177_ _08167_ _08108_ _08178_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12345_ _07711_ _08114_ _08179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12346_ id_stage_i.controller_i.instr_i\[27\] id_stage_i.controller_i.instr_i\[26\]
+ id_stage_i.controller_i.instr_i\[30\] _08180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12347_ _07833_ _08161_ _08180_ _08181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_12348_ _07616_ _08107_ _08181_ _08182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_12349_ _08179_ _08135_ _08139_ _08182_ _08183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12350_ _08183_ _08178_ _08172_ _08184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_12351_ _08170_ _08129_ _08184_ _08185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
Xplace1646 _09807_ net1645 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12353_ net2111 _00009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12354_ _08156_ net1825 _08187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xplace1652 _09794_ net1651 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1639 net1637 net1638 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1638 net1636 net1637 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12358_ net2092 _08191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12359_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ _08192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xplace1637 _09827_ net1636 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12361_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[6\]
+ _08194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1636 _09832_ net1635 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12363_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[1\]
+ _08196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_12364_ _08194_ _08196_ _08197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1654 _09792_ net1653 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12366_ _08194_ _08196_ _08199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12367_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[5\] _08199_
+ _08200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12368_ net1841 ex_block_i.alu_i.imd_val_q_i\[32\] ex_block_i.alu_i.imd_val_q_i\[0\]
+ _08197_ _08200_ net1798 _08201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_12369_ net2028 net1737 _08201_ _08202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12370_ _08187_ _08202_ _08203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12371_ _07595_ _07579_ net1892 _08204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12372_ net2022 net2019 net1845 _08205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12373_ _08204_ _08205_ net2020 _08206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12374_ net1892 _08105_ _08207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12375_ _08206_ _08207_ _08156_ _08167_ _08208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12376_ _07607_ _07711_ _08209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12377_ net2019 net1845 _08210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12378_ _08152_ _08210_ _08124_ _08105_ _08211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12379_ net2020 _08113_ _08212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12380_ _08209_ _08211_ _08212_ _08179_ _08213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12381_ _08121_ _08126_ _08214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12382_ _08208_ _08213_ _08127_ _08214_ _08215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_12383_ _08155_ _08148_ _08140_ _08169_ _08216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_12384_ _08179_ _08140_ _08172_ _08178_ _08217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_12385_ _08216_ _08215_ _08217_ _08218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12386_ net1693 net1694 _07695_ _08219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12387_ _08203_ _08219_ _00008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12388_ _00008_ _00815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12389_ _01139_ _08187_ _08220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1635 _09835_ net1634 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1632 _09841_ net1631 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1633 net1631 net1632 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12393_ ex_block_i.alu_i.imd_val_q_i\[32\] net1814 net1823
+ _08224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12394_ _08220_ _08224_ _00814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12395_ _00814_ _00007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12396_ _00010_ net2071 alu_adder_result_ex\[1\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12397_ alu_adder_result_ex\[1\] _01363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1631 _09844_ net1630 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace1634 net1632 net1633 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12400_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ _08227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12401_ _08227_ _08192_ _08197_ _08228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xplace1630 _09846_ net1629 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1657 _09787_ net1656 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1628 _09849_ net1627 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1626 _09853_ net1625 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12406_ gen_regfile_ff.register_file_i.rf_reg\[386\] gen_regfile_ff.register_file_i.rf_reg\[418\]
+ gen_regfile_ff.register_file_i.rf_reg\[450\] gen_regfile_ff.register_file_i.rf_reg\[482\]
+ net1999 net1964 _08233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12407_ gen_regfile_ff.register_file_i.rf_reg\[258\] gen_regfile_ff.register_file_i.rf_reg\[290\]
+ gen_regfile_ff.register_file_i.rf_reg\[322\] gen_regfile_ff.register_file_i.rf_reg\[354\]
+ net1999 net1964 _08234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1627 net1625 net1626 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1625 _09859_ net1624 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12410_ gen_regfile_ff.register_file_i.rf_reg\[130\] gen_regfile_ff.register_file_i.rf_reg\[162\]
+ gen_regfile_ff.register_file_i.rf_reg\[194\] gen_regfile_ff.register_file_i.rf_reg\[226\]
+ net1999 net1964 _08237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12411_ gen_regfile_ff.register_file_i.rf_reg\[66\] gen_regfile_ff.register_file_i.rf_reg\[98\]
+ net1999 _08238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1629 net1627 net1628 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12413_ net1999 gen_regfile_ff.register_file_i.rf_reg\[34\]
+ _08240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12414_ _08238_ _08240_ net1872 _08241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1623 _09871_ net1622 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12416_ _08233_ _08234_ _08237_ _08241_ _07518_ net1867 _08243_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1624 _09871_ net1623 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1621 _09880_ net1620 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12419_ gen_regfile_ff.register_file_i.rf_reg\[898\] gen_regfile_ff.register_file_i.rf_reg\[930\]
+ gen_regfile_ff.register_file_i.rf_reg\[962\] gen_regfile_ff.register_file_i.rf_reg\[994\]
+ net1999 net1964 _08246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12420_ gen_regfile_ff.register_file_i.rf_reg\[770\] gen_regfile_ff.register_file_i.rf_reg\[802\]
+ gen_regfile_ff.register_file_i.rf_reg\[834\] gen_regfile_ff.register_file_i.rf_reg\[866\]
+ net1999 net1964 _08247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12421_ gen_regfile_ff.register_file_i.rf_reg\[642\] gen_regfile_ff.register_file_i.rf_reg\[674\]
+ gen_regfile_ff.register_file_i.rf_reg\[706\] gen_regfile_ff.register_file_i.rf_reg\[738\]
+ net1999 net1964 _08248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12422_ gen_regfile_ff.register_file_i.rf_reg\[514\] gen_regfile_ff.register_file_i.rf_reg\[546\]
+ gen_regfile_ff.register_file_i.rf_reg\[578\] gen_regfile_ff.register_file_i.rf_reg\[610\]
+ net1999 net1964 _08249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12423_ _08246_ _08247_ _08248_ _08249_ _07518_ net1867 _08250_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12424_ net1842 _08250_ _08251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12425_ net1958 _08243_ _08251_ _08252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
Xplace1622 net1620 net1621 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1620 _09891_ net1619 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1619 _09955_ net1618 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12429_ net1841 ex_block_i.alu_i.imd_val_q_i\[34\] ex_block_i.alu_i.imd_val_q_i\[2\]
+ net1824 _08256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_12430_ _07765_ _08228_ net1781 net2028 _08256_ _08257_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xplace1618 _03879_ net1617 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12432_ _08218_ net1694 _07772_ _08259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12433_ _08187_ _08257_ _08259_ _00823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12434_ id_stage_i.controller_i.lsu_addr_last_i\[2\] _08260_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1617 _04583_ net1616 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1614 _05837_ net1613 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12437_ net1962 _08043_ _08263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12438_ _07613_ _07619_ _08263_ net1816 _08264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12439_ _08260_ _08041_ _08264_ _08049_ _08265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12440_ _07613_ _07619_ cs_registers_i.pc_id_i\[2\] net1816
+ _08266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12441_ _08041_ net1781 _08266_ net2063 _08267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12442_ _08265_ _08267_ _01151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12443_ _01151_ _01155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12444_ id_stage_i.controller_i.lsu_addr_last_i\[3\] _08268_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1613 _07695_ net1612 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12446_ net1960 _08043_ _08270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12447_ _07613_ _07619_ _08270_ net1816 _08271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12448_ _08268_ _08041_ _08271_ _08049_ _08272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12449_ gen_regfile_ff.register_file_i.rf_reg\[387\] gen_regfile_ff.register_file_i.rf_reg\[419\]
+ gen_regfile_ff.register_file_i.rf_reg\[451\] gen_regfile_ff.register_file_i.rf_reg\[483\]
+ net1994 net1973 _08273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12450_ gen_regfile_ff.register_file_i.rf_reg\[259\] gen_regfile_ff.register_file_i.rf_reg\[291\]
+ gen_regfile_ff.register_file_i.rf_reg\[323\] gen_regfile_ff.register_file_i.rf_reg\[355\]
+ net1994 net1973 _08274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1612 _07772_ net1611 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1611 _07997_ net1610 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12453_ gen_regfile_ff.register_file_i.rf_reg\[131\] gen_regfile_ff.register_file_i.rf_reg\[163\]
+ gen_regfile_ff.register_file_i.rf_reg\[195\] gen_regfile_ff.register_file_i.rf_reg\[227\]
+ net1995 net1973 _08277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12454_ gen_regfile_ff.register_file_i.rf_reg\[67\] gen_regfile_ff.register_file_i.rf_reg\[99\]
+ net1994 _08278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12455_ net1994 gen_regfile_ff.register_file_i.rf_reg\[35\]
+ _08279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12456_ _08278_ _08279_ net1874 _08280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1615 _04672_ net1614 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12458_ _08273_ _08274_ _08277_ _08280_ net1877 net1866 _08282_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12459_ gen_regfile_ff.register_file_i.rf_reg\[899\] gen_regfile_ff.register_file_i.rf_reg\[931\]
+ gen_regfile_ff.register_file_i.rf_reg\[963\] gen_regfile_ff.register_file_i.rf_reg\[995\]
+ net1995 net1973 _08283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12460_ gen_regfile_ff.register_file_i.rf_reg\[771\] gen_regfile_ff.register_file_i.rf_reg\[803\]
+ gen_regfile_ff.register_file_i.rf_reg\[835\] gen_regfile_ff.register_file_i.rf_reg\[867\]
+ net1995 net1973 _08284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1616 _04636_ net1615 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1665 net1663 net1664 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12463_ gen_regfile_ff.register_file_i.rf_reg\[643\] gen_regfile_ff.register_file_i.rf_reg\[675\]
+ gen_regfile_ff.register_file_i.rf_reg\[707\] gen_regfile_ff.register_file_i.rf_reg\[739\]
+ net1994 net1973 _08287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12464_ gen_regfile_ff.register_file_i.rf_reg\[515\] gen_regfile_ff.register_file_i.rf_reg\[547\]
+ gen_regfile_ff.register_file_i.rf_reg\[579\] gen_regfile_ff.register_file_i.rf_reg\[611\]
+ net1994 net1973 _08288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12465_ _08283_ _08284_ _08287_ _08288_ net1877 net1866 _08289_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12466_ net1843 _08289_ _08290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12467_ net1958 _08282_ _08290_ _08291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12468_ _07613_ _07619_ cs_registers_i.pc_id_i\[3\] net1816
+ _08292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12469_ _08041_ net1780 _08292_ net2063 _08293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12470_ _08272_ _08293_ _01158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12471_ net2103 _01162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12472_ id_stage_i.controller_i.lsu_addr_last_i\[4\] _08294_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12473_ net1958 net1816 _08043_ _08295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12474_ _07613_ _07619_ _08295_ _08296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12475_ _08294_ _08041_ _08296_ _08049_ _08297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12476_ net2193 gen_regfile_ff.register_file_i.rf_reg\[36\]
+ _08003_ _08298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1666 _09772_ net1665 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12478_ gen_regfile_ff.register_file_i.rf_reg\[644\] gen_regfile_ff.register_file_i.rf_reg\[676\]
+ gen_regfile_ff.register_file_i.rf_reg\[708\] gen_regfile_ff.register_file_i.rf_reg\[740\]
+ net2003 net1968 _08300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1609 _09595_ net1608 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12480_ gen_regfile_ff.register_file_i.rf_reg\[516\] gen_regfile_ff.register_file_i.rf_reg\[548\]
+ gen_regfile_ff.register_file_i.rf_reg\[580\] gen_regfile_ff.register_file_i.rf_reg\[612\]
+ net2003 net1968 _08302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12481_ gen_regfile_ff.register_file_i.rf_reg\[900\] gen_regfile_ff.register_file_i.rf_reg\[932\]
+ gen_regfile_ff.register_file_i.rf_reg\[964\] gen_regfile_ff.register_file_i.rf_reg\[996\]
+ net2003 net1968 _08303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12482_ gen_regfile_ff.register_file_i.rf_reg\[772\] gen_regfile_ff.register_file_i.rf_reg\[804\]
+ gen_regfile_ff.register_file_i.rf_reg\[836\] gen_regfile_ff.register_file_i.rf_reg\[868\]
+ net2003 net1968 _08304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1668 net1666 net1667 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12484_ _08300_ _08302_ _08303_ _08304_ net1883 net1959 _08306_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12485_ net1842 _08306_ _08307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12486_ gen_regfile_ff.register_file_i.rf_reg\[388\] gen_regfile_ff.register_file_i.rf_reg\[420\]
+ gen_regfile_ff.register_file_i.rf_reg\[452\] gen_regfile_ff.register_file_i.rf_reg\[484\]
+ net2000 net1973 _08308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12487_ gen_regfile_ff.register_file_i.rf_reg\[260\] gen_regfile_ff.register_file_i.rf_reg\[292\]
+ gen_regfile_ff.register_file_i.rf_reg\[324\] gen_regfile_ff.register_file_i.rf_reg\[356\]
+ net2003 net1973 _08309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12488_ gen_regfile_ff.register_file_i.rf_reg\[132\] gen_regfile_ff.register_file_i.rf_reg\[164\]
+ gen_regfile_ff.register_file_i.rf_reg\[196\] gen_regfile_ff.register_file_i.rf_reg\[228\]
+ net2003 net1968 _08310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12489_ gen_regfile_ff.register_file_i.rf_reg\[68\] gen_regfile_ff.register_file_i.rf_reg\[100\]
+ net1989 _08311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12490_ net1870 _08311_ _08312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12491_ _08308_ _08309_ _08310_ _08312_ net1883 net1867 _08313_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12492_ net1958 _08313_ _08314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12493_ _08298_ _08307_ _08314_ _08315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12494_ _07613_ _07619_ cs_registers_i.pc_id_i\[4\] net1816
+ _08316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12495_ _08041_ _08315_ _08316_ net2063 _08317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12496_ _08297_ _08317_ _01165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12497_ _01165_ _01169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1610 net1608 net1609 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1607 _09764_ net1606 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1603 _09796_ net1602 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12501_ gen_regfile_ff.register_file_i.rf_reg\[901\] gen_regfile_ff.register_file_i.rf_reg\[933\]
+ gen_regfile_ff.register_file_i.rf_reg\[965\] gen_regfile_ff.register_file_i.rf_reg\[997\]
+ net2134 net1973 _08321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12502_ gen_regfile_ff.register_file_i.rf_reg\[773\] gen_regfile_ff.register_file_i.rf_reg\[805\]
+ gen_regfile_ff.register_file_i.rf_reg\[837\] gen_regfile_ff.register_file_i.rf_reg\[869\]
+ net2134 net1973 _08322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1601 _09819_ net1600 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12504_ _08321_ _08322_ net1881 _08324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1602 _09801_ net1601 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12506_ gen_regfile_ff.register_file_i.rf_reg\[325\] gen_regfile_ff.register_file_i.rf_reg\[357\]
+ gen_regfile_ff.register_file_i.rf_reg\[453\] gen_regfile_ff.register_file_i.rf_reg\[485\]
+ net2005 net1962 _08326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12507_ gen_regfile_ff.register_file_i.rf_reg\[261\] gen_regfile_ff.register_file_i.rf_reg\[293\]
+ gen_regfile_ff.register_file_i.rf_reg\[389\] gen_regfile_ff.register_file_i.rf_reg\[421\]
+ net2005 net1962 _08327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1598 net2495 net1597 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12509_ gen_regfile_ff.register_file_i.rf_reg\[69\] gen_regfile_ff.register_file_i.rf_reg\[101\]
+ gen_regfile_ff.register_file_i.rf_reg\[197\] gen_regfile_ff.register_file_i.rf_reg\[229\]
+ net2005 net1962 _08329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12510_ gen_regfile_ff.register_file_i.rf_reg\[133\] gen_regfile_ff.register_file_i.rf_reg\[165\]
+ net2005 _08330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12511_ net2005 gen_regfile_ff.register_file_i.rf_reg\[37\]
+ _08331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12512_ _08330_ _08331_ _07518_ _08332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1590 _09950_ net1589 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12514_ _08326_ _08327_ _08329_ _08332_ net1870 net1864 _08334_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12515_ gen_regfile_ff.register_file_i.rf_reg\[645\] gen_regfile_ff.register_file_i.rf_reg\[677\]
+ gen_regfile_ff.register_file_i.rf_reg\[709\] gen_regfile_ff.register_file_i.rf_reg\[741\]
+ net2134 net1973 _08335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12516_ gen_regfile_ff.register_file_i.rf_reg\[517\] gen_regfile_ff.register_file_i.rf_reg\[549\]
+ gen_regfile_ff.register_file_i.rf_reg\[581\] gen_regfile_ff.register_file_i.rf_reg\[613\]
+ net2134 net1973 _08336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12517_ _08335_ _08336_ net1881 _08337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12518_ _07547_ _08337_ _08338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12519_ _07523_ _08324_ _08334_ net1958 _08338_ _08339_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
Xplace1589 _03987_ net1588 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_12521_ cs_registers_i.pc_id_i\[5\] net2063 _08341_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1588 _04669_ net1587 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1587 _07742_ net1586 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12524_ id_stage_i.controller_i.lsu_addr_last_i\[5\] net1818
+ _08344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12525_ net2126 net1778 _08341_ net1741 _08344_ _01172_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12526_ net1692 _01176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1600 net1598 net1599 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_12528_ gen_regfile_ff.register_file_i.rf_reg\[902\] gen_regfile_ff.register_file_i.rf_reg\[934\]
+ gen_regfile_ff.register_file_i.rf_reg\[966\] gen_regfile_ff.register_file_i.rf_reg\[998\]
+ net2137 net1967 _08346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12529_ gen_regfile_ff.register_file_i.rf_reg\[774\] gen_regfile_ff.register_file_i.rf_reg\[806\]
+ gen_regfile_ff.register_file_i.rf_reg\[838\] gen_regfile_ff.register_file_i.rf_reg\[870\]
+ net2003 net1968 _08347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12530_ _08346_ _08347_ net1882 _08348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12531_ gen_regfile_ff.register_file_i.rf_reg\[390\] gen_regfile_ff.register_file_i.rf_reg\[422\]
+ gen_regfile_ff.register_file_i.rf_reg\[454\] gen_regfile_ff.register_file_i.rf_reg\[486\]
+ net2137 net1967 _08349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1604 _09783_ net1603 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12533_ gen_regfile_ff.register_file_i.rf_reg\[262\] gen_regfile_ff.register_file_i.rf_reg\[294\]
+ gen_regfile_ff.register_file_i.rf_reg\[326\] gen_regfile_ff.register_file_i.rf_reg\[358\]
+ net2137 net1967 _08351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12534_ gen_regfile_ff.register_file_i.rf_reg\[134\] gen_regfile_ff.register_file_i.rf_reg\[166\]
+ gen_regfile_ff.register_file_i.rf_reg\[198\] gen_regfile_ff.register_file_i.rf_reg\[230\]
+ net2005 net1964 _08352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12535_ gen_regfile_ff.register_file_i.rf_reg\[70\] gen_regfile_ff.register_file_i.rf_reg\[102\]
+ net2005 _08353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12536_ net2005 gen_regfile_ff.register_file_i.rf_reg\[38\]
+ _08354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12537_ _08353_ _08354_ net1869 _08355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12538_ _08349_ _08351_ _08352_ _08355_ net1882 net1864 _08356_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12539_ gen_regfile_ff.register_file_i.rf_reg\[646\] gen_regfile_ff.register_file_i.rf_reg\[678\]
+ gen_regfile_ff.register_file_i.rf_reg\[710\] gen_regfile_ff.register_file_i.rf_reg\[742\]
+ net2005 net1964 _08357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12540_ gen_regfile_ff.register_file_i.rf_reg\[518\] gen_regfile_ff.register_file_i.rf_reg\[550\]
+ gen_regfile_ff.register_file_i.rf_reg\[582\] gen_regfile_ff.register_file_i.rf_reg\[614\]
+ net2005 net1964 _08358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12541_ _08357_ _08358_ net1882 _08359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12542_ _07547_ _08359_ _08360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12543_ _07523_ _08348_ _08356_ net1958 _08360_ _08361_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12544_ cs_registers_i.pc_id_i\[6\] net2063 _08362_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12545_ id_stage_i.controller_i.lsu_addr_last_i\[6\] net1818
+ _08363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12546_ net2126 net1777 _08362_ net1741 _08363_ _01179_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12547_ net1691 _01183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12548_ gen_regfile_ff.register_file_i.rf_reg\[903\] gen_regfile_ff.register_file_i.rf_reg\[935\]
+ gen_regfile_ff.register_file_i.rf_reg\[967\] gen_regfile_ff.register_file_i.rf_reg\[999\]
+ net2009 net1975 _08364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12549_ gen_regfile_ff.register_file_i.rf_reg\[775\] gen_regfile_ff.register_file_i.rf_reg\[807\]
+ gen_regfile_ff.register_file_i.rf_reg\[839\] gen_regfile_ff.register_file_i.rf_reg\[871\]
+ net2009 net1975 _08365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12550_ _08364_ _08365_ net1878 _08366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12551_ gen_regfile_ff.register_file_i.rf_reg\[391\] gen_regfile_ff.register_file_i.rf_reg\[423\]
+ gen_regfile_ff.register_file_i.rf_reg\[455\] gen_regfile_ff.register_file_i.rf_reg\[487\]
+ net2008 net1975 _08367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12552_ gen_regfile_ff.register_file_i.rf_reg\[263\] gen_regfile_ff.register_file_i.rf_reg\[295\]
+ gen_regfile_ff.register_file_i.rf_reg\[327\] gen_regfile_ff.register_file_i.rf_reg\[359\]
+ net2008 net1975 _08368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12553_ gen_regfile_ff.register_file_i.rf_reg\[135\] gen_regfile_ff.register_file_i.rf_reg\[167\]
+ gen_regfile_ff.register_file_i.rf_reg\[199\] gen_regfile_ff.register_file_i.rf_reg\[231\]
+ net2008 net1975 _08369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12554_ gen_regfile_ff.register_file_i.rf_reg\[71\] gen_regfile_ff.register_file_i.rf_reg\[103\]
+ net2008 _08370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12555_ net2193 gen_regfile_ff.register_file_i.rf_reg\[39\]
+ _08371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12556_ _08370_ _08371_ net1868 _08372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12557_ _08367_ _08368_ _08369_ _08372_ net1878 net1866 _08373_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_12558_ gen_regfile_ff.register_file_i.rf_reg\[647\] gen_regfile_ff.register_file_i.rf_reg\[679\]
+ gen_regfile_ff.register_file_i.rf_reg\[711\] gen_regfile_ff.register_file_i.rf_reg\[743\]
+ net2193 net1975 _08374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12559_ gen_regfile_ff.register_file_i.rf_reg\[519\] gen_regfile_ff.register_file_i.rf_reg\[551\]
+ gen_regfile_ff.register_file_i.rf_reg\[583\] gen_regfile_ff.register_file_i.rf_reg\[615\]
+ net2193 net1975 _08375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12560_ _08374_ _08375_ net1878 _08376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12561_ net1832 _08376_ _08377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12562_ net1876 _08366_ net1958 _08373_ _08377_ _08378_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12563_ cs_registers_i.pc_id_i\[7\] net2063 _08379_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12564_ id_stage_i.controller_i.lsu_addr_last_i\[7\] net1818
+ _08380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12565_ net2126 net1776 _08379_ net2052 _08380_ _01186_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12566_ net2116 _01190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12567_ _00841_ _08381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12568_ _00833_ _00832_ _08382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12569_ _08382_ _00837_ _00836_ _08383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12570_ _00821_ _08384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12571_ _00820_ _08385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12572_ _08384_ _00010_ _08385_ _08386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12573_ _00825_ _00829_ _08387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12574_ _00824_ _00829_ _00828_ _08388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12575_ _00832_ _00836_ _08389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12576_ _08388_ _08389_ _08390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12577_ _08387_ _08386_ _08390_ _08391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12578_ _00840_ _08392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12579_ _08381_ net2178 net2125 _08392_ _08393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12580_ net2082 _08393_ net183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12581_ _00833_ _00837_ _08387_ _08394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12582_ _00817_ net2071 _08395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12583_ _00841_ _08394_ _08395_ _08396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12584_ net2290 _00837_ _08397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12585_ _00837_ _00832_ _00836_ _08398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12586_ _08397_ net2300 _08398_ _08399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12587_ _00821_ _00816_ _08400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12588_ _00820_ _08400_ _08401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12589_ _00841_ net2291 _08401_ _08402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12590_ _08172_ _08178_ _08183_ _08403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12591_ _08215_ net2121 _08402_ _08403_ _08404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_12592_ _00841_ net2291 _08394_ _08405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12593_ _00841_ net2291 _08401_ _08395_ _08406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12594_ _08394_ _08401_ _08407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12595_ net2291 _08407_ _00841_ _08408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12596_ _08405_ _08406_ _08408_ _08409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_12597_ net2111 _08396_ _08404_ _08409_ net182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xplace1605 net1603 net1604 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1606 net1603 net1605 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1608 _09764_ net1607 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12601_ gen_regfile_ff.register_file_i.rf_reg\[904\] gen_regfile_ff.register_file_i.rf_reg\[936\]
+ gen_regfile_ff.register_file_i.rf_reg\[968\] gen_regfile_ff.register_file_i.rf_reg\[1000\]
+ net2010 net1977 _08413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12602_ gen_regfile_ff.register_file_i.rf_reg\[776\] gen_regfile_ff.register_file_i.rf_reg\[808\]
+ gen_regfile_ff.register_file_i.rf_reg\[840\] gen_regfile_ff.register_file_i.rf_reg\[872\]
+ net2010 net1977 _08414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12603_ _08413_ _08414_ net1878 _08415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12604_ gen_regfile_ff.register_file_i.rf_reg\[392\] gen_regfile_ff.register_file_i.rf_reg\[424\]
+ gen_regfile_ff.register_file_i.rf_reg\[456\] gen_regfile_ff.register_file_i.rf_reg\[488\]
+ net2013 net1984 _08416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12605_ gen_regfile_ff.register_file_i.rf_reg\[264\] gen_regfile_ff.register_file_i.rf_reg\[296\]
+ gen_regfile_ff.register_file_i.rf_reg\[328\] gen_regfile_ff.register_file_i.rf_reg\[360\]
+ net2013 net1984 _08417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12606_ gen_regfile_ff.register_file_i.rf_reg\[136\] gen_regfile_ff.register_file_i.rf_reg\[168\]
+ gen_regfile_ff.register_file_i.rf_reg\[200\] gen_regfile_ff.register_file_i.rf_reg\[232\]
+ net2193 net1975 _08418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12607_ gen_regfile_ff.register_file_i.rf_reg\[72\] gen_regfile_ff.register_file_i.rf_reg\[104\]
+ net2008 _08419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12608_ net2193 gen_regfile_ff.register_file_i.rf_reg\[40\]
+ _08420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12609_ _08419_ _08420_ net1868 _08421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12610_ _08416_ _08417_ _08418_ _08421_ net1878 net1866 _08422_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12611_ gen_regfile_ff.register_file_i.rf_reg\[648\] gen_regfile_ff.register_file_i.rf_reg\[680\]
+ gen_regfile_ff.register_file_i.rf_reg\[712\] gen_regfile_ff.register_file_i.rf_reg\[744\]
+ net2010 net1977 _08423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12612_ gen_regfile_ff.register_file_i.rf_reg\[520\] gen_regfile_ff.register_file_i.rf_reg\[552\]
+ gen_regfile_ff.register_file_i.rf_reg\[584\] gen_regfile_ff.register_file_i.rf_reg\[616\]
+ net2010 net1977 _08424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12613_ _08423_ _08424_ net1878 _08425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12614_ net1832 _08425_ _08426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12615_ net1876 _08415_ _08422_ net1958 _08426_ _08427_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12616_ cs_registers_i.pc_id_i\[8\] net2063 _08428_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1670 net1668 net1669 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12618_ id_stage_i.controller_i.lsu_addr_last_i\[8\] net2483
+ _08430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12619_ net1775 net2127 _08428_ net2053 _08430_ _01193_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12620_ net2072 _01197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1586 _09779_ net1585 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload12 clknet_leaf_7_clk_i_regs _unconnected_12 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload13 clknet_leaf_16_clk_i_regs _unconnected_13 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
X_12624_ gen_regfile_ff.register_file_i.rf_reg\[905\] gen_regfile_ff.register_file_i.rf_reg\[937\]
+ gen_regfile_ff.register_file_i.rf_reg\[969\] gen_regfile_ff.register_file_i.rf_reg\[1001\]
+ net2001 net1968 _08434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1584 _09839_ net1583 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12626_ gen_regfile_ff.register_file_i.rf_reg\[777\] gen_regfile_ff.register_file_i.rf_reg\[809\]
+ gen_regfile_ff.register_file_i.rf_reg\[841\] gen_regfile_ff.register_file_i.rf_reg\[873\]
+ net2001 net1968 _08436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12627_ gen_regfile_ff.register_file_i.rf_reg\[649\] gen_regfile_ff.register_file_i.rf_reg\[681\]
+ gen_regfile_ff.register_file_i.rf_reg\[713\] gen_regfile_ff.register_file_i.rf_reg\[745\]
+ net2001 net1968 _08437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12628_ gen_regfile_ff.register_file_i.rf_reg\[521\] gen_regfile_ff.register_file_i.rf_reg\[553\]
+ gen_regfile_ff.register_file_i.rf_reg\[585\] gen_regfile_ff.register_file_i.rf_reg\[617\]
+ net2001 net1968 _08438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12629_ _08434_ _08436_ _08437_ _08438_ net1884 net1867 _08439_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12630_ gen_regfile_ff.register_file_i.rf_reg\[329\] gen_regfile_ff.register_file_i.rf_reg\[361\]
+ gen_regfile_ff.register_file_i.rf_reg\[457\] gen_regfile_ff.register_file_i.rf_reg\[489\]
+ net2000 net1962 _08440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12631_ gen_regfile_ff.register_file_i.rf_reg\[265\] gen_regfile_ff.register_file_i.rf_reg\[297\]
+ gen_regfile_ff.register_file_i.rf_reg\[393\] gen_regfile_ff.register_file_i.rf_reg\[425\]
+ net2000 net1962 _08441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12632_ gen_regfile_ff.register_file_i.rf_reg\[73\] gen_regfile_ff.register_file_i.rf_reg\[105\]
+ gen_regfile_ff.register_file_i.rf_reg\[201\] gen_regfile_ff.register_file_i.rf_reg\[233\]
+ net2000 net1962 _08442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12633_ gen_regfile_ff.register_file_i.rf_reg\[137\] gen_regfile_ff.register_file_i.rf_reg\[169\]
+ net2000 _08443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12634_ net2000 gen_regfile_ff.register_file_i.rf_reg\[41\]
+ _08444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12635_ _08443_ _08444_ net1881 _08445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12636_ _08440_ _08441_ _08442_ _08445_ net1873 net1867 _08446_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12637_ net1958 _08446_ _08447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12638_ net1842 _08439_ _08447_ _08448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12639_ cs_registers_i.pc_id_i\[9\] net2063 _08449_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12640_ id_stage_i.controller_i.lsu_addr_last_i\[9\] net2483
+ _08450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12641_ net2127 net1736 _08449_ net2053 _08450_ _01200_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12642_ net2097 _01204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12643_ _00841_ net2082 _08451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12644_ _00845_ _00840_ _00844_ _08452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12645_ net2178 net2125 _08451_ _08452_ _08453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12646_ net2073 _08453_ _00848_ _08454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12647_ _00853_ _08454_ _08455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_12648_ _08455_ net185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12649_ net2109 _08456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12650_ _00820_ _08400_ _08457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12651_ _00824_ _08458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12652_ _08456_ _08457_ _08458_ _08459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12653_ _00829_ _08459_ _00828_ _08460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12654_ _08397_ _08451_ _08461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12655_ _08461_ _08462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12656_ _08381_ _08398_ _08392_ _08463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12657_ net2082 _08463_ _00844_ _08464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12658_ _08460_ _08462_ _08464_ _08465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12659_ _08387_ _08395_ _08466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12660_ _08466_ _08467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12661_ _08466_ _08461_ _08468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12662_ _08112_ _08120_ _08128_ _08468_ _08469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12663_ _08184_ _08467_ _08462_ _08170_ _08469_ _08470_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_12664_ _08465_ _08470_ net2073 _08471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12665_ net2073 _08465_ _08470_ _08472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12666_ _08471_ _08472_ net184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12667_ gen_regfile_ff.register_file_i.rf_reg\[906\] gen_regfile_ff.register_file_i.rf_reg\[938\]
+ gen_regfile_ff.register_file_i.rf_reg\[970\] gen_regfile_ff.register_file_i.rf_reg\[1002\]
+ net1990 net1974 _08473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12668_ gen_regfile_ff.register_file_i.rf_reg\[778\] gen_regfile_ff.register_file_i.rf_reg\[810\]
+ gen_regfile_ff.register_file_i.rf_reg\[842\] gen_regfile_ff.register_file_i.rf_reg\[874\]
+ net1990 net1974 _08474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12669_ gen_regfile_ff.register_file_i.rf_reg\[650\] gen_regfile_ff.register_file_i.rf_reg\[682\]
+ gen_regfile_ff.register_file_i.rf_reg\[714\] gen_regfile_ff.register_file_i.rf_reg\[746\]
+ net2000 net1974 _08475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12670_ gen_regfile_ff.register_file_i.rf_reg\[522\] gen_regfile_ff.register_file_i.rf_reg\[554\]
+ gen_regfile_ff.register_file_i.rf_reg\[586\] gen_regfile_ff.register_file_i.rf_reg\[618\]
+ net2000 net1974 _08476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12671_ _08473_ _08474_ _08475_ _08476_ net1881 net1867 _08477_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12672_ gen_regfile_ff.register_file_i.rf_reg\[394\] gen_regfile_ff.register_file_i.rf_reg\[426\]
+ gen_regfile_ff.register_file_i.rf_reg\[458\] gen_regfile_ff.register_file_i.rf_reg\[490\]
+ net1989 net1974 _08478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12673_ gen_regfile_ff.register_file_i.rf_reg\[266\] gen_regfile_ff.register_file_i.rf_reg\[298\]
+ gen_regfile_ff.register_file_i.rf_reg\[330\] gen_regfile_ff.register_file_i.rf_reg\[362\]
+ net1989 net1974 _08479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12674_ gen_regfile_ff.register_file_i.rf_reg\[138\] gen_regfile_ff.register_file_i.rf_reg\[170\]
+ gen_regfile_ff.register_file_i.rf_reg\[202\] gen_regfile_ff.register_file_i.rf_reg\[234\]
+ net1989 net1974 _08480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12675_ gen_regfile_ff.register_file_i.rf_reg\[74\] gen_regfile_ff.register_file_i.rf_reg\[106\]
+ net1994 _08481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12676_ net2134 gen_regfile_ff.register_file_i.rf_reg\[42\]
+ _08482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12677_ _08481_ _08482_ net1874 _08483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12678_ _08478_ _08479_ _08480_ _08483_ net1881 net1867 _08484_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12679_ net1958 _08484_ _08485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_12680_ net1842 _08477_ _08485_ _08486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12681_ cs_registers_i.pc_id_i\[10\] net2064 _08487_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12682_ id_stage_i.controller_i.lsu_addr_last_i\[10\] net2483
+ _08488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12683_ net2127 net1735 _08487_ net2053 _08488_ _01207_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12684_ net2102 _01211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12685_ _00856_ _08489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12686_ _00849_ _00853_ _08490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12687_ _08391_ _08383_ _08451_ _08490_ _08491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_12688_ _00853_ _00848_ _00852_ _08492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12689_ _08452_ _08490_ _08492_ _08493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12690_ _08491_ _08493_ net2173 _08494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12691_ net2062 _08495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12692_ _08489_ _08494_ _08495_ _08496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12693_ _08495_ _08489_ _08494_ _08497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12694_ _08496_ _08497_ net157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12695_ _00841_ net2082 _08498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12696_ _08401_ _08395_ _08394_ _08499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12697_ net2300 _08397_ _08499_ _08398_ _08500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12698_ _08498_ _08500_ _08501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12699_ _08401_ _08399_ _08502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_12700_ _08502_ _08503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12701_ _08215_ net2121 _08403_ _08503_ _08504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_12702_ _08452_ _08490_ _08505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12703_ _00853_ _00848_ _08506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12704_ _00852_ _08505_ _08506_ _08507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_12705_ _08490_ _08501_ net2094 _08507_ _08508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12706_ net2173 _08508_ _08509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_12707_ _08509_ net156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xplace1585 net1583 net1584 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1583 _09894_ net1582 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1582 _10012_ net1581 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
Xplace1581 _03989_ net1580 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1580 _04152_ net1579 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1579 _04676_ net1578 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload14 clknet_leaf_17_clk_i_regs _unconnected_14 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_12716_ gen_regfile_ff.register_file_i.rf_reg\[652\] gen_regfile_ff.register_file_i.rf_reg\[684\]
+ gen_regfile_ff.register_file_i.rf_reg\[716\] gen_regfile_ff.register_file_i.rf_reg\[748\]
+ net1946 net1910 _08518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload15 clknet_leaf_18_clk_i_regs _unconnected_15 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload16 clknet_leaf_20_clk_i_regs _unconnected_16 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_12719_ gen_regfile_ff.register_file_i.rf_reg\[524\] gen_regfile_ff.register_file_i.rf_reg\[556\]
+ gen_regfile_ff.register_file_i.rf_reg\[588\] gen_regfile_ff.register_file_i.rf_reg\[620\]
+ net1946 net1910 _08521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload17 clknet_leaf_21_clk_i_regs _unconnected_17 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload18 clknet_leaf_22_clk_i_regs _unconnected_18 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload19 clknet_leaf_23_clk_i_regs _unconnected_19 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_12723_ gen_regfile_ff.register_file_i.rf_reg\[908\] gen_regfile_ff.register_file_i.rf_reg\[940\]
+ gen_regfile_ff.register_file_i.rf_reg\[972\] gen_regfile_ff.register_file_i.rf_reg\[1004\]
+ net1946 net1910 _08525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12724_ gen_regfile_ff.register_file_i.rf_reg\[780\] gen_regfile_ff.register_file_i.rf_reg\[812\]
+ gen_regfile_ff.register_file_i.rf_reg\[844\] gen_regfile_ff.register_file_i.rf_reg\[876\]
+ net1946 net1910 _08526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload20 clknet_leaf_24_clk_i_regs _unconnected_20 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload21 clknet_leaf_26_clk_i_regs _unconnected_21 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1576 _00293_ net1575 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1577 net1575 net1576 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12729_ _08518_ _08521_ _08525_ _08526_ net1849 net1901 _08531_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1578 net1576 net1577 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1569 _00486_ net1568 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12732_ gen_regfile_ff.register_file_i.rf_reg\[140\] gen_regfile_ff.register_file_i.rf_reg\[172\]
+ gen_regfile_ff.register_file_i.rf_reg\[204\] gen_regfile_ff.register_file_i.rf_reg\[236\]
+ net1946 net1910 _08534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12733_ gen_regfile_ff.register_file_i.rf_reg\[44\] gen_regfile_ff.register_file_i.rf_reg\[108\]
+ net2089 _08535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1568 _00589_ net1567 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1567 _00680_ net1566 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12736_ gen_regfile_ff.register_file_i.rf_reg\[76\] _07745_
+ _08535_ net1946 _08538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12737_ _08538_ _08539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12738_ gen_regfile_ff.register_file_i.rf_reg\[396\] gen_regfile_ff.register_file_i.rf_reg\[428\]
+ gen_regfile_ff.register_file_i.rf_reg\[460\] gen_regfile_ff.register_file_i.rf_reg\[492\]
+ net1946 net1910 _08540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12739_ gen_regfile_ff.register_file_i.rf_reg\[268\] gen_regfile_ff.register_file_i.rf_reg\[300\]
+ gen_regfile_ff.register_file_i.rf_reg\[332\] gen_regfile_ff.register_file_i.rf_reg\[364\]
+ net1946 net1910 _08541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12740_ _08534_ _08539_ _08540_ _08541_ net1849 net1901 _08542_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1570 _00412_ net1569 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12742_ _08531_ _08542_ net1862 _08544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xplace1571 _00336_ net1570 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_12744_ net1891 _08546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12745_ net1800 _07767_ _08547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12746_ _08547_ _07699_ _08546_ _08548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_12747_ _07767_ net1800 _08549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12748_ net1800 net1799 _07767_ _08550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12749_ _08549_ _08550_ _08551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12750_ net2022 _08551_ _08552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12751_ net2060 _08552_ _08553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1565 _10149_ net1564 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1566 _10149_ net1565 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12754_ net1687 _08553_ net1795 _01225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xplace1572 net1570 net1571 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1564 _10183_ net1563 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1563 _10247_ net1562 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1573 net1570 net1572 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12759_ net1841 ex_block_i.alu_i.imd_val_q_i\[44\] ex_block_i.alu_i.imd_val_q_i\[12\]
+ _08197_ _08200_ net1687 _08560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_12760_ net2028 net1803 _08560_ _08561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12761_ net1693 net2111 _01225_ _08562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12762_ _08187_ _08561_ _08562_ _00863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1574 net1572 net1573 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1575 net1573 net1574 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload22 clknet_leaf_5_clk_i_regs _unconnected_22 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12766_ gen_regfile_ff.register_file_i.rf_reg\[653\] gen_regfile_ff.register_file_i.rf_reg\[685\]
+ gen_regfile_ff.register_file_i.rf_reg\[717\] gen_regfile_ff.register_file_i.rf_reg\[749\]
+ net1954 net1920 _08566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload23 clknet_leaf_6_clk_i_regs _unconnected_23 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_4
X_12768_ gen_regfile_ff.register_file_i.rf_reg\[525\] gen_regfile_ff.register_file_i.rf_reg\[557\]
+ gen_regfile_ff.register_file_i.rf_reg\[589\] gen_regfile_ff.register_file_i.rf_reg\[621\]
+ net1954 net1920 _08568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload24 clknet_leaf_8_clk_i_regs _unconnected_24 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_12770_ gen_regfile_ff.register_file_i.rf_reg\[909\] gen_regfile_ff.register_file_i.rf_reg\[941\]
+ gen_regfile_ff.register_file_i.rf_reg\[973\] gen_regfile_ff.register_file_i.rf_reg\[1005\]
+ net1954 net1920 _08570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12771_ gen_regfile_ff.register_file_i.rf_reg\[781\] gen_regfile_ff.register_file_i.rf_reg\[813\]
+ gen_regfile_ff.register_file_i.rf_reg\[845\] gen_regfile_ff.register_file_i.rf_reg\[877\]
+ net1954 net1920 _08571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload25 clknet_leaf_9_clk_i_regs _unconnected_25 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload26 clknet_leaf_11_clk_i_regs _unconnected_26 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_12774_ _08566_ _08568_ _08570_ _08571_ net1852 net1902 _08574_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12775_ gen_regfile_ff.register_file_i.rf_reg\[141\] gen_regfile_ff.register_file_i.rf_reg\[173\]
+ gen_regfile_ff.register_file_i.rf_reg\[205\] gen_regfile_ff.register_file_i.rf_reg\[237\]
+ net1954 net1920 _08575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12776_ gen_regfile_ff.register_file_i.rf_reg\[45\] gen_regfile_ff.register_file_i.rf_reg\[109\]
+ net1918 _08576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1562 _10159_ net1561 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12778_ net1918 gen_regfile_ff.register_file_i.rf_reg\[77\]
+ _08578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
Xplace1561 _10162_ net1560 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12781_ _08576_ _08578_ net1853 _08581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12782_ gen_regfile_ff.register_file_i.rf_reg\[397\] gen_regfile_ff.register_file_i.rf_reg\[429\]
+ gen_regfile_ff.register_file_i.rf_reg\[461\] gen_regfile_ff.register_file_i.rf_reg\[493\]
+ net1954 net1920 _08582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12783_ gen_regfile_ff.register_file_i.rf_reg\[269\] gen_regfile_ff.register_file_i.rf_reg\[301\]
+ gen_regfile_ff.register_file_i.rf_reg\[333\] gen_regfile_ff.register_file_i.rf_reg\[365\]
+ net1954 net1918 _08583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12784_ _08575_ _08581_ _08582_ _08583_ net1852 net1902 _08584_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1560 _10188_ net1559 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12786_ _08574_ _08584_ net1863 _08586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12787_ net2020 _08551_ _08587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12788_ _08548_ _08587_ _08588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12789_ net1774 _08588_ net1795 _01229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12790_ net1958 net1959 _08589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12791_ gen_regfile_ff.register_file_i.rf_reg\[845\] gen_regfile_ff.register_file_i.rf_reg\[877\]
+ gen_regfile_ff.register_file_i.rf_reg\[973\] gen_regfile_ff.register_file_i.rf_reg\[1005\]
+ net1997 net1962 _08590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12792_ gen_regfile_ff.register_file_i.rf_reg\[781\] gen_regfile_ff.register_file_i.rf_reg\[813\]
+ gen_regfile_ff.register_file_i.rf_reg\[909\] gen_regfile_ff.register_file_i.rf_reg\[941\]
+ net1997 net1962 _08591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12793_ _08590_ _08591_ net1874 _08592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12794_ gen_regfile_ff.register_file_i.rf_reg\[653\] gen_regfile_ff.register_file_i.rf_reg\[685\]
+ gen_regfile_ff.register_file_i.rf_reg\[717\] gen_regfile_ff.register_file_i.rf_reg\[749\]
+ net1997 net1971 _08593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12795_ gen_regfile_ff.register_file_i.rf_reg\[525\] gen_regfile_ff.register_file_i.rf_reg\[557\]
+ gen_regfile_ff.register_file_i.rf_reg\[589\] gen_regfile_ff.register_file_i.rf_reg\[621\]
+ net1997 net1971 _08594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12796_ _08593_ _08594_ net1879 _08595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12797_ net1958 net1866 _08596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12798_ _08589_ _08592_ _08595_ net1822 _08597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12799_ gen_regfile_ff.register_file_i.rf_reg\[141\] gen_regfile_ff.register_file_i.rf_reg\[173\]
+ gen_regfile_ff.register_file_i.rf_reg\[205\] gen_regfile_ff.register_file_i.rf_reg\[237\]
+ net1997 net1971 _08598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12800_ gen_regfile_ff.register_file_i.rf_reg\[77\] gen_regfile_ff.register_file_i.rf_reg\[109\]
+ net1997 _08599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12801_ net1997 gen_regfile_ff.register_file_i.rf_reg\[45\]
+ _08600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12802_ _08599_ _08600_ net1874 _08601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12803_ gen_regfile_ff.register_file_i.rf_reg\[397\] gen_regfile_ff.register_file_i.rf_reg\[429\]
+ gen_regfile_ff.register_file_i.rf_reg\[461\] gen_regfile_ff.register_file_i.rf_reg\[493\]
+ net1997 net1971 _08602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12804_ gen_regfile_ff.register_file_i.rf_reg\[269\] gen_regfile_ff.register_file_i.rf_reg\[301\]
+ gen_regfile_ff.register_file_i.rf_reg\[333\] gen_regfile_ff.register_file_i.rf_reg\[365\]
+ net1997 net1971 _08603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12805_ _08598_ _08601_ _08602_ _08603_ net1880 net1959 _08604_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_12806_ net1842 _08604_ _08605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_12807_ net1813 _08605_ _08606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12808_ net1841 ex_block_i.alu_i.imd_val_q_i\[45\] ex_block_i.alu_i.imd_val_q_i\[13\]
+ net1824 _08200_ net1774 _08607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_12809_ net2028 net1734 _08607_ _08608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12810_ net1693 net1694 _01229_ _08609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12811_ _08187_ _08608_ _08609_ _00867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12812_ cs_registers_i.pc_id_i\[13\] net1801 _08610_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1559 _10197_ net1558 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12814_ id_stage_i.controller_i.lsu_addr_last_i\[13\] net1818
+ _08612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12815_ net2127 net1734 _08610_ net1741 _08612_ _01228_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_12816_ net2070 _01232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12817_ net2178 net2124 _08451_ _08490_ _08613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_12818_ net2173 _08614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12819_ _08613_ _08507_ _08614_ _08615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12820_ _00856_ _08615_ net2088 net2062 _08616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12821_ _00865_ _00860_ _00864_ _08617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_12822_ _08616_ _08617_ _08618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12823_ net2083 _08618_ net159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12824_ _00857_ _00861_ _08619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12825_ net2073 _00853_ _08619_ _08620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_12826_ net2484 _08620_ _08621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12827_ net2088 _08620_ _08622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12828_ _08614_ _08492_ _08489_ _08623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12829_ net2062 _08623_ _00860_ _08624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12830_ net2088 _08622_ _08624_ _08625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12831_ net2088 _08626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12832_ _08626_ _08624_ _08627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12833_ _08465_ _08627_ _08628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12834_ _08628_ _08621_ _08470_ _08629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12835_ _08465_ _08621_ _08625_ _08629_ net158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xplace1558 _10197_ net1557 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1557 _10203_ net1556 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12838_ gen_regfile_ff.register_file_i.rf_reg\[654\] gen_regfile_ff.register_file_i.rf_reg\[686\]
+ gen_regfile_ff.register_file_i.rf_reg\[718\] gen_regfile_ff.register_file_i.rf_reg\[750\]
+ net1950 net1911 _08632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12839_ gen_regfile_ff.register_file_i.rf_reg\[526\] gen_regfile_ff.register_file_i.rf_reg\[558\]
+ gen_regfile_ff.register_file_i.rf_reg\[590\] gen_regfile_ff.register_file_i.rf_reg\[622\]
+ net1950 net1911 _08633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload27 clknet_leaf_12_clk_i_regs _unconnected_27 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_4
Xplace1556 _10211_ net1555 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12842_ gen_regfile_ff.register_file_i.rf_reg\[910\] gen_regfile_ff.register_file_i.rf_reg\[942\]
+ gen_regfile_ff.register_file_i.rf_reg\[974\] gen_regfile_ff.register_file_i.rf_reg\[1006\]
+ net2114 net1911 _08636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12843_ gen_regfile_ff.register_file_i.rf_reg\[782\] gen_regfile_ff.register_file_i.rf_reg\[814\]
+ gen_regfile_ff.register_file_i.rf_reg\[846\] gen_regfile_ff.register_file_i.rf_reg\[878\]
+ net1950 net1911 _08637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkload28 clknet_leaf_13_clk_i_regs _unconnected_28 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xplace1555 _10216_ net1554 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12846_ _08632_ _08633_ _08636_ _08637_ net1850 net1901 _08640_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12847_ gen_regfile_ff.register_file_i.rf_reg\[142\] gen_regfile_ff.register_file_i.rf_reg\[174\]
+ gen_regfile_ff.register_file_i.rf_reg\[206\] gen_regfile_ff.register_file_i.rf_reg\[238\]
+ net1949 net1919 _08641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12848_ gen_regfile_ff.register_file_i.rf_reg\[46\] gen_regfile_ff.register_file_i.rf_reg\[110\]
+ net2089 _08642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12849_ net2089 gen_regfile_ff.register_file_i.rf_reg\[78\]
+ _08643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12850_ _08642_ _08643_ net1853 _08644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1554 _10219_ net1553 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12852_ gen_regfile_ff.register_file_i.rf_reg\[398\] gen_regfile_ff.register_file_i.rf_reg\[430\]
+ gen_regfile_ff.register_file_i.rf_reg\[462\] gen_regfile_ff.register_file_i.rf_reg\[494\]
+ net1949 net1911 _08646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12853_ gen_regfile_ff.register_file_i.rf_reg\[270\] gen_regfile_ff.register_file_i.rf_reg\[302\]
+ gen_regfile_ff.register_file_i.rf_reg\[334\] gen_regfile_ff.register_file_i.rf_reg\[366\]
+ net1949 net1911 _08647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12854_ _08641_ _08644_ _08646_ _08647_ net1850 net1901 _08648_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12855_ _08640_ _08648_ net1863 _08649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12856_ net2019 _08551_ _08650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12857_ net2060 _08650_ _08651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12858_ net1773 _08651_ net1795 _01236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12859_ gen_regfile_ff.register_file_i.rf_reg\[910\] gen_regfile_ff.register_file_i.rf_reg\[942\]
+ gen_regfile_ff.register_file_i.rf_reg\[974\] gen_regfile_ff.register_file_i.rf_reg\[1006\]
+ net1993 net1969 _08652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12860_ gen_regfile_ff.register_file_i.rf_reg\[782\] gen_regfile_ff.register_file_i.rf_reg\[814\]
+ gen_regfile_ff.register_file_i.rf_reg\[846\] gen_regfile_ff.register_file_i.rf_reg\[878\]
+ net1993 net1969 _08653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12861_ gen_regfile_ff.register_file_i.rf_reg\[654\] gen_regfile_ff.register_file_i.rf_reg\[686\]
+ gen_regfile_ff.register_file_i.rf_reg\[718\] gen_regfile_ff.register_file_i.rf_reg\[750\]
+ net1993 net1969 _08654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12862_ gen_regfile_ff.register_file_i.rf_reg\[526\] gen_regfile_ff.register_file_i.rf_reg\[558\]
+ gen_regfile_ff.register_file_i.rf_reg\[590\] gen_regfile_ff.register_file_i.rf_reg\[622\]
+ net1993 net1969 _08655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12863_ _08652_ _08653_ _08654_ _08655_ net1881 net1866 _08656_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_4
X_12864_ net1871 net1989 _08657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1553 _10239_ net1552 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12866_ gen_regfile_ff.register_file_i.rf_reg\[78\] gen_regfile_ff.register_file_i.rf_reg\[110\]
+ net1991 _08659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12867_ gen_regfile_ff.register_file_i.rf_reg\[46\] net1820
+ _08659_ net1970 net1962 _08660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xclkload30 clknet_leaf_15_clk_i_regs _unconnected_29 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_12869_ gen_regfile_ff.register_file_i.rf_reg\[142\] gen_regfile_ff.register_file_i.rf_reg\[174\]
+ gen_regfile_ff.register_file_i.rf_reg\[206\] gen_regfile_ff.register_file_i.rf_reg\[238\]
+ net1990 net1968 _08662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12870_ net1881 _08662_ net1866 _08663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12871_ gen_regfile_ff.register_file_i.rf_reg\[398\] gen_regfile_ff.register_file_i.rf_reg\[430\]
+ gen_regfile_ff.register_file_i.rf_reg\[462\] gen_regfile_ff.register_file_i.rf_reg\[494\]
+ net1990 net1968 _08664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12872_ gen_regfile_ff.register_file_i.rf_reg\[270\] gen_regfile_ff.register_file_i.rf_reg\[302\]
+ gen_regfile_ff.register_file_i.rf_reg\[334\] gen_regfile_ff.register_file_i.rf_reg\[366\]
+ net1990 net1968 _08665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12873_ _08664_ _08665_ net1881 _08666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12874_ net1961 _08666_ _08667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12875_ _08660_ _08663_ _08667_ net1842 _08668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12876_ net1842 _08656_ _08668_ _08669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_12877_ net1841 ex_block_i.alu_i.imd_val_q_i\[46\] ex_block_i.alu_i.imd_val_q_i\[14\]
+ _08197_ _08200_ net1773 _08670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_12878_ net2028 net1733 _08670_ _08671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12879_ net1693 net2111 _01236_ _08672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12880_ _08187_ _08671_ _08672_ _00871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12881_ cs_registers_i.pc_id_i\[14\] net1801 _08673_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12882_ id_stage_i.controller_i.lsu_addr_last_i\[14\] net1818
+ _08674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12883_ net1742 net1733 _08673_ net1741 _08674_ _01235_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12884_ net1685 _01239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkload29 clknet_leaf_14_clk_i_regs _unconnected_30 VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_3
Xplace1552 _04596_ net1551 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12887_ gen_regfile_ff.register_file_i.rf_reg\[655\] gen_regfile_ff.register_file_i.rf_reg\[687\]
+ gen_regfile_ff.register_file_i.rf_reg\[719\] gen_regfile_ff.register_file_i.rf_reg\[751\]
+ net2188 net1921 _08677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12888_ gen_regfile_ff.register_file_i.rf_reg\[527\] gen_regfile_ff.register_file_i.rf_reg\[559\]
+ gen_regfile_ff.register_file_i.rf_reg\[591\] gen_regfile_ff.register_file_i.rf_reg\[623\]
+ net2188 net1921 _08678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12889_ gen_regfile_ff.register_file_i.rf_reg\[911\] gen_regfile_ff.register_file_i.rf_reg\[943\]
+ gen_regfile_ff.register_file_i.rf_reg\[975\] gen_regfile_ff.register_file_i.rf_reg\[1007\]
+ net2188 net1921 _08679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkbuf_leaf_0_clk clknet_2_0_0_clk clknet_leaf_0_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_12891_ gen_regfile_ff.register_file_i.rf_reg\[783\] gen_regfile_ff.register_file_i.rf_reg\[815\]
+ gen_regfile_ff.register_file_i.rf_reg\[847\] gen_regfile_ff.register_file_i.rf_reg\[879\]
+ net2188 net1921 _08681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12892_ _08677_ _08678_ _08679_ _08681_ net1852 net1902 _08682_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12893_ gen_regfile_ff.register_file_i.rf_reg\[143\] gen_regfile_ff.register_file_i.rf_reg\[175\]
+ gen_regfile_ff.register_file_i.rf_reg\[207\] gen_regfile_ff.register_file_i.rf_reg\[239\]
+ net2188 net1919 _08683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12894_ gen_regfile_ff.register_file_i.rf_reg\[47\] gen_regfile_ff.register_file_i.rf_reg\[111\]
+ net1919 _08684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12895_ net1919 gen_regfile_ff.register_file_i.rf_reg\[79\]
+ _08685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12896_ _08684_ _08685_ net1853 _08686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12897_ gen_regfile_ff.register_file_i.rf_reg\[399\] gen_regfile_ff.register_file_i.rf_reg\[431\]
+ gen_regfile_ff.register_file_i.rf_reg\[463\] gen_regfile_ff.register_file_i.rf_reg\[495\]
+ net2188 net1918 _08687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12898_ gen_regfile_ff.register_file_i.rf_reg\[271\] gen_regfile_ff.register_file_i.rf_reg\[303\]
+ gen_regfile_ff.register_file_i.rf_reg\[335\] gen_regfile_ff.register_file_i.rf_reg\[367\]
+ net2188 net1918 _08688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12899_ _08683_ _08686_ _08687_ _08688_ net1852 net1902 _08689_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12900_ _08682_ _08689_ net1863 _08690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12901_ net2009 _08551_ _08691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12902_ net2060 _08691_ _08692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12903_ net1772 _08692_ net1795 _01243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12904_ net1842 net1866 _08693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12905_ gen_regfile_ff.register_file_i.rf_reg\[79\] gen_regfile_ff.register_file_i.rf_reg\[111\]
+ net1991 _08694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12906_ gen_regfile_ff.register_file_i.rf_reg\[207\] gen_regfile_ff.register_file_i.rf_reg\[239\]
+ net1991 _08695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12907_ net1991 gen_regfile_ff.register_file_i.rf_reg\[47\]
+ _08696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12908_ gen_regfile_ff.register_file_i.rf_reg\[143\] gen_regfile_ff.register_file_i.rf_reg\[175\]
+ net1991 _08697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_1_clk clknet_2_0_0_clk clknet_leaf_1_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_12910_ _08694_ _08695_ _08696_ _08697_ net1962 net1874 _08699_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12911_ gen_regfile_ff.register_file_i.rf_reg\[399\] gen_regfile_ff.register_file_i.rf_reg\[431\]
+ gen_regfile_ff.register_file_i.rf_reg\[463\] gen_regfile_ff.register_file_i.rf_reg\[495\]
+ net2162 net1968 _08700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12912_ gen_regfile_ff.register_file_i.rf_reg\[271\] gen_regfile_ff.register_file_i.rf_reg\[303\]
+ gen_regfile_ff.register_file_i.rf_reg\[335\] gen_regfile_ff.register_file_i.rf_reg\[367\]
+ net2162 net1968 _08701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12913_ _08700_ _08701_ net1880 _08702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12914_ net1842 net1959 _08703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12915_ _08693_ _08699_ _08702_ _08703_ _08704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12916_ gen_regfile_ff.register_file_i.rf_reg\[911\] gen_regfile_ff.register_file_i.rf_reg\[943\]
+ gen_regfile_ff.register_file_i.rf_reg\[975\] gen_regfile_ff.register_file_i.rf_reg\[1007\]
+ net1997 net1971 _08705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12917_ gen_regfile_ff.register_file_i.rf_reg\[783\] gen_regfile_ff.register_file_i.rf_reg\[815\]
+ gen_regfile_ff.register_file_i.rf_reg\[847\] gen_regfile_ff.register_file_i.rf_reg\[879\]
+ net1997 net1971 _08706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12918_ _08705_ _08706_ net1880 _08707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12919_ gen_regfile_ff.register_file_i.rf_reg\[655\] gen_regfile_ff.register_file_i.rf_reg\[687\]
+ gen_regfile_ff.register_file_i.rf_reg\[719\] gen_regfile_ff.register_file_i.rf_reg\[751\]
+ net1997 net1971 _08708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12920_ gen_regfile_ff.register_file_i.rf_reg\[527\] gen_regfile_ff.register_file_i.rf_reg\[559\]
+ gen_regfile_ff.register_file_i.rf_reg\[591\] gen_regfile_ff.register_file_i.rf_reg\[623\]
+ net1997 net1971 _08709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12921_ _08708_ _08709_ net1880 _08710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12922_ _08589_ _08707_ _08710_ net1822 _08711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12923_ net1812 net1811 _08712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12924_ net2028 _08712_ _08713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12925_ net1841 ex_block_i.alu_i.imd_val_q_i\[47\] ex_block_i.alu_i.imd_val_q_i\[15\]
+ _08197_ _08200_ net1772 _08714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
Xplace1551 net2492 net1550 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_12927_ _08713_ _08714_ net1814 _08716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12928_ net1693 net2111 _01243_ _08717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12929_ _08716_ _08717_ _00875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12930_ cs_registers_i.pc_id_i\[15\] net1801 _08718_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12931_ id_stage_i.controller_i.lsu_addr_last_i\[15\] net1818
+ _08719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12932_ net2126 _08712_ _08718_ net1741 _08719_ _01242_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_12933_ net1684 _01246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12934_ _08617_ _08720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12935_ net2083 _08720_ _08721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12936_ net2095 _08721_ _08722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_12937_ _00869_ _00868_ _08723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12938_ _00865_ net2062 _08723_ _08724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_12939_ _08489_ _08722_ _08725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12940_ _08722_ _08724_ _08725_ _08494_ _08726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12941_ _00872_ _08727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12942_ net2077 _08727_ _08728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12943_ net2079 _08729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12944_ _08729_ net2077 _08730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12945_ net2077 _08730_ _08727_ _08731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12946_ _08489_ _08722_ _08732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12947_ net2076 _08733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_12948_ net2079 _08733_ _08734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12949_ _08722_ _08724_ _08735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12950_ _08615_ _08732_ _08734_ _08735_ _08736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12951_ _08726_ _08728_ _08731_ _08736_ net161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_12952_ net2083 _08621_ _08737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12953_ _00860_ _00864_ _00868_ _08738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_12954_ net2062 _00856_ _08493_ _08619_ _08738_ _08739_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_12955_ _00865_ _00864_ _00868_ _08723_ _08740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12956_ _08740_ _08739_ _08741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_12957_ _08501_ net2094 _08737_ net2074 _08742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_12958_ _08729_ _08742_ net160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_12959_ gen_regfile_ff.register_file_i.rf_reg\[656\] gen_regfile_ff.register_file_i.rf_reg\[688\]
+ gen_regfile_ff.register_file_i.rf_reg\[720\] gen_regfile_ff.register_file_i.rf_reg\[752\]
+ net1956 net1930 _08743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12960_ gen_regfile_ff.register_file_i.rf_reg\[528\] gen_regfile_ff.register_file_i.rf_reg\[560\]
+ gen_regfile_ff.register_file_i.rf_reg\[592\] gen_regfile_ff.register_file_i.rf_reg\[624\]
+ net1956 net1930 _08744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12961_ gen_regfile_ff.register_file_i.rf_reg\[912\] gen_regfile_ff.register_file_i.rf_reg\[944\]
+ gen_regfile_ff.register_file_i.rf_reg\[976\] gen_regfile_ff.register_file_i.rf_reg\[1008\]
+ net1956 net1930 _08745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12962_ gen_regfile_ff.register_file_i.rf_reg\[784\] gen_regfile_ff.register_file_i.rf_reg\[816\]
+ gen_regfile_ff.register_file_i.rf_reg\[848\] gen_regfile_ff.register_file_i.rf_reg\[880\]
+ net1956 net1930 _08746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12963_ _08743_ _08744_ _08745_ _08746_ net1847 net1902 _08747_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12964_ gen_regfile_ff.register_file_i.rf_reg\[144\] gen_regfile_ff.register_file_i.rf_reg\[176\]
+ gen_regfile_ff.register_file_i.rf_reg\[208\] gen_regfile_ff.register_file_i.rf_reg\[240\]
+ net1954 net1918 _08748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12965_ gen_regfile_ff.register_file_i.rf_reg\[48\] gen_regfile_ff.register_file_i.rf_reg\[112\]
+ net1918 _08749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12966_ net1918 gen_regfile_ff.register_file_i.rf_reg\[80\]
+ _08750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12967_ _08749_ _08750_ net1853 _08751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12968_ gen_regfile_ff.register_file_i.rf_reg\[400\] gen_regfile_ff.register_file_i.rf_reg\[432\]
+ gen_regfile_ff.register_file_i.rf_reg\[464\] gen_regfile_ff.register_file_i.rf_reg\[496\]
+ net1954 net1918 _08752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12969_ gen_regfile_ff.register_file_i.rf_reg\[272\] gen_regfile_ff.register_file_i.rf_reg\[304\]
+ gen_regfile_ff.register_file_i.rf_reg\[336\] gen_regfile_ff.register_file_i.rf_reg\[368\]
+ net2188 net1918 _08753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12970_ _08748_ _08751_ _08752_ _08753_ net1852 net1902 _08754_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12971_ _08747_ _08754_ net1863 _08755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_12972_ net1965 _08551_ _08756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12973_ net2059 _08756_ _08757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12974_ net1771 _08757_ net1795 _01250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12975_ gen_regfile_ff.register_file_i.rf_reg\[144\] gen_regfile_ff.register_file_i.rf_reg\[176\]
+ net2164 _08758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12976_ gen_regfile_ff.register_file_i.rf_reg\[208\] gen_regfile_ff.register_file_i.rf_reg\[240\]
+ net2163 _08759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12977_ net2163 gen_regfile_ff.register_file_i.rf_reg\[48\]
+ _08760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_12978_ gen_regfile_ff.register_file_i.rf_reg\[80\] gen_regfile_ff.register_file_i.rf_reg\[112\]
+ net2163 _08761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_2_clk clknet_2_0_0_clk clknet_leaf_2_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_12980_ _08758_ _08759_ _08760_ _08761_ net1968 net1880 _08763_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12981_ gen_regfile_ff.register_file_i.rf_reg\[336\] gen_regfile_ff.register_file_i.rf_reg\[368\]
+ gen_regfile_ff.register_file_i.rf_reg\[464\] gen_regfile_ff.register_file_i.rf_reg\[496\]
+ net2162 net1962 _08764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12982_ gen_regfile_ff.register_file_i.rf_reg\[272\] gen_regfile_ff.register_file_i.rf_reg\[304\]
+ gen_regfile_ff.register_file_i.rf_reg\[400\] gen_regfile_ff.register_file_i.rf_reg\[432\]
+ net2162 net1962 _08765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12983_ _08764_ _08765_ net1874 _08766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12984_ _08693_ _08763_ _08766_ _08703_ _08767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12985_ gen_regfile_ff.register_file_i.rf_reg\[912\] gen_regfile_ff.register_file_i.rf_reg\[944\]
+ gen_regfile_ff.register_file_i.rf_reg\[976\] gen_regfile_ff.register_file_i.rf_reg\[1008\]
+ net2164 net1985 _08768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12986_ gen_regfile_ff.register_file_i.rf_reg\[784\] gen_regfile_ff.register_file_i.rf_reg\[816\]
+ gen_regfile_ff.register_file_i.rf_reg\[848\] gen_regfile_ff.register_file_i.rf_reg\[880\]
+ net2164 net1985 _08769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12987_ _08768_ _08769_ net1879 _08770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12988_ gen_regfile_ff.register_file_i.rf_reg\[656\] gen_regfile_ff.register_file_i.rf_reg\[688\]
+ gen_regfile_ff.register_file_i.rf_reg\[720\] gen_regfile_ff.register_file_i.rf_reg\[752\]
+ net2164 net1968 _08771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12989_ gen_regfile_ff.register_file_i.rf_reg\[528\] gen_regfile_ff.register_file_i.rf_reg\[560\]
+ gen_regfile_ff.register_file_i.rf_reg\[592\] gen_regfile_ff.register_file_i.rf_reg\[624\]
+ net2164 net1968 _08772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_12990_ _08771_ _08772_ net1879 _08773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12991_ _08589_ _08770_ _08773_ _08596_ _08774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_12992_ _08767_ _08774_ _08775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_12993_ net1841 ex_block_i.alu_i.imd_val_q_i\[48\] ex_block_i.alu_i.imd_val_q_i\[16\]
+ net1824 _08200_ net1771 _08776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_12994_ net2028 net1770 _08776_ _08777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_12995_ net1693 net2111 _01250_ _08778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_12996_ _08187_ _08777_ _08778_ _00879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_12997_ cs_registers_i.pc_id_i\[16\] net1801 _08779_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12998_ id_stage_i.controller_i.lsu_addr_last_i\[16\] net2483
+ _08780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_12999_ net2127 net1770 _08779_ net2053 _08780_ _01249_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13000_ net1683 _01253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13001_ gen_regfile_ff.register_file_i.rf_reg\[657\] gen_regfile_ff.register_file_i.rf_reg\[689\]
+ gen_regfile_ff.register_file_i.rf_reg\[721\] gen_regfile_ff.register_file_i.rf_reg\[753\]
+ net1947 net1911 _08781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13002_ gen_regfile_ff.register_file_i.rf_reg\[529\] gen_regfile_ff.register_file_i.rf_reg\[561\]
+ gen_regfile_ff.register_file_i.rf_reg\[593\] gen_regfile_ff.register_file_i.rf_reg\[625\]
+ net1947 net1911 _08782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13003_ gen_regfile_ff.register_file_i.rf_reg\[913\] gen_regfile_ff.register_file_i.rf_reg\[945\]
+ gen_regfile_ff.register_file_i.rf_reg\[977\] gen_regfile_ff.register_file_i.rf_reg\[1009\]
+ net1947 net1911 _08783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13004_ gen_regfile_ff.register_file_i.rf_reg\[785\] gen_regfile_ff.register_file_i.rf_reg\[817\]
+ gen_regfile_ff.register_file_i.rf_reg\[849\] gen_regfile_ff.register_file_i.rf_reg\[881\]
+ net1947 net1911 _08784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13005_ _08781_ _08782_ _08783_ _08784_ net1847 net1901 _08785_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13006_ gen_regfile_ff.register_file_i.rf_reg\[145\] gen_regfile_ff.register_file_i.rf_reg\[177\]
+ gen_regfile_ff.register_file_i.rf_reg\[209\] gen_regfile_ff.register_file_i.rf_reg\[241\]
+ net1947 net1911 _08786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13007_ gen_regfile_ff.register_file_i.rf_reg\[49\] gen_regfile_ff.register_file_i.rf_reg\[113\]
+ net1911 _08787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13008_ net1911 gen_regfile_ff.register_file_i.rf_reg\[81\]
+ _08788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13009_ _08787_ _08788_ net1853 _08789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13010_ gen_regfile_ff.register_file_i.rf_reg\[401\] gen_regfile_ff.register_file_i.rf_reg\[433\]
+ gen_regfile_ff.register_file_i.rf_reg\[465\] gen_regfile_ff.register_file_i.rf_reg\[497\]
+ net1947 net1911 _08790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13011_ gen_regfile_ff.register_file_i.rf_reg\[273\] gen_regfile_ff.register_file_i.rf_reg\[305\]
+ gen_regfile_ff.register_file_i.rf_reg\[337\] gen_regfile_ff.register_file_i.rf_reg\[369\]
+ net1947 net1911 _08791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13012_ _08786_ _08789_ _08790_ _08791_ net1849 net1901 _08792_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13013_ _08785_ _08792_ net1862 _08793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13014_ net1962 _08551_ _08794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13015_ net2060 _08794_ _08795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13016_ net1769 _08795_ net1795 _01257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13017_ gen_regfile_ff.register_file_i.rf_reg\[913\] gen_regfile_ff.register_file_i.rf_reg\[945\]
+ gen_regfile_ff.register_file_i.rf_reg\[977\] gen_regfile_ff.register_file_i.rf_reg\[1009\]
+ net2001 net1968 _08796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13018_ gen_regfile_ff.register_file_i.rf_reg\[785\] gen_regfile_ff.register_file_i.rf_reg\[817\]
+ gen_regfile_ff.register_file_i.rf_reg\[849\] gen_regfile_ff.register_file_i.rf_reg\[881\]
+ net2001 net1968 _08797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13019_ gen_regfile_ff.register_file_i.rf_reg\[657\] gen_regfile_ff.register_file_i.rf_reg\[689\]
+ gen_regfile_ff.register_file_i.rf_reg\[721\] gen_regfile_ff.register_file_i.rf_reg\[753\]
+ net2001 net1968 _08798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13020_ gen_regfile_ff.register_file_i.rf_reg\[529\] gen_regfile_ff.register_file_i.rf_reg\[561\]
+ gen_regfile_ff.register_file_i.rf_reg\[593\] gen_regfile_ff.register_file_i.rf_reg\[625\]
+ net2001 net1968 _08799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13021_ _08796_ _08797_ _08798_ _08799_ net1884 net1867 _08800_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13022_ gen_regfile_ff.register_file_i.rf_reg\[81\] gen_regfile_ff.register_file_i.rf_reg\[113\]
+ net1990 _08801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13023_ gen_regfile_ff.register_file_i.rf_reg\[49\] _08657_
+ _08801_ net1970 net1962 _08802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13024_ gen_regfile_ff.register_file_i.rf_reg\[145\] gen_regfile_ff.register_file_i.rf_reg\[177\]
+ gen_regfile_ff.register_file_i.rf_reg\[209\] gen_regfile_ff.register_file_i.rf_reg\[241\]
+ net2001 net1968 _08803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13025_ net1884 _08803_ net1867 _08804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13026_ gen_regfile_ff.register_file_i.rf_reg\[401\] gen_regfile_ff.register_file_i.rf_reg\[433\]
+ gen_regfile_ff.register_file_i.rf_reg\[465\] gen_regfile_ff.register_file_i.rf_reg\[497\]
+ net2001 net1968 _08805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13027_ gen_regfile_ff.register_file_i.rf_reg\[273\] gen_regfile_ff.register_file_i.rf_reg\[305\]
+ gen_regfile_ff.register_file_i.rf_reg\[337\] gen_regfile_ff.register_file_i.rf_reg\[369\]
+ net2001 net1968 _08806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13028_ _08805_ _08806_ net1884 _08807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13029_ net1961 _08807_ _08808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13030_ _08802_ _08804_ _08808_ net1842 _08809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13031_ net1842 _08800_ _08809_ _08810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13032_ net1841 ex_block_i.alu_i.imd_val_q_i\[49\] ex_block_i.alu_i.imd_val_q_i\[17\]
+ net1824 _08200_ net1769 _08811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13033_ net2028 net1732 _08811_ _08812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkbuf_leaf_3_clk clknet_2_0_0_clk clknet_leaf_3_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13035_ net2175 net1694 _01257_ _08814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13036_ _08187_ _08812_ _08814_ _00883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13037_ cs_registers_i.pc_id_i\[17\] net1801 _08815_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13038_ id_stage_i.controller_i.lsu_addr_last_i\[17\] net1818
+ _08816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13039_ net1742 net1732 _08815_ net1741 _08816_ _01256_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_13040_ _01256_ _01260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13041_ _00881_ _00877_ _00873_ _08817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_13042_ net2484 _08619_ _08723_ _08817_ _08818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13043_ _08506_ _08505_ _08491_ _08818_ _08819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_13044_ _00880_ _08820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13045_ net2079 net2095 _00872_ _08821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13046_ _00876_ _08822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13047_ _08733_ _08821_ _08822_ _08823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_13048_ _00881_ _08823_ _08824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13049_ net2173 _00852_ _08825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13050_ _08489_ _08825_ _08724_ _08826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13051_ _08721_ _08826_ _08817_ _08827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13052_ _08827_ _08824_ _08820_ _08828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_13053_ net2287 _08828_ _08829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13054_ _00885_ _08829_ net163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13055_ _00864_ _08830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13056_ _08626_ _08624_ _08830_ _08831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13057_ net2083 net2079 net2077 _08831_ _08832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13058_ _08823_ _08832_ _08833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13059_ net2083 _08621_ _08834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13060_ net2079 net2077 _08834_ _08835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13061_ _08465_ _08470_ _08835_ _08836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13062_ _00881_ _08837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13063_ _08833_ _08836_ _08837_ _08838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13064_ _08837_ _08833_ _08836_ _08839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_13065_ net1455 _08839_ net162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13066_ gen_regfile_ff.register_file_i.rf_reg\[658\] gen_regfile_ff.register_file_i.rf_reg\[690\]
+ gen_regfile_ff.register_file_i.rf_reg\[722\] gen_regfile_ff.register_file_i.rf_reg\[754\]
+ net1943 net1928 _08840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13067_ gen_regfile_ff.register_file_i.rf_reg\[530\] gen_regfile_ff.register_file_i.rf_reg\[562\]
+ gen_regfile_ff.register_file_i.rf_reg\[594\] gen_regfile_ff.register_file_i.rf_reg\[626\]
+ net1943 net1928 _08841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13068_ gen_regfile_ff.register_file_i.rf_reg\[914\] gen_regfile_ff.register_file_i.rf_reg\[946\]
+ gen_regfile_ff.register_file_i.rf_reg\[978\] gen_regfile_ff.register_file_i.rf_reg\[1010\]
+ net1943 net1928 _08842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13069_ gen_regfile_ff.register_file_i.rf_reg\[786\] gen_regfile_ff.register_file_i.rf_reg\[818\]
+ gen_regfile_ff.register_file_i.rf_reg\[850\] gen_regfile_ff.register_file_i.rf_reg\[882\]
+ net1943 net1928 _08843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13070_ _08840_ _08841_ _08842_ _08843_ net1847 net1900 _08844_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13071_ gen_regfile_ff.register_file_i.rf_reg\[146\] gen_regfile_ff.register_file_i.rf_reg\[178\]
+ gen_regfile_ff.register_file_i.rf_reg\[210\] gen_regfile_ff.register_file_i.rf_reg\[242\]
+ net1940 net1927 _08845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13072_ gen_regfile_ff.register_file_i.rf_reg\[50\] gen_regfile_ff.register_file_i.rf_reg\[114\]
+ net1927 _08846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13073_ net1927 gen_regfile_ff.register_file_i.rf_reg\[82\]
+ _08847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13074_ _08846_ _08847_ net1853 _08848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13075_ gen_regfile_ff.register_file_i.rf_reg\[402\] gen_regfile_ff.register_file_i.rf_reg\[434\]
+ gen_regfile_ff.register_file_i.rf_reg\[466\] gen_regfile_ff.register_file_i.rf_reg\[498\]
+ net1940 net1927 _08849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13076_ gen_regfile_ff.register_file_i.rf_reg\[274\] gen_regfile_ff.register_file_i.rf_reg\[306\]
+ gen_regfile_ff.register_file_i.rf_reg\[338\] gen_regfile_ff.register_file_i.rf_reg\[370\]
+ net1940 net1927 _08850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13077_ _08845_ _08848_ _08849_ _08850_ net1847 net1902 _08851_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13078_ _08844_ _08851_ net1863 _08852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xclkbuf_leaf_4_clk clknet_2_1_0_clk clknet_leaf_4_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13080_ net1960 _08551_ _08854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13081_ net2059 _08854_ _08855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13082_ net1768 _08855_ net1795 _01264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13083_ gen_regfile_ff.register_file_i.rf_reg\[914\] gen_regfile_ff.register_file_i.rf_reg\[946\]
+ gen_regfile_ff.register_file_i.rf_reg\[978\] gen_regfile_ff.register_file_i.rf_reg\[1010\]
+ net2015 net1983 _08856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13084_ gen_regfile_ff.register_file_i.rf_reg\[786\] gen_regfile_ff.register_file_i.rf_reg\[818\]
+ gen_regfile_ff.register_file_i.rf_reg\[850\] gen_regfile_ff.register_file_i.rf_reg\[882\]
+ net2015 net1983 _08857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13085_ gen_regfile_ff.register_file_i.rf_reg\[658\] gen_regfile_ff.register_file_i.rf_reg\[690\]
+ gen_regfile_ff.register_file_i.rf_reg\[722\] gen_regfile_ff.register_file_i.rf_reg\[754\]
+ net2015 net1983 _08858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13086_ gen_regfile_ff.register_file_i.rf_reg\[530\] gen_regfile_ff.register_file_i.rf_reg\[562\]
+ gen_regfile_ff.register_file_i.rf_reg\[594\] gen_regfile_ff.register_file_i.rf_reg\[626\]
+ net2015 net1983 _08859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13087_ _08856_ _08857_ _08858_ _08859_ net1877 net1866 _08860_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13088_ gen_regfile_ff.register_file_i.rf_reg\[82\] gen_regfile_ff.register_file_i.rf_reg\[114\]
+ net2134 _08861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13089_ gen_regfile_ff.register_file_i.rf_reg\[50\] _08657_
+ _08861_ net1986 net1962 _08862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13090_ gen_regfile_ff.register_file_i.rf_reg\[146\] gen_regfile_ff.register_file_i.rf_reg\[178\]
+ gen_regfile_ff.register_file_i.rf_reg\[210\] gen_regfile_ff.register_file_i.rf_reg\[242\]
+ net2134 net1985 _08863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13091_ net1877 _08863_ net1866 _08864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13092_ gen_regfile_ff.register_file_i.rf_reg\[402\] gen_regfile_ff.register_file_i.rf_reg\[434\]
+ gen_regfile_ff.register_file_i.rf_reg\[466\] gen_regfile_ff.register_file_i.rf_reg\[498\]
+ net1989 net1983 _08865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13093_ gen_regfile_ff.register_file_i.rf_reg\[274\] gen_regfile_ff.register_file_i.rf_reg\[306\]
+ gen_regfile_ff.register_file_i.rf_reg\[338\] gen_regfile_ff.register_file_i.rf_reg\[370\]
+ net2134 net1983 _08866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13094_ _08865_ _08866_ net1877 _08867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13095_ net1959 _08867_ _08868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13096_ _08862_ _08864_ _08868_ net1842 _08869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13097_ net1842 _08860_ _08869_ _08870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13098_ _08192_ ex_block_i.alu_i.imd_val_q_i\[50\] ex_block_i.alu_i.imd_val_q_i\[18\]
+ net1824 _08200_ net1768 _08871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13099_ net2028 net1731 _08871_ _08872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13100_ net2175 net2111 _01264_ _08873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13101_ _08187_ _08872_ _08873_ _00887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13102_ cs_registers_i.pc_id_i\[18\] net1801 _08874_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13103_ id_stage_i.controller_i.lsu_addr_last_i\[18\] net1818
+ _08875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13104_ net1742 net1731 _08874_ net1741 _08875_ _01263_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13105_ net1682 _01267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkbuf_leaf_5_clk clknet_2_1_0_clk clknet_leaf_5_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13107_ gen_regfile_ff.register_file_i.rf_reg\[659\] gen_regfile_ff.register_file_i.rf_reg\[691\]
+ gen_regfile_ff.register_file_i.rf_reg\[723\] gen_regfile_ff.register_file_i.rf_reg\[755\]
+ net2182 net1924 _08877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13108_ gen_regfile_ff.register_file_i.rf_reg\[531\] gen_regfile_ff.register_file_i.rf_reg\[563\]
+ gen_regfile_ff.register_file_i.rf_reg\[595\] gen_regfile_ff.register_file_i.rf_reg\[627\]
+ net1938 net1924 _08878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13109_ gen_regfile_ff.register_file_i.rf_reg\[915\] gen_regfile_ff.register_file_i.rf_reg\[947\]
+ gen_regfile_ff.register_file_i.rf_reg\[979\] gen_regfile_ff.register_file_i.rf_reg\[1011\]
+ net2182 net1924 _08879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13110_ gen_regfile_ff.register_file_i.rf_reg\[787\] gen_regfile_ff.register_file_i.rf_reg\[819\]
+ gen_regfile_ff.register_file_i.rf_reg\[851\] gen_regfile_ff.register_file_i.rf_reg\[883\]
+ net2182 net1924 _08880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13111_ _08877_ _08878_ _08879_ _08880_ net1851 net1900 _08881_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13112_ gen_regfile_ff.register_file_i.rf_reg\[147\] gen_regfile_ff.register_file_i.rf_reg\[179\]
+ gen_regfile_ff.register_file_i.rf_reg\[211\] gen_regfile_ff.register_file_i.rf_reg\[243\]
+ net1938 net1922 _08882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13113_ gen_regfile_ff.register_file_i.rf_reg\[51\] gen_regfile_ff.register_file_i.rf_reg\[115\]
+ net1922 _08883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13114_ net1922 gen_regfile_ff.register_file_i.rf_reg\[83\]
+ _08884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13115_ _08883_ _08884_ net1854 _08885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13116_ gen_regfile_ff.register_file_i.rf_reg\[403\] gen_regfile_ff.register_file_i.rf_reg\[435\]
+ gen_regfile_ff.register_file_i.rf_reg\[467\] gen_regfile_ff.register_file_i.rf_reg\[499\]
+ net1938 net1922 _08886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13117_ gen_regfile_ff.register_file_i.rf_reg\[275\] gen_regfile_ff.register_file_i.rf_reg\[307\]
+ gen_regfile_ff.register_file_i.rf_reg\[339\] gen_regfile_ff.register_file_i.rf_reg\[371\]
+ net1938 net1922 _08887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13118_ _08882_ _08885_ _08886_ _08887_ net1851 net1900 _08888_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13119_ _08881_ _08888_ net1860 _08889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13120_ net1958 _08551_ _08890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13121_ net2060 _08890_ _08891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13122_ net1767 _08891_ net1795 _01271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13123_ gen_regfile_ff.register_file_i.rf_reg\[915\] gen_regfile_ff.register_file_i.rf_reg\[947\]
+ gen_regfile_ff.register_file_i.rf_reg\[979\] gen_regfile_ff.register_file_i.rf_reg\[1011\]
+ net2011 net1980 _08892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13124_ gen_regfile_ff.register_file_i.rf_reg\[787\] gen_regfile_ff.register_file_i.rf_reg\[819\]
+ gen_regfile_ff.register_file_i.rf_reg\[851\] gen_regfile_ff.register_file_i.rf_reg\[883\]
+ net2011 net1980 _08893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13125_ gen_regfile_ff.register_file_i.rf_reg\[659\] gen_regfile_ff.register_file_i.rf_reg\[691\]
+ gen_regfile_ff.register_file_i.rf_reg\[723\] gen_regfile_ff.register_file_i.rf_reg\[755\]
+ net2011 net1980 _08894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13126_ gen_regfile_ff.register_file_i.rf_reg\[531\] gen_regfile_ff.register_file_i.rf_reg\[563\]
+ gen_regfile_ff.register_file_i.rf_reg\[595\] gen_regfile_ff.register_file_i.rf_reg\[627\]
+ net2011 net1980 _08895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13127_ _08892_ _08893_ _08894_ _08895_ net1878 net1866 _08896_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13128_ gen_regfile_ff.register_file_i.rf_reg\[83\] gen_regfile_ff.register_file_i.rf_reg\[115\]
+ net2193 _08897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13129_ gen_regfile_ff.register_file_i.rf_reg\[51\] net1821
+ _08897_ net1982 net1963 _08898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13130_ gen_regfile_ff.register_file_i.rf_reg\[147\] gen_regfile_ff.register_file_i.rf_reg\[179\]
+ gen_regfile_ff.register_file_i.rf_reg\[211\] gen_regfile_ff.register_file_i.rf_reg\[243\]
+ net2193 net1982 _08899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13131_ net1878 _08899_ net1866 _08900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13132_ gen_regfile_ff.register_file_i.rf_reg\[403\] gen_regfile_ff.register_file_i.rf_reg\[435\]
+ gen_regfile_ff.register_file_i.rf_reg\[467\] gen_regfile_ff.register_file_i.rf_reg\[499\]
+ net2008 net1976 _08901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13133_ gen_regfile_ff.register_file_i.rf_reg\[275\] gen_regfile_ff.register_file_i.rf_reg\[307\]
+ gen_regfile_ff.register_file_i.rf_reg\[339\] gen_regfile_ff.register_file_i.rf_reg\[371\]
+ net2008 net1976 _08902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13134_ _08901_ _08902_ net1878 _08903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13135_ net1959 _08903_ _08904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13136_ _08898_ _08900_ _08904_ net1843 _08905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13137_ net1843 _08896_ _08905_ _08906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13138_ _08192_ ex_block_i.alu_i.imd_val_q_i\[51\] ex_block_i.alu_i.imd_val_q_i\[19\]
+ net1824 _08200_ net1767 _08907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13139_ net2028 net1730 _08907_ _08908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13140_ net1693 net2111 _01271_ _08909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13141_ _08187_ _08908_ _08909_ _00891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13142_ cs_registers_i.pc_id_i\[19\] net1801 _08910_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13143_ id_stage_i.controller_i.lsu_addr_last_i\[19\] net1818
+ _08911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13144_ net1742 net1730 _08910_ net1741 _08911_ _01270_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13145_ net1681 _01274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13146_ _00893_ _08912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13147_ _00889_ _00884_ _08913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13148_ _00888_ _08913_ _08914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13149_ _00885_ net2108 _08915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13150_ net2287 _08828_ _08915_ _08916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13151_ _08914_ _08916_ _08917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13152_ _08912_ _08917_ net165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13153_ _08129_ _08170_ _08502_ _08184_ _08918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13154_ _08498_ _08500_ _08919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_13155_ _00885_ net2194 _08920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_13156_ _08920_ _08737_ _08921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_13157_ _08919_ _08921_ _08922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13158_ net2076 _00872_ _00876_ _08923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13159_ _08923_ _08837_ _08820_ _08924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13160_ _00885_ _08924_ _00884_ _08925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13161_ _08920_ _08740_ _08739_ _08925_ _08926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_13162_ _08918_ _08922_ _08926_ _08927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13163_ _08927_ net2107 _08928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13164_ _08928_ net164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13165_ gen_regfile_ff.register_file_i.rf_reg\[660\] gen_regfile_ff.register_file_i.rf_reg\[692\]
+ gen_regfile_ff.register_file_i.rf_reg\[724\] gen_regfile_ff.register_file_i.rf_reg\[756\]
+ net1938 net1924 _08929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13166_ gen_regfile_ff.register_file_i.rf_reg\[532\] gen_regfile_ff.register_file_i.rf_reg\[564\]
+ gen_regfile_ff.register_file_i.rf_reg\[596\] gen_regfile_ff.register_file_i.rf_reg\[628\]
+ net1938 net1924 _08930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13167_ gen_regfile_ff.register_file_i.rf_reg\[916\] gen_regfile_ff.register_file_i.rf_reg\[948\]
+ gen_regfile_ff.register_file_i.rf_reg\[980\] gen_regfile_ff.register_file_i.rf_reg\[1012\]
+ net1938 net1924 _08931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13168_ gen_regfile_ff.register_file_i.rf_reg\[788\] gen_regfile_ff.register_file_i.rf_reg\[820\]
+ gen_regfile_ff.register_file_i.rf_reg\[852\] gen_regfile_ff.register_file_i.rf_reg\[884\]
+ net1938 net1924 _08932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13169_ _08929_ _08930_ _08931_ _08932_ net1851 net1900 _08933_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13170_ gen_regfile_ff.register_file_i.rf_reg\[148\] gen_regfile_ff.register_file_i.rf_reg\[180\]
+ gen_regfile_ff.register_file_i.rf_reg\[212\] gen_regfile_ff.register_file_i.rf_reg\[244\]
+ net1938 net1924 _08934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13171_ gen_regfile_ff.register_file_i.rf_reg\[52\] gen_regfile_ff.register_file_i.rf_reg\[116\]
+ net1922 _08935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13172_ net1922 gen_regfile_ff.register_file_i.rf_reg\[84\]
+ _08936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13173_ _08935_ _08936_ net1854 _08937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13174_ gen_regfile_ff.register_file_i.rf_reg\[404\] gen_regfile_ff.register_file_i.rf_reg\[436\]
+ gen_regfile_ff.register_file_i.rf_reg\[468\] gen_regfile_ff.register_file_i.rf_reg\[500\]
+ net1938 net1922 _08938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13175_ gen_regfile_ff.register_file_i.rf_reg\[276\] gen_regfile_ff.register_file_i.rf_reg\[308\]
+ gen_regfile_ff.register_file_i.rf_reg\[340\] gen_regfile_ff.register_file_i.rf_reg\[372\]
+ net1938 net1922 _08939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13176_ _08934_ _08937_ _08938_ _08939_ net1851 net1900 _08940_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13177_ _08933_ _08940_ net1860 _08941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13178_ _08546_ _07861_ _08942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
Xclkbuf_leaf_6_clk clknet_2_1_0_clk clknet_leaf_6_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13180_ net1855 net2054 _08942_ _08944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13181_ net1766 _08944_ net1795 _01278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13182_ _08941_ _08945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13183_ gen_regfile_ff.register_file_i.rf_reg\[404\] gen_regfile_ff.register_file_i.rf_reg\[436\]
+ gen_regfile_ff.register_file_i.rf_reg\[468\] gen_regfile_ff.register_file_i.rf_reg\[500\]
+ net2008 net1976 _08946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13184_ gen_regfile_ff.register_file_i.rf_reg\[276\] gen_regfile_ff.register_file_i.rf_reg\[308\]
+ gen_regfile_ff.register_file_i.rf_reg\[340\] gen_regfile_ff.register_file_i.rf_reg\[372\]
+ net2008 net1976 _08947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13185_ _08946_ _08947_ net1878 _08948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13186_ net1959 _08948_ _08949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13187_ gen_regfile_ff.register_file_i.rf_reg\[84\] gen_regfile_ff.register_file_i.rf_reg\[116\]
+ net2193 _08950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13188_ gen_regfile_ff.register_file_i.rf_reg\[52\] net1821
+ _08950_ net1976 _08951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13189_ gen_regfile_ff.register_file_i.rf_reg\[148\] gen_regfile_ff.register_file_i.rf_reg\[180\]
+ gen_regfile_ff.register_file_i.rf_reg\[212\] gen_regfile_ff.register_file_i.rf_reg\[244\]
+ net2193 net1979 _08952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13190_ net1878 _08952_ net1866 _08953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13191_ net1878 _08951_ _08953_ _08954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13192_ gen_regfile_ff.register_file_i.rf_reg\[916\] gen_regfile_ff.register_file_i.rf_reg\[948\]
+ gen_regfile_ff.register_file_i.rf_reg\[980\] gen_regfile_ff.register_file_i.rf_reg\[1012\]
+ net2010 net1979 _08955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13193_ gen_regfile_ff.register_file_i.rf_reg\[788\] gen_regfile_ff.register_file_i.rf_reg\[820\]
+ gen_regfile_ff.register_file_i.rf_reg\[852\] gen_regfile_ff.register_file_i.rf_reg\[884\]
+ net2010 net1979 _08956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13194_ gen_regfile_ff.register_file_i.rf_reg\[660\] gen_regfile_ff.register_file_i.rf_reg\[692\]
+ gen_regfile_ff.register_file_i.rf_reg\[724\] gen_regfile_ff.register_file_i.rf_reg\[756\]
+ net2010 net1979 _08957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13195_ gen_regfile_ff.register_file_i.rf_reg\[532\] gen_regfile_ff.register_file_i.rf_reg\[564\]
+ gen_regfile_ff.register_file_i.rf_reg\[596\] gen_regfile_ff.register_file_i.rf_reg\[628\]
+ net2193 net1979 _08958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13196_ _08955_ _08956_ _08957_ _08958_ net1878 net1866 _08959_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13197_ net1843 _08959_ _08960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13198_ _08960_ _08961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13199_ net1958 net1810 net1765 net1764 _08962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13200_ net1841 ex_block_i.alu_i.imd_val_q_i\[52\] ex_block_i.alu_i.imd_val_q_i\[20\]
+ net1824 _08963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_13201_ _08228_ net1729 net1728 net2028 _08963_ _08964_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xplace1550 _09687_ net1549 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13203_ net1693 net1694 _01278_ _08966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13204_ _08187_ _08964_ _08966_ _00895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13205_ cs_registers_i.pc_id_i\[20\] net1801 _08967_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13206_ id_stage_i.controller_i.lsu_addr_last_i\[20\] net1818
+ _08968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13207_ net2160 net1742 _08967_ net1741 _08968_ _01277_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_13208_ net2135 _01281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13209_ gen_regfile_ff.register_file_i.rf_reg\[661\] gen_regfile_ff.register_file_i.rf_reg\[693\]
+ gen_regfile_ff.register_file_i.rf_reg\[725\] gen_regfile_ff.register_file_i.rf_reg\[757\]
+ net1949 net1911 _08969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13210_ gen_regfile_ff.register_file_i.rf_reg\[533\] gen_regfile_ff.register_file_i.rf_reg\[565\]
+ gen_regfile_ff.register_file_i.rf_reg\[597\] gen_regfile_ff.register_file_i.rf_reg\[629\]
+ net1949 net1911 _08970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13211_ gen_regfile_ff.register_file_i.rf_reg\[917\] gen_regfile_ff.register_file_i.rf_reg\[949\]
+ gen_regfile_ff.register_file_i.rf_reg\[981\] gen_regfile_ff.register_file_i.rf_reg\[1013\]
+ net1949 net1911 _08971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13212_ gen_regfile_ff.register_file_i.rf_reg\[789\] gen_regfile_ff.register_file_i.rf_reg\[821\]
+ gen_regfile_ff.register_file_i.rf_reg\[853\] gen_regfile_ff.register_file_i.rf_reg\[885\]
+ net1949 net1911 _08972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13213_ _08969_ _08970_ _08971_ _08972_ net1850 net1901 _08973_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13214_ gen_regfile_ff.register_file_i.rf_reg\[149\] gen_regfile_ff.register_file_i.rf_reg\[181\]
+ gen_regfile_ff.register_file_i.rf_reg\[213\] gen_regfile_ff.register_file_i.rf_reg\[245\]
+ net1949 net2089 _08974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13215_ gen_regfile_ff.register_file_i.rf_reg\[53\] gen_regfile_ff.register_file_i.rf_reg\[117\]
+ net2089 _08975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13216_ net2089 gen_regfile_ff.register_file_i.rf_reg\[85\]
+ _08976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13217_ _08975_ _08976_ net1853 _08977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13218_ gen_regfile_ff.register_file_i.rf_reg\[405\] gen_regfile_ff.register_file_i.rf_reg\[437\]
+ gen_regfile_ff.register_file_i.rf_reg\[469\] gen_regfile_ff.register_file_i.rf_reg\[501\]
+ net1949 net1911 _08978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13219_ gen_regfile_ff.register_file_i.rf_reg\[277\] gen_regfile_ff.register_file_i.rf_reg\[309\]
+ gen_regfile_ff.register_file_i.rf_reg\[341\] gen_regfile_ff.register_file_i.rf_reg\[373\]
+ net1949 net1911 _08979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13220_ _08974_ _08977_ _08978_ _08979_ net1850 net1901 _08980_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13221_ _08973_ _08980_ net1863 _08981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xplace1548 _00452_ net1547 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13223_ net1908 _08547_ _08983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13224_ net2057 _08983_ _08984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13225_ net1763 _08984_ net1795 _01285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13226_ gen_regfile_ff.register_file_i.rf_reg\[853\] gen_regfile_ff.register_file_i.rf_reg\[885\]
+ gen_regfile_ff.register_file_i.rf_reg\[981\] gen_regfile_ff.register_file_i.rf_reg\[1013\]
+ net1990 net1962 _08985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13227_ gen_regfile_ff.register_file_i.rf_reg\[789\] gen_regfile_ff.register_file_i.rf_reg\[821\]
+ gen_regfile_ff.register_file_i.rf_reg\[917\] gen_regfile_ff.register_file_i.rf_reg\[949\]
+ net1990 net1962 _08986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13228_ gen_regfile_ff.register_file_i.rf_reg\[597\] gen_regfile_ff.register_file_i.rf_reg\[629\]
+ gen_regfile_ff.register_file_i.rf_reg\[725\] gen_regfile_ff.register_file_i.rf_reg\[757\]
+ net1990 net1962 _08987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13229_ gen_regfile_ff.register_file_i.rf_reg\[533\] gen_regfile_ff.register_file_i.rf_reg\[565\]
+ gen_regfile_ff.register_file_i.rf_reg\[661\] gen_regfile_ff.register_file_i.rf_reg\[693\]
+ net1990 net1962 _08988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13230_ _08985_ _08986_ _08987_ _08988_ net1874 net1866 _08989_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13231_ gen_regfile_ff.register_file_i.rf_reg\[85\] gen_regfile_ff.register_file_i.rf_reg\[117\]
+ net1990 _08990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13232_ gen_regfile_ff.register_file_i.rf_reg\[53\] net1820
+ _08990_ net1970 net1962 _08991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13233_ gen_regfile_ff.register_file_i.rf_reg\[149\] gen_regfile_ff.register_file_i.rf_reg\[181\]
+ gen_regfile_ff.register_file_i.rf_reg\[213\] gen_regfile_ff.register_file_i.rf_reg\[245\]
+ net1990 net1970 _08992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13234_ net1881 _08992_ net1866 _08993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13235_ gen_regfile_ff.register_file_i.rf_reg\[405\] gen_regfile_ff.register_file_i.rf_reg\[437\]
+ gen_regfile_ff.register_file_i.rf_reg\[469\] gen_regfile_ff.register_file_i.rf_reg\[501\]
+ net1990 net1968 _08994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13236_ gen_regfile_ff.register_file_i.rf_reg\[277\] gen_regfile_ff.register_file_i.rf_reg\[309\]
+ gen_regfile_ff.register_file_i.rf_reg\[341\] gen_regfile_ff.register_file_i.rf_reg\[373\]
+ net1990 net1968 _08995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13237_ _08994_ _08995_ net1881 _08996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13238_ net1961 _08996_ _08997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13239_ _08991_ _08993_ _08997_ net1842 _08998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13240_ net1842 _08989_ _08998_ _08999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
Xplace1547 _00659_ net1546 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13242_ net1841 ex_block_i.alu_i.imd_val_q_i\[53\] ex_block_i.alu_i.imd_val_q_i\[21\]
+ net1824 _08200_ net1763 _09001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13243_ net2028 net1727 _09001_ _09002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13244_ net2175 net1694 _01285_ _09003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13245_ net1783 _09002_ _09003_ _00899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13246_ cs_registers_i.pc_id_i\[21\] net1801 _09004_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13247_ id_stage_i.controller_i.lsu_addr_last_i\[21\] net1818
+ _09005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13248_ net1742 net1727 _09004_ net1741 _09005_ _01284_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13249_ net1680 _01288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13250_ _00885_ net2172 _09006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13251_ _00897_ _00901_ _09007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13252_ _00893_ _09007_ _09008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13253_ _09006_ _09008_ _09009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13254_ _08819_ _08828_ _09009_ _09010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13255_ _08914_ _09008_ _09011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13256_ _00897_ _00892_ _09012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13257_ _00896_ _09012_ _09013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13258_ _00901_ _09013_ _09014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13259_ _09010_ _09011_ _09014_ _09015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13260_ _00893_ _00897_ _09016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13261_ _08917_ _09016_ _09013_ _00901_ _09017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_13262_ _09015_ net1434 net167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13263_ _08919_ _08834_ _08817_ _09006_ _09018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_13264_ net2107 _08926_ _00892_ _00888_ _09019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_13265_ _00897_ _09019_ _09020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13266_ net2123 _09018_ _09020_ _09021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13267_ _08912_ _00897_ _09022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13268_ net2123 _09018_ _09022_ _09023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13269_ net2108 _08926_ _00888_ _09024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13270_ _00892_ _09025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13271_ _08912_ _09025_ _09026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13272_ _09025_ _09026_ _00897_ _09027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13273_ _09024_ _09022_ _09027_ _09028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13274_ _09028_ _09029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13275_ _09021_ _09023_ _09029_ net166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13276_ gen_regfile_ff.register_file_i.rf_reg\[662\] gen_regfile_ff.register_file_i.rf_reg\[694\]
+ gen_regfile_ff.register_file_i.rf_reg\[726\] gen_regfile_ff.register_file_i.rf_reg\[758\]
+ net1952 net1918 _09030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13277_ gen_regfile_ff.register_file_i.rf_reg\[534\] gen_regfile_ff.register_file_i.rf_reg\[566\]
+ gen_regfile_ff.register_file_i.rf_reg\[598\] gen_regfile_ff.register_file_i.rf_reg\[630\]
+ net1952 net1918 _09031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13278_ gen_regfile_ff.register_file_i.rf_reg\[918\] gen_regfile_ff.register_file_i.rf_reg\[950\]
+ gen_regfile_ff.register_file_i.rf_reg\[982\] gen_regfile_ff.register_file_i.rf_reg\[1014\]
+ net2114 net1918 _09032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13279_ gen_regfile_ff.register_file_i.rf_reg\[790\] gen_regfile_ff.register_file_i.rf_reg\[822\]
+ gen_regfile_ff.register_file_i.rf_reg\[854\] gen_regfile_ff.register_file_i.rf_reg\[886\]
+ net1952 net1918 _09033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13280_ _09030_ _09031_ _09032_ _09033_ net1847 net1902 _09034_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13281_ gen_regfile_ff.register_file_i.rf_reg\[150\] gen_regfile_ff.register_file_i.rf_reg\[182\]
+ gen_regfile_ff.register_file_i.rf_reg\[214\] gen_regfile_ff.register_file_i.rf_reg\[246\]
+ net1953 net1918 _09035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13282_ gen_regfile_ff.register_file_i.rf_reg\[54\] gen_regfile_ff.register_file_i.rf_reg\[118\]
+ net1918 _09036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13283_ net1918 gen_regfile_ff.register_file_i.rf_reg\[86\]
+ _09037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13284_ _09036_ _09037_ net1853 _09038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13285_ gen_regfile_ff.register_file_i.rf_reg\[406\] gen_regfile_ff.register_file_i.rf_reg\[438\]
+ gen_regfile_ff.register_file_i.rf_reg\[470\] gen_regfile_ff.register_file_i.rf_reg\[502\]
+ net1951 net1918 _09039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13286_ gen_regfile_ff.register_file_i.rf_reg\[278\] gen_regfile_ff.register_file_i.rf_reg\[310\]
+ gen_regfile_ff.register_file_i.rf_reg\[342\] gen_regfile_ff.register_file_i.rf_reg\[374\]
+ net1951 net1918 _09040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13287_ _09035_ _09038_ _09039_ _09040_ net1847 net1902 _09041_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13288_ _09034_ _09041_ net1863 _09042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13289_ net1848 net2054 _08942_ _09043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13290_ net1762 _09043_ net1795 _01292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1546 _00490_ net1545 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13292_ gen_regfile_ff.register_file_i.rf_reg\[854\] gen_regfile_ff.register_file_i.rf_reg\[886\]
+ gen_regfile_ff.register_file_i.rf_reg\[982\] gen_regfile_ff.register_file_i.rf_reg\[1014\]
+ net2166 net1963 _09045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13293_ gen_regfile_ff.register_file_i.rf_reg\[790\] gen_regfile_ff.register_file_i.rf_reg\[822\]
+ gen_regfile_ff.register_file_i.rf_reg\[918\] gen_regfile_ff.register_file_i.rf_reg\[950\]
+ net2166 net1963 _09046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13294_ gen_regfile_ff.register_file_i.rf_reg\[598\] gen_regfile_ff.register_file_i.rf_reg\[630\]
+ gen_regfile_ff.register_file_i.rf_reg\[726\] gen_regfile_ff.register_file_i.rf_reg\[758\]
+ net2134 net1963 _09047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13295_ gen_regfile_ff.register_file_i.rf_reg\[534\] gen_regfile_ff.register_file_i.rf_reg\[566\]
+ gen_regfile_ff.register_file_i.rf_reg\[662\] gen_regfile_ff.register_file_i.rf_reg\[694\]
+ net2134 net1963 _09048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13296_ _09045_ _09046_ _09047_ _09048_ net1874 net1866 _09049_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13297_ gen_regfile_ff.register_file_i.rf_reg\[86\] gen_regfile_ff.register_file_i.rf_reg\[118\]
+ net2166 _09050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13298_ gen_regfile_ff.register_file_i.rf_reg\[54\] _08657_
+ _09050_ net1973 net1962 _09051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13299_ gen_regfile_ff.register_file_i.rf_reg\[150\] gen_regfile_ff.register_file_i.rf_reg\[182\]
+ gen_regfile_ff.register_file_i.rf_reg\[214\] gen_regfile_ff.register_file_i.rf_reg\[246\]
+ net2166 net1973 _09052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13300_ net1881 _09052_ net1866 _09053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13301_ gen_regfile_ff.register_file_i.rf_reg\[406\] gen_regfile_ff.register_file_i.rf_reg\[438\]
+ gen_regfile_ff.register_file_i.rf_reg\[470\] gen_regfile_ff.register_file_i.rf_reg\[502\]
+ net1990 net1973 _09054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13302_ gen_regfile_ff.register_file_i.rf_reg\[278\] gen_regfile_ff.register_file_i.rf_reg\[310\]
+ gen_regfile_ff.register_file_i.rf_reg\[342\] gen_regfile_ff.register_file_i.rf_reg\[374\]
+ net1990 net1973 _09055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13303_ _09054_ _09055_ net1881 _09056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13304_ net1961 _09056_ _09057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13305_ _09051_ _09053_ _09057_ net1842 _09058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13306_ net1843 _09049_ _09058_ _09059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1545 _00684_ net1544 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1549 _09702_ net1548 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13309_ net1841 ex_block_i.alu_i.imd_val_q_i\[54\] ex_block_i.alu_i.imd_val_q_i\[22\]
+ net1824 _08200_ net1762 _09062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13310_ net2028 net1726 _09062_ _09063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13311_ net1693 net1694 _01292_ _09064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13312_ net1783 _09063_ _09064_ _00903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13313_ cs_registers_i.pc_id_i\[22\] net1801 _09065_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13314_ id_stage_i.controller_i.lsu_addr_last_i\[22\] net1818
+ _09066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13315_ net1742 net1726 _09065_ net1741 _09066_ _01291_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13316_ net1679 _01295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13317_ gen_regfile_ff.register_file_i.rf_reg\[663\] gen_regfile_ff.register_file_i.rf_reg\[695\]
+ gen_regfile_ff.register_file_i.rf_reg\[727\] gen_regfile_ff.register_file_i.rf_reg\[759\]
+ net2114 net1930 _09067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13318_ gen_regfile_ff.register_file_i.rf_reg\[535\] gen_regfile_ff.register_file_i.rf_reg\[567\]
+ gen_regfile_ff.register_file_i.rf_reg\[599\] gen_regfile_ff.register_file_i.rf_reg\[631\]
+ net2114 net1930 _09068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13319_ gen_regfile_ff.register_file_i.rf_reg\[919\] gen_regfile_ff.register_file_i.rf_reg\[951\]
+ gen_regfile_ff.register_file_i.rf_reg\[983\] gen_regfile_ff.register_file_i.rf_reg\[1015\]
+ net2114 net1930 _09069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13320_ gen_regfile_ff.register_file_i.rf_reg\[791\] gen_regfile_ff.register_file_i.rf_reg\[823\]
+ gen_regfile_ff.register_file_i.rf_reg\[855\] gen_regfile_ff.register_file_i.rf_reg\[887\]
+ net2114 net1930 _09070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13321_ _09067_ _09068_ _09069_ _09070_ net1847 net1902 _09071_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13322_ gen_regfile_ff.register_file_i.rf_reg\[151\] gen_regfile_ff.register_file_i.rf_reg\[183\]
+ gen_regfile_ff.register_file_i.rf_reg\[215\] gen_regfile_ff.register_file_i.rf_reg\[247\]
+ net1955 net1930 _09072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13323_ gen_regfile_ff.register_file_i.rf_reg\[55\] gen_regfile_ff.register_file_i.rf_reg\[119\]
+ net1927 _09073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13324_ net1927 gen_regfile_ff.register_file_i.rf_reg\[87\]
+ _09074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13325_ _09073_ _09074_ net1853 _09075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13326_ gen_regfile_ff.register_file_i.rf_reg\[407\] gen_regfile_ff.register_file_i.rf_reg\[439\]
+ gen_regfile_ff.register_file_i.rf_reg\[471\] gen_regfile_ff.register_file_i.rf_reg\[503\]
+ net2114 net1930 _09076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13327_ gen_regfile_ff.register_file_i.rf_reg\[279\] gen_regfile_ff.register_file_i.rf_reg\[311\]
+ gen_regfile_ff.register_file_i.rf_reg\[343\] gen_regfile_ff.register_file_i.rf_reg\[375\]
+ net1955 net1930 _09077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13328_ _09072_ _09075_ _09076_ _09077_ net1847 net1902 _09078_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13329_ _09071_ _09078_ net1863 _09079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13330_ net1858 net2054 _08942_ _09080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13331_ net1761 _09080_ net1795 _01299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13332_ gen_regfile_ff.register_file_i.rf_reg\[919\] gen_regfile_ff.register_file_i.rf_reg\[951\]
+ gen_regfile_ff.register_file_i.rf_reg\[983\] gen_regfile_ff.register_file_i.rf_reg\[1015\]
+ net1998 net1988 _09081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13333_ gen_regfile_ff.register_file_i.rf_reg\[791\] gen_regfile_ff.register_file_i.rf_reg\[823\]
+ gen_regfile_ff.register_file_i.rf_reg\[855\] gen_regfile_ff.register_file_i.rf_reg\[887\]
+ net1998 net1988 _09082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13334_ gen_regfile_ff.register_file_i.rf_reg\[663\] gen_regfile_ff.register_file_i.rf_reg\[695\]
+ gen_regfile_ff.register_file_i.rf_reg\[727\] gen_regfile_ff.register_file_i.rf_reg\[759\]
+ net1998 net1988 _09083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13335_ gen_regfile_ff.register_file_i.rf_reg\[535\] gen_regfile_ff.register_file_i.rf_reg\[567\]
+ gen_regfile_ff.register_file_i.rf_reg\[599\] gen_regfile_ff.register_file_i.rf_reg\[631\]
+ net1998 net1988 _09084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13336_ _09081_ _09082_ _09083_ _09084_ net1877 net1866 _09085_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13337_ gen_regfile_ff.register_file_i.rf_reg\[87\] gen_regfile_ff.register_file_i.rf_reg\[119\]
+ net1998 _09086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13338_ gen_regfile_ff.register_file_i.rf_reg\[55\] net1821
+ _09086_ net1986 net1962 _09087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13339_ gen_regfile_ff.register_file_i.rf_reg\[151\] gen_regfile_ff.register_file_i.rf_reg\[183\]
+ gen_regfile_ff.register_file_i.rf_reg\[215\] gen_regfile_ff.register_file_i.rf_reg\[247\]
+ net1998 net1985 _09088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13340_ net1879 _09088_ net1866 _09089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13341_ gen_regfile_ff.register_file_i.rf_reg\[407\] gen_regfile_ff.register_file_i.rf_reg\[439\]
+ gen_regfile_ff.register_file_i.rf_reg\[471\] gen_regfile_ff.register_file_i.rf_reg\[503\]
+ net2165 net1986 _09090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13342_ gen_regfile_ff.register_file_i.rf_reg\[279\] gen_regfile_ff.register_file_i.rf_reg\[311\]
+ gen_regfile_ff.register_file_i.rf_reg\[343\] gen_regfile_ff.register_file_i.rf_reg\[375\]
+ net2165 net1986 _09091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13343_ _09090_ _09091_ net1879 _09092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13344_ net1959 _09092_ _09093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13345_ _09087_ _09089_ _09093_ net1842 _09094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13346_ net1842 _09085_ _09094_ _09095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13347_ _08192_ ex_block_i.alu_i.imd_val_q_i\[55\] ex_block_i.alu_i.imd_val_q_i\[23\]
+ net1824 _08200_ net1761 _09096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13348_ net2028 net1725 _09096_ _09097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13349_ net1693 net2111 _01299_ _09098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13350_ net1783 _09097_ _09098_ _00907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13351_ cs_registers_i.pc_id_i\[23\] net1801 _09099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13352_ id_stage_i.controller_i.lsu_addr_last_i\[23\] net1818
+ _09100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13353_ net1742 net1725 _09099_ net1741 _09100_ _01298_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13354_ net1678 _01302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13355_ _00904_ _09101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13356_ _00900_ _09014_ _09102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13357_ _09010_ _09011_ _09102_ net2186 _09103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13358_ _00909_ _09104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_13359_ _09101_ _09103_ _09104_ _09105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13360_ _09104_ _09101_ _09103_ _09106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13361_ _09105_ _09106_ net169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13362_ net2107 _09008_ _09107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13363_ _08919_ _08921_ _09107_ _09108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13364_ _08924_ _09006_ _08914_ _09109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13365_ _08912_ _09109_ _09025_ _09110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13366_ _00901_ _00896_ _09111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13367_ _00900_ _09111_ _09112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13368_ _09007_ _09110_ _09112_ _09113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13369_ net2107 _09008_ _09114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13370_ _08741_ _08920_ _09114_ _09115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13371_ _09113_ _09115_ _09116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13372_ _08918_ _09108_ _09116_ _09117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_13373_ net2186 _09117_ net168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13374_ gen_regfile_ff.register_file_i.rf_reg\[664\] gen_regfile_ff.register_file_i.rf_reg\[696\]
+ gen_regfile_ff.register_file_i.rf_reg\[728\] gen_regfile_ff.register_file_i.rf_reg\[760\]
+ net1948 net1911 _09118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xplace1544 _04411_ net1543 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13376_ gen_regfile_ff.register_file_i.rf_reg\[536\] gen_regfile_ff.register_file_i.rf_reg\[568\]
+ gen_regfile_ff.register_file_i.rf_reg\[600\] gen_regfile_ff.register_file_i.rf_reg\[632\]
+ net1948 net1911 _09120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13377_ gen_regfile_ff.register_file_i.rf_reg\[920\] gen_regfile_ff.register_file_i.rf_reg\[952\]
+ gen_regfile_ff.register_file_i.rf_reg\[984\] gen_regfile_ff.register_file_i.rf_reg\[1016\]
+ net1948 net1911 _09121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13378_ gen_regfile_ff.register_file_i.rf_reg\[792\] gen_regfile_ff.register_file_i.rf_reg\[824\]
+ gen_regfile_ff.register_file_i.rf_reg\[856\] gen_regfile_ff.register_file_i.rf_reg\[888\]
+ net1948 net1911 _09122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13379_ _09118_ _09120_ _09121_ _09122_ net1847 net1901 _09123_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13380_ gen_regfile_ff.register_file_i.rf_reg\[152\] gen_regfile_ff.register_file_i.rf_reg\[184\]
+ gen_regfile_ff.register_file_i.rf_reg\[216\] gen_regfile_ff.register_file_i.rf_reg\[248\]
+ net1953 net2089 _09124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13381_ gen_regfile_ff.register_file_i.rf_reg\[56\] gen_regfile_ff.register_file_i.rf_reg\[120\]
+ net2089 _09125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13382_ net2089 gen_regfile_ff.register_file_i.rf_reg\[88\]
+ _09126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13383_ _09125_ _09126_ net1853 _09127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13384_ gen_regfile_ff.register_file_i.rf_reg\[408\] gen_regfile_ff.register_file_i.rf_reg\[440\]
+ gen_regfile_ff.register_file_i.rf_reg\[472\] gen_regfile_ff.register_file_i.rf_reg\[504\]
+ net1953 net2089 _09128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13385_ gen_regfile_ff.register_file_i.rf_reg\[280\] gen_regfile_ff.register_file_i.rf_reg\[312\]
+ gen_regfile_ff.register_file_i.rf_reg\[344\] gen_regfile_ff.register_file_i.rf_reg\[376\]
+ net1953 net2089 _09129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13386_ _09124_ _09127_ _09128_ _09129_ net1847 net1901 _09130_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13387_ _09123_ _09130_ net1862 _09131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13388_ net1860 net2054 _08942_ _09132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13389_ net1760 _09132_ net1795 _01306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_7_clk clknet_2_0_0_clk clknet_leaf_7_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13391_ gen_regfile_ff.register_file_i.rf_reg\[856\] gen_regfile_ff.register_file_i.rf_reg\[888\]
+ gen_regfile_ff.register_file_i.rf_reg\[984\] gen_regfile_ff.register_file_i.rf_reg\[1016\]
+ net1992 net1962 _09134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13392_ gen_regfile_ff.register_file_i.rf_reg\[792\] gen_regfile_ff.register_file_i.rf_reg\[824\]
+ gen_regfile_ff.register_file_i.rf_reg\[920\] gen_regfile_ff.register_file_i.rf_reg\[952\]
+ net1992 net1962 _09135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13393_ gen_regfile_ff.register_file_i.rf_reg\[600\] gen_regfile_ff.register_file_i.rf_reg\[632\]
+ gen_regfile_ff.register_file_i.rf_reg\[728\] gen_regfile_ff.register_file_i.rf_reg\[760\]
+ net1992 net1962 _09136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13394_ gen_regfile_ff.register_file_i.rf_reg\[536\] gen_regfile_ff.register_file_i.rf_reg\[568\]
+ gen_regfile_ff.register_file_i.rf_reg\[664\] gen_regfile_ff.register_file_i.rf_reg\[696\]
+ net1992 net1962 _09137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13395_ _09134_ _09135_ _09136_ _09137_ net1873 net1866 _09138_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13396_ gen_regfile_ff.register_file_i.rf_reg\[88\] gen_regfile_ff.register_file_i.rf_reg\[120\]
+ net1990 _09139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13397_ gen_regfile_ff.register_file_i.rf_reg\[56\] net1820
+ _09139_ net1970 net1962 _09140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13398_ gen_regfile_ff.register_file_i.rf_reg\[152\] gen_regfile_ff.register_file_i.rf_reg\[184\]
+ gen_regfile_ff.register_file_i.rf_reg\[216\] gen_regfile_ff.register_file_i.rf_reg\[248\]
+ net1990 net1970 _09141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13399_ net1881 _09141_ net1866 _09142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13400_ gen_regfile_ff.register_file_i.rf_reg\[408\] gen_regfile_ff.register_file_i.rf_reg\[440\]
+ gen_regfile_ff.register_file_i.rf_reg\[472\] gen_regfile_ff.register_file_i.rf_reg\[504\]
+ net1990 net1970 _09143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13401_ gen_regfile_ff.register_file_i.rf_reg\[280\] gen_regfile_ff.register_file_i.rf_reg\[312\]
+ gen_regfile_ff.register_file_i.rf_reg\[344\] gen_regfile_ff.register_file_i.rf_reg\[376\]
+ net1990 net1968 _09144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13402_ _09143_ _09144_ net1881 _09145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13403_ net1961 _09145_ _09146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13404_ _09140_ _09142_ _09146_ net1842 _09147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13405_ net1842 _09138_ _09147_ _09148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_13406_ net1841 ex_block_i.alu_i.imd_val_q_i\[56\] ex_block_i.alu_i.imd_val_q_i\[24\]
+ net1824 _08200_ net1760 _09149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13407_ net2028 net1723 _09149_ _09150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13408_ net1693 net2111 _01306_ _09151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13409_ net1783 _09150_ _09151_ _00911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13410_ cs_registers_i.pc_id_i\[24\] net1801 _09152_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13411_ id_stage_i.controller_i.lsu_addr_last_i\[24\] net1818
+ _09153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13412_ net1742 net1723 _09152_ net1741 _09153_ _01305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13413_ net1677 _01309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13414_ gen_regfile_ff.register_file_i.rf_reg\[665\] gen_regfile_ff.register_file_i.rf_reg\[697\]
+ gen_regfile_ff.register_file_i.rf_reg\[729\] gen_regfile_ff.register_file_i.rf_reg\[761\]
+ net2112 net1927 _09154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13415_ gen_regfile_ff.register_file_i.rf_reg\[537\] gen_regfile_ff.register_file_i.rf_reg\[569\]
+ gen_regfile_ff.register_file_i.rf_reg\[601\] gen_regfile_ff.register_file_i.rf_reg\[633\]
+ net2112 net1927 _09155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13416_ gen_regfile_ff.register_file_i.rf_reg\[921\] gen_regfile_ff.register_file_i.rf_reg\[953\]
+ gen_regfile_ff.register_file_i.rf_reg\[985\] gen_regfile_ff.register_file_i.rf_reg\[1017\]
+ net2112 net1927 _09156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13417_ gen_regfile_ff.register_file_i.rf_reg\[793\] gen_regfile_ff.register_file_i.rf_reg\[825\]
+ gen_regfile_ff.register_file_i.rf_reg\[857\] gen_regfile_ff.register_file_i.rf_reg\[889\]
+ net2112 net1927 _09157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13418_ _09154_ _09155_ _09156_ _09157_ net1851 net1900 _09158_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13419_ gen_regfile_ff.register_file_i.rf_reg\[153\] gen_regfile_ff.register_file_i.rf_reg\[185\]
+ gen_regfile_ff.register_file_i.rf_reg\[217\] gen_regfile_ff.register_file_i.rf_reg\[249\]
+ net2112 net1927 _09159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13420_ gen_regfile_ff.register_file_i.rf_reg\[57\] gen_regfile_ff.register_file_i.rf_reg\[121\]
+ net1927 _09160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13421_ net1927 gen_regfile_ff.register_file_i.rf_reg\[89\]
+ _09161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13422_ _09160_ _09161_ net1854 _09162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13423_ gen_regfile_ff.register_file_i.rf_reg\[409\] gen_regfile_ff.register_file_i.rf_reg\[441\]
+ gen_regfile_ff.register_file_i.rf_reg\[473\] gen_regfile_ff.register_file_i.rf_reg\[505\]
+ net2112 net1927 _09163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13424_ gen_regfile_ff.register_file_i.rf_reg\[281\] gen_regfile_ff.register_file_i.rf_reg\[313\]
+ gen_regfile_ff.register_file_i.rf_reg\[345\] gen_regfile_ff.register_file_i.rf_reg\[377\]
+ net2112 net1927 _09164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13425_ _09159_ _09162_ _09163_ _09164_ net1851 net1900 _09165_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13426_ _09158_ _09165_ net1860 _09166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13427_ _07833_ net2054 _08942_ _09167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13428_ net1759 _09167_ net1795 _01313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13429_ gen_regfile_ff.register_file_i.rf_reg\[857\] gen_regfile_ff.register_file_i.rf_reg\[889\]
+ gen_regfile_ff.register_file_i.rf_reg\[985\] gen_regfile_ff.register_file_i.rf_reg\[1017\]
+ net2014 net1963 _09168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13430_ gen_regfile_ff.register_file_i.rf_reg\[793\] gen_regfile_ff.register_file_i.rf_reg\[825\]
+ gen_regfile_ff.register_file_i.rf_reg\[921\] gen_regfile_ff.register_file_i.rf_reg\[953\]
+ net2014 net1963 _09169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13431_ gen_regfile_ff.register_file_i.rf_reg\[601\] gen_regfile_ff.register_file_i.rf_reg\[633\]
+ gen_regfile_ff.register_file_i.rf_reg\[729\] gen_regfile_ff.register_file_i.rf_reg\[761\]
+ net2014 net1963 _09170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13432_ gen_regfile_ff.register_file_i.rf_reg\[537\] gen_regfile_ff.register_file_i.rf_reg\[569\]
+ gen_regfile_ff.register_file_i.rf_reg\[665\] gen_regfile_ff.register_file_i.rf_reg\[697\]
+ net2014 net1963 _09171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13433_ _09168_ _09169_ _09170_ _09171_ net1875 net1866 _09172_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13434_ gen_regfile_ff.register_file_i.rf_reg\[89\] gen_regfile_ff.register_file_i.rf_reg\[121\]
+ net2014 _09173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13435_ gen_regfile_ff.register_file_i.rf_reg\[57\] net1821
+ _09173_ net1984 net1963 _09174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13436_ gen_regfile_ff.register_file_i.rf_reg\[153\] gen_regfile_ff.register_file_i.rf_reg\[185\]
+ gen_regfile_ff.register_file_i.rf_reg\[217\] gen_regfile_ff.register_file_i.rf_reg\[249\]
+ net2014 net1984 _09175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13437_ net1877 _09175_ net1866 _09176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13438_ gen_regfile_ff.register_file_i.rf_reg\[409\] gen_regfile_ff.register_file_i.rf_reg\[441\]
+ gen_regfile_ff.register_file_i.rf_reg\[473\] gen_regfile_ff.register_file_i.rf_reg\[505\]
+ net2013 net1984 _09177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13439_ gen_regfile_ff.register_file_i.rf_reg\[281\] gen_regfile_ff.register_file_i.rf_reg\[313\]
+ gen_regfile_ff.register_file_i.rf_reg\[345\] gen_regfile_ff.register_file_i.rf_reg\[377\]
+ net2014 net1984 _09178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13440_ _09177_ _09178_ net1877 _09179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13441_ net1959 _09179_ _09180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13442_ _09174_ _09176_ _09180_ net1843 _09181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13443_ net1843 _09172_ _09181_ _09182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13444_ net1841 ex_block_i.alu_i.imd_val_q_i\[57\] ex_block_i.alu_i.imd_val_q_i\[25\]
+ _08197_ _08200_ net1759 _09183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13445_ net2028 net1722 _09183_ _09184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13446_ net2175 net2111 _01313_ _09185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13447_ net1783 _09184_ _09185_ _00915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13448_ cs_registers_i.pc_id_i\[25\] net1801 _09186_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13449_ id_stage_i.controller_i.lsu_addr_last_i\[25\] net1818
+ _09187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13450_ net1742 net1722 _09186_ net1741 _09187_ _01312_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_13451_ _01312_ _01316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13452_ _00905_ _00900_ _00904_ _09188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13453_ _00908_ _09189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13454_ _09104_ _09188_ _09189_ _09190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13455_ _09190_ _00913_ _00912_ _09191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13456_ _00905_ _00909_ _00913_ _09192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13457_ _00917_ _09192_ _09193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13458_ _00917_ _09194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13459_ _09194_ _09191_ _09195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13460_ net2129 _09193_ _09195_ _09196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13461_ _00917_ _09192_ _09197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_13462_ _09010_ _09011_ _09014_ _09197_ _09198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13463_ _09194_ net2129 _09199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13464_ _09010_ _09011_ _09014_ _09199_ _09200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13465_ _09196_ _09198_ _09200_ net171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13466_ net2123 _09018_ _09019_ _09201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13467_ net2186 _09007_ _09026_ _09202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13468_ net2186 _09112_ _00904_ _09203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13469_ _00913_ _09189_ _09203_ _09204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13470_ _09201_ _09202_ _09204_ _09205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13471_ _00913_ _09206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13472_ _00909_ _09206_ _09201_ _09202_ _09207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13473_ _09104_ _00913_ _09203_ _09208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13474_ _09104_ _00913_ _09209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13475_ _09206_ _09209_ _09189_ _09210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13476_ _09207_ _09205_ _09208_ _09210_ net170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_13477_ gen_regfile_ff.register_file_i.rf_reg\[666\] gen_regfile_ff.register_file_i.rf_reg\[698\]
+ gen_regfile_ff.register_file_i.rf_reg\[730\] gen_regfile_ff.register_file_i.rf_reg\[762\]
+ net2182 net1925 _09211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13478_ gen_regfile_ff.register_file_i.rf_reg\[538\] gen_regfile_ff.register_file_i.rf_reg\[570\]
+ gen_regfile_ff.register_file_i.rf_reg\[602\] gen_regfile_ff.register_file_i.rf_reg\[634\]
+ net2182 net1925 _09212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13479_ gen_regfile_ff.register_file_i.rf_reg\[922\] gen_regfile_ff.register_file_i.rf_reg\[954\]
+ gen_regfile_ff.register_file_i.rf_reg\[986\] gen_regfile_ff.register_file_i.rf_reg\[1018\]
+ net2182 net1924 _09213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13480_ gen_regfile_ff.register_file_i.rf_reg\[794\] gen_regfile_ff.register_file_i.rf_reg\[826\]
+ gen_regfile_ff.register_file_i.rf_reg\[858\] gen_regfile_ff.register_file_i.rf_reg\[890\]
+ net2182 net1924 _09214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13481_ _09211_ _09212_ _09213_ _09214_ net1851 net1900 _09215_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13482_ gen_regfile_ff.register_file_i.rf_reg\[154\] gen_regfile_ff.register_file_i.rf_reg\[186\]
+ gen_regfile_ff.register_file_i.rf_reg\[218\] gen_regfile_ff.register_file_i.rf_reg\[250\]
+ net2182 net1925 _09216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13483_ gen_regfile_ff.register_file_i.rf_reg\[58\] gen_regfile_ff.register_file_i.rf_reg\[122\]
+ net1922 _09217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13484_ net1922 gen_regfile_ff.register_file_i.rf_reg\[90\]
+ _09218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13485_ _09217_ _09218_ net1854 _09219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13486_ gen_regfile_ff.register_file_i.rf_reg\[410\] gen_regfile_ff.register_file_i.rf_reg\[442\]
+ gen_regfile_ff.register_file_i.rf_reg\[474\] gen_regfile_ff.register_file_i.rf_reg\[506\]
+ net2182 net1925 _09220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13487_ gen_regfile_ff.register_file_i.rf_reg\[282\] gen_regfile_ff.register_file_i.rf_reg\[314\]
+ gen_regfile_ff.register_file_i.rf_reg\[346\] gen_regfile_ff.register_file_i.rf_reg\[378\]
+ net1942 net1925 _09221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13488_ _09216_ _09219_ _09220_ _09221_ net1851 net1900 _09222_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13489_ _09215_ _09222_ net1860 _09223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13490_ _07860_ net2054 net2056 _09224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13491_ net1758 _09224_ net1795 _01320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13492_ gen_regfile_ff.register_file_i.rf_reg\[922\] gen_regfile_ff.register_file_i.rf_reg\[954\]
+ gen_regfile_ff.register_file_i.rf_reg\[986\] gen_regfile_ff.register_file_i.rf_reg\[1018\]
+ net2012 net1981 _09225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13493_ gen_regfile_ff.register_file_i.rf_reg\[794\] gen_regfile_ff.register_file_i.rf_reg\[826\]
+ gen_regfile_ff.register_file_i.rf_reg\[858\] gen_regfile_ff.register_file_i.rf_reg\[890\]
+ net2012 net1981 _09226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13494_ gen_regfile_ff.register_file_i.rf_reg\[666\] gen_regfile_ff.register_file_i.rf_reg\[698\]
+ gen_regfile_ff.register_file_i.rf_reg\[730\] gen_regfile_ff.register_file_i.rf_reg\[762\]
+ net2012 net1981 _09227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13495_ gen_regfile_ff.register_file_i.rf_reg\[538\] gen_regfile_ff.register_file_i.rf_reg\[570\]
+ gen_regfile_ff.register_file_i.rf_reg\[602\] gen_regfile_ff.register_file_i.rf_reg\[634\]
+ net2012 net1981 _09228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13496_ _09225_ _09226_ _09227_ _09228_ net1878 net1866 _09229_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13497_ gen_regfile_ff.register_file_i.rf_reg\[90\] gen_regfile_ff.register_file_i.rf_reg\[122\]
+ net2012 _09230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13498_ gen_regfile_ff.register_file_i.rf_reg\[58\] net1821
+ _09230_ net1982 net1963 _09231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13499_ gen_regfile_ff.register_file_i.rf_reg\[154\] gen_regfile_ff.register_file_i.rf_reg\[186\]
+ gen_regfile_ff.register_file_i.rf_reg\[218\] gen_regfile_ff.register_file_i.rf_reg\[250\]
+ net2012 net1981 _09232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13500_ net1878 _09232_ net1866 _09233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13501_ gen_regfile_ff.register_file_i.rf_reg\[410\] gen_regfile_ff.register_file_i.rf_reg\[442\]
+ gen_regfile_ff.register_file_i.rf_reg\[474\] gen_regfile_ff.register_file_i.rf_reg\[506\]
+ net2012 net1980 _09234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13502_ gen_regfile_ff.register_file_i.rf_reg\[282\] gen_regfile_ff.register_file_i.rf_reg\[314\]
+ gen_regfile_ff.register_file_i.rf_reg\[346\] gen_regfile_ff.register_file_i.rf_reg\[378\]
+ net2012 net1982 _09235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13503_ _09234_ _09235_ net1878 _09236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13504_ net1959 _09236_ _09237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13505_ _09231_ _09233_ _09237_ net1843 _09238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13506_ net1843 _09229_ _09238_ _09239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13507_ _08192_ ex_block_i.alu_i.imd_val_q_i\[58\] ex_block_i.alu_i.imd_val_q_i\[26\]
+ net1824 _08200_ net1758 _09240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13508_ net2028 net1721 _09240_ _09241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13509_ net2175 net2111 _01320_ _09242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13510_ _08187_ _09241_ _09242_ _00919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13511_ cs_registers_i.pc_id_i\[26\] net1801 _09243_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13512_ id_stage_i.controller_i.lsu_addr_last_i\[26\] net1818
+ _09244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13513_ net1742 net1721 _09243_ net1741 _09244_ _01319_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_13514_ _01319_ _01323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13515_ gen_regfile_ff.register_file_i.rf_reg\[667\] gen_regfile_ff.register_file_i.rf_reg\[699\]
+ gen_regfile_ff.register_file_i.rf_reg\[731\] gen_regfile_ff.register_file_i.rf_reg\[763\]
+ net2112 net1927 _09245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13516_ gen_regfile_ff.register_file_i.rf_reg\[539\] gen_regfile_ff.register_file_i.rf_reg\[571\]
+ gen_regfile_ff.register_file_i.rf_reg\[603\] gen_regfile_ff.register_file_i.rf_reg\[635\]
+ net2112 net1927 _09246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xclkbuf_leaf_8_clk clknet_2_1_0_clk clknet_leaf_8_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13518_ gen_regfile_ff.register_file_i.rf_reg\[923\] gen_regfile_ff.register_file_i.rf_reg\[955\]
+ gen_regfile_ff.register_file_i.rf_reg\[987\] gen_regfile_ff.register_file_i.rf_reg\[1019\]
+ net2112 net1927 _09248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13519_ gen_regfile_ff.register_file_i.rf_reg\[795\] gen_regfile_ff.register_file_i.rf_reg\[827\]
+ gen_regfile_ff.register_file_i.rf_reg\[859\] gen_regfile_ff.register_file_i.rf_reg\[891\]
+ net2112 net1927 _09249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13520_ _09245_ _09246_ _09248_ _09249_ net1847 net1900 _09250_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13521_ gen_regfile_ff.register_file_i.rf_reg\[155\] gen_regfile_ff.register_file_i.rf_reg\[187\]
+ gen_regfile_ff.register_file_i.rf_reg\[219\] gen_regfile_ff.register_file_i.rf_reg\[251\]
+ net1942 net1927 _09251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13522_ gen_regfile_ff.register_file_i.rf_reg\[59\] gen_regfile_ff.register_file_i.rf_reg\[123\]
+ net1927 _09252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13523_ net1927 gen_regfile_ff.register_file_i.rf_reg\[91\]
+ _09253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13524_ _09252_ _09253_ net1853 _09254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13525_ gen_regfile_ff.register_file_i.rf_reg\[411\] gen_regfile_ff.register_file_i.rf_reg\[443\]
+ gen_regfile_ff.register_file_i.rf_reg\[475\] gen_regfile_ff.register_file_i.rf_reg\[507\]
+ net1941 net1927 _09255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13526_ gen_regfile_ff.register_file_i.rf_reg\[283\] gen_regfile_ff.register_file_i.rf_reg\[315\]
+ gen_regfile_ff.register_file_i.rf_reg\[347\] gen_regfile_ff.register_file_i.rf_reg\[379\]
+ net1941 net1927 _09256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13527_ _09251_ _09254_ _09255_ _09256_ net1847 net1900 _09257_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13528_ _09250_ _09257_ net1863 _09258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13529_ net1896 _08547_ _09259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13530_ net2057 _09259_ _09260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13531_ net1757 _09260_ net1795 _01327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13532_ gen_regfile_ff.register_file_i.rf_reg\[667\] gen_regfile_ff.register_file_i.rf_reg\[699\]
+ gen_regfile_ff.register_file_i.rf_reg\[731\] gen_regfile_ff.register_file_i.rf_reg\[763\]
+ net2014 net1985 _09261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13533_ gen_regfile_ff.register_file_i.rf_reg\[539\] gen_regfile_ff.register_file_i.rf_reg\[571\]
+ gen_regfile_ff.register_file_i.rf_reg\[603\] gen_regfile_ff.register_file_i.rf_reg\[635\]
+ net2014 net1985 _09262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13534_ _09261_ _09262_ net1879 _09263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13535_ gen_regfile_ff.register_file_i.rf_reg\[859\] gen_regfile_ff.register_file_i.rf_reg\[891\]
+ gen_regfile_ff.register_file_i.rf_reg\[987\] gen_regfile_ff.register_file_i.rf_reg\[1019\]
+ net2014 net1962 _09264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13536_ gen_regfile_ff.register_file_i.rf_reg\[795\] gen_regfile_ff.register_file_i.rf_reg\[827\]
+ gen_regfile_ff.register_file_i.rf_reg\[923\] gen_regfile_ff.register_file_i.rf_reg\[955\]
+ net2014 net1962 _09265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13537_ _09264_ _09265_ net1875 _09266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13538_ net1822 _09263_ _09266_ _08589_ _09267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13539_ gen_regfile_ff.register_file_i.rf_reg\[155\] gen_regfile_ff.register_file_i.rf_reg\[187\]
+ gen_regfile_ff.register_file_i.rf_reg\[219\] gen_regfile_ff.register_file_i.rf_reg\[251\]
+ net2014 net1987 _09268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13540_ gen_regfile_ff.register_file_i.rf_reg\[91\] gen_regfile_ff.register_file_i.rf_reg\[123\]
+ net2014 _09269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13541_ net2014 gen_regfile_ff.register_file_i.rf_reg\[59\]
+ _09270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13542_ _09269_ _09270_ net1875 _09271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13543_ gen_regfile_ff.register_file_i.rf_reg\[411\] gen_regfile_ff.register_file_i.rf_reg\[443\]
+ gen_regfile_ff.register_file_i.rf_reg\[475\] gen_regfile_ff.register_file_i.rf_reg\[507\]
+ net2014 net1984 _09272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13544_ gen_regfile_ff.register_file_i.rf_reg\[283\] gen_regfile_ff.register_file_i.rf_reg\[315\]
+ gen_regfile_ff.register_file_i.rf_reg\[347\] gen_regfile_ff.register_file_i.rf_reg\[379\]
+ net2014 net1985 _09273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13545_ _09268_ _09271_ _09272_ _09273_ net1877 net1959 _09274_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13546_ net1842 _09274_ _09275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13547_ _09267_ _09275_ _09276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13548_ _08192_ ex_block_i.alu_i.imd_val_q_i\[59\] ex_block_i.alu_i.imd_val_q_i\[27\]
+ net1824 _08200_ net1757 _09277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13549_ net2028 net1720 _09277_ _09278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1543 _06192_ net1542 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13551_ net2175 net2111 _01327_ _09280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13552_ _08187_ _09278_ _09280_ _00923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13553_ cs_registers_i.pc_id_i\[27\] net1801 _09281_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13554_ id_stage_i.controller_i.lsu_addr_last_i\[27\] net1818
+ _09282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13555_ net1742 net1720 _09281_ net1741 _09282_ _01326_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_4
X_13556_ _01326_ _01330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13557_ _00916_ _00920_ _09014_ _09195_ _09283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13558_ _00916_ _00920_ _09195_ _09197_ _09284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13559_ _00921_ _09285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13560_ _00920_ _09286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13561_ _09285_ _09286_ _09287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13562_ _09284_ _09287_ _09288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13563_ _09010_ _09011_ _09283_ _09288_ _09289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_13564_ _00925_ _09289_ net173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_4
X_13565_ net2074 _08920_ _09290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13566_ _08919_ _08921_ _09290_ _09291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13567_ net2074 _08920_ _08502_ _09292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_13568_ _08215_ net2121 _09292_ _08403_ _09293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13569_ _00909_ _00904_ _00908_ _09294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13570_ _00912_ _09295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13571_ _09206_ _09294_ _09295_ _09296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13572_ _00917_ _09296_ _00916_ _09297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13573_ _09285_ _09113_ _09297_ _09298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13574_ _09291_ _09293_ _09298_ _09299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13575_ _09107_ _09197_ _09300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13576_ _09285_ _09291_ _09293_ _09300_ _09301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_13577_ _00917_ _09192_ _09302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13578_ _09285_ _09302_ _09303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13579_ _00921_ _09303_ _09297_ _09304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13580_ _00921_ _09197_ _09305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13581_ _09285_ _09114_ _09297_ _09306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13582_ _09305_ _09306_ net2085 _09307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13583_ _09304_ _09307_ _09308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13584_ _09299_ _09308_ _09301_ _09309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_4
X_13585_ _09309_ net172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13586_ gen_regfile_ff.register_file_i.rf_reg\[668\] gen_regfile_ff.register_file_i.rf_reg\[700\]
+ gen_regfile_ff.register_file_i.rf_reg\[732\] gen_regfile_ff.register_file_i.rf_reg\[764\]
+ net1937 net1923 _09310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13587_ gen_regfile_ff.register_file_i.rf_reg\[540\] gen_regfile_ff.register_file_i.rf_reg\[572\]
+ gen_regfile_ff.register_file_i.rf_reg\[604\] gen_regfile_ff.register_file_i.rf_reg\[636\]
+ net1937 net1923 _09311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13588_ gen_regfile_ff.register_file_i.rf_reg\[924\] gen_regfile_ff.register_file_i.rf_reg\[956\]
+ gen_regfile_ff.register_file_i.rf_reg\[988\] gen_regfile_ff.register_file_i.rf_reg\[1020\]
+ net1937 net1923 _09312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13589_ gen_regfile_ff.register_file_i.rf_reg\[796\] gen_regfile_ff.register_file_i.rf_reg\[828\]
+ gen_regfile_ff.register_file_i.rf_reg\[860\] gen_regfile_ff.register_file_i.rf_reg\[892\]
+ net1937 net1923 _09313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13590_ _09310_ _09311_ _09312_ _09313_ net1851 net1900 _09314_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13591_ gen_regfile_ff.register_file_i.rf_reg\[156\] gen_regfile_ff.register_file_i.rf_reg\[188\]
+ gen_regfile_ff.register_file_i.rf_reg\[220\] gen_regfile_ff.register_file_i.rf_reg\[252\]
+ net1937 net1922 _09315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13592_ gen_regfile_ff.register_file_i.rf_reg\[60\] gen_regfile_ff.register_file_i.rf_reg\[124\]
+ net1922 _09316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13593_ net1922 gen_regfile_ff.register_file_i.rf_reg\[92\]
+ _09317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13594_ _09316_ _09317_ net1854 _09318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13595_ gen_regfile_ff.register_file_i.rf_reg\[412\] gen_regfile_ff.register_file_i.rf_reg\[444\]
+ gen_regfile_ff.register_file_i.rf_reg\[476\] gen_regfile_ff.register_file_i.rf_reg\[508\]
+ net1937 net1923 _09319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13596_ gen_regfile_ff.register_file_i.rf_reg\[284\] gen_regfile_ff.register_file_i.rf_reg\[316\]
+ gen_regfile_ff.register_file_i.rf_reg\[348\] gen_regfile_ff.register_file_i.rf_reg\[380\]
+ net2112 net1922 _09320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13597_ _09315_ _09318_ _09319_ _09320_ net1851 net1900 _09321_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13598_ _09314_ _09321_ net1860 _09322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_13599_ _07905_ net2054 net2057 _09323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13600_ net1756 _09323_ net1795 _01334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13601_ gen_regfile_ff.register_file_i.rf_reg\[412\] gen_regfile_ff.register_file_i.rf_reg\[444\]
+ gen_regfile_ff.register_file_i.rf_reg\[476\] gen_regfile_ff.register_file_i.rf_reg\[508\]
+ net2010 net1978 _09324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13602_ gen_regfile_ff.register_file_i.rf_reg\[284\] gen_regfile_ff.register_file_i.rf_reg\[316\]
+ gen_regfile_ff.register_file_i.rf_reg\[348\] gen_regfile_ff.register_file_i.rf_reg\[380\]
+ net2193 net1978 _09325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13603_ gen_regfile_ff.register_file_i.rf_reg\[156\] gen_regfile_ff.register_file_i.rf_reg\[188\]
+ gen_regfile_ff.register_file_i.rf_reg\[220\] gen_regfile_ff.register_file_i.rf_reg\[252\]
+ net2010 net1978 _09326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13604_ gen_regfile_ff.register_file_i.rf_reg\[92\] gen_regfile_ff.register_file_i.rf_reg\[124\]
+ net2193 _09327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13605_ net2010 gen_regfile_ff.register_file_i.rf_reg\[60\]
+ _09328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13606_ _09327_ _09328_ net1868 _09329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13607_ _09324_ _09325_ _09326_ _09329_ net1878 net1866 _09330_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13608_ net1958 _09330_ _09331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13609_ gen_regfile_ff.register_file_i.rf_reg\[924\] gen_regfile_ff.register_file_i.rf_reg\[956\]
+ gen_regfile_ff.register_file_i.rf_reg\[988\] gen_regfile_ff.register_file_i.rf_reg\[1020\]
+ net2010 net1978 _09332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13610_ gen_regfile_ff.register_file_i.rf_reg\[796\] gen_regfile_ff.register_file_i.rf_reg\[828\]
+ gen_regfile_ff.register_file_i.rf_reg\[860\] gen_regfile_ff.register_file_i.rf_reg\[892\]
+ net2010 net1978 _09333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13611_ _09332_ _09333_ net1878 _09334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13612_ net1876 _09334_ _09335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13613_ gen_regfile_ff.register_file_i.rf_reg\[668\] gen_regfile_ff.register_file_i.rf_reg\[700\]
+ gen_regfile_ff.register_file_i.rf_reg\[732\] gen_regfile_ff.register_file_i.rf_reg\[764\]
+ net2010 net1978 _09336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13614_ gen_regfile_ff.register_file_i.rf_reg\[540\] gen_regfile_ff.register_file_i.rf_reg\[572\]
+ gen_regfile_ff.register_file_i.rf_reg\[604\] gen_regfile_ff.register_file_i.rf_reg\[636\]
+ net2010 net1978 _09337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13615_ _09336_ _09337_ net1878 _09338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13616_ net1832 _09338_ _09339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13617_ _09331_ _09335_ _09339_ _09340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13618_ _08192_ ex_block_i.alu_i.imd_val_q_i\[60\] ex_block_i.alu_i.imd_val_q_i\[28\]
+ net1824 _08200_ net1756 _09341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_13619_ net2028 _09340_ _09341_ _09342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13620_ net2175 net2111 _01334_ _09343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13621_ _08187_ _09342_ _09343_ _00927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13622_ cs_registers_i.pc_id_i\[28\] net1801 _09344_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13623_ id_stage_i.controller_i.lsu_addr_last_i\[28\] net1818
+ _09345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13624_ net1742 _09340_ _09344_ net1741 _09345_ _01333_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13625_ net1676 _01337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13626_ gen_regfile_ff.register_file_i.rf_reg\[669\] gen_regfile_ff.register_file_i.rf_reg\[701\]
+ gen_regfile_ff.register_file_i.rf_reg\[733\] gen_regfile_ff.register_file_i.rf_reg\[765\]
+ net1943 net1926 _09346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13627_ gen_regfile_ff.register_file_i.rf_reg\[541\] gen_regfile_ff.register_file_i.rf_reg\[573\]
+ gen_regfile_ff.register_file_i.rf_reg\[605\] gen_regfile_ff.register_file_i.rf_reg\[637\]
+ net1943 net1926 _09347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13628_ gen_regfile_ff.register_file_i.rf_reg\[925\] gen_regfile_ff.register_file_i.rf_reg\[957\]
+ gen_regfile_ff.register_file_i.rf_reg\[989\] gen_regfile_ff.register_file_i.rf_reg\[1021\]
+ net2182 net1926 _09348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13629_ gen_regfile_ff.register_file_i.rf_reg\[797\] gen_regfile_ff.register_file_i.rf_reg\[829\]
+ gen_regfile_ff.register_file_i.rf_reg\[861\] gen_regfile_ff.register_file_i.rf_reg\[893\]
+ net1943 net1926 _09349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13630_ _09346_ _09347_ _09348_ _09349_ net1851 net1900 _09350_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13631_ gen_regfile_ff.register_file_i.rf_reg\[157\] gen_regfile_ff.register_file_i.rf_reg\[189\]
+ gen_regfile_ff.register_file_i.rf_reg\[221\] gen_regfile_ff.register_file_i.rf_reg\[253\]
+ net1943 net1925 _09351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13632_ gen_regfile_ff.register_file_i.rf_reg\[61\] gen_regfile_ff.register_file_i.rf_reg\[125\]
+ net1925 _09352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13633_ net1925 gen_regfile_ff.register_file_i.rf_reg\[93\]
+ _09353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13634_ _09352_ _09353_ net1853 _09354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13635_ gen_regfile_ff.register_file_i.rf_reg\[413\] gen_regfile_ff.register_file_i.rf_reg\[445\]
+ gen_regfile_ff.register_file_i.rf_reg\[477\] gen_regfile_ff.register_file_i.rf_reg\[509\]
+ net2182 net1926 _09355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13636_ gen_regfile_ff.register_file_i.rf_reg\[285\] gen_regfile_ff.register_file_i.rf_reg\[317\]
+ gen_regfile_ff.register_file_i.rf_reg\[349\] gen_regfile_ff.register_file_i.rf_reg\[381\]
+ net1943 net1925 _09356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13637_ _09351_ _09354_ _09355_ _09356_ net1851 net1900 _09357_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13638_ _09350_ _09357_ net1860 _09358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1542 _06893_ net1541 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13640_ _07926_ net2054 net2057 _09360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13641_ net1755 _09360_ net1795 _01341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13642_ _01341_ _01345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13643_ gen_regfile_ff.register_file_i.rf_reg\[413\] gen_regfile_ff.register_file_i.rf_reg\[445\]
+ gen_regfile_ff.register_file_i.rf_reg\[477\] gen_regfile_ff.register_file_i.rf_reg\[509\]
+ net2016 net1981 _09361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13644_ gen_regfile_ff.register_file_i.rf_reg\[285\] gen_regfile_ff.register_file_i.rf_reg\[317\]
+ gen_regfile_ff.register_file_i.rf_reg\[349\] gen_regfile_ff.register_file_i.rf_reg\[381\]
+ net2016 net1981 _09362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13645_ gen_regfile_ff.register_file_i.rf_reg\[157\] gen_regfile_ff.register_file_i.rf_reg\[189\]
+ gen_regfile_ff.register_file_i.rf_reg\[221\] gen_regfile_ff.register_file_i.rf_reg\[253\]
+ net2016 net1981 _09363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13646_ gen_regfile_ff.register_file_i.rf_reg\[93\] gen_regfile_ff.register_file_i.rf_reg\[125\]
+ net2016 _09364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13647_ net2016 gen_regfile_ff.register_file_i.rf_reg\[61\]
+ _09365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13648_ _09364_ _09365_ net1875 _09366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13649_ _09361_ _09362_ _09363_ _09366_ net1878 net1866 _09367_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13650_ gen_regfile_ff.register_file_i.rf_reg\[925\] gen_regfile_ff.register_file_i.rf_reg\[957\]
+ gen_regfile_ff.register_file_i.rf_reg\[989\] gen_regfile_ff.register_file_i.rf_reg\[1021\]
+ net2016 net1981 _09368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13651_ gen_regfile_ff.register_file_i.rf_reg\[797\] gen_regfile_ff.register_file_i.rf_reg\[829\]
+ gen_regfile_ff.register_file_i.rf_reg\[861\] gen_regfile_ff.register_file_i.rf_reg\[893\]
+ net2016 net1981 _09369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13652_ gen_regfile_ff.register_file_i.rf_reg\[669\] gen_regfile_ff.register_file_i.rf_reg\[701\]
+ gen_regfile_ff.register_file_i.rf_reg\[733\] gen_regfile_ff.register_file_i.rf_reg\[765\]
+ net2016 net1981 _09370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13653_ gen_regfile_ff.register_file_i.rf_reg\[541\] gen_regfile_ff.register_file_i.rf_reg\[573\]
+ gen_regfile_ff.register_file_i.rf_reg\[605\] gen_regfile_ff.register_file_i.rf_reg\[637\]
+ net2016 net1981 _09371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13654_ _09368_ _09369_ _09370_ _09371_ net1878 net1866 _09372_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13655_ net1843 _09372_ _09373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13656_ net1958 _09367_ _09373_ _09374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13657_ cs_registers_i.pc_id_i\[29\] net1801 _09375_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13658_ id_stage_i.controller_i.lsu_addr_last_i\[29\] net1818
+ _09376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13659_ net1742 net1754 _09375_ net1741 _09376_ _01340_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13660_ net1675 _01344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13661_ _00925_ _09377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13662_ _00929_ _09378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13663_ _00929_ _00924_ _00928_ _09379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13664_ _09377_ _09378_ _09289_ _09379_ _09380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13665_ _00933_ _09380_ net175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_4
X_13666_ _08919_ _08921_ _09107_ _09381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13667_ _09115_ _09113_ _09382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13668_ net2123 _09381_ _09382_ _09383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13669_ _09297_ _09384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13670_ _09197_ _09383_ _09384_ _09385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13671_ _09285_ _09377_ _00929_ _09386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13672_ _00925_ _09287_ _09387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13673_ _00924_ _09387_ _09388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13674_ _00925_ _00920_ _00924_ _09389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13675_ _09388_ _09389_ _09378_ _09390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13676_ _09378_ _00920_ _00924_ _09391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13677_ _09302_ _09117_ _09297_ _09391_ _09392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13678_ _09386_ _09385_ _09390_ _09392_ net174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13679_ gen_regfile_ff.register_file_i.rf_reg\[670\] gen_regfile_ff.register_file_i.rf_reg\[702\]
+ gen_regfile_ff.register_file_i.rf_reg\[734\] gen_regfile_ff.register_file_i.rf_reg\[766\]
+ net1943 net1928 _09393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13680_ gen_regfile_ff.register_file_i.rf_reg\[542\] gen_regfile_ff.register_file_i.rf_reg\[574\]
+ gen_regfile_ff.register_file_i.rf_reg\[606\] gen_regfile_ff.register_file_i.rf_reg\[638\]
+ net1943 net1928 _09394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13681_ gen_regfile_ff.register_file_i.rf_reg\[926\] gen_regfile_ff.register_file_i.rf_reg\[958\]
+ gen_regfile_ff.register_file_i.rf_reg\[990\] gen_regfile_ff.register_file_i.rf_reg\[1022\]
+ net1943 net1928 _09395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13682_ gen_regfile_ff.register_file_i.rf_reg\[798\] gen_regfile_ff.register_file_i.rf_reg\[830\]
+ gen_regfile_ff.register_file_i.rf_reg\[862\] gen_regfile_ff.register_file_i.rf_reg\[894\]
+ net1943 net1928 _09396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13683_ _09393_ _09394_ _09395_ _09396_ net1847 net1900 _09397_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13684_ gen_regfile_ff.register_file_i.rf_reg\[158\] gen_regfile_ff.register_file_i.rf_reg\[190\]
+ gen_regfile_ff.register_file_i.rf_reg\[222\] gen_regfile_ff.register_file_i.rf_reg\[254\]
+ net1943 net1929 _09398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13685_ gen_regfile_ff.register_file_i.rf_reg\[62\] gen_regfile_ff.register_file_i.rf_reg\[126\]
+ net1929 _09399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13686_ net1929 gen_regfile_ff.register_file_i.rf_reg\[94\]
+ _09400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13687_ _09399_ _09400_ net1853 _09401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13688_ gen_regfile_ff.register_file_i.rf_reg\[414\] gen_regfile_ff.register_file_i.rf_reg\[446\]
+ gen_regfile_ff.register_file_i.rf_reg\[478\] gen_regfile_ff.register_file_i.rf_reg\[510\]
+ net1942 net1929 _09402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13689_ gen_regfile_ff.register_file_i.rf_reg\[286\] gen_regfile_ff.register_file_i.rf_reg\[318\]
+ gen_regfile_ff.register_file_i.rf_reg\[350\] gen_regfile_ff.register_file_i.rf_reg\[382\]
+ net1943 net1929 _09403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13690_ _09398_ _09401_ _09402_ _09403_ net1847 net1900 _09404_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13691_ _09397_ _09404_ net1860 _09405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1541 _00011_ net1540 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_13693_ net1845 net2054 net2056 _09407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13694_ net1753 _09407_ net1795 _01348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13695_ _01348_ _01352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13696_ gen_regfile_ff.register_file_i.rf_reg\[414\] gen_regfile_ff.register_file_i.rf_reg\[446\]
+ gen_regfile_ff.register_file_i.rf_reg\[478\] gen_regfile_ff.register_file_i.rf_reg\[510\]
+ net2016 net1987 _09408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13697_ gen_regfile_ff.register_file_i.rf_reg\[286\] gen_regfile_ff.register_file_i.rf_reg\[318\]
+ gen_regfile_ff.register_file_i.rf_reg\[350\] gen_regfile_ff.register_file_i.rf_reg\[382\]
+ net2016 net1987 _09409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13698_ gen_regfile_ff.register_file_i.rf_reg\[158\] gen_regfile_ff.register_file_i.rf_reg\[190\]
+ gen_regfile_ff.register_file_i.rf_reg\[222\] gen_regfile_ff.register_file_i.rf_reg\[254\]
+ net2016 net1987 _09410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13699_ gen_regfile_ff.register_file_i.rf_reg\[94\] gen_regfile_ff.register_file_i.rf_reg\[126\]
+ net2016 _09411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13700_ net2016 gen_regfile_ff.register_file_i.rf_reg\[62\]
+ _09412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13701_ _09411_ _09412_ net1875 _09413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13702_ _09408_ _09409_ _09410_ _09413_ net1877 net1866 _09414_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13703_ gen_regfile_ff.register_file_i.rf_reg\[926\] gen_regfile_ff.register_file_i.rf_reg\[958\]
+ gen_regfile_ff.register_file_i.rf_reg\[990\] gen_regfile_ff.register_file_i.rf_reg\[1022\]
+ net2016 net1987 _09415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13704_ gen_regfile_ff.register_file_i.rf_reg\[798\] gen_regfile_ff.register_file_i.rf_reg\[830\]
+ gen_regfile_ff.register_file_i.rf_reg\[862\] gen_regfile_ff.register_file_i.rf_reg\[894\]
+ net2016 net1987 _09416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13705_ gen_regfile_ff.register_file_i.rf_reg\[670\] gen_regfile_ff.register_file_i.rf_reg\[702\]
+ gen_regfile_ff.register_file_i.rf_reg\[734\] gen_regfile_ff.register_file_i.rf_reg\[766\]
+ net2016 net1987 _09417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13706_ gen_regfile_ff.register_file_i.rf_reg\[542\] gen_regfile_ff.register_file_i.rf_reg\[574\]
+ gen_regfile_ff.register_file_i.rf_reg\[606\] gen_regfile_ff.register_file_i.rf_reg\[638\]
+ net2016 net1987 _09418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13707_ _09415_ _09416_ _09417_ _09418_ net1877 net1866 _09419_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13708_ net1842 _09419_ _09420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13709_ net1958 _09414_ _09420_ _09421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13710_ cs_registers_i.pc_id_i\[30\] net1801 _09422_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13711_ id_stage_i.controller_i.lsu_addr_last_i\[30\] net1818
+ _09423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13712_ net1742 net1752 _09422_ net1741 _09423_ _01347_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13713_ _01347_ _01351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13714_ gen_regfile_ff.register_file_i.rf_reg\[927\] gen_regfile_ff.register_file_i.rf_reg\[959\]
+ gen_regfile_ff.register_file_i.rf_reg\[991\] gen_regfile_ff.register_file_i.rf_reg\[1023\]
+ net2140 net1914 _09424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13715_ gen_regfile_ff.register_file_i.rf_reg\[799\] gen_regfile_ff.register_file_i.rf_reg\[831\]
+ gen_regfile_ff.register_file_i.rf_reg\[863\] gen_regfile_ff.register_file_i.rf_reg\[895\]
+ net2139 net1914 _09425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13716_ _09424_ _09425_ net1847 _09426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13717_ gen_regfile_ff.register_file_i.rf_reg\[575\] gen_regfile_ff.register_file_i.rf_reg\[639\]
+ gen_regfile_ff.register_file_i.rf_reg\[703\] gen_regfile_ff.register_file_i.rf_reg\[767\]
+ net1914 net1904 _09427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13718_ gen_regfile_ff.register_file_i.rf_reg\[543\] gen_regfile_ff.register_file_i.rf_reg\[607\]
+ gen_regfile_ff.register_file_i.rf_reg\[671\] gen_regfile_ff.register_file_i.rf_reg\[735\]
+ net1914 net1904 _09428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13719_ _09427_ _09428_ net1857 _09429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13720_ _09426_ _09429_ net1859 _09430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13721_ net1899 _09430_ _09431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13722_ gen_regfile_ff.register_file_i.rf_reg\[63\] gen_regfile_ff.register_file_i.rf_reg\[127\]
+ net1914 _09432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13723_ gen_regfile_ff.register_file_i.rf_reg\[95\] net1828
+ _09432_ net1936 net1904 _09433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13724_ gen_regfile_ff.register_file_i.rf_reg\[159\] gen_regfile_ff.register_file_i.rf_reg\[223\]
+ net1914 _09434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13725_ net1936 net1848 _09434_ _09435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13726_ gen_regfile_ff.register_file_i.rf_reg\[191\] gen_regfile_ff.register_file_i.rf_reg\[255\]
+ net1914 _09436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13727_ _07840_ _09436_ _09437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13728_ _07684_ _09433_ _09435_ _09437_ _09438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13729_ gen_regfile_ff.register_file_i.rf_reg\[415\] gen_regfile_ff.register_file_i.rf_reg\[447\]
+ gen_regfile_ff.register_file_i.rf_reg\[479\] gen_regfile_ff.register_file_i.rf_reg\[511\]
+ net1935 net1914 _09439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13730_ gen_regfile_ff.register_file_i.rf_reg\[287\] gen_regfile_ff.register_file_i.rf_reg\[319\]
+ gen_regfile_ff.register_file_i.rf_reg\[351\] gen_regfile_ff.register_file_i.rf_reg\[383\]
+ net1935 net1914 _09440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13731_ _09439_ _09440_ net1848 _09441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13732_ _07846_ _09441_ _09442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13733_ _09431_ _09438_ _09442_ _09443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13734_ _07706_ _07714_ net2061 _09444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13735_ net1891 net1795 _09445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13736_ _09444_ _09445_ _09446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13737_ net1797 net1719 _09446_ _00943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13738_ _00943_ _00939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13739_ gen_regfile_ff.register_file_i.rf_reg\[671\] gen_regfile_ff.register_file_i.rf_reg\[703\]
+ gen_regfile_ff.register_file_i.rf_reg\[735\] gen_regfile_ff.register_file_i.rf_reg\[767\]
+ net2006 net1975 _09447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13740_ gen_regfile_ff.register_file_i.rf_reg\[543\] gen_regfile_ff.register_file_i.rf_reg\[575\]
+ gen_regfile_ff.register_file_i.rf_reg\[607\] gen_regfile_ff.register_file_i.rf_reg\[639\]
+ net2006 net1975 _09448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13741_ _09447_ _09448_ net1881 _09449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13742_ net1832 _09449_ _09450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13743_ gen_regfile_ff.register_file_i.rf_reg\[927\] gen_regfile_ff.register_file_i.rf_reg\[959\]
+ gen_regfile_ff.register_file_i.rf_reg\[991\] gen_regfile_ff.register_file_i.rf_reg\[1023\]
+ net2006 net1975 _09451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13744_ gen_regfile_ff.register_file_i.rf_reg\[799\] gen_regfile_ff.register_file_i.rf_reg\[831\]
+ gen_regfile_ff.register_file_i.rf_reg\[863\] gen_regfile_ff.register_file_i.rf_reg\[895\]
+ net2006 net1975 _09452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13745_ _09451_ _09452_ net1881 _09453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13746_ _07523_ _09453_ _09454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13747_ gen_regfile_ff.register_file_i.rf_reg\[351\] gen_regfile_ff.register_file_i.rf_reg\[383\]
+ gen_regfile_ff.register_file_i.rf_reg\[479\] gen_regfile_ff.register_file_i.rf_reg\[511\]
+ net2005 net1962 _09455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13748_ gen_regfile_ff.register_file_i.rf_reg\[95\] gen_regfile_ff.register_file_i.rf_reg\[127\]
+ gen_regfile_ff.register_file_i.rf_reg\[223\] gen_regfile_ff.register_file_i.rf_reg\[255\]
+ net2008 net1962 _09456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13749_ _09455_ _09456_ net1866 _09457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13750_ net1958 net1868 _09457_ _09458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13751_ net1975 _09455_ _09459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13752_ gen_regfile_ff.register_file_i.rf_reg\[287\] gen_regfile_ff.register_file_i.rf_reg\[319\]
+ gen_regfile_ff.register_file_i.rf_reg\[415\] gen_regfile_ff.register_file_i.rf_reg\[447\]
+ net2007 net1962 _09460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_13753_ net1958 net1866 _09459_ _09460_ _09461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13754_ gen_regfile_ff.register_file_i.rf_reg\[159\] gen_regfile_ff.register_file_i.rf_reg\[191\]
+ net2005 _09462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13755_ net2008 gen_regfile_ff.register_file_i.rf_reg\[63\]
+ _09463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13756_ _09462_ _09463_ net1877 _09464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13757_ net1958 net1959 net1975 _09464_ _09465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13758_ _09461_ _09465_ _09466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13759_ _09450_ _09454_ _09458_ _09466_ _09467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13760_ cs_registers_i.pc_id_i\[31\] net1801 _09468_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13761_ id_stage_i.controller_i.lsu_addr_last_i\[31\] net1818
+ net2100 _09468_ _09469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13762_ net2127 _09467_ _09469_ _00938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13763_ _00938_ _09470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkbuf_leaf_9_clk clknet_2_1_0_clk clknet_leaf_9_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13765_ _09431_ _09438_ _09442_ _09471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13766_ _08192_ ex_block_i.alu_i.imd_val_q_i\[63\] ex_block_i.alu_i.imd_val_q_i\[31\]
+ net1824 _09472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_13767_ _08228_ _09471_ _09467_ net2028 _09472_ _09473_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13768_ net2175 _00939_ _09473_ _09474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13769_ ex_block_i.alu_i.imd_val_q_i\[63\] net1823 _09475_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13770_ _09474_ _09475_ _09476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13771_ _09379_ _09477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13772_ _00933_ _09477_ _09478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13773_ _00932_ _09478_ _09479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13774_ _00937_ _09479_ _00936_ _09480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13775_ _00925_ _00929_ _00933_ _00937_ _09481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_13776_ _09289_ _09481_ _09482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_13777_ net2175 _00939_ _09470_ _09483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_13778_ net1815 _09483_ _09484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13779_ net1815 _09476_ _09482_ _09480_ _09484_ _09485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_13780_ _09474_ _09475_ _09486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_13781_ _09481_ _09289_ _09480_ _09487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13782_ net1783 _09483_ _09488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13783_ net1815 _09486_ _09488_ _09487_ _09489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13784_ _09485_ _09489_ net178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_13785_ _00921_ _00925_ _00929_ _00933_ _09490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_13786_ _09285_ _09297_ _09286_ _09491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13787_ _00925_ _09491_ _00924_ _09492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13788_ _00928_ _09493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13789_ _09378_ _09492_ _09493_ _09494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13790_ _00933_ _09494_ _00932_ _09495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13791_ _09302_ _09117_ _09490_ _09495_ _09496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13792_ _09496_ _00937_ net177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_13793_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09497_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13794_ id_stage_i.controller_i.ctrl_fsm_cs\[3\] _09498_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13795_ _09497_ id_stage_i.controller_i.ctrl_fsm_cs\[1\]
+ _09498_ id_stage_i.controller_i.ctrl_fsm_cs\[2\] _09499_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13796_ _09499_ _09500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13797_ _08143_ _08145_ _09501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13798_ _08156_ _08164_ _08168_ _09501_ _09502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13799_ _08121_ _08209_ _08123_ _09503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13800_ net2147 id_stage_i.controller_i.instr_i\[13\] _07579_
+ _09504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13801_ _07566_ id_stage_i.controller_i.instr_i\[14\] _09505_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13802_ _09504_ _09505_ id_stage_i.controller_i.instr_i\[5\]
+ _09506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13803_ net2147 _08000_ _08150_ _09507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13804_ _07586_ _07615_ _09508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13805_ _09506_ _09507_ net1889 _09508_ _09509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_13806_ _07568_ _08122_ net2132 _09510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13807_ _07560_ _07590_ _08047_ _07588_ _09511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_13808_ _07559_ net1831 _09512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13809_ id_stage_i.decoder_i.illegal_c_insn_i _07582_ _09513_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13810_ _07565_ _09510_ _09511_ _09512_ _09513_ _09514_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13811_ _09502_ _09503_ _09509_ _09514_ _09515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_13812_ _08158_ net1826 _09516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13813_ id_stage_i.controller_i.instr_i\[14\] gen_regfile_ff.register_file_i.waddr_a_i\[4\]
+ _09517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13814_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] gen_regfile_ff.register_file_i.waddr_a_i\[3\]
+ _09518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13815_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] _09519_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13816_ _07968_ _09519_ _09520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13817_ _08004_ _09517_ _09518_ _09520_ _09521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13818_ _09516_ _09521_ _09522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13819_ net1908 net1903 net1892 _09523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13820_ net1827 _08167_ _09523_ _09524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13821_ net1899 net1898 net1891 _09525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13822_ net1908 _08180_ _09525_ _09526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13823_ net1858 net1895 _09527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13824_ net1894 _07840_ _09526_ _09527_ _09528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13825_ _07860_ _08546_ _09529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13826_ net1899 net1898 net1896 net1892 _09530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13827_ net1899 net1898 net1896 net1892 _09531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_13828_ _09530_ _09531_ _09532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13829_ net1900 _07926_ _07905_ _09533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13830_ net1855 net1908 net1848 _09534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13831_ _09529_ _09532_ _09533_ _09534_ _09535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13832_ _09516_ _09524_ _09528_ _09535_ _09536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13833_ _09522_ _09536_ _09537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13834_ _09515_ _09537_ _09538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13835_ _09538_ _09539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13836_ _08043_ _09539_ id_stage_i.controller_i.instr_valid_i
+ _09540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13837_ _08043_ _09515_ _09537_ _09541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xclkbuf_leaf_10_clk clknet_2_1_0_clk clknet_leaf_10_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13839_ net1699 net1698 net1697 _09541_ _09543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13840_ _07708_ _07716_ _07741_ net1701 _09544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13841_ net2068 net1610 _09545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13842_ _07859_ _01180_ _09541_ _09546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13843_ _09543_ _09544_ _09545_ _09546_ _09547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13844_ net1896 _07860_ _09548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13845_ _07893_ _07897_ _07903_ _09549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13846_ net1795 net1790 _09549_ _09550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13847_ net1797 _07861_ _09548_ _09550_ _09551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13848_ net1700 _09551_ _09552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13849_ net1699 net1698 _01212_ _09553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13850_ net1701 net1696 _09541_ _09554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13851_ _09541_ _09552_ _09553_ _09554_ _09555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13852_ _07710_ _07768_ _07769_ _09556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13853_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] net2061
+ net2067 _09557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13854_ _09556_ _09557_ _01159_ _09541_ _09558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13855_ _09547_ _09555_ _09558_ _09559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13856_ id_stage_i.controller_i.instr_is_compressed_i _07697_
+ _07699_ _09560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13857_ net1908 _07706_ _09561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13858_ _09560_ _09561_ _07775_ _09562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13859_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] net2061
+ _07710_ net2067 _09563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_13860_ net1855 _07968_ net2069 _09564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13861_ net2061 _07655_ _09565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13862_ net1798 net2185 net1797 _09566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13863_ _09564_ _09565_ _09566_ _09567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13864_ _09562_ _09563_ _09567_ _09568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_13865_ net1612 _07708_ _07716_ _07741_ _09569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13866_ _09568_ _09569_ _07859_ _09570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13867_ net1699 _09541_ _09571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13868_ _08162_ _09572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13869_ net1797 _07861_ _09572_ _09573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13870_ net1790 net1788 net1797 _09574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13871_ _09573_ _09574_ _09575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13872_ net1698 _01212_ _09576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13873_ net1696 _09571_ _09575_ _09576_ _09577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13874_ net1702 _09541_ _09578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13875_ _07773_ _09578_ _09579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13876_ net1701 _09570_ _09577_ _09579_ _09580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_13877_ net1611 _09568_ _09578_ _09581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13878_ net2068 _09553_ _09546_ _09554_ _09582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13879_ _09558_ _09581_ _09582_ _09583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13880_ _09559_ _09580_ _09583_ _09584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13881_ net1831 net1826 _09585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13882_ _09502_ _09503_ _09509_ _09514_ _09586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13883_ _09522_ _09536_ _09587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13884_ _09585_ _09586_ _09587_ _09588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13885_ net1797 net2185 _09589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13886_ _09562_ _09563_ _09589_ net1612 _09590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13887_ net1702 net1701 _09591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13888_ _07773_ _09590_ _09591_ _09592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13889_ net1702 net1701 _07859_ _09593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13890_ _09588_ _09593_ _09594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13891_ _09562_ _09563_ _09567_ _09541_ _09595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_13892_ net1611 _09569_ net1608 _09596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13893_ _07859_ _09588_ _09592_ _09594_ _09596_ _09597_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_13894_ _09562_ _09563_ _09567_ _09598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_13895_ net1702 _09541_ _09599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13896_ _07773_ _09598_ _09599_ _09600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13897_ net1701 _09588_ _09601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13898_ net1797 _07861_ _09572_ _09574_ _09602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_13899_ net1700 _09602_ _09603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13900_ net1610 _09601_ _09603_ _09604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13901_ net1698 net1697 _09571_ _09605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13902_ _07770_ _07771_ _09606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13903_ _09606_ net1702 _01212_ _09588_ _09607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_13904_ net1698 _09571_ _09608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13905_ net1696 _09552_ _09601_ _09609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13906_ _09600_ _09604_ _09605_ _09607_ _09608_ _09609_ _09610_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_4
X_13907_ net1797 _07861_ _09548_ _09611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13908_ _09550_ _09611_ _09612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13909_ _07773_ _09598_ _09544_ _09578_ _09613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13910_ _07859_ net1610 _09541_ _09553_ _09614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_13911_ _09612_ _09602_ _09613_ _09614_ _09615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13912_ _09577_ _09597_ _09610_ _09615_ _09616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13913_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _09617_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13914_ _09498_ id_stage_i.controller_i.ctrl_fsm_cs\[2\]
+ _09618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13915_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09617_
+ _09618_ _09619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13916_ _07642_ id_stage_i.controller_i.instr_fetch_err_i
+ _09620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13917_ _09619_ _09620_ _09621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13918_ _00952_ _09621_ _09622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13919_ _01212_ net1696 _09585_ _09622_ _09623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_13920_ _09538_ _09623_ _09624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13921_ _09585_ _09586_ _09587_ _09625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13922_ _07773_ net1702 _09625_ _09626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13923_ _08043_ _09515_ _09537_ _09627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13924_ net1699 net1698 net1697 _09627_ _09628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_13925_ net1700 _09627_ _09551_ _09629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13926_ net1701 net1610 _09630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13927_ _09628_ _09629_ _09630_ _09631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13928_ _00958_ _09632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13929_ _00956_ _09632_ _00955_ _09633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13930_ _00956_ _00959_ _09634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13931_ _09633_ _09634_ _09635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13932_ cs_registers_i.debug_mode_i _09626_ _09631_ _09635_
+ _09636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_13933_ _09584_ _09616_ _09624_ _09636_ _09637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13934_ _07860_ _08546_ _09530_ _09638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_13935_ _09533_ _09534_ _09638_ _09639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13936_ cs_registers_i.priv_mode_id_o\[1\] cs_registers_i.priv_mode_id_o\[0\]
+ _09640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13937_ _09528_ _09641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13938_ _08180_ _09525_ _09533_ _09534_ _09642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_13939_ cs_registers_i.csr_mstatus_tw_o _09641_ _09642_ _09643_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13940_ cs_registers_i.debug_mode_i _09639_ _09640_ _09643_
+ _09644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_13941_ _07595_ _07574_ _09645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13942_ id_stage_i.controller_i.instr_valid_i _09645_ net1826
+ _09646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13943_ _09644_ _09646_ _09647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13944_ _09540_ _09637_ _09647_ _09648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13945_ _09500_ _09648_ id_stage_i.controller_i.illegal_insn_d
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13946_ net1827 _08167_ _09523_ _09649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13947_ id_stage_i.controller_i.instr_valid_i id_stage_i.controller_i.instr_fetch_err_i
+ _09650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13948_ _09649_ _09646_ net1840 _09651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_13949_ _09540_ _09637_ _09647_ _09651_ _09652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_13950_ _09500_ _09652_ id_stage_i.controller_i.exc_req_d
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13951_ _07553_ _07550_ _09653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13952_ net64 _09653_ _09654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13953_ net30 _09655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13954_ load_store_unit_i.lsu_err_q _09656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13955_ _09655_ _09656_ _09657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13956_ _09654_ _09657_ _09658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13957_ load_store_unit_i.data_we_q _09658_ id_stage_i.controller_i.store_err_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13958_ load_store_unit_i.data_we_q _09654_ _09657_ id_stage_i.controller_i.load_err_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xclkbuf_leaf_11_clk clknet_2_1_0_clk clknet_leaf_11_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13960_ net1831 _08182_ _09660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkbuf_leaf_12_clk clknet_2_1_0_clk clknet_leaf_12_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13962_ net1751 _09662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13963_ net2032 _09662_ _09663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13964_ net2030 _09663_ _09664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13965_ _07579_ net1897 net1783 _09665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xclkbuf_leaf_13_clk clknet_2_1_0_clk clknet_leaf_13_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_14_clk clknet_2_1_0_clk clknet_leaf_14_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13968_ net2019 _07860_ net1815 _09668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xclkbuf_leaf_15_clk clknet_2_1_0_clk clknet_leaf_15_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13970_ net2031 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ net1823 _09670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_13971_ _09450_ _09454_ _09458_ _09466_ _09671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_13972_ net2021 _08047_ _09672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13973_ _07596_ _08182_ _09672_ _09673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13974_ net1717 _09673_ _09674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13975_ _07579_ net1825 _09675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13976_ net2020 _07860_ _09675_ _09676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13977_ net2020 net1825 _09676_ net2022 _08108_ _09677_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_13978_ net2019 net1825 _09677_ _09678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xclkbuf_leaf_16_clk clknet_2_3_0_clk clknet_leaf_16_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13980_ net1674 net1673 _09680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_13981_ net2022 _07579_ _07640_ _09681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13982_ _08182_ _09681_ _09443_ _09682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_13983_ net1674 _09680_ net1672 _09683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13984_ net1674 net1673 _09683_ ex_block_i.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ net2031 _09684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_13985_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _09670_ _09684_ _09685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_13986_ _09539_ _09621_ _09686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_13987_ net1750 _09685_ _08187_ _09686_ _09687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_13988_ net1718 net1549 _09688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_13989_ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _09664_ _09688_ _00000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_13990_ net2032 net1751 _09689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkbuf_leaf_17_clk clknet_2_3_0_clk clknet_leaf_17_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13992_ net2030 net1716 _09688_ _00001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1540 alu_adder_result_ex\[1\] net1539 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkbuf_leaf_18_clk clknet_2_3_0_clk clknet_leaf_18_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_19_clk clknet_2_3_0_clk clknet_leaf_19_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_20_clk clknet_2_3_0_clk clknet_leaf_20_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_13997_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _09695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_13998_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\] _09696_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_13999_ _09695_ _00968_ _09696_ _09697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14000_ net2027 _09697_ _09698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14001_ _09686_ _09699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14002_ _09699_ net1750 _09700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkbuf_leaf_21_clk clknet_2_3_0_clk clknet_leaf_21_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14004_ net2029 _09698_ _09700_ _00002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14005_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ _09700_ _09702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkbuf_leaf_22_clk clknet_2_3_0_clk clknet_leaf_22_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14007_ _09700_ _09697_ _08194_ _09704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14008_ net1548 _09704_ _00005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14009_ net2111 _08395_ _08401_ _09705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14010_ net2109 _09705_ net176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14011_ _01366_ _09706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_14012_ net2080 _08387_ _09707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14013_ _09707_ net2300 _09708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14014_ _00833_ _09708_ _00832_ _09709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14015_ _00837_ _09709_ net181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14016_ net2109 net2080 _00824_ _09710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14017_ _00829_ _09710_ net179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14018_ _09706_ net183 net181 net179 _09711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14019_ net185 net157 net163 _09711_ _09712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14020_ _08460_ _08467_ _09713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14021_ _08129_ _08170_ _08460_ _08184_ _09714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14022_ _09713_ _09714_ _09715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14023_ net2290 _09715_ net180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_14024_ net182 net165 net180 _09716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14025_ net156 net160 net164 _09717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14026_ net176 _09712_ _09716_ _09717_ _09718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14027_ net167 net168 net171 net172 _09719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14028_ net184 net159 net158 net161 _09720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14029_ net162 net166 net177 _09720_ _09721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14030_ net169 _09718_ _09719_ _09721_ _09722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_14031_ _00925_ _09480_ _09723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14032_ _09289_ _09723_ _09724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14033_ net1783 _09483_ _09725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14034_ net1783 _09476_ _09724_ _09725_ _09726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14035_ net1815 _09483_ _09727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14036_ _09377_ _09289_ _09480_ _09728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14037_ net1783 _09486_ _09727_ _09728_ _09729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14038_ _09726_ _09729_ _09730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14039_ _09480_ _09481_ _09731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14040_ _00925_ _09731_ _09732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14041_ _09289_ _09732_ _09733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14042_ net1815 _09486_ _09733_ _09488_ _09734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_14043_ _09377_ _09289_ _09731_ _09735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14044_ net1815 _09476_ _09484_ _09735_ _09736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_14045_ _09734_ _09736_ _09737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14046_ net2065 net2169 net174 _09738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14047_ _09730_ _09737_ _09738_ _09739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14048_ _09722_ _09739_ _09740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14049_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _09700_ _09741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14050_ _08227_ _09700_ _09740_ _09741_ _00004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14051_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _09740_ _09742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14052_ _08192_ _09742_ _09743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14053_ ex_block_i.gen_multdiv_fast.multdiv_i.div_valid _09743_
+ _09700_ _00003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14054_ cs_registers_i.pc_if_i\[2\] _00809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14055_ net1540 alu_adder_result_ex\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_14056_ ex_block_i.alu_i.imd_val_q_i\[48\] ex_block_i.alu_i.imd_val_q_i\[32\]
+ net1751 _09744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14057_ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _09745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xclkbuf_leaf_23_clk clknet_2_3_0_clk clknet_leaf_23_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_24_clk clknet_2_3_0_clk clknet_leaf_24_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14060_ net2032 _09744_ net1839 ex_block_i.alu_i.imd_val_q_i\[48\]
+ _09748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14061_ _09748_ _00970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14062_ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _09749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14063_ _08755_ _09745_ _09750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14064_ _07691_ net1838 _09750_ _09751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkbuf_leaf_25_clk clknet_2_2_0_clk clknet_leaf_25_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14066_ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[1\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ _09753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xclkbuf_leaf_26_clk clknet_2_2_0_clk clknet_leaf_26_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14068_ _08191_ _08775_ net1836 _09755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_14069_ net1671 _09755_ _00971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xclkbuf_leaf_27_clk clknet_2_2_0_clk clknet_leaf_27_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace1539 _11434_ net1538 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14072_ ex_block_i.alu_i.imd_val_q_i\[49\] ex_block_i.alu_i.imd_val_q_i\[33\]
+ net1751 _09758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1538 _00584_ net1537 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14074_ ex_block_i.alu_i.imd_val_q_i\[49\] net1839 _09758_
+ net2032 _00014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14075_ ex_block_i.alu_i.imd_val_q_i\[50\] ex_block_i.alu_i.imd_val_q_i\[34\]
+ net1751 _09760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14076_ ex_block_i.alu_i.imd_val_q_i\[50\] net1839 _09760_
+ net2032 _00017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xclkbuf_leaf_28_clk clknet_2_2_0_clk clknet_leaf_28_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_29_clk clknet_2_2_0_clk clknet_leaf_29_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14079_ net1739 _09749_ _09763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14080_ _08852_ _09745_ _09763_ _09764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_14081_ _09755_ net1606 _00021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14082_ ex_block_i.alu_i.imd_val_q_i\[51\] ex_block_i.alu_i.imd_val_q_i\[35\]
+ net1751 _09765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14083_ ex_block_i.alu_i.imd_val_q_i\[51\] net1839 _09765_
+ net2032 _00026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14084_ ex_block_i.alu_i.imd_val_q_i\[52\] ex_block_i.alu_i.imd_val_q_i\[36\]
+ net1751 _09766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14085_ ex_block_i.alu_i.imd_val_q_i\[52\] net1839 _09766_
+ net2032 _00031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xclkbuf_leaf_30_clk clknet_2_2_0_clk clknet_leaf_30_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14087_ net2272 _08870_ _09753_ _09768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_31_clk clknet_2_2_0_clk clknet_leaf_31_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14089_ net1606 net1666 _00033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14090_ _07787_ _07793_ _07799_ _07803_ _09770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
X_14091_ _08889_ _09745_ _09771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14092_ _09770_ _09749_ _09771_ _09772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkbuf_leaf_32_clk clknet_2_1_0_clk clknet_leaf_32_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14094_ net1785 _08810_ _09753_ _09774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_33_clk clknet_2_0_0_clk clknet_leaf_33_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14096_ net1664 net1660 _00034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14097_ net1793 _08945_ _09745_ _09776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_14098_ _09755_ net1659 _00035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14099_ ex_block_i.alu_i.imd_val_q_i\[53\] ex_block_i.alu_i.imd_val_q_i\[37\]
+ net1751 _09777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14100_ ex_block_i.alu_i.imd_val_q_i\[53\] net1839 _09777_
+ net2032 _00041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14101_ ex_block_i.alu_i.imd_val_q_i\[54\] ex_block_i.alu_i.imd_val_q_i\[38\]
+ net1751 _09778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14102_ ex_block_i.alu_i.imd_val_q_i\[54\] net1839 _09778_
+ net2032 _00051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14103_ _09764_ _09779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14104_ _08298_ _08307_ _08314_ _09780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_14105_ net1958 _08949_ _08954_ _09781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14106_ _08961_ _09781_ _09782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14107_ net1714 _09782_ net1836 _09783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14108_ _09779_ net1603 _00054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14109_ net1779 _08906_ _09753_ _09784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_35_clk clknet_2_0_0_clk clknet_leaf_35_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14111_ net1663 _09784_ _00055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14112_ net1666 _09776_ _00056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14113_ ex_block_i.alu_i.imd_val_q_i\[55\] ex_block_i.alu_i.imd_val_q_i\[39\]
+ net1751 _09786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14114_ ex_block_i.alu_i.imd_val_q_i\[55\] net1839 _09786_
+ net2032 _00066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14115_ _08339_ _08999_ _09753_ _09787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_34_clk clknet_2_0_0_clk clknet_leaf_34_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14117_ net1607 _09787_ _00068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14118_ _09772_ _09789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14119_ _09789_ net1603 _00069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkbuf_leaf_36_clk clknet_2_0_0_clk clknet_leaf_36_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14121_ _09776_ _09784_ _00067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14122_ net1791 net1838 _09791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14123_ _08981_ _09745_ _09791_ _09792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14124_ net1666 _09792_ _00072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14125_ ex_block_i.alu_i.imd_val_q_i\[56\] ex_block_i.alu_i.imd_val_q_i\[40\]
+ net1751 _09793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14126_ ex_block_i.alu_i.imd_val_q_i\[56\] net1839 _09793_
+ net2032 _00090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14127_ _08361_ _09059_ _09753_ _09794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_37_clk clknet_2_0_0_clk clknet_leaf_37_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14129_ net1607 net1649 _00092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14130_ net1663 _09787_ _00091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14131_ _09776_ _09796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14132_ _09796_ net1604 _00093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14133_ _09784_ _09792_ _00096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14134_ ex_block_i.alu_i.imd_val_q_i\[57\] ex_block_i.alu_i.imd_val_q_i\[41\]
+ net1751 _09797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14135_ ex_block_i.alu_i.imd_val_q_i\[57\] net1839 _09797_
+ net2032 _00110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14136_ _08378_ net1724 net1837 _09798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_38_clk clknet_2_0_0_clk clknet_leaf_38_clk VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14138_ net1606 _09798_ _00113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14139_ net1662 net1651 _00112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14140_ _09776_ net1656 _00111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14142_ net1653 _09801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14143_ net1603 _09801_ _00119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14144_ ex_block_i.alu_i.imd_val_q_i\[58\] ex_block_i.alu_i.imd_val_q_i\[42\]
+ net1751 _09802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14145_ ex_block_i.alu_i.imd_val_q_i\[58\] net1839 _09802_
+ net2032 _00130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14146_ _08427_ _09148_ net1837 _09803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_2_0_0_clk clknet_0_clk clknet_2_0_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14148_ net1607 _09803_ _00135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14149_ net1662 _09798_ _00134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14150_ _09776_ net1651 _00133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14151_ _09787_ net1653 _00141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14152_ _07914_ _07918_ _07923_ _09805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14153_ _09131_ _09745_ _09806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14154_ _09805_ _09749_ _09806_ _09807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkbuf_2_1_0_clk clknet_0_clk clknet_2_1_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14156_ net1666 net1644 _00146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14157_ ex_block_i.alu_i.imd_val_q_i\[59\] ex_block_i.alu_i.imd_val_q_i\[43\]
+ net1751 _09809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14158_ ex_block_i.alu_i.imd_val_q_i\[59\] net1839 _09809_
+ net2032 _00156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14159_ net2167 _09182_ net1837 _09810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_2_2_0_clk clknet_0_clk clknet_2_2_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14161_ net1607 net1642 _00159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14162_ net1662 _09803_ _00158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14163_ _09776_ _09798_ _00157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xclkbuf_2_3_0_clk clknet_0_clk clknet_2_3_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14165_ net1653 net1651 _00165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14166_ _09784_ _09807_ _00169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14167_ _09258_ _09745_ _09813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14168_ net2075 net1838 _09813_ _09814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkload31 clknet_2_0_0_clk _unconnected_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_14170_ net1668 _09814_ _00173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14171_ ex_block_i.alu_i.imd_val_q_i\[60\] ex_block_i.alu_i.imd_val_q_i\[44\]
+ net1751 _09816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14172_ ex_block_i.alu_i.imd_val_q_i\[60\] net1839 _09816_
+ net2032 _00184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14173_ _08486_ _09239_ net1837 _09817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1537 _00585_ net1536 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14175_ net1607 _09817_ _00187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14176_ net1663 net1642 _00186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14177_ _09776_ _09803_ _00185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14178_ net1653 _09798_ _00193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14179_ _09807_ _09819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14180_ net1603 _09819_ _00198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14181_ ex_block_i.alu_i.imd_val_q_i\[61\] ex_block_i.alu_i.imd_val_q_i\[45\]
+ net1751 _09820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14182_ ex_block_i.alu_i.imd_val_q_i\[61\] net1839 _09820_
+ net2032 _00208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14183_ net1738 _09276_ net1837 _09821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1536 _10228_ net1535 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14185_ net1607 _09821_ _00211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14186_ net1665 _09817_ _00210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14187_ _09776_ net1642 _00209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14188_ net1653 net1646 _00217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14189_ _09787_ _09807_ _00222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14190_ net1666 _09814_ _00224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14191_ _09322_ _09745_ _09823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14192_ net2105 net1838 _09823_ _09824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xplace1535 _01360_ net1534 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14194_ net1661 net1598 _00223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14195_ _08586_ net1838 _09826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14196_ _09358_ _09745_ _09826_ _09827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xplace1534 _01362_ net1533 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14198_ net1668 _09827_ _00225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14199_ ex_block_i.alu_i.imd_val_q_i\[62\] ex_block_i.alu_i.imd_val_q_i\[46\]
+ net1751 _09829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14200_ ex_block_i.alu_i.imd_val_q_i\[62\] net1839 _09829_
+ net2032 _00240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14201_ net1802 _09830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14202_ _09331_ _09335_ _09339_ _09831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_14203_ _09830_ _09831_ net1836 _09832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xclkload32 clknet_2_2_0_clk _unconnected_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_20
X_14205_ net1585 _09832_ _00243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14206_ net1653 net1642 _00246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14207_ _09794_ _09807_ _00250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14208_ _09784_ _09814_ _00253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14209_ net1666 _09824_ _00252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14210_ net1660 _09827_ _00251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14211_ ex_block_i.alu_i.imd_val_q_i\[63\] ex_block_i.alu_i.imd_val_q_i\[47\]
+ net1751 _09834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14212_ ex_block_i.alu_i.imd_val_q_i\[63\] net1839 _09834_
+ net2032 _00269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14213_ _08606_ _09374_ net1836 _09835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
Xclkload33 clknet_2_3_0_clk _unconnected_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_20
X_14215_ net1607 _09835_ _00272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14216_ _09789_ _09832_ _00271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14217_ _09776_ _09821_ _00270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14218_ net1653 _09817_ _00278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14219_ _09798_ net1645 _00281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14220_ _09814_ _09837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14221_ net1603 _09837_ _00284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14222_ net1657 net1598 _00283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14223_ net1667 net1636 _00282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14224_ _09674_ _09838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
X_14225_ _09838_ net1836 _09839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_14226_ net1670 net1583 _00293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14227_ net1812 net1811 _09840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14228_ _09840_ net1717 net1836 _09841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload34 clknet_leaf_0_clk _unconnected_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_14230_ _08793_ _09745_ _09843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_14231_ net2143 _09749_ _09843_ _09844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_14232_ net1630 _09845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_14233_ _09841_ _09845_ _00300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14234_ net2191 _09421_ net1836 _09846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload35 clknet_leaf_1_clk _unconnected_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14236_ net1607 net1629 _00299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14237_ net1665 net1634 _00298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14238_ net1602 net1635 _00307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14239_ _09079_ _09745_ _09848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14240_ _07904_ net1838 _09848_ _09849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload36 clknet_leaf_2_clk _unconnected_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14242_ net1642 net1627 _00311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14243_ _07957_ _07961_ _07966_ _09851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14244_ _09223_ _09745_ _09852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14245_ _09851_ net1838 _09852_ _09853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload37 clknet_leaf_3_clk _unconnected_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_14247_ net1650 net1626 _00314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14248_ net1655 net1641 _00313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14249_ net1598 _09855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14250_ net1605 _09855_ _00312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14251_ _09784_ net1636 _00320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14252_ net2030 ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ net1716 ex_block_i.alu_i.imd_val_q_i\[49\] _09856_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14253_ _09856_ _00337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14254_ net1583 net1630 _00336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14255_ net1585 _09841_ _00342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14256_ net1665 net1629 _00341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14257_ _09776_ net1634 _00340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14258_ net1601 net1635 _00350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14259_ net1645 net1643 _00354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14260_ net1650 net1641 _00357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14261_ net1655 net1599 _00356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14262_ net1636 _09857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14263_ net1605 _09857_ _00355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14264_ _08649_ net1838 _09858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14265_ _09405_ _09745_ _09858_ _09859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkload38 clknet_leaf_33_clk _unconnected_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_14267_ net1657 net1624 _00364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14268_ net2030 ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ _09673_ _09861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
Xclkload39 clknet_leaf_34_clk _unconnected_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload40 clknet_leaf_35_clk _unconnected_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
X_14271_ ex_block_i.alu_i.imd_val_q_i\[50\] net1716 _09864_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14272_ _09861_ _09864_ _00372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xclkload41 clknet_leaf_36_clk _unconnected_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_14274_ net1607 net1583 _00377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_14275_ _09789_ net1631 _00376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14276_ _09776_ net1629 _00375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14277_ net1653 net1634 _00385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14278_ net1645 net1640 _00389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14279_ net1648 net1641 _00392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14280_ net1650 net1599 _00391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14281_ net1655 net1637 _00390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14282_ net1624 _09866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_14283_ net1605 _09866_ _00399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14284_ ex_block_i.alu_i.imd_val_q_i\[51\] net1716 _09867_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14285_ _09861_ _09867_ _00409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14286_ net1665 net1583 _00412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14287_ _09796_ net1631 _00411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14288_ net1653 net1629 _00420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14289_ net1645 net1639 _00424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14290_ net1647 net1641 _00427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14291_ net1648 net1599 _00426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14292_ net1650 net1637 _00425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14293_ net1655 net1624 _00434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14294_ ex_block_i.alu_i.imd_val_q_i\[52\] net1716 _09868_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14295_ _09861_ _09868_ _00445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14296_ _09776_ net1583 _00447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14297_ net1601 net1631 _00453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14298_ net1600 net1635 _00460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14299_ net1643 net1641 _00463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14300_ net1647 net1599 _00462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14301_ net1648 net1637 _00461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14302_ net1650 net1624 _00470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14303_ ex_block_i.alu_i.imd_val_q_i\[53\] net1716 _09869_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14304_ _09861_ _09869_ _00481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14305_ net1653 net1583 _00486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14306_ _09042_ _09745_ _09870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14307_ net1789 _09749_ _09870_ _09871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_14308_ net1623 _09872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14309_ net1631 net1594 _00485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14310_ net1629 net1628 _00487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14311_ net1645 net1634 _00495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14312_ net1641 net1640 _00498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14313_ net1643 net1599 _00497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14314_ net1647 net1637 _00496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14315_ net1648 net1624 _00505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14316_ ex_block_i.alu_i.imd_val_q_i\[54\] net1716 _09873_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14317_ net1710 _09873_ _00516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xclkload42 clknet_leaf_37_clk _unconnected_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_14319_ net1583 net1623 _00520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14320_ net1627 _09875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14321_ net1631 net1593 _00519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14322_ net1645 net1629 _00528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14323_ net1641 net1639 _00531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14324_ net1640 net1599 _00530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14325_ net1643 net1637 _00529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14326_ net1647 net1624 _00538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14327_ ex_block_i.alu_i.imd_val_q_i\[55\] net1716 _09876_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14328_ net1710 _09876_ _00549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14329_ net1583 net1627 _00551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14330_ net1600 net1631 _00560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14331_ net1597 net1635 _00563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14332_ net1639 net1599 _00562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14333_ net1640 net1637 _00561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14334_ net1643 net1624 _00570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14335_ ex_block_i.alu_i.imd_val_q_i\[56\] net1716 _09877_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14336_ net1710 _09877_ _00581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14337_ net1645 net1584 _00589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14338_ _07935_ _07939_ _07944_ _09878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_14339_ _09166_ _09745_ _09879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14340_ _09878_ _09749_ _09879_ _09880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14341_ net1620 _09881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14342_ net1631 net1592 _00588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14343_ net1629 net1626 _00590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14344_ net1641 net1634 _00595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14345_ _09855_ net1635 _00594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14346_ net1639 net1637 _00593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14347_ net1640 net1624 _00604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14348_ ex_block_i.alu_i.imd_val_q_i\[57\] net1716 _09882_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14349_ net1710 _09882_ _00615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1533 _10262_ net1532 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14351_ net1584 net1621 _00620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14352_ _09853_ _09884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14353_ net1632 net1591 _00619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14354_ net1641 net1629 _00625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14355_ net1599 net1634 _00624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14356_ net1595 net1635 _00623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14357_ net1639 net1624 _00635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14358_ ex_block_i.alu_i.imd_val_q_i\[58\] net1716 _09885_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14359_ net1710 _09885_ _00646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14360_ net1584 net1626 _00649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14361_ net1597 net1632 _00654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14362_ net1599 net1629 _00653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14363_ net1638 net1634 _00652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14364_ net1635 _09866_ _00664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14365_ ex_block_i.alu_i.imd_val_q_i\[59\] net1716 _09886_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14366_ net1710 _09886_ _00675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14367_ net1641 net1584 _00680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14368_ _09855_ net1632 _00679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14369_ net1638 net1629 _00678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14370_ net1634 net1624 _00690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14371_ ex_block_i.alu_i.imd_val_q_i\[60\] net1716 _09887_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14372_ net1710 _09887_ _00701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14373_ net1599 net1584 _00705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14374_ net1595 net1633 _00704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14375_ net1629 net1624 _00714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14376_ ex_block_i.alu_i.imd_val_q_i\[61\] net1716 _09888_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14377_ net1710 _09888_ _00725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14378_ net1638 net1584 _00727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14379_ net1633 _09866_ _00736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14380_ ex_block_i.alu_i.imd_val_q_i\[62\] net1716 _09889_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14381_ net1710 _09889_ _00747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14382_ net1584 net1624 _00756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14383_ _08690_ net1838 _09890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14384_ net1719 _09745_ _09890_ _09891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_14385_ net1619 _09892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14386_ net1633 _09892_ _00755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14387_ _09682_ net1839 _09893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_14388_ _09893_ _09894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14389_ net1629 net1582 _00754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14390_ ex_block_i.alu_i.imd_val_q_i\[63\] net1716 _09895_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14391_ net1710 _09895_ _00771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xclkload44 clknet_leaf_4_clk _unconnected_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_14393_ net1584 net1619 _00776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14394_ net1633 net1590 _00777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14395_ ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ net1716 _09897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14396_ net1710 _09897_ _00791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14397_ net1584 net1582 _00799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14398_ net2493 _00452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14399_ _00750_ _00751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14400_ _09529_ _09532_ _09533_ _09534_ _09898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14401_ id_stage_i.controller_i.instr_valid_i _09645_ net1826
+ _09899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14402_ id_stage_i.controller_i.store_err_q id_stage_i.controller_i.load_err_q
+ _09900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14403_ id_stage_i.controller_i.exc_req_q _09900_ _09901_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14404_ _09898_ _09899_ _09901_ _09902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14405_ cs_registers_i.priv_mode_id_o\[1\] _00953_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14406_ cs_registers_i.dcsr_q\[12\] _00953_ _09903_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14407_ cs_registers_i.dcsr_q\[15\] _09640_ _09904_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14408_ cs_registers_i.priv_mode_id_o\[0\] _09903_ _09904_
+ _09905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14409_ cs_registers_i.debug_mode_i _09905_ net1932 _09906_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14410_ id_stage_i.controller_i.illegal_insn_q _09907_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14411_ _09907_ _09620_ _09908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14412_ _09645_ net1826 _09649_ _09909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14413_ _09901_ _09906_ _09908_ _09909_ _09910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_14414_ _09499_ _09910_ _09911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14415_ _07631_ _07632_ _07645_ _09912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14416_ id_stage_i.id_fsm_q _07575_ _09912_ _09913_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or3_2
X_14417_ _09621_ _09913_ _09914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14418_ id_stage_i.branch_set _09915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14419_ _09586_ _09587_ _09914_ _09915_ _09916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_14420_ id_stage_i.controller_i.instr_valid_i id_stage_i.controller_i.instr_fetch_err_i
+ _09917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14421_ net1809 _09917_ _09918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14422_ net65 cs_registers_i.dcsr_q\[2\] _09919_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14423_ id_stage_i.controller_i.ctrl_fsm_cs\[2\] _09920_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14424_ _09617_ _09920_ _09921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14425_ id_stage_i.controller_i.ctrl_fsm_cs\[3\] _09921_
+ _09922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14426_ _09497_ _09922_ _09923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14427_ cs_registers_i.mie_q\[14\] net140 _09924_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14428_ cs_registers_i.mie_q\[6\] net146 cs_registers_i.mie_q\[7\]
+ net147 _09925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14429_ cs_registers_i.mie_q\[4\] net144 cs_registers_i.mie_q\[5\]
+ net145 _09926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14430_ cs_registers_i.mie_q\[2\] net142 cs_registers_i.mie_q\[3\]
+ net143 _09927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14431_ cs_registers_i.mie_q\[0\] net135 cs_registers_i.mie_q\[1\]
+ net141 _09928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14432_ _09925_ _09926_ _09927_ _09928_ _09929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_14433_ cs_registers_i.mie_q\[12\] net138 cs_registers_i.mie_q\[13\]
+ net139 _09930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14434_ cs_registers_i.mie_q\[10\] net136 cs_registers_i.mie_q\[11\]
+ net137 _09931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14435_ cs_registers_i.mie_q\[8\] net148 cs_registers_i.mie_q\[9\]
+ net149 _09932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14436_ _09930_ _09931_ _09932_ _09933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14437_ cs_registers_i.mie_q\[16\] net152 net150 _09934_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14438_ net134 cs_registers_i.mie_q\[15\] cs_registers_i.mie_q\[17\]
+ net151 _09935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14439_ _09934_ _09935_ _09936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14440_ _09924_ _09929_ _09933_ _09936_ _09937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_14441_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _09498_
+ id_stage_i.controller_i.ctrl_fsm_cs\[2\] _09938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14442_ cs_registers_i.nmi_mode_i _09939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14443_ net2038 cs_registers_i.csr_mstatus_mie_o _09940_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14444_ _09939_ _09940_ _09941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14445_ cs_registers_i.debug_mode_i _09942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14446_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09942_
+ _09943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14447_ _09938_ _09941_ _09943_ _09944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14448_ net1808 _09944_ _09945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14449_ _09919_ _09923_ _09945_ _09946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xplace1532 _10492_ net1531 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14451_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09498_
+ _09921_ _09948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14452_ _09946_ _09948_ _09949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14453_ _09902_ _09911_ _09916_ _09918_ _09949_ _09950_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_14454_ _09529_ _09532_ _09533_ _09534_ _09951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_14455_ id_stage_i.controller_i.exc_req_q _09900_ _09952_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14456_ _09951_ _09646_ _09952_ _09953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14457_ _09617_ _09953_ _09497_ _09954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14458_ _09618_ _09954_ _09922_ _09955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload45 clknet_leaf_6_clk _unconnected_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14460_ net1589 net1618 _09957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1531 _10794_ net1530 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload47 clknet_leaf_9_clk _unconnected_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload48 clknet_leaf_10_clk _unconnected_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_14464_ net1809 net176 _09961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14465_ _09500_ _09639_ _09899_ _09952_ _09962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
Xplace1530 _03452_ net1529 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload49 clknet_leaf_11_clk _unconnected_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_14468_ _09499_ _09642_ _09646_ _09901_ _09965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xplace1529 _03553_ net1528 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload50 clknet_leaf_12_clk _unconnected_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xplace1528 _03906_ net1527 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14472_ _09924_ _09929_ _09933_ _09969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14473_ cs_registers_i.mie_q\[13\] net139 _09970_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14474_ cs_registers_i.mie_q\[10\] net136 _09971_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14475_ cs_registers_i.mie_q\[8\] net2040 _09972_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14476_ cs_registers_i.mie_q\[6\] net2042 _09973_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14477_ cs_registers_i.mie_q\[4\] net2044 _09974_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14478_ cs_registers_i.mie_q\[2\] net2046 _09975_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14479_ cs_registers_i.mie_q\[1\] net2047 _09976_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14480_ cs_registers_i.mie_q\[3\] net2045 _09975_ _09976_
+ _09977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14481_ cs_registers_i.mie_q\[5\] net2043 _09978_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14482_ _09974_ _09977_ _09978_ _09979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14483_ cs_registers_i.mie_q\[7\] net2041 _09973_ _09979_
+ _09980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14484_ cs_registers_i.mie_q\[9\] net2039 _09981_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14485_ _09972_ _09980_ _09981_ _09982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14486_ cs_registers_i.mie_q\[11\] net2049 _09971_ _09982_
+ _09983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_14487_ cs_registers_i.mie_q\[12\] net2048 _09983_ _09984_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14488_ _09970_ _09984_ _09924_ _09985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14489_ net2038 _09939_ _09986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14490_ _09969_ _09985_ _09986_ _09987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14491_ _09945_ _09987_ _09988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14492_ cs_registers_i.csr_depc_o\[2\] net1747 _09965_ cs_registers_i.csr_mepc_o\[2\]
+ _09988_ _09989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14493_ _09961_ _09989_ _09990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14494_ _09957_ _09990_ _09991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1527 _03975_ net1526 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkload51 clknet_leaf_13_clk _unconnected_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xplace1526 _03981_ net1525 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14498_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ net1589 _09995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14499_ _09991_ _09995_ _01372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14500_ _09499_ _09952_ _09996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14501_ cs_registers_i.debug_mode_i _09996_ _09997_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14502_ net1809 net1519 net1746 cs_registers_i.csr_mepc_o\[3\]
+ _09997_ _09998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14503_ _09926_ _09999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14504_ _09999_ _09927_ _09925_ _10000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14505_ _09932_ _10000_ _10001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14506_ _09931_ _10001_ _10002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14507_ net1835 _10002_ _10003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14508_ _09924_ _09986_ _10004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14509_ _09969_ _10003_ _10004_ _10005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14510_ _09945_ _10005_ _10006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1525 _04044_ net1524 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14512_ cs_registers_i.csr_depc_o\[3\] net1747 _10008_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14513_ _09998_ _10006_ _10008_ _10009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_14514_ _09902_ _09911_ _09949_ _10010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14515_ _09916_ _09918_ _10011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14516_ _10010_ _10011_ _10012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xplace1524 _04135_ net1523 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14518_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ _10009_ _10012_ _01374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14519_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q
+ _10014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1523 _01365_ net1522 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14521_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ _10016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkload52 clknet_leaf_14_clk _unconnected_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_14523_ _10014_ net1589 net1834 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload53 clknet_leaf_15_clk _unconnected_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xclkload54 clknet_leaf_32_clk _unconnected_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload55 clknet_leaf_25_clk _unconnected_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
Xclkload56 clknet_leaf_26_clk _unconnected_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
X_14528_ net2025 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ _10022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14529_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]
+ _10023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14530_ _10023_ net112 _10024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14531_ net101 _10024_ _10025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14532_ net99 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]
+ net2025 _10026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14533_ net2026 _10022_ _10025_ _10026_ _10027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
Xclkload57 clknet_leaf_27_clk _unconnected_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload58 clknet_leaf_28_clk _unconnected_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1522 net176 net1521 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14537_ net2025 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _10031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14538_ _10023_ net109 net108 _10032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_14539_ _10031_ _10032_ _10033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14540_ _10026_ _10033_ _10034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14541_ net2026 _10034_ _00810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14542_ _10027_ _00810_ _01132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14543_ _01132_ _00811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14544_ net154 _10035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14545_ net65 core_busy_q net1808 fetch_enable_q net155 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_14546_ _10035_ net155 _00006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1521 _09706_ net1520 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_14548_ _09755_ net2475 _00012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14549_ net1666 net2475 _00024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14550_ _09784_ net2481 _00030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14551_ net1606 _09784_ _00044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14552_ _09794_ net2481 _00064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14553_ _00990_ _00083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14554_ net2474 _09803_ _00088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14555_ net2474 net1642 _00108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14556_ net1666 net1627 _00117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14557_ _09784_ net1627 _00139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14558_ net1668 net1625 _00144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14559_ _09817_ net1630 _00154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14560_ net1603 _09875_ _00163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14561_ net1661 net1625 _00167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14562_ _09821_ net2481 _00182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14563_ _09787_ net1627 _00191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14564_ net1666 net1625 _00196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14565_ _09832_ _09845_ _00206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14566_ net1649 net1627 _00215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14567_ _09784_ net1625 _00220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14568_ _09835_ net2481 _00238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14569_ _09776_ _09817_ _00241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14570_ _09798_ net1627 _00244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14571_ net1603 _09884_ _00248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14572_ net1630 _09846_ _00267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14573_ net1646 net1627 _00276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14574_ net1654 net1625 _00279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14575_ net1640 net2477 _00305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14576_ net1648 net1621 _00309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14577_ net1660 _09891_ _00318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1520 net179 net1519 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_14579_ net1669 net1582 _00324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14580_ net1640 net1628 _00348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14581_ net1648 net1626 _00352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14582_ net1660 net1582 _00362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14583_ net1639 net1628 _00383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14584_ net1647 net1626 _00387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14585_ net1667 net1582 _00397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14586_ net1635 net1593 _00418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14587_ net1643 net1626 _00422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14588_ net1657 net1582 _00432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14589_ net1640 net1626 _00458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14590_ net1605 net1590 _00468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14591_ net1639 net1626 _00493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14592_ net1655 net1582 _00503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14593_ net1635 net1591 _00526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14594_ net1650 net1582 _00536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14595_ net1634 net1626 _00558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14596_ net1648 net1582 _00568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14597_ net1647 net1582 _00602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14598_ net1643 net1582 _00633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14599_ net1640 net1582 _00662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14600_ net1639 net1582 _00688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14601_ net1635 net1590 _00712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14602_ net1634 net1582 _00734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14603_ net1671 net1660 _00013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14604_ net1660 net2475 _00018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14605_ net1671 _09784_ _00025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14606_ net1671 _09787_ _00042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14607_ net1666 net1664 _00045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14608_ net1670 _09794_ _00052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14609_ net2474 _09798_ _00065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14610_ net1660 net1622 _00073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14611_ _00991_ _00084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14612_ _09798_ net2476 _00089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14613_ net1666 net1622 _00097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14614_ _09803_ net2476 _00109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14615_ _09784_ net2477 _00118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14616_ net1642 net2476 _00131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14617_ net1603 _09872_ _00140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14618_ net1661 net1620 _00145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14619_ net1670 _09821_ _00155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14620_ _09787_ net1623 _00164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14621_ net1666 net1620 _00168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14622_ net1670 _10037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_14623_ _10037_ _09832_ _00183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14624_ net1651 net1623 _00192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14625_ _09784_ net1621 _00197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14626_ net2474 _09835_ _00207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14627_ _09798_ net1623 _00216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14628_ net1603 _09881_ _00221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14629_ net2474 _09846_ _00239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14630_ net1665 _09821_ _00242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14631_ net1646 net2477 _00245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14632_ _09787_ net1620 _00249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14633_ _10037_ _09841_ _00268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14634_ net1642 net1623 _00277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14635_ net1649 net1621 _00280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14636_ net1653 net1639 _00306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14637_ net1646 net1645 _00310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14638_ net1667 _09859_ _00319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14639_ _01030_ _00325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14640_ net1639 net2477 _00349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14641_ net1647 net1621 _00353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14642_ net1667 net1619 _00363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14643_ net1635 net1594 _00384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14644_ net1643 net1621 _00388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14645_ net1657 net1619 _00398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14646_ net1634 net2477 _00419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14647_ net1640 net1621 _00423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14648_ net1605 _09892_ _00433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14649_ net1634 net1628 _00454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14650_ net1639 net1621 _00459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14651_ net1655 net1619 _00469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14652_ net1635 net1592 _00494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14653_ net1650 net1619 _00504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14654_ net1634 net1621 _00527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14655_ net1648 net1619 _00537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14656_ net1629 net1621 _00559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14657_ net1647 net1619 _00569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14658_ net1643 net1619 _00603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14659_ net1640 net1619 _00634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14660_ net1639 net1619 _00663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14661_ net1635 _09892_ _00689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14662_ net1634 net1619 _00713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14663_ net1629 net1619 _00735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14664_ net1671 net1666 _00019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14665_ _10037_ net1604 _00032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14666_ net1604 _09845_ _00043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14667_ net1660 net1659 _00046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14668_ _09787_ net1630 _00053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14669_ _09755_ net1627 _00074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14670_ net1660 net1627 _00098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14671_ net1670 _09817_ _00132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14672_ net1629 net2477 _00455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14673_ _00103_ _00104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14674_ _00123_ _00124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14675_ _00233_ _00234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14676_ _00260_ _00261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14677_ _00036_ _00037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14678_ _00057_ _00058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14679_ _00070_ _00071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14680_ _00078_ _00079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14681_ _00094_ _00095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14682_ _00115_ _00116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14683_ _00137_ _00138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14684_ _00161_ _00162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14685_ _00177_ _00178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14686_ _00189_ _00190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14687_ _00213_ _00214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14688_ _00226_ _00227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14689_ _00254_ _00255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14690_ _00274_ _00275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14691_ _00285_ _00286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14692_ _00297_ _00304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14693_ _00302_ _00303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14694_ _00316_ _00317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14695_ _00323_ _00326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14696_ _00331_ _00332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14697_ _00339_ _00345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14698_ _00344_ _00346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14699_ _00359_ _00360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14700_ _00374_ _00382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14701_ _00379_ _00380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14702_ _00394_ _00395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14703_ _00405_ _00406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14704_ _00410_ _00417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14705_ _00414_ _00415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14706_ _00429_ _00430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14707_ _00440_ _00441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14708_ _00451_ _00457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14709_ _00465_ _00466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14710_ _00476_ _00477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14711_ _00482_ _00484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14712_ _00489_ _00491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14713_ _00500_ _00501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14714_ _00511_ _00512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14715_ _00518_ _00525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14716_ _00522_ _00524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14717_ _00533_ _00534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14718_ _00544_ _00545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14719_ _00550_ _00557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14720_ _00553_ _00555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14721_ _00565_ _00566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14722_ _00576_ _00577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14723_ _00587_ _00601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14724_ _00592_ _00599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14725_ _00597_ _00598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14726_ _00610_ _00611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14727_ _00616_ _00618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14728_ _00622_ _00630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14729_ _00627_ _00628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14730_ _00641_ _00642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14731_ _00648_ _00661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14732_ _00651_ _00659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14733_ _00656_ _00657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14734_ _00670_ _00671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14735_ _00677_ _00687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14736_ _00682_ _00683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14737_ _00696_ _00697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14738_ _00703_ _00711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14739_ _00707_ _00708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14740_ _00720_ _00721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14741_ _00726_ _00733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14742_ _00729_ _00730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14743_ _00742_ _00743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14744_ _00753_ _00767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14745_ _00758_ _00759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14746_ _00765_ _00766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14747_ _00773_ _00775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14748_ _00778_ _00780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14749_ _00785_ _00787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14750_ _00795_ _00797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14751_ _00803_ _00804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14752_ _00047_ _00988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14753_ _00114_ _00142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14754_ _00136_ _00166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14755_ _00160_ _00194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14756_ _00174_ _00201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14757_ _00176_ _00203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14758_ _00188_ _00218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14759_ _00212_ _00247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14760_ _00273_ _00308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14761_ _00296_ _00347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14762_ _00301_ _00351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14763_ _00315_ _00365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14764_ _00330_ _00369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14765_ _00338_ _00381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14766_ _00343_ _00386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14767_ _00358_ _00400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14768_ _00373_ _00416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14769_ _00378_ _00421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14770_ _00393_ _00435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14771_ _00404_ _00442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14772_ _00413_ _00456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14773_ _00428_ _00471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14774_ _00439_ _00478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14775_ _00446_ _00483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14776_ _00448_ _00490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14777_ _00450_ _00492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14778_ _00464_ _00506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14779_ _00475_ _00513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14780_ _00488_ _00523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14781_ _00499_ _00539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14782_ _00510_ _00546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14783_ _00517_ _00556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14784_ _00521_ _00554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14785_ _00532_ _00571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14786_ _00543_ _00578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14787_ _00552_ _00583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14788_ _00564_ _00605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14789_ _00575_ _00612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14790_ _00582_ _00617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14791_ _00586_ _00632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14792_ _00591_ _00629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14793_ _00596_ _00636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14794_ _00609_ _00643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14795_ _00621_ _00658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14796_ _00626_ _00665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14797_ _00640_ _00672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14798_ _00647_ _00686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14799_ _00650_ _00684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14800_ _00655_ _00691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14801_ _00669_ _00698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14802_ _00676_ _00710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14803_ _00681_ _00715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14804_ _00695_ _00722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14805_ _00702_ _00732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14806_ _00706_ _00737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14807_ _00719_ _00744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14808_ _00728_ _00760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14809_ _00741_ _00768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14810_ _00748_ _00774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14811_ _00752_ _00786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14812_ _00757_ _00779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14813_ _00764_ _00788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14814_ _00772_ _00796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14815_ _00784_ _00806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclkload61 clknet_leaf_17_clk _unconnected_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
X_14817_ ex_block_i.alu_i.imd_val_q_i\[33\] net1823 _10039_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14818_ _01145_ _10039_ net1814 _00818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14819_ ex_block_i.alu_i.imd_val_q_i\[34\] net1823 _10040_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14820_ _01151_ _10040_ net1814 _00822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14821_ ex_block_i.alu_i.imd_val_q_i\[35\] net1823 _10041_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14822_ _01158_ _10041_ net1814 _00826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14823_ ex_block_i.alu_i.imd_val_q_i\[36\] net1823 _10042_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14824_ _01165_ _10042_ net1814 _00830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14825_ ex_block_i.alu_i.imd_val_q_i\[37\] net1823 _10043_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14826_ _01172_ _10043_ net1814 _00834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14827_ ex_block_i.alu_i.imd_val_q_i\[38\] net1823 _10044_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14828_ net1691 _10044_ net1814 _00838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14829_ ex_block_i.alu_i.imd_val_q_i\[39\] net1823 _10045_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14830_ net1690 _10045_ net1814 _00842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14831_ ex_block_i.alu_i.imd_val_q_i\[40\] net1823 _10046_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14832_ _01193_ _10046_ net1814 _00846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14833_ ex_block_i.alu_i.imd_val_q_i\[41\] net1823 _10047_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14834_ net1689 _10047_ net1814 _00850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14835_ ex_block_i.alu_i.imd_val_q_i\[42\] net1823 _10048_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkload59 clknet_leaf_29_clk _unconnected_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
X_14837_ net1688 _10048_ net1814 _00854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload60 clknet_leaf_31_clk _unconnected_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_14839_ ex_block_i.alu_i.imd_val_q_i\[43\] net1823 _10051_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14840_ net1695 _10051_ net1814 _00858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14841_ ex_block_i.alu_i.imd_val_q_i\[44\] net1823 _10052_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14842_ _01226_ _10052_ net1814 _00862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14843_ ex_block_i.alu_i.imd_val_q_i\[45\] net1823 _10053_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14844_ _01228_ _10053_ net1814 _00866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14845_ ex_block_i.alu_i.imd_val_q_i\[46\] net1823 _10054_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14846_ net1685 _10054_ net1814 _00870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14847_ ex_block_i.alu_i.imd_val_q_i\[47\] net1823 _10055_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14848_ net1684 _10055_ net1814 _00874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14849_ ex_block_i.alu_i.imd_val_q_i\[48\] net1823 _10056_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14850_ net1683 _10056_ net1814 _00878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14851_ ex_block_i.alu_i.imd_val_q_i\[49\] net1823 _10057_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14852_ _01256_ _10057_ net1814 _00882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14853_ ex_block_i.alu_i.imd_val_q_i\[50\] net1823 _10058_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14854_ net1682 _10058_ net1814 _00886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14855_ ex_block_i.alu_i.imd_val_q_i\[51\] net1823 _10059_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14856_ net1681 _10059_ net1814 _00890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14857_ ex_block_i.alu_i.imd_val_q_i\[52\] net1823 _10060_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclkload67 clknet_leaf_23_clk _unconnected_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
X_14859_ _01277_ _10060_ net1814 _00894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload62 clknet_leaf_18_clk _unconnected_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_14861_ ex_block_i.alu_i.imd_val_q_i\[53\] net1823 _10063_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14862_ net1680 _10063_ net1815 _00898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14863_ ex_block_i.alu_i.imd_val_q_i\[54\] net1823 _10064_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14864_ net1679 _10064_ net1815 _00902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14865_ ex_block_i.alu_i.imd_val_q_i\[55\] net1823 _10065_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14866_ net1678 _10065_ net1815 _00906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14867_ ex_block_i.alu_i.imd_val_q_i\[56\] net1823 _10066_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14868_ net1677 _10066_ net1815 _00910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14869_ ex_block_i.alu_i.imd_val_q_i\[57\] net1823 _10067_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14870_ _01312_ _10067_ net1815 _00914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14871_ ex_block_i.alu_i.imd_val_q_i\[58\] net1823 _10068_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14872_ _01319_ _10068_ net1814 _00918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14873_ ex_block_i.alu_i.imd_val_q_i\[59\] net1823 _10069_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14874_ _01326_ _10069_ net1814 _00922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14875_ ex_block_i.alu_i.imd_val_q_i\[60\] net1823 _10070_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14876_ net1676 _10070_ net1814 _00926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14877_ ex_block_i.alu_i.imd_val_q_i\[61\] net1823 _10071_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14878_ net1675 _10071_ net1814 _00930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14879_ ex_block_i.alu_i.imd_val_q_i\[62\] net1823 _10072_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_14880_ _01347_ _10072_ net1814 _00934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload66 clknet_leaf_22_clk _unconnected_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload65 clknet_leaf_21_clk _unconnected_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_14883_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _00962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14884_ _00015_ _00022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14885_ _09755_ net1664 _00976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14886_ _00038_ _00039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14887_ net1660 net1652 _00986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14888_ _00061_ _00062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14889_ _00080_ _00081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14890_ _00075_ _00101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14891_ net1668 net1644 _00996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14892_ _00120_ _00122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14893_ _00099_ _00121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14894_ net1668 net1620 _01001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14895_ _00127_ _00128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14896_ _00126_ _00152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14897_ _00147_ _00171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14898_ _00143_ _00175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14899_ _00150_ _00180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14900_ net1668 _09824_ _01012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14901_ _00195_ _00230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14902_ _00200_ _00231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14903_ _00204_ _01020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14904_ _00256_ _00258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14905_ _00228_ _00257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14906_ net1669 _09859_ _01024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14907_ _00236_ _00265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14908_ net1669 _09891_ _01028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14909_ _00263_ _00291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14910_ _00321_ _00322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14911_ _00327_ _00328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14912_ _00289_ _00334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14913_ _00371_ _01038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14914_ _00366_ _01041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14915_ _00370_ _01043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14916_ _00401_ _01047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14917_ _00407_ _01049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14918_ _00436_ _01053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14919_ _00443_ _01055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14920_ _00472_ _01059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14921_ _00479_ _01061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14922_ _00507_ _01065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14923_ _00514_ _01067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14924_ _00540_ _01071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14925_ _00547_ _01073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14926_ _00572_ _01077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14927_ _00579_ _01079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14928_ _00606_ _01083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14929_ _00613_ _01085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14930_ _00637_ _01089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14931_ _00644_ _01091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14932_ _00666_ _01095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14933_ _00673_ _01097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14934_ _00584_ _00585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
X_14935_ _00692_ _01101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14936_ _00699_ _01103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14937_ _00716_ _01107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14938_ _00723_ _01109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14939_ _00738_ _01113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14940_ _00745_ _01115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14941_ _00761_ _01119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14942_ _00749_ _00783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14943_ _00769_ _01121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14944_ _00781_ _01126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14945_ _00789_ _01128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14946_ net2150 _01221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14947_ _09498_ id_stage_i.controller_i.ctrl_fsm_cs\[2\]
+ _10074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14948_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] id_stage_i.controller_i.ctrl_fsm_cs\[3\]
+ _09921_ _10075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14949_ _10074_ _10075_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _10076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclkload64 clknet_leaf_20_clk _unconnected_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload63 clknet_leaf_19_clk _unconnected_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_14952_ net2023 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _09950_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ _10079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_14953_ _10076_ _10079_ _10080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14954_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ _10080_ _10081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14955_ _10081_ _01371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_14956_ net1841 ex_block_i.alu_i.imd_val_q_i\[33\] ex_block_i.alu_i.imd_val_q_i\[1\]
+ net1824 _08200_ net2185 _10082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_14957_ net2028 net1786 _10082_ _10083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14958_ net2119 net1694 _07742_ _10084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14959_ _08187_ _10083_ _10084_ _00819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14960_ _08192_ ex_block_i.alu_i.imd_val_q_i\[35\] ex_block_i.alu_i.imd_val_q_i\[3\]
+ _08197_ _10085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14961_ _07804_ _08228_ net1780 net2028 _10085_ _10086_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14962_ _08187_ _10086_ _10087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_14963_ net1694 net2119 _07808_ _10088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14964_ _10087_ _10088_ _00827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_14965_ _08192_ ex_block_i.alu_i.imd_val_q_i\[36\] ex_block_i.alu_i.imd_val_q_i\[4\]
+ _08197_ _10089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14966_ net1794 _08228_ _08315_ net2028 _10089_ _10090_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xclkload68 clknet_leaf_24_clk _unconnected_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_20
X_14968_ net1694 net2119 _07831_ _10092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14969_ _08187_ _10090_ _10092_ _00831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14970_ net1841 ex_block_i.alu_i.imd_val_q_i\[37\] ex_block_i.alu_i.imd_val_q_i\[5\]
+ net1824 _10093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14971_ net1792 _08200_ _10094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_14972_ net2028 net1778 _10093_ _10094_ _10095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_14973_ net2119 net1694 _01173_ _10096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14974_ _08187_ _10095_ _10096_ _00835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14975_ net1841 ex_block_i.alu_i.imd_val_q_i\[38\] ex_block_i.alu_i.imd_val_q_i\[6\]
+ net1824 _08200_ net1790 _10097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_14976_ net2028 net1777 _10097_ _10098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14977_ net2119 net1694 _01180_ _10099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14978_ _08187_ _10098_ _10099_ _00839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14979_ net1841 ex_block_i.alu_i.imd_val_q_i\[39\] ex_block_i.alu_i.imd_val_q_i\[7\]
+ net1824 _10100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14980_ _09549_ _08228_ net1776 net2028 _10100_ _10101_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14981_ net1694 _08218_ _01191_ _10102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14982_ _08187_ _10101_ _10102_ _00843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14983_ net1841 ex_block_i.alu_i.imd_val_q_i\[40\] ex_block_i.alu_i.imd_val_q_i\[8\]
+ _08197_ _10103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14984_ _07924_ _08228_ net1775 net2028 _10103_ _10104_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14985_ _08218_ net1694 _07925_ _10105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14986_ _08187_ _10104_ _10105_ _00847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14987_ _08192_ ex_block_i.alu_i.imd_val_q_i\[41\] ex_block_i.alu_i.imd_val_q_i\[9\]
+ _08197_ _10106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14988_ _07945_ _08228_ net2174 net2028 _10106_ _10107_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14989_ _08218_ net1694 _07946_ _10108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14990_ _08187_ _10107_ _10108_ _00851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14991_ net1841 ex_block_i.alu_i.imd_val_q_i\[42\] ex_block_i.alu_i.imd_val_q_i\[10\]
+ _08197_ _10109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_14992_ _07967_ _08228_ net1735 net2028 _10109_ _10110_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_14993_ _08218_ net1694 net1697 _10111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14994_ _08187_ _10110_ _10111_ _00855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14995_ net1841 ex_block_i.alu_i.imd_val_q_i\[43\] ex_block_i.alu_i.imd_val_q_i\[11\]
+ net1824 _08200_ net2158 _10112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_14996_ net2028 net1738 _10112_ _10113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_14997_ net1693 net1694 _07997_ _10114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_14998_ _08187_ _10113_ _10114_ _00859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_14999_ _08192_ ex_block_i.alu_i.imd_val_q_i\[61\] ex_block_i.alu_i.imd_val_q_i\[29\]
+ net1824 _08200_ net1755 _10115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_15000_ net2028 net1754 _10115_ _10116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15001_ net2175 net2111 _01341_ _10117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15002_ _08187_ _10116_ _10117_ _00931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15003_ _08192_ ex_block_i.alu_i.imd_val_q_i\[62\] ex_block_i.alu_i.imd_val_q_i\[30\]
+ net1824 _08200_ net1753 _10118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_15004_ net2028 net1752 _10118_ _10119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15005_ net2175 net2111 _01348_ _10120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15006_ _08187_ _10119_ _10120_ _00935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xdelaybuf_1_core_clock delaynet_0_core_clock delaynet_1_core_clock
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xdelaybuf_0_core_clock clk_i delaynet_0_core_clock VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_15009_ net1698 _09627_ _00954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15010_ net1699 _09627_ _00957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15011_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _00963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15012_ _00016_ _00973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15013_ _00020_ _00023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15014_ net1606 net1660 _00977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15015_ _00029_ _00979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15016_ _00028_ _00040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15017_ _09755_ net1652 _00982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15018_ _00050_ _00984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15019_ _09755_ net1622 _00987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15020_ _00049_ _00063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15021_ _00076_ _00077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15022_ _00060_ _00082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15023_ _00100_ _00102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15024_ _00107_ _00998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15025_ net1660 net1644 _01002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15026_ _00106_ _00129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15027_ _00148_ _01006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15028_ _00151_ _00153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15029_ _00170_ _00172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15030_ _00179_ _00181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15031_ net1661 _09814_ _01013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15032_ _00205_ _01015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15033_ _00229_ _00232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15034_ _00202_ _01018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15035_ _00237_ _01021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15036_ _00219_ _00259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15037_ _00264_ _00266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15038_ net1660 _09859_ _01029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15039_ _00290_ _00292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15040_ net2030 ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ net1716 ex_block_i.alu_i.imd_val_q_i\[48\] _10123_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15041_ _10123_ _00295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15042_ _00287_ _00329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15043_ _00333_ _00335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15044_ _00367_ _01036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15045_ _00402_ _01042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15046_ _00361_ _00403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15047_ _00408_ _01044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15048_ _00437_ _01048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15049_ _00396_ _00438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15050_ _00444_ _01050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15051_ _00473_ _01054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15052_ _00431_ _00474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15053_ _00480_ _01056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15054_ _00508_ _01060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15055_ _00467_ _00509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15056_ _00515_ _01062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15057_ _00541_ _01066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15058_ _00502_ _00542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15059_ _00548_ _01068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15060_ _00573_ _01072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15061_ _00535_ _00574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15062_ _00580_ _01074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15063_ _00607_ _01078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15064_ _00567_ _00608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15065_ _00614_ _01080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15066_ _00638_ _01084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15067_ _00600_ _00639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15068_ _00645_ _01086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15069_ _00667_ _01090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15070_ _00631_ _00668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15071_ _00674_ _01092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15072_ _00693_ _01096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15073_ _00660_ _00694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15074_ _00700_ _01098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15075_ _00717_ _01102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15076_ _00685_ _00718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15077_ _00724_ _01104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15078_ _00739_ _01108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15079_ _00709_ _00740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15080_ _00746_ _01110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15081_ _00762_ _01114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15082_ _00731_ _00763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15083_ _00770_ _01116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15084_ _00782_ _01120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15085_ _00790_ _01122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15086_ _00808_ _01129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15087_ net2068 _01187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15088_ net2096 _01233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15089_ net2176 _01240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15090_ _01243_ _01247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15091_ _01250_ _01254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15092_ _01257_ _01261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15093_ net2482 _01268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15094_ _01271_ _01275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15095_ _01278_ _01282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15096_ _01285_ _01289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15097_ _01292_ _01296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15098_ _01299_ _01303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15099_ _01306_ _01310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15100_ _01313_ _01317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15101_ _01320_ _01324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15102_ _01327_ _01331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15103_ _01334_ _01338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1519 _10268_ net1518 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15105_ _00989_ _00059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15106_ _00993_ _00085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15107_ _01003_ _00125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15108_ _01007_ _00149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15109_ _01019_ _00235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15110_ _01025_ _00262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15111_ _01031_ _00288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15112_ _00978_ _00027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15113_ _00983_ _00048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15114_ _00997_ _00105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15115_ _01014_ _00199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15116_ _01037_ _00368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15117_ _07566_ _07557_ _10124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15118_ _07711_ _10124_ _10125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15119_ _08121_ _10125_ _10126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xdelaybuf_2_core_clock delaynet_1_core_clock delaynet_2_core_clock
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_15121_ _07599_ _09699_ _10128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15122_ _10125_ _10128_ _10129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15123_ _07652_ _10129_ net2099 _10130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15124_ _07553_ net31 _10131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15125_ _10130_ _10131_ _10132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15126_ _10126_ load_store_unit_i.data_type_q\[2\] _10132_
+ _01376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15127_ _08158_ _10125_ _10133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xdelaybuf_3_core_clock delaynet_2_core_clock delaynet_3_core_clock
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_15129_ _10133_ load_store_unit_i.data_type_q\[1\] _10132_
+ _01377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15130_ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ _09688_ _01378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15131_ net2032 ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ _09688_ _01379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xdelaybuf_4_core_clock delaynet_3_core_clock delaynet_4_core_clock
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace1518 _10754_ net1517 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15134_ net2031 net2029 _09700_ _01380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1517 _10773_ net1516 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15136_ _09699_ net1750 _10138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15137_ net2028 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ _10138_ _01381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15138_ ex_block_i.gen_multdiv_fast.multdiv_i.div_valid ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ _10138_ _01382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15139_ net1705 _10139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2052 net178 net2051 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15141_ _00950_ _10141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2053 net2177 net2052 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2054 net2177 net2053 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15144_ _10141_ _08008_ _01139_ _10144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15145_ _10139_ _10144_ _10145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15146_ net1611 _01159_ _09627_ _10146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15147_ _01166_ _09627_ _10147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15148_ _10146_ _10147_ _10148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15149_ net1703 net1586 _09627_ _10149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
Xrebuffer2055 _08549_ net2054 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2056 gen_regfile_ff.register_file_i.raddr_a_i\[0\]
+ net2055 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_15152_ cs_registers_i.mhpmcounter\[1856\] _10152_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2057 net2057 net2056 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15154_ net1702 _09627_ _10154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15155_ net1612 _07773_ _10154_ _09544_ _10155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
Xsplit2058 _08942_ net2057 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
X_15157_ _07859_ net1610 _09627_ _10157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15158_ _09575_ _09553_ _10157_ _10158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15159_ _10155_ _10158_ _10159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2059 net2156 net2058 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_15161_ _09551_ _09553_ _10157_ _10161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15162_ _10155_ _10161_ _10162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2060 _08548_ net2059 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15164_ cs_registers_i.mhpmcounter\[1888\] _10164_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15165_ _10152_ _10159_ _10162_ _10164_ _10165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15166_ cs_registers_i.mcycle_counter_i.counter_val_o\[0\]
+ _10166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2062 net1799 net2061 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15168_ cs_registers_i.mcycle_counter_i.counter_val_o\[32\]
+ _10168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15169_ net1700 _09627_ _10169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15170_ net1699 net1698 _01212_ _09627_ _10170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15171_ net1696 _09575_ _10170_ _10171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15172_ _07773_ _09590_ _09591_ _10172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15173_ _10169_ _10171_ _10172_ _10173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15174_ _10166_ _10159_ _10162_ _10168_ _10173_ _10174_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_15175_ _09562_ _09563_ _09567_ _09627_ _10175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_15176_ _10149_ _10165_ _10174_ _10175_ _10176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15177_ net1700 _09568_ _10177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15178_ net1701 _10177_ _09577_ _09579_ _10178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15179_ cs_registers_i.mcountinhibit_q\[0\] _10178_ _10179_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15180_ net1611 _09568_ _10154_ _10180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15181_ net1701 _09625_ _10181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15182_ net1610 _09628_ _09603_ _10181_ _10182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15183_ _10180_ _10182_ _10183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2061 _08548_ net2060 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xrebuffer2064 _07610_ net2063 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15186_ _09628_ _09629_ _09630_ _10186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15187_ net1612 net1586 _07773_ _10154_ _10187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15188_ _10186_ _10187_ _10188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2063 _00861_ net2062 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2067 _07715_ net2066 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15191_ _01198_ _01205_ net1697 _09625_ _10191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15192_ net1701 _07859_ _09625_ _10192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15193_ net1610 _09602_ _10191_ _10192_ _10193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15194_ net1703 _09562_ _09563_ _09589_ _10194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15195_ net1702 _09627_ _10195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15196_ _07773_ _10194_ _10195_ _10196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15197_ _10193_ _10196_ _10197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1516 _03458_ net1515 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15199_ net67 net1563 _10188_ cs_registers_i.dscratch1_q\[0\]
+ _10197_ _10199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15200_ net1611 _01159_ _09598_ _09627_ _10200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_15201_ _10186_ _10200_ _10201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2066 net2204 net2065 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15203_ _10146_ _10186_ _10149_ _10203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xrebuffer2065 net2063 net2064 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2068 _07715_ net2067 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15206_ cs_registers_i.dcsr_q\[0\] _10201_ net1556 cs_registers_i.dscratch0_q\[0\]
+ _10206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15207_ _10179_ _10199_ _10206_ _10207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15208_ _07859_ _01180_ net2068 _09627_ _10208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15209_ net1701 net1696 _10170_ _10208_ _10209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xrebuffer2070 net1800 net2069 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15211_ _10209_ _10187_ _10211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2069 _01191_ net2068 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1515 _04155_ net1514 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15214_ _10146_ _10209_ _10149_ _10214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15215_ cs_registers_i.mtval_q\[0\] _10211_ _10214_ cs_registers_i.mcause_q\[0\]
+ _10215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15216_ _10209_ _10200_ _10216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1514 _06906_ net1513 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15218_ _07773_ _09569_ _10154_ _10218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15219_ _10209_ _10218_ _10219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2071 _01228_ net2070 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15221_ cs_registers_i.mscratch_q\[0\] net1554 net1553 cs_registers_i.csr_mepc_o\[0\]
+ _10221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15222_ _10215_ _10221_ _10222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15223_ _10148_ _10176_ _10207_ _10222_ _10223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15224_ _01139_ _10223_ _10224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15225_ _10145_ _10224_ _10225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15226_ net1697 net1610 _10226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15227_ _10226_ _09622_ _09588_ _10227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15228_ _09584_ _09616_ _10227_ _09636_ _10228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xplace1513 net183 net1512 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15230_ _10178_ net1535 _10230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15231_ cs_registers_i.mcountinhibit_q\[0\] _10225_ _10230_
+ _01383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15232_ _10141_ _08008_ _01151_ _10231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2072 _00821_ net2071 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2073 _01193_ net2072 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15235_ cs_registers_i.mtval_q\[2\] _10211_ _10214_ cs_registers_i.mcause_q\[2\]
+ _10219_ cs_registers_i.csr_mepc_o\[2\] _10234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
Xrebuffer2074 _00849_ net2073 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15237_ net1610 _09602_ _10191_ _10192_ _10236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_15238_ cs_registers_i.dcsr_q\[2\] _10201_ net1556 cs_registers_i.dscratch0_q\[2\]
+ _10218_ _10236_ _10237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15239_ cs_registers_i.mscratch_q\[2\] _10216_ _10238_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15240_ _10186_ _10218_ _10239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2075 _08741_ net2074 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2077 _00877_ net2076 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15243_ cs_registers_i.dscratch1_q\[2\] _10188_ _10239_ cs_registers_i.csr_depc_o\[2\]
+ net89 net1563 _10242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15244_ _10238_ _10242_ _10243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15245_ _07773_ _10154_ _10244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15246_ net1701 _10177_ _10171_ _10244_ _10245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xrebuffer2076 _07993_ net2075 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15248_ _10146_ _10147_ _10247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2078 net2076 net2077 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone2079 net2090 net2078 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xrebuffer2081 _08386_ net2080 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2080 _00873_ net2079 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15253_ cs_registers_i.mcycle_counter_i.counter_val_o\[2\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1858\] _10252_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15254_ cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1890\] _10253_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xplace1512 _10374_ net1511 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15256_ _10159_ _10252_ _10253_ _10162_ _10255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15257_ cs_registers_i.mcountinhibit_q\[2\] _10245_ net1562
+ _10255_ _10256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15258_ _10234_ _10237_ _10243_ _10256_ _10257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15259_ _10139_ _10231_ _10257_ _01155_ _10258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15260_ cs_registers_i.mcountinhibit_q\[2\] _10258_ _10230_
+ _01384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2082 load_store_unit_i.ls_fsm_cs\[2\] net2081 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15262_ _09601_ _10260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15263_ _09558_ _10260_ _10261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15264_ _09615_ net1608 _10228_ _10261_ _10262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15265_ cs_registers_i.mcountinhibit_q\[0\] net1532 _10263_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15266_ _09612_ _09613_ _09614_ _10264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15267_ _10264_ net1535 _10265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15268_ net1532 _10265_ _10266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15269_ _10263_ _10266_ _10267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15270_ cs_registers_i.mcountinhibit_q\[0\] net1532 _10268_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1511 _10855_ net1510 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1510 _10859_ net1509 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15273_ net1532 _10265_ _10271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2083 _00845_ net2082 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15275_ _01139_ _10223_ _10145_ _10273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15276_ cs_registers_i.mcycle_counter_i.counter_val_o\[0\]
+ net1518 _10271_ _10273_ _10274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15277_ cs_registers_i.mcycle_counter_i.counter_val_o\[0\]
+ _10267_ _10274_ _10275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15278_ _10275_ _01385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1508 _04571_ net1507 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1506 _05501_ net1505 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1505 _05592_ net1504 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15282_ _00950_ _08009_ net2102 _10279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15283_ cs_registers_i.mtval_q\[10\] net1555 _10280_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1503 _05610_ net1502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15285_ cs_registers_i.csr_mtvec_o\[10\] _10197_ _10282_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15286_ cs_registers_i.csr_mepc_o\[10\] net1553 _10283_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1502 _06466_ net1501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1504 _05610_ net1503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1501 net182 net1500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15290_ cs_registers_i.mcycle_counter_i.counter_val_o\[10\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1866\] _10287_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xplace1507 net1505 net1506 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15292_ cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1898\] _10289_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15293_ _10159_ _10287_ _10289_ net1560 _10290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15294_ net1562 _10290_ _10291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15295_ cs_registers_i.dscratch0_q\[10\] net1556 _10292_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15296_ cs_registers_i.dscratch1_q\[10\] _10188_ _10239_
+ cs_registers_i.csr_depc_o\[10\] net68 net1563 _10293_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
Xrebuffer2085 _09489_ net2084 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2086 _09113_ net2085 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15299_ cs_registers_i.mscratch_q\[10\] _10216_ _10245_ _10296_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15300_ _10291_ _10292_ _10293_ _10296_ _10297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15301_ _10280_ _10282_ _10283_ _10297_ _10298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15302_ net1705 _10279_ _10298_ net2102 _10299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15303_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[2\] cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[5\] _10300_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15304_ cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[6\] cs_registers_i.mcycle_counter_i.counter_val_o\[8\]
+ _10301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15305_ _01369_ _10300_ _10301_ _10302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15306_ cs_registers_i.mcycle_counter_i.counter_val_o\[9\]
+ _10302_ _10303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15307_ cs_registers_i.mcycle_counter_i.counter_val_o\[10\]
+ _10303_ _10304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_15308_ net1518 _10304_ _10305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15309_ _10263_ _10266_ _10306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15310_ cs_registers_i.mcycle_counter_i.counter_val_o\[10\]
+ _10306_ _10307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15311_ _10266_ _10299_ _10305_ _10307_ _01386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15312_ cs_registers_i.mcycle_counter_i.counter_val_o\[11\]
+ _10308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15313_ cs_registers_i.mcycle_counter_i.counter_val_o\[1\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[0\] _10309_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15314_ _10300_ _10301_ _10309_ _10310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15315_ cs_registers_i.mcycle_counter_i.counter_val_o\[9\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[10\] _10311_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15316_ _10310_ _10311_ _10312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15317_ _10271_ _10312_ net1518 _10313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15318_ _10141_ _08008_ net2159 _10314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15319_ _10139_ _10314_ _10315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15320_ cs_registers_i.mtval_q\[11\] _10316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15321_ net1701 net1696 _10170_ _10208_ _10317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15322_ net1611 _10195_ _09590_ _10318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15323_ cs_registers_i.csr_mtvec_o\[11\] _10319_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15324_ _10316_ _10317_ _10318_ _10193_ _10196_ _10319_ _10320_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_15325_ cs_registers_i.mie_q\[15\] _10180_ _10236_ _10321_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15326_ cs_registers_i.csr_mepc_o\[11\] _10209_ _10218_ _10322_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15327_ _10320_ _10321_ _10322_ _10323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15328_ cs_registers_i.mstatus_q\[2\] _10200_ _10236_ _10324_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15329_ net2050 _10180_ _10209_ _10325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15330_ cs_registers_i.mscratch_q\[11\] _10209_ _10200_ _10326_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15331_ _10245_ _10324_ _10325_ _10326_ _10327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15332_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ _10175_ _10328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15333_ net1703 _09541_ _10329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15334_ cs_registers_i.mhpmcounter\[1899\] net1586 _10329_
+ _10330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15335_ _10328_ _10330_ _10155_ _10161_ _10331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15336_ cs_registers_i.mcycle_counter_i.counter_val_o\[11\]
+ _10175_ _10332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15337_ cs_registers_i.mhpmcounter\[1867\] net1586 _10329_
+ _10333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15338_ _10332_ _10333_ _10155_ _10158_ _10334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15339_ _10331_ _10334_ _10148_ _10335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15340_ cs_registers_i.dscratch1_q\[11\] _10186_ _10187_
+ _10336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15341_ net69 _10337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15342_ _07773_ _09598_ _10195_ _10338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15343_ net1610 _09628_ _09603_ _10181_ _10339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15344_ net1611 _10194_ _10195_ _10340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15345_ cs_registers_i.csr_depc_o\[11\] _10341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15346_ _10337_ _10338_ _10339_ _10340_ _09631_ _10341_ _10342_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_15347_ cs_registers_i.dcsr_q\[11\] _10186_ _10200_ _10343_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15348_ cs_registers_i.dscratch0_q\[11\] _10146_ _10186_
+ _10149_ _10344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15349_ _10336_ _10342_ _10343_ _10344_ _10345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15350_ _10323_ _10327_ _10335_ _10345_ _10346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15351_ net2159 _10346_ _10347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15352_ _10315_ _10347_ _10348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15353_ _10308_ net1518 _10312_ _10349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15354_ _10271_ _10348_ _10349_ _10350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15355_ _10308_ _10313_ _10350_ _01387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15356_ _10159_ net1560 _10351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15357_ _10338_ _10317_ _09626_ _10352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15358_ net1701 net1696 _09629_ _10170_ _10353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15359_ _07859_ _01180_ _09627_ _10354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15360_ _09628_ _10354_ _09544_ _09545_ _10355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15361_ _10209_ _10353_ _10355_ _10356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15362_ _10352_ _10356_ _10357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15363_ net1701 _09570_ _10171_ _10244_ _10358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15364_ _10171_ _10359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15365_ _07773_ _10194_ _09598_ _09627_ _10360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15366_ _09625_ _09593_ _10361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15367_ _10169_ _10172_ _10360_ _10361_ _10362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15368_ _10158_ _10161_ _10155_ _10363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15369_ net1699 net1698 _09627_ _10364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15370_ _10364_ _09629_ _09630_ _10365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15371_ net1611 _01159_ net1697 _09627_ _10366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15372_ _10180_ _10182_ _10365_ _10366_ _10367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15373_ _10359_ _10362_ _10363_ _10367_ _10368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15374_ _09636_ _10369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15375_ _10357_ _10358_ _10368_ _10369_ _10370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_15376_ _10226_ _09622_ _09625_ _10371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15377_ _10370_ _10371_ _10372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xrebuffer2087 load_store_unit_i.ls_fsm_cs\[1\] net2086 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_15379_ _10175_ _10351_ _10372_ net1562 _10374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
Xrebuffer2088 net2086 net2087 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15381_ cs_registers_i.mcountinhibit_q\[0\] _10376_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__inv_2
X_15382_ cs_registers_i.mcycle_counter_i.counter_val_o\[11\]
+ _10376_ _10377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15383_ _10302_ _10311_ _10377_ _10378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15384_ cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ _10378_ _10379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15385_ _00950_ _08009_ net1704 _10380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15386_ cs_registers_i.mtval_q\[12\] _10381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15387_ cs_registers_i.csr_mtvec_o\[12\] _10382_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15388_ _10381_ _10317_ _10318_ _10193_ _10196_ _10382_ _10383_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_15389_ cs_registers_i.mstatus_q\[3\] _10200_ _10236_ _10384_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15390_ cs_registers_i.csr_mepc_o\[12\] _10209_ _10218_ _10385_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15391_ _10383_ _10384_ _10385_ _10386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15392_ cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ _10175_ _10387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15393_ cs_registers_i.mhpmcounter\[1900\] net1586 _10329_
+ _10388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15394_ _10387_ _10388_ _10155_ _10161_ _10389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15395_ cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ _10175_ _10390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15396_ cs_registers_i.mhpmcounter\[1868\] net1586 _10329_
+ _10391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15397_ _10390_ _10391_ _10155_ _10158_ _10392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15398_ _10389_ _10392_ _10148_ _10393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15399_ cs_registers_i.csr_depc_o\[12\] _10186_ _10218_ _10394_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15400_ net70 _10395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15401_ cs_registers_i.dscratch1_q\[12\] _10396_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15402_ _10395_ _10338_ _10339_ _10318_ _09631_ _10396_ _10397_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai33_2
X_15403_ cs_registers_i.dscratch0_q\[12\] _10146_ _10186_
+ _10149_ _10398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15404_ cs_registers_i.dcsr_q\[12\] _10186_ _10200_ _10399_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15405_ _10394_ _10397_ _10398_ _10399_ _10400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15406_ cs_registers_i.mscratch_q\[12\] _10209_ _10200_ _10401_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15407_ _10358_ _10401_ _10402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15408_ _10386_ _10393_ _10400_ _10402_ _10403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15409_ net1705 _10380_ _10403_ net1704 _10404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15410_ _09627_ _09598_ _10405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15411_ _07859_ _09627_ _10406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15412_ net1699 net1610 _10406_ _09576_ _10407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15413_ _09551_ _09575_ _10155_ _10407_ _10408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15414_ net1701 _10171_ _10244_ _10409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15415_ _09570_ _10409_ _10410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15416_ _01187_ _10354_ _10411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15417_ net1696 _09628_ _09544_ _10411_ _10412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15418_ _10209_ _10353_ _10412_ _10352_ _10413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_15419_ _10359_ _10362_ _10414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15420_ net1610 _09628_ _10415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15421_ _10180_ _10415_ _09603_ _10181_ _10416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15422_ _01166_ net1696 _09629_ _10417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15423_ _10364_ _10417_ _10366_ _10418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15424_ _10408_ _10416_ _10418_ _10419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15425_ _10410_ _10413_ _10414_ _10419_ _10420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15426_ _09636_ _10420_ _10371_ _10421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15427_ _10405_ _10408_ _10421_ _10148_ _10422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15428_ _09551_ _10155_ _10407_ _10423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15429_ _10423_ _10421_ _10424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15430_ _10422_ _10424_ _10425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xsplit2089 _00865_ net2088 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
Xplace1500 net181 net1499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15433_ _10378_ _10265_ net1532 _10428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15434_ cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ _10428_ _10429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15435_ net1511 _10379_ _10404_ _10425_ _10429_ _01388_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15436_ _10141_ _08008_ net2070 _10430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15437_ _10139_ _10430_ _10431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15438_ cs_registers_i.mtval_q\[13\] net1555 _10216_ cs_registers_i.mscratch_q\[13\]
+ _10197_ cs_registers_i.csr_mtvec_o\[13\] _10432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
Xrebuffer2091 gen_regfile_ff.register_file_i.raddr_b_i\[1\]
+ net2090 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace1498 _04697_ net1497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15441_ cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1869\] _10435_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15442_ cs_registers_i.mcycle_counter_i.counter_val_o\[45\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1901\] _10436_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15443_ _10159_ _10435_ _10436_ net1560 _10437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15444_ net1562 _10437_ _10438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1497 _05046_ net1496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1495 _05574_ net1494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1496 _05574_ net1495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15448_ cs_registers_i.dscratch1_q\[13\] _10188_ net1552
+ cs_registers_i.csr_depc_o\[13\] net71 net1563 _10442_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15449_ cs_registers_i.dcsr_q\[13\] _10201_ net1556 cs_registers_i.dscratch0_q\[13\]
+ _10443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15450_ _10442_ _10443_ _10444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15451_ cs_registers_i.csr_mepc_o\[13\] net1553 _10245_ _10445_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15452_ _10432_ _10438_ _10444_ _10445_ _10446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15453_ _01232_ _10446_ _10447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15454_ _10431_ _10447_ _10448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15455_ cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ _10312_ _10377_ _10449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15456_ _10264_ net1535 _10450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15457_ _10449_ _10450_ net1532 _10451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15458_ cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ _10451_ _10452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15459_ cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ net1532 _10449_ _10453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15460_ _10266_ _10448_ _10452_ _10453_ _01389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15461_ _10155_ _10161_ _10454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15462_ _10454_ _10372_ _10455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15463_ net1511 _10455_ _10456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15464_ _00950_ _08009_ net1685 _10457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15465_ cs_registers_i.mtval_q\[14\] net1555 net1553 cs_registers_i.csr_mepc_o\[14\]
+ _10197_ cs_registers_i.csr_mtvec_o\[14\] _10458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15466_ _10458_ _10459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1494 _05579_ net1493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1493 _05584_ net1492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15469_ cs_registers_i.mcycle_counter_i.counter_val_o\[14\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1870\] _10462_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15470_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1902\] _10463_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15471_ _10159_ _10462_ _10463_ net1560 _10464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15472_ net1562 _10464_ _10465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15473_ cs_registers_i.dscratch0_q\[14\] net1556 _10466_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15474_ cs_registers_i.dscratch1_q\[14\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[14\] net72 net1563 _10467_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
Xplace1492 _05596_ net1491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15476_ cs_registers_i.mscratch_q\[14\] _10216_ _10245_ _10469_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15477_ _10465_ _10466_ _10467_ _10469_ _10470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15478_ _10459_ _10470_ _10471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15479_ net1705 _10457_ _10471_ net1685 _10472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15480_ cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ _10379_ _10473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15481_ _10175_ _10454_ _10372_ net1562 _10474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15482_ net1511 _10473_ _10474_ _10475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15483_ cs_registers_i.mcycle_counter_i.counter_val_o\[14\]
+ _10475_ _10476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15484_ cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[14\] net1511
+ _10379_ _10477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15485_ _10456_ _10472_ _10476_ _10477_ _01390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_15486_ _10141_ _08008_ net1684 _10478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15487_ cs_registers_i.mtval_q\[15\] net1555 _10216_ cs_registers_i.mscratch_q\[15\]
+ _10197_ cs_registers_i.csr_mtvec_o\[15\] _10479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
Xplace1491 _05600_ net1490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15489_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1871\] _10481_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15490_ cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1903\] _10482_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15491_ _10159_ _10481_ _10482_ net1560 _10483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15492_ net1562 _10483_ _10484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15493_ cs_registers_i.dscratch1_q\[15\] _10188_ _10239_
+ cs_registers_i.csr_depc_o\[15\] net73 net1563 _10485_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15494_ cs_registers_i.dcsr_q\[15\] _10201_ net1556 cs_registers_i.dscratch0_q\[15\]
+ _10486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15495_ _10485_ _10486_ _10487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2092 net2090 net2091 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1499 _04697_ net1498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15498_ cs_registers_i.csr_mepc_o\[15\] net1553 _10245_ _10490_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15499_ _10479_ _10484_ _10487_ _10490_ _10491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15500_ _10139_ _10478_ _10491_ _01246_ _10492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xplace1490 _05602_ net1489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15502_ _10425_ net1531 _10494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15503_ cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[11\] cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[14\] _10495_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15504_ _10311_ _10495_ _10496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15505_ _10310_ _10496_ _10497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15506_ net1518 _10497_ _10498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2093 _08098_ net2092 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15508_ _10271_ _10497_ net1518 _10500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15509_ _10498_ _10500_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ _10501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15510_ _10494_ _10501_ _01391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15511_ net1511 _10455_ _10502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1489 _05606_ net1488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1488 _05614_ net1487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_15514_ _10141_ _08008_ net1683 _10505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15515_ _10139_ _10505_ _10506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15516_ _10180_ _10209_ _10507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1487 _05619_ net1486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1481 _05664_ net1480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15519_ net135 _10507_ net1554 cs_registers_i.mscratch_q\[16\]
+ net1553 cs_registers_i.csr_mepc_o\[16\] _10510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15520_ cs_registers_i.mtval_q\[16\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[16\]
+ _10511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15521_ _10180_ _10236_ _10512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1479 _05675_ net1478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15523_ cs_registers_i.mie_q\[0\] _10512_ _10245_ _10514_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15524_ _10511_ _10514_ _10515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15525_ cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1872\] _10516_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15526_ cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1904\] _10517_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15527_ net1561 _10516_ _10517_ net1560 _10518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15528_ net1562 _10518_ _10519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15529_ cs_registers_i.dscratch0_q\[16\] net1556 _10520_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15530_ cs_registers_i.dscratch1_q\[16\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[16\] net74 net1563 _10521_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15531_ _10520_ _10521_ _10522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15532_ _10510_ _10515_ _10519_ _10522_ _10523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15533_ net1683 _10523_ _10524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15534_ _10506_ _10524_ _10525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15535_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ _10302_ _10496_ _10526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15536_ net1518 _10526_ _10527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15537_ _10263_ _10526_ _10528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15538_ _10306_ _10528_ cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ _10529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15539_ _10502_ _10525_ _10527_ cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ _10529_ _01392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_15540_ _00950_ _08009_ _01256_ _10530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15541_ cs_registers_i.csr_mepc_o\[17\] net1553 _10197_ cs_registers_i.csr_mtvec_o\[17\]
+ _10531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15542_ cs_registers_i.mtval_q\[17\] net1555 _10216_ cs_registers_i.mscratch_q\[17\]
+ _10532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15543_ _10531_ _10532_ _10533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15544_ net2047 _10507_ _10512_ cs_registers_i.mie_q\[1\]
+ _10534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15545_ _10200_ _10236_ _10535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15546_ cs_registers_i.mstatus_q\[1\] _10535_ _10245_ _10536_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15547_ _10534_ _10536_ _10537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15548_ cs_registers_i.mcycle_counter_i.counter_val_o\[17\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1873\] _10538_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15549_ cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1905\] _10539_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15550_ net1561 _10538_ _10539_ net1560 _10540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15551_ net1562 _10540_ _10541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15552_ cs_registers_i.dscratch0_q\[17\] net1556 _10542_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15553_ cs_registers_i.dscratch1_q\[17\] _10188_ net1552
+ cs_registers_i.csr_depc_o\[17\] net75 net1563 _10543_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15554_ _10542_ _10543_ _10544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15555_ _10533_ _10537_ _10541_ _10544_ _10545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15556_ net1705 _10530_ _10545_ _01256_ _10546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15557_ _10376_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[16\] _10497_
+ _10547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15558_ net1511 _10547_ _10474_ _10548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15559_ cs_registers_i.mcycle_counter_i.counter_val_o\[17\]
+ _10548_ _10549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15560_ _10547_ _10550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15561_ cs_registers_i.mcycle_counter_i.counter_val_o\[17\]
+ net1511 _10550_ _10551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15562_ _10456_ _10546_ _10549_ _10551_ _01393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_15563_ _10141_ _08008_ net1682 _10552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15564_ _10139_ _10552_ _10553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15565_ net2046 _10507_ net1554 cs_registers_i.mscratch_q\[18\]
+ net1553 cs_registers_i.csr_mepc_o\[18\] _10554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15566_ cs_registers_i.mtval_q\[18\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[18\]
+ _10555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15567_ cs_registers_i.mie_q\[2\] _10512_ _10245_ _10556_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15568_ _10555_ _10556_ _10557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15569_ cs_registers_i.mcycle_counter_i.counter_val_o\[18\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1874\] _10558_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15570_ cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1906\] _10559_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15571_ net1561 _10558_ _10559_ net1560 _10560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15572_ net1562 _10560_ _10561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15573_ cs_registers_i.dscratch0_q\[18\] net1556 _10562_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15574_ cs_registers_i.dscratch1_q\[18\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[18\] net76 net1563 _10563_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15575_ _10562_ _10563_ _10564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15576_ _10554_ _10557_ _10561_ _10564_ _10565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15577_ net1682 _10565_ _10566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15578_ _10553_ _10566_ _10567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15579_ cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[17\] _10526_
+ _10568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15580_ net1518 _10568_ _10569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15581_ _10306_ _10569_ cs_registers_i.mcycle_counter_i.counter_val_o\[18\]
+ _10570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15582_ cs_registers_i.mcycle_counter_i.counter_val_o\[18\]
+ _10263_ _10568_ _10571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15583_ _10266_ _10567_ _10570_ _10571_ _01394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15584_ _10141_ _08008_ net1681 _10572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15585_ _10139_ _10572_ _10573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15586_ net2045 _10507_ net1554 cs_registers_i.mscratch_q\[19\]
+ net1553 cs_registers_i.csr_mepc_o\[19\] _10574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15587_ cs_registers_i.mtval_q\[19\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[19\]
+ _10575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15588_ cs_registers_i.mie_q\[3\] _10512_ _10245_ _10576_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15589_ _10575_ _10576_ _10577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15590_ cs_registers_i.mcycle_counter_i.counter_val_o\[19\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1875\] _10578_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15591_ cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1907\] _10579_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15592_ net1561 _10578_ _10579_ net1560 _10580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15593_ net1562 _10580_ _10581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15594_ cs_registers_i.dscratch0_q\[19\] net1556 _10582_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15595_ cs_registers_i.dscratch1_q\[19\] _10188_ net1552
+ cs_registers_i.csr_depc_o\[19\] net77 net1563 _10583_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15596_ _10582_ _10583_ _10584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15597_ _10574_ _10577_ _10581_ _10584_ _10585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15598_ net1681 _10585_ _10586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15599_ _10573_ _10586_ _10587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15600_ cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[17\] cs_registers_i.mcycle_counter_i.counter_val_o\[18\]
+ _10588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15601_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ _10310_ _10496_ _10588_ _10589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15602_ cs_registers_i.mcycle_counter_i.counter_val_o\[19\]
+ _10589_ _10590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_15603_ _10271_ _10587_ _10590_ net1518 _10591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15604_ cs_registers_i.mcycle_counter_i.counter_val_o\[19\]
+ _10306_ _10592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15605_ _10591_ _10592_ _01395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15606_ cs_registers_i.mcycle_counter_i.counter_val_o\[1\]
+ _10593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15607_ _10141_ _08008_ _01145_ _10594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15608_ _10139_ _10594_ _10595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15609_ cs_registers_i.mtval_q\[1\] _10211_ net1553 cs_registers_i.csr_mepc_o\[1\]
+ _10596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15610_ cs_registers_i.mcause_q\[1\] _10214_ _10216_ cs_registers_i.mscratch_q\[1\]
+ _10597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15611_ _10596_ _10597_ _10598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15612_ cs_registers_i.mcycle_counter_i.counter_val_o\[1\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1857\] _10599_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15613_ cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1889\] _10600_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15614_ _10159_ _10599_ _10600_ _10162_ _10601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15615_ net1562 _10601_ _10602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15616_ cs_registers_i.dscratch1_q\[1\] _10188_ _10239_ cs_registers_i.csr_depc_o\[1\]
+ net78 net1563 _10603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15617_ cs_registers_i.dcsr_q\[1\] _10201_ net1556 cs_registers_i.dscratch0_q\[1\]
+ _10604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15618_ _10598_ _10602_ _10603_ _10604_ _10605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15619_ _01145_ _10605_ _10606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15620_ _10595_ _10606_ _10607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15621_ _01370_ _10263_ _10266_ _10607_ _10608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15622_ _10593_ _10306_ _10608_ _01396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15623_ _10141_ _08008_ net2135 _10609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15624_ _10139_ _10609_ _10610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15625_ cs_registers_i.mtval_q\[20\] _10211_ net1554 cs_registers_i.mscratch_q\[20\]
+ net1553 cs_registers_i.csr_mepc_o\[20\] _10611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15626_ net2044 _10507_ net1557 cs_registers_i.csr_mtvec_o\[20\]
+ _10612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15627_ cs_registers_i.mie_q\[4\] _10512_ _10358_ _10613_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15628_ _10612_ _10613_ _10614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15629_ cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1876\] _10615_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15630_ cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1908\] _10616_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15631_ net1561 _10615_ _10616_ net1560 _10617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15632_ net1562 _10617_ _10618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15633_ cs_registers_i.dscratch0_q\[20\] net1556 _10619_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15634_ cs_registers_i.dscratch1_q\[20\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[20\] net79 net1563 _10620_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15635_ _10619_ _10620_ _10621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15636_ _10611_ _10614_ _10618_ _10621_ _10622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15637_ _01281_ _10622_ _10623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15638_ _10610_ _10623_ _10624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15639_ _10425_ _10624_ _10625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15640_ cs_registers_i.mcycle_counter_i.counter_val_o\[19\]
+ _10526_ _10588_ _10626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15641_ net1518 _10626_ _10627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15642_ _10271_ _10626_ net1518 _10628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15643_ _10627_ _10628_ cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ _10629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15644_ _10625_ _10629_ _01397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15645_ _10141_ _08008_ net1680 _10630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15646_ _10139_ _10630_ _10631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15647_ cs_registers_i.csr_mepc_o\[21\] net1553 net1557 cs_registers_i.csr_mtvec_o\[21\]
+ _10632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15648_ cs_registers_i.mtval_q\[21\] _10211_ net1554 cs_registers_i.mscratch_q\[21\]
+ _10633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15649_ _10632_ _10633_ _10634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15650_ net2043 _10507_ _10512_ cs_registers_i.mie_q\[5\]
+ _10635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15651_ cs_registers_i.csr_mstatus_tw_o _10535_ _10245_ _10636_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15652_ _10635_ _10636_ _10637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15653_ cs_registers_i.mcycle_counter_i.counter_val_o\[21\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1877\] _10638_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15654_ cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1909\] _10639_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15655_ _10159_ _10638_ _10639_ net1560 _10640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15656_ net1562 _10640_ _10641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15657_ cs_registers_i.dscratch0_q\[21\] net1556 _10642_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15658_ cs_registers_i.dscratch1_q\[21\] _10188_ _10239_
+ cs_registers_i.csr_depc_o\[21\] net80 net1563 _10643_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15659_ _10642_ _10643_ _10644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15660_ _10634_ _10637_ _10641_ _10644_ _10645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15661_ net1680 _10645_ _10646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15662_ _10631_ _10646_ _10647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15663_ cs_registers_i.mcycle_counter_i.counter_val_o\[21\]
+ _10271_ _10648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15664_ cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[19\] _10497_
+ _10588_ _10649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15665_ cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ net1518 _10649_ _10650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15666_ _10648_ cs_registers_i.mcycle_counter_i.counter_val_o\[21\]
+ _10650_ _10651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15667_ _10425_ _10647_ _10651_ _01398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15668_ _00950_ _08009_ net1679 _10652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15669_ net2042 _10507_ net1554 cs_registers_i.mscratch_q\[22\]
+ net1553 cs_registers_i.csr_mepc_o\[22\] _10653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15670_ cs_registers_i.mtval_q\[22\] _10211_ net1557 cs_registers_i.csr_mtvec_o\[22\]
+ _10654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15671_ cs_registers_i.mie_q\[6\] _10512_ _10245_ _10655_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15672_ cs_registers_i.mcycle_counter_i.counter_val_o\[22\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1878\] _10656_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15673_ cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1910\] _10657_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15674_ net1561 _10656_ _10657_ net1560 _10658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15675_ cs_registers_i.dscratch1_q\[22\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[22\] net81 net1563 _10659_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15676_ _10659_ _10660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15677_ cs_registers_i.dscratch0_q\[22\] net1556 _10658_
+ net1562 _10660_ _10661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15678_ _10653_ _10654_ _10655_ _10661_ _10662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15679_ net1705 _10652_ _10662_ net1679 _10663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15680_ cs_registers_i.mcycle_counter_i.counter_val_o\[22\]
+ _10271_ _10664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15681_ cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[21\] net1518
+ _10626_ _10665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15682_ cs_registers_i.mcycle_counter_i.counter_val_o\[22\]
+ _10664_ _10665_ _10666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15683_ _10425_ _10663_ _10666_ _01399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15684_ _00950_ _08009_ net1678 _10667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15685_ net2041 _10507_ net1554 cs_registers_i.mscratch_q\[23\]
+ net1553 cs_registers_i.csr_mepc_o\[23\] _10668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15686_ cs_registers_i.mtval_q\[23\] _10211_ net1557 cs_registers_i.csr_mtvec_o\[23\]
+ _10669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15687_ cs_registers_i.mie_q\[7\] _10512_ _10245_ _10670_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15688_ cs_registers_i.mcycle_counter_i.counter_val_o\[23\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1879\] _10671_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15689_ cs_registers_i.mcycle_counter_i.counter_val_o\[55\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1911\] _10672_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15690_ net1561 _10671_ _10672_ net1560 _10673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15691_ cs_registers_i.dscratch1_q\[23\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[23\] net82 net1563 _10674_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15692_ _10674_ _10675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15693_ cs_registers_i.dscratch0_q\[23\] net1556 _10673_
+ net1562 _10675_ _10676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15694_ _10668_ _10669_ _10670_ _10676_ _10677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15695_ net1705 _10667_ _10677_ net1678 _10678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15696_ cs_registers_i.mcycle_counter_i.counter_val_o\[23\]
+ _10271_ _10679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15697_ cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[21\] cs_registers_i.mcycle_counter_i.counter_val_o\[22\]
+ _10680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15698_ net1518 _10649_ _10680_ _10681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15699_ _10679_ cs_registers_i.mcycle_counter_i.counter_val_o\[23\]
+ _10681_ _10682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15700_ _10425_ _10678_ _10682_ _01400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15701_ _10141_ _08008_ net1677 _10683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15702_ _10139_ _10683_ _10684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15703_ net2040 _10507_ net1554 cs_registers_i.mscratch_q\[24\]
+ net1553 cs_registers_i.csr_mepc_o\[24\] _10685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15704_ cs_registers_i.mtval_q\[24\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[24\]
+ _10686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15705_ cs_registers_i.mie_q\[8\] _10512_ _10245_ _10687_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15706_ _10686_ _10687_ _10688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15707_ cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1880\] _10689_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15708_ cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1912\] _10690_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15709_ net1561 _10689_ _10690_ net1560 _10691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15710_ net1562 _10691_ _10692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15711_ cs_registers_i.dscratch0_q\[24\] net1556 _10693_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15712_ cs_registers_i.dscratch1_q\[24\] _10188_ net1552
+ cs_registers_i.csr_depc_o\[24\] net83 net1563 _10694_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15713_ _10693_ _10694_ _10695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15714_ _10685_ _10688_ _10692_ _10695_ _10696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15715_ net1677 _10696_ _10697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15716_ _10684_ _10697_ _10698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15717_ cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ _10266_ _10699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15718_ cs_registers_i.mcycle_counter_i.counter_val_o\[23\]
+ _10680_ _10700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15719_ net1518 _10626_ _10700_ _10701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15720_ cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ _10699_ _10701_ _10702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15721_ _10502_ _10698_ _10702_ _01401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15722_ cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[25\] _10700_
+ _10703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15723_ _10649_ _10703_ _10704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15724_ _00950_ _08009_ _01312_ _10705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15725_ net2039 _10507_ net1554 cs_registers_i.mscratch_q\[25\]
+ net1553 cs_registers_i.csr_mepc_o\[25\] _10706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15726_ cs_registers_i.mtval_q\[25\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[25\]
+ _10707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15727_ cs_registers_i.mie_q\[9\] _10512_ _10245_ _10708_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15728_ cs_registers_i.mcycle_counter_i.counter_val_o\[25\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1881\] _10709_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15729_ cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1913\] _10710_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15730_ net1561 _10709_ _10710_ net1560 _10711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15731_ cs_registers_i.dscratch1_q\[25\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[25\] net84 net1563 _10712_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15732_ _10712_ _10713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15733_ cs_registers_i.dscratch0_q\[25\] net1556 _10711_
+ net1562 _10713_ _10714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15734_ _10706_ _10707_ _10708_ _10714_ _10715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15735_ net1705 _10705_ _10715_ _01312_ _10716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15736_ cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ net1518 _10649_ _10700_ _10717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15737_ cs_registers_i.mcycle_counter_i.counter_val_o\[25\]
+ _10456_ _10717_ _10718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15738_ net1518 _10704_ _10716_ _10456_ _10718_ _01402_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15739_ cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ _10719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15740_ _10141_ _08008_ _01319_ _10720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15741_ _10139_ _10720_ _10721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15742_ net136 _10507_ net1554 cs_registers_i.mscratch_q\[26\]
+ net1553 cs_registers_i.csr_mepc_o\[26\] _10722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15743_ cs_registers_i.mtval_q\[26\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[26\]
+ _10723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15744_ cs_registers_i.mie_q\[10\] _10512_ _10245_ _10724_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15745_ _10723_ _10724_ _10725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15746_ cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1882\] _10726_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15747_ cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1914\] _10727_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15748_ net1561 _10726_ _10727_ net1560 _10728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15749_ net1562 _10728_ _10729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15750_ cs_registers_i.dscratch0_q\[26\] net1556 _10730_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15751_ cs_registers_i.dscratch1_q\[26\] _10188_ net1552
+ cs_registers_i.csr_depc_o\[26\] net85 net1563 _10731_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15752_ _10730_ _10731_ _10732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15753_ _10722_ _10725_ _10729_ _10732_ _10733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15754_ _01319_ _10733_ _10734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15755_ _10721_ _10734_ _10735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1477 _05681_ net1476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15757_ _10626_ _10703_ _10737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15758_ _10719_ _10737_ _10738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_15759_ _10271_ _10735_ _10738_ net1518 _10739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15760_ _10719_ _10267_ _10739_ _01403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15761_ cs_registers_i.mcycle_counter_i.counter_val_o\[27\]
+ _10271_ _10740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15762_ cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ net1518 _10704_ _10741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15763_ _10740_ cs_registers_i.mcycle_counter_i.counter_val_o\[27\]
+ _10741_ _10742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15764_ _10141_ _08008_ _01326_ _10743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15765_ cs_registers_i.mtval_q\[27\] _10211_ net1554 cs_registers_i.mscratch_q\[27\]
+ net1553 cs_registers_i.csr_mepc_o\[27\] _10744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15766_ net2049 _10507_ net1558 cs_registers_i.csr_mtvec_o\[27\]
+ _10745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15767_ cs_registers_i.mie_q\[11\] _10512_ _10245_ _10746_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15768_ cs_registers_i.mcycle_counter_i.counter_val_o\[27\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1883\] _10747_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15769_ cs_registers_i.mcycle_counter_i.counter_val_o\[59\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1915\] _10748_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15770_ net1561 _10747_ _10748_ net1560 _10749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15771_ cs_registers_i.dscratch1_q\[27\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[27\] net86 net1563 _10750_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15772_ _10750_ _10751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15773_ cs_registers_i.dscratch0_q\[27\] net1556 _10749_
+ net1562 _10751_ _10752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15774_ _10744_ _10745_ _10746_ _10752_ _10753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15775_ _10139_ _10743_ _10753_ _01330_ _10754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xplace1475 _05685_ net1474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_15777_ _10502_ net1517 _10756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15778_ _10742_ _10756_ _01404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15779_ cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[27\] _10757_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15780_ _10376_ _10737_ _10757_ _10758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15781_ _10758_ _10450_ net1532 _10759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15782_ cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ _10759_ _10760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15783_ net2048 _10507_ net1554 cs_registers_i.mscratch_q\[28\]
+ net1553 cs_registers_i.csr_mepc_o\[28\] _10761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15784_ cs_registers_i.mtval_q\[28\] _10211_ net1558 cs_registers_i.csr_mtvec_o\[28\]
+ _10762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15785_ cs_registers_i.mie_q\[12\] _10512_ _10245_ _10763_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15786_ cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1884\] _10764_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15787_ cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1916\] _10765_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15788_ net1561 _10764_ _10765_ net1560 _10766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15789_ cs_registers_i.dscratch1_q\[28\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[28\] net87 net1563 _10767_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15790_ _10767_ _10768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15791_ cs_registers_i.dscratch0_q\[28\] net1556 _10766_
+ net1562 _10768_ _10769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15792_ _10761_ _10762_ _10763_ _10769_ _10770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15793_ _00950_ _08009_ net1676 _10771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15794_ net1705 _10771_ _10772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15795_ _01337_ _10770_ _10772_ _10773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1473 _05693_ net1472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15797_ _10271_ net1516 _10775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15798_ cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ net1532 _10758_ _10776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15799_ _10760_ _10775_ _10776_ _01405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15800_ _00950_ _08009_ net1675 _10777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15801_ net139 _10507_ net1554 cs_registers_i.mscratch_q\[29\]
+ net1553 cs_registers_i.csr_mepc_o\[29\] _10778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15802_ cs_registers_i.mtval_q\[29\] _10211_ net1557 cs_registers_i.csr_mtvec_o\[29\]
+ _10779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15803_ cs_registers_i.mie_q\[13\] _10512_ _10245_ _10780_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15804_ cs_registers_i.mcycle_counter_i.counter_val_o\[29\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1885\] _10781_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15805_ cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1917\] _10782_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15806_ net1561 _10781_ _10782_ net1560 _10783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15807_ cs_registers_i.dscratch1_q\[29\] net1559 _10239_
+ cs_registers_i.csr_depc_o\[29\] net88 net1563 _10784_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15808_ _10784_ _10785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15809_ cs_registers_i.dscratch0_q\[29\] net1556 _10783_
+ net1562 _10785_ _10786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15810_ _10778_ _10779_ _10780_ _10786_ _10787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15811_ net1705 _10777_ _10787_ net1675 _10788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15812_ cs_registers_i.mcycle_counter_i.counter_val_o\[29\]
+ _10271_ _10789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15813_ cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ net1518 _10704_ _10757_ _10790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15814_ _10789_ cs_registers_i.mcycle_counter_i.counter_val_o\[29\]
+ _10790_ _10791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15815_ _10425_ _10788_ _10791_ _01406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15816_ _10258_ _10792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15817_ _10175_ net1562 _10793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15818_ _10423_ _10421_ _10793_ _10794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
X_15819_ _10376_ _01369_ net1532 _10795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15820_ net1530 _10795_ _10796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15821_ _01369_ net1518 _10797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15822_ _10796_ _10797_ cs_registers_i.mcycle_counter_i.counter_val_o\[2\]
+ _10798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15823_ _10792_ _10425_ _10798_ _01407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15824_ cs_registers_i.mcycle_counter_i.counter_val_o\[30\]
+ _10799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15825_ cs_registers_i.mtval_q\[30\] net1555 net1557 cs_registers_i.csr_mtvec_o\[30\]
+ _10512_ cs_registers_i.mie_q\[14\] _10800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15826_ net140 _10507_ net1554 cs_registers_i.mscratch_q\[30\]
+ _10801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15827_ cs_registers_i.csr_mepc_o\[30\] net1553 _10358_ _10802_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15828_ cs_registers_i.mcycle_counter_i.counter_val_o\[30\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1886\] _10803_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15829_ cs_registers_i.mcycle_counter_i.counter_val_o\[62\]
+ net1609 net1564 cs_registers_i.mhpmcounter\[1918\] _10804_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15830_ _10159_ _10803_ _10804_ net1560 _10805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15831_ cs_registers_i.dscratch1_q\[30\] _10188_ _10201_
+ _10806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15832_ net90 net1563 net1552 cs_registers_i.csr_depc_o\[30\]
+ _10807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15833_ _10806_ _10807_ _10808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15834_ cs_registers_i.dscratch0_q\[30\] net1556 _10805_
+ net1562 _10808_ _10809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15835_ _10800_ _10801_ _10802_ _10809_ _10810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15836_ _00950_ _08009_ _01347_ _10811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15837_ net1705 _10811_ _10812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_15838_ _01351_ _10810_ _10812_ _10813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15839_ cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[27\] cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[29\] _10814_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15840_ _10737_ _10814_ _10815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15841_ _10799_ _10815_ _10816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_15842_ _10271_ _10813_ _10816_ net1518 _10817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15843_ _10799_ _10267_ _10817_ _01408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15844_ cs_registers_i.mcycle_counter_i.counter_val_o\[31\]
+ _10818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15845_ cs_registers_i.mcycle_counter_i.counter_val_o\[30\]
+ _10814_ _10819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15846_ _10704_ _10819_ _10820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15847_ _10271_ _10820_ net1518 _10821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15848_ _10818_ _10820_ _10822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15849_ cs_registers_i.mcause_q\[5\] _10214_ _10216_ cs_registers_i.mscratch_q\[31\]
+ _10823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15850_ cs_registers_i.mtval_q\[31\] net1555 net1553 cs_registers_i.csr_mepc_o\[31\]
+ _10824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15851_ _10823_ _10824_ _10825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15852_ _09628_ _10417_ _10826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15853_ cs_registers_i.csr_depc_o\[31\] _10826_ _10218_ _10827_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15854_ _10180_ _10415_ _09603_ _10181_ _10828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15855_ net91 _10828_ _10829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15856_ cs_registers_i.dscratch1_q\[31\] _10826_ _10187_
+ _10830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15857_ _10827_ _10829_ _10830_ _10831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15858_ cs_registers_i.dscratch0_q\[31\] _10832_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_15859_ _10146_ _10149_ _10833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15860_ _10826_ _10833_ _10834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15861_ cs_registers_i.csr_mtvec_o\[31\] _10197_ _10835_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15862_ _10177_ _10409_ _10836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15863_ _10832_ _10834_ _10835_ _10836_ _10837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_15864_ _09575_ _10155_ _10407_ _10838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15865_ cs_registers_i.mcycle_counter_i.counter_val_o\[31\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1887\] _10839_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15866_ cs_registers_i.mcycle_counter_i.counter_val_o\[63\]
+ net1609 net1565 cs_registers_i.mhpmcounter\[1919\] _10840_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15867_ _10838_ _10839_ _10840_ _10423_ _10841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15868_ net1562 _10841_ _10842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15869_ _10825_ _10831_ _10837_ _10842_ _10843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_15870_ _08008_ _10141_ _09470_ _10844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15871_ _10139_ _10844_ _10845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15872_ _09470_ _10843_ _10845_ _10846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15873_ net1518 _10822_ _10846_ _10425_ _10847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15874_ _10818_ _10821_ _10847_ _01409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1464 _05715_ net1463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15876_ cs_registers_i.mcycle_counter_i.counter_val_o\[31\]
+ _10737_ _10819_ _10849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15877_ _10162_ _10370_ _10371_ _10793_ _10850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_15878_ _10376_ _10850_ _10851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15879_ _10849_ _10851_ _10852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15880_ _10849_ _10852_ _10168_ _10853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1462 _05719_ net1461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15882_ net1518 _10850_ _10855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xplace1461 _05723_ net1460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15884_ _10225_ net1530 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[32\]
+ _10857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15885_ net1532 _10853_ _10857_ _01410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15886_ cs_registers_i.mcycle_counter_i.counter_val_o\[32\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[31\] _10820_
+ _10858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15887_ _10376_ _10850_ _10859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1460 net185 net1459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15889_ cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ net1509 _10858_ _10861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15890_ cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ _10858_ _10861_ _10862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1459 net184 net1458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15892_ net1530 _10607_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ _10864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15893_ net1532 _10862_ _10864_ _01411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15894_ cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[32\] _10849_
+ _10865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_15895_ cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ net1509 _10865_ _10866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15896_ cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ _10865_ _10866_ _10867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15897_ _10258_ net1530 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ _10868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15898_ net1532 _10867_ _10868_ _01412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15899_ cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[32\] cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[31\] _10869_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15900_ _10819_ _10869_ _10870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15901_ _10704_ _10870_ _10871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15902_ _10851_ _10871_ _10872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15903_ _10872_ _10871_ cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ _10873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15904_ _10141_ _08008_ net2103 _10874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15905_ _10139_ _10874_ _10875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15906_ cs_registers_i.mtval_q\[3\] net1555 _10512_ cs_registers_i.mie_q\[17\]
+ _10876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15907_ net151 _10507_ _10214_ cs_registers_i.mcause_q\[3\]
+ _10877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15908_ _10876_ _10877_ _10878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15909_ cs_registers_i.csr_mepc_o\[3\] net1553 _10535_ cs_registers_i.csr_mstatus_mie_o
+ _10879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15910_ cs_registers_i.mscratch_q\[3\] _10216_ _10245_ _10880_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15911_ _10879_ _10880_ _10881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15912_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1859\] _10882_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15913_ cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1891\] _10883_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15914_ _10159_ _10882_ _10883_ _10162_ _10884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15915_ net1562 _10884_ _10885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15916_ cs_registers_i.dscratch0_q\[3\] net1556 _10886_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15917_ cs_registers_i.dscratch1_q\[3\] _10188_ _10239_ cs_registers_i.csr_depc_o\[3\]
+ net92 net1563 _10887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15918_ _10886_ _10887_ _10888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15919_ _10878_ _10881_ _10885_ _10888_ _10889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_15920_ net2103 _10889_ _10890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15921_ _10875_ _10890_ _10891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15922_ cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ net1510 _10891_ net1530 _10892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15923_ net1532 _10873_ _10892_ _01413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15924_ cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[34\] _10893_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15925_ _10865_ _10893_ _10894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15926_ cs_registers_i.mcycle_counter_i.counter_val_o\[36\]
+ net1509 _10894_ _10895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15927_ cs_registers_i.mcycle_counter_i.counter_val_o\[36\]
+ _10894_ _10895_ _10896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15928_ _10141_ _08008_ _01165_ _10897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15929_ _10139_ _10897_ _10898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15930_ cs_registers_i.mtval_q\[4\] _10211_ _10214_ cs_registers_i.mcause_q\[4\]
+ _10216_ cs_registers_i.mscratch_q\[4\] _10899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15931_ cs_registers_i.csr_depc_o\[4\] _10826_ _10218_ _10900_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15932_ cs_registers_i.dscratch1_q\[4\] _10826_ _10187_ _10901_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15933_ net93 _10828_ _10900_ _10901_ _10902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_15934_ cs_registers_i.dscratch0_q\[4\] _10826_ _10833_ _10903_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15935_ _10177_ _10409_ net1553 cs_registers_i.csr_mepc_o\[4\]
+ _10903_ _10904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_15936_ cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1860\] _10905_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15937_ cs_registers_i.mcycle_counter_i.counter_val_o\[36\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1892\] _10906_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15938_ _10838_ _10905_ _10906_ _10423_ _10907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15939_ net1562 _10907_ _10908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15940_ _10899_ _10902_ _10904_ _10908_ _10909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15941_ _01165_ _10909_ _10910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15942_ _10898_ _10910_ _10911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15943_ cs_registers_i.mcycle_counter_i.counter_val_o\[36\]
+ net1510 _10911_ net1530 _10912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15944_ net1532 _10896_ _10912_ _01414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_15945_ cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[36\] _10913_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15946_ _10871_ _10913_ _10914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15947_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ net1509 _10914_ _10915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_15948_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ _10914_ _10915_ _10916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15949_ _10141_ _08008_ net1692 _10917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15950_ _09602_ _09613_ _09614_ _10918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15951_ cs_registers_i.mcycle_counter_i.counter_val_o\[5\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1861\] _10919_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15952_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1893\] _10920_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15953_ _09612_ _09613_ _09614_ _10921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_15954_ _10918_ _10919_ _10920_ _10921_ _10922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15955_ _09569_ _09579_ _09582_ _10923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15956_ cs_registers_i.csr_mepc_o\[5\] _10923_ _10178_ _10924_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15957_ _09558_ _09582_ net1608 _10925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15958_ net1612 net1586 _10926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15959_ _10926_ _09579_ _09582_ _10927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15960_ cs_registers_i.mscratch_q\[5\] _10925_ _10927_ cs_registers_i.mtval_q\[5\]
+ _10928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15961_ net1696 _09543_ _09552_ _09601_ _10929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15962_ _10929_ _10926_ _09579_ _10930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15963_ net1610 _09601_ _10931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15964_ _09543_ _09603_ _09581_ _10931_ _10932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15965_ cs_registers_i.dscratch1_q\[5\] _10930_ _10932_ net94
+ _10933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15966_ net1586 _10329_ _10934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15967_ _09558_ _10929_ _10934_ _10935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15968_ _10929_ _09569_ _09579_ _10936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_15969_ cs_registers_i.dscratch0_q\[5\] _10935_ _10936_ cs_registers_i.csr_depc_o\[5\]
+ _10937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15970_ _10924_ _10928_ _10933_ _10937_ _10938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15971_ _10261_ _10922_ _10938_ _10939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15972_ _10139_ _10917_ _10939_ _01176_ _10940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15973_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ net1510 _10940_ net1530 _10941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15974_ net1532 _10916_ _10941_ _01415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1458 net157 net1457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15976_ _10141_ _08008_ net1691 _10943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_15977_ _10139_ _10943_ _10944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15978_ cs_registers_i.mtval_q\[6\] _10211_ net1553 cs_registers_i.csr_mepc_o\[6\]
+ _10945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15979_ cs_registers_i.mscratch_q\[6\] _10216_ _10245_ _10946_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_15980_ cs_registers_i.mcycle_counter_i.counter_val_o\[6\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1862\] _10947_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15981_ cs_registers_i.mcycle_counter_i.counter_val_o\[38\]
+ net1608 _10149_ cs_registers_i.mhpmcounter\[1894\] _10948_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15982_ _10159_ _10947_ _10948_ _10162_ _10949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_15983_ net1562 _10949_ _10950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15984_ cs_registers_i.dscratch1_q\[6\] _10188_ _10239_ cs_registers_i.csr_depc_o\[6\]
+ net95 net1563 _10951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_15985_ cs_registers_i.dcsr_q\[6\] _10201_ net1556 cs_registers_i.dscratch0_q\[6\]
+ _10952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_15986_ _10951_ _10952_ _10953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_15987_ _10945_ _10946_ _10950_ _10953_ _10954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_15988_ net1691 _10954_ _10955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_15989_ _10944_ _10955_ _10956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1463 _05719_ net1462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15991_ cs_registers_i.mcycle_counter_i.counter_val_o\[38\]
+ net1510 _10956_ net1530 _10958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xplace1457 net160 net1456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1456 _08838_ net1455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_15994_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ _10703_ _10870_ _10913_ _10961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_15995_ _10626_ _10961_ _10962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15996_ cs_registers_i.mcycle_counter_i.counter_val_o\[38\]
+ _10962_ _10963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15997_ cs_registers_i.mcycle_counter_i.counter_val_o\[38\]
+ net1509 _10962_ _10963_ _10964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_15998_ net1511 _10964_ _10965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_15999_ _10958_ _10965_ _01416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16000_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[38\] _10871_
+ _10913_ _10966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16001_ cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ net1509 _10966_ _10967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16002_ cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ _10966_ _10967_ _10968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16003_ _10141_ _08008_ net2116 _10969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16004_ _10139_ _10969_ _10970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16005_ cs_registers_i.csr_mepc_o\[7\] net1553 _10535_ cs_registers_i.mstatus_q\[4\]
+ _10512_ cs_registers_i.mie_q\[16\] _10971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16006_ cs_registers_i.mtval_q\[7\] net1555 _10216_ cs_registers_i.mscratch_q\[7\]
+ _10972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16007_ net152 _10507_ _10245_ _10973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16008_ _10972_ _10973_ _10974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16009_ cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1863\] _10975_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16010_ cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1895\] _10976_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16011_ _10159_ _10975_ _10976_ net1560 _10977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16012_ net1562 _10977_ _10978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16013_ cs_registers_i.dscratch1_q\[7\] _10188_ _10239_ cs_registers_i.csr_depc_o\[7\]
+ net96 net1563 _10979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16014_ cs_registers_i.dcsr_q\[7\] _10201_ net1556 cs_registers_i.dscratch0_q\[7\]
+ _10980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16015_ _10979_ _10980_ _10981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16016_ _10971_ _10974_ _10978_ _10981_ _10982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16017_ net2116 _10982_ _10983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16018_ _10970_ _10983_ _10984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16019_ cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ net1510 _10984_ net1530 _10985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16020_ net1532 _10968_ _10985_ _01417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16021_ cs_registers_i.mcycle_counter_i.counter_val_o\[2\]
+ _10309_ _10986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16022_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ _10986_ _10987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_16023_ _10271_ _10891_ _10987_ net1518 _10988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16024_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ _10306_ _10989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16025_ _10988_ _10989_ _01418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16026_ _10626_ _10961_ _10990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16027_ cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[38\] _10991_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16028_ _10990_ _10991_ _10992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16029_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ _10992_ _10993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16030_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ net1509 _10992_ _10994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16031_ _10993_ _10994_ _10995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16032_ _10141_ _08008_ net2072 _10996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16033_ _10139_ _10996_ _10997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16034_ cs_registers_i.mtval_q\[8\] net1555 _10216_ cs_registers_i.mscratch_q\[8\]
+ _10197_ cs_registers_i.csr_mtvec_o\[8\] _10998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16035_ cs_registers_i.mcycle_counter_i.counter_val_o\[8\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1864\] _10999_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16036_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1896\] _11000_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16037_ _10159_ _10999_ _11000_ net1560 _11001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16038_ net1562 _11001_ _11002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16039_ cs_registers_i.dscratch1_q\[8\] _10188_ net1552 cs_registers_i.csr_depc_o\[8\]
+ net97 net1563 _11003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16040_ cs_registers_i.dcsr_q\[8\] _10201_ net1556 cs_registers_i.dscratch0_q\[8\]
+ _11004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16041_ _11003_ _11004_ _11005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16042_ cs_registers_i.csr_mepc_o\[8\] net1553 _10358_ _11006_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16043_ _10998_ _11002_ _11005_ _11006_ _11007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16044_ _01197_ _11007_ _11008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16045_ _10997_ _11008_ _11009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16046_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ net1510 _11009_ net1530 _11010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16047_ net1532 _10995_ _11010_ _01419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16048_ _10141_ _08008_ net2097 _11011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16049_ _10139_ _11011_ _11012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16050_ cs_registers_i.mtval_q\[9\] net1555 net1553 cs_registers_i.csr_mepc_o\[9\]
+ _10197_ cs_registers_i.csr_mtvec_o\[9\] _11013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16051_ cs_registers_i.mcycle_counter_i.counter_val_o\[9\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1865\] _11014_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16052_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ net1609 _10149_ cs_registers_i.mhpmcounter\[1897\] _11015_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16053_ _10159_ _11014_ _11015_ net1560 _11016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16054_ net1562 _11016_ _11017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16055_ cs_registers_i.dscratch0_q\[9\] net1556 _11018_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16056_ cs_registers_i.dscratch1_q\[9\] _10188_ net1552 cs_registers_i.csr_depc_o\[9\]
+ net98 net1563 _11019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_16057_ cs_registers_i.mscratch_q\[9\] _10216_ _10245_ _11020_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16058_ _11018_ _11019_ _11020_ _11021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16059_ _11013_ _11017_ _11021_ _11022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16060_ net2097 _11022_ _11023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16061_ _11012_ _11023_ _11024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16062_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ net1510 _11024_ net1530 _11025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16063_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ _10991_ _11026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16064_ _10649_ _10961_ _11026_ _11027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16065_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ _11027_ _11028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16066_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ net1509 _11027_ _11028_ _11029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16067_ net1511 _11029_ _11030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16068_ _11025_ _11030_ _01420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16069_ _10280_ _10282_ _10283_ _10297_ _11031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16070_ net1705 _10279_ _11032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16071_ _01211_ _11031_ _11032_ _11033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16072_ _11033_ net1530 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ _11034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16073_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[41\] _10990_
+ _10991_ _11035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16074_ cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ _11035_ _11036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16075_ cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ net1509 _11035_ _11036_ _11037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16076_ net1511 _11037_ _11038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16077_ _11034_ _11038_ _01421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16078_ _10348_ net1530 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ _11039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16079_ _10649_ _10961_ _11026_ _11040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16080_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[42\] _11040_
+ _11041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16081_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ _11041_ _11042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16082_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ net1509 _11041_ _11042_ _11043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16083_ net1511 _11043_ _11044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16084_ _11039_ _11044_ _01422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16085_ cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[41\] _10990_
+ _10991_ _11045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16086_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[42\] _11045_
+ _11046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16087_ cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ _11046_ _11047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16088_ cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ net1509 _11046_ _11048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16089_ _11047_ _11048_ _11049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16090_ _10386_ _10393_ _10400_ _10402_ _11050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16091_ net1705 _10380_ _11051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16092_ _01222_ _11050_ _11051_ _11052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16093_ net1530 _11052_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ _11053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16094_ net1532 _11049_ _11053_ _01423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16095_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[41\] cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ _11040_ _11054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16096_ cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ _11054_ _11055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16097_ cs_registers_i.mcycle_counter_i.counter_val_o\[45\]
+ _11055_ _11056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16098_ cs_registers_i.mcycle_counter_i.counter_val_o\[45\]
+ net1509 _11055_ _11057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16099_ _11056_ _11057_ _11058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16100_ _10431_ _10447_ _11059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1465 _05715_ net1464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16102_ net1530 _11059_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[45\]
+ _11061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16103_ net1532 _11058_ _11061_ _01424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16104_ _10459_ _10470_ _11062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16105_ net1705 _10457_ _11063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16106_ _01239_ _11062_ _11063_ _11064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16107_ net1530 _11064_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ _11065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16108_ cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[45\] _11066_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16109_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[42\] _11045_
+ _11066_ _11067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16110_ _11067_ _11068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16111_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ _11068_ _11069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16112_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ net1509 _11068_ _11069_ _11070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16113_ net1511 _11070_ _11071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16114_ _11065_ _11071_ _01425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1467 _05711_ net1466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16116_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ _11054_ _11066_ _11073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16117_ cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ net1509 _11073_ _11074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16118_ cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ _11073_ _11074_ _11075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16119_ net1530 net1531 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ _11076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16120_ net1532 _11075_ _11076_ _01426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16121_ _10506_ _10524_ _11077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16122_ net1530 _11077_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ _11078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16123_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[47\] _11067_
+ _11079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16124_ cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ _11079_ _11080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16125_ cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ net1509 _11079_ _11080_ _11081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16126_ net1511 _11081_ _11082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16127_ _11078_ _11082_ _01427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16128_ cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[48\] _11083_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16129_ _11073_ _11083_ _11084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16130_ cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ net1509 _11084_ _11085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16131_ cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ _11084_ _11085_ _11086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16132_ _10533_ _10537_ _10541_ _10544_ _11087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16133_ net1705 _10530_ _11088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16134_ _01260_ _11087_ _11088_ _11089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16135_ net1530 _11089_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ _11090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16136_ net1532 _11086_ _11090_ _01428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16137_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[2\] _01369_
+ net1518 _11091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16138_ cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ _10456_ _11091_ _11092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16139_ _10898_ _10910_ _11093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16140_ _10456_ _11093_ _11091_ cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ _11094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16141_ _11092_ _11094_ _01429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16142_ cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ _10703_ _10870_ _10913_ _11095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16143_ cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ _10626_ _11095_ _11026_ _11096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16144_ cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[42\] _11096_
+ _11066_ _11097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16145_ cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[49\] _11098_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16146_ cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[47\] _11097_
+ _11098_ _11099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16147_ _11099_ _11100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16148_ cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ _11100_ _11101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16149_ cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ net1509 _11100_ _11102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16150_ _11101_ _11102_ _11103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16151_ _10553_ _10566_ _11104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16152_ net1530 _11104_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ _11105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16153_ net1532 _11103_ _11105_ _01430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16154_ cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[50\] _03285_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16155_ _11084_ _03285_ _03286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16156_ cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ net1509 _03286_ _03287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16157_ cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ _03286_ _03287_ _03288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16158_ net1530 _10587_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ _03289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16159_ net1532 _03288_ _03289_ _01431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16160_ cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[51\] _03290_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16161_ _11100_ _03290_ _03291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16162_ cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ _03291_ _03292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16163_ cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ net1509 _03291_ _03293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16164_ _03292_ _03293_ _03294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16165_ net1530 _10624_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ _03295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16166_ net1532 _03294_ _03295_ _01432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16167_ _10631_ _10646_ _03296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16168_ net1530 _03296_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ _03297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16169_ cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ _03298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16170_ cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[52\] _03299_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16171_ _03286_ _03299_ _03300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16172_ _10376_ _10850_ _03300_ _03298_ _03301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16173_ _03298_ _03300_ _03301_ _03302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16174_ net1511 _03302_ _03303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16175_ _03297_ _03303_ _01433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16176_ _10653_ _10654_ _10655_ _10661_ _03304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16177_ net1705 _10652_ _03305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16178_ _01295_ _03304_ _03305_ _03306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16179_ net1530 _03306_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ _03307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16180_ cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[49\] _03308_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16181_ cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[53\] _03309_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16182_ _11079_ _03308_ _03290_ _03309_ _03310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16183_ _03310_ _03311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16184_ cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ _03311_ _03312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16185_ cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ net1509 _03311_ _03312_ _03313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16186_ net1511 _03313_ _03314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16187_ _03307_ _03314_ _01434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16188_ cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[54\] _03300_
+ _03315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16189_ cs_registers_i.mcycle_counter_i.counter_val_o\[55\]
+ _03315_ _03316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16190_ cs_registers_i.mcycle_counter_i.counter_val_o\[55\]
+ net1509 _03315_ _03316_ _03317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16191_ net1511 _03317_ _03318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16192_ _10668_ _10669_ _10670_ _10676_ _03319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16193_ net1705 _10667_ _03320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16194_ _01302_ _03319_ _03320_ _03321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16195_ net1530 _03321_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[55\]
+ _03322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16196_ _03318_ _03322_ _01435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16197_ _10684_ _10697_ _03323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16198_ net1530 _03323_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ _03324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16199_ cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[55\] _03325_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16200_ _03310_ _03325_ _03326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16201_ cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ _03326_ _03327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16202_ cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ net1509 _03326_ _03327_ _03328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16203_ net1511 _03328_ _03329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16204_ _03324_ _03329_ _01436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16205_ cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[56\] _03300_
+ _03325_ _03330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16206_ cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ net1509 _03330_ _03331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16207_ cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ _03330_ _03331_ _03332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16208_ _10706_ _10707_ _10708_ _10714_ _03333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16209_ net1705 _10705_ _03334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16210_ _01316_ _03333_ _03334_ _03335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16211_ net1530 _03335_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ _03336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16212_ net1532 _03332_ _03336_ _01437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16213_ cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[57\] _03310_
+ _03325_ _03337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16214_ cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ net1509 _03337_ _03338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16215_ cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ _03337_ _03338_ _03339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16216_ net1530 _10735_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ _03340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16217_ net1532 _03339_ _03340_ _01438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16218_ cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[56\] _03300_
+ _03325_ _03341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16219_ cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[58\] _03341_
+ _03342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16220_ cs_registers_i.mcycle_counter_i.counter_val_o\[59\]
+ _03342_ _03343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16221_ cs_registers_i.mcycle_counter_i.counter_val_o\[59\]
+ net1509 _03342_ _03343_ _03344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16222_ net1511 _03344_ _03345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16223_ net1530 net1517 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[59\]
+ _03346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16224_ _03345_ _03346_ _01439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16225_ _10940_ _03347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16226_ cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[2\] cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ _10309_ _03348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16227_ _10376_ _03348_ _03349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16228_ _10422_ _03349_ _03350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16229_ net1530 _03350_ cs_registers_i.mcycle_counter_i.counter_val_o\[5\]
+ _03351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16230_ cs_registers_i.mcycle_counter_i.counter_val_o\[5\]
+ net1532 _03349_ _03352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16231_ _10266_ _03347_ _03351_ _03352_ _01440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16232_ cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[57\] _03310_
+ _03325_ _03353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16233_ cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[59\] _03354_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16234_ _03353_ _03354_ _03355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16235_ cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ _03355_ _03356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16236_ cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ net1509 _03355_ _03357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16237_ _03356_ _03357_ _03358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16238_ net1530 net1516 net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ _03359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16239_ net1532 _03358_ _03359_ _01441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16240_ cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[60\] _03341_
+ _03354_ _03360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16241_ cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ net1509 _03360_ _03361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16242_ cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ _03360_ _03361_ _03362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16243_ _10778_ _10779_ _10780_ _10786_ _03363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16244_ net1705 _10777_ _03364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16245_ _01344_ _03363_ _03364_ _03365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16246_ net1530 _03365_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ _03366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16247_ net1532 _03362_ _03366_ _01442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16248_ cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[61\] _03353_
+ _03354_ _03367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16249_ cs_registers_i.mcycle_counter_i.counter_val_o\[62\]
+ _03367_ _03368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16250_ cs_registers_i.mcycle_counter_i.counter_val_o\[62\]
+ net1509 _03367_ _03369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16251_ _03368_ _03369_ _03370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16252_ net1530 _10813_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[62\]
+ _03371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16253_ net1532 _03370_ _03371_ _01443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16254_ cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[62\] _03372_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16255_ _03360_ _03372_ _03373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16256_ cs_registers_i.mcycle_counter_i.counter_val_o\[63\]
+ net1509 _03373_ _03374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16257_ cs_registers_i.mcycle_counter_i.counter_val_o\[63\]
+ _03373_ _03374_ _03375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16258_ net1530 _10846_ net1510 cs_registers_i.mcycle_counter_i.counter_val_o\[63\]
+ _03376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16259_ net1532 _03375_ _03376_ _01444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16260_ _10944_ _10955_ _03377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16261_ _10376_ _01369_ _10300_ _03378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16262_ _03378_ _10450_ net1532 _03379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16263_ _01369_ net1518 _10300_ _03380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16264_ _03379_ _03380_ cs_registers_i.mcycle_counter_i.counter_val_o\[6\]
+ _03381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16265_ _10425_ _03377_ _03381_ _01445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16266_ cs_registers_i.mcycle_counter_i.counter_val_o\[6\]
+ net1518 _10300_ _10309_ _03382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16267_ cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ _10456_ _03382_ _03383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16268_ _10970_ _10983_ _03384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16269_ _10456_ _03384_ _03382_ cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ _03385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16270_ _03383_ _03385_ _01446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16271_ _10997_ _11008_ _03386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16272_ cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[6\] _03387_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16273_ _03387_ _03380_ cs_registers_i.mcycle_counter_i.counter_val_o\[8\]
+ _10425_ _03388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16274_ net1518 _10302_ _03389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16275_ _10425_ _03386_ _03388_ _03389_ _01447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16276_ cs_registers_i.mcycle_counter_i.counter_val_o\[9\]
+ _03390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16277_ _03390_ _10310_ _03391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_16278_ _10271_ _11024_ _03391_ net1518 _03392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16279_ _03390_ _10267_ _03392_ _01448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16280_ _08179_ _08136_ _03393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16281_ _08140_ _08148_ _08172_ _08178_ _03394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16282_ _08208_ _08213_ _03395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16283_ _08155_ _08169_ _03396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1455 net180 net1454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16285_ _03395_ _03396_ _03398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16286_ _03394_ _03398_ _03399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_16287_ _03393_ _03399_ _08217_ _03400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16288_ _03400_ _03401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16289_ _09722_ _09739_ _03401_ _03402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16290_ _07599_ _09699_ _03403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16291_ _07711_ _07645_ _03404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16292_ _08179_ _08136_ _03405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16293_ _08208_ _08213_ _03406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16294_ _03406_ _03396_ _03407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_16295_ _03405_ _03407_ _03408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16296_ _03396_ _03394_ _03409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16297_ _03396_ _03394_ _03410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16298_ _03409_ _03410_ _03395_ _03411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16299_ _08179_ _08140_ _08172_ _08178_ _03412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16300_ _03405_ _03411_ _03412_ _03413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1469 _05706_ net1468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16302_ _08127_ net1782 _03415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16303_ _03396_ _03394_ _03415_ _03416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16304_ _03412_ _03409_ _03416_ _03393_ _03417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16305_ _03395_ _09470_ _03417_ _03418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16306_ _03395_ _03417_ _09470_ _03419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16307_ _03418_ _03419_ _00941_ _03420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16308_ _00941_ net2106 net2084 _03420_ _03421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16309_ _03408_ _03413_ _03421_ _03422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16310_ _08127_ _03403_ _03404_ _03422_ _03423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16311_ net169 _09718_ _09719_ _09721_ _03424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16312_ _09726_ _09729_ _03425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16313_ net2065 net2169 net174 _03426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16314_ _03425_ _09734_ _09736_ _03426_ _03427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16315_ _08127_ _10128_ _03428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16316_ _03424_ _03427_ _03428_ _03429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16317_ _07599_ _09654_ _10125_ _03430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16318_ _07642_ _03430_ _03431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16319_ net2032 _09645_ ex_block_i.gen_multdiv_fast.multdiv_i.div_valid
+ net2030 _03432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16320_ net1815 _03432_ _03433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16321_ _03433_ _03434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16322_ _09913_ _03434_ _09621_ _03435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16323_ _03431_ _03435_ _09538_ _03436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16324_ _03402_ _03423_ _03429_ _03436_ _03437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16325_ _09645_ net1826 _09649_ _03438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16326_ id_stage_i.controller_i.instr_fetch_err_i cs_registers_i.mcountinhibit_q\[2\]
+ _09658_ _03439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16327_ _09699_ _03438_ _03439_ _03440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16328_ _09624_ _10370_ _08043_ _03441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16329_ _03440_ _03441_ _03442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16330_ _10351_ _10372_ _10149_ net1562 _03443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16331_ _03437_ _03442_ _03443_ _03444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_4
X_16332_ net1560 _03443_ _03445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16333_ _03424_ _03427_ _03400_ _03446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16334_ _08127_ _03403_ _03404_ _03422_ _03447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16335_ _09722_ _09739_ _03448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16336_ _03446_ _03447_ _03428_ _03448_ _03449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_4
Xplace1454 _05521_ net1453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1472 _05698_ net1471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16339_ _09615_ _10228_ _10934_ _10261_ _03452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
Xplace1453 _00991_ net1452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1480 _05675_ net1479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16342_ _09585_ _09637_ _03455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16343_ _03436_ _03440_ _03456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16344_ _03449_ net1529 _03455_ _03456_ _03457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_16345_ _10264_ net1529 _03458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1482 _05664_ net1481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16347_ _10152_ _03457_ net1515 _03460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16348_ cs_registers_i.mhpmcounter\[1856\] _03444_ _03445_
+ _10273_ _03460_ _01449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16349_ cs_registers_i.mhpmcounter\[1859\] cs_registers_i.mhpmcounter\[1858\]
+ _01367_ _03461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16350_ cs_registers_i.mhpmcounter\[1860\] cs_registers_i.mhpmcounter\[1861\]
+ _03462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16351_ cs_registers_i.mhpmcounter\[1862\] _03461_ _03462_
+ _03463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16352_ cs_registers_i.mhpmcounter\[1863\] cs_registers_i.mhpmcounter\[1864\]
+ _03464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16353_ cs_registers_i.mhpmcounter\[1865\] _03463_ _03464_
+ _03465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16354_ net1560 _03443_ _03466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16355_ _03465_ _03466_ _03444_ _03467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16356_ cs_registers_i.mhpmcounter\[1866\] _03468_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1484 _05634_ net1483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16358_ _03468_ _03457_ _03465_ _03470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16359_ _10299_ _03445_ _03467_ _03468_ _03470_ _01450_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16360_ net2159 _10346_ _10315_ _03471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16361_ cs_registers_i.mhpmcounter\[1857\] cs_registers_i.mhpmcounter\[1856\]
+ cs_registers_i.mhpmcounter\[1858\] _03472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16362_ cs_registers_i.mhpmcounter\[1859\] cs_registers_i.mhpmcounter\[1862\]
+ _03462_ _03472_ _03473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16363_ _03464_ _03473_ _03474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16364_ cs_registers_i.mhpmcounter\[1865\] cs_registers_i.mhpmcounter\[1866\]
+ _03474_ _03475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16365_ _03475_ _03466_ _03444_ _03476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16366_ cs_registers_i.mhpmcounter\[1867\] _03477_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16367_ _03437_ _03442_ _03478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16368_ _10351_ _10372_ _10149_ net1562 _03479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16369_ _03477_ _03478_ _03479_ _03475_ _03480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16370_ _03471_ _03445_ _03476_ _03477_ _03480_ _01451_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16371_ cs_registers_i.mhpmcounter\[1867\] cs_registers_i.mhpmcounter\[1866\]
+ _03465_ _03481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16372_ _03481_ _03466_ _03444_ _03482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16373_ cs_registers_i.mhpmcounter\[1868\] _03483_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16374_ _03483_ _03478_ _03479_ _03481_ _03484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16375_ _10404_ _03445_ _03482_ _03483_ _03484_ _01452_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16376_ _10264_ net1529 _03485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1452 net156 net1451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16378_ cs_registers_i.mhpmcounter\[1868\] cs_registers_i.mhpmcounter\[1867\]
+ _03475_ _03487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16379_ cs_registers_i.mhpmcounter\[1869\] _03487_ _03488_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_16380_ cs_registers_i.mhpmcounter\[1869\] _03485_ _03489_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16381_ _03449_ net1529 _03455_ _03456_ _03490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
Xplace1451 net159 net1450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_16383_ _03488_ _03489_ net1389 _03492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16384_ _10448_ _03485_ _03492_ _01453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16385_ cs_registers_i.mhpmcounter\[1868\] cs_registers_i.mhpmcounter\[1869\]
+ _03493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16386_ _03481_ _03493_ _03494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1450 net158 net1449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_16388_ cs_registers_i.mhpmcounter\[1870\] _03485_ _03496_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16389_ _03457_ _03494_ _03496_ _03497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16390_ cs_registers_i.mhpmcounter\[1870\] _03498_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16391_ _03498_ _03457_ _03481_ _03493_ _03499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16392_ _11064_ net1515 _03500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16393_ _03497_ _03499_ _03500_ _01454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16394_ cs_registers_i.mhpmcounter\[1867\] cs_registers_i.mhpmcounter\[1865\]
+ cs_registers_i.mhpmcounter\[1866\] cs_registers_i.mhpmcounter\[1870\]
+ _03501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16395_ _03474_ _03493_ _03501_ _03502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16396_ cs_registers_i.mhpmcounter\[1871\] _03502_ _03503_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16397_ cs_registers_i.mhpmcounter\[1871\] _03502_ _03504_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1449 net161 net1448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_16399_ _03503_ _03504_ _03457_ _03506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1448 net163 net1447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_16401_ cs_registers_i.mhpmcounter\[1871\] _03485_ _03508_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1447 net162 net1446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16403_ net1531 net1515 _03508_ net1389 _03510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16404_ _03506_ _03510_ _01455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16405_ cs_registers_i.mhpmcounter\[1871\] _03464_ _03493_
+ _03501_ _03511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16406_ _03463_ _03511_ _03512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16407_ cs_registers_i.mhpmcounter\[1872\] _03512_ _03513_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16408_ cs_registers_i.mhpmcounter\[1872\] _03512_ _03514_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2094 gen_regfile_ff.register_file_i.raddr_a_i\[0\]
+ net2093 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_16410_ _03513_ _03514_ net1389 _03516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16411_ cs_registers_i.mhpmcounter\[1872\] _03490_ _03485_
+ _03517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16412_ _11077_ net1515 _03518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16413_ _03516_ _03517_ _03518_ _01456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xrebuffer2095 _08504_ net2094 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16415_ _03449_ _03455_ _03456_ _03520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16416_ _10264_ net1535 _10934_ _10261_ _03521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xrebuffer2096 _00868_ net2095 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16418_ _03521_ _03523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16419_ cs_registers_i.mhpmcounter\[1872\] _03473_ _03511_
+ _03524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16420_ _03523_ _03524_ _03525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16421_ _03520_ _03525_ _03485_ cs_registers_i.mhpmcounter\[1873\]
+ _03526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16422_ cs_registers_i.mhpmcounter\[1873\] _03527_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16423_ _03527_ _03524_ _03528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16424_ _11089_ net1515 _03528_ _03457_ _03529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16425_ _03526_ _03529_ _01457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16426_ cs_registers_i.mhpmcounter\[1872\] _03463_ _03511_
+ _03530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16427_ cs_registers_i.mhpmcounter\[1873\] _03530_ _03531_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16428_ cs_registers_i.mhpmcounter\[1874\] _03531_ _03532_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16429_ cs_registers_i.mhpmcounter\[1874\] _03531_ _03533_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16430_ _03532_ _03533_ _03457_ _03534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16431_ cs_registers_i.mhpmcounter\[1874\] _03485_ _03535_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16432_ _11104_ net1515 _03535_ net1389 _03536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16433_ _03534_ _03536_ _01458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16434_ _10573_ _10586_ _03537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16435_ cs_registers_i.mhpmcounter\[1873\] cs_registers_i.mhpmcounter\[1874\]
+ _03538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16436_ cs_registers_i.mhpmcounter\[1872\] _03473_ _03511_
+ _03538_ _03539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16437_ _03539_ _03466_ _03444_ _03540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16438_ cs_registers_i.mhpmcounter\[1875\] _03541_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16439_ _03524_ _03538_ _03542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16440_ _03542_ _03543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16441_ cs_registers_i.mhpmcounter\[1875\] net1389 _03543_
+ _03544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16442_ _03537_ _03445_ _03540_ _03541_ _03544_ _01459_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16443_ cs_registers_i.mhpmcounter\[1857\] net1389 _03485_
+ _03545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16444_ _01368_ _03457_ net1515 _10607_ _03546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16445_ _03545_ _03546_ _01460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16446_ _10610_ _10623_ _03547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16447_ cs_registers_i.mhpmcounter\[1873\] cs_registers_i.mhpmcounter\[1874\]
+ cs_registers_i.mhpmcounter\[1875\] _03530_ _03548_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16448_ _03548_ _03466_ _03444_ _03549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16449_ cs_registers_i.mhpmcounter\[1876\] _03550_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16450_ _03550_ _03457_ _03548_ _03551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16451_ _03547_ _03445_ _03549_ _03550_ _03551_ _01461_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16452_ net1612 net2289 _09625_ _03552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16453_ _10408_ _10421_ _03552_ _10148_ _03553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_16454_ net1528 _03437_ _03442_ _03543_ _03554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16455_ cs_registers_i.mhpmcounter\[1875\] cs_registers_i.mhpmcounter\[1876\]
+ _03555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16456_ _03554_ _03555_ cs_registers_i.mhpmcounter\[1877\]
+ _03485_ _03556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16457_ _03543_ _03555_ _03557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16458_ cs_registers_i.mhpmcounter\[1877\] net1389 _03557_
+ _03558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16459_ _03296_ net1515 _03559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16460_ _03556_ _03558_ _03559_ _01462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16461_ cs_registers_i.mhpmcounter\[1876\] cs_registers_i.mhpmcounter\[1877\]
+ _03548_ _03560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16462_ _03560_ _03466_ _03444_ _03561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16463_ cs_registers_i.mhpmcounter\[1878\] _03562_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16464_ _03562_ _03457_ _03560_ _03563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16465_ _10663_ _03445_ _03561_ _03562_ _03563_ _01463_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16466_ cs_registers_i.mhpmcounter\[1877\] _03564_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16467_ _03564_ _03562_ _03557_ _03565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16468_ cs_registers_i.mhpmcounter\[1879\] net1389 _03565_
+ _03566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_16469_ cs_registers_i.mhpmcounter\[1879\] _03457_ _03565_
+ _03567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16470_ cs_registers_i.mhpmcounter\[1879\] _03485_ _03568_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16471_ _10678_ _03485_ _03568_ _03457_ _03569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16472_ _03566_ _03567_ _03569_ _01464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16473_ cs_registers_i.mhpmcounter\[1878\] cs_registers_i.mhpmcounter\[1879\]
+ _03560_ _03570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16474_ cs_registers_i.mhpmcounter\[1880\] _03570_ _03571_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16475_ cs_registers_i.mhpmcounter\[1880\] _03570_ _03572_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16476_ _03571_ _03572_ _03457_ _03573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16477_ cs_registers_i.mhpmcounter\[1880\] _03485_ _03574_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16478_ _03323_ net1515 _03574_ net1389 _03575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16479_ _03573_ _03575_ _01465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16480_ cs_registers_i.mhpmcounter\[1875\] cs_registers_i.mhpmcounter\[1876\]
+ cs_registers_i.mhpmcounter\[1877\] cs_registers_i.mhpmcounter\[1878\]
+ _03576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16481_ cs_registers_i.mhpmcounter\[1879\] cs_registers_i.mhpmcounter\[1880\]
+ _03576_ _03577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16482_ _03539_ _03577_ _03578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16483_ _03578_ _03466_ _03444_ _03579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16484_ cs_registers_i.mhpmcounter\[1881\] _03580_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16485_ _03542_ _03577_ _03581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16486_ _03581_ _03582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16487_ cs_registers_i.mhpmcounter\[1881\] net1389 _03582_
+ _03583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16488_ _10716_ _03445_ _03579_ _03580_ _03583_ _01466_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_16489_ cs_registers_i.mhpmcounter\[1882\] _03584_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16490_ cs_registers_i.mhpmcounter\[1881\] _03538_ _03577_
+ _03585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16491_ _03530_ _03585_ _03586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16492_ _03584_ _03586_ _03587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16493_ _03584_ _03586_ _03588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16494_ _03587_ _03588_ _03457_ _03589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16495_ cs_registers_i.mhpmcounter\[1882\] _03485_ _03590_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16496_ _10735_ net1515 _03590_ net1389 _03591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16497_ _03589_ _03591_ _01467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16498_ _03580_ _03584_ _03582_ _03592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16499_ cs_registers_i.mhpmcounter\[1883\] _03592_ _03593_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16500_ cs_registers_i.mhpmcounter\[1883\] _03592_ _03594_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16501_ _03593_ _03594_ net1389 _03595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16502_ cs_registers_i.mhpmcounter\[1883\] net1389 _03485_
+ _03596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16503_ net1517 net1515 _03597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16504_ _03595_ _03596_ _03597_ _01468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16505_ cs_registers_i.mhpmcounter\[1882\] cs_registers_i.mhpmcounter\[1883\]
+ _03586_ _03598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16506_ cs_registers_i.mhpmcounter\[1884\] _03598_ _03599_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16507_ cs_registers_i.mhpmcounter\[1884\] _03598_ _03600_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16508_ _03599_ _03600_ _03457_ _03601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16509_ cs_registers_i.mhpmcounter\[1884\] _03485_ _03602_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16510_ net1516 net1515 _03602_ net1389 _03603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16511_ _03601_ _03603_ _01469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2097 _01229_ net2096 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16513_ cs_registers_i.mhpmcounter\[1885\] net1529 _03605_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16514_ net1529 _03606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16515_ cs_registers_i.mhpmcounter\[1885\] _03606_ _03607_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16516_ _03592_ _03608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16517_ cs_registers_i.mhpmcounter\[1883\] cs_registers_i.mhpmcounter\[1884\]
+ _03608_ _03609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16518_ _03449_ _03455_ _03456_ _03609_ _03610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16519_ _03605_ _03607_ _03610_ _03611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2098 net1689 net2097 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16521_ cs_registers_i.mhpmcounter\[1885\] _03521_ net1515
+ _03365_ _03613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16522_ _03611_ _03613_ _01470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16523_ cs_registers_i.mhpmcounter\[1858\] _03485_ _03614_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16524_ _01367_ _03615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16525_ cs_registers_i.mhpmcounter\[1858\] _03615_ _03616_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16526_ _03614_ _03616_ _03457_ _03617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16527_ cs_registers_i.mhpmcounter\[1858\] _03615_ net1389
+ _03618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16528_ _10792_ _03485_ _03617_ _03618_ _01471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16529_ cs_registers_i.mhpmcounter\[1884\] cs_registers_i.mhpmcounter\[1885\]
+ _03619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16530_ cs_registers_i.mhpmcounter\[1886\] _03490_ _03598_
+ _03619_ _03620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16531_ _03598_ _03619_ cs_registers_i.mhpmcounter\[1886\]
+ _03457_ _03621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16532_ cs_registers_i.mhpmcounter\[1886\] _03485_ _03622_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16533_ _10813_ net1515 _03622_ _03490_ _03623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16534_ _03620_ _03621_ _03623_ _01472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16535_ cs_registers_i.mhpmcounter\[1882\] cs_registers_i.mhpmcounter\[1883\]
+ cs_registers_i.mhpmcounter\[1884\] cs_registers_i.mhpmcounter\[1885\]
+ _03624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16536_ cs_registers_i.mhpmcounter\[1886\] _03624_ _03625_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16537_ _03524_ _03585_ _03625_ _03626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16538_ cs_registers_i.mhpmcounter\[1887\] _03626_ _03627_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16539_ cs_registers_i.mhpmcounter\[1887\] _03626_ _03628_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16540_ _03627_ _03628_ _03457_ _03629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16541_ cs_registers_i.mhpmcounter\[1887\] _03485_ _03630_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16542_ _10846_ net1515 _03630_ net1389 _03631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16543_ _03629_ _03631_ _01473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16544_ _10264_ net1535 _10934_ _10261_ _03632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16545_ _03490_ _03632_ _03633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2099 load_store_unit_i.ls_fsm_cs\[0\] net2098 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16547_ cs_registers_i.mhpmcounter\[1887\] _03586_ _03625_
+ _03635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16548_ _10164_ net1529 _03635_ _03636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16549_ _10225_ _03521_ _03636_ _03637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16550_ cs_registers_i.mhpmcounter\[1888\] _03632_ _03638_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16551_ _03635_ _03639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16552_ cs_registers_i.mhpmcounter\[1888\] net1529 _03639_
+ _03640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16553_ net1389 _03638_ _03640_ _03641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16554_ _03633_ _03637_ _03641_ _01474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16555_ cs_registers_i.mhpmcounter\[1889\] _03642_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16556_ _10423_ _10421_ _03552_ _10148_ _03643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16557_ net1528 _03437_ _03442_ _03643_ _03644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_16558_ _10408_ _10421_ _03552_ _10148_ _03645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
Xrebuffer2100 load_store_unit_i.ls_fsm_cs\[0\] net2099 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16560_ cs_registers_i.mhpmcounter\[1887\] _03524_ _03585_
+ _03625_ _03647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16561_ cs_registers_i.mhpmcounter\[1888\] _03647_ _03648_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16562_ _03645_ _03648_ _03649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16563_ _03644_ _03649_ _03650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2101 _08041_ net2100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16565_ _03642_ cs_registers_i.mhpmcounter\[1888\] net1529
+ _03647_ _03652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16566_ _01145_ _10605_ _10595_ _03653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16567_ _03653_ _03643_ _03654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16568_ _03644_ _03652_ _03654_ _03655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16569_ _03642_ _03650_ _03655_ _01475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16570_ cs_registers_i.mhpmcounter\[1890\] _03656_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16571_ _03642_ _10164_ _03639_ _03657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16572_ _03645_ _03657_ _03658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16573_ _03644_ _03658_ _03659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16574_ cs_registers_i.mhpmcounter\[1890\] _03657_ _03660_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16575_ _10258_ _03521_ _03660_ net1529 _03661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16576_ _03656_ _03659_ _03661_ _03633_ _01476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16577_ cs_registers_i.mhpmcounter\[1891\] _03662_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16578_ _03642_ _03656_ _03648_ _03663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16579_ _03645_ _03663_ _03664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16580_ _03644_ _03664_ _03665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16581_ cs_registers_i.mhpmcounter\[1891\] _03663_ _03666_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16582_ _10264_ _03606_ _03667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16583_ net1529 _03666_ _03667_ _10891_ _03668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16584_ _03662_ _03665_ _03668_ _03633_ _01477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16585_ cs_registers_i.mhpmcounter\[1892\] _03669_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16586_ cs_registers_i.mhpmcounter\[1889\] cs_registers_i.mhpmcounter\[1888\]
+ cs_registers_i.mhpmcounter\[1891\] cs_registers_i.mhpmcounter\[1890\]
+ _03670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16587_ _03635_ _03670_ _03671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16588_ net1528 _03671_ _03672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16589_ _03644_ _03672_ _03673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16590_ _03669_ net1529 _03671_ _03674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16591_ _10911_ _03521_ _03674_ _03675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16592_ _03669_ _03673_ _03675_ _03633_ _01478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16593_ cs_registers_i.mhpmcounter\[1892\] _03647_ _03670_
+ _03676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16594_ cs_registers_i.mhpmcounter\[1893\] _03676_ _03677_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xrebuffer2102 gen_regfile_ff.register_file_i.raddr_b_i\[2\]
+ net2101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16596_ _10940_ _03521_ _03677_ net1529 _03679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16597_ cs_registers_i.mhpmcounter\[1893\] _03632_ _03680_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16598_ cs_registers_i.mhpmcounter\[1893\] net1529 _03676_
+ _03681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16599_ net1389 _03680_ _03681_ _03682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16600_ _03633_ _03679_ _03682_ _01479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16601_ cs_registers_i.mhpmcounter\[1894\] _03683_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16602_ cs_registers_i.mhpmcounter\[1892\] cs_registers_i.mhpmcounter\[1893\]
+ _03684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16603_ _03671_ _03684_ _03685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16604_ net1528 _03685_ _03686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16605_ _03644_ _03686_ _03687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16606_ _03683_ net1529 _03671_ _03684_ _03688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16607_ _10956_ _03521_ _03688_ _03689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16608_ _03683_ _03687_ _03689_ _03633_ _01480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16609_ cs_registers_i.mhpmcounter\[1894\] _03670_ _03684_
+ _03690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16610_ _03647_ _03690_ _03691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16611_ cs_registers_i.mhpmcounter\[1895\] _03691_ _03692_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16612_ _10984_ _03521_ _03692_ _03479_ _03693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16613_ cs_registers_i.mhpmcounter\[1895\] _03632_ _03694_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16614_ cs_registers_i.mhpmcounter\[1895\] net1529 _03691_
+ _03695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16615_ net1389 _03694_ _03695_ _03696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16616_ _03633_ _03693_ _03696_ _01481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16617_ cs_registers_i.mhpmcounter\[1859\] _03697_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16618_ _03697_ _03472_ _03698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16619_ _03697_ _03472_ _03699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16620_ _03698_ _03699_ _03457_ _03700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16621_ cs_registers_i.mhpmcounter\[1859\] _03485_ _03701_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16622_ _10891_ net1515 _03701_ net1389 _03702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16623_ _03700_ _03702_ _01482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16624_ cs_registers_i.mhpmcounter\[1896\] _03703_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16625_ cs_registers_i.mhpmcounter\[1895\] _03635_ _03690_
+ _03704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16626_ _03645_ _03704_ _03705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16627_ _03644_ _03705_ _03706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16628_ _03704_ _03707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16629_ _03703_ _03707_ _03708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16630_ _11009_ _03521_ _03708_ net1529 _03709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16631_ _03703_ _03706_ _03709_ _03633_ _01483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16632_ _03490_ _03632_ _03710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1446 _01010_ net1445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1445 _01011_ net1444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16635_ cs_registers_i.mhpmcounter\[1895\] cs_registers_i.mhpmcounter\[1896\]
+ _03647_ _03690_ _03713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16636_ cs_registers_i.mhpmcounter\[1897\] _03713_ _03714_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16637_ _03714_ _03715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16638_ _11024_ _03667_ _03715_ net1529 _03716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16639_ _10454_ _10372_ _10149_ net1562 _03717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_16640_ _03437_ _03442_ _03443_ _03717_ _03718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16641_ _03443_ _03713_ _03719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16642_ _03718_ _03719_ cs_registers_i.mhpmcounter\[1897\]
+ _03720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16643_ _03710_ _03716_ _03720_ _01484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16644_ cs_registers_i.mhpmcounter\[1896\] cs_registers_i.mhpmcounter\[1897\]
+ _03707_ _03721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16645_ cs_registers_i.mhpmcounter\[1898\] _03721_ _03722_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16646_ _11033_ _03521_ _03722_ net1529 _03723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16647_ cs_registers_i.mhpmcounter\[1898\] _03724_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16648_ _03724_ _03632_ _03725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16649_ cs_registers_i.mhpmcounter\[1898\] _03606_ _03721_
+ _03725_ _03457_ _03726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_16650_ _03710_ _03723_ _03726_ _01485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16651_ cs_registers_i.mhpmcounter\[1899\] cs_registers_i.mhpmcounter\[1898\]
+ _03714_ _03727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16652_ _03727_ _03728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16653_ _10348_ _03667_ _03728_ net1529 _03729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16654_ _03724_ _03715_ _03479_ _03730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16655_ _03718_ _03730_ cs_registers_i.mhpmcounter\[1899\]
+ _03731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16656_ _03710_ _03729_ _03731_ _01486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16657_ cs_registers_i.mhpmcounter\[1899\] cs_registers_i.mhpmcounter\[1898\]
+ _03721_ _03732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16658_ cs_registers_i.mhpmcounter\[1900\] _03732_ _03733_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16659_ _11052_ _03667_ _03733_ net1529 _03734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16660_ net1528 _03732_ _03735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16661_ _03644_ _03735_ cs_registers_i.mhpmcounter\[1900\]
+ _03736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16662_ _03710_ _03734_ _03736_ _01487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16663_ cs_registers_i.mhpmcounter\[1900\] cs_registers_i.mhpmcounter\[1901\]
+ _03727_ _03737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16664_ _03737_ _03738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16665_ _11059_ _03667_ _03738_ net1529 _03739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16666_ cs_registers_i.mhpmcounter\[1900\] _03740_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16667_ _03740_ _03728_ _03479_ _03741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16668_ _03718_ _03741_ cs_registers_i.mhpmcounter\[1901\]
+ _03742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16669_ _03710_ _03739_ _03742_ _01488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16670_ cs_registers_i.mhpmcounter\[1902\] _03743_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16671_ cs_registers_i.mhpmcounter\[1900\] cs_registers_i.mhpmcounter\[1901\]
+ _03732_ _03744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16672_ net1528 _03744_ _03745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16673_ _03644_ _03745_ _03746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16674_ _03743_ net1529 _03744_ _03747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16675_ _11064_ _03521_ _03747_ _03748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16676_ _03743_ _03746_ _03748_ _03633_ _01489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_16677_ cs_registers_i.mhpmcounter\[1902\] cs_registers_i.mhpmcounter\[1903\]
+ _03737_ _03749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16678_ net1531 _03667_ _03749_ net1529 _03750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16679_ _03743_ _03738_ _03479_ _03751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16680_ _03718_ _03751_ cs_registers_i.mhpmcounter\[1903\]
+ _03752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16681_ _03710_ _03750_ _03752_ _01490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16682_ cs_registers_i.mhpmcounter\[1902\] cs_registers_i.mhpmcounter\[1903\]
+ cs_registers_i.mhpmcounter\[1904\] _03753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16683_ _03744_ _03753_ _03754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16684_ _11077_ _03667_ _03754_ net1529 _03755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16685_ cs_registers_i.mhpmcounter\[1902\] cs_registers_i.mhpmcounter\[1903\]
+ _03744_ _03756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16686_ net1528 _03756_ _03757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16687_ _03644_ _03757_ cs_registers_i.mhpmcounter\[1904\]
+ _03758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16688_ _03710_ _03755_ _03758_ _01491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16689_ cs_registers_i.mhpmcounter\[1905\] _03753_ _03759_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16690_ _03737_ _03759_ _03760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16691_ _11089_ _03667_ _03760_ net1529 _03761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16692_ _03737_ _03753_ _03762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16693_ _03645_ _03762_ _03763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16694_ _03644_ _03763_ cs_registers_i.mhpmcounter\[1905\]
+ _03764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16695_ _03710_ _03761_ _03764_ _01492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16696_ cs_registers_i.mhpmcounter\[1859\] cs_registers_i.mhpmcounter\[1858\]
+ _01367_ _03765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16697_ _03437_ _03442_ _03765_ _03479_ _03766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_16698_ cs_registers_i.mhpmcounter\[1860\] _03767_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16699_ _03717_ _03766_ _03767_ _03768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16700_ cs_registers_i.mhpmcounter\[1860\] net1389 _03765_
+ _03485_ _11093_ _03769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_16701_ _03768_ _03769_ _01493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16702_ cs_registers_i.mhpmcounter\[1906\] _03759_ _03770_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16703_ _03744_ _03770_ _03771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16704_ _03771_ _03772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16705_ _11104_ _03667_ _03772_ net1529 _03773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16706_ _03744_ _03759_ _03774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16707_ _03645_ _03774_ _03775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16708_ _03644_ _03775_ cs_registers_i.mhpmcounter\[1906\]
+ _03776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16709_ _03710_ _03773_ _03776_ _01494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16710_ _03737_ _03770_ _03777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16711_ cs_registers_i.mhpmcounter\[1907\] _03777_ _03778_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2103 net1688 net2102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16713_ _10587_ _03521_ _03778_ net1529 _03780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16714_ _03443_ _03777_ _03781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16715_ _03718_ _03781_ cs_registers_i.mhpmcounter\[1907\]
+ _03782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16716_ _03710_ _03780_ _03782_ _01495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1444 _01022_ net1443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16718_ cs_registers_i.mhpmcounter\[1907\] cs_registers_i.mhpmcounter\[1908\]
+ _03771_ _03784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16719_ _10624_ _03667_ _03784_ net1529 _03785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16720_ cs_registers_i.mhpmcounter\[1907\] _03771_ _03786_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16721_ _03645_ _03786_ _03787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16722_ _03644_ _03787_ cs_registers_i.mhpmcounter\[1908\]
+ _03788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16723_ _03710_ _03785_ _03788_ _01496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16724_ cs_registers_i.mhpmcounter\[1907\] cs_registers_i.mhpmcounter\[1908\]
+ cs_registers_i.mhpmcounter\[1909\] _03789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16725_ _03777_ _03789_ _03790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16726_ _03296_ _03667_ _03790_ net1529 _03791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16727_ cs_registers_i.mhpmcounter\[1907\] cs_registers_i.mhpmcounter\[1908\]
+ _03777_ _03792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16728_ _03443_ _03792_ _03793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16729_ _03718_ _03793_ cs_registers_i.mhpmcounter\[1909\]
+ _03794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16730_ _03710_ _03791_ _03794_ _01497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16731_ cs_registers_i.mhpmcounter\[1910\] _03771_ _03789_
+ _03795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16732_ _03795_ _03796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16733_ _03306_ _03667_ _03796_ net1529 _03797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16734_ _03771_ _03789_ _03798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16735_ _03645_ _03798_ _03799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16736_ _03644_ _03799_ cs_registers_i.mhpmcounter\[1910\]
+ _03800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16737_ _03710_ _03797_ _03800_ _01498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16738_ cs_registers_i.mhpmcounter\[1910\] _03777_ _03789_
+ _03801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16739_ cs_registers_i.mhpmcounter\[1911\] _03801_ _03802_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16740_ _03321_ _03667_ _03802_ net1529 _03803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16741_ _03443_ _03801_ _03804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16742_ _03718_ _03804_ cs_registers_i.mhpmcounter\[1911\]
+ _03805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16743_ _03710_ _03803_ _03805_ _01499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16744_ cs_registers_i.mhpmcounter\[1911\] cs_registers_i.mhpmcounter\[1912\]
+ _03795_ _03806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_16745_ _03323_ _03521_ _03806_ net1529 _03807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16746_ cs_registers_i.mhpmcounter\[1911\] _03795_ _03808_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16747_ _03645_ _03808_ _03809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16748_ _03644_ _03809_ cs_registers_i.mhpmcounter\[1912\]
+ _03810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16749_ _03710_ _03807_ _03810_ _01500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16750_ cs_registers_i.mhpmcounter\[1911\] cs_registers_i.mhpmcounter\[1912\]
+ cs_registers_i.mhpmcounter\[1913\] _03811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16751_ _03801_ _03811_ _03812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16752_ _03335_ _03667_ _03812_ net1529 _03813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16753_ cs_registers_i.mhpmcounter\[1911\] cs_registers_i.mhpmcounter\[1912\]
+ _03801_ _03814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16754_ _03443_ _03814_ _03815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16755_ _03718_ _03815_ cs_registers_i.mhpmcounter\[1913\]
+ _03816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16756_ _03710_ _03813_ _03816_ _01501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16757_ cs_registers_i.mhpmcounter\[1914\] _03811_ _03817_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16758_ _03795_ _03817_ _03818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16759_ _10735_ _03667_ _03818_ net1529 _03819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16760_ _03795_ _03811_ _03820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16761_ _03645_ _03820_ _03821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16762_ _03644_ _03821_ cs_registers_i.mhpmcounter\[1914\]
+ _03822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16763_ _03710_ _03819_ _03822_ _01502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16764_ cs_registers_i.mhpmcounter\[1915\] _03823_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16765_ _03801_ _03817_ _03824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16766_ _03823_ net1529 _03824_ _03825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16767_ net1517 _03521_ _03825_ _03826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16768_ cs_registers_i.mhpmcounter\[1915\] _03632_ _03827_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16769_ _03824_ _03828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16770_ cs_registers_i.mhpmcounter\[1915\] net1529 _03828_
+ _03829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16771_ _03490_ _03827_ _03829_ _03830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16772_ _03633_ _03826_ _03830_ _01503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16773_ cs_registers_i.mhpmcounter\[1859\] cs_registers_i.mhpmcounter\[1860\]
+ _03472_ _03831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16774_ cs_registers_i.mhpmcounter\[1861\] net1515 _03832_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16775_ _03457_ _03831_ _03832_ _03833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16776_ cs_registers_i.mhpmcounter\[1861\] _03457_ _03831_
+ _03834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16777_ _03347_ net1515 _03833_ _03834_ _01504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16778_ _03795_ _03817_ _03835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16779_ cs_registers_i.mhpmcounter\[1915\] cs_registers_i.mhpmcounter\[1916\]
+ _03836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16780_ _03835_ _03836_ _03837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16781_ net1516 _03521_ _03837_ net1529 _03838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16782_ _03823_ _03818_ _03645_ _03839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16783_ _03644_ _03839_ cs_registers_i.mhpmcounter\[1916\]
+ _03840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16784_ _03710_ _03838_ _03840_ _01505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16785_ cs_registers_i.mhpmcounter\[1917\] _03836_ _03841_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16786_ _03828_ _03841_ _03842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16787_ _03365_ _03667_ _03842_ net1529 _03843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16788_ _03824_ _03836_ _03844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16789_ _03645_ _03844_ _03845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16790_ _03644_ _03845_ cs_registers_i.mhpmcounter\[1917\]
+ _03846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16791_ _03710_ _03843_ _03846_ _01506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16792_ cs_registers_i.mhpmcounter\[1917\] cs_registers_i.mhpmcounter\[1918\]
+ _03836_ _03847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16793_ _03835_ _03847_ _03848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16794_ _10813_ _03521_ _03848_ net1529 _03849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16795_ _03818_ _03841_ _03645_ _03850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16796_ _03644_ _03850_ cs_registers_i.mhpmcounter\[1918\]
+ _03851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16797_ _03710_ _03849_ _03851_ _01507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16798_ cs_registers_i.mhpmcounter\[1919\] _03852_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16799_ _03852_ net1529 _03824_ _03847_ _03853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_16800_ _10846_ _03521_ _03853_ _03854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16801_ cs_registers_i.mhpmcounter\[1919\] _03632_ _03855_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16802_ _03824_ _03847_ _03852_ _03606_ _03856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16803_ _03490_ _03855_ _03856_ _03857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16804_ _03633_ _03854_ _03857_ _01508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16805_ _03461_ _03462_ _03858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16806_ cs_registers_i.mhpmcounter\[1862\] net1515 _03859_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16807_ _03457_ _03858_ _03859_ _03860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16808_ _03377_ net1515 _03463_ _03457_ _03860_ _01509_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_16809_ _03523_ _03473_ _03861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16810_ _03520_ _03861_ _03485_ cs_registers_i.mhpmcounter\[1863\]
+ _03862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16811_ _03473_ _03863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16812_ cs_registers_i.mhpmcounter\[1863\] net1389 _03863_
+ _03864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16813_ _03384_ _03485_ _03862_ _03864_ _01510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_16814_ cs_registers_i.mhpmcounter\[1863\] _03463_ _03865_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16815_ cs_registers_i.mhpmcounter\[1864\] net1515 _03866_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_16816_ _03457_ _03865_ _03866_ _03867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16817_ cs_registers_i.mhpmcounter\[1864\] _03457_ _03865_
+ _03868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16818_ _03386_ net1515 _03867_ _03868_ _01511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_16819_ _03464_ _03473_ _03869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16820_ cs_registers_i.mhpmcounter\[1865\] _03869_ _03870_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16821_ cs_registers_i.mhpmcounter\[1865\] _03869_ _03871_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16822_ _03870_ _03871_ _03457_ _03872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_16823_ cs_registers_i.mhpmcounter\[1865\] _03485_ _03873_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16824_ _11024_ net1515 _03873_ net1389 _03874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16825_ _03872_ _03874_ _01512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xplace1443 _01023_ net1442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16827_ _09905_ _09943_ _03876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16828_ _09497_ _09919_ _03877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16829_ _03876_ _03877_ _03878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16830_ _09922_ _03878_ _03879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16831_ _09906_ _09908_ _03438_ _03880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16832_ _03880_ _09996_ _09945_ _03881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16833_ net1617 _03881_ _03882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16834_ cs_registers_i.priv_mode_id_o\[0\] _03882_ _03883_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16835_ net1747 net1746 _03883_ _03884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16836_ cs_registers_i.dcsr_q\[0\] net1747 net1746 cs_registers_i.mstatus_q\[2\]
+ _03885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16837_ _03884_ _03885_ _01513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16838_ cs_registers_i.priv_mode_id_o\[1\] _03882_ _03886_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_16839_ net1747 net1746 _03886_ _03887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_16840_ cs_registers_i.dcsr_q\[1\] net1747 net1746 cs_registers_i.mstatus_q\[3\]
+ _03888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16841_ _03887_ _03888_ _01514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16842_ cs_registers_i.dcsr_q\[0\] _03889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16843_ _10372_ _10201_ _03890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16844_ _09558_ net1608 _03891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_16845_ _10929_ net1535 _03891_ _03892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16846_ _10273_ _03653_ _03892_ _03893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_16847_ _03889_ _03890_ _03893_ _03894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1442 _01027_ net1441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16849_ cs_registers_i.priv_mode_id_o\[0\] _03894_ net1617
+ _01515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16850_ cs_registers_i.dcsr_q\[11\] _10348_ _03892_ _01516_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16851_ cs_registers_i.dcsr_q\[12\] _11052_ _03892_ _01517_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16852_ cs_registers_i.dcsr_q\[13\] _11059_ _03892_ _01518_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16853_ cs_registers_i.dcsr_q\[15\] net1531 _03892_ _01519_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16854_ cs_registers_i.dcsr_q\[1\] _03896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16855_ _03896_ _03890_ _03893_ _03897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_16856_ cs_registers_i.priv_mode_id_o\[1\] _03897_ net1617
+ _01520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16857_ cs_registers_i.dcsr_q\[2\] _10258_ _03892_ _01521_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16858_ cs_registers_i.dcsr_q\[6\] _03898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16859_ cs_registers_i.dcsr_q\[2\] _09923_ net1617 _03898_
+ _01522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16860_ cs_registers_i.dcsr_q\[7\] _03879_ _03899_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16861_ net65 _03900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16862_ id_stage_i.controller_i.ctrl_fsm_cs\[3\] _09921_
+ _03901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16863_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _03900_
+ cs_registers_i.dcsr_q\[2\] _03901_ _03902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_16864_ _03899_ _03902_ _01523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_16865_ cs_registers_i.dcsr_q\[2\] _09923_ net1617 cs_registers_i.dcsr_q\[8\]
+ _03903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_16866_ _03903_ _01524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2104 _01158_ net2103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16868_ cs_registers_i.pc_if_i\[10\] cs_registers_i.pc_id_i\[10\]
+ net1708 _03905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16869_ net1535 _10936_ _03906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1441 _01032_ net1440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16871_ cs_registers_i.csr_depc_o\[10\] _11033_ _03906_ _03908_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16872_ _03905_ _03908_ net1617 _01525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16873_ cs_registers_i.pc_if_i\[11\] cs_registers_i.pc_id_i\[11\]
+ net1708 _03909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16874_ cs_registers_i.csr_depc_o\[11\] _10348_ net1527 _03910_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16875_ _03909_ _03910_ net1617 _01526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16876_ cs_registers_i.pc_if_i\[12\] cs_registers_i.pc_id_i\[12\]
+ net1708 _03911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16877_ cs_registers_i.csr_depc_o\[12\] _11052_ net1527 _03912_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16878_ _03911_ _03912_ net1617 _01527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16879_ cs_registers_i.pc_if_i\[13\] cs_registers_i.pc_id_i\[13\]
+ net1708 _03913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16880_ cs_registers_i.csr_depc_o\[13\] _11059_ _03906_ _03914_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16881_ _03913_ _03914_ net1617 _01528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16882_ cs_registers_i.pc_if_i\[14\] cs_registers_i.pc_id_i\[14\]
+ net1708 _03915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16883_ cs_registers_i.csr_depc_o\[14\] _11064_ net1527 _03916_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16884_ _03915_ _03916_ _03879_ _01529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16885_ cs_registers_i.pc_if_i\[15\] cs_registers_i.pc_id_i\[15\]
+ net1708 _03917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16886_ cs_registers_i.csr_depc_o\[15\] net1531 net1527 _03918_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1440 _01033_ net1439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16888_ _03917_ _03918_ _03879_ _01530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16889_ cs_registers_i.pc_if_i\[16\] cs_registers_i.pc_id_i\[16\]
+ net1708 _03920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16890_ cs_registers_i.csr_depc_o\[16\] _11077_ _03906_ _03921_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16891_ _03920_ _03921_ net1617 _01531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16892_ cs_registers_i.pc_if_i\[17\] cs_registers_i.pc_id_i\[17\]
+ net1708 _03922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16893_ cs_registers_i.csr_depc_o\[17\] _11089_ net1527 _03923_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16894_ _03922_ _03923_ _03879_ _01532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16895_ cs_registers_i.pc_if_i\[18\] cs_registers_i.pc_id_i\[18\]
+ net1708 _03924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16896_ cs_registers_i.csr_depc_o\[18\] _11104_ _03906_ _03925_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16897_ _03924_ _03925_ net1617 _01533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1439 _01034_ net1438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16899_ cs_registers_i.pc_if_i\[19\] cs_registers_i.pc_id_i\[19\]
+ net1708 _03927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16900_ cs_registers_i.csr_depc_o\[19\] _10587_ _03906_ _03928_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16901_ _03927_ _03928_ _03879_ _01534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16902_ net2026 cs_registers_i.pc_id_i\[1\] net1708 _03929_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1438 _01035_ net1437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16904_ cs_registers_i.csr_depc_o\[1\] _10607_ net1527 _03931_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16905_ _03929_ _03931_ net1617 _01535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16906_ cs_registers_i.pc_if_i\[20\] cs_registers_i.pc_id_i\[20\]
+ net1708 _03932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16907_ cs_registers_i.csr_depc_o\[20\] _10624_ _03906_ _03933_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16908_ _03932_ _03933_ net1617 _01536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16909_ cs_registers_i.pc_if_i\[21\] cs_registers_i.pc_id_i\[21\]
+ net1708 _03934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16910_ cs_registers_i.csr_depc_o\[21\] _03296_ _03906_ _03935_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16911_ _03934_ _03935_ net1617 _01537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16912_ cs_registers_i.pc_if_i\[22\] cs_registers_i.pc_id_i\[22\]
+ net1708 _03936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16913_ cs_registers_i.csr_depc_o\[22\] _03306_ _03906_ _03937_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16914_ _03936_ _03937_ _03879_ _01538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16915_ cs_registers_i.pc_if_i\[23\] cs_registers_i.pc_id_i\[23\]
+ net1708 _03938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16916_ cs_registers_i.csr_depc_o\[23\] _03321_ _03906_ _03939_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16917_ _03938_ _03939_ net1617 _01539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16918_ cs_registers_i.pc_if_i\[24\] cs_registers_i.pc_id_i\[24\]
+ net1708 _03940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16919_ cs_registers_i.csr_depc_o\[24\] _03323_ _03906_ _03941_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1437 net165 net1436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_16921_ _03940_ _03941_ _03879_ _01540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16922_ cs_registers_i.pc_if_i\[25\] cs_registers_i.pc_id_i\[25\]
+ net1708 _03943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16923_ cs_registers_i.csr_depc_o\[25\] _03335_ _03906_ _03944_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16924_ _03943_ _03944_ _03879_ _01541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1436 net164 net1435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_16926_ cs_registers_i.pc_if_i\[26\] cs_registers_i.pc_id_i\[26\]
+ net1708 _03946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16927_ cs_registers_i.csr_depc_o\[26\] _10735_ _03906_ _03947_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16928_ _03946_ _03947_ _03879_ _01542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16929_ cs_registers_i.pc_if_i\[27\] cs_registers_i.pc_id_i\[27\]
+ net1708 _03948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16930_ cs_registers_i.csr_depc_o\[27\] net1517 _03906_ _03949_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16931_ _03948_ _03949_ _03879_ _01543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16932_ cs_registers_i.pc_if_i\[28\] cs_registers_i.pc_id_i\[28\]
+ net1708 _03950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16933_ cs_registers_i.csr_depc_o\[28\] net1516 _03906_ _03951_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16934_ _03950_ _03951_ _03879_ _01544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16935_ cs_registers_i.pc_if_i\[29\] cs_registers_i.pc_id_i\[29\]
+ net1708 _03952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1435 _09017_ net1434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16937_ cs_registers_i.csr_depc_o\[29\] _03365_ _03906_ _03954_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16938_ _03952_ _03954_ _03879_ _01545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16939_ cs_registers_i.pc_if_i\[2\] cs_registers_i.pc_id_i\[2\]
+ net1708 _03955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16940_ cs_registers_i.csr_depc_o\[2\] _10258_ net1527 _03956_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16941_ _03955_ _03956_ net1617 _01546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16942_ cs_registers_i.pc_if_i\[30\] cs_registers_i.pc_id_i\[30\]
+ net1708 _03957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16943_ cs_registers_i.csr_depc_o\[30\] _10813_ _03906_ _03958_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16944_ _03957_ _03958_ net1617 _01547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16945_ cs_registers_i.pc_if_i\[31\] cs_registers_i.pc_id_i\[31\]
+ net1708 _03959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16946_ cs_registers_i.csr_depc_o\[31\] _10846_ _03906_ _03960_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16947_ _03959_ _03960_ net1617 _01548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16948_ cs_registers_i.pc_if_i\[3\] cs_registers_i.pc_id_i\[3\]
+ net1708 _03961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16949_ cs_registers_i.csr_depc_o\[3\] _10891_ _03906_ _03962_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16950_ _03961_ _03962_ net1617 _01549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16951_ cs_registers_i.pc_if_i\[4\] cs_registers_i.pc_id_i\[4\]
+ net1708 _03963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16952_ cs_registers_i.csr_depc_o\[4\] _10911_ net1527 _03964_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16953_ _03963_ _03964_ net1617 _01550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16954_ cs_registers_i.pc_if_i\[5\] cs_registers_i.pc_id_i\[5\]
+ net1708 _03965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16955_ cs_registers_i.csr_depc_o\[5\] _10940_ _03906_ _03966_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16956_ _03965_ _03966_ net1617 _01551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16957_ cs_registers_i.pc_if_i\[6\] cs_registers_i.pc_id_i\[6\]
+ net1708 _03967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16958_ cs_registers_i.csr_depc_o\[6\] _10956_ _03906_ _03968_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16959_ _03967_ _03968_ net1617 _01552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16960_ cs_registers_i.pc_if_i\[7\] cs_registers_i.pc_id_i\[7\]
+ net1708 _03969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16961_ cs_registers_i.csr_depc_o\[7\] _10984_ net1527 _03970_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16962_ _03969_ _03970_ _03879_ _01553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16963_ cs_registers_i.pc_if_i\[8\] cs_registers_i.pc_id_i\[8\]
+ net1708 _03971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16964_ cs_registers_i.csr_depc_o\[8\] _11009_ net1527 _03972_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16965_ _03971_ _03972_ _03879_ _01554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16966_ cs_registers_i.pc_if_i\[9\] cs_registers_i.pc_id_i\[9\]
+ net1708 _03973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16967_ cs_registers_i.csr_depc_o\[9\] _11024_ net1527 _03974_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16968_ _03973_ _03974_ _03879_ _01555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16969_ net1535 _10935_ _03975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1434 net166 net1433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_16971_ cs_registers_i.dscratch0_q\[0\] _10225_ _03975_ _01556_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16972_ cs_registers_i.dscratch0_q\[10\] _03977_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16973_ _03977_ _10299_ net1526 _03978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16974_ _03978_ _01557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_16975_ cs_registers_i.dscratch0_q\[11\] _10348_ _03975_
+ _01558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16976_ cs_registers_i.dscratch0_q\[12\] _11052_ _03975_
+ _01559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16977_ cs_registers_i.dscratch0_q\[13\] _11059_ net1526
+ _01560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16978_ cs_registers_i.dscratch0_q\[14\] _11064_ net1526
+ _01561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16979_ cs_registers_i.dscratch0_q\[15\] net1531 net1526
+ _01562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16980_ cs_registers_i.dscratch0_q\[16\] _11077_ net1526
+ _01563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16981_ cs_registers_i.dscratch0_q\[17\] _11089_ net1526
+ _01564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16982_ cs_registers_i.dscratch0_q\[18\] _11104_ net1526
+ _01565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16983_ cs_registers_i.dscratch0_q\[19\] _10587_ net1526
+ _01566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2105 net2153 net2104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_16985_ cs_registers_i.dscratch0_q\[1\] _10607_ net1526 _01567_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16986_ cs_registers_i.dscratch0_q\[20\] _10624_ net1526
+ _01568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16987_ cs_registers_i.dscratch0_q\[21\] _03296_ net1526
+ _01569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16988_ cs_registers_i.dscratch0_q\[22\] _03306_ net1526
+ _01570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16989_ cs_registers_i.dscratch0_q\[23\] _03321_ net1526
+ _01571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16990_ cs_registers_i.dscratch0_q\[24\] _03323_ net1526
+ _01572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16991_ cs_registers_i.dscratch0_q\[25\] _03335_ net1526
+ _01573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16992_ cs_registers_i.dscratch0_q\[26\] _10735_ net1526
+ _01574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16993_ cs_registers_i.dscratch0_q\[27\] net1517 net1526
+ _01575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16994_ cs_registers_i.dscratch0_q\[28\] net1516 net1526
+ _01576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2106 _08544_ net2105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_16996_ cs_registers_i.dscratch0_q\[29\] _03365_ net1526
+ _01577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16997_ cs_registers_i.dscratch0_q\[2\] _10258_ net1526 _01578_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16998_ cs_registers_i.dscratch0_q\[30\] _10813_ net1526
+ _01579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_16999_ cs_registers_i.dscratch0_q\[31\] _10846_ _03975_
+ _01580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17000_ cs_registers_i.dscratch0_q\[3\] _10891_ net1526 _01581_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17001_ cs_registers_i.dscratch0_q\[4\] _10911_ _03975_ _01582_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17002_ cs_registers_i.dscratch0_q\[5\] _10940_ _03975_ _01583_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17003_ cs_registers_i.dscratch0_q\[6\] _10956_ net1526 _01584_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17004_ cs_registers_i.dscratch0_q\[7\] _10984_ net1526 _01585_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17005_ cs_registers_i.dscratch0_q\[8\] _11009_ net1526 _01586_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17006_ cs_registers_i.dscratch0_q\[9\] _11024_ net1526 _01587_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17007_ net1535 _10930_ _03981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1433 net168 net1432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17009_ cs_registers_i.dscratch1_q\[0\] _10225_ net1525 _01588_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17010_ cs_registers_i.dscratch1_q\[10\] _03983_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17011_ _03983_ _10299_ net1525 _03984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17012_ _03984_ _01589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17013_ cs_registers_i.dscratch1_q\[11\] _10348_ net1525
+ _01590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17014_ cs_registers_i.dscratch1_q\[12\] _11052_ net1525
+ _01591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17015_ cs_registers_i.dscratch1_q\[13\] _11059_ net1525
+ _01592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17016_ cs_registers_i.dscratch1_q\[14\] _11064_ net1525
+ _01593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17017_ cs_registers_i.dscratch1_q\[15\] net1531 net1525
+ _01594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17018_ cs_registers_i.dscratch1_q\[16\] _11077_ net1525
+ _01595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17019_ cs_registers_i.dscratch1_q\[17\] _11089_ net1525
+ _01596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17020_ cs_registers_i.dscratch1_q\[18\] _11104_ net1525
+ _01597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17021_ cs_registers_i.dscratch1_q\[19\] _10587_ net1525
+ _01598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2107 _09485_ net2106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17023_ cs_registers_i.dscratch1_q\[1\] _10607_ net1525 _01599_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17024_ cs_registers_i.dscratch1_q\[20\] _10624_ net1525
+ _01600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17025_ cs_registers_i.dscratch1_q\[21\] _03296_ net1525
+ _01601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17026_ cs_registers_i.dscratch1_q\[22\] _03306_ net1525
+ _01602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17027_ cs_registers_i.dscratch1_q\[23\] _03321_ net1525
+ _01603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17028_ cs_registers_i.dscratch1_q\[24\] _03323_ net1525
+ _01604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17029_ cs_registers_i.dscratch1_q\[25\] _03335_ net1525
+ _01605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17030_ cs_registers_i.dscratch1_q\[26\] _10735_ net1525
+ _01606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17031_ cs_registers_i.dscratch1_q\[27\] net1517 net1525
+ _01607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17032_ cs_registers_i.dscratch1_q\[28\] net1516 net1525
+ _01608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1432 net171 net1431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17034_ cs_registers_i.dscratch1_q\[29\] _03365_ net1525
+ _01609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17035_ cs_registers_i.dscratch1_q\[2\] _10258_ net1525 _01610_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17036_ cs_registers_i.dscratch1_q\[30\] _10813_ net1525
+ _01611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17037_ cs_registers_i.dscratch1_q\[31\] _10846_ net1525
+ _01612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17038_ cs_registers_i.dscratch1_q\[3\] _10891_ net1525 _01613_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17039_ cs_registers_i.dscratch1_q\[4\] _10911_ net1525 _01614_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17040_ cs_registers_i.dscratch1_q\[5\] _10940_ net1525 _01615_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17041_ cs_registers_i.dscratch1_q\[6\] _10956_ net1525 _01616_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17042_ cs_registers_i.dscratch1_q\[7\] _10984_ net1525 _01617_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17043_ cs_registers_i.dscratch1_q\[8\] _11009_ net1525 _01618_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17044_ cs_registers_i.dscratch1_q\[9\] _11024_ net1525 _01619_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17045_ _09922_ _03878_ _03881_ cs_registers_i.debug_mode_i
+ _03987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_17046_ cs_registers_i.nmi_mode_i net1746 _03988_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17047_ net1588 _03988_ _03989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xrebuffer2205 net170 net2204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1430 net173 net1429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17050_ _09907_ _09651_ _09900_ _03992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xplace1429 _09309_ net1428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_17052_ net1840 net1706 _03994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17053_ _09908_ _03438_ _03995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17054_ cs_registers_i.debug_mode_i _09905_ _03996_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17055_ _09640_ _03996_ net1932 _03997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17056_ _03995_ _03997_ _03998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17057_ _09524_ _09899_ _09917_ _03999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17058_ id_stage_i.controller_i.illegal_insn_q _03999_ _09900_
+ _09996_ _04000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17059_ _03994_ _03998_ _04000_ _04001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17060_ _09988_ _04001_ _04002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xrebuffer2108 _00889_ net2107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1428 _04881_ net1427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17063_ cs_registers_i.mstack_cause_q\[0\] net1707 _04002_
+ net1588 _04005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17064_ _10273_ net1580 _04005_ _04006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17065_ _10372_ _10214_ net1580 _04007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17066_ _04006_ cs_registers_i.mcause_q\[0\] _04007_ _01620_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17067_ id_stage_i.controller_i.illegal_insn_q _09917_ _04008_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1427 _04883_ net1426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17069_ id_stage_i.controller_i.store_err_q _09651_ _04008_
+ _04010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17070_ _03998_ _04010_ _04011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17071_ _04000_ _04011_ _10006_ _04012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17072_ cs_registers_i.mstack_cause_q\[1\] net1707 _04012_
+ net1588 _04013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17073_ _03653_ net1580 _04013_ _04014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17074_ _04014_ cs_registers_i.mcause_q\[1\] _04007_ _01621_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17075_ net1588 _04015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2109 net2172 net2108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17077_ _09925_ _09926_ _04017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17078_ _09931_ _09932_ _04018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17079_ _09935_ _04019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17080_ net1835 _10004_ _04020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17081_ _04017_ _04018_ _09969_ _04019_ _04020_ _04021_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_17082_ _09499_ net1706 _04021_ _09945_ _04022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17083_ cs_registers_i.mstack_cause_q\[2\] net1707 _04023_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17084_ net1580 _04024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17085_ _10258_ _04024_ _04025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17086_ _04015_ _04022_ _04023_ _04025_ _04026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_17087_ _04026_ cs_registers_i.mcause_q\[2\] _04007_ _01622_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17088_ _10875_ _10890_ _04027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17089_ net1855 _09996_ _04028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17090_ net2050 cs_registers_i.mie_q\[15\] _09929_ _04029_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17091_ _09933_ _10004_ _04030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17092_ _04029_ _04030_ _09945_ _04031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17093_ _09908_ _03438_ _04028_ _04031_ _04032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17094_ cs_registers_i.mstack_cause_q\[3\] net1707 _04032_
+ net1588 _04033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17095_ _04027_ net1580 _04033_ _04034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17096_ _04034_ cs_registers_i.mcause_q\[3\] _04007_ _01623_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17097_ _09986_ _04035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17098_ _09969_ _04035_ _04036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_17099_ _09944_ _04036_ _04037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17100_ cs_registers_i.mstack_cause_q\[4\] net1707 _04037_
+ _04038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17101_ _11093_ net1580 _04038_ _04039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17102_ _04039_ cs_registers_i.mcause_q\[4\] _04007_ _01624_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17103_ _10846_ _04024_ _04040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2110 _00825_ net2109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17105_ cs_registers_i.mstack_cause_q\[5\] net1707 _04042_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17106_ _09945_ _04040_ _04042_ _04043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17107_ _04043_ cs_registers_i.mcause_q\[5\] _04007_ _01625_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17108_ net1535 _10923_ _03989_ _04044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xrebuffer2111 _07630_ net2110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17110_ cs_registers_i.mstack_epc_q\[0\] net1707 _04044_
+ cs_registers_i.csr_mepc_o\[0\] _04046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17111_ _04046_ _01626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xclone2112 net2148 net2111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17113_ _03905_ net1588 net1707 cs_registers_i.mstack_epc_q\[10\]
+ _04048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17114_ _10299_ net1580 _04048_ _04049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17115_ _04049_ cs_registers_i.csr_mepc_o\[10\] _04044_ _01627_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2113 net2113 net2112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_17117_ _03909_ net1588 net1707 cs_registers_i.mstack_epc_q\[11\]
+ _04051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17118_ _03471_ net1580 _04051_ _04052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17119_ _04052_ cs_registers_i.csr_mepc_o\[11\] _04044_ _01628_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17120_ _03911_ net1588 net1707 cs_registers_i.mstack_epc_q\[12\]
+ _04053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17121_ _10404_ net1580 _04053_ _04054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17122_ _04054_ cs_registers_i.csr_mepc_o\[12\] _04044_ _01629_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17123_ _03913_ net1588 net1707 cs_registers_i.mstack_epc_q\[13\]
+ _04055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17124_ _10448_ net1580 _04055_ _04056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17125_ _04056_ cs_registers_i.csr_mepc_o\[13\] net1524 _01630_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17126_ _03915_ net1588 net1707 cs_registers_i.mstack_epc_q\[14\]
+ _04057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17127_ _10472_ net1580 _04057_ _04058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17128_ _04058_ cs_registers_i.csr_mepc_o\[14\] _04044_ _01631_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17129_ net1531 _04059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17130_ _03917_ net1588 net1707 cs_registers_i.mstack_epc_q\[15\]
+ _04060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17131_ _04059_ net1580 _04060_ _04061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17132_ _04061_ cs_registers_i.csr_mepc_o\[15\] _04044_ _01632_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2114 gen_regfile_ff.register_file_i.raddr_b_i\[0\]
+ net2113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone2115 net2058 net2114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_17135_ _03920_ net1588 net1707 cs_registers_i.mstack_epc_q\[16\]
+ _04064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17136_ _10525_ net1580 _04064_ _04065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xrebuffer2116 _07555_ net2115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17138_ _04065_ cs_registers_i.csr_mepc_o\[16\] net1524 _01633_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17139_ _03922_ net1588 net1707 cs_registers_i.mstack_epc_q\[17\]
+ _04067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17140_ _10546_ net1580 _04067_ _04068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17141_ _04068_ cs_registers_i.csr_mepc_o\[17\] _04044_ _01634_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17142_ _03924_ net1588 net1707 cs_registers_i.mstack_epc_q\[18\]
+ _04069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17143_ _10567_ net1580 _04069_ _04070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17144_ _04070_ cs_registers_i.csr_mepc_o\[18\] net1524 _01635_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17145_ _03927_ net1588 net1707 cs_registers_i.mstack_epc_q\[19\]
+ _04071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17146_ _03537_ net1580 _04071_ _04072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17147_ _04072_ cs_registers_i.csr_mepc_o\[19\] net1524 _01636_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17148_ _03929_ net1588 net1707 cs_registers_i.mstack_epc_q\[1\]
+ _04073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17149_ _03653_ net1580 _04073_ _04074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17150_ _04074_ cs_registers_i.csr_mepc_o\[1\] _04044_ _01637_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1426 _01039_ net1425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17152_ _03932_ net1588 net1707 cs_registers_i.mstack_epc_q\[20\]
+ _04076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17153_ _03547_ net1580 _04076_ _04077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17154_ _04077_ cs_registers_i.csr_mepc_o\[20\] net1524 _01638_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17155_ _03934_ net1588 net1707 cs_registers_i.mstack_epc_q\[21\]
+ _04078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17156_ _10647_ net1580 _04078_ _04079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17157_ _04079_ cs_registers_i.csr_mepc_o\[21\] net1524 _01639_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17158_ _03936_ net1588 net1707 cs_registers_i.mstack_epc_q\[22\]
+ _04080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17159_ _10663_ net1580 _04080_ _04081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17160_ _04081_ cs_registers_i.csr_mepc_o\[22\] net1524 _01640_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17161_ _03938_ net1588 net1707 cs_registers_i.mstack_epc_q\[23\]
+ _04082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17162_ _10678_ net1580 _04082_ _04083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17163_ _04083_ cs_registers_i.csr_mepc_o\[23\] net1524 _01641_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17164_ _03940_ net1588 net1707 cs_registers_i.mstack_epc_q\[24\]
+ _04084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17165_ _10698_ net1580 _04084_ _04085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17166_ _04085_ cs_registers_i.csr_mepc_o\[24\] net1524 _01642_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1425 _01040_ net1424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1424 _01045_ net1423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17169_ _03943_ net1588 net1707 cs_registers_i.mstack_epc_q\[25\]
+ _04088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17170_ _10716_ net1580 _04088_ _04089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1423 _01046_ net1422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17172_ _04089_ cs_registers_i.csr_mepc_o\[25\] net1524 _01643_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17173_ cs_registers_i.csr_mepc_o\[26\] _04091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17174_ _03946_ net1588 net1707 cs_registers_i.mstack_epc_q\[26\]
+ _04092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17175_ _04092_ _04093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17176_ _10735_ _04024_ net1524 _04093_ _04094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_17177_ _04091_ net1524 _04094_ _01644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17178_ cs_registers_i.csr_mepc_o\[27\] _04095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17179_ _03948_ net1588 net1707 cs_registers_i.mstack_epc_q\[27\]
+ _04096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17180_ _04096_ _04097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17181_ net1517 _04024_ net1524 _04097_ _04098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_17182_ _04095_ net1524 _04098_ _01645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17183_ cs_registers_i.csr_mepc_o\[28\] _04099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17184_ _03950_ net1588 net1707 cs_registers_i.mstack_epc_q\[28\]
+ _04100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17185_ _04100_ _04101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17186_ net1516 _04024_ net1524 _04101_ _04102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_17187_ _04099_ net1524 _04102_ _01646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17188_ _03952_ net1588 net1707 cs_registers_i.mstack_epc_q\[29\]
+ _04103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17189_ _10788_ net1580 _04103_ _04104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17190_ _04104_ cs_registers_i.csr_mepc_o\[29\] net1524 _01647_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17191_ _03955_ net1588 net1707 cs_registers_i.mstack_epc_q\[2\]
+ _04105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17192_ _04025_ _04105_ _04106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17193_ _04106_ cs_registers_i.csr_mepc_o\[2\] _04044_ _01648_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17194_ _10800_ _10801_ _10802_ _10809_ _04107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_17195_ net1705 _10811_ _04107_ _01347_ _04108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17196_ _03957_ net1588 net1707 cs_registers_i.mstack_epc_q\[30\]
+ _04109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17197_ _04108_ net1580 _04109_ _04110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17198_ _04110_ cs_registers_i.csr_mepc_o\[30\] net1524 _01649_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17199_ _03959_ net1588 _04111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17200_ cs_registers_i.mstack_epc_q\[31\] net1707 _04112_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17201_ _04040_ _04111_ _04112_ _04113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17202_ _04113_ cs_registers_i.csr_mepc_o\[31\] _04044_ _01650_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17203_ _03961_ net1588 net1707 cs_registers_i.mstack_epc_q\[3\]
+ _04114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17204_ _04027_ net1580 _04114_ _04115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17205_ _04115_ cs_registers_i.csr_mepc_o\[3\] _04044_ _01651_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17206_ _03963_ net1588 net1707 cs_registers_i.mstack_epc_q\[4\]
+ _04116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17207_ _11093_ net1580 _04116_ _04117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17208_ _04117_ cs_registers_i.csr_mepc_o\[4\] _04044_ _01652_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17209_ _03965_ net1588 net1707 cs_registers_i.mstack_epc_q\[5\]
+ _04118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17210_ _03347_ net1580 _04118_ _04119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17211_ _04119_ cs_registers_i.csr_mepc_o\[5\] _04044_ _01653_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17212_ _03967_ net1588 net1707 cs_registers_i.mstack_epc_q\[6\]
+ _04120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17213_ _03377_ net1580 _04120_ _04121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17214_ _04121_ cs_registers_i.csr_mepc_o\[6\] _04044_ _01654_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17215_ _03969_ net1588 net1707 cs_registers_i.mstack_epc_q\[7\]
+ _04122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17216_ _03384_ net1580 _04122_ _04123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17217_ _04123_ cs_registers_i.csr_mepc_o\[7\] _04044_ _01655_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17218_ _03971_ net1588 net1707 cs_registers_i.mstack_epc_q\[8\]
+ _04124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17219_ _03386_ net1580 _04124_ _04125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17220_ _04125_ cs_registers_i.csr_mepc_o\[8\] _04044_ _01656_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17221_ _11012_ _11023_ _04126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17222_ _03973_ net1588 net1707 cs_registers_i.mstack_epc_q\[9\]
+ _04127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17223_ _04126_ net1580 _04127_ _04128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17224_ _04128_ cs_registers_i.csr_mepc_o\[9\] _04044_ _01657_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17225_ net1701 _07859_ _04129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17226_ _09588_ _04129_ _09577_ _04130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17227_ _09600_ _04130_ _04131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17228_ net1535 _04131_ _04132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1422 _01051_ net1421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1421 _01052_ net1420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17231_ cs_registers_i.mie_q\[0\] _11077_ _04132_ _01658_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17232_ cs_registers_i.mie_q\[10\] _10735_ _04132_ _01659_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17233_ cs_registers_i.mie_q\[11\] net1517 _04132_ _01660_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17234_ cs_registers_i.mie_q\[12\] net1516 _04132_ _01661_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17235_ cs_registers_i.mie_q\[13\] _03365_ _04132_ _01662_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17236_ cs_registers_i.mie_q\[14\] _10813_ _04132_ _01663_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17237_ cs_registers_i.mie_q\[15\] _10348_ _04132_ _01664_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17238_ cs_registers_i.mie_q\[16\] _10984_ _04132_ _01665_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17239_ cs_registers_i.mie_q\[17\] _10891_ _04132_ _01666_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17240_ cs_registers_i.mie_q\[1\] _11089_ _04132_ _01667_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17241_ cs_registers_i.mie_q\[2\] _11104_ _04132_ _01668_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17242_ cs_registers_i.mie_q\[3\] _10587_ _04132_ _01669_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17243_ cs_registers_i.mie_q\[4\] _10624_ _04132_ _01670_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17244_ cs_registers_i.mie_q\[5\] _03296_ _04132_ _01671_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17245_ cs_registers_i.mie_q\[6\] _03306_ _04132_ _01672_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17246_ cs_registers_i.mie_q\[7\] _03321_ _04132_ _01673_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17247_ cs_registers_i.mie_q\[8\] _03323_ _04132_ _01674_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17248_ cs_registers_i.mie_q\[9\] _03335_ _04132_ _01675_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17249_ net1535 _10925_ _04135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2117 net1690 net2116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17251_ cs_registers_i.mscratch_q\[0\] _10225_ _04135_ _01676_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17252_ cs_registers_i.mscratch_q\[10\] _04137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17253_ _04137_ _10299_ net1523 _04138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17254_ _04138_ _01677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17255_ cs_registers_i.mscratch_q\[11\] _10348_ _04135_ _01678_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17256_ cs_registers_i.mscratch_q\[12\] _11052_ _04135_ _01679_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17257_ cs_registers_i.mscratch_q\[13\] _11059_ _04135_ _01680_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17258_ cs_registers_i.mscratch_q\[14\] _11064_ net1523 _01681_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17259_ cs_registers_i.mscratch_q\[15\] net1531 _04135_ _01682_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17260_ cs_registers_i.mscratch_q\[16\] _11077_ net1523 _01683_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17261_ cs_registers_i.mscratch_q\[17\] _11089_ _04135_ _01684_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17262_ cs_registers_i.mscratch_q\[18\] _11104_ net1523 _01685_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17263_ cs_registers_i.mscratch_q\[19\] _10587_ net1523 _01686_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1420 _01058_ net1419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17265_ cs_registers_i.mscratch_q\[1\] _10607_ _04135_ _01687_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17266_ cs_registers_i.mscratch_q\[20\] _10624_ net1523 _01688_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17267_ cs_registers_i.mscratch_q\[21\] _03296_ net1523 _01689_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17268_ cs_registers_i.mscratch_q\[22\] _03306_ net1523 _01690_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17269_ cs_registers_i.mscratch_q\[23\] _03321_ net1523 _01691_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17270_ cs_registers_i.mscratch_q\[24\] _03323_ net1523 _01692_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17271_ cs_registers_i.mscratch_q\[25\] _03335_ net1523 _01693_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17272_ cs_registers_i.mscratch_q\[26\] _10735_ net1523 _01694_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17273_ cs_registers_i.mscratch_q\[27\] net1517 net1523 _01695_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17274_ cs_registers_i.mscratch_q\[28\] net1516 net1523 _01696_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1419 _01063_ net1418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17276_ cs_registers_i.mscratch_q\[29\] _03365_ net1523 _01697_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17277_ cs_registers_i.mscratch_q\[2\] _10258_ _04135_ _01698_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17278_ cs_registers_i.mscratch_q\[30\] _10813_ net1523 _01699_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17279_ cs_registers_i.mscratch_q\[31\] _10846_ _04135_ _01700_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17280_ cs_registers_i.mscratch_q\[3\] _10891_ _04135_ _01701_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17281_ cs_registers_i.mscratch_q\[4\] _10911_ _04135_ _01702_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17282_ cs_registers_i.mscratch_q\[5\] _10940_ _04135_ _01703_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17283_ cs_registers_i.mscratch_q\[6\] _10956_ _04135_ _01704_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17284_ cs_registers_i.mscratch_q\[7\] _10984_ _04135_ _01705_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17285_ cs_registers_i.mscratch_q\[8\] _11009_ _04135_ _01706_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17286_ cs_registers_i.mscratch_q\[9\] _11024_ net1523 _01707_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1417 _01069_ net1416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17288_ cs_registers_i.mstack_cause_q\[0\] cs_registers_i.mcause_q\[0\]
+ net1588 _01708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17289_ cs_registers_i.mstack_cause_q\[1\] cs_registers_i.mcause_q\[1\]
+ net1588 _01709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17290_ cs_registers_i.mstack_cause_q\[2\] cs_registers_i.mcause_q\[2\]
+ net1588 _01710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17291_ cs_registers_i.mstack_cause_q\[3\] cs_registers_i.mcause_q\[3\]
+ net1588 _01711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17292_ cs_registers_i.mstack_cause_q\[4\] cs_registers_i.mcause_q\[4\]
+ net1588 _01712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17293_ cs_registers_i.mstack_cause_q\[5\] cs_registers_i.mcause_q\[5\]
+ net1588 _01713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17294_ cs_registers_i.mstack_q\[0\] cs_registers_i.mstatus_q\[2\]
+ net1588 _01714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1416 _01070_ net1415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17296_ cs_registers_i.mstack_q\[1\] cs_registers_i.mstatus_q\[3\]
+ net1588 _01715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17297_ cs_registers_i.mstack_q\[2\] cs_registers_i.mstatus_q\[4\]
+ net1588 _01716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17298_ cs_registers_i.mstack_epc_q\[0\] cs_registers_i.csr_mepc_o\[0\]
+ net1588 _01717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17299_ cs_registers_i.mstack_epc_q\[10\] cs_registers_i.csr_mepc_o\[10\]
+ net1588 _01718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17300_ cs_registers_i.mstack_epc_q\[11\] cs_registers_i.csr_mepc_o\[11\]
+ net1588 _01719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17301_ cs_registers_i.mstack_epc_q\[12\] cs_registers_i.csr_mepc_o\[12\]
+ net1588 _01720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17302_ cs_registers_i.mstack_epc_q\[13\] cs_registers_i.csr_mepc_o\[13\]
+ net1588 _01721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17303_ cs_registers_i.mstack_epc_q\[14\] cs_registers_i.csr_mepc_o\[14\]
+ net1588 _01722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17304_ cs_registers_i.mstack_epc_q\[15\] cs_registers_i.csr_mepc_o\[15\]
+ net1588 _01723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17305_ cs_registers_i.mstack_epc_q\[16\] cs_registers_i.csr_mepc_o\[16\]
+ net1588 _01724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1415 _01076_ net1414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17307_ cs_registers_i.mstack_epc_q\[17\] cs_registers_i.csr_mepc_o\[17\]
+ net1588 _01725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17308_ cs_registers_i.mstack_epc_q\[18\] cs_registers_i.csr_mepc_o\[18\]
+ net1588 _01726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17309_ cs_registers_i.mstack_epc_q\[19\] cs_registers_i.csr_mepc_o\[19\]
+ net1588 _01727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17310_ cs_registers_i.mstack_epc_q\[1\] cs_registers_i.csr_mepc_o\[1\]
+ net1588 _01728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17311_ cs_registers_i.mstack_epc_q\[20\] cs_registers_i.csr_mepc_o\[20\]
+ net1588 _01729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17312_ cs_registers_i.mstack_epc_q\[21\] cs_registers_i.csr_mepc_o\[21\]
+ net1588 _01730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17313_ cs_registers_i.mstack_epc_q\[22\] cs_registers_i.csr_mepc_o\[22\]
+ net1588 _01731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17314_ cs_registers_i.mstack_epc_q\[23\] cs_registers_i.csr_mepc_o\[23\]
+ net1588 _01732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17315_ cs_registers_i.mstack_epc_q\[24\] cs_registers_i.csr_mepc_o\[24\]
+ net1588 _01733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17316_ cs_registers_i.mstack_epc_q\[25\] cs_registers_i.csr_mepc_o\[25\]
+ net1588 _01734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1418 _01064_ net1417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17318_ cs_registers_i.mstack_epc_q\[26\] cs_registers_i.csr_mepc_o\[26\]
+ net1588 _01735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17319_ cs_registers_i.mstack_epc_q\[27\] cs_registers_i.csr_mepc_o\[27\]
+ net1588 _01736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17320_ cs_registers_i.mstack_epc_q\[28\] cs_registers_i.csr_mepc_o\[28\]
+ net1588 _01737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17321_ cs_registers_i.mstack_epc_q\[29\] cs_registers_i.csr_mepc_o\[29\]
+ net1588 _01738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17322_ cs_registers_i.mstack_epc_q\[2\] cs_registers_i.csr_mepc_o\[2\]
+ net1588 _01739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17323_ cs_registers_i.mstack_epc_q\[30\] cs_registers_i.csr_mepc_o\[30\]
+ net1588 _01740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17324_ cs_registers_i.mstack_epc_q\[31\] cs_registers_i.csr_mepc_o\[31\]
+ net1588 _01741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17325_ cs_registers_i.mstack_epc_q\[3\] cs_registers_i.csr_mepc_o\[3\]
+ net1588 _01742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17326_ cs_registers_i.mstack_epc_q\[4\] cs_registers_i.csr_mepc_o\[4\]
+ net1588 _01743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17327_ cs_registers_i.mstack_epc_q\[5\] cs_registers_i.csr_mepc_o\[5\]
+ net1588 _01744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1414 _01094_ net1413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17329_ cs_registers_i.mstack_epc_q\[6\] cs_registers_i.csr_mepc_o\[6\]
+ net1588 _01745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17330_ cs_registers_i.mstack_epc_q\[7\] cs_registers_i.csr_mepc_o\[7\]
+ net1588 _01746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17331_ cs_registers_i.mstack_epc_q\[8\] cs_registers_i.csr_mepc_o\[8\]
+ net1588 _01747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17332_ cs_registers_i.mstack_epc_q\[9\] cs_registers_i.csr_mepc_o\[9\]
+ net1588 _01748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17333_ _10372_ _10535_ _04146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17334_ cs_registers_i.csr_mstatus_tw_o _03296_ _04146_ _01749_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17335_ cs_registers_i.mstatus_q\[1\] _11089_ _04146_ _01750_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1413 _01099_ net1412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2118 _07629_ net2117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17338_ id_stage_i.controller_i.instr_i\[0\] id_stage_i.controller_i.instr_compressed_i\[0\]
+ id_stage_i.controller_i.instr_is_compressed_i _04149_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17339_ id_stage_i.controller_i.lsu_addr_last_i\[0\] net1706
+ _04008_ _04149_ _04150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17340_ _09907_ _03994_ _04151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17341_ _09942_ _09996_ _04151_ _04152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_17342_ _10273_ net1588 _04150_ net1579 _04153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17343_ net1535 _10927_ _04154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17344_ _04015_ _04154_ _04155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2119 _07831_ net2118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17346_ cs_registers_i.mtval_q\[0\] _04153_ _04155_ _01755_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2120 net2120 _08215_ _08217_ net2119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17348_ gen_regfile_ff.register_file_i.waddr_a_i\[3\] id_stage_i.controller_i.instr_compressed_i\[10\]
+ id_stage_i.controller_i.instr_is_compressed_i _04158_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17349_ cs_registers_i.pc_id_i\[3\] cs_registers_i.pc_id_i\[4\]
+ cs_registers_i.pc_id_i\[5\] _04159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17350_ cs_registers_i.pc_id_i\[1\] cs_registers_i.pc_id_i\[2\]
+ id_stage_i.controller_i.instr_fetch_err_plus2_i _04159_ _04160_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17351_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_id_i\[7\]
+ cs_registers_i.pc_id_i\[8\] cs_registers_i.pc_id_i\[9\] _04161_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17352_ _04160_ _04161_ _04162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17353_ cs_registers_i.pc_id_i\[10\] _04162_ _04163_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xplace1412 _01118_ net1411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17355_ id_stage_i.controller_i.lsu_addr_last_i\[10\] net1706
+ _04008_ _04158_ _04163_ net1840 _04165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17356_ _10299_ net1588 net1579 _04165_ _04166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17357_ cs_registers_i.mtval_q\[10\] _04166_ _04155_ _01756_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2121 _08216_ net2120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17359_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] id_stage_i.controller_i.instr_compressed_i\[11\]
+ id_stage_i.controller_i.instr_is_compressed_i _04168_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17360_ cs_registers_i.pc_id_i\[3\] cs_registers_i.pc_id_i\[4\]
+ id_stage_i.controller_i.instr_fetch_err_plus2_i _00960_ _04169_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17361_ cs_registers_i.pc_id_i\[5\] _04169_ _04170_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17362_ cs_registers_i.pc_id_i\[10\] _04161_ _04171_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17363_ _04170_ _04171_ _04172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17364_ cs_registers_i.pc_id_i\[11\] _04172_ _04173_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17365_ id_stage_i.controller_i.lsu_addr_last_i\[11\] net1706
+ _04008_ _04168_ _04173_ net1840 _04174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17366_ _03471_ net1588 net1579 _04174_ _04175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17367_ cs_registers_i.mtval_q\[11\] _04175_ _04155_ _01757_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17368_ net2021 id_stage_i.controller_i.instr_compressed_i\[12\]
+ id_stage_i.controller_i.instr_is_compressed_i _04176_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17369_ _04160_ _04171_ _04177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17370_ cs_registers_i.pc_id_i\[11\] _04177_ _04178_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17371_ cs_registers_i.pc_id_i\[12\] _04178_ _04179_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17372_ id_stage_i.controller_i.lsu_addr_last_i\[12\] net1706
+ _04008_ _04176_ _04179_ net1840 _04180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17373_ _10404_ net1588 net1579 _04180_ _04181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17374_ cs_registers_i.mtval_q\[12\] _04181_ _04155_ _01758_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17375_ id_stage_i.controller_i.instr_i\[13\] id_stage_i.controller_i.instr_compressed_i\[13\]
+ id_stage_i.controller_i.instr_is_compressed_i _04182_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17376_ cs_registers_i.pc_id_i\[12\] cs_registers_i.pc_id_i\[11\]
+ _04172_ _04183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17377_ cs_registers_i.pc_id_i\[13\] _04183_ _04184_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17378_ id_stage_i.controller_i.lsu_addr_last_i\[13\] net1706
+ _04008_ _04182_ _04184_ net1840 _04185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17379_ _10448_ net1588 net1579 _04185_ _04186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17380_ cs_registers_i.mtval_q\[13\] _04186_ _04155_ _01759_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2122 _08216_ net2121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17382_ id_stage_i.controller_i.instr_i\[14\] id_stage_i.controller_i.instr_compressed_i\[14\]
+ id_stage_i.controller_i.instr_is_compressed_i _04188_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17383_ cs_registers_i.pc_id_i\[14\] _04189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17384_ cs_registers_i.pc_id_i\[12\] cs_registers_i.pc_id_i\[11\]
+ cs_registers_i.pc_id_i\[13\] _04177_ _04190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17385_ _04189_ _04190_ _04191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xplace1411 net167 net1410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17387_ id_stage_i.controller_i.lsu_addr_last_i\[14\] net1706
+ _04008_ _04188_ _04191_ net1840 _04193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17388_ _10472_ net1588 net1579 _04193_ _04194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17389_ cs_registers_i.mtval_q\[14\] _04194_ net1514 _01760_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2123 net1406 net2122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17391_ net2017 id_stage_i.controller_i.instr_compressed_i\[15\]
+ id_stage_i.controller_i.instr_is_compressed_i _04196_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17392_ cs_registers_i.pc_id_i\[12\] cs_registers_i.pc_id_i\[11\]
+ cs_registers_i.pc_id_i\[13\] _04172_ _04197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17393_ cs_registers_i.pc_id_i\[14\] _04197_ _04198_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17394_ cs_registers_i.pc_id_i\[15\] _04198_ _04199_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17395_ id_stage_i.controller_i.lsu_addr_last_i\[15\] net1706
+ _04008_ _04196_ _04199_ net1840 _04200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17396_ _04059_ net1588 net1579 _04200_ _04201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xrebuffer2124 _08504_ net2123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17398_ cs_registers_i.mtval_q\[15\] _04201_ _04155_ _01761_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1410 net172 net1409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17400_ cs_registers_i.pc_id_i\[14\] cs_registers_i.pc_id_i\[15\]
+ _04190_ _04204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17401_ cs_registers_i.pc_id_i\[16\] _04204_ _04205_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
Xrebuffer2125 _08391_ net2124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17403_ id_stage_i.controller_i.instr_is_compressed_i _04207_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17404_ _04207_ _04008_ _04208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1409 net2169 net1408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17406_ id_stage_i.controller_i.lsu_addr_last_i\[16\] net1706
+ _04205_ net1840 _04208_ net1965 _04210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17407_ _10525_ net1588 net1579 _04210_ _04211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17408_ cs_registers_i.mtval_q\[16\] _04211_ net1514 _01762_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17409_ cs_registers_i.pc_id_i\[17\] _04212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17410_ cs_registers_i.pc_id_i\[14\] cs_registers_i.pc_id_i\[15\]
+ cs_registers_i.pc_id_i\[16\] _04197_ _04213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17411_ _04212_ _04213_ _04214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17412_ id_stage_i.controller_i.lsu_addr_last_i\[17\] net1706
+ _04214_ net1840 _04208_ net1962 _04215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17413_ _10546_ net1588 net1579 _04215_ _04216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17414_ cs_registers_i.mtval_q\[17\] _04216_ net1514 _01763_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17415_ cs_registers_i.pc_id_i\[18\] _04217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17416_ cs_registers_i.pc_id_i\[14\] cs_registers_i.pc_id_i\[15\]
+ cs_registers_i.pc_id_i\[16\] cs_registers_i.pc_id_i\[17\]
+ _04218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17417_ _04190_ _04218_ _04219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17418_ _04217_ _04219_ _04220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17419_ id_stage_i.controller_i.lsu_addr_last_i\[18\] net1706
+ _04220_ net1840 _04208_ net1960 _04221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17420_ _10567_ net1588 net1579 _04221_ _04222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17421_ cs_registers_i.mtval_q\[18\] _04222_ net1514 _01764_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17422_ cs_registers_i.pc_id_i\[18\] _04218_ _04223_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17423_ _04197_ _04223_ _04224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17424_ cs_registers_i.pc_id_i\[19\] _04224_ _04225_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17425_ id_stage_i.controller_i.lsu_addr_last_i\[19\] net1706
+ _04225_ net1840 _04208_ net1958 _04226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17426_ _03537_ net1588 net1579 _04226_ _04227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17427_ cs_registers_i.mtval_q\[19\] _04227_ net1514 _01765_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17428_ id_stage_i.controller_i.instr_i\[1\] id_stage_i.controller_i.instr_compressed_i\[1\]
+ id_stage_i.controller_i.instr_is_compressed_i _04228_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17429_ cs_registers_i.pc_id_i\[1\] id_stage_i.controller_i.instr_fetch_err_plus2_i
+ _04229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17430_ id_stage_i.controller_i.lsu_addr_last_i\[1\] net1706
+ _04008_ _04228_ _04229_ net1840 _04230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17431_ _03653_ net1588 net1579 _04230_ _04231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17432_ cs_registers_i.mtval_q\[1\] _04231_ _04155_ _01766_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17433_ cs_registers_i.pc_id_i\[19\] _04223_ _04232_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17434_ _04190_ _04232_ _04233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17435_ cs_registers_i.pc_id_i\[20\] _04233_ _04234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17436_ id_stage_i.controller_i.lsu_addr_last_i\[20\] net1706
+ _04234_ net1840 _04208_ net1932 _04235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17437_ _03547_ net1588 net1579 _04235_ _04236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17438_ cs_registers_i.mtval_q\[20\] _04236_ net1514 _01767_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17439_ cs_registers_i.pc_id_i\[20\] _04197_ _04232_ _04237_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17440_ cs_registers_i.pc_id_i\[21\] _04237_ _04238_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17441_ id_stage_i.controller_i.lsu_addr_last_i\[21\] net1706
+ _04238_ net1840 _04208_ net1908 _04239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17442_ _10647_ net1588 net1579 _04239_ _04240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17443_ cs_registers_i.mtval_q\[21\] _04240_ _04155_ _01768_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17444_ cs_registers_i.pc_id_i\[20\] cs_registers_i.pc_id_i\[21\]
+ _04241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17445_ _04233_ _04241_ _04242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17446_ cs_registers_i.pc_id_i\[22\] _04242_ _04243_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17447_ id_stage_i.controller_i.lsu_addr_last_i\[22\] net1706
+ _04243_ net1840 _04208_ net1903 _04244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17448_ _10663_ net1588 net1579 _04244_ _04245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17449_ cs_registers_i.mtval_q\[22\] _04245_ net1514 _01769_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1408 net174 net1407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_17451_ cs_registers_i.pc_id_i\[23\] _04247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17452_ cs_registers_i.pc_id_i\[22\] _04197_ _04232_ _04241_
+ _04248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17453_ _04247_ _04248_ _04249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17454_ id_stage_i.controller_i.lsu_addr_last_i\[23\] net1706
+ _04249_ net1840 _04208_ net1900 _04250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17455_ _10678_ net1588 net1579 _04250_ _04251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17456_ cs_registers_i.mtval_q\[23\] _04251_ net1514 _01770_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2126 net2124 net2125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17458_ cs_registers_i.pc_id_i\[24\] _04253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17459_ cs_registers_i.pc_id_i\[22\] _04233_ _04241_ _04254_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17460_ cs_registers_i.pc_id_i\[23\] _04254_ _04255_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17461_ _04253_ _04255_ _04256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17462_ id_stage_i.controller_i.lsu_addr_last_i\[24\] net1706
+ _04256_ net1840 _04208_ net1899 _04257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17463_ _10698_ net1588 net1579 _04257_ _04258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xrebuffer2127 _07603_ net2126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17465_ cs_registers_i.mtval_q\[24\] _04258_ net1514 _01771_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1406 _04922_ net1405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17467_ cs_registers_i.pc_id_i\[25\] _04261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17468_ cs_registers_i.pc_id_i\[23\] cs_registers_i.pc_id_i\[24\]
+ _04248_ _04262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17469_ _04261_ _04262_ _04263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17470_ id_stage_i.controller_i.lsu_addr_last_i\[25\] net1706
+ _04263_ net1840 _04208_ net1898 _04264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17471_ _10716_ net1588 net1579 _04264_ _04265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17472_ cs_registers_i.mtval_q\[25\] _04265_ net1514 _01772_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17473_ cs_registers_i.pc_id_i\[26\] _04266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17474_ cs_registers_i.pc_id_i\[23\] cs_registers_i.pc_id_i\[24\]
+ cs_registers_i.pc_id_i\[25\] _04254_ _04267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17475_ _04266_ _04267_ _04268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17476_ id_stage_i.controller_i.lsu_addr_last_i\[26\] net1706
+ _04268_ net1840 _04208_ net1897 _04269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17477_ _10721_ _10734_ _04015_ _04270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_17478_ net1579 _04269_ _04270_ _04271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17479_ cs_registers_i.mtval_q\[26\] _04271_ net1514 _01773_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17480_ cs_registers_i.pc_id_i\[23\] cs_registers_i.pc_id_i\[24\]
+ cs_registers_i.pc_id_i\[25\] cs_registers_i.pc_id_i\[26\]
+ _04272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17481_ _04248_ _04272_ _04273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17482_ cs_registers_i.pc_id_i\[27\] _04273_ _04274_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17483_ id_stage_i.controller_i.lsu_addr_last_i\[27\] net1706
+ _04274_ net1840 _04208_ net1896 _04275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17484_ net1579 _04275_ _04276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17485_ net1517 _04015_ _04276_ _04277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17486_ cs_registers_i.mtval_q\[27\] net1514 _04278_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17487_ net1514 _04277_ _04278_ _01774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17488_ cs_registers_i.pc_id_i\[27\] _04272_ _04279_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17489_ _04254_ _04279_ _04280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17490_ cs_registers_i.pc_id_i\[28\] _04280_ _04281_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17491_ id_stage_i.controller_i.lsu_addr_last_i\[28\] net1706
+ _04281_ net1840 _04208_ net1895 _04282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17492_ net1579 _04282_ _04283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17493_ net1516 _04015_ _04283_ _04284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17494_ cs_registers_i.mtval_q\[28\] net1514 _04285_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17495_ net1514 _04284_ _04285_ _01775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17496_ cs_registers_i.pc_id_i\[28\] _04279_ _04286_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17497_ _04248_ _04286_ _04287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17498_ cs_registers_i.pc_id_i\[29\] _04287_ _04288_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17499_ id_stage_i.controller_i.lsu_addr_last_i\[29\] net1706
+ _04288_ net1840 _04208_ net1894 _04289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17500_ _10788_ net1588 net1579 _04289_ _04290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17501_ cs_registers_i.mtval_q\[29\] _04290_ net1514 _01776_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17502_ net2145 id_stage_i.controller_i.instr_compressed_i\[2\]
+ id_stage_i.controller_i.instr_is_compressed_i _04291_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17503_ cs_registers_i.pc_id_i\[2\] _00961_ id_stage_i.controller_i.instr_fetch_err_plus2_i
+ _04292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17504_ id_stage_i.controller_i.lsu_addr_last_i\[2\] net1706
+ _04008_ _04291_ _04292_ net1840 _04293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17505_ _10792_ net1588 net1579 _04293_ _04294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17506_ cs_registers_i.mtval_q\[2\] _04294_ _04155_ _01777_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17507_ cs_registers_i.pc_id_i\[29\] _04286_ _04295_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17508_ _04254_ _04295_ _04296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17509_ cs_registers_i.pc_id_i\[30\] _04296_ _04297_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17510_ id_stage_i.controller_i.lsu_addr_last_i\[30\] net1706
+ _04297_ net1840 _04208_ net1892 _04298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17511_ _04108_ net1588 net1579 _04298_ _04299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17512_ cs_registers_i.mtval_q\[30\] _04299_ net1514 _01778_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17513_ _09470_ _10843_ _04300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17514_ cs_registers_i.pc_id_i\[30\] _04248_ _04295_ _04301_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17515_ cs_registers_i.pc_id_i\[31\] _04301_ _04302_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17516_ id_stage_i.controller_i.lsu_addr_last_i\[31\] net1706
+ _04302_ net1840 _04208_ net1891 _04303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17517_ _10845_ _04300_ net1588 net1579 _04303_ _04304_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_17518_ cs_registers_i.mtval_q\[31\] _04304_ _04155_ _01779_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17519_ net2131 id_stage_i.controller_i.instr_compressed_i\[3\]
+ id_stage_i.controller_i.instr_is_compressed_i _04305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17520_ id_stage_i.controller_i.instr_fetch_err_plus2_i _00960_
+ _04306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17521_ cs_registers_i.pc_id_i\[3\] _04306_ _04307_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17522_ id_stage_i.controller_i.lsu_addr_last_i\[3\] net1706
+ _04008_ _04305_ _04307_ net1840 _04308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17523_ _04027_ net1588 net1579 _04308_ _04309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17524_ cs_registers_i.mtval_q\[3\] _04309_ _04155_ _01780_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17525_ net2189 id_stage_i.controller_i.instr_compressed_i\[4\]
+ id_stage_i.controller_i.instr_is_compressed_i _04310_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17526_ cs_registers_i.pc_id_i\[1\] cs_registers_i.pc_id_i\[2\]
+ cs_registers_i.pc_id_i\[3\] id_stage_i.controller_i.instr_fetch_err_plus2_i
+ _04311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17527_ cs_registers_i.pc_id_i\[4\] _04311_ _04312_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17528_ id_stage_i.controller_i.lsu_addr_last_i\[4\] net1706
+ _04008_ _04310_ _04312_ net1840 _04313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17529_ _11093_ net1588 net1579 _04313_ _04314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17530_ cs_registers_i.mtval_q\[4\] _04314_ _04155_ _01781_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17531_ id_stage_i.controller_i.instr_i\[5\] id_stage_i.controller_i.instr_compressed_i\[5\]
+ id_stage_i.controller_i.instr_is_compressed_i _04315_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17532_ cs_registers_i.pc_id_i\[5\] _04169_ _04316_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17533_ id_stage_i.controller_i.lsu_addr_last_i\[5\] net1706
+ _04008_ _04315_ _04316_ net1840 _04317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17534_ _03347_ net1588 net1579 _04317_ _04318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17535_ cs_registers_i.mtval_q\[5\] _04318_ _04155_ _01782_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17536_ net2146 id_stage_i.controller_i.instr_compressed_i\[6\]
+ id_stage_i.controller_i.instr_is_compressed_i _04319_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17537_ cs_registers_i.pc_id_i\[6\] _04160_ _04320_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17538_ id_stage_i.controller_i.lsu_addr_last_i\[6\] net1706
+ _04008_ _04319_ _04320_ net1840 _04321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17539_ _03377_ net1588 net1579 _04321_ _04322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17540_ cs_registers_i.mtval_q\[6\] _04322_ _04155_ _01783_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17541_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] id_stage_i.controller_i.instr_compressed_i\[7\]
+ id_stage_i.controller_i.instr_is_compressed_i _04323_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17542_ cs_registers_i.pc_id_i\[6\] _04170_ _04324_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17543_ cs_registers_i.pc_id_i\[7\] _04324_ _04325_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17544_ id_stage_i.controller_i.lsu_addr_last_i\[7\] net1706
+ _04008_ _04323_ _04325_ net1840 _04326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17545_ _03384_ net1588 net1579 _04326_ _04327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17546_ cs_registers_i.mtval_q\[7\] _04327_ _04155_ _01784_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17547_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] id_stage_i.controller_i.instr_compressed_i\[8\]
+ id_stage_i.controller_i.instr_is_compressed_i _04328_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17548_ cs_registers_i.pc_id_i\[8\] _04329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17549_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_id_i\[7\]
+ _04160_ _04330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17550_ _04329_ _04330_ _04331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17551_ id_stage_i.controller_i.lsu_addr_last_i\[8\] net1706
+ _04008_ _04328_ _04331_ net1840 _04332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17552_ _03386_ net1588 net1579 _04332_ _04333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17553_ cs_registers_i.mtval_q\[8\] _04333_ _04155_ _01785_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17554_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] id_stage_i.controller_i.instr_compressed_i\[9\]
+ id_stage_i.controller_i.instr_is_compressed_i _04334_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17555_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_id_i\[7\]
+ cs_registers_i.pc_id_i\[8\] _04170_ _04335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17556_ cs_registers_i.pc_id_i\[9\] _04335_ _04336_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17557_ id_stage_i.controller_i.lsu_addr_last_i\[9\] net1706
+ _04008_ _04334_ _04336_ net1840 _04337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_17558_ _04126_ net1588 net1579 _04337_ _04338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17559_ cs_registers_i.mtval_q\[9\] _04338_ _04155_ _01786_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17560_ _07773_ _10194_ _09599_ _04130_ _04339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_17561_ net1535 _04339_ _04340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1407 net177 net1406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17563_ _09498_ _09921_ _04342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17564_ _10372_ net1557 _04343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17565_ net1807 _04343_ _04344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2128 _07603_ net2127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17567_ cs_registers_i.csr_mtvec_o\[10\] _04346_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xplace1405 _05206_ net1404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17569_ net6 net1807 _04348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17570_ _10299_ _04340_ _04344_ _04346_ _04348_ _01787_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xplace1404 _05207_ net1403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1403 net2491 net1402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclone2129 net2058 net2128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_17574_ net7 net1807 _04343_ _10348_ _04352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17575_ _10319_ _04344_ _04352_ _01788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17576_ net8 net1807 _04343_ _11052_ _04353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17577_ _10382_ _04344_ _04353_ _01789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17578_ cs_registers_i.csr_mtvec_o\[13\] _04354_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17579_ net9 net1807 _04343_ _11059_ _04355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17580_ _04354_ _04344_ _04355_ _01790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17581_ cs_registers_i.csr_mtvec_o\[14\] _04356_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17582_ net10 net1807 _04357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17583_ _10472_ _04340_ _04344_ _04356_ _04357_ _01791_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17584_ cs_registers_i.csr_mtvec_o\[15\] _04358_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17585_ net11 net1807 _04343_ net1531 _04359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17586_ _04358_ _04344_ _04359_ _01792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17587_ cs_registers_i.csr_mtvec_o\[16\] _04360_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17588_ net12 net1807 _04361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17589_ _10525_ _04340_ _04344_ _04360_ _04361_ _01793_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17590_ cs_registers_i.csr_mtvec_o\[17\] _04362_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17591_ net13 net1807 _04343_ _11089_ _04363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17592_ _04362_ _04344_ _04363_ _01794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17593_ cs_registers_i.csr_mtvec_o\[18\] _04364_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17594_ net14 net1807 _04365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17595_ _10567_ _04340_ _04344_ _04364_ _04365_ _01795_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17596_ cs_registers_i.csr_mtvec_o\[19\] _04366_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17597_ net15 net1807 _04367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17598_ _03537_ _04340_ _04344_ _04366_ _04367_ _01796_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17599_ cs_registers_i.csr_mtvec_o\[20\] _04368_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17600_ net16 net1807 _04369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17601_ _03547_ _04340_ _04344_ _04368_ _04369_ _01797_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17602_ cs_registers_i.csr_mtvec_o\[21\] _04370_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17603_ net17 net1807 _04371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17604_ _10647_ _04340_ _04344_ _04370_ _04371_ _01798_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17605_ cs_registers_i.csr_mtvec_o\[22\] _04372_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17606_ net18 net1807 _04373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17607_ _10663_ _04340_ _04344_ _04372_ _04373_ _01799_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17608_ cs_registers_i.csr_mtvec_o\[23\] _04374_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17609_ net19 net1807 _04375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17610_ _10678_ _04340_ _04344_ _04374_ _04375_ _01800_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17611_ cs_registers_i.csr_mtvec_o\[24\] _04376_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17612_ net20 net1807 _04377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17613_ _10698_ _04340_ _04344_ _04376_ _04377_ _01801_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17614_ cs_registers_i.csr_mtvec_o\[25\] _04378_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17615_ net21 net1807 _04379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17616_ _10716_ _04340_ _04344_ _04378_ _04379_ _01802_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17617_ cs_registers_i.csr_mtvec_o\[26\] _04380_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17618_ net22 net1807 _04343_ _10735_ _04381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17619_ _04380_ _04344_ _04381_ _01803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17620_ cs_registers_i.csr_mtvec_o\[27\] _04382_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17621_ net23 net1807 _04343_ net1517 _04383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17622_ _04382_ _04344_ _04383_ _01804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17623_ cs_registers_i.csr_mtvec_o\[28\] _04384_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17624_ net24 net1807 _04343_ net1516 _04385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17625_ _04384_ _04344_ _04385_ _01805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17626_ cs_registers_i.csr_mtvec_o\[29\] _04386_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17627_ net25 net1807 _04387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17628_ _10788_ _04340_ _04344_ _04386_ _04387_ _01806_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17629_ cs_registers_i.csr_mtvec_o\[30\] _04388_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17630_ net26 net1807 _04389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17631_ _04108_ _04340_ _04344_ _04388_ _04389_ _01807_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17632_ cs_registers_i.csr_mtvec_o\[31\] _04390_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17633_ net27 net1807 _04343_ _10846_ _04391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17634_ _04390_ _04344_ _04391_ _01808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17635_ cs_registers_i.csr_mtvec_o\[8\] _04392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17636_ net28 net1807 _04343_ _11009_ _04393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_17637_ _04392_ _04344_ _04393_ _01809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17638_ cs_registers_i.csr_mtvec_o\[9\] _04394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17639_ net29 net1807 _04395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17640_ _04126_ _04340_ _04344_ _04394_ _04395_ _01810_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xrebuffer2130 _09191_ net2129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17642_ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ net1673 _09700_ _04397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17643_ ex_block_i.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ _09740_ _04397_ _01811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17644_ net2028 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\] _04398_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_17645_ _09700_ _04398_ _04399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17646_ _09700_ _04399_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _01812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17647_ _00965_ _04398_ _04400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17648_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _04400_ _09700_ _01813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17649_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _00966_ _04401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17650_ _04398_ _04401_ _04402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17651_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _04402_ _09700_ _01814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17652_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\] ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _04403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17653_ _09695_ _04403_ _04404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_17654_ _04398_ _04404_ _04405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17655_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _04405_ _09700_ _01815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17656_ _00966_ _04406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17657_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\] _04406_
+ _04407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17658_ _04398_ _04407_ _10138_ _04408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17659_ _04399_ _04407_ _04409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_17660_ _04408_ _04409_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ _01816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17661_ alu_adder_result_ex\[0\] net1784 net1674 _04410_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17662_ net2028 _09700_ _04411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2131 net1890 net2130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17664_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]
+ _04410_ net1543 _01817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17665_ net1735 _04413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2132 net2130 net2131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17667_ _04413_ net1451 net1596 _04415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17668_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]
+ _04415_ net1543 _01818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17669_ net1738 _04416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17670_ _04416_ net1457 net1596 _04417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17671_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]
+ _04417_ net1543 _01819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17672_ _09830_ net2298 net1596 _04418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17673_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]
+ _04418_ net1543 _01820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17674_ net1813 _08605_ _04419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17675_ _04419_ net1450 net1596 _04420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17676_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]
+ _04420_ net1543 _01821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17677_ net2292 net1596 _04421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17678_ net1733 net1596 _04421_ _04422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17679_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]
+ _04422_ net1543 _01822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17680_ net1748 net1448 net1596 _04423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17681_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]
+ _04423_ net1543 _01823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17682_ net1770 _04424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17683_ _04424_ net1446 net1596 _04425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17684_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]
+ _04425_ net1543 _01824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17685_ net2288 _04426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17686_ net1732 _04426_ net1596 _04427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17687_ _04427_ _04428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17688_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]
+ _04428_ net1543 _01825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17689_ net1731 net2171 net1596 _04429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17690_ _04429_ _04430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17691_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]
+ _04430_ net1543 _01826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17692_ net1730 _04431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2133 net2130 net2132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17694_ _04431_ net1436 net1596 _04433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2134 net1890 net2133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17696_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]
+ _04433_ net1543 _01827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17697_ net1786 _04435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17698_ net1539 _04435_ net1674 _04436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17699_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]
+ _04436_ net1543 _01828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17700_ net1658 net2278 net1596 _04437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17701_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]
+ _04437_ net1543 _01829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17702_ net1727 _04438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17703_ _04438_ net1410 net1596 _04439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17704_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]
+ _04439_ net1543 _01830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17705_ net1726 _04440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17706_ _04440_ net1432 net1596 _04441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17707_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]
+ _04441_ net1543 _01831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17708_ net169 _04442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17709_ net1725 _04442_ net1596 _04443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17710_ _04443_ _04444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17711_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]
+ _04444_ net1543 _01832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17712_ net2065 _04445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17713_ net1723 _04445_ net1596 _04446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17714_ _04446_ _04447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17715_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]
+ _04447_ net1543 _01833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17716_ net1431 net1596 _04448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17717_ net1722 net1596 _04448_ _04449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17718_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]
+ _04449_ net1543 _01834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17719_ net1721 net2293 net1596 _04450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17720_ _04450_ _04451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17721_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]
+ _04451_ net1543 _01835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17722_ net1720 _04452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17723_ _04452_ net1429 net1596 _04453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17724_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]
+ _04453_ net1543 _01836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17725_ net1712 net2138 net1596 _04454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2135 net2093 net2134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_17727_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]
+ _04454_ net1543 _01837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17728_ net1754 _04456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17729_ _04456_ net1408 net1596 _04457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17730_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]
+ _04457_ net1543 _01838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17731_ net1781 _04458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17732_ _04458_ net1521 net1596 _04459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17733_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]
+ _04459_ net1543 _01839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17734_ net1752 _04460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17735_ _04460_ net2122 net1596 _04461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17736_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]
+ _04461_ net1543 _01840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17737_ net2051 _04462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17738_ _04462_ _09673_ _09467_ _04463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17739_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ _04463_ net1543 _01841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17740_ net1780 _04464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17741_ net1519 _04464_ net1674 _04465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17742_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]
+ _04465_ net1543 _01842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17743_ net1715 net1454 net1596 _04466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17744_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]
+ _04466_ net1543 _01843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17745_ _08324_ _08337_ net1867 _04467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17746_ _04467_ _08334_ net1844 _04468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17747_ net1499 _04468_ net1674 _04469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17748_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]
+ _04469_ net1543 _01844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17749_ _08348_ _08359_ net1867 _04470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17750_ _04470_ _08356_ net1844 _04471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17751_ _04471_ net1500 net1596 _04472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17752_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]
+ _04472_ net1543 _01845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17753_ _08366_ _08376_ net1866 _04473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17754_ _04473_ _08373_ net1844 _04474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17755_ net1512 _04474_ net1674 _04475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17756_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]
+ _04475_ net1543 _01846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17757_ net1458 _04476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17758_ net1775 _04476_ net1596 _04477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17759_ _04477_ _04478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17760_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]
+ _04478_ net1543 _01847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17761_ net2174 _04479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17762_ net1459 _04479_ net1674 _04480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17763_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]
+ _04480_ net1543 _01848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17764_ _08194_ _04411_ _04481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2136 _01277_ net2135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17766_ net2106 net2084 ex_block_i.alu_i.imd_val_q_i\[31\]
+ _04483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17767_ ex_block_i.alu_i.imd_val_q_i\[63\] _04484_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17768_ ex_block_i.alu_i.imd_val_q_i\[31\] net2106 net2084
+ _04484_ _04485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17769_ _09695_ _09696_ _04483_ _04485_ _04486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xrebuffer2137 net1687 net2136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17771_ net2027 _09700_ _04488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17772_ _00964_ _04488_ _04489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17773_ _04486_ _04489_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]
+ _04490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17774_ _04481_ _04490_ _01849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17775_ _04483_ _04485_ _04491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xclone2138 net2055 net2137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17777_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _09696_ _04491_ _04493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17778_ _00967_ _04488_ _04494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17779_ _04493_ _04494_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]
+ _04495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17780_ _04481_ _04495_ _01850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17781_ _00969_ _04488_ _04496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17782_ _04493_ _04496_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]
+ _04497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17783_ _04481_ _04497_ _01851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17784_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ _04498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17785_ _04498_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _04499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17786_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _04483_ _04485_ _04499_ _04500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17787_ _04489_ _04500_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]
+ _04501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17788_ _04481_ _04501_ _01852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17789_ _00968_ _04488_ _04502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17790_ _04500_ _04502_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]
+ _04503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17791_ _04481_ _04503_ _01853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17792_ _04494_ _04500_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]
+ _04504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17793_ _04481_ _04504_ _01854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17794_ _04496_ _04500_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]
+ _04505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17795_ _04481_ _04505_ _01855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17796_ _04498_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ _04506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17797_ _09695_ _04483_ _04485_ _04506_ _04507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17798_ _04489_ _04507_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]
+ _04508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17799_ _04481_ _04508_ _01856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17800_ _04502_ _04507_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]
+ _04509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17801_ _04481_ _04509_ _01857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17802_ _04494_ _04507_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]
+ _04510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17803_ _04481_ _04510_ _01858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xrebuffer2139 net1407 net2138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17805_ _04496_ _04507_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]
+ _04512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17806_ _04481_ _04512_ _01859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17807_ _04481_ _04513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17808_ _09695_ _00968_ _09696_ _04491_ _04514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17809_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]
+ _04513_ _04514_ _04488_ _04515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17810_ _04515_ _01860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17811_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\] _04516_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17812_ _09695_ _04483_ _04485_ _04516_ _04517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17813_ _04489_ _04517_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]
+ _04518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17814_ _04481_ _04518_ _01861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17815_ _04502_ _04517_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]
+ _04519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17816_ _04481_ _04519_ _01862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17817_ _04494_ _04517_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]
+ _04520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17818_ _04481_ _04520_ _01863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17819_ _04496_ _04517_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]
+ _04521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17820_ _04481_ _04521_ _01864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17821_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _04483_ _04485_ _04506_ _04522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17822_ _04489_ _04522_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]
+ _04523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17823_ _04481_ _04523_ _01865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17824_ _04502_ _04522_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]
+ _04524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17825_ _04481_ _04524_ _01866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17826_ _04494_ _04522_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]
+ _04525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17827_ _04481_ _04525_ _01867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17828_ _04496_ _04522_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]
+ _04526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17829_ _04481_ _04526_ _01868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17830_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _04483_ _04485_ _04516_ _04527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17831_ _04489_ _04527_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]
+ _04528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17832_ _04481_ _04528_ _01869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1402 _04770_ net1401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17834_ _04502_ _04527_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]
+ _04530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17835_ _04481_ _04530_ _01870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17836_ _04486_ _04494_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]
+ _04531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17837_ _04481_ _04531_ _01871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17838_ _04494_ _04527_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]
+ _04532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17839_ _04481_ _04532_ _01872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17840_ _04496_ _04527_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]
+ _04533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17841_ _04481_ _04533_ _01873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17842_ _04486_ _04496_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]
+ _04534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17843_ _04481_ _04534_ _01874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17844_ _09695_ _04483_ _04485_ _04499_ _04535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17845_ _04489_ _04535_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]
+ _04536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17846_ _04481_ _04536_ _01875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17847_ _04502_ _04535_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]
+ _04537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17848_ _04481_ _04537_ _01876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17849_ _04494_ _04535_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]
+ _04538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17850_ _04481_ _04538_ _01877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17851_ _04496_ _04535_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]
+ _04539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17852_ _04481_ _04539_ _01878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17853_ _04489_ _04493_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]
+ _04540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17854_ _04481_ _04540_ _01879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xplace1401 _05237_ net1400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1400 _05430_ net1399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17857_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ _00968_ _09696_ _04491_ _04543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_17858_ _09700_ _04543_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ _04544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17859_ net2028 _09700_ _04545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17860_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ _04545_ net2027 _04546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17861_ _04544_ _04546_ _01880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17862_ fetch_enable_q net66 _01881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_17863_ _07567_ _07643_ _07634_ _04547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17864_ _07586_ _04547_ _04548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17865_ _09624_ _10370_ _04548_ _04549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_17866_ _09699_ _03434_ _04550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17867_ _04549_ _04550_ _04551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2140 net1933 net2139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xrebuffer2141 net2139 net2140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer2142 net2139 net2141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17871_ net48 net32 net1887 _04555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17872_ net62 net39 net1887 _04556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17873_ net1886 _04557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2143 net1933 net2142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17875_ _04555_ _04556_ _04557_ _04559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17876_ load_store_unit_i.data_type_q\[2\] load_store_unit_i.data_type_q\[1\]
+ _04560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xrebuffer2144 _07740_ net2143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2145 net1893 net2144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2146 net1893 net2145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2147 net1888 net2146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xsplit2148 net1888 net2147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xrebuffer2149 _08185_ net2148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17883_ net62 load_store_unit_i.rdata_q\[8\] load_store_unit_i.rdata_q\[16\]
+ net32 net1887 net1886 _04567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17884_ net61 net47 net38 net56 net1886 net1887 _04568_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17885_ load_store_unit_i.data_type_q\[1\] load_store_unit_i.data_sign_ext_q
+ _04568_ _04569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_17886_ load_store_unit_i.data_type_q\[2\] _04559_ _04560_
+ _04567_ _04569_ _04570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_17887_ _04549_ _04550_ _04571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2150 _07570_ net2149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2151 _01225_ net2150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17890_ _01137_ _04574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17891_ id_stage_i.controller_i.instr_valid_i _07599_ _04575_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17892_ _04575_ _04576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17893_ _04574_ net1611 _01159_ _04576_ _04577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17894_ _01166_ _04577_ _04578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2152 net1931 net2151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17896_ _07773_ _09568_ _04575_ _04580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17897_ net1702 _04580_ _04581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xsplit2153 net1931 net2152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_17899_ _03415_ _03396_ _04583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17900_ net1691 _01312_ net1616 _04584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2154 gen_regfile_ff.register_file_i.raddr_b_i\[0\]
+ net2153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17902_ net1692 _01319_ net1616 _04586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17903_ _04584_ _04586_ net1612 _04587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17904_ net2072 net1678 net1616 _04588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17905_ net2116 net1677 net1616 _04589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17906_ _04588_ _04589_ net1612 _04590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2155 gen_regfile_ff.register_file_i.raddr_b_i\[0\]
+ net2154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_17908_ _01145_ _01151_ _01347_ net1675 net1703 net1616 _04592_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xrebuffer2160 net1695 net2159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17910_ net2103 _01165_ net1676 _01326_ net1703 net1616 _04594_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17911_ _01138_ _04595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17912_ _04595_ net2289 _04575_ _04596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2159 net1787 net2158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2158 net1774 net2157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17915_ _04574_ _04576_ _04599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17916_ _07773_ _04599_ _04600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2157 gen_regfile_ff.register_file_i.raddr_b_i\[0\]
+ net2156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17918_ _04587_ _04590_ _04592_ _04594_ _04596_ _04600_ _04602_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17919_ _04581_ _04602_ _04603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17920_ _08082_ _08099_ net1616 _04604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17921_ _09470_ net1616 _04605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17922_ _04604_ _04605_ _04606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17923_ _01138_ net1586 _04575_ _04607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2156 gen_regfile_ff.register_file_i.raddr_b_i\[0\]
+ net2155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17925_ _08121_ _08126_ _04609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17926_ _03395_ _04609_ _03396_ _04610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_17927_ net1612 _04600_ _04607_ _04610_ _04611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17928_ _01159_ _04580_ _04612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2162 net2160 net2161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17930_ _04606_ _04611_ _04612_ _04614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_17931_ _09470_ _04610_ _04615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xrebuffer2161 net1728 net2160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_17933_ _04578_ _04615_ _04617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17934_ _04578_ _04603_ _04614_ _04617_ _04618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_17935_ _01165_ net1692 _01326_ _01319_ net1703 net1616 _04619_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17936_ _04584_ _04589_ net1703 _04620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17937_ _01145_ _01139_ _01347_ _00938_ net1612 net1616 _04621_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17938_ _01151_ net2103 net1675 net1676 net1703 net1616 _04622_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17939_ _04619_ _04620_ _04621_ _04622_ net1551 _04600_ _04623_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17940_ net2070 net1682 net1616 _04624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17941_ net1704 net1681 net1616 _04625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17942_ _04624_ _04625_ net1612 _04626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17943_ net1685 _01256_ net1616 _04627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17944_ net1684 net1683 net1616 _04628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17945_ _04627_ _04628_ net1703 _04629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17946_ net2097 net1679 net1616 _04630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17947_ _04588_ _04630_ net1703 _04631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17948_ net2159 net2135 net1616 _04632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17949_ net2102 net1680 net1616 _04633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17950_ _04632_ _04633_ net1612 _04634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17951_ _04626_ _04629_ _04631_ _04634_ net1551 _04600_ _04635_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_17952_ _03415_ _03396_ _04636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2163 net1996 net2162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17954_ net2102 net1680 _04636_ _04638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17955_ net2159 net2135 _04636_ _04639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17956_ _04638_ _04639_ net1612 _04640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17957_ net2072 net1678 _04636_ _04641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17958_ net2097 net1679 _04636_ _04642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17959_ _04641_ _04642_ net1612 _04643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17960_ net1685 _01256_ _04636_ _04644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17961_ net1684 net1683 _04636_ _04645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17962_ _04644_ _04645_ net1612 _04646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17963_ net1704 net1681 _04636_ _04647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17964_ net2070 net1682 _04636_ _04648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17965_ _04647_ _04648_ net1612 _04649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1399 _04491_ net1398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_17967_ _04640_ _04643_ _04646_ _04649_ net1551 _04600_ _04651_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xrebuffer2164 net1996 net2163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17969_ net1701 _04577_ _04653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2165 net1996 net2164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2166 net1996 net2165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17972_ _04615_ _04623_ _04635_ _04651_ _04612_ _04653_ _04656_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xrebuffer2167 net1996 net2166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17974_ _04618_ _04656_ _04583_ _04658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17975_ net1782 _04658_ _04659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17976_ _08128_ _03412_ _08216_ _04660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xrebuffer2168 _08448_ net2167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17978_ _08128_ _03396_ _04662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17979_ _03394_ _04662_ _04663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_17980_ _08127_ _03412_ _04664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_17981_ _04663_ _04664_ _04665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xclone2169 net2090 net2168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_17983_ _03396_ _04667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17984_ _03395_ _08129_ _03394_ _04668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_17985_ _04667_ _08217_ _04668_ _04669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xrebuffer2170 net175 net2169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1398 _04924_ net1397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17988_ _08217_ _03394_ _04672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xrebuffer2171 net1889 net2170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17990_ _01195_ net1614 _04674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17991_ _08217_ _03394_ _04675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_17992_ net1587 _04675_ _04676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2172 _08928_ net2171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_17994_ _01196_ net1578 _04678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_17995_ _01199_ net1587 _04674_ _04678_ _04679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_17996_ net1458 _04660_ _04665_ _04679_ _04680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_17997_ ex_block_i.alu_i.imd_val_q_i\[40\] _04681_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_17998_ _00086_ _01000_ _04682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_17999_ net2030 ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ net1751 _04683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18000_ net1718 _04683_ _04684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1397 _05290_ net1396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18002_ _04681_ _04682_ _04684_ _04686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18003_ _04680_ _04686_ net1815 _04687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18004_ _11007_ net1507 _04659_ _04687_ _04688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18005_ net1508 _04570_ _04688_ _04689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2173 _00889_ net2172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18007_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] gen_regfile_ff.register_file_i.waddr_a_i\[3\]
+ _04691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18008_ net30 load_store_unit_i.lsu_err_q load_store_unit_i.data_we_q
+ _09654_ _04692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18009_ _09538_ _03433_ _04548_ _09585_ _09686_ _04693_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18010_ _09585_ _09637_ _04693_ _04694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_18011_ _04692_ _04694_ _04695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18012_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] gen_regfile_ff.register_file_i.waddr_a_i\[1\]
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _04695_ _04696_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_18013_ _04691_ _04696_ _04697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xrebuffer2174 _00857_ net2173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18015_ gen_regfile_ff.register_file_i.rf_reg\[1000\] net1392
+ _04697_ _01882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18016_ net49 net43 net1887 _04699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18017_ net63 net40 net1887 _04700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18018_ _04699_ _04700_ _04557_ _04701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2175 net1736 net2174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18020_ net63 load_store_unit_i.rdata_q\[9\] load_store_unit_i.rdata_q\[17\]
+ net43 net1887 net1886 _04703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18021_ load_store_unit_i.data_type_q\[2\] _04701_ _04703_
+ _04560_ _04569_ _04704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xclone2176 net2180 net2175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18023_ net1612 _04610_ _04706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18024_ _04604_ _04605_ _04706_ _04707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18025_ _04587_ _04592_ _04594_ _04707_ _04600_ _04607_ _04708_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18026_ _04625_ _04632_ net1612 _04709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18027_ _04630_ _04633_ net1703 _04710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18028_ _04624_ _04627_ net1703 _04711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18029_ net1611 _04599_ _04712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2177 _01236_ net2176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18031_ _04590_ _04709_ _04710_ _04711_ _04712_ net1551 _04714_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18032_ _04639_ _04647_ net1612 _04715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18033_ _04638_ _04642_ net1703 _04716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18034_ net1703 _04636_ _04717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18035_ net1684 net1683 _04717_ _04718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18036_ _04644_ _04648_ net1703 _04719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18037_ _04715_ _04716_ _04718_ _04719_ net1551 _04600_ _04720_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xrebuffer2178 _07622_ net2177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18039_ _04615_ _04708_ _04714_ _04720_ _04612_ _04653_ _04722_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18040_ net1782 _04583_ _04723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18041_ _04722_ _04723_ _04724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xrebuffer2179 _08383_ net2178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2180 net1913 net2179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2181 _08218_ net2180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18045_ _09470_ _04610_ _04728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18046_ _04712_ net1551 _04729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18047_ _04581_ _04729_ _04578_ _04730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18048_ _04619_ _04622_ _04631_ _04620_ _04607_ _04712_ _04731_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18049_ _04653_ _04612_ _04731_ _04732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_18050_ _04621_ _04733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18051_ _04578_ _04612_ _04729_ _04733_ _04734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18052_ _04728_ _04730_ _04732_ _04734_ _04735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18053_ _03415_ _08217_ _08170_ _04736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18054_ _04663_ _04664_ _04737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18055_ _01206_ net1587 _04738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18056_ _01202_ net1614 net1578 _01203_ _04738_ _04739_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18057_ _08455_ _04736_ _04737_ _04739_ _04740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18058_ _01000_ _04741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18059_ net1452 _00995_ _00994_ _04742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18060_ _00999_ _04743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18061_ _04741_ _04742_ _04743_ _04744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18062_ _01005_ _04744_ _04745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_18063_ ex_block_i.alu_i.imd_val_q_i\[41\] _04745_ _04684_
+ _04746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18064_ _04740_ _04746_ net1815 _04747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18065_ net1615 _04735_ _04747_ _11022_ _04748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18066_ net1507 _04724_ _04748_ _04749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18067_ net1508 _04704_ _04749_ _04750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2182 _07654_ net2181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18069_ gen_regfile_ff.register_file_i.rf_reg\[1001\] net1388
+ net1497 _01883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18070_ net33 load_store_unit_i.rdata_q\[10\] load_store_unit_i.rdata_q\[18\]
+ net54 net1887 net1886 _04752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18071_ net50 net54 net1887 _04753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18072_ net33 net41 net1887 _04754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18073_ _04753_ _04754_ _04557_ _04755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18074_ net1833 _04752_ _04755_ load_store_unit_i.data_type_q\[2\]
+ _04569_ _04756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18075_ _04615_ _04621_ _04622_ _04619_ net1551 _04712_ _04757_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18076_ _04620_ _04631_ _04634_ _04626_ net1551 _04712_ _04758_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18077_ _04629_ _04646_ _04649_ _04640_ net1551 _04712_ _04759_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18078_ _04615_ _04757_ _04758_ _04759_ _04612_ _04653_ _04760_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18079_ _04592_ _04707_ _04607_ _04761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18080_ _04615_ _04761_ _04712_ _04762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18081_ _04587_ _04594_ _04710_ _04590_ _04607_ _04712_ _04763_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18082_ _04581_ _04763_ _04764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18083_ _04612_ _04762_ _04764_ _04653_ _04765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18084_ _03396_ _04765_ _04766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18085_ _03396_ _04760_ _04766_ net1782 _04767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xclone2183 net2139 net2182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_18087_ _00086_ _04741_ _04743_ _04769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18088_ _01005_ _04769_ _01004_ _04770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18089_ _01009_ net1401 _04771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xrebuffer2184 _07600_ net2183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18091_ ex_block_i.alu_i.imd_val_q_i\[42\] _04771_ _04684_
+ _04773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2185 net2090 net2184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xrebuffer2186 net1796 net2185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2187 _00905_ net2186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18095_ _01213_ net1587 _04777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18096_ _01209_ net1614 net1578 _01210_ _04777_ _04778_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18097_ _08509_ _04736_ _04737_ _04778_ net1783 _04779_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_18098_ net1783 _04773_ _04779_ _09585_ _04780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18099_ _11031_ net1507 _04767_ _04780_ _04781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18100_ net1508 _04756_ _04781_ _04782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2188 net1772 net2187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18102_ gen_regfile_ff.register_file_i.rf_reg\[1002\] net1381
+ net1498 _01884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18103_ net34 load_store_unit_i.rdata_q\[11\] load_store_unit_i.rdata_q\[19\]
+ net57 net1887 net1886 _04784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18104_ net51 net57 net1887 _04785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18105_ net34 net42 net1887 _04786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18106_ _04785_ _04786_ _04557_ _04787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18107_ net1833 _04784_ _04787_ load_store_unit_i.data_type_q\[2\]
+ _04569_ _04788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18108_ _01008_ _04789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18109_ _01009_ _04790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18110_ _01005_ _04744_ _01004_ _04791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18111_ _04790_ _04791_ _04792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18112_ _04789_ _04792_ _04793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18113_ net1444 _04793_ _04794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18114_ ex_block_i.alu_i.imd_val_q_i\[43\] _04794_ _04684_
+ _04795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18115_ _08187_ _04795_ _04796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18116_ net1457 _04660_ _04797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18117_ _01216_ net1614 _04798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18118_ _01217_ net1578 _04799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18119_ _01220_ net1587 _04798_ _04799_ _04800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18120_ _04665_ _04800_ _04801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18121_ _04596_ _04592_ _04802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18122_ _04607_ _04594_ _04803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18123_ net1782 _04667_ _04804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18124_ _04804_ _04805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18125_ _03406_ _04805_ _04596_ net1703 _04806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18126_ _04606_ _04600_ _04807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18127_ _04600_ _04802_ _04803_ _04806_ _04807_ _04808_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_18128_ _04587_ _04590_ net1551 _04809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18129_ _04709_ _04710_ _04607_ _04810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18130_ _04809_ _04810_ _04712_ _04811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18131_ _04715_ _04719_ _04607_ _04812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18132_ _04711_ _04718_ net1551 _04813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18133_ _04812_ _04813_ _04600_ _04814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18134_ _04615_ _04808_ _04811_ _04814_ _04612_ _04653_ _04815_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18135_ net1783 _04583_ _04816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18136_ _04797_ _04801_ _04815_ _04816_ _04817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18137_ _04653_ _04581_ _04818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18138_ _04621_ _04622_ net1551 _04819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18139_ _04615_ _04819_ _04712_ _04820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2189 net1944 net2188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_18141_ _04619_ _04620_ _04631_ _04634_ net1551 _04712_ _04822_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18142_ _04653_ _04612_ _04823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18143_ _04578_ _04615_ _04824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18144_ _04818_ _04820_ _04822_ _04823_ _04824_ _04825_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18145_ _04665_ _04800_ _04797_ net1782 _04826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18146_ net1615 _04825_ _04826_ net1783 _04827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18147_ _04796_ _04817_ _04827_ _04828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18148_ _10346_ net1508 _04828_ _04829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18149_ net1508 _04788_ _04829_ _04830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2190 id_stage_i.controller_i.instr_i\[4\] net2189
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18151_ gen_regfile_ff.register_file_i.rf_reg\[1003\] net1376
+ _04697_ _01885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18152_ net52 net58 net1887 _04832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18153_ net35 net44 net1887 _04833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18154_ _04832_ _04833_ _04557_ _04834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18155_ net35 load_store_unit_i.rdata_q\[12\] load_store_unit_i.rdata_q\[20\]
+ net58 net1887 net1886 _04835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xrebuffer2191 net1771 net2190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18157_ load_store_unit_i.data_type_q\[2\] _04834_ _04835_
+ net1833 _04569_ _04837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18158_ _04837_ _04838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18159_ _04808_ _04811_ _04612_ _04839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2192 _08669_ net2191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18161_ _04653_ _04839_ _04583_ _04841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2193 net1773 net2192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18163_ _01227_ net1614 _04843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18164_ _01224_ net1578 _04844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18165_ _01223_ net1587 _04843_ _04844_ _04845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18166_ net2298 _04660_ _04665_ _04845_ _04846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18167_ _04626_ _04629_ _04646_ _04649_ net1551 _04712_ _04847_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18168_ _04615_ _04820_ _04822_ _04847_ _04612_ _04653_ _04848_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18169_ net1615 _04848_ net1782 _04849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18170_ net1783 _04846_ _04849_ _04850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18171_ _04790_ net1401 _04789_ _04851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18172_ net1444 _04851_ net1445 _04852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18173_ _01017_ _04852_ _04853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18174_ ex_block_i.alu_i.imd_val_q_i\[44\] net1391 _04684_
+ _04854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18175_ _08187_ _04854_ _04855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18176_ _04841_ _04850_ _04855_ _11050_ _04856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
Xclone2194 net2005 net2193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_18178_ _04838_ _04856_ net1507 _04858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2195 _08817_ net2194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18180_ gen_regfile_ff.register_file_i.rf_reg\[1004\] net1375
+ net1497 _01886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18181_ net1887 _04860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xrebuffer2273 _08252_ net2272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18183_ _04557_ net1887 _04862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2277 _06353_ net2276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18185_ net1886 _04860_ _04864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18186_ load_store_unit_i.rdata_q\[13\] _04862_ _04864_ load_store_unit_i.rdata_q\[21\]
+ _04865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18187_ _04860_ net53 net45 _04862_ _04866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18188_ _04865_ _04866_ load_store_unit_i.data_type_q\[2\]
+ _04867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18189_ net1887 net59 _04868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18190_ _04867_ _04868_ _04869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18191_ _04557_ _04860_ _04870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18192_ net36 _04870_ _04871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18193_ _04860_ _04867_ _04869_ _04557_ _04871_ _04872_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_18194_ load_store_unit_i.data_type_q\[2\] _04873_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18195_ _04873_ load_store_unit_i.data_type_q\[1\] _04874_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18196_ _04872_ _04874_ _04569_ _04875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18197_ _01230_ net1614 _04876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18198_ _01231_ net1578 _04877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18199_ _01234_ net1587 _04876_ _04877_ _04878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18200_ net1450 _04660_ _04665_ _04878_ _04879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18201_ ex_block_i.alu_i.imd_val_q_i\[45\] _04880_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18202_ _01008_ net1445 _01016_ _04881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18203_ _01011_ _01010_ _01017_ _04882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_18204_ _01016_ _04883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18205_ _04792_ net1427 _04882_ net1426 _04884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18206_ net1442 _04884_ _04885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18207_ _04880_ _04885_ _04684_ _04886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2279 net1433 net2278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18209_ _04879_ _04886_ net1815 _04888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18210_ _04709_ _04711_ _04718_ _04719_ net1551 _04712_ _04889_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18211_ _04762_ _04889_ _04653_ _04890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18212_ _04615_ _04763_ _04653_ _04891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18213_ _04890_ _04891_ _04581_ _04892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18214_ _04757_ _04758_ _04612_ _04893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18215_ _04653_ _04893_ _04894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18216_ _03396_ _04894_ _04895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18217_ _03396_ _04892_ _04895_ net1782 _04896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18218_ _10446_ net1507 _04888_ _04896_ _04897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18219_ net1508 _04875_ _04897_ _04898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2289 net1447 net2288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18221_ gen_regfile_ff.register_file_i.rf_reg\[1005\] net1377
+ net1498 _01887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18222_ net55 net60 net1887 _04900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18223_ net37 net46 net1887 _04901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18224_ _04900_ _04901_ _04557_ _04902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18225_ net37 load_store_unit_i.rdata_q\[14\] load_store_unit_i.rdata_q\[22\]
+ net60 net1887 net1886 _04903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18226_ load_store_unit_i.data_type_q\[2\] _04902_ _04903_
+ _04560_ _04569_ _04904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xrebuffer2288 _08819_ net2287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xrebuffer2290 _01135_ net2289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1396 _03437_ net1395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18230_ _01241_ net1587 _04908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18231_ _01237_ net1614 net1578 _01238_ _04908_ _04909_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18232_ net2292 _04660_ _04910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18233_ _04737_ _04909_ _04910_ net1783 _04911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18234_ _04723_ _04912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18235_ _04581_ _04729_ _04733_ _04913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18236_ _04581_ _04729_ _04615_ _04914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18237_ _04578_ _04913_ _04914_ _04915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18238_ _04626_ _04634_ _04646_ _04629_ _04607_ _04712_ _04916_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18239_ _04731_ _04916_ _04612_ _04917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18240_ _04578_ _04917_ _04918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18241_ _04708_ _04714_ _04612_ _04919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18242_ _04653_ _04919_ _04824_ _04920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18243_ _04912_ _04915_ _04918_ _04920_ _04583_ _04921_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_18244_ _04883_ _04882_ _04922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18245_ _01023_ _04922_ _04923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18246_ _04770_ _04790_ net1427 _04924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18247_ _04923_ net1397 net1443 _04925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18248_ net1441 _04925_ _04926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18249_ ex_block_i.alu_i.imd_val_q_i\[46\] _04926_ _04684_
+ _04927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18250_ _08187_ _04927_ _04928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18251_ _04911_ _04921_ _04928_ _04929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18252_ _11062_ net1507 _04929_ _04930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18253_ net1508 _04904_ _04930_ _04931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2291 _00833_ net2290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18255_ gen_regfile_ff.register_file_i.rf_reg\[1006\] net1371
+ net1497 _01888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1394 _03449_ net1393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1393 _04689_ net1392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18258_ net38 load_store_unit_i.rdata_q\[15\] load_store_unit_i.rdata_q\[23\]
+ net61 net1887 net1886 _04935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18259_ net56 net61 net1887 _04936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18260_ net38 net47 net1887 _04937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18261_ _04936_ _04937_ _04557_ _04938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18262_ load_store_unit_i.data_type_q\[2\] _04938_ _04939_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18263_ _04560_ _04935_ _04939_ _04569_ _04940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18264_ _04623_ _04635_ _04612_ _04941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18265_ _04615_ _04941_ _04653_ _04942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18266_ _04606_ _04611_ _04943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18267_ _04810_ _04813_ _04712_ _04944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18268_ _04615_ _04602_ _04943_ _04944_ _04653_ _04612_ _04945_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18269_ _04942_ _04945_ _04583_ _04946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18270_ net1782 _04946_ _04947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18271_ _01244_ net1614 _04948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18272_ _01245_ net1578 _04949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18273_ _01248_ net1587 _04948_ _04949_ _04950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18274_ net1448 _04660_ _04665_ _04950_ _04951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18275_ ex_block_i.alu_i.imd_val_q_i\[47\] _04952_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18276_ net1443 _01026_ _04953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18277_ _04791_ _04790_ net1427 _04953_ _04954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18278_ net1442 net1405 _04955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18279_ net1441 _01026_ _04956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18280_ _04955_ _04953_ _04956_ _04957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18281_ net1439 _04954_ _04957_ _04958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18282_ _04954_ _04957_ net1439 _04959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18283_ _04958_ _04959_ _04960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18284_ _04952_ _04960_ _04684_ _04961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18285_ _04951_ _04961_ net1815 _04962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18286_ _10491_ net1507 _04947_ _04962_ _04963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18287_ net1508 _04940_ _04963_ _04964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1392 _04853_ net1391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18289_ gen_regfile_ff.register_file_i.rf_reg\[1007\] net1374
+ net1497 _01889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18290_ _04942_ _04945_ net1615 _04966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1395 net1393 net1394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18292_ _01255_ net1587 _04968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18293_ _01251_ net1614 net1578 _01252_ _04968_ _04969_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18294_ net1455 _08839_ _04736_ _04737_ _04969_ _04970_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_18295_ net1441 net1439 _04923_ _04971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18296_ _01027_ _01033_ _01022_ _04972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18297_ net1439 _01026_ _04972_ _04973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18298_ _04973_ _04974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18299_ net1397 _04971_ _04974_ net1440 _04975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18300_ net1437 _04975_ _04976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xplace1391 _05101_ net1390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18302_ _00972_ _04976_ _04683_ _04978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18303_ ex_block_i.alu_i.imd_val_q_i\[48\] _04978_ net1718
+ _04979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18304_ _04970_ _04979_ net1815 _04980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18305_ net1782 _04966_ _04980_ _10523_ _04981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18306_ net39 net32 load_store_unit_i.rdata_q\[16\] net62
+ net1886 net1887 _04982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18307_ load_store_unit_i.data_sign_ext_q _04939_ _04983_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18308_ _04569_ _04983_ _04984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xrebuffer2292 _08399_ net2291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18310_ _03455_ _04693_ _04986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2293 net1456 net2292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18312_ net1833 _04982_ _04984_ _04986_ _04988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18313_ net1507 net1373 _04988_ _04989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xhold2466 net2469 net2465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
X_18315_ gen_regfile_ff.register_file_i.rf_reg\[1008\] net1370
+ net1498 _01890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18316_ net40 net43 load_store_unit_i.rdata_q\[17\] net63
+ net1886 net1887 _04991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18317_ _04560_ _04991_ _04984_ _04992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18318_ _04915_ _04918_ _04993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18319_ _01258_ net1614 _04994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18320_ _01259_ net1578 _04995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18321_ _01262_ net1587 _04994_ _04995_ _04996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18322_ _09585_ net1783 _04997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18323_ net2288 _04660_ _04665_ _04996_ _04997_ _04998_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18324_ _04920_ _04998_ _04999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18325_ _04993_ _04999_ _04583_ _05000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18326_ net1440 _04958_ _05001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18327_ net1437 _05001_ net1438 _05002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18328_ net1424 _05002_ _05003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18329_ _00974_ _05003_ _04683_ _05004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18330_ ex_block_i.alu_i.imd_val_q_i\[49\] _05004_ net1718
+ _05005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18331_ net1783 _05005_ _05006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18332_ _08043_ _11087_ _04998_ _04609_ _05006_ _05007_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18333_ _05000_ _05007_ net1508 _05008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18334_ net1508 _04992_ net1367 _05009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2301 _08388_ net2300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18336_ gen_regfile_ff.register_file_i.rf_reg\[1009\] net1362
+ net1497 _01891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18337_ _01171_ net1587 _05011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18338_ _01167_ net1614 net1578 _01168_ _05011_ _05012_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18339_ net1454 _04660_ _05013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18340_ _04737_ _05012_ _05013_ _05014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18341_ ex_block_i.alu_i.imd_val_q_i\[36\] _00981_ _04684_
+ _05015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18342_ _05014_ _05015_ net1815 _05016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18343_ _04578_ _04581_ _04728_ _05017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18344_ _04578_ _04581_ _04808_ _05017_ _05018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_18345_ net1691 _01312_ _04636_ _05019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18346_ net2116 net1677 _04636_ _05020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18347_ _05019_ _05020_ net1612 _05021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18348_ _01319_ net1616 _05022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18349_ _01176_ net1616 _05023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18350_ _08297_ _08317_ _04636_ _05024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18351_ _01326_ net1616 net1703 _05025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18352_ net1703 _05022_ _05023_ _05024_ _05025_ _05026_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_18353_ _04640_ _04643_ _05021_ _05026_ net1551 _04712_ _05027_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18354_ _04820_ _04822_ _04847_ _05027_ _04612_ _04653_ _05028_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18355_ net1615 _05028_ _05029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18356_ net1615 _05018_ _05029_ _04609_ _05030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18357_ _10909_ net1508 _05016_ _05030_ _05031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18358_ net1886 _04860_ net44 _05032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18359_ _04557_ net1887 net35 _05033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18360_ _05032_ _05033_ _05034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18361_ load_store_unit_i.rdata_q\[4\] _04862_ _04864_ load_store_unit_i.rdata_q\[12\]
+ _05035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18362_ _05034_ _05035_ net1833 _05036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18363_ net1886 net1887 _05037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18364_ load_store_unit_i.data_type_q\[1\] net52 _04874_
+ load_store_unit_i.rdata_q\[20\] _05038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18365_ _05037_ _05038_ _05039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18366_ net58 _04870_ _05040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18367_ _04694_ _05036_ _05039_ _05040_ _05041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_18368_ _05031_ _05041_ _05042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xrebuffer2294 net1428 net2293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18370_ _04692_ _04694_ _05044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18371_ _07968_ _09519_ gen_regfile_ff.register_file_i.waddr_a_i\[4\]
+ _05044_ _05045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18372_ _09518_ _05045_ _05046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xrebuffer2300 _07808_ net2299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18374_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[100\]
+ net1496 _01892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18375_ _04617_ _04894_ _05048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18376_ _04892_ _05048_ _04667_ _05049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18377_ _01269_ net1587 _05050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18378_ _01265_ net1614 net1578 _01266_ _05050_ _05051_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18379_ net2171 _04736_ _04737_ _05051_ _05052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18380_ _01032_ _01034_ _01039_ _05053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18381_ _04924_ _04971_ _04974_ _05053_ _05054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_18382_ _01035_ net1438 _05055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18383_ net1424 _05055_ net1425 _05056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18384_ _05054_ _05056_ _05057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18385_ net1422 _05057_ _05058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18386_ _00975_ _05058_ _04683_ _05059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18387_ ex_block_i.alu_i.imd_val_q_i\[50\] _05059_ net1718
+ _05060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18388_ _05052_ _05060_ net1815 _05061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18389_ net1782 _05049_ _05061_ _10565_ _05062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18390_ net41 net54 load_store_unit_i.rdata_q\[18\] net33
+ net1886 net1887 _05063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18391_ net1833 _05063_ _04984_ _04986_ _05064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18392_ net1507 net1369 _05064_ _05065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2299 net1449 net2298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xhold2467 net2468 net2466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
X_18395_ gen_regfile_ff.register_file_i.rf_reg\[1010\] net1368
+ net1498 _01893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18396_ _04615_ _04839_ _04653_ _05068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18397_ _04848_ _05068_ _04583_ _05069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18398_ _01276_ net1587 _05070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18399_ _01272_ net1614 net1578 _01273_ _05070_ _05071_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18400_ net1436 _04660_ _05072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18401_ _04737_ _05071_ _05072_ _05073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18402_ net1439 _01035_ _05074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18403_ net1424 _04954_ _04957_ _05074_ _05075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
X_18404_ _01040_ net1438 _05076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18405_ _01035_ _01040_ _01032_ _05077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18406_ _05076_ _05077_ _05078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18407_ net1425 _05075_ _05078_ _05079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18408_ net1422 _05079_ net1423 _05080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18409_ net1420 _05080_ _05081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18410_ _00980_ _05081_ _04683_ _05082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18411_ ex_block_i.alu_i.imd_val_q_i\[51\] _05082_ net1718
+ _05083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18412_ _05073_ _05083_ net1815 _05084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18413_ net1782 _05069_ _05084_ _05085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18414_ _09585_ _04693_ _05086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18415_ net42 net57 load_store_unit_i.rdata_q\[19\] net34
+ net1886 net1887 _05087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18416_ net1833 _05087_ _04984_ _05088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18417_ _09585_ _10585_ _05089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18418_ _05088_ _05089_ net1507 _05090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18419_ _05085_ _05086_ _05090_ _05091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1390 _03490_ net1389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18421_ gen_regfile_ff.register_file_i.rf_reg\[1011\] net1366
+ _04697_ _01894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18422_ _01283_ net1587 _05093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18423_ _01279_ net1614 net1578 _01280_ _05093_ _05094_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18424_ _04737_ _05094_ _05095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18425_ net2278 _04660_ _05095_ _05096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18426_ ex_block_i.alu_i.imd_val_q_i\[52\] _05097_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18427_ _01046_ net1420 net1419 _05098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_18428_ _01052_ _01058_ _01045_ _05099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18429_ net1419 _01051_ _05099_ _05100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18430_ _05054_ _05056_ _05098_ _05100_ _05101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_18431_ _01046_ _05102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18432_ net1423 _05103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18433_ _05102_ _05057_ _05103_ _05104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18434_ net1420 _05104_ net1421 net1419 _05105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18435_ net1390 _05105_ _04683_ _05106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18436_ _00981_ _04683_ _05106_ _05107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18437_ _05097_ _05107_ net1718 _05108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18438_ _05096_ _05108_ net1815 _05109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18439_ _04912_ _04825_ _05109_ _10622_ _05110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18440_ net1615 _04815_ _05110_ _05111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18441_ net44 net58 load_store_unit_i.rdata_q\[20\] net35
+ net1886 net1887 _05112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18442_ net1833 _05112_ _04984_ _04986_ _05113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18443_ net1507 net1361 _05113_ _05114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xhold2468 net2465 net2467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
X_18445_ gen_regfile_ff.register_file_i.rf_reg\[1012\] net1354
+ _04697_ _01895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18446_ _01290_ net1587 _05116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18447_ _01286_ net1614 net1578 _01287_ _05116_ _05117_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18448_ _09015_ net1434 _04736_ _04737_ _05117_ _05118_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_18449_ net1421 _05119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18450_ net1425 net1423 _05120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18451_ net1420 _05121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18452_ _05102_ _05103_ _05121_ _05122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18453_ _05075_ _05078_ _05120_ _05122_ _05123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_18454_ _05119_ _05123_ _05124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18455_ net1419 _05124_ _01057_ _05125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18456_ net1417 _05125_ _05126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18457_ _00985_ _05126_ _04683_ _05127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18458_ ex_block_i.alu_i.imd_val_q_i\[53\] _05127_ net1718
+ _05128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18459_ _05118_ _05128_ net1815 _05129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18460_ _04617_ _04765_ _05130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18461_ _04667_ _04760_ _05131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18462_ _04667_ _05130_ _05131_ _04609_ _05132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18463_ _10645_ net1508 _05129_ _05132_ _05133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_18464_ net45 net59 load_store_unit_i.rdata_q\[21\] net36
+ net1886 net1887 _05134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18465_ net1833 _05134_ _05135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18466_ _04986_ _04984_ _05135_ _05136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18467_ _05133_ _05136_ _05137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xhold2469 core_clock_gate_i.en_latch net2468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
X_18469_ gen_regfile_ff.register_file_i.rf_reg\[1013\] net1360
+ net1497 _01896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18470_ _04722_ _04735_ _04583_ _05139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18471_ _01297_ net1587 _05140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18472_ _01293_ net1614 net1578 _01294_ _05140_ _05141_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18473_ net1432 _04660_ _05142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18474_ _04737_ _05141_ _05142_ _05143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18475_ _01057_ net1390 _05144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18476_ net1417 _05144_ net1418 _05145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18477_ net1415 _05145_ _05146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18478_ _00992_ _05146_ _04683_ _05147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18479_ ex_block_i.alu_i.imd_val_q_i\[54\] _05147_ net1718
+ _05148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18480_ _05143_ _05148_ net1815 _05149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18481_ net1782 _05139_ _10662_ _05149_ _05150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_18482_ net46 net60 load_store_unit_i.rdata_q\[22\] net37
+ net1886 net1887 _05151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18483_ _04560_ _05151_ _04984_ _04986_ _05152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18484_ _05150_ net1507 _05152_ _05153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xhold2470 net2466 net2469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
X_18486_ gen_regfile_ff.register_file_i.rf_reg\[1014\] net2471
+ net1498 _01897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18487_ _04618_ _04656_ net1615 _05155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18488_ _01304_ net1587 _05156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18489_ _01300_ net1614 net1578 _01301_ _05156_ _05157_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18490_ _04442_ _04736_ _04737_ _05157_ _05158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18491_ net1421 _01057_ net1418 _05159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18492_ net1419 _01057_ _05160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18493_ net1417 _05160_ net1418 _05161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18494_ _05123_ _05159_ _05161_ _05162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18495_ net1415 _05162_ net1416 _05163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18496_ net1414 _05163_ _05164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_18497_ _00087_ _05164_ _04683_ _05165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18498_ _05165_ _05166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18499_ ex_block_i.alu_i.imd_val_q_i\[55\] _05166_ net1718
+ _05167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18500_ _05158_ _05167_ net1815 _05168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18501_ net1782 _05155_ _05168_ _10677_ _05169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18502_ net47 net61 load_store_unit_i.rdata_q\[23\] net38
+ net1886 net1887 _05170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18503_ _04560_ _05170_ _04984_ _04986_ _05171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18504_ net1507 net1358 _05171_ _05172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xplace1389 _04750_ net1388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18506_ gen_regfile_ff.register_file_i.rf_reg\[1015\] net1353
+ net1498 _01898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18507_ _01057_ _01063_ _01069_ _05174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18508_ _05101_ _05174_ _05175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18509_ _01064_ _01063_ _01069_ _05176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18510_ _01070_ _01069_ _05177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18511_ _05176_ _05177_ _05178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18512_ net1414 _05175_ _05178_ _05179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18513_ _01075_ _05179_ _05180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18514_ _01082_ _05180_ _05181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
Xclone2471 _05318_ net2470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_18516_ _04682_ _05181_ _04683_ _05183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18517_ _05183_ _05184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18518_ ex_block_i.alu_i.imd_val_q_i\[56\] _05184_ net1718
+ _05185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18519_ _04615_ _04623_ _04823_ _05186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18520_ _04805_ _05186_ _05187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18521_ _01311_ net1587 _05188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18522_ _01307_ net1614 net1578 _01308_ _05188_ _05189_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18523_ _04737_ _05189_ net1783 _05190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18524_ net2065 _04660_ _05191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18525_ _10696_ _05187_ _05190_ _05191_ _05192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18526_ _04641_ _05020_ net1703 _05193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18527_ _04716_ _05193_ net1551 _05194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18528_ _04812_ _05194_ _04712_ _05195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18529_ _04602_ _04943_ _05195_ _04944_ _04581_ _04653_ _05196_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18530_ net1615 _05196_ _05197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18531_ _08187_ _05185_ _05192_ _05197_ _05198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18532_ _04555_ _04556_ net1886 _05199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18533_ net1833 _05199_ _04984_ _04986_ _05200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18534_ net1507 net1357 _05200_ _05201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclone2472 _05153_ net2471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_18536_ gen_regfile_ff.register_file_i.rf_reg\[1016\] net1352
+ net1497 _01899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18537_ _04699_ _04700_ net1886 _05203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18538_ net1833 _05203_ _04984_ _04986_ _05204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18539_ _08043_ _03333_ net1507 _05205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18540_ _01088_ _05206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_18541_ _01076_ _01082_ _05207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18542_ _01075_ _01082_ _01081_ _05208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
X_18543_ net1380 net1403 net1402 _05209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18544_ net1404 _05209_ _05210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18545_ _04745_ _05210_ _04683_ _05211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18546_ _07579_ net1815 _05211_ _05212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_18547_ ex_block_i.alu_i.imd_val_q_i\[57\] net1750 _05213_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18548_ _01318_ net1587 _05214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18549_ _01314_ net1614 net1578 _01315_ _05214_ _05215_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18550_ net1431 _04660_ _05216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18551_ _04737_ _05215_ _05216_ _05217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18552_ _04621_ _04615_ _04729_ _05218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18553_ _04640_ _04649_ _05021_ _04643_ _04607_ _04712_ _05219_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18554_ _04731_ _05218_ _05219_ _04916_ _04581_ _04653_ _05220_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18555_ _04615_ _04708_ _04823_ _05221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18556_ net1783 _05217_ _05220_ net1615 _05221_ _04723_ _05222_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_18557_ _05086_ _05212_ _05213_ _05222_ _05223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18558_ _05204_ _05205_ _05223_ _05224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xplace1388 _06458_ net1387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18560_ gen_regfile_ff.register_file_i.rf_reg\[1017\] net1356
+ net1498 _01900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18561_ net1692 _01319_ _04636_ _05226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18562_ _05019_ _05226_ net1703 _05227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18563_ _04715_ _04716_ _05193_ _05227_ net1551 _04712_ _05228_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18564_ _04763_ _05228_ _04653_ _05229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18565_ _04890_ _05229_ _04612_ _05230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18566_ _04615_ _04757_ _04823_ _05231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18567_ _05230_ _05231_ _04583_ _05232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18568_ _01325_ net1587 _05233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18569_ _01321_ net1614 net1578 _01322_ _05233_ _05234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18570_ net2293 _04736_ _04737_ _05234_ _05235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18571_ _01087_ _05236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18572_ _05206_ _05208_ _05236_ _05237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_18573_ _05206_ _05207_ _05238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
X_18574_ _05175_ _05178_ _05238_ _05239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18575_ net1400 _05239_ _05240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18576_ net1413 _05240_ _05241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18577_ _04771_ _05241_ _04683_ _05242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18578_ ex_block_i.alu_i.imd_val_q_i\[58\] _05242_ net1718
+ _05243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18579_ _05235_ _05243_ net1815 _05244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18580_ net1782 _05232_ _05244_ _10733_ _05245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18581_ _04753_ _04754_ net1886 _05246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18582_ net1833 _05246_ _04984_ _04986_ _05247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18583_ net1355 _04986_ _05247_ _05248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclone2473 _05153_ net2472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18585_ gen_regfile_ff.register_file_i.rf_reg\[1018\] net1351
+ _04697_ _01901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18586_ _04794_ _05250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18587_ net1415 _01094_ _05238_ _05251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_18588_ _05123_ _05159_ _05161_ _05251_ _05252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18589_ _01094_ _05237_ _05253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18590_ _01094_ net1416 _05238_ _05254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18591_ _05253_ _05254_ _05255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18592_ _01093_ _05252_ _05255_ _05256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18593_ _01100_ _05256_ _05257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18594_ _04683_ _05257_ _05258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18595_ _04683_ _05250_ _05258_ net1718 _05259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18596_ ex_block_i.alu_i.imd_val_q_i\[59\] net1718 _05259_
+ net1815 _05260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18597_ _01328_ net1614 _05261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18598_ _01329_ net1578 _05262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18599_ _01332_ net1587 _05261_ _05262_ _05263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18600_ net1429 _04660_ _04665_ _05263_ _05264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18601_ net1815 _05264_ _05265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18602_ _04583_ _05018_ _05266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18603_ _04583_ _05028_ _05266_ net1782 _05267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18604_ _10753_ net1507 _05265_ _05267_ _05268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18605_ _04785_ _04786_ net1886 _05269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18606_ net1833 _05269_ _04984_ _04986_ _05270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18607_ _05260_ _05268_ _05270_ _05271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2477 net1630 net2476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18609_ gen_regfile_ff.register_file_i.rf_reg\[1019\] net1364
+ net1498 _01902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18610_ ex_block_i.alu_i.imd_val_q_i\[37\] _00985_ _04684_
+ _05273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18611_ _01178_ net1587 _05274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18612_ _01174_ net1614 net1578 _01175_ _05274_ _05275_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18613_ net1499 _04660_ _05276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18614_ _04737_ _05275_ _05276_ net1783 _05277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18615_ net1783 _05273_ _05277_ _05278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18616_ _10939_ _05278_ _05279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18617_ _04723_ _05230_ _05231_ net1615 _05279_ _05280_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18618_ net1886 _04860_ net45 _05281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18619_ _04557_ net1887 net36 _05282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18620_ _05281_ _05282_ _05283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18621_ load_store_unit_i.rdata_q\[5\] _04862_ _04864_ load_store_unit_i.rdata_q\[13\]
+ _05284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18622_ _05283_ _05284_ net1833 _05285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18623_ load_store_unit_i.data_type_q\[1\] net53 _04874_
+ load_store_unit_i.rdata_q\[21\] _05286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18624_ _05037_ _05286_ _05287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18625_ net59 _04870_ _05288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18626_ _04694_ _05285_ _05287_ _05288_ _05289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18627_ net1507 _05280_ _05289_ _05290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclone2474 _05153_ net2473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
X_18629_ net1396 gen_regfile_ff.register_file_i.rf_reg\[101\]
+ net1496 _01903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18630_ _01339_ net1587 _05292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18631_ _01335_ net1614 net1578 _01336_ _05292_ _05293_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18632_ net2138 _04660_ _05294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18633_ _04737_ _05293_ _05294_ _05295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18634_ _04615_ _04820_ _04612_ _05296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18635_ _08272_ _08293_ _04636_ _05297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18636_ net1676 net1616 net1703 _05298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18637_ _01326_ net1616 net1612 _05299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18638_ _05297_ _05298_ _05299_ _05024_ _05300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18639_ _05227_ _05300_ net1551 _05301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18640_ _04812_ _04813_ _05301_ _05194_ _04600_ _04612_ _05302_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18641_ _04615_ _04839_ _05296_ _05302_ _03396_ _04653_ _05303_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18642_ net1412 _05304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18643_ _01094_ _01100_ _05238_ _05305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18644_ _05174_ _05101_ _05178_ _05305_ _05306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18645_ _01094_ _01100_ _05237_ _05307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18646_ _01100_ _01093_ _05307_ _05308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18647_ _05304_ _05306_ _05308_ _05309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18648_ _01106_ _05309_ _05310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18649_ _04853_ _05310_ _04683_ _05311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18650_ ex_block_i.alu_i.imd_val_q_i\[60\] _05311_ net1718
+ _05312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18651_ net1815 _05312_ _05313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_18652_ net1783 _05295_ _05303_ net1782 _05313_ _05314_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_18653_ _10770_ _05314_ _09585_ _05315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_18654_ _04832_ _04833_ net1886 _05316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18655_ net1833 _05316_ _04984_ net1507 _05317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18656_ _05315_ net1507 _05317_ _05318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclone2495 _05318_ net2494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xrebuffer2484 net1817 net2483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18659_ gen_regfile_ff.register_file_i.rf_reg\[1020\] net1350
+ _04697_ _01904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18660_ ex_block_i.alu_i.imd_val_q_i\[61\] net1750 _05321_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18661_ _01093_ _01099_ _01105_ _05322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18662_ _01100_ _01099_ _05323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18663_ _01106_ _05323_ _01105_ _05324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18664_ _05324_ _05325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18665_ _05255_ _05252_ _05322_ _05325_ _05326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_18666_ _01112_ _05326_ _05327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_18667_ _04885_ _05327_ _04683_ _05328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18668_ net1750 _05328_ _05329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18669_ _05321_ _05329_ net1815 _05330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18670_ _04615_ _04762_ _04823_ _05331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18671_ _01346_ net1587 _05332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18672_ _01342_ net1614 net1578 _01343_ _05332_ _05333_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18673_ _04737_ _05333_ _05334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18674_ net1408 _04660_ _05331_ _04805_ _05334_ _05335_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18675_ _08265_ _08267_ _04636_ _05336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18676_ net1675 net1616 net1703 _05337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18677_ net1676 net1616 net1612 _05338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18678_ _05336_ _05337_ _05338_ _05297_ _05339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18679_ _04643_ _05021_ _05026_ _05339_ net1551 _04712_ _05340_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18680_ _04757_ _04759_ _04758_ _05340_ _04653_ _04612_ _05341_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18681_ net1615 _05341_ _05342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18682_ _05335_ _05342_ _04997_ _05343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18683_ _10787_ net1508 _05343_ _05344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18684_ net53 net36 net59 net45 net1886 net1887 _05345_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18685_ net1833 _05345_ _04984_ _05346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18686_ _05330_ _05344_ _05346_ _04694_ _05347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xrebuffer2483 _01264_ net2482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18688_ gen_regfile_ff.register_file_i.rf_reg\[1021\] net1363
+ _04697_ _01905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18689_ _04900_ _04901_ net1886 _05349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18690_ _04560_ _05349_ _04984_ _05350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18691_ _08050_ _08077_ _04636_ _05351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18692_ _01347_ net1616 net1703 _05352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18693_ net1675 net1616 net1612 _05353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18694_ _05351_ _05352_ _05353_ _05336_ _05354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18695_ _05193_ _05227_ _05300_ _05354_ net1551 _04712_ _05355_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18696_ _04708_ _04714_ _04720_ _05355_ _04612_ _04653_ _05356_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18697_ _04578_ _04581_ _04729_ _05357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18698_ _04621_ _04615_ _05357_ _05358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18699_ _01353_ net1587 _05359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18700_ _01349_ net1614 net1578 _01350_ _05359_ _05360_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18701_ net2122 _04660_ _05361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18702_ _04737_ _05360_ _05361_ _05362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18703_ net1615 _05356_ _05358_ _04723_ _05362_ _05363_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18704_ net1815 _05363_ _05364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18705_ net1412 _01105_ _01111_ _05365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18706_ _05306_ _05308_ _05365_ _05366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_18707_ _01106_ _01105_ _01111_ _05367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18708_ _01112_ _01111_ _05368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18709_ _05367_ _05368_ _05369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18710_ net1411 _05366_ _05369_ _05370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18711_ _05366_ _05369_ net1411 _05371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18712_ _05370_ _05371_ _05372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18713_ _04926_ _05372_ _04683_ _05373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18714_ ex_block_i.alu_i.imd_val_q_i\[62\] _05373_ net1718
+ _05374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18715_ net1815 _05374_ _05375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18716_ _10810_ net1507 _05364_ _05375_ _05376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18717_ net1508 _05350_ _05376_ _05377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2481 _06392_ net2480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18719_ gen_regfile_ff.register_file_i.rf_reg\[1022\] net1349
+ net1498 _01906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18720_ _04936_ _04937_ net1886 _05379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18721_ _04560_ _05379_ _05380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18722_ _04986_ _04984_ _05380_ _05381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18723_ _10159_ _10839_ _10840_ net1560 _05382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18724_ net1562 _05382_ _05383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18725_ cs_registers_i.dscratch0_q\[31\] net1556 _05384_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18726_ cs_registers_i.dscratch1_q\[31\] _10188_ _10239_
+ cs_registers_i.csr_depc_o\[31\] net91 net1563 _05385_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_18727_ cs_registers_i.csr_mtvec_o\[31\] _10197_ _10245_
+ _05386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18728_ _05383_ _05384_ _05385_ _05386_ _05387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_18729_ _01112_ _01118_ _05388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18730_ _01118_ _01111_ _01117_ _05389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18731_ _05326_ _05388_ _05389_ _05390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18732_ _01124_ _05390_ _05391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_18733_ _04960_ _05391_ _04683_ _05392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18734_ net1750 _05392_ _05393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_18735_ ex_block_i.alu_i.imd_val_q_i\[63\] net1750 net1783
+ _05394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18736_ _04615_ _04943_ _04823_ _05395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18737_ _09470_ _04636_ _05396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18738_ _08082_ _08099_ _04636_ net1703 _05397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_18739_ _01347_ net1616 net1612 _05398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18740_ _05396_ _05397_ _05398_ _05351_ _05399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18741_ _05021_ _05026_ _05339_ _05399_ net1551 _04712_ _05400_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18742_ _04623_ _04635_ _04651_ _05400_ _04612_ _04653_ _05401_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_18743_ _04583_ _05401_ _05402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18744_ net1615 _05395_ _05402_ net1782 _05403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18745_ _00944_ net1587 _05404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18746_ _00940_ net1614 net1578 _00941_ _05404_ _05405_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18747_ _04737_ _05405_ net1783 _05406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18748_ net2051 _04660_ _05406_ _05407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18749_ _05393_ _05394_ _05403_ _05407_ _05408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18750_ _10825_ _05387_ net1508 _05408_ _05409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_18751_ _05381_ _05409_ _05410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
Xrebuffer2480 net1768 net2479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18753_ gen_regfile_ff.register_file_i.rf_reg\[1023\] net1348
+ _04697_ _01907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18754_ _05220_ _05221_ net1615 _05412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18755_ _01185_ net1587 _05413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18756_ _01181_ net1614 net1578 _01182_ _05413_ _05414_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18757_ _04737_ _05414_ _05415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18758_ net1500 _04660_ _05415_ _05416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18759_ _05416_ _05417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18760_ ex_block_i.alu_i.imd_val_q_i\[38\] _00992_ _04684_
+ _05418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18761_ _05417_ _05418_ net1815 _05419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18762_ net1782 _05412_ _05419_ _10954_ _05420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18763_ net1886 _04860_ net46 _05421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18764_ _04557_ net1887 net37 _05422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18765_ _05421_ _05422_ _05423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18766_ load_store_unit_i.rdata_q\[6\] _04862_ _04864_ load_store_unit_i.rdata_q\[14\]
+ _05424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18767_ _05423_ _05424_ _04560_ _05425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18768_ load_store_unit_i.data_type_q\[1\] net55 _04874_
+ load_store_unit_i.rdata_q\[22\] _05426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18769_ _05037_ _05426_ _05427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18770_ net60 _04870_ _05428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18771_ _04694_ _05425_ _05427_ _05428_ _05429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18772_ net1507 _05420_ _05429_ _05430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xrebuffer2479 _06391_ net2478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18774_ net1399 gen_regfile_ff.register_file_i.rf_reg\[102\]
+ net1496 _01908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18775_ _04723_ _05196_ _05432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18776_ _01192_ net1587 _05433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18777_ _01188_ net1614 net1578 _01189_ _05433_ _05434_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18778_ net1512 _04660_ _05435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18779_ _04737_ _05434_ _05435_ _05436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18780_ _00087_ _05437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18781_ ex_block_i.alu_i.imd_val_q_i\[39\] _05437_ _04684_
+ _05438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18782_ _05436_ _05438_ net1815 _05439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18783_ net1615 _05186_ _05439_ _10982_ _05440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18784_ _05432_ _05440_ _05441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18785_ _04860_ _04873_ load_store_unit_i.rdata_q\[15\] _05442_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18786_ net1887 load_store_unit_i.rdata_q\[23\] _05442_ _05443_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18787_ _04860_ net47 _05444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18788_ load_store_unit_i.data_type_q\[2\] load_store_unit_i.rdata_q\[23\]
+ net56 load_store_unit_i.data_type_q\[1\] _05445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18789_ load_store_unit_i.data_type_q\[1\] _05443_ _05444_
+ _04560_ _05445_ _04860_ _05446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_18790_ net38 load_store_unit_i.rdata_q\[7\] _04560_ _05447_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18791_ net61 _05447_ net1887 _05448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18792_ _05446_ _05448_ _04557_ _05449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18793_ _05441_ _05449_ net1508 _05450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2478 _09871_ net2477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_18795_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[103\]
+ net1496 _01909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1387 _06502_ net1386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18797_ net1392 gen_regfile_ff.register_file_i.rf_reg\[104\]
+ net1496 _01910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1386 _06502_ net1385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18799_ net1388 gen_regfile_ff.register_file_i.rf_reg\[105\]
+ net1496 _01911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2494 _00449_ net2493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18801_ net1381 gen_regfile_ff.register_file_i.rf_reg\[106\]
+ net1496 _01912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2485 _00865_ net2484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18803_ net1376 gen_regfile_ff.register_file_i.rf_reg\[107\]
+ net1496 _01913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2493 _00449_ net2492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18805_ net1375 gen_regfile_ff.register_file_i.rf_reg\[108\]
+ net1496 _01914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2492 _05208_ net2491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18807_ net1377 gen_regfile_ff.register_file_i.rf_reg\[109\]
+ net1496 _01915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1385 _06506_ net1384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1384 _06506_ net1383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18810_ net1371 gen_regfile_ff.register_file_i.rf_reg\[110\]
+ net1496 _01916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2496 _09837_ net2495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18812_ net1374 gen_regfile_ff.register_file_i.rf_reg\[111\]
+ net1496 _01917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1383 _06679_ net1382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18814_ net1370 gen_regfile_ff.register_file_i.rf_reg\[112\]
+ net1496 _01918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
XANTENNA_1 net1435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
X_18816_ net1362 gen_regfile_ff.register_file_i.rf_reg\[113\]
+ net1496 _01919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1381 _05163_ net1380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18818_ net1368 gen_regfile_ff.register_file_i.rf_reg\[114\]
+ net1496 _01920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1380 _05497_ net1379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18820_ net1366 gen_regfile_ff.register_file_i.rf_reg\[115\]
+ net1496 _01921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
XANTENNA_2 net1432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
X_18822_ net1354 gen_regfile_ff.register_file_i.rf_reg\[116\]
+ net1496 _01922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1382 _04782_ net1381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18824_ net1360 gen_regfile_ff.register_file_i.rf_reg\[117\]
+ net1496 _01923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1379 _06489_ net1378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18826_ net1359 gen_regfile_ff.register_file_i.rf_reg\[118\]
+ net1496 _01924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
XANTENNA_3 net1431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
X_18828_ net1353 gen_regfile_ff.register_file_i.rf_reg\[119\]
+ net1496 _01925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
XANTENNA_4 data_rvalid_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
Xplace1378 _04898_ net1377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18831_ net1352 gen_regfile_ff.register_file_i.rf_reg\[120\]
+ net1496 _01926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1377 _04830_ net1376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18833_ net1356 gen_regfile_ff.register_file_i.rf_reg\[121\]
+ net1496 _01927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1376 _04858_ net1375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18835_ net1351 gen_regfile_ff.register_file_i.rf_reg\[122\]
+ net1496 _01928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1375 _04964_ net1374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18837_ net1364 gen_regfile_ff.register_file_i.rf_reg\[123\]
+ net1496 _01929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1373 _05107_ net1372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18839_ net2470 gen_regfile_ff.register_file_i.rf_reg\[124\]
+ net1496 _01930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1372 _04931_ net1371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18841_ net1363 gen_regfile_ff.register_file_i.rf_reg\[125\]
+ net1496 _01931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1371 _04989_ net1370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18843_ net1349 gen_regfile_ff.register_file_i.rf_reg\[126\]
+ net1496 _01932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1370 _05062_ net1369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18845_ net1348 gen_regfile_ff.register_file_i.rf_reg\[127\]
+ net1496 _01933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18846_ ex_block_i.alu_i.imd_val_q_i\[32\] _00972_ _04684_
+ _05478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18847_ _08127_ _03412_ _03422_ _05479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18848_ _01144_ net1587 _05480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18849_ _01141_ net1614 net1578 _01142_ _05480_ _05481_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18850_ net1540 _04736_ _04737_ _05481_ _05482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18851_ _04723_ _05401_ _05395_ net1615 _05482_ _05483_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18852_ _03424_ _03427_ _08127_ _05484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18853_ _03402_ _05479_ _05483_ _05484_ _05485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18854_ _09585_ net1783 _05486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18855_ net1815 _05478_ _05485_ _05486_ _10223_ _05487_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18856_ _04860_ net32 _05488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18857_ load_store_unit_i.data_type_q\[1\] net48 _04874_
+ load_store_unit_i.rdata_q\[16\] _05489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18858_ net1886 _04860_ net39 _05490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18859_ _04557_ net1887 net62 _05491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18860_ _05490_ _05491_ _05492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18861_ load_store_unit_i.rdata_q\[0\] _04862_ _04864_ load_store_unit_i.rdata_q\[8\]
+ _05493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18862_ _05492_ _05493_ _04560_ _05494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18863_ net1886 _05488_ _05037_ _05489_ _05494_ _05495_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_18864_ _04694_ _05495_ _05496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18865_ net1508 _05487_ _05496_ _05497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xplace1368 _05008_ net1367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18867_ gen_regfile_ff.register_file_i.waddr_a_i\[3\] _05499_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_18868_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _05499_
+ _05500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18869_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _09520_
+ _05044_ _05500_ _05501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_4
Xplace1367 _05091_ net1366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18871_ gen_regfile_ff.register_file_i.rf_reg\[128\] net1379
+ net1505 _01934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18872_ load_store_unit_i.rdata_q\[1\] _04862_ _04864_ load_store_unit_i.rdata_q\[9\]
+ _05503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18873_ net1886 _04860_ net40 _05504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18874_ net63 _04862_ _05504_ _04560_ _05505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18875_ _04560_ _05503_ _05505_ _05506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18876_ load_store_unit_i.data_type_q\[1\] net49 _04874_
+ load_store_unit_i.rdata_q\[17\] _05507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18877_ _04860_ _05507_ net1886 _05508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_18878_ net43 _05506_ net1887 _05509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18879_ _05506_ _05508_ _05509_ net1886 _05510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_18880_ ex_block_i.alu_i.imd_val_q_i\[33\] _00974_ _04684_
+ _05511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18881_ _08187_ _05511_ _05512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18882_ _04583_ _05356_ _05513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_18883_ net1615 _05358_ _05513_ _05514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18884_ _01147_ net1614 _05515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18885_ _01148_ net1578 _05516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18886_ _01150_ net1587 _05515_ _05516_ _05517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18887_ net1539 _04660_ _04665_ _05517_ _05518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18888_ _04609_ _05514_ _05518_ net1783 _05519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18889_ _05512_ _05519_ _10605_ net1508 _05520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_18890_ net1508 _05510_ _05520_ _05521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xclone2475 _09751_ net2474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
X_18892_ gen_regfile_ff.register_file_i.rf_reg\[129\] net1453
+ net1505 _01935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18893_ load_store_unit_i.rdata_q\[2\] _04862_ _04864_ load_store_unit_i.rdata_q\[10\]
+ _05523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18894_ net1886 _04860_ net41 _05524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18895_ _04557_ net1887 net33 _05525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18896_ net1833 _05524_ _05525_ _05526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_18897_ net1833 _05523_ _05526_ _05527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18898_ _04557_ _04860_ net54 _05528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18899_ load_store_unit_i.data_type_q\[1\] net50 _04874_
+ load_store_unit_i.rdata_q\[18\] _05529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18900_ _05037_ _05529_ _05530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18901_ _04986_ _05527_ _05528_ _05530_ _05531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_18902_ ex_block_i.alu_i.imd_val_q_i\[34\] _00975_ _04684_
+ _05532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18903_ _08187_ _05532_ _05533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18904_ _01153_ net1614 _05534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18905_ _01154_ net1578 _05535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18906_ _01157_ net1587 _05534_ _05535_ _05536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18907_ net1521 _04660_ _04665_ _05536_ _05537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18908_ _04762_ _04823_ _04583_ _05538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_18909_ net1615 _05341_ _05539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18910_ _04609_ _05538_ _05539_ _05540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_18911_ net1783 _05537_ _05540_ _05541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18912_ _05533_ _05541_ _10257_ net1507 _05542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18913_ _05531_ _05542_ _05543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xplace1365 _05271_ net1364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18915_ gen_regfile_ff.register_file_i.rf_reg\[130\] _05543_
+ net1505 _01936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18916_ load_store_unit_i.data_type_q\[1\] net51 _04874_
+ load_store_unit_i.rdata_q\[19\] _05545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18917_ net57 _04870_ _05546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18918_ net1886 _04860_ net42 _05547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18919_ _04557_ net1887 net34 _05548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_18920_ _05547_ _05548_ _05549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_18921_ load_store_unit_i.rdata_q\[3\] _04862_ _04864_ load_store_unit_i.rdata_q\[11\]
+ _05550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_18922_ _05549_ _05550_ net1833 _05551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18923_ _05037_ _05545_ _05546_ _05551_ _05552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18924_ _10889_ _05552_ net1508 _05553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18925_ _04653_ _05296_ _05554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18926_ _01160_ net1614 _05555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18927_ _01161_ net1578 _05556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_18928_ _01164_ net1587 _05555_ _05556_ _05557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18929_ net1519 _04660_ _04665_ _05557_ net1815 _05558_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_18930_ _04578_ _05302_ _05559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18931_ _04653_ _04839_ _05559_ _04805_ _05560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18932_ _04583_ _05554_ _05558_ _05560_ _05561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_18933_ ex_block_i.alu_i.imd_val_q_i\[35\] _00980_ _04684_
+ _05562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18934_ _08187_ _05562_ _05563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_18935_ _09585_ _04986_ _05561_ _05563_ _05564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_18936_ _05553_ _05564_ _05565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1364 _05347_ net1363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18938_ gen_regfile_ff.register_file_i.rf_reg\[131\] _05565_
+ net1506 _01937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1362 _05111_ net1361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18940_ gen_regfile_ff.register_file_i.rf_reg\[132\] _05042_
+ net1505 _01938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1361 _05137_ net1360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18942_ gen_regfile_ff.register_file_i.rf_reg\[133\] net1396
+ net1505 _01939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1360 _05153_ net1359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18944_ gen_regfile_ff.register_file_i.rf_reg\[134\] net1399
+ net1505 _01940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1358 _05198_ net1357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18946_ gen_regfile_ff.register_file_i.rf_reg\[135\] _05450_
+ net1505 _01941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18947_ gen_regfile_ff.register_file_i.rf_reg\[136\] net1392
+ net1506 _01942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18948_ gen_regfile_ff.register_file_i.rf_reg\[137\] net1388
+ net1506 _01943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1356 _05245_ net1355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_18950_ gen_regfile_ff.register_file_i.rf_reg\[138\] net1381
+ net1506 _01944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18951_ gen_regfile_ff.register_file_i.rf_reg\[139\] net1376
+ net1505 _01945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18952_ gen_regfile_ff.register_file_i.rf_reg\[140\] net1375
+ net1506 _01946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18953_ gen_regfile_ff.register_file_i.rf_reg\[141\] net1377
+ net1506 _01947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18954_ gen_regfile_ff.register_file_i.rf_reg\[142\] net1371
+ net1506 _01948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18955_ gen_regfile_ff.register_file_i.rf_reg\[143\] net1374
+ net1506 _01949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18956_ gen_regfile_ff.register_file_i.rf_reg\[144\] net1370
+ net1506 _01950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18957_ gen_regfile_ff.register_file_i.rf_reg\[145\] net1362
+ net1506 _01951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18958_ gen_regfile_ff.register_file_i.rf_reg\[146\] net1368
+ net1506 _01952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18959_ gen_regfile_ff.register_file_i.rf_reg\[147\] net1366
+ net1506 _01953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1355 _05114_ net1354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18961_ gen_regfile_ff.register_file_i.rf_reg\[148\] net1354
+ net1506 _01954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18962_ gen_regfile_ff.register_file_i.rf_reg\[149\] net1360
+ net1506 _01955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18963_ gen_regfile_ff.register_file_i.rf_reg\[150\] net1359
+ net1506 _01956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18964_ gen_regfile_ff.register_file_i.rf_reg\[151\] net1353
+ net1506 _01957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18965_ gen_regfile_ff.register_file_i.rf_reg\[152\] net1352
+ net1506 _01958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18966_ gen_regfile_ff.register_file_i.rf_reg\[153\] net1356
+ net1506 _01959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18967_ gen_regfile_ff.register_file_i.rf_reg\[154\] net1351
+ net1506 _01960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18968_ gen_regfile_ff.register_file_i.rf_reg\[155\] net1364
+ net1506 _01961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18969_ gen_regfile_ff.register_file_i.rf_reg\[156\] net2494
+ net1506 _01962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18970_ gen_regfile_ff.register_file_i.rf_reg\[157\] net1363
+ net1506 _01963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18971_ gen_regfile_ff.register_file_i.rf_reg\[158\] net1349
+ net1506 _01964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18972_ gen_regfile_ff.register_file_i.rf_reg\[159\] net1348
+ net1505 _01965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18973_ _07968_ gen_regfile_ff.register_file_i.waddr_a_i\[1\]
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _05044_ _05573_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_18974_ _05500_ _05573_ _05574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xplace1354 _05172_ net1353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18976_ gen_regfile_ff.register_file_i.rf_reg\[160\] net1379
+ _05574_ _01966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18977_ gen_regfile_ff.register_file_i.rf_reg\[161\] net1453
+ _05574_ _01967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18978_ gen_regfile_ff.register_file_i.rf_reg\[162\] _05543_
+ _05574_ _01968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18979_ gen_regfile_ff.register_file_i.rf_reg\[163\] _05565_
+ net1494 _01969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18980_ gen_regfile_ff.register_file_i.rf_reg\[164\] _05042_
+ _05574_ _01970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18981_ gen_regfile_ff.register_file_i.rf_reg\[165\] net1396
+ _05574_ _01971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18982_ gen_regfile_ff.register_file_i.rf_reg\[166\] net1399
+ _05574_ _01972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18983_ gen_regfile_ff.register_file_i.rf_reg\[167\] _05450_
+ _05574_ _01973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18984_ gen_regfile_ff.register_file_i.rf_reg\[168\] net1392
+ net1495 _01974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18985_ gen_regfile_ff.register_file_i.rf_reg\[169\] net1388
+ net1494 _01975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1353 _05201_ net1352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18987_ gen_regfile_ff.register_file_i.rf_reg\[170\] net1381
+ net1494 _01976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18988_ gen_regfile_ff.register_file_i.rf_reg\[171\] net1376
+ _05574_ _01977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18989_ gen_regfile_ff.register_file_i.rf_reg\[172\] net1375
+ net1494 _01978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18990_ gen_regfile_ff.register_file_i.rf_reg\[173\] net1377
+ net1494 _01979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18991_ gen_regfile_ff.register_file_i.rf_reg\[174\] net1371
+ net1494 _01980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18992_ gen_regfile_ff.register_file_i.rf_reg\[175\] net1374
+ net1494 _01981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18993_ gen_regfile_ff.register_file_i.rf_reg\[176\] net1370
+ net1494 _01982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18994_ gen_regfile_ff.register_file_i.rf_reg\[177\] net1362
+ net1494 _01983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18995_ gen_regfile_ff.register_file_i.rf_reg\[178\] net1368
+ net1495 _01984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18996_ gen_regfile_ff.register_file_i.rf_reg\[179\] net1366
+ net1495 _01985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1352 _05248_ net1351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_18998_ gen_regfile_ff.register_file_i.rf_reg\[180\] net1354
+ net1495 _01986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_18999_ gen_regfile_ff.register_file_i.rf_reg\[181\] net1360
+ net1494 _01987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19000_ gen_regfile_ff.register_file_i.rf_reg\[182\] net2471
+ net1494 _01988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19001_ gen_regfile_ff.register_file_i.rf_reg\[183\] net1353
+ net1494 _01989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19002_ gen_regfile_ff.register_file_i.rf_reg\[184\] net1352
+ net1494 _01990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19003_ gen_regfile_ff.register_file_i.rf_reg\[185\] net1356
+ net1495 _01991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19004_ gen_regfile_ff.register_file_i.rf_reg\[186\] net1351
+ net1495 _01992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19005_ gen_regfile_ff.register_file_i.rf_reg\[187\] net1364
+ net1495 _01993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19006_ gen_regfile_ff.register_file_i.rf_reg\[188\] net2470
+ net1495 _01994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19007_ gen_regfile_ff.register_file_i.rf_reg\[189\] net1363
+ net1495 _01995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19008_ gen_regfile_ff.register_file_i.rf_reg\[190\] net1349
+ net1495 _01996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19009_ gen_regfile_ff.register_file_i.rf_reg\[191\] net1348
+ _05574_ _01997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19010_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _09519_
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _05044_ _05578_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_19011_ _05500_ _05578_ _05579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xplace1351 _05318_ net1350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
X_19013_ gen_regfile_ff.register_file_i.rf_reg\[192\] net1379
+ _05579_ _01998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19014_ gen_regfile_ff.register_file_i.rf_reg\[193\] net1453
+ _05579_ _01999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19015_ gen_regfile_ff.register_file_i.rf_reg\[194\] _05543_
+ _05579_ _02000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19016_ gen_regfile_ff.register_file_i.rf_reg\[195\] _05565_
+ net1493 _02001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19017_ gen_regfile_ff.register_file_i.rf_reg\[196\] _05042_
+ _05579_ _02002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19018_ gen_regfile_ff.register_file_i.rf_reg\[197\] net1396
+ _05579_ _02003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19019_ gen_regfile_ff.register_file_i.rf_reg\[198\] net1399
+ _05579_ _02004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19020_ gen_regfile_ff.register_file_i.rf_reg\[199\] _05450_
+ net1493 _02005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19021_ gen_regfile_ff.register_file_i.rf_reg\[200\] net1392
+ net1493 _02006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19022_ gen_regfile_ff.register_file_i.rf_reg\[201\] net1388
+ _05579_ _02007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1350 _05377_ net1349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19024_ gen_regfile_ff.register_file_i.rf_reg\[202\] net1381
+ net1493 _02008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19025_ gen_regfile_ff.register_file_i.rf_reg\[203\] net1376
+ _05579_ _02009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19026_ gen_regfile_ff.register_file_i.rf_reg\[204\] net1375
+ _05579_ _02010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19027_ gen_regfile_ff.register_file_i.rf_reg\[205\] net1377
+ _05579_ _02011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19028_ gen_regfile_ff.register_file_i.rf_reg\[206\] net1371
+ _05579_ _02012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19029_ gen_regfile_ff.register_file_i.rf_reg\[207\] net1374
+ _05579_ _02013_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19030_ gen_regfile_ff.register_file_i.rf_reg\[208\] net1370
+ net1493 _02014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19031_ gen_regfile_ff.register_file_i.rf_reg\[209\] net1362
+ _05579_ _02015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19032_ gen_regfile_ff.register_file_i.rf_reg\[210\] net1368
+ net1493 _02016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19033_ gen_regfile_ff.register_file_i.rf_reg\[211\] net1366
+ net1493 _02017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1359 _05169_ net1358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19035_ gen_regfile_ff.register_file_i.rf_reg\[212\] net1354
+ net1493 _02018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19036_ gen_regfile_ff.register_file_i.rf_reg\[213\] net1360
+ _05579_ _02019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19037_ gen_regfile_ff.register_file_i.rf_reg\[214\] net2472
+ _05579_ _02020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19038_ gen_regfile_ff.register_file_i.rf_reg\[215\] net1353
+ net1493 _02021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19039_ gen_regfile_ff.register_file_i.rf_reg\[216\] net1352
+ _05579_ _02022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19040_ gen_regfile_ff.register_file_i.rf_reg\[217\] net1356
+ net1493 _02023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19041_ gen_regfile_ff.register_file_i.rf_reg\[218\] net1351
+ net1493 _02024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19042_ gen_regfile_ff.register_file_i.rf_reg\[219\] net1364
+ net1493 _02025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19043_ gen_regfile_ff.register_file_i.rf_reg\[220\] net2470
+ net1493 _02026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19044_ gen_regfile_ff.register_file_i.rf_reg\[221\] net1363
+ net1493 _02027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19045_ gen_regfile_ff.register_file_i.rf_reg\[222\] net1349
+ net1493 _02028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19046_ gen_regfile_ff.register_file_i.rf_reg\[223\] net1348
+ net1493 _02029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1357 _05224_ net1356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19048_ _05045_ _05500_ _05584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1349 _05410_ net1348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19050_ net1379 gen_regfile_ff.register_file_i.rf_reg\[224\]
+ _05584_ _02030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2043 net146 net2042 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19052_ net1453 gen_regfile_ff.register_file_i.rf_reg\[225\]
+ net1492 _02031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2028 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[6\]
+ net2027 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19054_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[226\]
+ net1492 _02032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2024 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[1\]
+ net2023 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19056_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[227\]
+ net1492 _02033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19057_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[228\]
+ net1492 _02034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19058_ net1396 gen_regfile_ff.register_file_i.rf_reg\[229\]
+ _05584_ _02035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19059_ net1399 gen_regfile_ff.register_file_i.rf_reg\[230\]
+ _05584_ _02036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19060_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[231\]
+ net1492 _02037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19061_ net1392 gen_regfile_ff.register_file_i.rf_reg\[232\]
+ net1492 _02038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19062_ net1388 gen_regfile_ff.register_file_i.rf_reg\[233\]
+ net1492 _02039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2027 cs_registers_i.pc_if_i\[1\] net2026 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19064_ net1381 gen_regfile_ff.register_file_i.rf_reg\[234\]
+ net1492 _02040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19065_ net1376 gen_regfile_ff.register_file_i.rf_reg\[235\]
+ _05584_ _02041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19066_ net1375 gen_regfile_ff.register_file_i.rf_reg\[236\]
+ net1492 _02042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19067_ net1377 gen_regfile_ff.register_file_i.rf_reg\[237\]
+ net1492 _02043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19068_ net1371 gen_regfile_ff.register_file_i.rf_reg\[238\]
+ net1492 _02044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19069_ net1374 gen_regfile_ff.register_file_i.rf_reg\[239\]
+ net1492 _02045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19070_ net1370 gen_regfile_ff.register_file_i.rf_reg\[240\]
+ net1492 _02046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19071_ net1362 gen_regfile_ff.register_file_i.rf_reg\[241\]
+ net1492 _02047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19072_ net1368 gen_regfile_ff.register_file_i.rf_reg\[242\]
+ net1492 _02048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19073_ net1366 gen_regfile_ff.register_file_i.rf_reg\[243\]
+ net1492 _02049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2035 net2033 net2034 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_19075_ net1354 gen_regfile_ff.register_file_i.rf_reg\[244\]
+ net1492 _02050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19076_ net1360 gen_regfile_ff.register_file_i.rf_reg\[245\]
+ net1492 _02051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19077_ net2473 gen_regfile_ff.register_file_i.rf_reg\[246\]
+ net1492 _02052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19078_ net1353 gen_regfile_ff.register_file_i.rf_reg\[247\]
+ net1492 _02053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19079_ net1352 gen_regfile_ff.register_file_i.rf_reg\[248\]
+ net1492 _02054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19080_ net1356 gen_regfile_ff.register_file_i.rf_reg\[249\]
+ net1492 _02055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19081_ net1351 gen_regfile_ff.register_file_i.rf_reg\[250\]
+ net1492 _02056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19082_ net1364 gen_regfile_ff.register_file_i.rf_reg\[251\]
+ net1492 _02057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19083_ net2494 gen_regfile_ff.register_file_i.rf_reg\[252\]
+ net1492 _02058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19084_ net1363 gen_regfile_ff.register_file_i.rf_reg\[253\]
+ net1492 _02059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19085_ net1349 gen_regfile_ff.register_file_i.rf_reg\[254\]
+ net1492 _02060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19086_ net1348 gen_regfile_ff.register_file_i.rf_reg\[255\]
+ net1492 _02061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19087_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _05499_
+ _05591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_19088_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _09520_
+ _05044_ _05591_ _05592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
Xplace2022 id_stage_i.controller_i.instr_i\[12\] net2021 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_19090_ net1379 gen_regfile_ff.register_file_i.rf_reg\[256\]
+ net1504 _02062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19091_ net1453 gen_regfile_ff.register_file_i.rf_reg\[257\]
+ net1504 _02063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19092_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[258\]
+ net1504 _02064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19093_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[259\]
+ net1504 _02065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19094_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[260\]
+ net1504 _02066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19095_ net1396 gen_regfile_ff.register_file_i.rf_reg\[261\]
+ net1504 _02067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19096_ net1399 gen_regfile_ff.register_file_i.rf_reg\[262\]
+ net1504 _02068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19097_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[263\]
+ net1504 _02069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19098_ net1392 gen_regfile_ff.register_file_i.rf_reg\[264\]
+ net1504 _02070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19099_ net1388 gen_regfile_ff.register_file_i.rf_reg\[265\]
+ net1504 _02071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2021 id_stage_i.controller_i.instr_i\[13\] net2020 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_19101_ net1381 gen_regfile_ff.register_file_i.rf_reg\[266\]
+ net1504 _02072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19102_ net1376 gen_regfile_ff.register_file_i.rf_reg\[267\]
+ net1504 _02073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19103_ net1375 gen_regfile_ff.register_file_i.rf_reg\[268\]
+ net1504 _02074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19104_ net1377 gen_regfile_ff.register_file_i.rf_reg\[269\]
+ net1504 _02075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19105_ net1371 gen_regfile_ff.register_file_i.rf_reg\[270\]
+ net1504 _02076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19106_ net1374 gen_regfile_ff.register_file_i.rf_reg\[271\]
+ net1504 _02077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19107_ net1370 gen_regfile_ff.register_file_i.rf_reg\[272\]
+ net1504 _02078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19108_ net1362 gen_regfile_ff.register_file_i.rf_reg\[273\]
+ net1504 _02079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19109_ net1368 gen_regfile_ff.register_file_i.rf_reg\[274\]
+ net1504 _02080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19110_ net1366 gen_regfile_ff.register_file_i.rf_reg\[275\]
+ net1504 _02081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace2046 net143 net2045 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19112_ net1354 gen_regfile_ff.register_file_i.rf_reg\[276\]
+ net1504 _02082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19113_ net1360 gen_regfile_ff.register_file_i.rf_reg\[277\]
+ net1504 _02083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19114_ net2473 gen_regfile_ff.register_file_i.rf_reg\[278\]
+ net1504 _02084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19115_ net1353 gen_regfile_ff.register_file_i.rf_reg\[279\]
+ net1504 _02085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19116_ net1352 gen_regfile_ff.register_file_i.rf_reg\[280\]
+ net1504 _02086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19117_ net1356 gen_regfile_ff.register_file_i.rf_reg\[281\]
+ net1504 _02087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19118_ net1351 gen_regfile_ff.register_file_i.rf_reg\[282\]
+ net1504 _02088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19119_ net1364 gen_regfile_ff.register_file_i.rf_reg\[283\]
+ net1504 _02089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19120_ net2494 gen_regfile_ff.register_file_i.rf_reg\[284\]
+ net1504 _02090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19121_ net1363 gen_regfile_ff.register_file_i.rf_reg\[285\]
+ net1504 _02091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19122_ net1349 gen_regfile_ff.register_file_i.rf_reg\[286\]
+ net1504 _02092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19123_ net1348 gen_regfile_ff.register_file_i.rf_reg\[287\]
+ net1504 _02093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19124_ _05573_ _05591_ _05596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xclkbuf_leaf_23_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_23_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_19126_ net1379 gen_regfile_ff.register_file_i.rf_reg\[288\]
+ net1491 _02094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19127_ net1453 gen_regfile_ff.register_file_i.rf_reg\[289\]
+ net1491 _02095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19128_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[290\]
+ net1491 _02096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19129_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[291\]
+ net1491 _02097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19130_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[292\]
+ net1491 _02098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19131_ net1396 gen_regfile_ff.register_file_i.rf_reg\[293\]
+ net1491 _02099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19132_ net1399 gen_regfile_ff.register_file_i.rf_reg\[294\]
+ net1491 _02100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19133_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[295\]
+ net1491 _02101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19134_ net1392 gen_regfile_ff.register_file_i.rf_reg\[296\]
+ net1491 _02102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19135_ net1388 gen_regfile_ff.register_file_i.rf_reg\[297\]
+ net1491 _02103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1960 gen_regfile_ff.register_file_i.raddr_a_i\[3\] net1959
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19137_ net1381 gen_regfile_ff.register_file_i.rf_reg\[298\]
+ net1491 _02104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19138_ net1376 gen_regfile_ff.register_file_i.rf_reg\[299\]
+ net1491 _02105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19139_ net1375 gen_regfile_ff.register_file_i.rf_reg\[300\]
+ net1491 _02106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19140_ net1377 gen_regfile_ff.register_file_i.rf_reg\[301\]
+ net1491 _02107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19141_ net1371 gen_regfile_ff.register_file_i.rf_reg\[302\]
+ net1491 _02108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19142_ net1374 gen_regfile_ff.register_file_i.rf_reg\[303\]
+ net1491 _02109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19143_ net1370 gen_regfile_ff.register_file_i.rf_reg\[304\]
+ net1491 _02110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19144_ net1362 gen_regfile_ff.register_file_i.rf_reg\[305\]
+ net1491 _02111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19145_ net1368 gen_regfile_ff.register_file_i.rf_reg\[306\]
+ net1491 _02112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19146_ net1366 gen_regfile_ff.register_file_i.rf_reg\[307\]
+ net1491 _02113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1959 gen_regfile_ff.register_file_i.raddr_a_i\[4\] net1958
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_19148_ net1354 gen_regfile_ff.register_file_i.rf_reg\[308\]
+ net1491 _02114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19149_ net1360 gen_regfile_ff.register_file_i.rf_reg\[309\]
+ net1491 _02115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19150_ net2473 gen_regfile_ff.register_file_i.rf_reg\[310\]
+ net1491 _02116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19151_ net1353 gen_regfile_ff.register_file_i.rf_reg\[311\]
+ net1491 _02117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19152_ net1352 gen_regfile_ff.register_file_i.rf_reg\[312\]
+ net1491 _02118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19153_ net1356 gen_regfile_ff.register_file_i.rf_reg\[313\]
+ net1491 _02119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19154_ net1351 gen_regfile_ff.register_file_i.rf_reg\[314\]
+ net1491 _02120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19155_ net1364 gen_regfile_ff.register_file_i.rf_reg\[315\]
+ net1491 _02121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19156_ net2494 gen_regfile_ff.register_file_i.rf_reg\[316\]
+ net1491 _02122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19157_ net1363 gen_regfile_ff.register_file_i.rf_reg\[317\]
+ net1491 _02123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19158_ net1349 gen_regfile_ff.register_file_i.rf_reg\[318\]
+ net1491 _02124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19159_ net1348 gen_regfile_ff.register_file_i.rf_reg\[319\]
+ net1491 _02125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19160_ _05578_ _05591_ _05600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xplace1961 net1959 net1960 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19162_ gen_regfile_ff.register_file_i.rf_reg\[320\] net1379
+ net1490 _02126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19163_ gen_regfile_ff.register_file_i.rf_reg\[321\] net1453
+ net1490 _02127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19164_ gen_regfile_ff.register_file_i.rf_reg\[322\] _05543_
+ net1490 _02128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19165_ gen_regfile_ff.register_file_i.rf_reg\[323\] _05565_
+ net1490 _02129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19166_ gen_regfile_ff.register_file_i.rf_reg\[324\] _05042_
+ net1490 _02130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19167_ gen_regfile_ff.register_file_i.rf_reg\[325\] net1396
+ net1490 _02131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19168_ gen_regfile_ff.register_file_i.rf_reg\[326\] net1399
+ net1490 _02132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19169_ gen_regfile_ff.register_file_i.rf_reg\[327\] _05450_
+ net1490 _02133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19170_ gen_regfile_ff.register_file_i.rf_reg\[328\] net1392
+ net1490 _02134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19171_ gen_regfile_ff.register_file_i.rf_reg\[329\] net1388
+ net1490 _02135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19172_ _09518_ _05573_ _05602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1975 net1973 net1974 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19174_ net1379 gen_regfile_ff.register_file_i.rf_reg\[32\]
+ _05602_ _02136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1974 net1972 net1973 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19176_ gen_regfile_ff.register_file_i.rf_reg\[330\] net1381
+ net1490 _02137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19177_ gen_regfile_ff.register_file_i.rf_reg\[331\] net1376
+ net1490 _02138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19178_ gen_regfile_ff.register_file_i.rf_reg\[332\] net1375
+ net1490 _02139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19179_ gen_regfile_ff.register_file_i.rf_reg\[333\] net1377
+ net1490 _02140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19180_ gen_regfile_ff.register_file_i.rf_reg\[334\] net1371
+ net1490 _02141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19181_ gen_regfile_ff.register_file_i.rf_reg\[335\] net1374
+ net1490 _02142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19182_ gen_regfile_ff.register_file_i.rf_reg\[336\] net1370
+ net1490 _02143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19183_ gen_regfile_ff.register_file_i.rf_reg\[337\] net1362
+ net1490 _02144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19184_ gen_regfile_ff.register_file_i.rf_reg\[338\] net1368
+ net1490 _02145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19185_ gen_regfile_ff.register_file_i.rf_reg\[339\] net1366
+ net1490 _02146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19186_ net1453 gen_regfile_ff.register_file_i.rf_reg\[33\]
+ _05602_ _02147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1973 gen_regfile_ff.register_file_i.raddr_a_i\[1\] net1972
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19188_ gen_regfile_ff.register_file_i.rf_reg\[340\] net1354
+ net1490 _02148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19189_ gen_regfile_ff.register_file_i.rf_reg\[341\] net1360
+ net1490 _02149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19190_ gen_regfile_ff.register_file_i.rf_reg\[342\] net2473
+ net1490 _02150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19191_ gen_regfile_ff.register_file_i.rf_reg\[343\] net1353
+ net1490 _02151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19192_ gen_regfile_ff.register_file_i.rf_reg\[344\] net1352
+ net1490 _02152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19193_ gen_regfile_ff.register_file_i.rf_reg\[345\] net1356
+ net1490 _02153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19194_ gen_regfile_ff.register_file_i.rf_reg\[346\] net1351
+ net1490 _02154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19195_ gen_regfile_ff.register_file_i.rf_reg\[347\] net1364
+ net1490 _02155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19196_ gen_regfile_ff.register_file_i.rf_reg\[348\] net2470
+ net1490 _02156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19197_ gen_regfile_ff.register_file_i.rf_reg\[349\] net1363
+ net1490 _02157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19198_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[34\]
+ _05602_ _02158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19199_ gen_regfile_ff.register_file_i.rf_reg\[350\] net1349
+ net1490 _02159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19200_ gen_regfile_ff.register_file_i.rf_reg\[351\] net1348
+ net1490 _02160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19201_ _05045_ _05591_ _05606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1981 net1976 net1980 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19203_ net1379 gen_regfile_ff.register_file_i.rf_reg\[352\]
+ net1488 _02161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19204_ net1453 gen_regfile_ff.register_file_i.rf_reg\[353\]
+ net1488 _02162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19205_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[354\]
+ net1488 _02163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19206_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[355\]
+ net1488 _02164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19207_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[356\]
+ net1488 _02165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19208_ net1396 gen_regfile_ff.register_file_i.rf_reg\[357\]
+ net1488 _02166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19209_ net1399 gen_regfile_ff.register_file_i.rf_reg\[358\]
+ net1488 _02167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19210_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[359\]
+ net1488 _02168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19211_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[35\]
+ net1489 _02169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19212_ net1392 gen_regfile_ff.register_file_i.rf_reg\[360\]
+ net1488 _02170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19213_ net1388 gen_regfile_ff.register_file_i.rf_reg\[361\]
+ net1488 _02171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1955 net1944 net1954 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_19215_ net1381 gen_regfile_ff.register_file_i.rf_reg\[362\]
+ net1488 _02172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19216_ net1376 gen_regfile_ff.register_file_i.rf_reg\[363\]
+ net1488 _02173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19217_ net1375 gen_regfile_ff.register_file_i.rf_reg\[364\]
+ net1488 _02174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19218_ net1377 gen_regfile_ff.register_file_i.rf_reg\[365\]
+ net1488 _02175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19219_ net1371 gen_regfile_ff.register_file_i.rf_reg\[366\]
+ net1488 _02176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19220_ net1374 gen_regfile_ff.register_file_i.rf_reg\[367\]
+ net1488 _02177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19221_ net1370 gen_regfile_ff.register_file_i.rf_reg\[368\]
+ net1488 _02178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19222_ net1362 gen_regfile_ff.register_file_i.rf_reg\[369\]
+ net1488 _02179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19223_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[36\]
+ _05602_ _02180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19224_ net1368 gen_regfile_ff.register_file_i.rf_reg\[370\]
+ net1488 _02181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19225_ net1366 gen_regfile_ff.register_file_i.rf_reg\[371\]
+ net1488 _02182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1879 net1877 net1878 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19227_ net1354 gen_regfile_ff.register_file_i.rf_reg\[372\]
+ net1488 _02183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19228_ net1360 gen_regfile_ff.register_file_i.rf_reg\[373\]
+ net1488 _02184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19229_ net2473 gen_regfile_ff.register_file_i.rf_reg\[374\]
+ net1488 _02185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19230_ net1353 gen_regfile_ff.register_file_i.rf_reg\[375\]
+ net1488 _02186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19231_ net1352 gen_regfile_ff.register_file_i.rf_reg\[376\]
+ net1488 _02187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19232_ net1356 gen_regfile_ff.register_file_i.rf_reg\[377\]
+ net1488 _02188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19233_ net1351 gen_regfile_ff.register_file_i.rf_reg\[378\]
+ net1488 _02189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19234_ net1364 gen_regfile_ff.register_file_i.rf_reg\[379\]
+ net1488 _02190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19235_ net1396 gen_regfile_ff.register_file_i.rf_reg\[37\]
+ _05602_ _02191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19236_ net2470 gen_regfile_ff.register_file_i.rf_reg\[380\]
+ net1488 _02192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19237_ net1363 gen_regfile_ff.register_file_i.rf_reg\[381\]
+ net1488 _02193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19238_ net1349 gen_regfile_ff.register_file_i.rf_reg\[382\]
+ net1488 _02194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19239_ net1348 gen_regfile_ff.register_file_i.rf_reg\[383\]
+ net1488 _02195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19240_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _09520_
+ _04691_ _05044_ _05610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
Xplace1864 _07657_ net1863 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19242_ net1379 gen_regfile_ff.register_file_i.rf_reg\[384\]
+ net1502 _02196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19243_ net1453 gen_regfile_ff.register_file_i.rf_reg\[385\]
+ net1502 _02197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19244_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[386\]
+ net1502 _02198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19245_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[387\]
+ net1503 _02199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19246_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[388\]
+ net1502 _02200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19247_ net1396 gen_regfile_ff.register_file_i.rf_reg\[389\]
+ net1502 _02201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19248_ net1399 gen_regfile_ff.register_file_i.rf_reg\[38\]
+ _05602_ _02202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19249_ net1399 gen_regfile_ff.register_file_i.rf_reg\[390\]
+ net1502 _02203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19250_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[391\]
+ net1503 _02204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19251_ net1392 gen_regfile_ff.register_file_i.rf_reg\[392\]
+ net1503 _02205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19252_ net1388 gen_regfile_ff.register_file_i.rf_reg\[393\]
+ net1502 _02206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1927 net1925 net1926 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19254_ net1381 gen_regfile_ff.register_file_i.rf_reg\[394\]
+ net1502 _02207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19255_ net1376 gen_regfile_ff.register_file_i.rf_reg\[395\]
+ net1502 _02208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19256_ net1375 gen_regfile_ff.register_file_i.rf_reg\[396\]
+ net1502 _02209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19257_ net1377 gen_regfile_ff.register_file_i.rf_reg\[397\]
+ net1503 _02210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19258_ net1371 gen_regfile_ff.register_file_i.rf_reg\[398\]
+ net1502 _02211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19259_ net1374 gen_regfile_ff.register_file_i.rf_reg\[399\]
+ net1503 _02212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19260_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[39\]
+ net1489 _02213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19261_ net1370 gen_regfile_ff.register_file_i.rf_reg\[400\]
+ net1503 _02214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19262_ net1362 gen_regfile_ff.register_file_i.rf_reg\[401\]
+ net1502 _02215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19263_ net1368 gen_regfile_ff.register_file_i.rf_reg\[402\]
+ net1503 _02216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19264_ net1366 gen_regfile_ff.register_file_i.rf_reg\[403\]
+ net1503 _02217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1806 _06492_ net1805 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19266_ net1354 gen_regfile_ff.register_file_i.rf_reg\[404\]
+ net1503 _02218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19267_ net1360 gen_regfile_ff.register_file_i.rf_reg\[405\]
+ net1502 _02219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19268_ net2472 gen_regfile_ff.register_file_i.rf_reg\[406\]
+ net1502 _02220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19269_ net1353 gen_regfile_ff.register_file_i.rf_reg\[407\]
+ net1503 _02221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19270_ net1352 gen_regfile_ff.register_file_i.rf_reg\[408\]
+ net1502 _02222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19271_ net1356 gen_regfile_ff.register_file_i.rf_reg\[409\]
+ net1503 _02223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19272_ net1392 gen_regfile_ff.register_file_i.rf_reg\[40\]
+ net1489 _02224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19273_ net1351 gen_regfile_ff.register_file_i.rf_reg\[410\]
+ net1503 _02225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19274_ net1364 gen_regfile_ff.register_file_i.rf_reg\[411\]
+ net1503 _02226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19275_ net2470 gen_regfile_ff.register_file_i.rf_reg\[412\]
+ net1503 _02227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19276_ net1363 gen_regfile_ff.register_file_i.rf_reg\[413\]
+ net1503 _02228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19277_ net1349 gen_regfile_ff.register_file_i.rf_reg\[414\]
+ net1503 _02229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19278_ net1348 gen_regfile_ff.register_file_i.rf_reg\[415\]
+ net1503 _02230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19279_ _04691_ _05573_ _05614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xplace2009 net2005 net2008 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
X_19281_ gen_regfile_ff.register_file_i.rf_reg\[416\] net1379
+ net1487 _02231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19282_ gen_regfile_ff.register_file_i.rf_reg\[417\] net1453
+ net1487 _02232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19283_ gen_regfile_ff.register_file_i.rf_reg\[418\] _05543_
+ net1487 _02233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19284_ gen_regfile_ff.register_file_i.rf_reg\[419\] _05565_
+ _05614_ _02234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19285_ net1388 gen_regfile_ff.register_file_i.rf_reg\[41\]
+ net1489 _02235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19286_ gen_regfile_ff.register_file_i.rf_reg\[420\] _05042_
+ net1487 _02236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19287_ gen_regfile_ff.register_file_i.rf_reg\[421\] net1396
+ net1487 _02237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19288_ gen_regfile_ff.register_file_i.rf_reg\[422\] net1399
+ net1487 _02238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19289_ gen_regfile_ff.register_file_i.rf_reg\[423\] _05450_
+ _05614_ _02239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19290_ gen_regfile_ff.register_file_i.rf_reg\[424\] net1392
+ _05614_ _02240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19291_ gen_regfile_ff.register_file_i.rf_reg\[425\] net1388
+ net1487 _02241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1750 _09770_ net1749 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19293_ gen_regfile_ff.register_file_i.rf_reg\[426\] net1381
+ net1487 _02242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19294_ gen_regfile_ff.register_file_i.rf_reg\[427\] net1376
+ net1487 _02243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19295_ gen_regfile_ff.register_file_i.rf_reg\[428\] net1375
+ net1487 _02244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19296_ gen_regfile_ff.register_file_i.rf_reg\[429\] net1377
+ net1487 _02245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1661 _09774_ net1660 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19298_ net1381 gen_regfile_ff.register_file_i.rf_reg\[42\]
+ net1489 _02246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19299_ gen_regfile_ff.register_file_i.rf_reg\[430\] net1371
+ net1487 _02247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19300_ gen_regfile_ff.register_file_i.rf_reg\[431\] net1374
+ net1487 _02248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19301_ gen_regfile_ff.register_file_i.rf_reg\[432\] net1370
+ net1487 _02249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19302_ gen_regfile_ff.register_file_i.rf_reg\[433\] net1362
+ net1487 _02250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19303_ gen_regfile_ff.register_file_i.rf_reg\[434\] net1368
+ _05614_ _02251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19304_ gen_regfile_ff.register_file_i.rf_reg\[435\] net1366
+ _05614_ _02252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1662 net1660 net1661 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19306_ gen_regfile_ff.register_file_i.rf_reg\[436\] net1354
+ _05614_ _02253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19307_ gen_regfile_ff.register_file_i.rf_reg\[437\] net1360
+ net1487 _02254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19308_ gen_regfile_ff.register_file_i.rf_reg\[438\] net2472
+ net1487 _02255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19309_ gen_regfile_ff.register_file_i.rf_reg\[439\] net1353
+ net1487 _02256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19310_ net1376 gen_regfile_ff.register_file_i.rf_reg\[43\]
+ _05602_ _02257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19311_ gen_regfile_ff.register_file_i.rf_reg\[440\] net1352
+ net1487 _02258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19312_ gen_regfile_ff.register_file_i.rf_reg\[441\] net1356
+ _05614_ _02259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19313_ gen_regfile_ff.register_file_i.rf_reg\[442\] net1351
+ _05614_ _02260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19314_ gen_regfile_ff.register_file_i.rf_reg\[443\] net1364
+ _05614_ _02261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19315_ gen_regfile_ff.register_file_i.rf_reg\[444\] net2470
+ _05614_ _02262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19316_ gen_regfile_ff.register_file_i.rf_reg\[445\] net1363
+ _05614_ _02263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19317_ gen_regfile_ff.register_file_i.rf_reg\[446\] net1349
+ _05614_ _02264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19318_ gen_regfile_ff.register_file_i.rf_reg\[447\] net1348
+ _05614_ _02265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19319_ _04691_ _05578_ _05619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1593 _09881_ net1592 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19321_ net1379 gen_regfile_ff.register_file_i.rf_reg\[448\]
+ _05619_ _02266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19322_ net1453 gen_regfile_ff.register_file_i.rf_reg\[449\]
+ _05619_ _02267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19323_ net1375 gen_regfile_ff.register_file_i.rf_reg\[44\]
+ net1489 _02268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19324_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[450\]
+ _05619_ _02269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19325_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[451\]
+ net1486 _02270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19326_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[452\]
+ _05619_ _02271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19327_ net1396 gen_regfile_ff.register_file_i.rf_reg\[453\]
+ _05619_ _02272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19328_ net1399 gen_regfile_ff.register_file_i.rf_reg\[454\]
+ _05619_ _02273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19329_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[455\]
+ net1486 _02274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19330_ net1392 gen_regfile_ff.register_file_i.rf_reg\[456\]
+ net1486 _02275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19331_ net1388 gen_regfile_ff.register_file_i.rf_reg\[457\]
+ _05619_ _02276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1592 _09884_ net1591 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19333_ net1381 gen_regfile_ff.register_file_i.rf_reg\[458\]
+ _05619_ _02277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19334_ net1376 gen_regfile_ff.register_file_i.rf_reg\[459\]
+ _05619_ _02278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19335_ net1377 gen_regfile_ff.register_file_i.rf_reg\[45\]
+ net1489 _02279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19336_ net1375 gen_regfile_ff.register_file_i.rf_reg\[460\]
+ _05619_ _02280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19337_ net1377 gen_regfile_ff.register_file_i.rf_reg\[461\]
+ net1486 _02281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19338_ net1371 gen_regfile_ff.register_file_i.rf_reg\[462\]
+ _05619_ _02282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19339_ net1374 gen_regfile_ff.register_file_i.rf_reg\[463\]
+ net1486 _02283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19340_ net1370 gen_regfile_ff.register_file_i.rf_reg\[464\]
+ net1486 _02284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19341_ net1362 gen_regfile_ff.register_file_i.rf_reg\[465\]
+ _05619_ _02285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19342_ net1368 gen_regfile_ff.register_file_i.rf_reg\[466\]
+ net1486 _02286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19343_ net1366 gen_regfile_ff.register_file_i.rf_reg\[467\]
+ net1486 _02287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1594 _09875_ net1593 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19345_ net1354 gen_regfile_ff.register_file_i.rf_reg\[468\]
+ net1486 _02288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19346_ net1360 gen_regfile_ff.register_file_i.rf_reg\[469\]
+ _05619_ _02289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19347_ net1371 gen_regfile_ff.register_file_i.rf_reg\[46\]
+ net1489 _02290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19348_ net2473 gen_regfile_ff.register_file_i.rf_reg\[470\]
+ _05619_ _02291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19349_ net1353 gen_regfile_ff.register_file_i.rf_reg\[471\]
+ net1486 _02292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19350_ net1352 gen_regfile_ff.register_file_i.rf_reg\[472\]
+ _05619_ _02293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19351_ net1356 gen_regfile_ff.register_file_i.rf_reg\[473\]
+ net1486 _02294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19352_ net1351 gen_regfile_ff.register_file_i.rf_reg\[474\]
+ net1486 _02295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19353_ net1364 gen_regfile_ff.register_file_i.rf_reg\[475\]
+ net1486 _02296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19354_ net2470 gen_regfile_ff.register_file_i.rf_reg\[476\]
+ net1486 _02297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19355_ net1363 gen_regfile_ff.register_file_i.rf_reg\[477\]
+ net1486 _02298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19356_ net1349 gen_regfile_ff.register_file_i.rf_reg\[478\]
+ net1486 _02299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19357_ net1348 gen_regfile_ff.register_file_i.rf_reg\[479\]
+ net1486 _02300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19358_ net1374 gen_regfile_ff.register_file_i.rf_reg\[47\]
+ net1489 _02301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19359_ _04691_ _05045_ _05623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1597 _09838_ net1596 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19361_ net1379 gen_regfile_ff.register_file_i.rf_reg\[480\]
+ _05623_ _02302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19362_ net1453 gen_regfile_ff.register_file_i.rf_reg\[481\]
+ _05623_ _02303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19363_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[482\]
+ _05623_ _02304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19364_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[483\]
+ net1485 _02305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19365_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[484\]
+ _05623_ _02306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19366_ net1396 gen_regfile_ff.register_file_i.rf_reg\[485\]
+ _05623_ _02307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19367_ net1399 gen_regfile_ff.register_file_i.rf_reg\[486\]
+ _05623_ _02308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19368_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[487\]
+ net1485 _02309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19369_ net1392 gen_regfile_ff.register_file_i.rf_reg\[488\]
+ net1485 _02310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19370_ net1388 gen_regfile_ff.register_file_i.rf_reg\[489\]
+ _05623_ _02311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19371_ net1370 gen_regfile_ff.register_file_i.rf_reg\[48\]
+ net1489 _02312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1596 _09857_ net1595 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19373_ net1381 gen_regfile_ff.register_file_i.rf_reg\[490\]
+ _05623_ _02313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19374_ net1376 gen_regfile_ff.register_file_i.rf_reg\[491\]
+ _05623_ _02314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19375_ net1375 gen_regfile_ff.register_file_i.rf_reg\[492\]
+ _05623_ _02315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19376_ net1377 gen_regfile_ff.register_file_i.rf_reg\[493\]
+ net1485 _02316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19377_ net1371 gen_regfile_ff.register_file_i.rf_reg\[494\]
+ _05623_ _02317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19378_ net1374 gen_regfile_ff.register_file_i.rf_reg\[495\]
+ net1485 _02318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19379_ net1370 gen_regfile_ff.register_file_i.rf_reg\[496\]
+ net1485 _02319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19380_ net1362 gen_regfile_ff.register_file_i.rf_reg\[497\]
+ _05623_ _02320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19381_ net1368 gen_regfile_ff.register_file_i.rf_reg\[498\]
+ net1485 _02321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19382_ net1366 gen_regfile_ff.register_file_i.rf_reg\[499\]
+ net1485 _02322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19383_ net1362 gen_regfile_ff.register_file_i.rf_reg\[49\]
+ net1489 _02323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1599 _09824_ net1598 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19385_ net1354 gen_regfile_ff.register_file_i.rf_reg\[500\]
+ net1485 _02324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19386_ net1360 gen_regfile_ff.register_file_i.rf_reg\[501\]
+ _05623_ _02325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19387_ net1359 gen_regfile_ff.register_file_i.rf_reg\[502\]
+ _05623_ _02326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19388_ net1353 gen_regfile_ff.register_file_i.rf_reg\[503\]
+ net1485 _02327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19389_ net1352 gen_regfile_ff.register_file_i.rf_reg\[504\]
+ _05623_ _02328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19390_ net1356 gen_regfile_ff.register_file_i.rf_reg\[505\]
+ net1485 _02329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19391_ net1351 gen_regfile_ff.register_file_i.rf_reg\[506\]
+ net1485 _02330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19392_ net1364 gen_regfile_ff.register_file_i.rf_reg\[507\]
+ net1485 _02331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19393_ net2470 gen_regfile_ff.register_file_i.rf_reg\[508\]
+ net1485 _02332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19394_ net1363 gen_regfile_ff.register_file_i.rf_reg\[509\]
+ net1485 _02333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19395_ net1368 gen_regfile_ff.register_file_i.rf_reg\[50\]
+ net1489 _02334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19396_ net1349 gen_regfile_ff.register_file_i.rf_reg\[510\]
+ net1485 _02335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19397_ net1348 gen_regfile_ff.register_file_i.rf_reg\[511\]
+ net1485 _02336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19398_ _07968_ _09519_ gen_regfile_ff.register_file_i.waddr_a_i\[4\]
+ _04695_ _05627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_19399_ _09518_ _05627_ _05628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xplace1595 _09872_ net1594 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19401_ net1379 gen_regfile_ff.register_file_i.rf_reg\[512\]
+ _05628_ _02337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19402_ net1453 gen_regfile_ff.register_file_i.rf_reg\[513\]
+ _05628_ _02338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19403_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[514\]
+ _05628_ _02339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19404_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[515\]
+ net1484 _02340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19405_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[516\]
+ _05628_ _02341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19406_ net1396 gen_regfile_ff.register_file_i.rf_reg\[517\]
+ _05628_ _02342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19407_ net1399 gen_regfile_ff.register_file_i.rf_reg\[518\]
+ _05628_ _02343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19408_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[519\]
+ net1484 _02344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19409_ net1366 gen_regfile_ff.register_file_i.rf_reg\[51\]
+ net1489 _02345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19410_ net1392 gen_regfile_ff.register_file_i.rf_reg\[520\]
+ net1484 _02346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19411_ net1388 gen_regfile_ff.register_file_i.rf_reg\[521\]
+ _05628_ _02347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1591 _09893_ net1590 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19413_ net1381 gen_regfile_ff.register_file_i.rf_reg\[522\]
+ _05628_ _02348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19414_ net1376 gen_regfile_ff.register_file_i.rf_reg\[523\]
+ _05628_ _02349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19415_ net1375 gen_regfile_ff.register_file_i.rf_reg\[524\]
+ _05628_ _02350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19416_ net1377 gen_regfile_ff.register_file_i.rf_reg\[525\]
+ net1484 _02351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19417_ net1371 gen_regfile_ff.register_file_i.rf_reg\[526\]
+ _05628_ _02352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19418_ net1374 gen_regfile_ff.register_file_i.rf_reg\[527\]
+ net1484 _02353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19419_ net1370 gen_regfile_ff.register_file_i.rf_reg\[528\]
+ net1484 _02354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19420_ net1362 gen_regfile_ff.register_file_i.rf_reg\[529\]
+ _05628_ _02355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload43 clknet_leaf_38_clk _unconnected_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
X_19422_ net1354 gen_regfile_ff.register_file_i.rf_reg\[52\]
+ net1489 _02356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19423_ net1368 gen_regfile_ff.register_file_i.rf_reg\[530\]
+ net1484 _02357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19424_ net1366 gen_regfile_ff.register_file_i.rf_reg\[531\]
+ net1484 _02358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkload46 clknet_leaf_8_clk _unconnected_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
X_19426_ net1354 gen_regfile_ff.register_file_i.rf_reg\[532\]
+ net1484 _02359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19427_ net1360 gen_regfile_ff.register_file_i.rf_reg\[533\]
+ _05628_ _02360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19428_ net2471 gen_regfile_ff.register_file_i.rf_reg\[534\]
+ net1484 _02361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19429_ net1353 gen_regfile_ff.register_file_i.rf_reg\[535\]
+ net1484 _02362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19430_ net1352 gen_regfile_ff.register_file_i.rf_reg\[536\]
+ net1484 _02363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19431_ net1356 gen_regfile_ff.register_file_i.rf_reg\[537\]
+ net1484 _02364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19432_ net1351 gen_regfile_ff.register_file_i.rf_reg\[538\]
+ net1484 _02365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19433_ net1364 gen_regfile_ff.register_file_i.rf_reg\[539\]
+ net1484 _02366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19434_ net1360 gen_regfile_ff.register_file_i.rf_reg\[53\]
+ net1489 _02367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19435_ net2470 gen_regfile_ff.register_file_i.rf_reg\[540\]
+ net1484 _02368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19436_ net1363 gen_regfile_ff.register_file_i.rf_reg\[541\]
+ net1484 _02369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19437_ net1349 gen_regfile_ff.register_file_i.rf_reg\[542\]
+ net1484 _02370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19438_ net1348 gen_regfile_ff.register_file_i.rf_reg\[543\]
+ net1484 _02371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19439_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _09519_
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _04695_ _05633_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_19440_ _09518_ _05633_ _05634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xrebuffer2084 _00869_ net2083 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19442_ gen_regfile_ff.register_file_i.rf_reg\[544\] net1379
+ _05634_ _02372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19443_ gen_regfile_ff.register_file_i.rf_reg\[545\] net1453
+ _05634_ _02373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19444_ gen_regfile_ff.register_file_i.rf_reg\[546\] _05543_
+ _05634_ _02374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19445_ gen_regfile_ff.register_file_i.rf_reg\[547\] _05565_
+ net1482 _02375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19446_ gen_regfile_ff.register_file_i.rf_reg\[548\] _05042_
+ net1483 _02376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19447_ gen_regfile_ff.register_file_i.rf_reg\[549\] net1396
+ net1483 _02377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19448_ net2473 gen_regfile_ff.register_file_i.rf_reg\[54\]
+ net1489 _02378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19449_ gen_regfile_ff.register_file_i.rf_reg\[550\] net1399
+ _05634_ _02379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19450_ gen_regfile_ff.register_file_i.rf_reg\[551\] _05450_
+ _05634_ _02380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1509 _04551_ net1508 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19452_ gen_regfile_ff.register_file_i.rf_reg\[552\] net1392
+ _05634_ _02381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclone2090 net2091 net2089 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
X_19454_ gen_regfile_ff.register_file_i.rf_reg\[553\] net1388
+ net1483 _02382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1486 _05623_ net1485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1485 _05628_ net1484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19457_ gen_regfile_ff.register_file_i.rf_reg\[554\] net1381
+ net1483 _02383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1483 _05634_ net1482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19459_ gen_regfile_ff.register_file_i.rf_reg\[555\] net1376
+ _05634_ _02384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1478 _05679_ net1477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19461_ gen_regfile_ff.register_file_i.rf_reg\[556\] net1375
+ net1483 _02385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1476 _05681_ net1475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19463_ gen_regfile_ff.register_file_i.rf_reg\[557\] net1377
+ net1482 _02386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1474 _05689_ net1473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
X_19465_ gen_regfile_ff.register_file_i.rf_reg\[558\] net1371
+ net1483 _02387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1471 _05698_ net1470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19467_ gen_regfile_ff.register_file_i.rf_reg\[559\] net1374
+ net1482 _02388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19468_ net1353 gen_regfile_ff.register_file_i.rf_reg\[55\]
+ net1489 _02389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1470 _05702_ net1469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19470_ gen_regfile_ff.register_file_i.rf_reg\[560\] net1370
+ net1482 _02390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1468 _05706_ net1467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19472_ gen_regfile_ff.register_file_i.rf_reg\[561\] net1362
+ net1483 _02391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace1466 _05711_ net1465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19474_ gen_regfile_ff.register_file_i.rf_reg\[562\] net1368
+ net1482 _02392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xrebuffer2476 net2481 net2475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_19476_ gen_regfile_ff.register_file_i.rf_reg\[563\] net1366
+ _05634_ _02393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput255 net254 instr_req_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput254 net253 instr_addr_o[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19479_ gen_regfile_ff.register_file_i.rf_reg\[564\] net1354
+ _05634_ _02394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput253 net252 instr_addr_o[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19481_ gen_regfile_ff.register_file_i.rf_reg\[565\] net1360
+ net1483 _02395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput252 net251 instr_addr_o[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19483_ gen_regfile_ff.register_file_i.rf_reg\[566\] net2472
+ net1482 _02396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput251 net250 instr_addr_o[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19485_ gen_regfile_ff.register_file_i.rf_reg\[567\] net1353
+ net1482 _02397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput250 net249 instr_addr_o[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19487_ gen_regfile_ff.register_file_i.rf_reg\[568\] net1352
+ net1483 _02398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput249 net248 instr_addr_o[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19489_ gen_regfile_ff.register_file_i.rf_reg\[569\] net1356
+ net1482 _02399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19490_ net1352 gen_regfile_ff.register_file_i.rf_reg\[56\]
+ net1489 _02400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput248 net247 instr_addr_o[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19492_ gen_regfile_ff.register_file_i.rf_reg\[570\] net1351
+ _05634_ _02401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput247 net246 instr_addr_o[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19494_ gen_regfile_ff.register_file_i.rf_reg\[571\] net1364
+ net1482 _02402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput246 net245 instr_addr_o[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19496_ gen_regfile_ff.register_file_i.rf_reg\[572\] net1350
+ _05634_ _02403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput245 net244 instr_addr_o[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19498_ gen_regfile_ff.register_file_i.rf_reg\[573\] net1363
+ net1482 _02404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput244 net243 instr_addr_o[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19500_ gen_regfile_ff.register_file_i.rf_reg\[574\] net1349
+ net1482 _02405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput243 net242 instr_addr_o[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19502_ gen_regfile_ff.register_file_i.rf_reg\[575\] net1348
+ _05634_ _02406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput242 net241 instr_addr_o[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19504_ _07968_ gen_regfile_ff.register_file_i.waddr_a_i\[1\]
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _04695_ _05663_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_19505_ _09518_ _05663_ _05664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput241 net240 instr_addr_o[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19507_ gen_regfile_ff.register_file_i.rf_reg\[576\] net1379
+ _05664_ _02407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput240 net239 instr_addr_o[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19509_ gen_regfile_ff.register_file_i.rf_reg\[577\] net1453
+ _05664_ _02408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput239 net238 instr_addr_o[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19511_ gen_regfile_ff.register_file_i.rf_reg\[578\] _05543_
+ _05664_ _02409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput238 net237 instr_addr_o[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19513_ gen_regfile_ff.register_file_i.rf_reg\[579\] _05565_
+ net1481 _02410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19514_ net1356 gen_regfile_ff.register_file_i.rf_reg\[57\]
+ net1489 _02411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput237 net236 instr_addr_o[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19516_ gen_regfile_ff.register_file_i.rf_reg\[580\] _05042_
+ net1480 _02412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput236 net235 instr_addr_o[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19518_ gen_regfile_ff.register_file_i.rf_reg\[581\] net1396
+ net1480 _02413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput235 net234 instr_addr_o[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19520_ gen_regfile_ff.register_file_i.rf_reg\[582\] net1399
+ _05664_ _02414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput234 net233 instr_addr_o[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19522_ gen_regfile_ff.register_file_i.rf_reg\[583\] _05450_
+ _05664_ _02415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19523_ gen_regfile_ff.register_file_i.rf_reg\[584\] net1392
+ _05664_ _02416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19524_ gen_regfile_ff.register_file_i.rf_reg\[585\] net1388
+ net1480 _02417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput233 net232 instr_addr_o[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19526_ gen_regfile_ff.register_file_i.rf_reg\[586\] net1381
+ net1480 _02418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19527_ gen_regfile_ff.register_file_i.rf_reg\[587\] net1376
+ _05664_ _02419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19528_ gen_regfile_ff.register_file_i.rf_reg\[588\] net1375
+ net1480 _02420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19529_ gen_regfile_ff.register_file_i.rf_reg\[589\] net1377
+ net1481 _02421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19530_ net1351 gen_regfile_ff.register_file_i.rf_reg\[58\]
+ net1489 _02422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19531_ gen_regfile_ff.register_file_i.rf_reg\[590\] net1371
+ net1480 _02423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19532_ gen_regfile_ff.register_file_i.rf_reg\[591\] net1374
+ net1481 _02424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19533_ gen_regfile_ff.register_file_i.rf_reg\[592\] net1370
+ net1481 _02425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19534_ gen_regfile_ff.register_file_i.rf_reg\[593\] net1362
+ net1480 _02426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19535_ gen_regfile_ff.register_file_i.rf_reg\[594\] net1368
+ net1481 _02427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19536_ gen_regfile_ff.register_file_i.rf_reg\[595\] net1366
+ _05664_ _02428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput232 net231 instr_addr_o[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19538_ gen_regfile_ff.register_file_i.rf_reg\[596\] net1354
+ _05664_ _02429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19539_ gen_regfile_ff.register_file_i.rf_reg\[597\] net1360
+ net1481 _02430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19540_ gen_regfile_ff.register_file_i.rf_reg\[598\] net2471
+ net1481 _02431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19541_ gen_regfile_ff.register_file_i.rf_reg\[599\] net1353
+ net1481 _02432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19542_ net1364 gen_regfile_ff.register_file_i.rf_reg\[59\]
+ net1489 _02433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19543_ gen_regfile_ff.register_file_i.rf_reg\[600\] net1352
+ net1480 _02434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19544_ gen_regfile_ff.register_file_i.rf_reg\[601\] net1356
+ net1481 _02435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19545_ gen_regfile_ff.register_file_i.rf_reg\[602\] net1351
+ _05664_ _02436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19546_ gen_regfile_ff.register_file_i.rf_reg\[603\] net1364
+ net1481 _02437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19547_ gen_regfile_ff.register_file_i.rf_reg\[604\] net1350
+ _05664_ _02438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19548_ gen_regfile_ff.register_file_i.rf_reg\[605\] net1363
+ net1481 _02439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19549_ gen_regfile_ff.register_file_i.rf_reg\[606\] net1349
+ net1481 _02440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19550_ gen_regfile_ff.register_file_i.rf_reg\[607\] net1348
+ _05664_ _02441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19551_ _09518_ _04696_ _05675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput231 net230 instr_addr_o[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19553_ gen_regfile_ff.register_file_i.rf_reg\[608\] net1379
+ _05675_ _02442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19554_ gen_regfile_ff.register_file_i.rf_reg\[609\] net1453
+ _05675_ _02443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19555_ net2470 gen_regfile_ff.register_file_i.rf_reg\[60\]
+ net1489 _02444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19556_ gen_regfile_ff.register_file_i.rf_reg\[610\] _05543_
+ _05675_ _02445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19557_ gen_regfile_ff.register_file_i.rf_reg\[611\] _05565_
+ net1479 _02446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19558_ gen_regfile_ff.register_file_i.rf_reg\[612\] _05042_
+ net1478 _02447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19559_ gen_regfile_ff.register_file_i.rf_reg\[613\] net1396
+ net1478 _02448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19560_ gen_regfile_ff.register_file_i.rf_reg\[614\] net1399
+ _05675_ _02449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19561_ gen_regfile_ff.register_file_i.rf_reg\[615\] _05450_
+ _05675_ _02450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19562_ gen_regfile_ff.register_file_i.rf_reg\[616\] net1392
+ _05675_ _02451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19563_ gen_regfile_ff.register_file_i.rf_reg\[617\] net1388
+ net1478 _02452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput230 net229 instr_addr_o[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19565_ gen_regfile_ff.register_file_i.rf_reg\[618\] net1381
+ net1478 _02453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19566_ gen_regfile_ff.register_file_i.rf_reg\[619\] net1376
+ _05675_ _02454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19567_ net1363 gen_regfile_ff.register_file_i.rf_reg\[61\]
+ net1489 _02455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19568_ gen_regfile_ff.register_file_i.rf_reg\[620\] net1375
+ net1478 _02456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19569_ gen_regfile_ff.register_file_i.rf_reg\[621\] net1377
+ net1479 _02457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19570_ gen_regfile_ff.register_file_i.rf_reg\[622\] net1371
+ net1478 _02458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19571_ gen_regfile_ff.register_file_i.rf_reg\[623\] net1374
+ net1479 _02459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19572_ gen_regfile_ff.register_file_i.rf_reg\[624\] net1370
+ net1479 _02460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19573_ gen_regfile_ff.register_file_i.rf_reg\[625\] net1362
+ net1478 _02461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19574_ gen_regfile_ff.register_file_i.rf_reg\[626\] net1368
+ net1479 _02462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19575_ gen_regfile_ff.register_file_i.rf_reg\[627\] net1366
+ _05675_ _02463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput229 net228 instr_addr_o[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19577_ gen_regfile_ff.register_file_i.rf_reg\[628\] net1354
+ _05675_ _02464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19578_ gen_regfile_ff.register_file_i.rf_reg\[629\] net1360
+ net1478 _02465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19579_ net1349 gen_regfile_ff.register_file_i.rf_reg\[62\]
+ net1489 _02466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19580_ gen_regfile_ff.register_file_i.rf_reg\[630\] net2471
+ net1479 _02467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19581_ gen_regfile_ff.register_file_i.rf_reg\[631\] net1353
+ net1479 _02468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19582_ gen_regfile_ff.register_file_i.rf_reg\[632\] net1352
+ net1478 _02469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19583_ gen_regfile_ff.register_file_i.rf_reg\[633\] net1356
+ net1479 _02470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19584_ gen_regfile_ff.register_file_i.rf_reg\[634\] net1351
+ _05675_ _02471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19585_ gen_regfile_ff.register_file_i.rf_reg\[635\] net1364
+ net1479 _02472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19586_ gen_regfile_ff.register_file_i.rf_reg\[636\] net1350
+ _05675_ _02473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19587_ gen_regfile_ff.register_file_i.rf_reg\[637\] net1363
+ net1479 _02474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19588_ gen_regfile_ff.register_file_i.rf_reg\[638\] net1349
+ net1479 _02475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19589_ gen_regfile_ff.register_file_i.rf_reg\[639\] net1348
+ net1478 _02476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19590_ net1348 gen_regfile_ff.register_file_i.rf_reg\[63\]
+ net1489 _02477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19591_ _05500_ _05627_ _05679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xoutput228 net227 instr_addr_o[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19593_ net1379 gen_regfile_ff.register_file_i.rf_reg\[640\]
+ _05679_ _02478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19594_ net1453 gen_regfile_ff.register_file_i.rf_reg\[641\]
+ _05679_ _02479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19595_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[642\]
+ _05679_ _02480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19596_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[643\]
+ net1477 _02481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19597_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[644\]
+ _05679_ _02482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19598_ net1396 gen_regfile_ff.register_file_i.rf_reg\[645\]
+ net1477 _02483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19599_ net1399 gen_regfile_ff.register_file_i.rf_reg\[646\]
+ _05679_ _02484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19600_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[647\]
+ net1477 _02485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19601_ net1392 gen_regfile_ff.register_file_i.rf_reg\[648\]
+ net1477 _02486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19602_ net1388 gen_regfile_ff.register_file_i.rf_reg\[649\]
+ _05679_ _02487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19603_ _09518_ _05578_ _05681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput227 net226 instr_addr_o[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19605_ gen_regfile_ff.register_file_i.rf_reg\[64\] net1379
+ _05681_ _02488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput226 net225 instr_addr_o[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19607_ net1381 gen_regfile_ff.register_file_i.rf_reg\[650\]
+ _05679_ _02489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19608_ net1376 gen_regfile_ff.register_file_i.rf_reg\[651\]
+ _05679_ _02490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19609_ net1375 gen_regfile_ff.register_file_i.rf_reg\[652\]
+ _05679_ _02491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19610_ net1377 gen_regfile_ff.register_file_i.rf_reg\[653\]
+ net1477 _02492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19611_ net1371 gen_regfile_ff.register_file_i.rf_reg\[654\]
+ _05679_ _02493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19612_ net1374 gen_regfile_ff.register_file_i.rf_reg\[655\]
+ _05679_ _02494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19613_ net1370 gen_regfile_ff.register_file_i.rf_reg\[656\]
+ net1477 _02495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19614_ net1362 gen_regfile_ff.register_file_i.rf_reg\[657\]
+ _05679_ _02496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19615_ net1368 gen_regfile_ff.register_file_i.rf_reg\[658\]
+ net1477 _02497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19616_ net1366 gen_regfile_ff.register_file_i.rf_reg\[659\]
+ net1477 _02498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19617_ gen_regfile_ff.register_file_i.rf_reg\[65\] net1453
+ _05681_ _02499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput225 net224 instr_addr_o[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19619_ net1354 gen_regfile_ff.register_file_i.rf_reg\[660\]
+ net1477 _02500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19620_ net1360 gen_regfile_ff.register_file_i.rf_reg\[661\]
+ _05679_ _02501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19621_ net2472 gen_regfile_ff.register_file_i.rf_reg\[662\]
+ net1477 _02502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19622_ net1353 gen_regfile_ff.register_file_i.rf_reg\[663\]
+ net1477 _02503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19623_ net1352 gen_regfile_ff.register_file_i.rf_reg\[664\]
+ _05679_ _02504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19624_ net1356 gen_regfile_ff.register_file_i.rf_reg\[665\]
+ net1477 _02505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19625_ net1351 gen_regfile_ff.register_file_i.rf_reg\[666\]
+ net1477 _02506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19626_ net1364 gen_regfile_ff.register_file_i.rf_reg\[667\]
+ net1477 _02507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19627_ net2470 gen_regfile_ff.register_file_i.rf_reg\[668\]
+ net1477 _02508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19628_ net1363 gen_regfile_ff.register_file_i.rf_reg\[669\]
+ net1477 _02509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19629_ gen_regfile_ff.register_file_i.rf_reg\[66\] _05543_
+ _05681_ _02510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19630_ net1349 gen_regfile_ff.register_file_i.rf_reg\[670\]
+ net1477 _02511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19631_ net1348 gen_regfile_ff.register_file_i.rf_reg\[671\]
+ net1477 _02512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19632_ _05500_ _05633_ _05685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput224 net223 data_we_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19634_ gen_regfile_ff.register_file_i.rf_reg\[672\] net1379
+ _05685_ _02513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19635_ gen_regfile_ff.register_file_i.rf_reg\[673\] net1453
+ _05685_ _02514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19636_ gen_regfile_ff.register_file_i.rf_reg\[674\] _05543_
+ _05685_ _02515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19637_ gen_regfile_ff.register_file_i.rf_reg\[675\] _05565_
+ net1474 _02516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19638_ gen_regfile_ff.register_file_i.rf_reg\[676\] _05042_
+ _05685_ _02517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19639_ gen_regfile_ff.register_file_i.rf_reg\[677\] net1396
+ net1474 _02518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19640_ gen_regfile_ff.register_file_i.rf_reg\[678\] net1399
+ _05685_ _02519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19641_ gen_regfile_ff.register_file_i.rf_reg\[679\] _05450_
+ net1474 _02520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19642_ gen_regfile_ff.register_file_i.rf_reg\[67\] _05565_
+ net1475 _02521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19643_ gen_regfile_ff.register_file_i.rf_reg\[680\] net1392
+ net1474 _02522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19644_ gen_regfile_ff.register_file_i.rf_reg\[681\] net1388
+ _05685_ _02523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput223 net222 data_wdata_o[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19646_ gen_regfile_ff.register_file_i.rf_reg\[682\] net1381
+ _05685_ _02524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19647_ gen_regfile_ff.register_file_i.rf_reg\[683\] net1376
+ _05685_ _02525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19648_ gen_regfile_ff.register_file_i.rf_reg\[684\] net1375
+ _05685_ _02526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19649_ gen_regfile_ff.register_file_i.rf_reg\[685\] net1377
+ net1474 _02527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19650_ gen_regfile_ff.register_file_i.rf_reg\[686\] net1371
+ _05685_ _02528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19651_ gen_regfile_ff.register_file_i.rf_reg\[687\] net1374
+ _05685_ _02529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19652_ gen_regfile_ff.register_file_i.rf_reg\[688\] net1370
+ net1474 _02530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19653_ gen_regfile_ff.register_file_i.rf_reg\[689\] net1362
+ _05685_ _02531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19654_ gen_regfile_ff.register_file_i.rf_reg\[68\] _05042_
+ _05681_ _02532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19655_ gen_regfile_ff.register_file_i.rf_reg\[690\] net1368
+ net1474 _02533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19656_ gen_regfile_ff.register_file_i.rf_reg\[691\] net1366
+ net1474 _02534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput222 net221 data_wdata_o[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19658_ gen_regfile_ff.register_file_i.rf_reg\[692\] net1354
+ net1474 _02535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19659_ gen_regfile_ff.register_file_i.rf_reg\[693\] net1360
+ _05685_ _02536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19660_ gen_regfile_ff.register_file_i.rf_reg\[694\] net2471
+ net1474 _02537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19661_ gen_regfile_ff.register_file_i.rf_reg\[695\] net1353
+ net1474 _02538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19662_ gen_regfile_ff.register_file_i.rf_reg\[696\] net1352
+ _05685_ _02539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19663_ gen_regfile_ff.register_file_i.rf_reg\[697\] net1356
+ net1474 _02540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19664_ gen_regfile_ff.register_file_i.rf_reg\[698\] net1351
+ net1474 _02541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19665_ gen_regfile_ff.register_file_i.rf_reg\[699\] net1364
+ net1474 _02542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19666_ gen_regfile_ff.register_file_i.rf_reg\[69\] net1396
+ _05681_ _02543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19667_ gen_regfile_ff.register_file_i.rf_reg\[700\] net2470
+ net1474 _02544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19668_ gen_regfile_ff.register_file_i.rf_reg\[701\] net1363
+ net1474 _02545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19669_ gen_regfile_ff.register_file_i.rf_reg\[702\] net1349
+ net1474 _02546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19670_ gen_regfile_ff.register_file_i.rf_reg\[703\] net1348
+ net1474 _02547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19671_ _05500_ _05663_ _05689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput221 net220 data_wdata_o[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19673_ gen_regfile_ff.register_file_i.rf_reg\[704\] net1379
+ net1473 _02548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19674_ gen_regfile_ff.register_file_i.rf_reg\[705\] net1453
+ net1473 _02549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19675_ gen_regfile_ff.register_file_i.rf_reg\[706\] _05543_
+ net1473 _02550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19676_ gen_regfile_ff.register_file_i.rf_reg\[707\] _05565_
+ net1473 _02551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19677_ gen_regfile_ff.register_file_i.rf_reg\[708\] _05042_
+ net1473 _02552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19678_ gen_regfile_ff.register_file_i.rf_reg\[709\] net1396
+ net1473 _02553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19679_ gen_regfile_ff.register_file_i.rf_reg\[70\] net1399
+ _05681_ _02554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19680_ gen_regfile_ff.register_file_i.rf_reg\[710\] net1399
+ net1473 _02555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19681_ gen_regfile_ff.register_file_i.rf_reg\[711\] _05450_
+ net1473 _02556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19682_ gen_regfile_ff.register_file_i.rf_reg\[712\] net1392
+ net1473 _02557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19683_ gen_regfile_ff.register_file_i.rf_reg\[713\] net1388
+ net1473 _02558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput220 net219 data_wdata_o[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19685_ gen_regfile_ff.register_file_i.rf_reg\[714\] net1381
+ net1473 _02559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19686_ gen_regfile_ff.register_file_i.rf_reg\[715\] net1376
+ net1473 _02560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19687_ gen_regfile_ff.register_file_i.rf_reg\[716\] net1375
+ net1473 _02561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19688_ gen_regfile_ff.register_file_i.rf_reg\[717\] net1377
+ net1473 _02562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19689_ gen_regfile_ff.register_file_i.rf_reg\[718\] net1371
+ net1473 _02563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19690_ gen_regfile_ff.register_file_i.rf_reg\[719\] net1374
+ net1473 _02564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19691_ gen_regfile_ff.register_file_i.rf_reg\[71\] _05450_
+ _05681_ _02565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19692_ gen_regfile_ff.register_file_i.rf_reg\[720\] net1370
+ net1473 _02566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19693_ gen_regfile_ff.register_file_i.rf_reg\[721\] net1362
+ net1473 _02567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19694_ gen_regfile_ff.register_file_i.rf_reg\[722\] net1368
+ net1473 _02568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19695_ gen_regfile_ff.register_file_i.rf_reg\[723\] net1366
+ net1473 _02569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput219 net218 data_wdata_o[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19697_ gen_regfile_ff.register_file_i.rf_reg\[724\] net1354
+ net1473 _02570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19698_ gen_regfile_ff.register_file_i.rf_reg\[725\] net1360
+ net1473 _02571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19699_ gen_regfile_ff.register_file_i.rf_reg\[726\] net2471
+ net1473 _02572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19700_ gen_regfile_ff.register_file_i.rf_reg\[727\] net1353
+ net1473 _02573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19701_ gen_regfile_ff.register_file_i.rf_reg\[728\] net1352
+ net1473 _02574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19702_ gen_regfile_ff.register_file_i.rf_reg\[729\] net1356
+ net1473 _02575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19703_ gen_regfile_ff.register_file_i.rf_reg\[72\] net1392
+ net1475 _02576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19704_ gen_regfile_ff.register_file_i.rf_reg\[730\] net1351
+ net1473 _02577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19705_ gen_regfile_ff.register_file_i.rf_reg\[731\] net1364
+ net1473 _02578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19706_ gen_regfile_ff.register_file_i.rf_reg\[732\] net2494
+ net1473 _02579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19707_ gen_regfile_ff.register_file_i.rf_reg\[733\] net1363
+ net1473 _02580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19708_ gen_regfile_ff.register_file_i.rf_reg\[734\] net1349
+ net1473 _02581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19709_ gen_regfile_ff.register_file_i.rf_reg\[735\] net1348
+ net1473 _02582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19710_ _04696_ _05500_ _05693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xoutput218 net217 data_wdata_o[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19712_ net1379 gen_regfile_ff.register_file_i.rf_reg\[736\]
+ _05693_ _02583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19713_ net1453 gen_regfile_ff.register_file_i.rf_reg\[737\]
+ _05693_ _02584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19714_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[738\]
+ _05693_ _02585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19715_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[739\]
+ net1472 _02586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19716_ gen_regfile_ff.register_file_i.rf_reg\[73\] net1388
+ net1475 _02587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19717_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[740\]
+ _05693_ _02588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19718_ net1396 gen_regfile_ff.register_file_i.rf_reg\[741\]
+ net1472 _02589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19719_ net1399 gen_regfile_ff.register_file_i.rf_reg\[742\]
+ _05693_ _02590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19720_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[743\]
+ net1472 _02591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19721_ net1392 gen_regfile_ff.register_file_i.rf_reg\[744\]
+ net1472 _02592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19722_ net1388 gen_regfile_ff.register_file_i.rf_reg\[745\]
+ _05693_ _02593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput217 net216 data_wdata_o[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19724_ net1381 gen_regfile_ff.register_file_i.rf_reg\[746\]
+ _05693_ _02594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19725_ net1376 gen_regfile_ff.register_file_i.rf_reg\[747\]
+ _05693_ _02595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19726_ net1375 gen_regfile_ff.register_file_i.rf_reg\[748\]
+ _05693_ _02596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19727_ net1377 gen_regfile_ff.register_file_i.rf_reg\[749\]
+ net1472 _02597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput216 net215 data_wdata_o[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19729_ gen_regfile_ff.register_file_i.rf_reg\[74\] net1381
+ net1475 _02598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19730_ net1371 gen_regfile_ff.register_file_i.rf_reg\[750\]
+ net1472 _02599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19731_ net1374 gen_regfile_ff.register_file_i.rf_reg\[751\]
+ net1472 _02600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19732_ net1370 gen_regfile_ff.register_file_i.rf_reg\[752\]
+ net1472 _02601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19733_ net1362 gen_regfile_ff.register_file_i.rf_reg\[753\]
+ _05693_ _02602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19734_ net1368 gen_regfile_ff.register_file_i.rf_reg\[754\]
+ net1472 _02603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19735_ net1366 gen_regfile_ff.register_file_i.rf_reg\[755\]
+ net1472 _02604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput215 net214 data_wdata_o[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19737_ net1354 gen_regfile_ff.register_file_i.rf_reg\[756\]
+ net1472 _02605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19738_ net1360 gen_regfile_ff.register_file_i.rf_reg\[757\]
+ net1472 _02606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19739_ net2472 gen_regfile_ff.register_file_i.rf_reg\[758\]
+ net1472 _02607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19740_ net1353 gen_regfile_ff.register_file_i.rf_reg\[759\]
+ net1472 _02608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19741_ gen_regfile_ff.register_file_i.rf_reg\[75\] net1376
+ _05681_ _02609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19742_ net1352 gen_regfile_ff.register_file_i.rf_reg\[760\]
+ net1472 _02610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19743_ net1356 gen_regfile_ff.register_file_i.rf_reg\[761\]
+ net1472 _02611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19744_ net1351 gen_regfile_ff.register_file_i.rf_reg\[762\]
+ net1472 _02612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19745_ net1364 gen_regfile_ff.register_file_i.rf_reg\[763\]
+ net1472 _02613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19746_ net2470 gen_regfile_ff.register_file_i.rf_reg\[764\]
+ net1472 _02614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19747_ net1363 gen_regfile_ff.register_file_i.rf_reg\[765\]
+ net1472 _02615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19748_ net1349 gen_regfile_ff.register_file_i.rf_reg\[766\]
+ net1472 _02616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19749_ net1348 gen_regfile_ff.register_file_i.rf_reg\[767\]
+ net1472 _02617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19750_ _05591_ _05627_ _05698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput214 net213 data_wdata_o[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19752_ gen_regfile_ff.register_file_i.rf_reg\[768\] net1379
+ net1470 _02618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19753_ gen_regfile_ff.register_file_i.rf_reg\[769\] net1453
+ net1470 _02619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19754_ gen_regfile_ff.register_file_i.rf_reg\[76\] net1375
+ net1475 _02620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19755_ gen_regfile_ff.register_file_i.rf_reg\[770\] _05543_
+ net1470 _02621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19756_ gen_regfile_ff.register_file_i.rf_reg\[771\] _05565_
+ net1471 _02622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19757_ gen_regfile_ff.register_file_i.rf_reg\[772\] _05042_
+ net1470 _02623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19758_ gen_regfile_ff.register_file_i.rf_reg\[773\] net1396
+ net1471 _02624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19759_ gen_regfile_ff.register_file_i.rf_reg\[774\] net1399
+ net1470 _02625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19760_ gen_regfile_ff.register_file_i.rf_reg\[775\] _05450_
+ net1471 _02626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19761_ gen_regfile_ff.register_file_i.rf_reg\[776\] net1392
+ net1471 _02627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19762_ gen_regfile_ff.register_file_i.rf_reg\[777\] net1388
+ net1470 _02628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput213 net212 data_wdata_o[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19764_ gen_regfile_ff.register_file_i.rf_reg\[778\] net1381
+ net1471 _02629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19765_ gen_regfile_ff.register_file_i.rf_reg\[779\] net1376
+ net1470 _02630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19766_ gen_regfile_ff.register_file_i.rf_reg\[77\] net1377
+ net1475 _02631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19767_ gen_regfile_ff.register_file_i.rf_reg\[780\] net1375
+ net1470 _02632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19768_ gen_regfile_ff.register_file_i.rf_reg\[781\] net1377
+ net1471 _02633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19769_ gen_regfile_ff.register_file_i.rf_reg\[782\] net1371
+ net1470 _02634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19770_ gen_regfile_ff.register_file_i.rf_reg\[783\] net1374
+ net1471 _02635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19771_ gen_regfile_ff.register_file_i.rf_reg\[784\] net1370
+ net1471 _02636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19772_ gen_regfile_ff.register_file_i.rf_reg\[785\] net1362
+ net1470 _02637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19773_ gen_regfile_ff.register_file_i.rf_reg\[786\] net1368
+ net1471 _02638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19774_ gen_regfile_ff.register_file_i.rf_reg\[787\] net1366
+ net1471 _02639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput212 net211 data_wdata_o[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19776_ gen_regfile_ff.register_file_i.rf_reg\[788\] net1354
+ net1471 _02640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19777_ gen_regfile_ff.register_file_i.rf_reg\[789\] net1360
+ net1470 _02641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19778_ gen_regfile_ff.register_file_i.rf_reg\[78\] net1371
+ net1475 _02642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19779_ gen_regfile_ff.register_file_i.rf_reg\[790\] net2473
+ net1471 _02643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19780_ gen_regfile_ff.register_file_i.rf_reg\[791\] net1353
+ net1471 _02644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19781_ gen_regfile_ff.register_file_i.rf_reg\[792\] net1352
+ net1470 _02645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19782_ gen_regfile_ff.register_file_i.rf_reg\[793\] net1356
+ net1471 _02646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19783_ gen_regfile_ff.register_file_i.rf_reg\[794\] net1351
+ net1471 _02647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19784_ gen_regfile_ff.register_file_i.rf_reg\[795\] net1364
+ net1471 _02648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19785_ gen_regfile_ff.register_file_i.rf_reg\[796\] net1350
+ net1471 _02649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19786_ gen_regfile_ff.register_file_i.rf_reg\[797\] net1363
+ net1471 _02650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19787_ gen_regfile_ff.register_file_i.rf_reg\[798\] net1349
+ net1471 _02651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19788_ gen_regfile_ff.register_file_i.rf_reg\[799\] net1348
+ net1471 _02652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19789_ gen_regfile_ff.register_file_i.rf_reg\[79\] net1374
+ net1475 _02653_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19790_ _05591_ _05633_ _05702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xoutput211 net210 data_wdata_o[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19792_ net1379 gen_regfile_ff.register_file_i.rf_reg\[800\]
+ net1469 _02654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19793_ net1453 gen_regfile_ff.register_file_i.rf_reg\[801\]
+ net1469 _02655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19794_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[802\]
+ net1469 _02656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19795_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[803\]
+ net1469 _02657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19796_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[804\]
+ net1469 _02658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19797_ net1396 gen_regfile_ff.register_file_i.rf_reg\[805\]
+ net1469 _02659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19798_ net1399 gen_regfile_ff.register_file_i.rf_reg\[806\]
+ net1469 _02660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19799_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[807\]
+ _05702_ _02661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19800_ net1392 gen_regfile_ff.register_file_i.rf_reg\[808\]
+ _05702_ _02662_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19801_ net1388 gen_regfile_ff.register_file_i.rf_reg\[809\]
+ net1469 _02663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19802_ gen_regfile_ff.register_file_i.rf_reg\[80\] net1370
+ net1476 _02664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput210 net209 data_wdata_o[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19804_ net1381 gen_regfile_ff.register_file_i.rf_reg\[810\]
+ net1469 _02665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19805_ net1376 gen_regfile_ff.register_file_i.rf_reg\[811\]
+ net1469 _02666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19806_ net1375 gen_regfile_ff.register_file_i.rf_reg\[812\]
+ net1469 _02667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19807_ net1377 gen_regfile_ff.register_file_i.rf_reg\[813\]
+ net1469 _02668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19808_ net1371 gen_regfile_ff.register_file_i.rf_reg\[814\]
+ net1469 _02669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19809_ net1374 gen_regfile_ff.register_file_i.rf_reg\[815\]
+ net1469 _02670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19810_ net1370 gen_regfile_ff.register_file_i.rf_reg\[816\]
+ net1469 _02671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19811_ net1362 gen_regfile_ff.register_file_i.rf_reg\[817\]
+ net1469 _02672_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19812_ net1368 gen_regfile_ff.register_file_i.rf_reg\[818\]
+ net1469 _02673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19813_ net1366 gen_regfile_ff.register_file_i.rf_reg\[819\]
+ _05702_ _02674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19814_ gen_regfile_ff.register_file_i.rf_reg\[81\] net1362
+ net1475 _02675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput209 net208 data_wdata_o[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19816_ net1354 gen_regfile_ff.register_file_i.rf_reg\[820\]
+ _05702_ _02676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19817_ net1360 gen_regfile_ff.register_file_i.rf_reg\[821\]
+ net1469 _02677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19818_ net1359 gen_regfile_ff.register_file_i.rf_reg\[822\]
+ net1469 _02678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19819_ net1353 gen_regfile_ff.register_file_i.rf_reg\[823\]
+ net1469 _02679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19820_ net1352 gen_regfile_ff.register_file_i.rf_reg\[824\]
+ net1469 _02680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19821_ net1356 gen_regfile_ff.register_file_i.rf_reg\[825\]
+ net1469 _02681_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19822_ net1351 gen_regfile_ff.register_file_i.rf_reg\[826\]
+ _05702_ _02682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19823_ net1364 gen_regfile_ff.register_file_i.rf_reg\[827\]
+ net1469 _02683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19824_ net2494 gen_regfile_ff.register_file_i.rf_reg\[828\]
+ _05702_ _02684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19825_ net1363 gen_regfile_ff.register_file_i.rf_reg\[829\]
+ net1469 _02685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19826_ gen_regfile_ff.register_file_i.rf_reg\[82\] net1368
+ net1476 _02686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19827_ net1349 gen_regfile_ff.register_file_i.rf_reg\[830\]
+ net1469 _02687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19828_ net1348 gen_regfile_ff.register_file_i.rf_reg\[831\]
+ net1469 _02688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19829_ _05591_ _05663_ _05706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput208 net207 data_wdata_o[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19831_ gen_regfile_ff.register_file_i.rf_reg\[832\] net1379
+ net1467 _02689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19832_ gen_regfile_ff.register_file_i.rf_reg\[833\] net1453
+ net1467 _02690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19833_ gen_regfile_ff.register_file_i.rf_reg\[834\] _05543_
+ net1467 _02691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19834_ gen_regfile_ff.register_file_i.rf_reg\[835\] _05565_
+ net1468 _02692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19835_ gen_regfile_ff.register_file_i.rf_reg\[836\] _05042_
+ net1467 _02693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19836_ gen_regfile_ff.register_file_i.rf_reg\[837\] net1396
+ net1468 _02694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19837_ gen_regfile_ff.register_file_i.rf_reg\[838\] net1399
+ net1467 _02695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19838_ gen_regfile_ff.register_file_i.rf_reg\[839\] _05450_
+ net1468 _02696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19839_ gen_regfile_ff.register_file_i.rf_reg\[83\] net1366
+ net1476 _02697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19840_ gen_regfile_ff.register_file_i.rf_reg\[840\] net1392
+ net1468 _02698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19841_ gen_regfile_ff.register_file_i.rf_reg\[841\] net1388
+ net1467 _02699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput207 net206 data_wdata_o[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19843_ gen_regfile_ff.register_file_i.rf_reg\[842\] net1381
+ net1468 _02700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19844_ gen_regfile_ff.register_file_i.rf_reg\[843\] net1376
+ net1467 _02701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19845_ gen_regfile_ff.register_file_i.rf_reg\[844\] net1375
+ net1467 _02702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19846_ gen_regfile_ff.register_file_i.rf_reg\[845\] net1377
+ net1468 _02703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19847_ gen_regfile_ff.register_file_i.rf_reg\[846\] net1371
+ net1467 _02704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19848_ gen_regfile_ff.register_file_i.rf_reg\[847\] net1374
+ net1467 _02705_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19849_ gen_regfile_ff.register_file_i.rf_reg\[848\] net1370
+ net1468 _02706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19850_ gen_regfile_ff.register_file_i.rf_reg\[849\] net1362
+ net1467 _02707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput206 net205 data_wdata_o[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19852_ gen_regfile_ff.register_file_i.rf_reg\[84\] net1354
+ net1476 _02708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19853_ gen_regfile_ff.register_file_i.rf_reg\[850\] net1368
+ net1468 _02709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19854_ gen_regfile_ff.register_file_i.rf_reg\[851\] net1366
+ net1468 _02710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput205 net204 data_wdata_o[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19856_ gen_regfile_ff.register_file_i.rf_reg\[852\] net1354
+ net1468 _02711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19857_ gen_regfile_ff.register_file_i.rf_reg\[853\] net1360
+ net1467 _02712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19858_ gen_regfile_ff.register_file_i.rf_reg\[854\] net1359
+ net1468 _02713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19859_ gen_regfile_ff.register_file_i.rf_reg\[855\] net1353
+ net1468 _02714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19860_ gen_regfile_ff.register_file_i.rf_reg\[856\] net1352
+ net1467 _02715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19861_ gen_regfile_ff.register_file_i.rf_reg\[857\] net1356
+ net1468 _02716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19862_ gen_regfile_ff.register_file_i.rf_reg\[858\] net1351
+ net1468 _02717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19863_ gen_regfile_ff.register_file_i.rf_reg\[859\] net1364
+ net1468 _02718_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19864_ gen_regfile_ff.register_file_i.rf_reg\[85\] net1360
+ net1475 _02719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19865_ gen_regfile_ff.register_file_i.rf_reg\[860\] net2494
+ net1468 _02720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19866_ gen_regfile_ff.register_file_i.rf_reg\[861\] net1363
+ net1468 _02721_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19867_ gen_regfile_ff.register_file_i.rf_reg\[862\] net1349
+ net1468 _02722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19868_ gen_regfile_ff.register_file_i.rf_reg\[863\] net1348
+ net1468 _02723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19869_ _04696_ _05591_ _05711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput204 net203 data_wdata_o[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19871_ gen_regfile_ff.register_file_i.rf_reg\[864\] net1379
+ net1465 _02724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19872_ gen_regfile_ff.register_file_i.rf_reg\[865\] net1453
+ net1465 _02725_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19873_ gen_regfile_ff.register_file_i.rf_reg\[866\] _05543_
+ net1465 _02726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19874_ gen_regfile_ff.register_file_i.rf_reg\[867\] _05565_
+ net1466 _02727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19875_ gen_regfile_ff.register_file_i.rf_reg\[868\] _05042_
+ net1465 _02728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19876_ gen_regfile_ff.register_file_i.rf_reg\[869\] net1396
+ net1466 _02729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19877_ gen_regfile_ff.register_file_i.rf_reg\[86\] net2472
+ net1475 _02730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19878_ gen_regfile_ff.register_file_i.rf_reg\[870\] net1399
+ net1465 _02731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19879_ gen_regfile_ff.register_file_i.rf_reg\[871\] _05450_
+ _05711_ _02732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19880_ gen_regfile_ff.register_file_i.rf_reg\[872\] net1392
+ _05711_ _02733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19881_ gen_regfile_ff.register_file_i.rf_reg\[873\] net1388
+ net1465 _02734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput203 net202 data_wdata_o[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19883_ gen_regfile_ff.register_file_i.rf_reg\[874\] net1381
+ net1466 _02735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19884_ gen_regfile_ff.register_file_i.rf_reg\[875\] net1376
+ net1465 _02736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19885_ gen_regfile_ff.register_file_i.rf_reg\[876\] net1375
+ net1465 _02737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19886_ gen_regfile_ff.register_file_i.rf_reg\[877\] net1377
+ net1466 _02738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19887_ gen_regfile_ff.register_file_i.rf_reg\[878\] net1371
+ net1465 _02739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19888_ gen_regfile_ff.register_file_i.rf_reg\[879\] net1374
+ net1466 _02740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19889_ gen_regfile_ff.register_file_i.rf_reg\[87\] net1353
+ net1476 _02741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19890_ gen_regfile_ff.register_file_i.rf_reg\[880\] net1370
+ net1466 _02742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19891_ gen_regfile_ff.register_file_i.rf_reg\[881\] net1362
+ net1465 _02743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19892_ gen_regfile_ff.register_file_i.rf_reg\[882\] net1368
+ net1466 _02744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19893_ gen_regfile_ff.register_file_i.rf_reg\[883\] net1366
+ _05711_ _02745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput202 net201 data_wdata_o[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19895_ gen_regfile_ff.register_file_i.rf_reg\[884\] net1354
+ _05711_ _02746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19896_ gen_regfile_ff.register_file_i.rf_reg\[885\] net1360
+ net1465 _02747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19897_ gen_regfile_ff.register_file_i.rf_reg\[886\] net1359
+ net1466 _02748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19898_ gen_regfile_ff.register_file_i.rf_reg\[887\] net1353
+ net1466 _02749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19899_ gen_regfile_ff.register_file_i.rf_reg\[888\] net1352
+ net1465 _02750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19900_ gen_regfile_ff.register_file_i.rf_reg\[889\] net1356
+ net1466 _02751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19901_ gen_regfile_ff.register_file_i.rf_reg\[88\] net1352
+ net1475 _02752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19902_ gen_regfile_ff.register_file_i.rf_reg\[890\] net1351
+ _05711_ _02753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19903_ gen_regfile_ff.register_file_i.rf_reg\[891\] net1364
+ net1466 _02754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19904_ gen_regfile_ff.register_file_i.rf_reg\[892\] net1350
+ _05711_ _02755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19905_ gen_regfile_ff.register_file_i.rf_reg\[893\] net1363
+ net1466 _02756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19906_ gen_regfile_ff.register_file_i.rf_reg\[894\] net1349
+ net1466 _02757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19907_ gen_regfile_ff.register_file_i.rf_reg\[895\] net1348
+ _05711_ _02758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19908_ _04691_ _05627_ _05715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput201 net200 data_wdata_o[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19910_ gen_regfile_ff.register_file_i.rf_reg\[896\] net1379
+ net1463 _02759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19911_ gen_regfile_ff.register_file_i.rf_reg\[897\] net1453
+ net1463 _02760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19912_ gen_regfile_ff.register_file_i.rf_reg\[898\] _05543_
+ net1463 _02761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19913_ gen_regfile_ff.register_file_i.rf_reg\[899\] _05565_
+ net1464 _02762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19914_ gen_regfile_ff.register_file_i.rf_reg\[89\] net1356
+ net1476 _02763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19915_ gen_regfile_ff.register_file_i.rf_reg\[900\] _05042_
+ net1463 _02764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19916_ gen_regfile_ff.register_file_i.rf_reg\[901\] net1396
+ net1464 _02765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19917_ gen_regfile_ff.register_file_i.rf_reg\[902\] net1399
+ net1463 _02766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19918_ gen_regfile_ff.register_file_i.rf_reg\[903\] _05450_
+ net1464 _02767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19919_ gen_regfile_ff.register_file_i.rf_reg\[904\] net1392
+ net1464 _02768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19920_ gen_regfile_ff.register_file_i.rf_reg\[905\] net1388
+ net1463 _02769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput200 net199 data_wdata_o[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19922_ gen_regfile_ff.register_file_i.rf_reg\[906\] net1381
+ net1464 _02770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19923_ gen_regfile_ff.register_file_i.rf_reg\[907\] net1376
+ net1463 _02771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19924_ gen_regfile_ff.register_file_i.rf_reg\[908\] net1375
+ net1463 _02772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19925_ gen_regfile_ff.register_file_i.rf_reg\[909\] net1377
+ net1464 _02773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19926_ gen_regfile_ff.register_file_i.rf_reg\[90\] net1351
+ net1476 _02774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19927_ gen_regfile_ff.register_file_i.rf_reg\[910\] net1371
+ net1463 _02775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19928_ gen_regfile_ff.register_file_i.rf_reg\[911\] net1374
+ net1464 _02776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19929_ gen_regfile_ff.register_file_i.rf_reg\[912\] net1370
+ net1464 _02777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19930_ gen_regfile_ff.register_file_i.rf_reg\[913\] net1362
+ net1463 _02778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19931_ gen_regfile_ff.register_file_i.rf_reg\[914\] net1368
+ net1464 _02779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19932_ gen_regfile_ff.register_file_i.rf_reg\[915\] net1366
+ net1464 _02780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput199 net198 data_wdata_o[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19934_ gen_regfile_ff.register_file_i.rf_reg\[916\] net1354
+ net1464 _02781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19935_ gen_regfile_ff.register_file_i.rf_reg\[917\] net1360
+ net1463 _02782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19936_ gen_regfile_ff.register_file_i.rf_reg\[918\] net1359
+ net1464 _02783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19937_ gen_regfile_ff.register_file_i.rf_reg\[919\] net1353
+ net1464 _02784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19938_ gen_regfile_ff.register_file_i.rf_reg\[91\] net1364
+ net1476 _02785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19939_ gen_regfile_ff.register_file_i.rf_reg\[920\] net1352
+ net1463 _02786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19940_ gen_regfile_ff.register_file_i.rf_reg\[921\] net1356
+ net1464 _02787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19941_ gen_regfile_ff.register_file_i.rf_reg\[922\] net1351
+ net1464 _02788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19942_ gen_regfile_ff.register_file_i.rf_reg\[923\] net1364
+ net1464 _02789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19943_ gen_regfile_ff.register_file_i.rf_reg\[924\] net1350
+ net1464 _02790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19944_ gen_regfile_ff.register_file_i.rf_reg\[925\] net1363
+ net1464 _02791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19945_ gen_regfile_ff.register_file_i.rf_reg\[926\] net1349
+ net1464 _02792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19946_ gen_regfile_ff.register_file_i.rf_reg\[927\] net1348
+ net1464 _02793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19947_ _04691_ _05633_ _05719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_4
Xoutput198 net197 data_wdata_o[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19949_ gen_regfile_ff.register_file_i.rf_reg\[928\] net1379
+ _05719_ _02794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19950_ gen_regfile_ff.register_file_i.rf_reg\[929\] net1453
+ _05719_ _02795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19951_ gen_regfile_ff.register_file_i.rf_reg\[92\] net2470
+ net1476 _02796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19952_ gen_regfile_ff.register_file_i.rf_reg\[930\] _05543_
+ net1461 _02797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19953_ gen_regfile_ff.register_file_i.rf_reg\[931\] _05565_
+ net1461 _02798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19954_ gen_regfile_ff.register_file_i.rf_reg\[932\] _05042_
+ _05719_ _02799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19955_ gen_regfile_ff.register_file_i.rf_reg\[933\] net1396
+ net1461 _02800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19956_ gen_regfile_ff.register_file_i.rf_reg\[934\] net1399
+ _05719_ _02801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19957_ gen_regfile_ff.register_file_i.rf_reg\[935\] _05450_
+ net1462 _02802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19958_ gen_regfile_ff.register_file_i.rf_reg\[936\] net1392
+ net1462 _02803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19959_ gen_regfile_ff.register_file_i.rf_reg\[937\] net1388
+ net1461 _02804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput197 net196 data_wdata_o[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19961_ gen_regfile_ff.register_file_i.rf_reg\[938\] net1381
+ net1461 _02805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19962_ gen_regfile_ff.register_file_i.rf_reg\[939\] net1376
+ _05719_ _02806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19963_ gen_regfile_ff.register_file_i.rf_reg\[93\] net1363
+ net1476 _02807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19964_ gen_regfile_ff.register_file_i.rf_reg\[940\] net1375
+ net1461 _02808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19965_ gen_regfile_ff.register_file_i.rf_reg\[941\] net1377
+ net1462 _02809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19966_ gen_regfile_ff.register_file_i.rf_reg\[942\] net1371
+ net1461 _02810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19967_ gen_regfile_ff.register_file_i.rf_reg\[943\] net1374
+ net1461 _02811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19968_ gen_regfile_ff.register_file_i.rf_reg\[944\] net1370
+ net1462 _02812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19969_ gen_regfile_ff.register_file_i.rf_reg\[945\] net1362
+ net1461 _02813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19970_ gen_regfile_ff.register_file_i.rf_reg\[946\] net1368
+ net1462 _02814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19971_ gen_regfile_ff.register_file_i.rf_reg\[947\] net1366
+ net1462 _02815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput196 net195 data_wdata_o[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19973_ gen_regfile_ff.register_file_i.rf_reg\[948\] net1354
+ net1462 _02816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19974_ gen_regfile_ff.register_file_i.rf_reg\[949\] net1360
+ net1461 _02817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19975_ gen_regfile_ff.register_file_i.rf_reg\[94\] net1349
+ net1476 _02818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19976_ gen_regfile_ff.register_file_i.rf_reg\[950\] net2471
+ net1461 _02819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19977_ gen_regfile_ff.register_file_i.rf_reg\[951\] net1353
+ net1462 _02820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19978_ gen_regfile_ff.register_file_i.rf_reg\[952\] net1352
+ net1461 _02821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19979_ gen_regfile_ff.register_file_i.rf_reg\[953\] net1356
+ net1461 _02822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19980_ gen_regfile_ff.register_file_i.rf_reg\[954\] net1351
+ net1462 _02823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19981_ gen_regfile_ff.register_file_i.rf_reg\[955\] net1364
+ net1461 _02824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19982_ gen_regfile_ff.register_file_i.rf_reg\[956\] net2494
+ net1462 _02825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19983_ gen_regfile_ff.register_file_i.rf_reg\[957\] net1363
+ net1462 _02826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19984_ gen_regfile_ff.register_file_i.rf_reg\[958\] net1349
+ net1462 _02827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19985_ gen_regfile_ff.register_file_i.rf_reg\[959\] net1348
+ _05719_ _02828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19986_ gen_regfile_ff.register_file_i.rf_reg\[95\] net1348
+ _05681_ _02829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19987_ _04691_ _05663_ _05723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xoutput195 net194 data_wdata_o[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_19989_ net1379 gen_regfile_ff.register_file_i.rf_reg\[960\]
+ _05723_ _02830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19990_ net1453 gen_regfile_ff.register_file_i.rf_reg\[961\]
+ _05723_ _02831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19991_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[962\]
+ _05723_ _02832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19992_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[963\]
+ net1460 _02833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19993_ _05042_ gen_regfile_ff.register_file_i.rf_reg\[964\]
+ _05723_ _02834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19994_ net1396 gen_regfile_ff.register_file_i.rf_reg\[965\]
+ net1460 _02835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19995_ net1399 gen_regfile_ff.register_file_i.rf_reg\[966\]
+ _05723_ _02836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19996_ _05450_ gen_regfile_ff.register_file_i.rf_reg\[967\]
+ net1460 _02837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19997_ net1392 gen_regfile_ff.register_file_i.rf_reg\[968\]
+ net1460 _02838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19998_ net1388 gen_regfile_ff.register_file_i.rf_reg\[969\]
+ _05723_ _02839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_19999_ net1379 gen_regfile_ff.register_file_i.rf_reg\[96\]
+ net1496 _02840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput194 net193 data_wdata_o[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20001_ net1381 gen_regfile_ff.register_file_i.rf_reg\[970\]
+ net1460 _02841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20002_ net1376 gen_regfile_ff.register_file_i.rf_reg\[971\]
+ _05723_ _02842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20003_ net1375 gen_regfile_ff.register_file_i.rf_reg\[972\]
+ _05723_ _02843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20004_ net1377 gen_regfile_ff.register_file_i.rf_reg\[973\]
+ net1460 _02844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20005_ net1371 gen_regfile_ff.register_file_i.rf_reg\[974\]
+ _05723_ _02845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20006_ net1374 gen_regfile_ff.register_file_i.rf_reg\[975\]
+ _05723_ _02846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20007_ net1370 gen_regfile_ff.register_file_i.rf_reg\[976\]
+ net1460 _02847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20008_ net1362 gen_regfile_ff.register_file_i.rf_reg\[977\]
+ _05723_ _02848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20009_ net1368 gen_regfile_ff.register_file_i.rf_reg\[978\]
+ net1460 _02849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20010_ net1366 gen_regfile_ff.register_file_i.rf_reg\[979\]
+ net1460 _02850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20011_ net1453 gen_regfile_ff.register_file_i.rf_reg\[97\]
+ net1496 _02851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput193 net192 data_wdata_o[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20013_ net1354 gen_regfile_ff.register_file_i.rf_reg\[980\]
+ net1460 _02852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20014_ net1360 gen_regfile_ff.register_file_i.rf_reg\[981\]
+ _05723_ _02853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20015_ net1359 gen_regfile_ff.register_file_i.rf_reg\[982\]
+ net1460 _02854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20016_ net1353 gen_regfile_ff.register_file_i.rf_reg\[983\]
+ net1460 _02855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20017_ net1352 gen_regfile_ff.register_file_i.rf_reg\[984\]
+ _05723_ _02856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20018_ net1356 gen_regfile_ff.register_file_i.rf_reg\[985\]
+ net1460 _02857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20019_ net1351 gen_regfile_ff.register_file_i.rf_reg\[986\]
+ net1460 _02858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20020_ net1364 gen_regfile_ff.register_file_i.rf_reg\[987\]
+ net1460 _02859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20021_ net1350 gen_regfile_ff.register_file_i.rf_reg\[988\]
+ net1460 _02860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20022_ net1363 gen_regfile_ff.register_file_i.rf_reg\[989\]
+ net1460 _02861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20023_ _05543_ gen_regfile_ff.register_file_i.rf_reg\[98\]
+ net1496 _02862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20024_ net1349 gen_regfile_ff.register_file_i.rf_reg\[990\]
+ net1460 _02863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20025_ net1348 gen_regfile_ff.register_file_i.rf_reg\[991\]
+ net1460 _02864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20026_ gen_regfile_ff.register_file_i.rf_reg\[992\] net1379
+ _04697_ _02865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20027_ gen_regfile_ff.register_file_i.rf_reg\[993\] net1453
+ _04697_ _02866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20028_ gen_regfile_ff.register_file_i.rf_reg\[994\] _05543_
+ net1497 _02867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20029_ gen_regfile_ff.register_file_i.rf_reg\[995\] _05565_
+ net1498 _02868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20030_ gen_regfile_ff.register_file_i.rf_reg\[996\] _05042_
+ _04697_ _02869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20031_ gen_regfile_ff.register_file_i.rf_reg\[997\] net1396
+ _04697_ _02870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20032_ gen_regfile_ff.register_file_i.rf_reg\[998\] net1399
+ _04697_ _02871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20033_ gen_regfile_ff.register_file_i.rf_reg\[999\] _05450_
+ _04697_ _02872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20034_ _05565_ gen_regfile_ff.register_file_i.rf_reg\[99\]
+ net1496 _02873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20035_ _09497_ id_stage_i.controller_i.ctrl_fsm_cs\[1\]
+ _10074_ _05727_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xoutput192 net191 data_wdata_o[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20037_ net1932 _00948_ _09526_ _05729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20038_ _00948_ _05730_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20039_ net1903 _00952_ _05730_ _09638_ _05731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20040_ _05729_ _05731_ _05732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20041_ _07642_ _09533_ _09621_ _05732_ _05733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20042_ _09528_ _09898_ _05734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20043_ _05734_ _09646_ _09658_ _05735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20044_ _09625_ _05733_ _05735_ _05736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20045_ id_stage_i.controller_i.exc_req_d _05736_ _05737_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20046_ id_stage_i.controller_i.instr_valid_i cs_registers_i.dcsr_q\[2\]
+ _05738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20047_ _03900_ _05738_ cs_registers_i.debug_mode_i _05739_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20048_ _05739_ _05740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20049_ net1395 _05740_ _05741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20050_ _05727_ _05737_ _05741_ _05742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20051_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09942_
+ _05743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20052_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _09498_
+ _05744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20053_ _09920_ _05744_ _05745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20054_ _09919_ net1808 _05743_ _05745_ _05746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20055_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] id_stage_i.controller_i.ctrl_fsm_cs\[2\]
+ _05747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20056_ _09617_ _05740_ _05748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20057_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09920_
+ _05748_ _05749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20058_ _09497_ _05747_ _05749_ _09498_ _05750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20059_ net1932 _09905_ _03995_ _05751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20060_ _05740_ _05751_ _05752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20061_ _09499_ _05752_ _05753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20062_ _09528_ _09899_ _09902_ _05754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20063_ _05753_ _05754_ _05755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20064_ _03901_ _05746_ _05750_ _05755_ _05756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20065_ _09942_ net1808 _09941_ _05757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20066_ _03999_ _05736_ _05758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20067_ _05758_ _05759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20068_ _09624_ _09636_ _09616_ _05759_ _05760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_4
X_20069_ _09624_ _09636_ _05759_ _05761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_20070_ _09559_ _09580_ _09583_ _05762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20071_ _09540_ _05758_ _05761_ _05762_ _05763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20072_ _05760_ _05763_ _05764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20073_ _05739_ _05757_ _09617_ _09618_ _05765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20074_ _09497_ _09920_ _05744_ _05766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20075_ _05765_ _05766_ _05767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20076_ _05767_ _05768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20077_ _05727_ _05764_ _05768_ _05769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20078_ net1395 _05769_ _05770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20079_ _09497_ _09618_ _05771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20080_ _05748_ _05771_ _05772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20081_ _05757_ _05770_ _05772_ _05773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_20082_ _05742_ _05756_ _05773_ _02874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20083_ _03436_ net1393 _05757_ _05774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20084_ net1395 _05740_ _05775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20085_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _05774_
+ _05775_ net1809 _05776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20086_ _05760_ _05763_ _05777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_20087_ _05757_ _05748_ _05771_ _05778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20088_ _05753_ _05779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20089_ cs_registers_i.debug_mode_i _09919_ net1808 id_stage_i.controller_i.ctrl_fsm_cs\[0\]
+ _05780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20090_ _09920_ _05744_ _05780_ _05781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20091_ _05779_ _05754_ _05781_ _05782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20092_ net1809 _05777_ _05778_ _05782_ _05783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20093_ _05776_ _05783_ _02875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20094_ _09910_ _05753_ _05754_ _05784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20095_ id_stage_i.controller_i.ctrl_fsm_cs\[3\] _09920_
+ _05740_ _05771_ _05785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20096_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _05785_
+ _05786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20097_ _05744_ _09921_ id_stage_i.controller_i.ctrl_fsm_cs\[0\]
+ _05787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20098_ _05784_ _05786_ _05787_ _05788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20099_ _05737_ _05775_ net1809 _05789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20100_ id_stage_i.controller_i.ctrl_fsm_cs\[2\] _09919_
+ net1808 _05743_ _05790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20101_ _09498_ _05790_ _09921_ _05791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20102_ _05788_ _05789_ _05791_ _02876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20103_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _09910_
+ _05752_ _05792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20104_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _10074_
+ _05748_ _05792_ _05793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20105_ _05727_ _05737_ _05775_ _05793_ _02877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20106_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09919_
+ _09922_ _05794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20107_ _09942_ net1747 _05794_ _02878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20108_ net2038 _09938_ _09943_ _05795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20109_ _09939_ _05795_ net1746 _02879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20110_ _07575_ _09912_ _05796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20111_ _08127_ _03422_ _03402_ _05797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20112_ _05797_ _05484_ _03404_ _05798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20113_ _05796_ _10125_ _03433_ _05798_ _05799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_20114_ _09538_ _09654_ _10125_ _05800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20115_ _09621_ _03433_ _05800_ id_stage_i.id_fsm_q _05801_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20116_ _03403_ _05799_ _05801_ _02880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xoutput191 net190 data_req_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20118_ net1798 alu_adder_result_ex\[0\] net1672 _05803_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20119_ ex_block_i.alu_i.imd_val_q_i\[0\] _05803_ net1548
+ _02881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20120_ net1711 net1451 net1672 _05804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20121_ ex_block_i.alu_i.imd_val_q_i\[10\] _05804_ net1548
+ _02882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20122_ net2158 net1457 net1672 _05805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20123_ ex_block_i.alu_i.imd_val_q_i\[11\] _05805_ net1548
+ _02883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20124_ net2136 net2298 net1672 _05806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20125_ ex_block_i.alu_i.imd_val_q_i\[12\] _05806_ net1548
+ _02884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20126_ net2157 net1450 net1672 _05807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20127_ ex_block_i.alu_i.imd_val_q_i\[13\] _05807_ net1548
+ _02885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20128_ net2192 net2292 net1672 _05808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20129_ ex_block_i.alu_i.imd_val_q_i\[14\] _05808_ net1548
+ _02886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20130_ net2187 net1448 net1672 _05809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20131_ ex_block_i.alu_i.imd_val_q_i\[15\] _05809_ net1548
+ _02887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20132_ net2190 net1446 net1672 _05810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20133_ ex_block_i.alu_i.imd_val_q_i\[16\] _05810_ net1548
+ _02888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20134_ net1769 net2288 net1672 _05811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20135_ ex_block_i.alu_i.imd_val_q_i\[17\] _05811_ net1548
+ _02889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20136_ net1768 net1435 net1672 _05812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput190 net189 data_be_o[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20138_ ex_block_i.alu_i.imd_val_q_i\[18\] _05812_ net1548
+ _02890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput189 net188 data_be_o[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20140_ net1767 net1436 net1672 _05815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20141_ ex_block_i.alu_i.imd_val_q_i\[19\] _05815_ net1548
+ _02891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20142_ net2185 net1539 net1672 _05816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20143_ ex_block_i.alu_i.imd_val_q_i\[1\] _05816_ net1548
+ _02892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20144_ net1766 net2278 net1672 _05817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20145_ ex_block_i.alu_i.imd_val_q_i\[20\] _05817_ net1548
+ _02893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20146_ net1763 net1410 net1672 _05818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20147_ ex_block_i.alu_i.imd_val_q_i\[21\] _05818_ net1548
+ _02894_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20148_ net1762 net1432 net1672 _05819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20149_ ex_block_i.alu_i.imd_val_q_i\[22\] _05819_ net1548
+ _02895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20150_ net1761 net169 net1672 _05820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20151_ ex_block_i.alu_i.imd_val_q_i\[23\] _05820_ net1548
+ _02896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20152_ net1760 net2204 net1672 _05821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20153_ ex_block_i.alu_i.imd_val_q_i\[24\] _05821_ net1548
+ _02897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20154_ net1759 net1431 net1672 _05822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20155_ ex_block_i.alu_i.imd_val_q_i\[25\] _05822_ net1548
+ _02898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20156_ net1758 net1409 net1672 _05823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20157_ ex_block_i.alu_i.imd_val_q_i\[26\] _05823_ net1548
+ _02899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20158_ net1757 net1429 net1672 _05824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput188 net187 data_be_o[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20160_ ex_block_i.alu_i.imd_val_q_i\[27\] _05824_ net1548
+ _02900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput187 net186 data_be_o[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20162_ net1756 net2138 net1672 _05827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20163_ ex_block_i.alu_i.imd_val_q_i\[28\] _05827_ net1548
+ _02901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20164_ net1755 net1408 net1672 _05828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20165_ ex_block_i.alu_i.imd_val_q_i\[29\] _05828_ net1548
+ _02902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20166_ net1740 net1521 net1672 _05829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20167_ ex_block_i.alu_i.imd_val_q_i\[2\] _05829_ net1548
+ _02903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20168_ net1753 net2122 net1672 _05830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20169_ ex_block_i.alu_i.imd_val_q_i\[30\] _05830_ net1548
+ _02904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20170_ net1783 _08174_ net2051 _05831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20171_ net1719 _05831_ _05832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20172_ ex_block_i.alu_i.imd_val_q_i\[31\] _05832_ net1548
+ _02905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput186 net1459 data_addr_o[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput185 net1458 data_addr_o[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20175_ net2031 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ net1823 _05835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_4
Xoutput184 net1512 data_addr_o[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20177_ net2019 net1825 _09677_ _05837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
Xoutput183 net1500 data_addr_o[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20179_ net1806 net1613 _05839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20180_ net1718 _04683_ _05840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20181_ net1784 net1718 _05839_ _05840_ _00972_ _05841_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_20182_ net1549 _04683_ _05842_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20183_ ex_block_i.alu_i.imd_val_q_i\[32\] _05842_ _05843_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20184_ ex_block_i.alu_i.imd_val_q_i\[32\] alu_adder_result_ex\[0\]
+ net1398 _05844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20185_ _00964_ _04486_ _05845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20186_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]
+ net1613 _05845_ _05846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20187_ net1673 _05844_ _05846_ net2029 _05847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xoutput182 net1499 data_addr_o[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20189_ net1750 net1549 _05849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20190_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20191_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20192_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20193_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20194_ _05850_ _05851_ _05852_ _05853_ _04401_ _04404_ _05854_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20195_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20196_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20197_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20198_ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\] _00965_
+ _05858_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20199_ _05855_ _05856_ _05857_ _05858_ _04401_ _04404_ _05859_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_20200_ _04498_ _04407_ _05860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20201_ _05854_ _05859_ _05860_ _05861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20202_ net2031 alu_adder_result_ex\[0\] ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\] _05861_
+ net2027 _05862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_20203_ _09670_ _05847_ _05849_ _05862_ _05863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20204_ net1549 _05841_ _05843_ _05863_ _02906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20205_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]
+ _04514_ _05864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20206_ ex_block_i.alu_i.imd_val_q_i\[33\] net1539 net1398
+ _05865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput181 net1454 data_addr_o[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20208_ _05864_ _05865_ net1613 _05867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20209_ net1806 net1613 _05868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput180 net1519 data_addr_o[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20211_ net2031 net1539 _05844_ net2027 net1806 _05870_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20212_ net1786 _05868_ _05870_ _05871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20213_ net2029 _05867_ _05871_ _05872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xoutput179 net2051 data_addr_o[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20215_ net1549 _04684_ _05874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20216_ ex_block_i.alu_i.imd_val_q_i\[33\] _05842_ _05874_
+ _00974_ _05875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_20217_ _05849_ _05872_ _05875_ _02907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xoutput178 net2122 data_addr_o[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20219_ _00967_ _04486_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]
+ _05877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xoutput177 net1521 data_addr_o[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20221_ ex_block_i.alu_i.imd_val_q_i\[34\] net1521 net1398
+ _05879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20222_ net1673 _05879_ net2029 _05880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xoutput176 net1408 data_addr_o[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20224_ net2031 net1521 _05865_ net2027 net1806 _05882_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20225_ _05877_ _05880_ _05882_ _05883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20226_ net1781 _05868_ net1718 _05884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20227_ ex_block_i.alu_i.imd_val_q_i\[34\] _05842_ _05883_
+ _05884_ _05885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20228_ net1549 _04683_ _05886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xoutput175 net2138 data_addr_o[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20230_ net1549 _04684_ _05888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput174 net1429 data_addr_o[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20232_ ex_block_i.alu_i.imd_val_q_i\[34\] _05886_ _05888_
+ _00975_ _05890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20233_ _05885_ _05890_ _02908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20234_ ex_block_i.alu_i.imd_val_q_i\[35\] net1519 net1398
+ _05891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20235_ net1673 _05891_ _05892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20236_ _00969_ _04486_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]
+ _05893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20237_ net2031 net1519 _05879_ net2027 net1806 _05894_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20238_ _08196_ _05892_ _05893_ _05894_ _05895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20239_ net1780 _05868_ net1718 _05896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20240_ ex_block_i.alu_i.imd_val_q_i\[35\] _05842_ _05895_
+ _05896_ _05897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20241_ ex_block_i.alu_i.imd_val_q_i\[35\] _05886_ _05888_
+ _00980_ _05898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20242_ _05897_ _05898_ _02909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20243_ ex_block_i.alu_i.imd_val_q_i\[36\] net1454 net1398
+ _05899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20244_ _00964_ _04535_ _05900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20245_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]
+ net1613 _05900_ _05901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20246_ net1673 _05899_ _05901_ net2029 _05902_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20247_ net2031 net1454 _05891_ net2027 net1806 _05903_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20248_ _05902_ _05903_ _05904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20249_ ex_block_i.alu_i.imd_val_q_i\[36\] _05842_ _05839_
+ net1715 net1750 _05905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20250_ ex_block_i.alu_i.imd_val_q_i\[36\] _05886_ _05888_
+ _00981_ _05906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20251_ _05904_ _05905_ _05906_ _02910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20252_ ex_block_i.alu_i.imd_val_q_i\[37\] net1499 net1398
+ _05907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20253_ _00968_ _04535_ _05908_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20254_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]
+ net1613 _05908_ _05909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20255_ net1673 _05907_ _05909_ net2029 _05910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20256_ net2031 net1499 _05899_ net2027 net1806 _05911_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20257_ _05910_ _05911_ _05912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20258_ ex_block_i.alu_i.imd_val_q_i\[37\] _05842_ _05839_
+ _04468_ net1750 _05913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20259_ ex_block_i.alu_i.imd_val_q_i\[37\] _05886_ _05888_
+ _00985_ _05914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20260_ _05912_ _05913_ _05914_ _02911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20261_ net1749 net1519 net1672 _05915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20262_ ex_block_i.alu_i.imd_val_q_i\[3\] _05915_ net1548
+ _02912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20263_ ex_block_i.alu_i.imd_val_q_i\[38\] net1500 net1398
+ _05916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20264_ _00967_ _04535_ _05917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20265_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]
+ net1613 _05917_ _05918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20266_ net1673 _05916_ _05918_ net2029 _05919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20267_ net2031 net1500 _05907_ net2027 net1806 _05920_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20268_ _05919_ _05920_ _05921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20269_ ex_block_i.alu_i.imd_val_q_i\[38\] _05842_ _05839_
+ _04471_ net1750 _05922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20270_ ex_block_i.alu_i.imd_val_q_i\[38\] _05886_ _05888_
+ _00992_ _05923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20271_ _05921_ _05922_ _05923_ _02913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20272_ ex_block_i.alu_i.imd_val_q_i\[39\] net1512 net1398
+ _05924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20273_ _00969_ _04535_ _05925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20274_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]
+ net1613 _05925_ _05926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20275_ net1673 _05924_ _05926_ net2029 _05927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20276_ net2031 net1512 _05916_ net2027 net1806 _05928_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20277_ _05927_ _05928_ _05929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20278_ ex_block_i.alu_i.imd_val_q_i\[39\] _05842_ _05839_
+ _04474_ net1750 _05930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20279_ ex_block_i.alu_i.imd_val_q_i\[39\] _05886_ _05888_
+ _05437_ _05931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20280_ _05929_ _05930_ _05931_ _02914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20281_ _04681_ _05886_ _05888_ _04682_ _05932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20282_ net1549 _05933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20283_ _00964_ _04493_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]
+ _05934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20284_ ex_block_i.alu_i.imd_val_q_i\[40\] net1458 net1398
+ _05935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20285_ net1673 _05935_ _05936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20286_ net1673 _05934_ _05936_ _08196_ _05937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xoutput173 net1409 data_addr_o[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput172 net1431 data_addr_o[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20289_ net2031 net1458 _05924_ net2027 net1806 _05940_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20290_ net1775 _05868_ _05940_ _05941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20291_ net1718 _05933_ _05937_ _05941_ _05942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20292_ _05932_ _05942_ _02915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20293_ _09670_ _05849_ _05943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20294_ net2031 net1459 _05935_ net2027 _05943_ _05944_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20295_ ex_block_i.alu_i.imd_val_q_i\[41\] net1459 net1398
+ _05945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20296_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ net1613 _04543_ _05946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20297_ net1673 _05945_ _05946_ net2029 _05947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20298_ net2174 net1750 _05948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20299_ _05840_ _04745_ _05839_ _05948_ _05949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_20300_ ex_block_i.alu_i.imd_val_q_i\[41\] _05842_ _05950_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20301_ _05944_ _05947_ _05949_ net1549 _05950_ _02916_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20302_ ex_block_i.alu_i.imd_val_q_i\[42\] net1451 net1398
+ _05951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20303_ net1673 _05951_ _05952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20304_ _00967_ _04493_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]
+ _05953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20305_ net2031 net1451 _05945_ net2027 net1806 _05954_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20306_ _08196_ _05952_ _05953_ _05954_ _05955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20307_ net1735 _05868_ net1718 _05956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20308_ ex_block_i.alu_i.imd_val_q_i\[42\] _05842_ _05955_
+ _05956_ _05957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20309_ ex_block_i.alu_i.imd_val_q_i\[42\] _05886_ _05888_
+ _04771_ _05958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20310_ _05957_ _05958_ _02917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20311_ ex_block_i.alu_i.imd_val_q_i\[43\] net1457 net1398
+ _05959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20312_ net1673 _05959_ _05960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20313_ _00969_ _04493_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]
+ _05961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20314_ net2031 net1457 _05951_ net2027 net1806 _05962_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20315_ _08196_ _05960_ _05961_ _05962_ _05963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20316_ net1738 _05868_ net1718 _05964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20317_ ex_block_i.alu_i.imd_val_q_i\[43\] _05842_ _05963_
+ _05964_ _05965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20318_ ex_block_i.alu_i.imd_val_q_i\[43\] _05886_ _05888_
+ _04794_ _05966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20319_ _05965_ _05966_ _02918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20320_ ex_block_i.alu_i.imd_val_q_i\[44\] net2298 net1398
+ _05967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20321_ net1673 _05967_ _05968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20322_ _00964_ _04500_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]
+ _05969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20323_ net2031 net2298 _05959_ net2027 net1806 _05970_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20324_ _08196_ _05968_ _05969_ _05970_ _05971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20325_ net1803 _05868_ net1718 _05972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20326_ ex_block_i.alu_i.imd_val_q_i\[44\] _05842_ _05971_
+ _05972_ _05973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20327_ ex_block_i.alu_i.imd_val_q_i\[44\] _05886_ _05888_
+ net1391 _05974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20328_ _05973_ _05974_ _02919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20329_ ex_block_i.alu_i.imd_val_q_i\[45\] net1450 net1398
+ _05975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20330_ net1673 _05975_ _05976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20331_ _00968_ _04500_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]
+ _05977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20332_ net2031 net1450 _05967_ net2027 net1806 _05978_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20333_ _08196_ _05976_ _05977_ _05978_ _05979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20334_ net1734 _05868_ net1718 _05980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20335_ ex_block_i.alu_i.imd_val_q_i\[45\] _05842_ _05979_
+ _05980_ _05981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20336_ _04880_ _05842_ _05874_ _04885_ _05981_ _02920_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20337_ _00967_ _04500_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]
+ _05982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20338_ ex_block_i.alu_i.imd_val_q_i\[46\] net2292 net1398
+ _05983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20339_ net1673 _05983_ net2029 _05984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20340_ net2031 net2292 _05975_ net2027 net1806 _05985_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20341_ _05982_ _05984_ _05985_ _05986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20342_ net1733 _05868_ net1718 _05987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20343_ ex_block_i.alu_i.imd_val_q_i\[46\] _05842_ _05986_
+ _05987_ _05988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20344_ ex_block_i.alu_i.imd_val_q_i\[46\] _05886_ _05888_
+ _04926_ _05989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20345_ _05988_ _05989_ _02921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20346_ ex_block_i.alu_i.imd_val_q_i\[47\] net1448 net1398
+ _05990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20347_ _00969_ _04500_ _05991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20348_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]
+ net1613 _05991_ _05992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20349_ net1673 _05990_ _05992_ net2029 _05993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20350_ net2031 net1448 _05983_ net2027 net1806 _05994_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20351_ _05993_ _05994_ _05995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20352_ ex_block_i.alu_i.imd_val_q_i\[47\] _05842_ _05839_
+ net1748 net1750 _05996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20353_ _04952_ _05842_ _05995_ _05996_ _05874_ _04960_ _02922_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_20354_ net1794 _05997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20355_ _05997_ net1454 net1672 _05998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20356_ ex_block_i.alu_i.imd_val_q_i\[4\] _05998_ net1548
+ _02923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput171 net2065 data_addr_o[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20358_ ex_block_i.alu_i.imd_val_q_i\[48\] net1446 net1398
+ _06000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20359_ _00964_ _04507_ _06001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput170 net169 data_addr_o[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20361_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]
+ net1613 _06003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20362_ net1673 _06000_ _06001_ _06003_ net2029 _06004_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
Xoutput169 net1432 data_addr_o[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20364_ net2031 net1446 _05990_ net2027 net1806 _06006_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20365_ net1770 _05868_ _06004_ _06006_ _06007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20366_ _04978_ _06007_ net1750 _06008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20367_ ex_block_i.alu_i.imd_val_q_i\[48\] _06008_ net1549
+ _02924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20368_ ex_block_i.alu_i.imd_val_q_i\[49\] net2288 net1398
+ _06009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20369_ _00968_ _04507_ _06010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20370_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]
+ net1613 _06011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20371_ net1673 _06009_ _06010_ _06011_ net2029 _06012_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20372_ net2031 net2288 _06000_ net2027 net1806 _06013_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20373_ net1732 _05868_ _06012_ _06013_ _06014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20374_ _05004_ _06014_ net1750 _06015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20375_ ex_block_i.alu_i.imd_val_q_i\[49\] _06015_ net1549
+ _02925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20376_ ex_block_i.alu_i.imd_val_q_i\[50\] net1435 net1398
+ _06016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20377_ _00967_ _04507_ _06017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20378_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]
+ net1613 _06018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20379_ net1673 _06016_ _06017_ _06018_ net2029 _06019_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20380_ net2031 net1435 _06009_ net2027 net1806 _06020_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20381_ net1731 _05868_ _06019_ _06020_ _06021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20382_ _05059_ _06021_ net1750 _06022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20383_ ex_block_i.alu_i.imd_val_q_i\[50\] _06022_ _09687_
+ _02926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20384_ ex_block_i.alu_i.imd_val_q_i\[51\] net1436 net1398
+ _06023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20385_ _00969_ _04507_ _06024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20386_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]
+ net1613 _06025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20387_ net1673 _06023_ _06024_ _06025_ net2029 _06026_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20388_ net2031 net1436 _06016_ net2027 net1806 _06027_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20389_ net1730 _05868_ _06026_ _06027_ _06028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20390_ _05082_ _06028_ net1750 _06029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20391_ ex_block_i.alu_i.imd_val_q_i\[51\] _06029_ _09687_
+ _02927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20392_ net1750 net1372 _06030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20393_ ex_block_i.alu_i.imd_val_q_i\[52\] net2278 net1398
+ _06031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20394_ _00964_ _04517_ _06032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20395_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]
+ net1613 _06033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20396_ net1673 _06031_ _06032_ _06033_ net2029 _06034_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20397_ net2031 net2278 _06023_ net2027 net1806 _06035_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20398_ net2161 _05868_ _06034_ _06035_ net1718 _06036_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20399_ _06030_ _06036_ _06037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20400_ ex_block_i.alu_i.imd_val_q_i\[52\] _06037_ net1549
+ _02928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20401_ ex_block_i.alu_i.imd_val_q_i\[53\] net1410 net1398
+ _06038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20402_ _00968_ _04517_ _06039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20403_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]
+ net1613 _06040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20404_ net1673 _06038_ _06039_ _06040_ net2029 _06041_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20405_ net2031 net1410 _06031_ net2027 net1806 _06042_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20406_ net1727 _05868_ _06041_ _06042_ _06043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20407_ _05127_ _06043_ net1750 _06044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20408_ ex_block_i.alu_i.imd_val_q_i\[53\] _06044_ _09687_
+ _02929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20409_ ex_block_i.alu_i.imd_val_q_i\[54\] net1432 net1398
+ _06045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20410_ _00967_ _04517_ _06046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20411_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]
+ net1613 _06047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20412_ net1673 _06045_ _06046_ _06047_ net2029 _06048_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20413_ net2031 net1432 _06038_ net2027 net1806 _06049_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20414_ net1726 _05868_ _06048_ _06049_ _06050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20415_ _05147_ _06050_ net1750 _06051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20416_ ex_block_i.alu_i.imd_val_q_i\[54\] _06051_ _09687_
+ _02930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20417_ ex_block_i.alu_i.imd_val_q_i\[55\] net169 net1398
+ _06052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20418_ _00969_ _04517_ _06053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20419_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]
+ net1613 _06054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20420_ net1673 _06052_ _06053_ _06054_ net2029 _06055_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20421_ net2031 net169 _06045_ net2027 net1806 _06056_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20422_ net1725 _05868_ _06055_ _06056_ _06057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20423_ _05166_ _06057_ net1750 _06058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20424_ ex_block_i.alu_i.imd_val_q_i\[55\] _06058_ _09687_
+ _02931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20425_ ex_block_i.alu_i.imd_val_q_i\[56\] net2065 net1398
+ _06059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20426_ _00964_ _04522_ _06060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20427_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]
+ net1613 _06061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20428_ net1673 _06059_ _06060_ _06061_ net2029 _06062_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20429_ net2031 net2065 _06052_ net2027 net1806 _06063_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20430_ net1723 _05868_ _06062_ _06063_ _06064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20431_ _05184_ _06064_ net1750 _06065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20432_ ex_block_i.alu_i.imd_val_q_i\[56\] _06065_ _09687_
+ _02932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20433_ ex_block_i.alu_i.imd_val_q_i\[57\] net1431 net1398
+ _06066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20434_ _00968_ _04522_ _06067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20435_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]
+ net1613 _06068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20436_ net1673 _06066_ _06067_ _06068_ net2029 _06069_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20437_ net2031 net1431 _06059_ net2027 net1806 _06070_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20438_ net1722 _05868_ _06069_ _06070_ _06071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20439_ _05211_ _06071_ net1750 _06072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20440_ ex_block_i.alu_i.imd_val_q_i\[57\] _06072_ _09687_
+ _02933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20441_ net1792 net1499 net1672 _06073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20442_ ex_block_i.alu_i.imd_val_q_i\[5\] _06073_ net1548
+ _02934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20443_ ex_block_i.alu_i.imd_val_q_i\[58\] net1409 net1398
+ _06074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20444_ _00967_ _04522_ _06075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20445_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]
+ net1613 _06076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20446_ net1673 _06074_ _06075_ _06076_ net2029 _06077_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20447_ net2031 net1409 _06066_ net2027 net1806 _06078_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20448_ net1721 _05868_ _06077_ _06078_ _06079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20449_ _05242_ _06079_ net1750 _06080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20450_ ex_block_i.alu_i.imd_val_q_i\[58\] _06080_ _09687_
+ _02935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20451_ ex_block_i.alu_i.imd_val_q_i\[59\] _05933_ _06081_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20452_ ex_block_i.alu_i.imd_val_q_i\[59\] net1429 net1398
+ _06082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20453_ _00969_ _04522_ _06083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20454_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]
+ net1613 _06084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20455_ net1673 _06082_ _06083_ _06084_ net2029 _06085_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20456_ net2031 net1429 _06074_ net2027 net1806 _06086_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20457_ net1720 _05868_ _06085_ _06086_ _06087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20458_ net1718 _06087_ _05259_ net1549 _06088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20459_ _06081_ _06088_ _02936_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20460_ ex_block_i.alu_i.imd_val_q_i\[60\] net2138 net1398
+ _06089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20461_ _00964_ _04527_ _06090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20462_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]
+ net1613 _06091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20463_ net1673 _06089_ _06090_ _06091_ net2029 _06092_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20464_ net2031 net2138 _06082_ net2027 net1806 _06093_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20465_ _09340_ _05868_ _06092_ _06093_ _06094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20466_ _05311_ _06094_ net1750 _06095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20467_ ex_block_i.alu_i.imd_val_q_i\[60\] _06095_ _09687_
+ _02937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20468_ ex_block_i.alu_i.imd_val_q_i\[61\] net1408 net1398
+ _06096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20469_ _00968_ _04527_ _06097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20470_ ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]
+ net1613 _06098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20471_ net1673 _06096_ _06097_ _06098_ net2029 _06099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20472_ net2031 net1408 _06089_ net2027 net1806 _06100_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20473_ net1754 _05868_ _06099_ _06100_ net1718 _06101_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20474_ _05329_ _06101_ _06102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20475_ ex_block_i.alu_i.imd_val_q_i\[61\] _06102_ net1549
+ _02938_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20476_ ex_block_i.alu_i.imd_val_q_i\[62\] net2122 net1398
+ _06103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20477_ net1673 _06103_ _06104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20478_ _00967_ _04527_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]
+ _06105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20479_ net2031 net2122 _06096_ net2027 net1806 _06106_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20480_ net1752 _05868_ _06107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20481_ _08196_ _06104_ _06105_ _06106_ _06107_ _06108_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_20482_ _05849_ _06108_ _06109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20483_ ex_block_i.alu_i.imd_val_q_i\[62\] _05933_ _09688_
+ _05373_ _06110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20484_ _06109_ _06110_ _02939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20485_ ex_block_i.alu_i.imd_val_q_i\[63\] net2051 net1673
+ _06111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20486_ _00969_ _04527_ net1613 ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]
+ _06112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20487_ _08196_ _06111_ _06112_ _06113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20488_ net2031 net2051 _06103_ net2027 net1806 _06114_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20489_ _06113_ _06114_ _06115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20490_ _09467_ _05868_ _06116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20491_ net1718 _06115_ _06116_ _05393_ _06117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20492_ ex_block_i.alu_i.imd_val_q_i\[63\] _06117_ _09687_
+ _02940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20493_ net1806 _09677_ _06118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20494_ _08194_ _04484_ _04462_ _06119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20495_ _06118_ _06119_ _06120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20496_ _01117_ _05370_ _06121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20497_ _01124_ _06121_ _01123_ _06122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20498_ _01131_ _06122_ _06123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20499_ net1718 _06120_ _06123_ _05840_ _06124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_20500_ ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ _06124_ net1549 _02941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20501_ _01124_ _05390_ _06125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20502_ _01123_ _06125_ _06126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20503_ _01131_ _06126_ _01130_ _06127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20504_ _00798_ _00749_ _06128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20505_ _01127_ _00794_ _06128_ _06129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20506_ _00805_ _00807_ _06130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20507_ net1547 _00792_ _06130_ _06131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20508_ _00800_ _00801_ _06132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20509_ net1537 _00793_ _06133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20510_ _00802_ _00750_ _01125_ _06134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20511_ _06132_ _06133_ _06134_ _06135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20512_ _06129_ _06131_ _06135_ _06136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20513_ ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ net1716 _06137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20514_ net1710 _06137_ _06138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20515_ net1576 _06136_ _06138_ _06139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20516_ net1570 _06127_ _06139_ _06140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_20517_ net1718 _06118_ _06140_ _05840_ _06141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_20518_ ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ _06141_ net1549 _02942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20519_ net1790 net1500 net1672 _06142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20520_ ex_block_i.alu_i.imd_val_q_i\[6\] _06142_ net1548
+ _02943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20521_ net1788 net1512 net1672 _06143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20522_ ex_block_i.alu_i.imd_val_q_i\[7\] _06143_ net1548
+ _02944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20523_ net1713 net1458 net1672 _06144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20524_ ex_block_i.alu_i.imd_val_q_i\[8\] _06144_ net1548
+ _02945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20525_ net1709 net1459 net1672 _06145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20526_ ex_block_i.alu_i.imd_val_q_i\[9\] _06145_ net1548
+ _02946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20527_ cs_registers_i.debug_mode_i _09901_ _09497_ _06146_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20528_ _09938_ _06146_ _06147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20529_ cs_registers_i.csr_mepc_o\[10\] net1746 _06147_ cs_registers_i.csr_mtvec_o\[10\]
+ _06148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20530_ _06148_ _06149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20531_ net6 net1618 net1747 cs_registers_i.csr_depc_o\[10\]
+ _06149_ _06150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20532_ _08509_ _05727_ _10012_ _06150_ _06151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20533_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ _10012_ _06152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20534_ _06151_ _06152_ _06153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20535_ cs_registers_i.csr_mtvec_o\[9\] _06147_ _06154_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20536_ cs_registers_i.csr_depc_o\[9\] net1747 _09965_ cs_registers_i.csr_mepc_o\[9\]
+ _06155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20537_ _08455_ _05727_ _06154_ _06155_ _06156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20538_ id_stage_i.controller_i.ctrl_fsm_cs\[1\] _09902_
+ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _06157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20539_ _10074_ _06157_ _03901_ _06158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20540_ net29 _06156_ _06158_ _06159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20541_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ _06159_ _10012_ _06160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20542_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ _06161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20543_ cs_registers_i.csr_depc_o\[4\] net1747 net1746 cs_registers_i.csr_mepc_o\[4\]
+ _04021_ _09945_ _06162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_20544_ _06162_ _06163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20545_ net1809 net1454 net1589 _06163_ _06164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20546_ _06161_ net1589 _06164_ _06165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20547_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ _06166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20548_ net1809 net1499 net1746 cs_registers_i.csr_mepc_o\[5\]
+ _06167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20549_ cs_registers_i.csr_depc_o\[5\] net1747 _06168_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20550_ _10012_ _04031_ _06167_ _06168_ _06169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20551_ _06166_ net1589 _06169_ _06170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20552_ _01375_ _06165_ _06170_ _06171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20553_ net1500 net1809 _06172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20554_ cs_registers_i.csr_depc_o\[6\] net1747 _06173_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20555_ cs_registers_i.csr_mepc_o\[6\] net1746 _06174_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20556_ _04037_ _06173_ _06174_ _06175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20557_ _08471_ _08472_ net1809 _06176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20558_ cs_registers_i.csr_mepc_o\[8\] _09965_ _06147_ cs_registers_i.csr_mtvec_o\[8\]
+ _06177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20559_ _06177_ _06178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20560_ net28 net1618 net1747 cs_registers_i.csr_depc_o\[8\]
+ _06178_ _06179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20561_ _06179_ _06180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20562_ _06172_ _06175_ _06176_ _06180_ _09957_ _06181_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_20563_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ net1589 _06182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20564_ net1512 net1809 _06183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20565_ cs_registers_i.csr_depc_o\[7\] net1747 _09965_ cs_registers_i.csr_mepc_o\[7\]
+ _06184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20566_ _06158_ _06183_ _06184_ _06185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20567_ _06185_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ net1589 _06186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20568_ _06186_ _06187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20569_ _06181_ _06182_ _06187_ _06188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20570_ _06171_ _06188_ _06189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20571_ _06160_ _06189_ _06190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20572_ _06153_ _06190_ _06191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20573_ net1589 _10081_ _06192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput168 net1410 data_addr_o[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput167 net2278 data_addr_o[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20576_ _06191_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ net1542 _02947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20577_ id_stage_i.controller_i.ctrl_fsm_cs\[0\] _09952_
+ _09938_ _06195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20578_ _03901_ _06195_ _06196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20579_ cs_registers_i.csr_mtvec_o\[11\] _09922_ _09997_
+ _06196_ _06197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20580_ cs_registers_i.csr_mepc_o\[11\] _09965_ _06198_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20581_ cs_registers_i.csr_depc_o\[11\] net1747 _06199_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20582_ _06197_ _06198_ _06199_ _06200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20583_ _08496_ _08497_ _05727_ _06200_ _06201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20584_ net7 _06201_ _06158_ _06202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20585_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ _06202_ _10012_ _06203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20586_ _01373_ _01374_ _06165_ _06204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20587_ _06170_ _06204_ _06205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20588_ _06188_ _06205_ _06206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20589_ _06153_ _06160_ _06206_ _06207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20590_ _06203_ _06207_ _06208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20591_ _06208_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ net1542 _02948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20592_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]
+ _06209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20593_ cs_registers_i.csr_mtvec_o\[12\] _06147_ _06210_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20594_ cs_registers_i.csr_depc_o\[12\] net1747 net1746 cs_registers_i.csr_mepc_o\[12\]
+ _06211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20595_ net8 net1618 _06212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20596_ _06210_ _06211_ _06212_ _06213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20597_ net1809 net1449 net1589 _06213_ _06214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_20598_ _06209_ net1589 _06214_ _06215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20599_ _06151_ _06152_ _06160_ _06203_ _06216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20600_ _06189_ _06216_ _06217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20601_ _06215_ _06217_ _06218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20602_ _06218_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]
+ net1542 _02949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20603_ net9 _06158_ _06219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xoutput166 net1436 data_addr_o[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20605_ cs_registers_i.csr_mtvec_o\[13\] _06147_ _06221_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20606_ cs_registers_i.csr_depc_o\[13\] net1747 net1746 cs_registers_i.csr_mepc_o\[13\]
+ _06222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20607_ _06221_ _06222_ _06223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20608_ net1450 net1809 net1618 _06223_ _06224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_20609_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ net1589 _06225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20610_ net1589 _06219_ _06224_ _06225_ _06226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20611_ _06188_ _06205_ _06215_ _06216_ _06227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20612_ _06226_ _06227_ _06228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
Xoutput165 net1435 data_addr_o[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20614_ _06228_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ net1542 _02950_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput164 net2288 data_addr_o[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20616_ _06188_ _06215_ _06216_ _06226_ _06231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20617_ _06171_ _06231_ _06232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20618_ _01371_ _06232_ _06233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20619_ _10081_ _06233_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ _06234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput163 net1446 data_addr_o[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20621_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ net1589 _06236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20622_ net1456 net1809 _06237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20623_ cs_registers_i.csr_mtvec_o\[14\] _06147_ _06238_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20624_ cs_registers_i.csr_depc_o\[14\] net1747 _09965_ cs_registers_i.csr_mepc_o\[14\]
+ _06239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20625_ _06238_ _06239_ _06240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20626_ net10 net1618 _06241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20627_ _06241_ _06240_ _06237_ net1581 _06242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_20628_ _06232_ _06242_ _06243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20629_ net1589 _06234_ _06236_ _06243_ _02951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20630_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ net1589 _06244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20631_ cs_registers_i.csr_mtvec_o\[15\] _06147_ _06245_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20632_ cs_registers_i.csr_depc_o\[15\] net1747 _09965_ cs_registers_i.csr_mepc_o\[15\]
+ _06246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20633_ net1448 net1809 _06247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20634_ _06158_ _06245_ _06246_ _06247_ _06248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_20635_ net11 _06158_ _06248_ net1581 _06249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_4
X_20636_ _06249_ _06244_ _06250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20637_ _06236_ _06242_ _06251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20638_ _06205_ _06231_ _06251_ _06252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20639_ _06250_ _06252_ _06253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20640_ _06253_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ _06192_ _02952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20641_ _09922_ _09997_ _06254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20642_ cs_registers_i.csr_mtvec_o\[16\] _06254_ _06196_
+ _06255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20643_ cs_registers_i.csr_mepc_o\[16\] _09965_ _06256_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20644_ _06255_ _06256_ _06257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20645_ net12 net1618 net1747 cs_registers_i.csr_depc_o\[16\]
+ _06257_ _06258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20646_ net1455 _08839_ _05727_ _06258_ _06259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20647_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ _06259_ _10012_ _06260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20648_ _06232_ _06251_ _06250_ _06261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20649_ _06260_ _06261_ _06262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20650_ _06262_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ _06192_ _02953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20651_ cs_registers_i.csr_mtvec_o\[17\] _06147_ _06263_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20652_ cs_registers_i.csr_depc_o\[17\] net1747 _09965_ cs_registers_i.csr_mepc_o\[17\]
+ _06263_ _06264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20653_ net1447 net1809 net1618 net13 _06265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20654_ _06264_ _06265_ net1589 _06266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20655_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ net1589 _06267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20656_ _06267_ _06266_ _06268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20657_ _06251_ _06250_ _06260_ _06269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20658_ _06231_ _06269_ _06270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20659_ _06205_ _06270_ _06271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20660_ _06268_ _06271_ _06272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20661_ _06272_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ _06192_ _02954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput162 net1448 data_addr_o[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20663_ cs_registers_i.csr_mtvec_o\[18\] _06147_ _06274_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20664_ cs_registers_i.csr_depc_o\[18\] net1747 _09965_ cs_registers_i.csr_mepc_o\[18\]
+ _06274_ _06275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20665_ _06275_ _06276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20666_ net1435 net1809 net1618 net14 _06276_ _06277_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20667_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ net1589 _06278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20668_ net1589 _06277_ _06278_ _06279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20669_ _06232_ _06269_ _06268_ _06280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20670_ _06279_ _06280_ _06281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20671_ _06281_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ _06192_ _02955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20672_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]
+ _06282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20673_ cs_registers_i.csr_mtvec_o\[19\] _06147_ _06283_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20674_ cs_registers_i.csr_depc_o\[19\] net1747 _09965_ cs_registers_i.csr_mepc_o\[19\]
+ _06284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20675_ net15 net1618 _06285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20676_ _06283_ _06284_ _06285_ _06286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20677_ net1436 net1809 net1589 _06286_ _06287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_20678_ _06282_ net1589 _06287_ _06288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20679_ _06205_ _06279_ _06289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20680_ _06268_ _06270_ _06289_ _06290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20681_ _06288_ _06290_ _06291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20682_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]
+ _06192_ _06292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20683_ _06192_ _06291_ _06292_ _02956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20684_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]
+ net1589 _06293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20685_ cs_registers_i.csr_mtvec_o\[20\] _06254_ _06294_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20686_ cs_registers_i.csr_mepc_o\[20\] net1746 _06196_ _06294_
+ _06295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20687_ cs_registers_i.csr_depc_o\[20\] net1747 _06296_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20688_ _06295_ _06296_ _06297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20689_ net1433 net1809 net1618 net16 _06297_ _06298_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20690_ net1589 _06298_ _06299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20691_ _06232_ _06269_ _06300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20692_ _06268_ _06279_ _06288_ _06301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20693_ _06300_ _06301_ _06302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20694_ _06293_ _06299_ _06302_ _06303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20695_ _06302_ _06299_ _06304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput161 net2292 data_addr_o[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20697_ _10081_ _06302_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]
+ net1589 _06306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20698_ net1542 _06303_ _06304_ _06306_ _02957_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20699_ cs_registers_i.csr_mtvec_o\[21\] _06147_ _06307_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20700_ cs_registers_i.csr_depc_o\[21\] net1747 net1746 cs_registers_i.csr_mepc_o\[21\]
+ _06307_ _06308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20701_ _06308_ _06309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20702_ net17 net1618 _06309_ _06310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20703_ _09015_ net1434 _05727_ _06310_ _06311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
X_20704_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ _06311_ _10012_ _06312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_4
X_20705_ _06293_ _06299_ _06313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_20706_ _06301_ _06313_ _06314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20707_ _06205_ _06231_ _06269_ _06314_ _06315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20708_ _06312_ _06315_ _06316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20709_ _06316_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ net1542 _02958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20710_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ net1589 _06317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20711_ cs_registers_i.csr_mtvec_o\[22\] _06147_ _06318_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20712_ cs_registers_i.csr_depc_o\[22\] net1747 _09965_ cs_registers_i.csr_mepc_o\[22\]
+ _06318_ _06319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20713_ _06319_ _06320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20714_ net1432 net1809 net1618 net18 _06320_ _06321_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20715_ net1589 _06321_ _06322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20716_ _06232_ _06269_ _06314_ _06323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20717_ _06312_ _06323_ _06324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20718_ _06317_ _06322_ _06324_ _06325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20719_ _06324_ _06322_ _06326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20720_ _10081_ _06324_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ net1589 _06327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20721_ net1542 _06325_ _06326_ _06327_ _02959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20722_ cs_registers_i.csr_mepc_o\[23\] net1746 _06147_ cs_registers_i.csr_mtvec_o\[23\]
+ _06328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20723_ _06328_ _06329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20724_ net19 net1618 net1747 cs_registers_i.csr_depc_o\[23\]
+ _06329_ _06330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20725_ _09105_ _09106_ _05727_ _06330_ _06331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20726_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ _06331_ _10012_ _06332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20727_ net1589 _06321_ _06317_ _06333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20728_ _06312_ _06315_ _06333_ _06334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20729_ _06332_ _06334_ _06335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20730_ _06335_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ net1542 _02960_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20731_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ net1589 _06336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20732_ cs_registers_i.csr_mtvec_o\[24\] _06147_ _06337_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20733_ cs_registers_i.csr_depc_o\[24\] net1747 _09965_ cs_registers_i.csr_mepc_o\[24\]
+ _06338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20734_ _06337_ _06338_ _06339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20735_ net170 net1809 net1618 net20 _06339_ _06340_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20736_ net1589 _06340_ _06341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20737_ _06312_ _06333_ _06332_ _06342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20738_ _06323_ _06342_ _06343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20739_ _06336_ _06341_ _06343_ _06344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20740_ _06343_ _06341_ _06345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20741_ _10081_ _06343_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ net1589 _06346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20742_ net1542 _06344_ _06345_ _06346_ _02961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20743_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ net1589 _06347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20744_ cs_registers_i.csr_mtvec_o\[25\] _06254_ _06348_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20745_ cs_registers_i.csr_mepc_o\[25\] _09965_ _06196_ _06348_
+ _06349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20746_ cs_registers_i.csr_depc_o\[25\] net1747 _06350_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20747_ _06349_ _06350_ _06351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20748_ net1431 net1809 net1618 net21 _06351_ _06352_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20749_ _06352_ net1589 _06353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20750_ net1589 _06340_ _06336_ _06354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20751_ _06342_ _06354_ _06355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20752_ _06315_ _06355_ _06356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20753_ _06347_ net2276 _06356_ _06357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20754_ _06356_ net2276 _06358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20755_ _10081_ _06356_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ net1589 _06359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20756_ net1542 _06357_ _06358_ _06359_ _02962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20757_ cs_registers_i.csr_mtvec_o\[26\] _06147_ _06360_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20758_ cs_registers_i.csr_depc_o\[26\] net1747 _09965_ cs_registers_i.csr_mepc_o\[26\]
+ _06360_ _06361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20759_ net22 net1618 _06362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20760_ net1428 _05727_ _06361_ _06362_ _06363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20761_ _06363_ net1581 _06364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20762_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ net1589 _06365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20763_ _06365_ _06364_ _06366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20764_ _06347_ _06353_ _06367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20765_ _06323_ _06355_ _06367_ _06368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20766_ _06366_ _06368_ _06369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20767_ _06369_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ net1542 _02963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20768_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ net1589 _06370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20769_ cs_registers_i.csr_mtvec_o\[27\] _06254_ _06371_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20770_ cs_registers_i.csr_mepc_o\[27\] _09965_ _06196_ _06371_
+ _06372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20771_ cs_registers_i.csr_depc_o\[27\] net1747 _06373_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20772_ _06372_ _06373_ _06374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20773_ net173 net1809 net1618 net23 _06374_ _06375_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20774_ net1589 _06375_ _06376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20775_ _06370_ _06376_ _06377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20776_ _06377_ _06378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20777_ _10081_ _06370_ _06376_ _06379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20778_ _06313_ _06380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_3
X_20779_ _06268_ _06288_ _06380_ _06381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20780_ _06342_ _06354_ _06367_ _06366_ _06382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20781_ _06270_ _06289_ _06381_ _06382_ _06383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20782_ _06378_ _06379_ _06383_ _06384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20783_ _06192_ _06370_ _06384_ _02964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20784_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ _06385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xoutput160 net1450 data_addr_o[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20786_ cs_registers_i.csr_mtvec_o\[28\] _06254_ _06387_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20787_ cs_registers_i.csr_mepc_o\[28\] _09965_ _06196_ _06387_
+ _06388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20788_ cs_registers_i.csr_depc_o\[28\] net1747 _06389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20789_ _06388_ _06389_ _06390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20790_ net1809 net1407 net1618 net24 _06390_ _06391_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20791_ _06391_ net1589 _06392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20792_ _06385_ _10012_ _06392_ _06393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20793_ _06323_ _06382_ _06377_ _06394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20794_ _06393_ _06394_ _06395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20795_ _06395_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ _06192_ _02965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20796_ cs_registers_i.csr_mtvec_o\[29\] _06147_ _06396_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20797_ cs_registers_i.csr_depc_o\[29\] net1747 _09965_ cs_registers_i.csr_mepc_o\[29\]
+ _06397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20798_ _06396_ _06397_ _06398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20799_ net1809 net175 net1618 net25 _06398_ _06399_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20800_ _06399_ net1589 _06400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20801_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ net1589 _06401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20802_ _06400_ _06401_ _06402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_20803_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ _06403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20804_ _06403_ _06376_ _06392_ _06385_ _06404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20805_ _06376_ net2478 _10012_ _06405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20806_ _06315_ _06382_ _06404_ _06405_ _06406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20807_ _06402_ _06406_ _06407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20808_ _06407_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ _06192_ _02966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20809_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[2\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ net1542 _02967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20810_ cs_registers_i.csr_mtvec_o\[30\] _06147_ _06408_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20811_ cs_registers_i.csr_depc_o\[30\] net1747 net1746 cs_registers_i.csr_mepc_o\[30\]
+ _06409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20812_ _06408_ _06409_ _06410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20813_ net1406 net1809 net1618 net26 _06410_ _06411_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20814_ _06411_ net1589 _06412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20815_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ net1589 _06413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20816_ _06412_ _06413_ _06414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_20817_ _06382_ _06402_ _06404_ _06405_ _06415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20818_ _06323_ _06415_ _06416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20819_ _06414_ _06416_ _06417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20820_ _06417_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ net1542 _02968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20821_ cs_registers_i.csr_mtvec_o\[31\] _06147_ _06418_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20822_ cs_registers_i.csr_depc_o\[31\] net1747 net1746 cs_registers_i.csr_mepc_o\[31\]
+ _06419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20823_ _06418_ _06419_ _06420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20824_ net178 net1809 net1618 net27 _06420_ _06421_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_4
X_20825_ _06421_ net1589 _06422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_4
X_20826_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ net1589 _06423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20827_ _06422_ _06423_ _06424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
X_20828_ _06315_ _06414_ _06415_ _06425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20829_ _06424_ _06425_ _06426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20830_ _06426_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ net1542 _02969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20831_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[3\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ net1542 _02970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20832_ _01375_ _06165_ _06427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20833_ _06427_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ net1542 _02971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20834_ _06170_ _06204_ _06428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20835_ _06428_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ net1542 _02972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20836_ _06172_ _06175_ _09957_ _06429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_4
X_20837_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ net1589 _06430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20838_ _06429_ _06430_ _06431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20839_ _06171_ _06431_ _06432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20840_ _06432_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ net1542 _02973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20841_ _06205_ _06431_ _06433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20842_ _06187_ _06433_ _06434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20843_ _06434_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ net1542 _02974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20844_ _06176_ _06180_ _06435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20845_ _06171_ _06186_ _06431_ _06436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20846_ _06435_ _06436_ _06189_ _06437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20847_ net1589 _06437_ _06438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20848_ _01371_ _06189_ _06439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20849_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ _10012_ _06440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20850_ _10081_ _06436_ _06440_ _06441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20851_ _06438_ _06439_ _06441_ _02975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20852_ _06160_ _06206_ _06442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20853_ _06442_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ net1542 _02976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20854_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ net133 _06443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20855_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _06443_ _06444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20856_ _10023_ _06444_ _06445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xoutput159 net2298 data_addr_o[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput158 net1457 data_addr_o[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20859_ net2025 _06444_ _06448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20860_ net2024 _06448_ _06449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20861_ net2024 _06450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20862_ _10026_ _10033_ _06451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20863_ net2026 _06450_ _06451_ _06448_ _06452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xoutput157 net1451 data_addr_o[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20865_ net2026 _06451_ _06444_ net2025 _06454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20866_ _06452_ _06454_ _06455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20867_ _10027_ _03436_ _06455_ _06456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20868_ net1809 _05777_ _05767_ _06456_ _06457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_20869_ net1393 _06457_ _06458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xoutput156 net155 core_sleep_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20871_ _06445_ _06449_ _06458_ _06460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput155 test_en_i net154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput154 rst_ni net153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
X_20874_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]
+ _06463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20875_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _06464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20876_ net2024 _10027_ _03436_ _06455_ _06465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_20877_ net1809 _05777_ _05767_ _06465_ _06466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20878_ net1394 net1501 _06467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20879_ _06463_ _06464_ _06467_ _06468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20880_ net1393 _06457_ _06469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput153 irq_timer_i net152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput152 irq_software_i net151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput151 irq_nm_i net150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20884_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _06443_ _06473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput150 irq_fast_i[9] net149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20886_ _10023_ net2024 net99 net1819 _06475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_20887_ _10023_ net2024 _06476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20888_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ net1819 _06476_ _06477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20889_ _03402_ _03423_ _03429_ _06478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput149 irq_fast_i[8] net148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput148 irq_fast_i[7] net147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20892_ net2025 net2024 net99 net1819 _06481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_20893_ _06478_ _05769_ _06456_ _06481_ _06482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20894_ _06469_ _06475_ _06477_ _06482_ _06483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20895_ _06460_ _06468_ _06483_ _02977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput147 irq_fast_i[6] net146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20897_ net99 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ net2023 _06485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20898_ net2024 _06448_ _06486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20899_ net2024 _06444_ net2023 _06487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20900_ _06487_ _06488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20901_ _06486_ _06488_ _06458_ _06489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput146 irq_fast_i[5] net145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput145 irq_fast_i[4] net144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20904_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _06485_ net1378 _02978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_20905_ _06450_ net2023 net1819 _06492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
Xinput144 irq_fast_i[3] net143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20907_ net99 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ net1805 _02979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput143 irq_fast_i[2] net142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput142 irq_fast_i[1] net141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20910_ net1539 net1809 _06496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20911_ cs_registers_i.csr_depc_o\[1\] net1747 _09965_ cs_registers_i.csr_mepc_o\[1\]
+ _06496_ _06497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_20912_ _03436_ _06455_ _06498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20913_ _06498_ _06499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20914_ net1809 _05777_ _05767_ _06499_ _06500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xinput141 irq_fast_i[14] net140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20916_ net1393 _06500_ _06502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput140 irq_fast_i[13] net139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20918_ _06451_ net1385 net2026 _06504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20919_ _10027_ _06505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20920_ net1393 _06500_ _06506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
Xinput139 irq_fast_i[12] net138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput138 irq_fast_i[11] net137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput137 irq_fast_i[10] net136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20924_ _06505_ net1384 _10012_ _06510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20925_ _10012_ _06497_ _06504_ _06510_ _02980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20926_ cs_registers_i.pc_if_i\[3\] _06511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20927_ _06511_ _00812_ _06512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20928_ cs_registers_i.pc_if_i\[4\] cs_registers_i.pc_if_i\[5\]
+ cs_registers_i.pc_if_i\[6\] _06513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20929_ cs_registers_i.pc_if_i\[7\] _06513_ _06514_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20930_ cs_registers_i.pc_if_i\[8\] _06514_ _06515_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20931_ cs_registers_i.pc_if_i\[9\] _06515_ _06516_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20932_ cs_registers_i.pc_if_i\[10\] _06516_ _06517_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20933_ net1393 _06500_ _06512_ _06517_ _06518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20934_ cs_registers_i.pc_if_i\[11\] _06518_ _06519_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_20935_ _06202_ _06519_ net1589 _02981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput136 irq_fast_i[0] net135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20937_ cs_registers_i.pc_if_i\[11\] _06517_ _06521_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20938_ _01133_ _06522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20939_ net2026 _01134_ _10034_ _06523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20940_ _06522_ _06523_ _06511_ _06524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20941_ _06521_ _06524_ _06525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20942_ net1383 _06525_ cs_registers_i.pc_if_i\[12\] net1581
+ _06526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_20943_ cs_registers_i.pc_if_i\[12\] net1589 net1383 _06525_
+ _06527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20944_ _06214_ _06526_ _06527_ _02982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xinput135 irq_external_i net134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20946_ cs_registers_i.pc_if_i\[12\] _06512_ _06521_ _06529_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20947_ net1383 _06529_ _06530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20948_ cs_registers_i.pc_if_i\[13\] net1589 _06531_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20949_ cs_registers_i.pc_if_i\[13\] _06532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput134 instr_rvalid_i net133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20951_ _06532_ net1589 net1383 _06529_ _06534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_20952_ net1589 _06219_ _06224_ _06535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20953_ _06530_ _06531_ _06534_ _06535_ _02983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_20954_ cs_registers_i.pc_if_i\[14\] _06536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20955_ cs_registers_i.pc_if_i\[12\] _06521_ _06524_ _06537_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20956_ _06532_ _06537_ _06242_ _06538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20957_ net1581 net1383 _06538_ _06539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20958_ cs_registers_i.pc_if_i\[13\] cs_registers_i.pc_if_i\[14\]
+ _06540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20959_ net1386 _06537_ _06540_ net1589 _06541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20960_ _06536_ _06539_ _06541_ _06242_ _02984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20961_ cs_registers_i.pc_if_i\[13\] cs_registers_i.pc_if_i\[14\]
+ _06542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20962_ net1393 _06500_ _06529_ _06542_ _06543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20963_ cs_registers_i.pc_if_i\[15\] _06543_ _06544_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20964_ net1581 _06544_ _06249_ _02985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20965_ cs_registers_i.pc_if_i\[16\] _06545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20966_ net1581 _06259_ _06546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20967_ cs_registers_i.pc_if_i\[15\] _06547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20968_ _06547_ _06537_ _06540_ _06548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_20969_ _06546_ _06548_ _06549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20970_ net1581 net1383 _06549_ _06550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput133 instr_rdata_i[9] net132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_20972_ _06545_ net1386 _06548_ net1589 _06552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20973_ _06545_ _06550_ _06552_ _06546_ _02986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20974_ cs_registers_i.pc_if_i\[17\] _06553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20975_ cs_registers_i.pc_if_i\[15\] _06529_ _06542_ _06554_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_20976_ cs_registers_i.pc_if_i\[16\] _06554_ _06555_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20977_ net1581 net1383 _06555_ _06266_ _06556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_20978_ cs_registers_i.pc_if_i\[16\] cs_registers_i.pc_if_i\[17\]
+ _06554_ _06557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_20979_ net1386 _06557_ net1589 _06558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20980_ _06266_ _06559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20981_ _06553_ _06556_ _06558_ _06559_ _02987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20982_ cs_registers_i.pc_if_i\[18\] _06560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20983_ cs_registers_i.pc_if_i\[16\] cs_registers_i.pc_if_i\[17\]
+ _06561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_20984_ net1589 _06277_ _06562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20985_ _06548_ _06561_ _06562_ _06563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20986_ net1581 net1383 _06563_ _06564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_20987_ _06560_ _06561_ _06565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20988_ net1386 _06548_ _06565_ net1589 _06566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20989_ _06560_ _06564_ _06566_ _06562_ _02988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_20990_ _06560_ _06561_ _06567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_20991_ net1393 _06500_ _06554_ _06567_ _06568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_20992_ cs_registers_i.pc_if_i\[19\] _06568_ _06569_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_20993_ net1589 _06569_ _06287_ _02989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_20994_ cs_registers_i.pc_if_i\[20\] _06570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20995_ cs_registers_i.pc_if_i\[19\] _06567_ _06571_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_20996_ _06571_ _06572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_20997_ _06548_ _06572_ _06573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_20998_ _06570_ net1386 _06573_ net1589 _06574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_20999_ _06299_ _06573_ _06575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21000_ net1581 net1383 _06575_ _06576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21001_ _06299_ _06574_ _06576_ _06570_ _02990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21002_ _00809_ _00813_ net1384 _06577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21003_ _10012_ _06577_ _09991_ _02991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21004_ cs_registers_i.pc_if_i\[21\] _06578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21005_ cs_registers_i.pc_if_i\[20\] _06554_ _06571_ _06579_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21006_ net1581 _06311_ _06580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21007_ net1581 net1383 _06579_ _06580_ _06581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_21008_ net1410 net1809 _06582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21009_ _06582_ _06310_ _06583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput132 instr_rdata_i[8] net131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21011_ cs_registers_i.pc_if_i\[20\] cs_registers_i.pc_if_i\[21\]
+ _06571_ _06585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21012_ net1393 _06500_ _06554_ _06585_ _06586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21013_ _06583_ _06586_ net1589 _06587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21014_ _06578_ _06581_ _06587_ _02992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21015_ cs_registers_i.pc_if_i\[22\] _06588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput131 instr_rdata_i[7] net130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21017_ _06570_ _06578_ _06573_ _06590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21018_ _06322_ _06590_ _06591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21019_ net1581 net1383 _06591_ _06592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21020_ _06588_ net1386 _06590_ net1589 _06593_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21021_ _06588_ _06592_ _06593_ _06322_ _02993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21022_ cs_registers_i.pc_if_i\[23\] _06594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21023_ cs_registers_i.pc_if_i\[20\] cs_registers_i.pc_if_i\[21\]
+ _06554_ _06571_ _06595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_21024_ net1581 _06331_ _06596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21025_ _06588_ _06595_ _06596_ _06597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21026_ net1581 net1383 _06597_ _06598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21027_ cs_registers_i.pc_if_i\[22\] cs_registers_i.pc_if_i\[23\]
+ _06599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21028_ net1386 _06595_ _06599_ net1589 _06600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21029_ _06594_ _06598_ _06600_ _06596_ _02994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21030_ cs_registers_i.pc_if_i\[24\] _06601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21031_ _06590_ _06599_ _06341_ _06602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21032_ net1581 net1383 _06602_ _06603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21033_ _06601_ _06599_ _06604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21034_ net1386 _06590_ _06604_ net1589 _06605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21035_ _06601_ _06603_ _06605_ _06341_ _02995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21036_ cs_registers_i.pc_if_i\[25\] _06606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21037_ _06595_ _06604_ net2276 _06607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21038_ net1581 net1383 _06607_ _06608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21039_ _06606_ _06604_ _06609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21040_ net1386 _06595_ _06609_ net1589 _06610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21041_ _06606_ _06608_ _06610_ net2276 _02996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21042_ cs_registers_i.pc_if_i\[26\] _06611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21043_ _06590_ _06609_ _06364_ _06612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21044_ net1581 net1383 _06612_ _06613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21045_ _06611_ _06609_ _06614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21046_ _06614_ _06615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21047_ _06590_ _06615_ _06616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21048_ net1386 _06616_ net1589 _06617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21049_ _06611_ _06613_ _06617_ _06364_ _02997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21050_ cs_registers_i.pc_if_i\[27\] _06618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21051_ _06595_ _06615_ _06619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21052_ _06376_ _06619_ _06620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21053_ net1581 net1383 _06620_ _06621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21054_ _06618_ net1386 _06619_ net1589 _06622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21055_ _06618_ _06621_ _06622_ _06376_ _02998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21056_ cs_registers_i.pc_if_i\[28\] _06623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21057_ _06618_ _06616_ net2480 _06624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21058_ net1581 net1383 _06624_ _06625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21059_ cs_registers_i.pc_if_i\[27\] cs_registers_i.pc_if_i\[28\]
+ _06626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21060_ _06615_ _06626_ _06627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21061_ net1386 _06590_ _06627_ net1589 _06628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21062_ _06623_ _06625_ _06628_ net2480 _02999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21063_ cs_registers_i.pc_if_i\[29\] _06629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21064_ _06619_ _06626_ _06400_ _06630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21065_ net1581 net1383 _06630_ _06631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21066_ _06629_ _06626_ _06632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21067_ net1386 _06619_ _06632_ net1589 _06633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21068_ _06629_ _06631_ _06633_ _06400_ _03000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21069_ cs_registers_i.pc_if_i\[30\] _06634_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21070_ _06616_ _06632_ _06412_ _06635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21071_ net1581 net1383 _06635_ _06636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21072_ _06634_ _06632_ _06637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21073_ _06614_ _06637_ _06638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21074_ net1386 _06590_ _06638_ net1589 _06639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21075_ _06634_ _06636_ _06639_ _06412_ _03001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21076_ _10012_ _10009_ _06640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21077_ _06511_ _00812_ net1385 net1589 _06641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21078_ _00812_ _06640_ _06642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21079_ _10012_ net1384 _06642_ _06643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21080_ _06640_ _06641_ _06643_ _06511_ _03002_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21081_ cs_registers_i.pc_if_i\[31\] _06644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21082_ _06634_ _06619_ _06632_ _06422_ _06645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21083_ net1581 net1383 _06645_ _06646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21084_ cs_registers_i.pc_if_i\[31\] _06637_ _06647_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21085_ net1386 _06619_ _06647_ net1589 _06648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21086_ _06644_ _06646_ _06648_ _06422_ _03003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21087_ net1384 _06524_ _06649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21088_ cs_registers_i.pc_if_i\[4\] net1589 _06650_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21089_ net1384 _06524_ cs_registers_i.pc_if_i\[4\] _10012_
+ _06651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21090_ _06649_ _06650_ _06651_ _06164_ _03004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21091_ cs_registers_i.pc_if_i\[4\] net1393 _06500_ _06512_
+ _06652_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21092_ cs_registers_i.pc_if_i\[5\] _06652_ _06653_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_21093_ net1589 _06653_ _06169_ _03005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21094_ cs_registers_i.pc_if_i\[4\] cs_registers_i.pc_if_i\[5\]
+ _06524_ _06654_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_21095_ _06429_ _06654_ _06655_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21096_ _10012_ net1384 _06655_ _06656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21097_ cs_registers_i.pc_if_i\[6\] _06657_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21098_ _06429_ net1384 _06513_ _06524_ _06658_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21099_ _10012_ _06429_ _06656_ _06657_ _06658_ _03006_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21100_ net1393 _06500_ _06512_ _06513_ _06659_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21101_ cs_registers_i.pc_if_i\[7\] _06659_ _06660_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_21102_ _06185_ _06660_ net1589 _03007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21103_ net1393 _06500_ _06514_ _06524_ _06661_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21104_ cs_registers_i.pc_if_i\[8\] _06661_ _06662_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_21105_ _10012_ _06435_ _06663_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21106_ net1589 _06662_ _06663_ _03008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21107_ net1393 _06500_ _06512_ _06515_ _06664_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21108_ cs_registers_i.pc_if_i\[9\] _06664_ _06665_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_21109_ _06159_ _06665_ net1589 _03009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21110_ net1393 _06500_ _06516_ _06524_ _06666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21111_ cs_registers_i.pc_if_i\[10\] _06666_ _06667_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_21112_ _06151_ _06668_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21113_ net1589 _06667_ _06668_ _03010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21114_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ _06669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21115_ _06450_ net1393 _06457_ _06670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21116_ _06469_ _06670_ _10023_ _06671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput130 instr_rdata_i[6] net129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput129 instr_rdata_i[5] net128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21119_ net101 _06674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21120_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ _06675_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21121_ _06674_ _06675_ net2024 _06676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21122_ net1393 _06457_ _10023_ _06677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21123_ _10023_ net1393 _06457_ _06678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21124_ net1393 net1501 _06679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21125_ net1819 _06677_ _06678_ _06679_ _06680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
Xinput128 instr_rdata_i[4] net127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput127 instr_rdata_i[3] net126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21128_ _06669_ net1819 _06679_ _06683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21129_ _06669_ _06671_ _06676_ _06680_ _06683_ _03011_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21130_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ _06684_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput126 instr_rdata_i[31] net125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21132_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ net2024 _06686_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21133_ _06686_ _06687_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21134_ _06684_ net1819 _06679_ _06688_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21135_ _06684_ _06671_ _06680_ _06687_ _06688_ _03012_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21136_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ _06689_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21137_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ net2024 _06690_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21138_ _06690_ _06691_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21139_ _06689_ net1819 _06679_ _06692_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21140_ _06689_ _06671_ _06680_ _06691_ _06692_ _03013_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21141_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ _06693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21142_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ net2024 _06694_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21143_ _06694_ _06695_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21144_ _06693_ net1819 _06679_ _06696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21145_ _06693_ _06671_ _06680_ _06695_ _06696_ _03014_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21146_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ _06697_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21147_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ net2024 _06698_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21148_ _06698_ _06699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput125 instr_rdata_i[30] net124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21150_ _06697_ net1819 _06679_ _06701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21151_ _06697_ _06671_ _06680_ _06699_ _06701_ _03015_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21152_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ _06702_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21153_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ net2024 _06703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21154_ _06703_ _06704_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput124 instr_rdata_i[2] net123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21156_ _06702_ net1819 _06679_ _06706_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21157_ _06702_ _06671_ _06680_ _06704_ _06706_ _03016_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21158_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ _06707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21159_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ net2024 _06708_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21160_ _06708_ _06709_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21161_ _06707_ net1819 _06679_ _06710_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21162_ _06707_ _06671_ _06680_ _06709_ _06710_ _03017_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21163_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ _06711_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21164_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ _06712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21165_ _06711_ _06712_ _06467_ _06713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21166_ _10023_ net2024 _06712_ _06444_ _06714_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21167_ net108 _06715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21168_ _10023_ _06715_ _06450_ _06444_ _06716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21169_ net2025 _06715_ _06450_ _06444_ _06717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput123 instr_rdata_i[29] net122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21171_ _06716_ _06717_ net1387 _06719_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21172_ _06460_ _06713_ _06714_ _06719_ _03018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xinput122 instr_rdata_i[28] net121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput121 instr_rdata_i[27] net120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21175_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ net1394 net1501 _06722_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21176_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ net1382 _06722_ _06723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput120 instr_rdata_i[26] net119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput119 instr_rdata_i[25] net118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21179_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ net1819 _06476_ _06726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xinput118 instr_rdata_i[24] net117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21181_ net2025 net109 net2024 net1819 _06728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
Xinput117 instr_rdata_i[23] net116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput116 instr_rdata_i[22] net115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21184_ _10023_ net109 net2024 net1819 _06731_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21185_ _06728_ _06731_ net1387 _06732_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21186_ _06460_ _06723_ _06726_ _06732_ _03019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21187_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ net1394 net1501 _06733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21188_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ net1382 _06733_ _06734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21189_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ net1819 _06476_ _06735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21190_ net2025 net110 net2024 net1819 _06736_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21191_ _10023_ net110 net2024 net1819 _06737_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21192_ _06736_ _06737_ net1387 _06738_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21193_ _06460_ _06734_ _06735_ _06738_ _03020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21194_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ net1394 net1501 _06739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21195_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ net1382 _06739_ _06740_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21196_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ net1819 _06476_ _06741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21197_ net2025 net111 net2024 net1819 _06742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
Xinput115 instr_rdata_i[21] net114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21199_ _10023_ net111 net2024 net1819 _06744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21200_ _06742_ _06744_ net1387 _06745_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21201_ _06460_ _06740_ _06741_ _06745_ _03021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21202_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ _06746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21203_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ net2024 _06747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21204_ _06747_ _06748_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21205_ _06746_ net1819 _06679_ _06749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21206_ _06746_ _06671_ _06680_ _06748_ _06749_ _03022_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21207_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ net1394 net1501 _06750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21208_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ net1382 _06750_ _06751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21209_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ net1819 _06476_ _06752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xinput114 instr_rdata_i[20] net113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21211_ net2025 net113 net2024 net1819 _06754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21212_ _10023_ net113 net2024 net1819 _06755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21213_ _06754_ _06755_ net1387 _06756_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21214_ _06460_ _06751_ _06752_ _06756_ _03023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21215_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ net1394 net1501 _06757_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21216_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ net1382 _06757_ _06758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21217_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ net1819 _06476_ _06759_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21218_ net2025 net114 net2024 net1819 _06760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21219_ _10023_ net114 net2024 net1819 _06761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21220_ _06760_ _06761_ net1387 _06762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21221_ _06460_ _06758_ _06759_ _06762_ _03024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21222_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ net1394 net1501 _06763_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21223_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ net1382 _06763_ _06764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21224_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ net1819 _06476_ _06765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21225_ net2025 net115 net2024 net1819 _06766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21226_ _10023_ net115 net2024 net1819 _06767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21227_ _06766_ _06767_ net1387 _06768_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21228_ _06460_ _06764_ _06765_ _06768_ _03025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21229_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ net1394 net1501 _06769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21230_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ net1382 _06769_ _06770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21231_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ net1819 _06476_ _06771_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21232_ net2025 net116 net2024 net1819 _06772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21233_ _10023_ net116 net2024 net1819 _06773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21234_ _06772_ _06773_ net1387 _06774_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21235_ _06460_ _06770_ _06771_ _06774_ _03026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21236_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ net1394 net1501 _06775_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21237_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ net1382 _06775_ _06776_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21238_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ net1819 _06476_ _06777_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21239_ net2025 net117 net2024 net1819 _06778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21240_ _10023_ net117 net2024 net1819 _06779_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21241_ _06778_ _06779_ net1387 _06780_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21242_ _06460_ _06776_ _06777_ _06780_ _03027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21243_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ net1394 net1501 _06781_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21244_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ net1382 _06781_ _06782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21245_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ net1819 _06476_ _06783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21246_ net2025 net118 net2024 net1819 _06784_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21247_ _10023_ net118 net2024 net1819 _06785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21248_ _06784_ _06785_ net1387 _06786_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21249_ _06460_ _06782_ _06783_ _06786_ _03028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21250_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ net1394 net1501 _06787_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21251_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ net1382 _06787_ _06788_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21252_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ net1819 _06476_ _06789_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21253_ net2025 net119 net2024 net1819 _06790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21254_ _10023_ net119 net2024 net1819 _06791_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21255_ _06790_ _06791_ net1387 _06792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21256_ _06460_ _06788_ _06789_ _06792_ _03029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21257_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ net1394 net1501 _06793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21258_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ net1382 _06793_ _06794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21259_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ net1819 _06476_ _06795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21260_ net2025 net120 net2024 net1819 _06796_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21261_ _10023_ net120 net2024 net1819 _06797_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21262_ _06796_ _06797_ net1387 _06798_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21263_ _06460_ _06794_ _06795_ _06798_ _03030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21264_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ net1394 net1501 _06799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21265_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ net1382 _06799_ _06800_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21266_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ net1819 _06476_ _06801_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21267_ net2025 net121 net2024 net1819 _06802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21268_ _10023_ net121 net2024 net1819 _06803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21269_ _06802_ _06803_ net1387 _06804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21270_ _06460_ _06800_ _06801_ _06804_ _03031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21271_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ net1394 net1501 _06805_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21272_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ net1382 _06805_ _06806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21273_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ net1819 _06476_ _06807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21274_ net2025 net122 net2024 net1819 _06808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21275_ _10023_ net122 net2024 net1819 _06809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21276_ _06808_ _06809_ net1387 _06810_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21277_ _06460_ _06806_ _06807_ _06810_ _03032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21278_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ _06811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21279_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ net2024 _06812_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21280_ _06812_ _06813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21281_ _06811_ net1819 _06679_ _06814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21282_ _06811_ _06671_ _06680_ _06813_ _06814_ _03033_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21283_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ net1394 net1501 _06815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21284_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ net1382 _06815_ _06816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21285_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ net1819 _06476_ _06817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21286_ net2025 net124 net2024 net1819 _06818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21287_ _10023_ net124 net2024 net1819 _06819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21288_ _06818_ _06819_ net1387 _06820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21289_ _06460_ _06816_ _06817_ _06820_ _03034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21290_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ net1394 net1501 _06821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21291_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ net1382 _06821_ _06822_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21292_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ net1819 _06476_ _06823_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21293_ net2025 net125 net2024 net1819 _06824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21294_ _10023_ net125 net2024 net1819 _06825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21295_ _06824_ _06825_ net1387 _06826_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21296_ _06460_ _06822_ _06823_ _06826_ _03035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21297_ net101 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ net2023 _06827_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21298_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ _06827_ net1378 _03036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21299_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ net2023 _06828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21300_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ _06828_ net1378 _03037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21301_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ net2023 _06829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21302_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ _06829_ net1378 _03038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21303_ net126 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ net2023 _06830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21304_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ _06830_ net1378 _03039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21305_ net127 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ net2023 _06831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21306_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ _06831_ net1378 _03040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21307_ net128 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ net2023 _06832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21308_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ _06832_ net1378 _03041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21309_ net129 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ net2023 _06833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21310_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ _06833_ net1378 _03042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21311_ net130 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ net2023 _06834_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21312_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ _06834_ net1378 _03043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21313_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ _06835_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21314_ net126 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ net2024 _06836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21315_ _06836_ _06837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21316_ _06835_ net1819 _06679_ _06838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21317_ _06835_ _06671_ _06680_ _06837_ _06838_ _03044_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xinput113 instr_rdata_i[1] net112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21319_ net131 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ net2023 _06840_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21320_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ _06840_ net1378 _03045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21321_ net132 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ net2023 _06841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput112 instr_rdata_i[19] net111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21323_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ _06841_ net1378 _03046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21324_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ net2023 _06843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21325_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ _06843_ net1378 _03047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21326_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ net2023 _06844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21327_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ _06844_ net1378 _03048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21328_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ net2023 _06845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21329_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ _06845_ net1378 _03049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21330_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ net2023 _06846_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21331_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ _06846_ net1378 _03050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21332_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ net2023 _06847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21333_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ _06847_ net1378 _03051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21334_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ net2023 _06848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21335_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ _06848_ net1378 _03052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21336_ net108 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ net2023 _06849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21337_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ _06849_ net1378 _03053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21338_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ net2023 _06850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21339_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ _06850_ net1378 _03054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21340_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ _06851_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21341_ net127 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ net2024 _06852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21342_ _06852_ _06853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21343_ _06851_ net1819 _06679_ _06854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21344_ _06851_ _06671_ _06680_ _06853_ _06854_ _03055_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
Xinput111 instr_rdata_i[18] net110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21346_ net110 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ net2023 _06856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21347_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ _06856_ net1378 _03056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21348_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ net2023 _06857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput110 instr_rdata_i[17] net109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21350_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ _06857_ net1378 _03057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21351_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ net2023 _06859_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21352_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ _06859_ net1378 _03058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21353_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ net2023 _06860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21354_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ _06860_ net1378 _03059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21355_ net115 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ net2023 _06861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21356_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ _06861_ net1378 _03060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21357_ net116 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ net2023 _06862_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21358_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ _06862_ net1378 _03061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21359_ net117 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ net2023 _06863_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21360_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ _06863_ net1378 _03062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21361_ net118 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ net2023 _06864_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21362_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ _06864_ net1378 _03063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21363_ net119 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ net2023 _06865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21364_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ _06865_ net1378 _03064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21365_ net120 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ net2023 _06866_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21366_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ _06866_ net1378 _03065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21367_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ _06867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21368_ net128 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ net2024 _06868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21369_ _06868_ _06869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21370_ _06867_ net1819 _06679_ _06870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21371_ _06867_ _06671_ _06680_ _06869_ _06870_ _03066_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21372_ net121 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ net2023 _06871_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21373_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ _06871_ net1378 _03067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21374_ net122 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ net2023 _06872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21375_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ _06872_ net1378 _03068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21376_ net124 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ net2023 _06873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21377_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ _06873_ net1378 _03069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21378_ net125 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ net2023 _06874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21379_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ _06874_ net1378 _03070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21380_ net101 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ net1805 _03071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21381_ net112 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ net1805 _03072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21382_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ net1805 _03073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21383_ net126 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ net1805 _03074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21384_ net127 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ net1805 _03075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21385_ net128 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ net1805 _03076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21386_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ _06875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21387_ net129 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ net2024 _06876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21388_ _06876_ _06877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21389_ _06875_ net1819 _06679_ _06878_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21390_ _06875_ _06671_ _06680_ _06877_ _06878_ _03077_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21391_ net129 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ net1805 _03078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21392_ net130 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ net1805 _03079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21393_ net131 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ net1805 _03080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput109 instr_rdata_i[16] net108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21395_ net132 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ net1805 _03081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21396_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ net1805 _03082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21397_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ net1805 _03083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21398_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ net1805 _03084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21399_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ net1805 _03085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21400_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ net1805 _03086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21401_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ net1805 _03087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21402_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ _06880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21403_ net130 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ net2024 _06881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21404_ _06881_ _06882_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21405_ _06880_ net1819 _06679_ _06883_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21406_ _06880_ _06671_ _06680_ _06882_ _06883_ _03088_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21407_ net108 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ net1805 _03089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21408_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ net1805 _03090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21409_ net110 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ net1805 _03091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput108 instr_rdata_i[15] net107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21411_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ net1805 _03092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21412_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ net1805 _03093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21413_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ net1805 _03094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21414_ net115 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ net1805 _03095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21415_ net116 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ net1805 _03096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21416_ net117 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ net1805 _03097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21417_ net118 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ net1805 _03098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21418_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ _06885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21419_ net131 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ net2024 _06886_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21420_ _06886_ _06887_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21421_ _06885_ net1819 _06679_ _06888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21422_ _06885_ _06671_ _06680_ _06887_ _06888_ _03099_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21423_ net119 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ net1805 _03100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21424_ net120 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ net1805 _03101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21425_ net121 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ net1805 _03102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21426_ net122 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ net1805 _03103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21427_ net124 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ net1805 _03104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21428_ net125 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ net1805 _03105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21429_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ _06889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21430_ net132 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ net2024 _06890_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21431_ _06890_ _06891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21432_ _06889_ net1819 _06679_ _06892_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21433_ _06889_ _06671_ _06680_ _06891_ _06892_ _03106_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21434_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ _06153_ net1834 net224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21435_ net100 _10081_ _06893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput107 instr_rdata_i[14] net106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21437_ net224 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ _06893_ _03107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21438_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ _06203_ net1834 net225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21439_ net225 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ _06893_ _03108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21440_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ _06215_ net1834 net226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21441_ net226 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ _06893_ _03109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21442_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ _06226_ net1834 net227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21443_ net227 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ _06893_ _03110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21444_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ _06251_ net1834 net228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21445_ net228 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ _06893_ _03111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21446_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ _06250_ net1834 net229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21447_ net229 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ _06893_ _03112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21448_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ _06260_ net1834 net230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21449_ net230 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ _06893_ _03113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput106 instr_rdata_i[13] net105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21451_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ _06268_ net1834 net231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21452_ net231 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ _06893_ _03114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21453_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ _06279_ net1834 net232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21454_ net232 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ _06893_ _03115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21455_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ _06288_ net1834 net233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21456_ net233 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ _06893_ _03116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21457_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ _06380_ net1834 net234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput105 instr_rdata_i[12] net104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21459_ net234 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ _06893_ _03117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21460_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ _06312_ net1834 net235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21461_ net235 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ net1541 _03118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21462_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ _06333_ net1834 net236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21463_ net236 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ _06893_ _03119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21464_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ _06332_ net1834 net237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21465_ net237 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ _06893_ _03120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21466_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ _06354_ net1834 net238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21467_ net238 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ _06893_ _03121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21468_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ _06367_ net1834 net239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21469_ net239 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ _06893_ _03122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21470_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ _06366_ net1834 net240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21471_ net240 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ _06893_ _03123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput104 instr_rdata_i[11] net103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21473_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ _06377_ net1834 net241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21474_ net241 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ _06893_ _03124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21475_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ _06393_ net1834 net242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21476_ net242 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ _06893_ _03125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21477_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ _06402_ net1834 net243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21478_ net243 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ _06893_ _03126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21479_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ _01372_ net1834 net244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput103 instr_rdata_i[10] net102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21481_ net244 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ net1541 _03127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21482_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ _06414_ net1834 net245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21483_ net245 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ _06893_ _03128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21484_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ _06424_ net1834 net246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21485_ net246 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ _06893_ _03129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21486_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ _01374_ net1834 net247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21487_ net247 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ net1541 _03130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21488_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ _06165_ net1834 net248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21489_ net248 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ net1541 _03131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21490_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ _06170_ net1834 net249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21491_ net249 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ net1541 _03132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21492_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ _06431_ net1834 net250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21493_ net250 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ net1541 _03133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21494_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ _06186_ net1834 net251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21495_ net251 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ _06893_ _03134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21496_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ _06899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21497_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ _06440_ _06663_ _06899_ net252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21498_ net252 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ _06893_ _03135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21499_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ _06160_ net1834 net253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21500_ net253 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ net1541 _03136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21501_ net64 _09655_ _06900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21502_ _10129_ _06900_ net2087 _06901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21503_ net2086 load_store_unit_i.lsu_err_q _06902_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21504_ _06901_ _06902_ net2098 _06903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21505_ net31 _06903_ _06904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21506_ _07550_ _06900_ _06905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21507_ _06904_ _06905_ net2081 _06906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput102 instr_rdata_i[0] net101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput101 instr_gnt_i net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21510_ id_stage_i.controller_i.lsu_addr_last_i\[0\] alu_adder_result_ex\[0\]
+ net1513 _03220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21511_ id_stage_i.controller_i.lsu_addr_last_i\[10\] net1451
+ net1513 _03221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21512_ id_stage_i.controller_i.lsu_addr_last_i\[11\] net1457
+ net1513 _03222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21513_ id_stage_i.controller_i.lsu_addr_last_i\[12\] net2298
+ net1513 _03223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21514_ id_stage_i.controller_i.lsu_addr_last_i\[13\] net1450
+ net1513 _03224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21515_ id_stage_i.controller_i.lsu_addr_last_i\[14\] net2292
+ net1513 _03225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21516_ id_stage_i.controller_i.lsu_addr_last_i\[15\] net1448
+ net1513 _03226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21517_ id_stage_i.controller_i.lsu_addr_last_i\[16\] net1446
+ net1513 _03227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21518_ id_stage_i.controller_i.lsu_addr_last_i\[17\] net2288
+ net1513 _03228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21519_ id_stage_i.controller_i.lsu_addr_last_i\[18\] net1435
+ net1513 _03229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput100 instr_err_i net99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21521_ id_stage_i.controller_i.lsu_addr_last_i\[19\] net1436
+ net1513 _03230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21522_ id_stage_i.controller_i.lsu_addr_last_i\[1\] net1539
+ net1513 _03231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21523_ id_stage_i.controller_i.lsu_addr_last_i\[20\] net2278
+ net1513 _03232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21524_ id_stage_i.controller_i.lsu_addr_last_i\[21\] net1410
+ net1513 _03233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21525_ id_stage_i.controller_i.lsu_addr_last_i\[22\] net1432
+ net1513 _03234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21526_ id_stage_i.controller_i.lsu_addr_last_i\[23\] net169
+ net1513 _03235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21527_ id_stage_i.controller_i.lsu_addr_last_i\[24\] net2204
+ net1513 _03236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21528_ id_stage_i.controller_i.lsu_addr_last_i\[25\] net1431
+ net1513 _03237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21529_ id_stage_i.controller_i.lsu_addr_last_i\[26\] net1409
+ net1513 _03238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21530_ id_stage_i.controller_i.lsu_addr_last_i\[27\] net1429
+ net1513 _03239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput99 hart_id_i[9] net98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21532_ id_stage_i.controller_i.lsu_addr_last_i\[28\] net2138
+ net1513 _03240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21533_ id_stage_i.controller_i.lsu_addr_last_i\[29\] net2169
+ net1513 _03241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21534_ id_stage_i.controller_i.lsu_addr_last_i\[2\] net176
+ net1513 _03242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21535_ id_stage_i.controller_i.lsu_addr_last_i\[30\] net2122
+ net1513 _03243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21536_ id_stage_i.controller_i.lsu_addr_last_i\[31\] net2051
+ net1513 _03244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21537_ id_stage_i.controller_i.lsu_addr_last_i\[3\] net1519
+ net1513 _03245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21538_ id_stage_i.controller_i.lsu_addr_last_i\[4\] net1454
+ net1513 _03246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21539_ id_stage_i.controller_i.lsu_addr_last_i\[5\] net1499
+ net1513 _03247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21540_ id_stage_i.controller_i.lsu_addr_last_i\[6\] net1500
+ net1513 _03248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21541_ id_stage_i.controller_i.lsu_addr_last_i\[7\] net1512
+ net1513 _03249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21542_ id_stage_i.controller_i.lsu_addr_last_i\[8\] net1458
+ net1513 _03250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21543_ id_stage_i.controller_i.lsu_addr_last_i\[9\] net1459
+ net1513 _03251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21544_ _07557_ _07579_ net2149 _07711_ _06911_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21545_ _06911_ load_store_unit_i.data_sign_ext_q _10132_
+ _03252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21546_ _07616_ _10124_ _09538_ net223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21547_ net223 load_store_unit_i.data_we_q _10132_ _03253_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput98 hart_id_i[8] net97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21549_ net2022 _01360_ _06913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21550_ _08000_ _10125_ _06914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21551_ _06913_ net1520 _06914_ _06915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21552_ net2098 _06915_ _06916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21553_ net31 _06917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21554_ _07552_ net64 _06918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21555_ load_store_unit_i.ls_fsm_cs\[1\] _06917_ _06918_
+ _06919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_21556_ load_store_unit_i.ls_fsm_cs\[1\] _06916_ _06919_
+ _06920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21557_ net2098 _10129_ net31 _06921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21558_ net31 _06918_ net2087 _06922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21559_ _06921_ _06922_ net2081 _06923_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21560_ load_store_unit_i.handle_misaligned_q _06920_ _06923_
+ _03254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21561_ net64 _10129_ _07652_ _06924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21562_ net2098 _06924_ _06925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21563_ _07553_ _06917_ _06925_ _03255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21564_ _10129_ _06916_ load_store_unit_i.ls_fsm_cs\[1\]
+ _06926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21565_ net31 _06926_ _06927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21566_ _10129_ _06915_ net2098 _06928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21567_ load_store_unit_i.ls_fsm_cs\[1\] _06917_ _06928_
+ _06929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21568_ _06927_ _06929_ net2081 _03256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21569_ _07553_ _10131_ net2087 _06930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21570_ net2098 net64 _06930_ _03257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21571_ _07652_ net64 _06931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21572_ _06924_ _06931_ net2081 _06932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21573_ _07552_ _06932_ _06933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21574_ net2081 net2086 _06934_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_21575_ _06918_ _06934_ _06935_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21576_ _09656_ _06933_ _06935_ _09655_ _03258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_21577_ alu_adder_result_ex\[0\] net1887 _10132_ _03259_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21578_ net1539 net1886 _10132_ _03260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21579_ load_store_unit_i.data_we_q _06935_ _06936_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput97 hart_id_i[7] net96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21581_ net62 load_store_unit_i.rdata_q\[0\] net1745 _03261_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21582_ net41 load_store_unit_i.rdata_q\[10\] net1745 _03262_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21583_ net42 load_store_unit_i.rdata_q\[11\] net1745 _03263_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21584_ net44 load_store_unit_i.rdata_q\[12\] net1745 _03264_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21585_ net45 load_store_unit_i.rdata_q\[13\] net1745 _03265_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21586_ net46 load_store_unit_i.rdata_q\[14\] net1745 _03266_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21587_ net47 load_store_unit_i.rdata_q\[15\] net1745 _03267_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21588_ net48 load_store_unit_i.rdata_q\[16\] net1745 _03268_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21589_ net49 load_store_unit_i.rdata_q\[17\] net1745 _03269_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21590_ net50 load_store_unit_i.rdata_q\[18\] net1745 _03270_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput96 hart_id_i[6] net95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21592_ net51 load_store_unit_i.rdata_q\[19\] net1745 _03271_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21593_ net63 load_store_unit_i.rdata_q\[1\] net1745 _03272_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21594_ net52 load_store_unit_i.rdata_q\[20\] net1745 _03273_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21595_ net53 load_store_unit_i.rdata_q\[21\] net1745 _03274_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21596_ net55 load_store_unit_i.rdata_q\[22\] net1745 _03275_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21597_ net56 load_store_unit_i.rdata_q\[23\] net1745 _03276_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21598_ net33 load_store_unit_i.rdata_q\[2\] net1745 _03277_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21599_ net34 load_store_unit_i.rdata_q\[3\] net1745 _03278_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21600_ net35 load_store_unit_i.rdata_q\[4\] net1745 _03279_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21601_ net36 load_store_unit_i.rdata_q\[5\] net1745 _03280_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21602_ net37 load_store_unit_i.rdata_q\[6\] net1745 _03281_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21603_ net38 load_store_unit_i.rdata_q\[7\] net1745 _03282_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21604_ net39 load_store_unit_i.rdata_q\[8\] net1745 _03283_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21605_ net40 load_store_unit_i.rdata_q\[9\] net1745 _03284_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21606_ cs_registers_i.priv_mode_id_o\[0\] net1588 net1707
+ cs_registers_i.mstack_q\[0\] _06939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21607_ net1746 net1588 _06940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21608_ _07773_ net1702 _09635_ _09568_ _06941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_21609_ _10371_ _10193_ _06941_ _06942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21610_ _06940_ _06942_ _06943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21611_ _03471_ _10404_ net1588 net1746 _06944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21612_ _06943_ _06944_ _06945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21613_ cs_registers_i.mstatus_q\[2\] _04146_ _06945_ _06946_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21614_ _06939_ _06946_ _01751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21615_ cs_registers_i.priv_mode_id_o\[1\] net1588 net1707
+ cs_registers_i.mstack_q\[1\] _06947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21616_ _04146_ _06944_ _06948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21617_ cs_registers_i.mstatus_q\[3\] _06948_ _06945_ _06949_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21618_ _06947_ _06949_ _01752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21619_ _09939_ cs_registers_i.mstack_q\[2\] _06950_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21620_ cs_registers_i.csr_mstatus_mie_o net1588 _06950_
+ net1746 _06943_ _06951_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21621_ _04146_ _06952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21622_ _10984_ _06952_ _06940_ _06953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21623_ cs_registers_i.mstatus_q\[4\] _06954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21624_ _06954_ _06952_ _06940_ _06955_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21625_ _06951_ _06953_ _06955_ _01753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21626_ cs_registers_i.csr_mstatus_mie_o _06943_ _06956_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21627_ cs_registers_i.mstatus_q\[4\] net1746 _06957_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21628_ _10891_ _04015_ _04146_ _06958_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21629_ _06956_ _06957_ _06958_ _01754_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21630_ cs_registers_i.pc_if_i\[1\] _06959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput95 hart_id_i[5] net94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21632_ _06674_ _06669_ net2025 _06961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21633_ _06715_ _06711_ net2025 _06962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21634_ net2026 _06962_ _06963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21635_ _06959_ _06961_ _06963_ _06964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput94 hart_id_i[4] net93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21637_ net2025 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ _10024_ _06966_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21638_ net109 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ net2025 _06967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21639_ net2026 _06967_ _06968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21640_ net2026 _06966_ _06968_ _06969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput93 hart_id_i[3] net92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21642_ net125 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ net2025 _06971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21643_ net107 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ net2025 _06972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21644_ _06971_ _06972_ _06959_ _06973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput92 hart_id_i[31] net91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput91 hart_id_i[30] net90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21647_ net121 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ net2025 _06976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21648_ net104 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ net2025 _06977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21649_ _06959_ _06977_ _06978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21650_ net2026 _06976_ _06978_ _06979_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21651_ net131 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ net2025 _06980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21652_ net117 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ net2025 _06981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21653_ _06980_ _06981_ net2026 _06982_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput90 hart_id_i[2] net89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21655_ net132 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ net2025 _06984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21656_ net118 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ net2025 _06985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21657_ _06984_ _06985_ net2026 _06986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput89 hart_id_i[29] net88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21659_ net130 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ net2025 _06988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21660_ net116 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ net2025 _06989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21661_ _06988_ _06989_ net2026 _06990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21662_ net119 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ net2025 _06991_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21663_ net102 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ net2025 _06992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21664_ _06991_ _06992_ _06959_ _06993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21665_ net120 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ net2025 _06994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21666_ net103 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ net2025 _06995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21667_ _06994_ _06995_ _06959_ _06996_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21668_ _06993_ _06996_ _06997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21669_ _06982_ _06986_ _06990_ _06997_ _06998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_21670_ net124 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ net2025 _06999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21671_ net106 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ net2025 _07000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21672_ _06999_ _07000_ _06959_ _07001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput88 hart_id_i[28] net87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21674_ _06979_ _06998_ _07001_ _07003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21675_ _06976_ _06977_ _06959_ _07004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput87 hart_id_i[27] net86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput86 hart_id_i[26] net85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21678_ _06959_ _06972_ _07007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21679_ net2026 _06971_ _07007_ _07008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput85 hart_id_i[25] net84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21681_ net111 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ net2025 _07010_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21682_ net126 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ net2025 _07011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21683_ _07010_ _07011_ _06959_ _07012_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput84 hart_id_i[24] net83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21685_ net115 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ net2025 _07014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21686_ net129 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ net2025 _07015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21687_ _07014_ _07015_ _06959_ _07016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21688_ net114 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ net2025 _07017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21689_ net128 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ net2025 _07018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21690_ _07017_ _07018_ _06959_ _07019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21691_ _07016_ _07019_ _07020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21692_ net113 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ net2025 _07021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21693_ net127 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ net2025 _07022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21694_ _07021_ _07022_ _06959_ _07023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput83 hart_id_i[23] net82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21696_ net110 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ net2025 _07025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21697_ net123 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ net2025 _07026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21698_ _07025_ _07026_ _06959_ _07027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21699_ _07012_ _07020_ _07023_ _07027_ _07028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_21700_ _06959_ _07000_ _07029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21701_ net2026 _06999_ _07029_ _07030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21702_ _07028_ net1804 _07031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21703_ _07004_ _07008_ _06998_ _07031_ _07032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_21704_ _06973_ _07003_ _07032_ _07033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput82 hart_id_i[22] net81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21706_ _06967_ _07035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21707_ _06966_ _07035_ net2026 _07036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput81 hart_id_i[21] net80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21709_ _07004_ _07020_ _06998_ _07008_ _07038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21710_ net1804 _07036_ _07038_ _07039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21711_ net122 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ net2025 _07040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21712_ net105 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ net2025 _07041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21713_ _07040_ _07041_ _06959_ _07042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput80 hart_id_i[20] net79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput79 hart_id_i[1] net78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21716_ net1743 _07033_ _07039_ _07042_ _07045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21717_ _07008_ _07001_ _07046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21718_ _07042_ _07046_ _07047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21719_ _06979_ _07028_ _07047_ _07048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput78 hart_id_i[19] net77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21721_ _06959_ _07041_ _07050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21722_ net2026 _07040_ _07050_ _07051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21723_ _07051_ net1804 _07052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21724_ _06973_ _07052_ _07053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21725_ _06959_ _06992_ _07054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21726_ net2026 _06991_ _07054_ _07055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput77 hart_id_i[18] net76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput76 hart_id_i[17] net75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21729_ _07055_ _06996_ _07058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21730_ _07004_ _07053_ _07058_ _07059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21731_ net1744 _07036_ _07060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21732_ _07048_ _07059_ _07060_ _07061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21733_ net1744 _07045_ _07061_ _07062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21734_ id_stage_i.decoder_i.illegal_c_insn_i _07062_ net1384
+ _03137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21735_ net99 _10033_ _07063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21736_ _06450_ _07063_ _07064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21737_ net2026 _07064_ _10026_ _07065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21738_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _06451_ _07066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21739_ net2026 _06463_ _07067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21740_ net2024 _07066_ _07067_ _07068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21741_ _07065_ _07068_ _07069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21742_ id_stage_i.controller_i.instr_fetch_err_i _07069_
+ net1384 _03138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21743_ net2025 net99 _07070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21744_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ _07070_ _06450_ _07071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21745_ _07067_ _07071_ _07072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21746_ id_stage_i.controller_i.instr_fetch_err_plus2_i _07072_
+ net1384 _03139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21747_ net1744 net1743 _07073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21748_ id_stage_i.controller_i.instr_is_compressed_i _07073_
+ net1384 _03140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput75 hart_id_i[16] net74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21750_ id_stage_i.controller_i.instr_compressed_i\[0\] net1744
+ net1384 _03141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21751_ id_stage_i.controller_i.instr_compressed_i\[10\]
+ _06993_ net1384 _03142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21752_ id_stage_i.controller_i.instr_compressed_i\[11\]
+ _06996_ net1384 _03143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21753_ id_stage_i.controller_i.instr_compressed_i\[12\]
+ _07004_ net1384 _03144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21754_ id_stage_i.controller_i.instr_compressed_i\[13\]
+ _07042_ net1384 _03145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput74 hart_id_i[15] net73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21756_ id_stage_i.controller_i.instr_compressed_i\[14\]
+ _07001_ net1384 _03146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21757_ id_stage_i.controller_i.instr_compressed_i\[15\]
+ _06973_ net1384 _03147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21758_ id_stage_i.controller_i.instr_compressed_i\[1\] net1743
+ net1384 _03148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput73 hart_id_i[14] net72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21760_ id_stage_i.controller_i.instr_compressed_i\[2\] _07027_
+ net1384 _03149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21761_ id_stage_i.controller_i.instr_compressed_i\[3\] _07012_
+ net1384 _03150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput72 hart_id_i[13] net71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21763_ id_stage_i.controller_i.instr_compressed_i\[4\] _07023_
+ net1384 _03151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput71 hart_id_i[12] net70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21765_ id_stage_i.controller_i.instr_compressed_i\[5\] _07019_
+ net1384 _03152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput70 hart_id_i[11] net69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21767_ id_stage_i.controller_i.instr_compressed_i\[6\] _07016_
+ net1384 _03153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput69 hart_id_i[10] net68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21769_ id_stage_i.controller_i.instr_compressed_i\[7\] _06990_
+ net1384 _03154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21770_ id_stage_i.controller_i.instr_compressed_i\[8\] _06982_
+ net1384 _03155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21771_ id_stage_i.controller_i.instr_compressed_i\[9\] _06986_
+ net1384 _03156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput68 hart_id_i[0] net67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21773_ _06973_ net1804 _07082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21774_ _07036_ _07082_ _07042_ _07083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21775_ net1744 _07083_ _07084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21776_ id_stage_i.controller_i.instr_i\[0\] _07084_ net1384
+ _03157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21777_ _07042_ net1804 _07085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21778_ _06973_ _07052_ net1744 _07086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_21779_ _07051_ _07008_ _07087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput67 fetch_enable_i net66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21781_ _06961_ _06962_ net2026 _07089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput66 debug_req_i net65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput65 data_rvalid_i net64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21784_ _06993_ _07087_ _07089_ _07092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21785_ _07055_ _07085_ _07086_ _07092_ _07093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_21786_ _07028_ _07053_ _07094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21787_ _07089_ _07094_ _07055_ _07095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21788_ _07093_ _07095_ net1743 _07096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21789_ gen_regfile_ff.register_file_i.waddr_a_i\[3\] _07096_
+ net1384 _03158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21790_ net1804 _07087_ _07097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21791_ _07060_ _07097_ _07098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21792_ _07001_ _07098_ _06996_ _07099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21793_ _06993_ _06996_ _07100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21794_ _07004_ _07100_ _07101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21795_ _07053_ _07101_ _07102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput64 data_rdata_i[9] net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21797_ _07036_ _07102_ _07104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21798_ _07099_ _07104_ _07105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput63 data_rdata_i[8] net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21800_ _07087_ _07094_ net1743 _07107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21801_ _07089_ _07105_ _07107_ _07099_ _07108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_21802_ gen_regfile_ff.register_file_i.waddr_a_i\[4\] _07108_
+ net1384 _03159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput62 data_rdata_i[7] net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21804_ _06986_ _06990_ _06997_ _07110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_21805_ _06982_ _07110_ _07111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21806_ _07111_ _07112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21807_ _07047_ _07112_ _07113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21808_ _06993_ _06996_ _07114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21809_ _07016_ _07019_ _07114_ _07115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21810_ _07051_ _06973_ _07116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21811_ _06979_ _07087_ _07115_ _07116_ _07117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xinput61 data_rdata_i[6] net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21813_ _07042_ _06973_ _07001_ _07119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21814_ _07027_ _07113_ _07117_ net1804 _07119_ _07120_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21815_ net1804 _07087_ _07121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21816_ _07089_ net1743 _07122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21817_ _07051_ _07089_ _07123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21818_ _07042_ _07082_ _07124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21819_ _07089_ _07036_ _07125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21820_ _07124_ _07125_ _07126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21821_ _07036_ _07123_ _07126_ _07127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput60 data_rdata_i[5] net59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21823_ _07121_ _07122_ _07127_ _07004_ _07129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21824_ _07098_ _07120_ _07129_ _07130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21825_ net2021 _07130_ net1384 _03160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21826_ net1744 _07036_ _07131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21827_ _07016_ _07042_ _07004_ _07132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21828_ _07055_ _07132_ _07133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21829_ _07053_ _06996_ _07133_ _07134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21830_ _07012_ _07113_ _07134_ _07135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21831_ _07004_ net1804 net1743 _07136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput59 data_rdata_i[4] net58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21833_ _07052_ net1744 _07131_ _07135_ _07136_ _07051_ _07138_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
Xinput58 data_rdata_i[3] net57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21835_ id_stage_i.controller_i.instr_i\[13\] _07138_ net1384
+ _03161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21836_ _06979_ _07020_ _07140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21837_ _07100_ _07140_ _07141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21838_ _07004_ _07085_ _07113_ _07023_ _07141_ _07053_ _07142_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_21839_ net1744 net1743 _07143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21840_ _07042_ _07089_ _07143_ _07144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21841_ _07098_ _07142_ _07144_ net1804 _07145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_21842_ id_stage_i.controller_i.instr_i\[14\] _07145_ net1384
+ _03162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21843_ _07042_ _07100_ _07004_ _07146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21844_ _06973_ _07146_ _07001_ _07147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21845_ _06990_ _07147_ _07148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21846_ _06979_ _07085_ _07046_ _07149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21847_ _07019_ _07113_ _07148_ _07149_ _07150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21848_ _06990_ _07097_ _07151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21849_ _07131_ _07150_ _07151_ _07152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21850_ _07042_ _07152_ _07153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21851_ _07143_ _07153_ _07154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21852_ _07001_ _06990_ _07082_ net1743 _07155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21853_ _07004_ _07028_ _07053_ _07156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21854_ _07097_ _07156_ _07157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21855_ _07089_ net1743 _07158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21856_ _06990_ _07157_ _07158_ _07159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21857_ _07155_ _07159_ _07051_ _07160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21858_ _07131_ _07160_ _07161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21859_ _07008_ _07154_ _07161_ _07152_ _07162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21860_ net2017 _07162_ net1384 _03163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21861_ _06962_ _06676_ net2026 _07163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21862_ _07004_ _07028_ _07008_ _07164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21863_ _06982_ _07164_ _07165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21864_ _07042_ _07163_ _07165_ _07052_ _07166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21865_ net1743 _07166_ net1744 _07167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21866_ _07163_ _07168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21867_ _07004_ _07085_ _07102_ _07168_ _07121_ _07169_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21868_ _07016_ _07111_ _07047_ _07170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21869_ _07169_ _07170_ _07171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21870_ _06973_ _07001_ _07172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21871_ _07001_ _07116_ _07101_ _07172_ _07173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_21872_ _07171_ _07173_ _07174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21873_ _07097_ _07171_ _07174_ _06982_ net1743 _07175_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21874_ _07167_ _07175_ _07176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21875_ _07051_ _07001_ _07177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21876_ _07124_ _07163_ _07178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21877_ _06982_ _07177_ _07125_ _07178_ _07179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_21878_ _07143_ _07163_ _07176_ _07179_ _07180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21879_ net1965 _07180_ net1384 _03164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21880_ _06967_ _06747_ net2026 _07181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21881_ _06986_ _07157_ _07181_ _07042_ _07182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21882_ _07051_ _07001_ _07183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21883_ net1744 _07097_ _07184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21884_ net1744 _07183_ _07184_ _06986_ _07036_ _07185_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_21885_ _07085_ _07113_ _07186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21886_ _07004_ _07186_ _07187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21887_ _06986_ _07173_ _07188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21888_ _07102_ _07181_ _07189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21889_ _07184_ _07187_ _07188_ _07189_ _07190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21890_ _07073_ _07126_ _07191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21891_ _07191_ _07181_ _07192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21892_ _07158_ _07182_ _07185_ _07190_ _07192_ _07193_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_21893_ net1962 _07193_ net1384 _03165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21894_ _06993_ net1743 _07123_ _07157_ _07194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21895_ _07025_ _06812_ net2026 _07195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21896_ _07004_ _07100_ _07196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21897_ _07051_ _06973_ _07197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21898_ _07196_ _07195_ _07197_ _07198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21899_ _07097_ _07172_ _07187_ _07198_ _07199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21900_ _07055_ _07121_ _07199_ _07200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21901_ _07195_ _07200_ _07036_ _07201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21902_ _06973_ _07195_ _07183_ _07202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21903_ _07042_ _07195_ _07203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21904_ net1743 _07202_ _07203_ _07204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21905_ _07201_ _07204_ _07089_ _07205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21906_ _07194_ _07205_ _07206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21907_ net1960 _07206_ net1384 _03166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21908_ _07010_ _06836_ net2026 _07207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21909_ _06996_ _07121_ _07102_ _07207_ _07208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21910_ _07187_ _07208_ _07131_ _07209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21911_ _07127_ _07207_ _07210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21912_ _07052_ _06996_ _07122_ _07164_ _07211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21913_ _07209_ _07210_ _07211_ _07212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21914_ net1958 _07212_ net1384 _03167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21915_ net1744 _07124_ _07213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21916_ _07089_ _07102_ _07213_ _07036_ _07214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_21917_ id_stage_i.controller_i.instr_i\[1\] _07214_ net1384
+ _03168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21918_ net1743 _07123_ _07215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21919_ _07008_ net1804 _07216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21920_ _06979_ _06998_ _07217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21921_ _07028_ net1804 _07217_ _07218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21922_ _07027_ _07218_ _07051_ _07219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21923_ _07027_ _07001_ _07220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21924_ _07219_ _07220_ _07221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21925_ _07027_ _07216_ _07221_ _06973_ _07222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21926_ _07021_ _06852_ net2026 _07223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21927_ _07082_ _07196_ _07046_ _07224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21928_ _07042_ _07224_ _07225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21929_ _07004_ _07186_ _07223_ _07102_ _07225_ _07027_ _07226_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_21930_ _06973_ _07001_ _07227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21931_ _07216_ _07227_ _07089_ _07228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21932_ _07027_ _07051_ _07036_ _07228_ _07229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_21933_ _07127_ _07223_ _07229_ _07230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21934_ _07215_ _07222_ _07226_ _07098_ _07230_ _07231_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_21935_ net2104 _07231_ net1384 _03169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21936_ _07017_ _06868_ net2026 _07232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21937_ _07004_ _07113_ _07233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21938_ _07012_ _07225_ _07232_ _07102_ _07233_ _07234_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21939_ _07051_ _07089_ _07235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21940_ net1804 net1743 _07227_ _07236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21941_ _07001_ _07197_ _07131_ _07237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_21942_ _07235_ _07236_ _07237_ _07238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21943_ _07127_ _07232_ _07238_ _07012_ _07239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21944_ _07098_ _07234_ _07239_ _07240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21945_ net2078 _07240_ net1384 _03170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21946_ _07014_ _06876_ net2026 _07241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21947_ _07023_ _07225_ _07241_ _07102_ _07233_ _07242_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21948_ _07215_ _07237_ _07243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21949_ _07023_ _07001_ _07244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21950_ _07016_ _07244_ _06973_ _07245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21951_ _07051_ _07125_ _07245_ _07246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21952_ _07127_ _07241_ _07243_ _07023_ _07246_ _07247_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21953_ _07098_ _07242_ _07247_ _07248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput57 data_rdata_i[31] net56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_21955_ net1903 _07248_ net1384 _03171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21956_ _06989_ _06881_ net2026 _07250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21957_ _06979_ _07250_ _07251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21958_ _07019_ _07251_ _07100_ _07252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21959_ _07019_ _07046_ _07082_ _07252_ _07253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21960_ _07042_ _07253_ _07254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21961_ _07233_ _07254_ _07255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21962_ net1743 _07216_ _07123_ _07256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21963_ _07237_ _07256_ _07257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21964_ _07008_ _07055_ _07177_ _07258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21965_ _07019_ _07257_ _07258_ _07125_ _07250_ _07127_ _07259_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_21966_ _07098_ _07255_ _07259_ _07260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21967_ gen_regfile_ff.register_file_i.raddr_b_i\[3\] _07260_
+ net1384 _03172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21968_ _07047_ _07111_ _07087_ _07261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21969_ _07131_ _07261_ _07215_ _07262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21970_ _07016_ _07262_ _07263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21971_ _07087_ _07085_ net1744 _07264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21972_ _06996_ _07036_ _07264_ _07265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21973_ _06981_ _06886_ net2026 _07266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21974_ _07127_ _07266_ _07267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_21975_ _07053_ _07100_ _07266_ _07268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21976_ _07113_ _07268_ _07004_ _07269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21977_ _07016_ _07053_ _07114_ _07270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_21978_ _07269_ _07270_ _07098_ _07271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_21979_ _07263_ _07265_ _07267_ _07271_ _07272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_21980_ net1899 _07272_ net1384 _03173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21981_ _07004_ _07053_ _06996_ _07273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21982_ _06985_ _06890_ net2026 _07274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21983_ _07055_ _07274_ _07275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_21984_ _07047_ _07111_ _07276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21985_ _07085_ _07227_ _07277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_21986_ _07276_ _07277_ _07278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21987_ _07042_ _07111_ _07279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21988_ _07004_ _07046_ _07279_ _07280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21989_ _07273_ _07275_ _07278_ _07027_ _07280_ _07281_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_21990_ _07004_ _07060_ _07282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21991_ _07282_ _07283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_21992_ _07191_ _07274_ _07283_ _07121_ _07284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_21993_ _07042_ net1743 _07274_ _07285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_21994_ _07008_ _07036_ _07286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_21995_ net1804 _07286_ _06979_ _07042_ _07287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_21996_ _07285_ _07287_ _07089_ _07288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_21997_ _07098_ _07281_ _07284_ _07288_ _07289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_21998_ net1898 _07289_ net1384 _03174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_21999_ _07008_ _07279_ _07290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22000_ _07019_ _07001_ _07290_ _07291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22001_ _07042_ net1804 _06990_ _07292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22002_ _07291_ _07292_ _07293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_22003_ _06991_ _06686_ net2026 _07294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22004_ _07055_ _07294_ _06996_ net1804 _07295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_22005_ _06973_ _07295_ _07296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22006_ _07046_ _07112_ _07296_ _07051_ _07297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22007_ _07027_ _06990_ _06973_ _07298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22008_ _07042_ _07294_ _07298_ _07183_ _07299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22009_ _07158_ _07299_ _07300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_22010_ _07008_ _06990_ _07301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22011_ _07019_ _07301_ net1804 _07302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22012_ _07051_ _07125_ _07302_ _07303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22013_ _07191_ _07294_ _07300_ _07303_ _07304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_22014_ _07098_ _07293_ _07297_ _07282_ _07304_ _07305_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22015_ net1897 _07305_ net1384 _03175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22016_ _06994_ _06690_ net2026 _07306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22017_ _07012_ _06982_ _06973_ _07307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22018_ _07001_ _07307_ _07308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22019_ _07306_ _07308_ _07123_ _07309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22020_ _06982_ _07121_ _07124_ _07306_ _07310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22021_ _07085_ _07227_ _07311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22022_ _07012_ _07047_ _07111_ _07312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22023_ _07016_ _07311_ _07312_ _07313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22024_ _07087_ _07113_ _07004_ _07314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22025_ _07055_ _07306_ _07273_ _07315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22026_ net1744 _07313_ _07314_ _07315_ _07316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_22027_ _07089_ _07310_ _07316_ _07317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22028_ _07309_ _07317_ _07036_ _07318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22029_ net1896 _07318_ net1384 _03176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22030_ _07098_ _07282_ _07319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22031_ _06976_ _06694_ net2026 _07320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22032_ _07055_ _07320_ _07321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22033_ _07023_ _07004_ _07279_ _07322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22034_ _07042_ _06986_ _07087_ _07323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22035_ _06979_ _07172_ _07323_ _07001_ _07324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_22036_ _07273_ _07321_ _07322_ _07046_ _07324_ _07325_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22037_ _06986_ _07121_ _07124_ _07320_ _07326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22038_ _07125_ _07327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22039_ net1743 _07235_ _07320_ _07328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_22040_ _07319_ _07325_ _07326_ _07327_ _07328_ _07329_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22041_ net1895 _07329_ net1384 _03177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22042_ _07040_ _06698_ net2026 _07330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22043_ _07055_ _07330_ _07331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22044_ _07042_ _07055_ _07197_ _07001_ _07332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_22045_ _07004_ _07001_ _07273_ _07331_ _07332_ _07333_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22046_ _06993_ _07121_ _07125_ _07334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22047_ _07127_ _07330_ _07334_ _07335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22048_ _07319_ _07333_ _07335_ _07336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22049_ net1894 _07336_ net1384 _03178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22050_ _07027_ _07102_ _07186_ _07337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22051_ _07158_ _07217_ _07338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_22052_ _07027_ _07127_ _07338_ _07094_ _07339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22053_ _07098_ _07337_ _07339_ _07340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22054_ net2145 _07340_ net1384 _03179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22055_ _06999_ _06703_ net2026 _07341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22056_ _07020_ _06996_ _07055_ _07342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22057_ _07196_ _07341_ _07342_ _07004_ _06997_ _07343_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22058_ _07051_ _06982_ _07344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_22059_ _07197_ _07343_ _07344_ _07345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22060_ _07004_ _07345_ net1804 _07346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22061_ _07319_ _07347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22062_ _07127_ _07341_ _07346_ _07347_ net1385 _07348_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22063_ _07947_ net1385 _07348_ _03180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22064_ _06971_ _06708_ net2026 _07349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22065_ _07055_ _07349_ _06996_ _07350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22066_ _07053_ _07350_ _07282_ _07351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22067_ _07127_ _07349_ _07351_ net1385 _07352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_22068_ _08546_ net1385 _07352_ _03181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22069_ _07060_ _07102_ _07353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22070_ _07127_ _07353_ _07354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22071_ _07060_ _07085_ _07354_ _07012_ net1385 _07355_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22072_ _07560_ net1385 _07355_ _03182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22073_ _06973_ _07036_ _07042_ _07356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22074_ _07028_ net1743 _07357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22075_ _07197_ _07357_ _07358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22076_ _07023_ _07356_ _07358_ _07217_ _07177_ _07359_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22077_ _06973_ _07101_ net1743 _07360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22078_ net1743 _07277_ _07360_ _07023_ net1744 _07361_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22079_ net1744 _07359_ _07361_ _07362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22080_ net2189 _07362_ net1384 _03183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22081_ _07113_ _07363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22082_ _06979_ _07019_ _06973_ _07100_ _07364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_22083_ _07363_ _07277_ _07364_ _07365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22084_ _07042_ _07089_ _07036_ net1804 _07366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22085_ _06973_ _07235_ _07366_ _07019_ _07131_ _07367_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22086_ _07098_ _07365_ _07367_ _07368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22087_ _07019_ _07073_ _07368_ net1384 _07369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_22088_ _07581_ net1384 _07369_ _03184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22089_ _07016_ _07102_ _07311_ _07370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22090_ _07016_ _07042_ _07094_ _07371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22091_ _07131_ _07370_ _07371_ _07036_ _07372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_22092_ _07016_ _07191_ _07372_ _07073_ net1385 _07373_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22093_ _07566_ net1385 _07373_ _03185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22094_ _07227_ _07283_ _07374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22095_ _07060_ _07085_ _06990_ _07375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22096_ _06973_ _07375_ _07376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22097_ _07052_ _07131_ _06990_ _07377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22098_ _07374_ _07376_ _07377_ _07378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22099_ _07001_ _07357_ _06973_ _07379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22100_ _07286_ _07379_ _07235_ _07380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22101_ _07027_ _07036_ _07087_ _07381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22102_ _07004_ net1743 _06998_ _07094_ _07382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_22103_ _07381_ _07382_ _07089_ _07383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22104_ _07378_ _07380_ _07383_ _07384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput56 data_rdata_i[30] net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22106_ gen_regfile_ff.register_file_i.waddr_a_i\[0\] _07384_
+ net1384 _03186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22107_ _07087_ _07227_ net1744 _07386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22108_ _07012_ _07036_ _07386_ _07387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_22109_ _07124_ _07277_ net1744 _07388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22110_ _07235_ _07379_ _07388_ net1743 _06982_ _07389_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22111_ _07387_ _07389_ _07390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22112_ gen_regfile_ff.register_file_i.waddr_a_i\[1\] _07390_
+ net1384 _03187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22113_ _07023_ _07008_ _07227_ _07016_ _07391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22114_ _07042_ _07327_ _07391_ _07392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_22115_ _07052_ _06986_ _07244_ _07393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22116_ _07008_ _07131_ _07393_ _07394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_22117_ _06973_ _07123_ _07357_ _07395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22118_ _07042_ _07060_ _07395_ _07396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22119_ _07008_ _07124_ _07089_ _07397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22120_ _07001_ _07396_ _07397_ net1743 _06986_ _07398_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22121_ _07392_ _07394_ _07398_ _07399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_22122_ gen_regfile_ff.register_file_i.waddr_a_i\[2\] _07399_
+ net1384 _03188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22123_ cs_registers_i.pc_id_i\[10\] cs_registers_i.pc_if_i\[10\]
+ net1383 _03189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22124_ cs_registers_i.pc_id_i\[11\] cs_registers_i.pc_if_i\[11\]
+ net1383 _03190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22125_ cs_registers_i.pc_id_i\[12\] cs_registers_i.pc_if_i\[12\]
+ net1383 _03191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22126_ cs_registers_i.pc_id_i\[13\] cs_registers_i.pc_if_i\[13\]
+ net1383 _03192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22127_ cs_registers_i.pc_id_i\[14\] cs_registers_i.pc_if_i\[14\]
+ net1383 _03193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22128_ cs_registers_i.pc_id_i\[15\] cs_registers_i.pc_if_i\[15\]
+ net1383 _03194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22129_ cs_registers_i.pc_id_i\[16\] cs_registers_i.pc_if_i\[16\]
+ net1383 _03195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput55 data_rdata_i[2] net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22131_ cs_registers_i.pc_id_i\[17\] cs_registers_i.pc_if_i\[17\]
+ net1383 _03196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22132_ cs_registers_i.pc_id_i\[18\] cs_registers_i.pc_if_i\[18\]
+ net1383 _03197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22133_ cs_registers_i.pc_id_i\[19\] cs_registers_i.pc_if_i\[19\]
+ net1383 _03198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22134_ cs_registers_i.pc_id_i\[1\] net2026 net1384 _03199_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22135_ cs_registers_i.pc_id_i\[20\] cs_registers_i.pc_if_i\[20\]
+ net1383 _03200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22136_ cs_registers_i.pc_id_i\[21\] cs_registers_i.pc_if_i\[21\]
+ net1383 _03201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22137_ cs_registers_i.pc_id_i\[22\] cs_registers_i.pc_if_i\[22\]
+ net1383 _03202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22138_ cs_registers_i.pc_id_i\[23\] cs_registers_i.pc_if_i\[23\]
+ net1383 _03203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22139_ cs_registers_i.pc_id_i\[24\] cs_registers_i.pc_if_i\[24\]
+ net1383 _03204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22140_ cs_registers_i.pc_id_i\[25\] cs_registers_i.pc_if_i\[25\]
+ net1383 _03205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput54 data_rdata_i[29] net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22142_ cs_registers_i.pc_id_i\[26\] cs_registers_i.pc_if_i\[26\]
+ net1383 _03206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22143_ cs_registers_i.pc_id_i\[27\] cs_registers_i.pc_if_i\[27\]
+ net1383 _03207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22144_ cs_registers_i.pc_id_i\[28\] cs_registers_i.pc_if_i\[28\]
+ net1383 _03208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22145_ cs_registers_i.pc_id_i\[29\] cs_registers_i.pc_if_i\[29\]
+ net1383 _03209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22146_ cs_registers_i.pc_id_i\[2\] cs_registers_i.pc_if_i\[2\]
+ net1383 _03210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22147_ cs_registers_i.pc_id_i\[30\] cs_registers_i.pc_if_i\[30\]
+ net1383 _03211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22148_ cs_registers_i.pc_id_i\[31\] cs_registers_i.pc_if_i\[31\]
+ net1383 _03212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22149_ cs_registers_i.pc_id_i\[3\] cs_registers_i.pc_if_i\[3\]
+ net1383 _03213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22150_ cs_registers_i.pc_id_i\[4\] cs_registers_i.pc_if_i\[4\]
+ net1383 _03214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22151_ cs_registers_i.pc_id_i\[5\] cs_registers_i.pc_if_i\[5\]
+ net1383 _03215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22152_ cs_registers_i.pc_id_i\[6\] cs_registers_i.pc_if_i\[6\]
+ net1383 _03216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22153_ cs_registers_i.pc_id_i\[7\] cs_registers_i.pc_if_i\[7\]
+ net1383 _03217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22154_ cs_registers_i.pc_id_i\[8\] cs_registers_i.pc_if_i\[8\]
+ net1383 _03218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22155_ cs_registers_i.pc_id_i\[9\] cs_registers_i.pc_if_i\[9\]
+ net1383 _03219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22156_ net1834 _10080_ net254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22157_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _07402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_22158_ _09653_ _07402_ _07403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22159_ _05781_ net254 _07403_ core_busy_d VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_22160_ clknet_1_0__leaf_clk_i net2467 clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22161_ _01356_ _07404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22162_ _01366_ _07404_ net2022 _07405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22163_ _07405_ _01357_ _06914_ net186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput53 data_rdata_i[28] net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22165_ _01366_ net1522 net1885 _07407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xinput52 data_rdata_i[27] net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput51 data_rdata_i[26] net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22168_ net1533 net1534 load_store_unit_i.handle_misaligned_q
+ _06914_ _07410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_22169_ _01364_ _10133_ _07411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22170_ _10133_ _07407_ _07410_ _07411_ net187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_22171_ _01361_ _10133_ _07412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22172_ net2022 _01359_ _06914_ _07413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22173_ _01358_ _06914_ _07413_ load_store_unit_i.handle_misaligned_q
+ _07414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_22174_ net1534 load_store_unit_i.handle_misaligned_q _06914_
+ _07415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22175_ _07412_ _07414_ _07415_ net188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_22176_ net2022 _06914_ _07416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22177_ net2022 net1533 net1534 _06914_ _07417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_22178_ load_store_unit_i.handle_misaligned_q _07416_ _07417_
+ net189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22179_ _10129_ _07418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22180_ _07550_ _07418_ net2081 net190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput50 data_rdata_i[25] net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput49 data_rdata_i[24] net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22183_ net1534 net1713 net2190 net1533 net1522 net1760 _07421_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22184_ _07421_ _07422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22185_ net1798 _07422_ net1520 net191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput48 data_rdata_i[23] net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput47 data_rdata_i[22] net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22188_ net1522 net1740 net2479 net1534 net1758 net1533 _07425_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22189_ _07425_ _07426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22190_ net1711 _07426_ net1520 net192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22191_ net1522 net1749 net1767 net1534 net1757 net1533 _07427_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22192_ _07427_ _07428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22193_ net2158 _07428_ net1520 net193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22194_ net1522 _07429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput46 data_rdata_i[21] net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22196_ net1534 net1766 net1756 net1533 _07431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22197_ _07429_ net1794 _07431_ _07432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22198_ net2136 _07432_ net1520 net194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22199_ net1522 net1792 net1763 net1534 net1755 net1533 _07433_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22200_ _07433_ _07434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22201_ net2157 _07434_ net1520 net195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22202_ net1522 net1790 net1762 net1534 net1753 net1533 _07435_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22203_ _07435_ _07436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22204_ net2192 _07436_ net1520 net196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22205_ net1522 net1788 net1761 net1534 net1719 net1533 _07437_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22206_ _07437_ _07438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22207_ net2187 _07438_ net1520 net197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput45 data_rdata_i[20] net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22209_ net1533 net1798 net1760 net1534 net1713 net1522 _07440_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22210_ _07440_ _07441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22211_ net2190 _07441_ net1520 net198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22212_ net1533 net2185 net1759 net1534 net1709 net1522 _07442_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22213_ _07442_ _07443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput44 data_rdata_i[1] net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22215_ net1769 _07443_ net1520 net199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22216_ net1533 net1740 net1758 net1534 net1711 net1522 _07445_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22217_ _07445_ _07446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22218_ net2479 _07446_ net1520 net200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22219_ net1533 net1749 net1757 net1534 net2158 net1522 _07447_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22220_ _07447_ _07448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22221_ net1767 _07448_ net1520 net201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22222_ net1534 net1709 net1769 net1533 net1522 net1759 _07449_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22223_ _07449_ _07450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22224_ net2185 _07450_ net1520 net202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22225_ net1533 _05997_ net1756 net1534 net2136 net1522 _07451_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22226_ _01366_ net1729 _07452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22227_ net1520 _07451_ _07452_ net203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22228_ net1533 net1792 net1755 net1534 net2157 net1522 _07453_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22229_ _07453_ _07454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22230_ net1763 _07454_ net1520 net204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22231_ net1533 net1790 net1753 net1534 net2192 net1522 _07455_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22232_ _07455_ _07456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22233_ net1762 _07456_ net1520 net205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22234_ net1533 net1788 net1719 net1534 net2187 net1522 _07457_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22235_ _07457_ _07458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22236_ net1761 _07458_ net1520 net206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22237_ net1534 net1798 net1713 net1533 net1522 net2190 _07459_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22238_ _07459_ _07460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22239_ net1760 _07460_ net1520 net207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22240_ net1534 net2185 net1709 net1533 net1522 net1769 _07461_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22241_ _07461_ _07462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22242_ net1759 _07462_ net1520 net208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22243_ net1534 net1740 net1711 net1533 net1522 net2479 _07463_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22244_ _07463_ _07464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22245_ net1758 _07464_ net1520 net209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22246_ net1534 net1749 net2158 net1533 net1522 net1767 _07465_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22247_ _07465_ _07466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput43 data_rdata_i[19] net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_22249_ net1757 _07466_ net1520 net210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22250_ net1534 _05997_ net2136 net1533 _07468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22251_ _07429_ net1729 _07468_ _07469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22252_ net1756 _07469_ net1520 net211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22253_ net1534 net1792 net2157 net1533 net1522 net1763 _07470_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22254_ _07470_ _07471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22255_ net1755 _07471_ net1520 net212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22256_ net1534 net1711 net2479 net1533 net1522 net1758 _07472_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22257_ _07472_ _07473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22258_ net1740 _07473_ net1520 net213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22259_ net1534 net1790 net2192 net1533 net1522 net1762 _07474_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22260_ _07474_ _07475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22261_ net1753 _07475_ net1520 net214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22262_ net1534 net1788 net2187 net1533 net1522 net1761 _07476_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22263_ _07476_ _07477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22264_ net1719 _07477_ net1520 net215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22265_ net1534 net2158 net1767 net1533 net1522 net1757 _07478_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22266_ _07478_ _07479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22267_ net1749 _07479_ net1520 net216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22268_ net1534 net2136 net1766 net1533 net1522 net1756 _07480_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22269_ net1794 _07480_ net1520 _07481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22270_ _07481_ net217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22271_ net1534 net2157 net1763 net1533 net1522 net1755 _07482_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22272_ _07482_ _07483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22273_ net1792 _07483_ net1520 net218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22274_ net1534 net2192 net1762 net1533 net1522 net1753 _07484_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22275_ _07484_ _07485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22276_ net1790 _07485_ net1520 net219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22277_ net1534 net2187 net1761 net1533 net1522 net1719 _07486_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22278_ _07486_ _07487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22279_ net1788 _07487_ net1520 net220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22280_ net1522 net1798 net2190 net1534 net1760 net1533 _07488_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22281_ _07488_ _07489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22282_ net1713 _07489_ net1520 net221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22283_ net1522 net2185 net1769 net1534 net1759 net1533 _07490_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_22284_ _07490_ _07491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22285_ net1709 _07491_ net1520 net222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22286_ _10128_ _05798_ id_stage_i.branch_set_d VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22287_ net133 _10012_ _07492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_22288_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _07492_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ _07493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22289_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _10012_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]
+ _07494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22290_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ net133 _07494_ _07495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22291_ net100 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ _07496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22292_ _07493_ _07495_ _07496_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22293_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ net100 _07497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22294_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ _07497_ _07498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22295_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ net133 _07494_ _07498_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22296_ _06450_ net1819 _06469_ _07499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_22297_ net1819 _06670_ _07499_ _10023_ _10012_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_22298_ net1393 net1819 _06457_ _07500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22299_ net2023 net1393 _06457_ _07501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_22300_ _06448_ _06458_ _07500_ _06450_ _07501_ _07502_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_22301_ net1589 _07502_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22302_ net1589 _06469_ _06488_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_22303_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ _07503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22304_ _07503_ net133 _07504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22305_ net100 net254 _07504_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ _07505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22306_ _07505_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_22307_ net254 _07497_ _07506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_22308_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ net133 _07506_ _07503_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_22309_ net1834 _10080_ net100 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_d
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_22310_ id_stage_i.controller_i.instr_valid_i _05745_ _05794_
+ _07507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_22311_ _06478_ _05777_ net1809 _07508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_22312_ _03436_ _07508_ _07509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_22313_ _09911_ _07507_ _07509_ _10012_ net1386 if_stage_i.instr_valid_id_d
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_22314_ _00007_ _00008_ _00009_ _00010_ _00011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22315_ _00012_ _00013_ _00014_ _00015_ _00016_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22316_ _00017_ _00018_ _00019_ _11106_ _00020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22317_ _00021_ _00022_ _00023_ _11107_ _11108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22318_ _00024_ _00025_ _00026_ _11109_ _11110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22319_ _00027_ _11106_ _11110_ _00028_ _00029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22320_ _00030_ _00031_ _00032_ _11111_ _11112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22321_ _00033_ _00034_ _00035_ _11113_ _00036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22322_ _00037_ _11112_ _11109_ _11114_ _00038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22323_ _00039_ _00040_ _11115_ _11116_ _11117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22324_ _00041_ _00042_ _00043_ _11118_ _11119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22325_ _00044_ _00045_ _00046_ _00047_ _11120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22326_ _11119_ _11111_ _11120_ _11121_ _11122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22327_ _11122_ _11114_ _00048_ _00049_ _00050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22328_ _00051_ _00052_ _00053_ _11123_ _11124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22329_ _00054_ _00055_ _00056_ _11125_ _00057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22330_ _11124_ _11118_ _00058_ _11126_ _11127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22331_ _11127_ _11121_ _00059_ _00060_ _00061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22332_ _00062_ _00063_ _11128_ _11129_ _11130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22333_ _00064_ _00065_ _00066_ _11131_ _11132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22334_ _00067_ _00068_ _00069_ _11133_ _00070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22335_ _00071_ _11123_ _11132_ _11134_ _11135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22336_ _00072_ _00073_ _00074_ _00075_ _00076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22337_ _11125_ _00077_ _11136_ _11137_ _00078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22338_ _11135_ _11126_ _00079_ _11138_ _00080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22339_ _00081_ _00082_ _11139_ _11140_ _11141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22340_ _00083_ _00084_ _00085_ _00086_ _00087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22341_ _00088_ _00089_ _00090_ _11142_ _11143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22342_ _00091_ _00092_ _00093_ _11144_ _00094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22343_ _11143_ _11131_ _00095_ _11145_ _11146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22344_ _00096_ _00097_ _00098_ _00099_ _00100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22345_ _11133_ _00101_ _00102_ _11147_ _00103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22346_ _11146_ _11134_ _00104_ _11148_ _11149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22347_ _11138_ _11149_ _00105_ _00106_ _00107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22348_ _00108_ _00109_ _00110_ _11150_ _11151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22349_ _00111_ _00112_ _00113_ _00114_ _00115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22350_ _11151_ _00116_ _11142_ _11152_ _11153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22351_ _00117_ _00118_ _00119_ _11154_ _00120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22352_ _00121_ _00122_ _11144_ _11155_ _00123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22353_ _00124_ _11145_ _11153_ _11156_ _11157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22354_ _11157_ _11148_ _00125_ _00126_ _00127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22355_ _00128_ _00129_ _11158_ _11159_ _11160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22356_ _00130_ _00131_ _00132_ _11161_ _11162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22357_ _00133_ _00134_ _00135_ _00136_ _00137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22358_ _11162_ _11150_ _00138_ _11163_ _11164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22359_ _00139_ _00140_ _00141_ _11165_ _11166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22360_ _11154_ _11166_ _00142_ _00143_ _11167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22361_ _11152_ _11164_ _11167_ _11168_ _11169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22362_ _00144_ _00145_ _00146_ _00147_ _00148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22363_ _00149_ _11156_ _11169_ _00150_ _00151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22364_ _11170_ _00152_ _00153_ _11171_ _11172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22365_ _00154_ _00155_ _00156_ _11173_ _11174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22366_ _00157_ _00158_ _00159_ _00160_ _00161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22367_ _00162_ _11161_ _11174_ _11175_ _11176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22368_ _00163_ _00164_ _00165_ _11177_ _11178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22369_ _11165_ _11178_ _00166_ _11179_ _11180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22370_ _11180_ _11163_ _11176_ _11181_ _11182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22371_ _00167_ _00168_ _00169_ _11183_ _00170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22372_ _00171_ _00172_ _00173_ _00174_ _11184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22373_ _00175_ _11185_ _11184_ _00176_ _00177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22374_ _11168_ _11182_ _00178_ _11186_ _00179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22375_ _11187_ _00180_ _00181_ _11188_ _11189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22376_ _00182_ _00183_ _00184_ _11190_ _11191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22377_ _00185_ _00186_ _00187_ _00188_ _00189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22378_ _00190_ _11173_ _11191_ _11192_ _11193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22379_ _00191_ _00192_ _00193_ _11194_ _11195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22380_ _11177_ _11195_ _00194_ _00195_ _11196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22381_ _11196_ _11175_ _11193_ _11197_ _11198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22382_ _00196_ _00197_ _00198_ _11199_ _11200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22383_ _00199_ _11183_ _11200_ _00200_ _11201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22384_ _00201_ _11201_ _11179_ _00202_ _11202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22385_ _11181_ _11198_ _11202_ _11203_ _11204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22386_ _00203_ _11186_ _11204_ _00204_ _00205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22387_ _00206_ _00207_ _00208_ _11205_ _11206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22388_ _00209_ _00210_ _00211_ _00212_ _00213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22389_ _00214_ _11190_ _11206_ _11207_ _11208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22390_ _00215_ _00216_ _00217_ _11209_ _11210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22391_ _11194_ _11210_ _00218_ _00219_ _11211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22392_ _11211_ _11192_ _11208_ _11212_ _11213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22393_ _00220_ _00221_ _00222_ _11214_ _11215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22394_ _00223_ _00224_ _00225_ _11216_ _00226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22395_ _11199_ _11215_ _00227_ _00228_ _00229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22396_ _00230_ _00231_ _00232_ _11217_ _00233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22397_ _11197_ _11213_ _00234_ _11218_ _11219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22398_ _00235_ _11203_ _11219_ _00236_ _00237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22399_ _00238_ _00239_ _00240_ _11220_ _11221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22400_ _00241_ _00242_ _00243_ _11222_ _11223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22401_ _11223_ _11205_ _11221_ _11224_ _11225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22402_ _00244_ _00245_ _00246_ _11226_ _11227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22403_ _11209_ _11227_ _00247_ _11228_ _11229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22404_ _11229_ _11207_ _11225_ _11230_ _11231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22405_ _00248_ _00249_ _00250_ _11232_ _11233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22406_ _00253_ _00252_ _00251_ _11234_ _00254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22407_ _00255_ _11214_ _11233_ _11235_ _00256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22408_ _00257_ _00258_ _00259_ _11236_ _00260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22409_ _11231_ _00261_ _11212_ _11237_ _11238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22410_ _00262_ _11218_ _11238_ _00263_ _00264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22411_ _11239_ _00265_ _00266_ _11240_ _11241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22412_ _00267_ _00268_ _00269_ _11242_ _11243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22413_ _00270_ _00271_ _00272_ _00273_ _00274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22414_ _11220_ _11243_ _00275_ _11244_ _11245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22415_ _00276_ _00277_ _00278_ _11246_ _11247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22416_ _11226_ _11247_ _11222_ _11248_ _11249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22417_ _11249_ _11224_ _11245_ _11250_ _11251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22418_ _00279_ _00280_ _00281_ _11252_ _11253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22419_ _00282_ _00283_ _00284_ _11254_ _00285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22420_ _11253_ _11232_ _00286_ _11255_ _11256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22421_ _11256_ _11235_ _11228_ _00287_ _11257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22422_ _11251_ _11230_ _11257_ _11258_ _11259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22423_ _11259_ _11237_ _00288_ _00289_ _00290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22424_ _00292_ _00291_ _11260_ _11261_ _11262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22425_ net1575 _09894_ _00295_ _00296_ _00297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22426_ _00298_ _00299_ _00300_ _00301_ _00302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22427_ _00303_ _11242_ _00304_ _11263_ _11264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22428_ _00305_ _00306_ _00307_ _11265_ _11266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22429_ _11246_ _11266_ _00308_ _11267_ _11268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22430_ _11268_ _11244_ _11264_ _11269_ _11270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22431_ _00309_ _00310_ _00311_ _11271_ _11272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22432_ _00312_ _00313_ _00314_ _00315_ _00316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22433_ _00317_ _11252_ _11272_ _11273_ _11274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22434_ _11255_ _11274_ _11248_ _11275_ _11276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22435_ _11276_ _11250_ _11270_ _11277_ _11278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22436_ _00318_ _00319_ _00320_ _11279_ _00321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22437_ _11280_ _00322_ _11254_ _11281_ _00323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22438_ _00324_ _00325_ _00326_ _11282_ _00327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22439_ _11283_ _00328_ _00329_ _00330_ _00331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22440_ _00332_ _11258_ _11278_ _11284_ _00333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22441_ _11285_ _00334_ _00335_ _11286_ _11287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22442_ net1570 _00337_ net1575 _00338_ _00339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22443_ _00340_ _00341_ _00342_ _00343_ _00344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22444_ _00347_ _00346_ _00345_ _11288_ _11289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22445_ _00348_ _00349_ _00350_ _11290_ _11291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22446_ _11265_ _11291_ _00351_ _11292_ _11293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22447_ _11289_ _11263_ _11293_ _11294_ _11295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22448_ _00352_ _00353_ _00354_ _11296_ _11297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22449_ _00355_ _00356_ _00357_ _00358_ _00359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22450_ _00360_ _11271_ _11297_ _11298_ _11299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22451_ _11273_ _11299_ _11267_ _00361_ _11300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22452_ _11295_ _11269_ _11300_ _11301_ _11302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22453_ _00362_ _00363_ _00364_ _11303_ _11304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22454_ _11279_ _11304_ _00365_ _00366_ _00367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22455_ _11282_ _00368_ _11275_ _11305_ _11306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22456_ _11306_ _11277_ _11302_ _11307_ _11308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22457_ _00369_ _11284_ _11308_ _00370_ _00371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22458_ net1570 _00372_ net1575 _00373_ _00374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22459_ _00375_ _00376_ _00377_ _00378_ _00379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22460_ _00380_ _00381_ _00382_ _11309_ _11310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22461_ _00383_ _00384_ _00385_ _11311_ _11312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22462_ _11290_ _11312_ _00386_ _11313_ _11314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22463_ _11314_ _11288_ _11310_ _11315_ _11316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22464_ _00387_ _00388_ _00389_ _11317_ _11318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22465_ _00390_ _00391_ _00392_ _00393_ _00394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22466_ _00395_ _11296_ _11318_ _11319_ _11320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22467_ _11298_ _11320_ _11292_ _00396_ _11321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22468_ _11321_ _11294_ _11316_ _11322_ _11323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22469_ _00397_ _00398_ _00399_ _11324_ _11325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22470_ _11303_ _11325_ _00400_ _00401_ _00402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22471_ _11326_ _11327_ _00403_ _00404_ _00405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22472_ _00406_ _11301_ _11323_ _11328_ _11329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22473_ _11329_ _11305_ _11307_ _00407_ _00408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22474_ net1570 _00409_ net1575 _11330_ _00410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22475_ _00411_ net1569 _00377_ _00413_ _00414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22476_ _00417_ _00416_ _00415_ _11331_ _11332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22477_ _00418_ _00419_ _00420_ _11333_ _11334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22478_ _11311_ _11334_ _00421_ _11335_ _11336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22479_ _11332_ _11309_ _11336_ _11337_ _11338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22480_ _00422_ _00423_ _00424_ _11339_ _11340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22481_ _00425_ _00426_ _00427_ _00428_ _00429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22482_ _00430_ _11317_ _11340_ _11341_ _11342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22483_ _11342_ _11313_ _11319_ _00431_ _11343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22484_ _11338_ _11315_ _11343_ _11344_ _11345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22485_ _00432_ _00433_ _00434_ _11346_ _11347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22486_ _11324_ _11347_ _00435_ _00436_ _00437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22487_ _11348_ _11349_ _00438_ _00439_ _00440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22488_ _11345_ _11322_ _00441_ _11350_ _11351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22489_ _11351_ _11328_ _00442_ _00443_ _00444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22490_ net1570 _00445_ net1575 _00446_ _11352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22491_ _00377_ _00447_ _00412_ _00448_ _00449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22492_ _11352_ _11330_ _00449_ _00450_ _00451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22493_ _00453_ _00454_ _00455_ _11353_ _11354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22494_ _00456_ _11333_ _11354_ _11355_ _11356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22495_ _11331_ _00457_ _11356_ _11357_ _11358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22496_ _00458_ _00459_ _00460_ _11359_ _11360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22497_ _00461_ _00462_ _00463_ _00464_ _00465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22498_ _00466_ _11339_ _11360_ _11361_ _11362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22499_ _11341_ _11362_ _11335_ _00467_ _11363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22500_ _11363_ _11337_ _11358_ _11364_ _11365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22501_ _00468_ _00469_ _00470_ _11366_ _11367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22502_ _11346_ _11367_ _00471_ _00472_ _00473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22503_ _11368_ _11369_ _00474_ _00475_ _00476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22504_ _00477_ _11344_ _11365_ _11370_ _11371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22505_ _00478_ _11350_ _11371_ _00479_ _00480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22506_ net1571 _00481_ net1575 _11372_ _00482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22507_ _00483_ _00452_ _00484_ _11373_ _11374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22508_ _00485_ net1568 _00487_ _00488_ _00489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22509_ net1545 _11353_ _00491_ _11375_ _11376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22510_ _00492_ _11374_ _11376_ _11377_ _11378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22511_ _00493_ _00494_ _00495_ _11379_ _11380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22512_ _00496_ _00497_ _00498_ _00499_ _00500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22513_ _00501_ _11359_ _11380_ _11381_ _11382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22514_ _11361_ _11382_ _11355_ _00502_ _11383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22515_ _11383_ _11357_ _11378_ _11384_ _11385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22516_ _00503_ _00504_ _00505_ _11386_ _11387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22517_ _11366_ _11387_ _00506_ _00507_ _00508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22518_ _11388_ _11389_ _00509_ _00510_ _00511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22519_ _00512_ _11364_ _11385_ _11390_ _11391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22520_ _00513_ _11370_ _11391_ _00514_ _00515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22521_ net1571 _00516_ net1575 _11392_ _11393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22522_ net2492 _11372_ _11393_ _00517_ _00518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22523_ net1568 _00519_ _00520_ _00521_ _00522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22524_ net1545 _00523_ _00524_ _11394_ _11395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22525_ _11395_ _11373_ _00525_ _11396_ _11397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22526_ _00526_ _00527_ _00528_ _11398_ _11399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22527_ _00529_ _00530_ _00531_ _00532_ _00533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22528_ _00534_ _11379_ _11399_ _11400_ _11401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22529_ _11375_ _11381_ _11401_ _00535_ _11402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22530_ _11377_ _11397_ _11402_ _11403_ _11404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22531_ _00536_ _00537_ _00538_ _11405_ _11406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22532_ _11386_ _11406_ _00539_ _00540_ _00541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22533_ _11407_ _11408_ _00542_ _00543_ _00544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22534_ _00545_ _11384_ _11404_ _11409_ _11410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22535_ _00546_ _11390_ _11410_ _00547_ _00548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22536_ net1570 _00549_ net1575 _11411_ _11412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22537_ net2492 _11392_ _11412_ _11413_ _00550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22538_ _00486_ _00520_ _00551_ _00552_ _00553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22539_ net1545 _00554_ _00555_ _11414_ _11415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22540_ _00556_ _00557_ _11415_ _11416_ _11417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22541_ _00558_ _00559_ _00560_ _11418_ _11419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22542_ _00561_ _00562_ _00563_ _00564_ _00565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22543_ _00566_ _11398_ _11419_ _11420_ _11421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22544_ _11400_ _11421_ _11394_ _00567_ _11422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22545_ _11422_ _11396_ _11417_ _11423_ _11424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22546_ _00568_ _00569_ _00570_ _11425_ _11426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22547_ _11405_ _11426_ _00571_ _00572_ _00573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22548_ _11427_ _11428_ _00574_ _00575_ _00576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22549_ _00577_ _11403_ _11424_ _11429_ _11430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22550_ _00578_ _11409_ _11430_ _00579_ _00580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22551_ net1570 _00581_ net1575 _11431_ _11432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22552_ net2492 _11411_ _11432_ _00582_ _11433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22553_ _00490_ _00583_ _00555_ _11434_ _00584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_2
X_22554_ _00585_ _11413_ _11433_ _00586_ _00587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22555_ _00588_ _00589_ _00590_ _00591_ _00592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22556_ _00593_ _00594_ _00595_ _00596_ _00597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22557_ _00598_ _11418_ _00599_ _11435_ _11436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22558_ _11414_ _11420_ _11436_ _00600_ _11437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22559_ _11416_ _00601_ _11437_ _11438_ _11439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22560_ _00602_ _00603_ _00604_ _11440_ _11441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22561_ _11425_ _11441_ _00605_ _00606_ _00607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22562_ _11442_ _11443_ _00608_ _00609_ _00610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22563_ _00611_ _11423_ _11439_ _11444_ _11445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22564_ _00612_ _11429_ _11445_ _00613_ _00614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22565_ net1572 _00615_ net1576 _11446_ _11447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22566_ net2492 _11431_ _11447_ _11448_ _00616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22567_ _00617_ _00618_ net1537 _11449_ _11450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22568_ net1567 _00619_ _00620_ _00621_ _00622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22569_ _00623_ _00624_ _00625_ _00626_ _00627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22570_ _00628_ _00629_ _00630_ _11451_ _11452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22571_ _11435_ _11452_ _11434_ _00631_ _11453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22572_ _11453_ _00632_ _11450_ _11454_ _11455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22573_ _00633_ _00634_ _00635_ _11456_ _11457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22574_ _11440_ _11457_ _00636_ _00637_ _00638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22575_ _11458_ _11459_ _00639_ _00640_ _00641_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22576_ _00642_ _11438_ _11455_ _11460_ _11461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22577_ _00643_ _11444_ _11461_ _00644_ _00645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22578_ net1573 _00646_ net1576 _11462_ _11463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22579_ net1550 _11463_ _11446_ _11464_ _11465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22580_ net1536 _11448_ _11465_ _00647_ _00648_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22581_ net1567 _00620_ _00649_ _00650_ _00651_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22582_ _00652_ _00653_ _00654_ _00655_ _00656_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22583_ _00657_ _00658_ _00659_ _11466_ _11467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22584_ _11434_ _11451_ _11467_ _00660_ _11468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22585_ _11468_ _11449_ _00661_ _11469_ _11470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22586_ _00662_ _00663_ _00664_ _11471_ _11472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22587_ _11456_ _11472_ _00665_ _00666_ _00667_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22588_ _11473_ _11474_ _00668_ _00669_ _00670_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22589_ _00671_ _11454_ _11470_ _11475_ _11476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22590_ _00672_ _11460_ _11476_ _00673_ _00674_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22591_ net1573 _00675_ net1576 _11477_ _11478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22592_ net1550 _11462_ _11478_ _11479_ _11480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22593_ net1536 _11464_ _11480_ _00676_ _00677_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22594_ _00678_ _00679_ _00680_ _00681_ _00682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22595_ _00683_ _00684_ _00659_ _11481_ _11482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22596_ _11466_ _11482_ net1538 _00685_ _11483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22597_ _11483_ _00686_ _00687_ _11484_ _11485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22598_ _00688_ _00689_ _00690_ _11486_ _11487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22599_ _11471_ _11487_ _00691_ _00692_ _00693_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22600_ _11488_ _11489_ _00694_ _00695_ _00696_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22601_ _00697_ _11469_ _11485_ _11490_ _11491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22602_ _00698_ _11475_ _11491_ _00699_ _00700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22603_ net1574 net1577 _00701_ _11492_ _11493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22604_ net1550 _11477_ _11493_ _11494_ _11495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22605_ net1536 _11479_ _11495_ _00702_ _00703_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22606_ net1566 _00704_ _00705_ _00706_ _00707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22607_ net1544 net1546 _00708_ _11496_ _11497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22608_ net1538 _11481_ _11497_ _00709_ _11498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22609_ _11498_ _00710_ _00711_ _11499_ _11500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22610_ _00712_ _00713_ _00714_ _11501_ _11502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22611_ _11486_ _11502_ _00715_ _00716_ _00717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22612_ _11503_ _11504_ _00718_ _00719_ _00720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22613_ _00721_ _11484_ _11500_ _11505_ _11506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22614_ _00722_ _11490_ _11506_ _00723_ _00724_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22615_ net1574 net1577 _00725_ _11507_ _11508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22616_ net1550 _11492_ _11508_ _11509_ _11510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22617_ net1536 _11494_ _11510_ _11511_ _00726_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22618_ net1566 _00705_ _00727_ _00728_ _00729_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22619_ net1544 net1546 _00730_ _11512_ _11513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22620_ net1538 _11496_ _11513_ _00731_ _11514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22621_ _11514_ _00732_ _00733_ _11515_ _11516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22622_ _00734_ _00735_ _00736_ _11517_ _11518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22623_ _11501_ _11518_ _00737_ _00738_ _00739_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22624_ _11519_ _11520_ _00740_ _00741_ _00742_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22625_ _00743_ _11499_ _11516_ _11521_ _11522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22626_ _00744_ _11505_ _11522_ _00745_ _00746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22627_ net1574 net1577 _00747_ _11523_ _11524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22628_ net1550 _11507_ _11524_ _11525_ _11526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22629_ net1536 _11509_ _11526_ _00748_ _11527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22630_ net1538 _11513_ _11512_ _00749_ _00750_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22631_ _00751_ _11511_ _11527_ _00752_ _00753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22632_ _00754_ _00755_ _00756_ _00757_ _00758_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22633_ _11517_ _00759_ _00760_ _00761_ _00762_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22634_ _11528_ _11529_ _00763_ _00764_ _00765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22635_ _00766_ _11515_ _00767_ _11530_ _11531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22636_ _00768_ _11521_ _11531_ _00769_ _00770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22637_ net1574 net1577 _00771_ _11532_ _11533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22638_ net1550 _11523_ _11533_ _11534_ _11535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22639_ net1536 _11525_ _11535_ _00772_ _00773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22640_ _00774_ _00775_ _00750_ _11536_ _11537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22641_ _00776_ _00756_ _00777_ _11538_ _00778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22642_ _00760_ _00779_ _00780_ _00781_ _00782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22643_ _00783_ _11539_ _11540_ _00784_ _00785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22644_ _00786_ _11537_ _00787_ _11541_ _11542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22645_ _00788_ _11530_ _11542_ _00789_ _00790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22646_ net1574 net1577 _00791_ _00792_ _11543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22647_ net1550 _11532_ _11543_ _00793_ _11544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22648_ net1536 _11534_ _11544_ _00794_ _00795_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22649_ _00796_ _00797_ _00750_ _00798_ _11545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22650_ _00776_ _00799_ _00756_ _00800_ _11546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22651_ _11538_ _11546_ _00728_ _00801_ _11547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22652_ _00783_ _11548_ _11549_ _00802_ _00803_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22653_ _00804_ _11536_ _11545_ _00805_ _11550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22654_ _00806_ _11541_ _11550_ _00807_ _00808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22655_ _00809_ _00810_ _00811_ _00812_ _00813_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_22656_ _00814_ _00815_ _00816_ _00817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22657_ _00819_ _00818_ _00820_ _00821_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22658_ _00822_ _00823_ _00824_ _00825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22659_ _00826_ _00827_ _00828_ _00829_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22660_ _00831_ _00830_ _00832_ _00833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22661_ _00834_ _00835_ _00836_ _00837_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_22662_ _00838_ _00839_ _00840_ _00841_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22663_ _00843_ _00842_ _00844_ _00845_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22664_ _00847_ _00846_ _00848_ _00849_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22665_ _00850_ _00851_ _00852_ _00853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22666_ _00855_ _00854_ _00856_ _00857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22667_ _00859_ _00858_ _00860_ _00861_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22668_ _00862_ _00863_ _00864_ _00865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_22669_ _00866_ _00867_ _00868_ _00869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_22670_ _00871_ _00870_ _00872_ _00873_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22671_ _00875_ _00874_ _00876_ _00877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22672_ _00879_ _00878_ _00880_ _00881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22673_ _00882_ _00883_ _00884_ _00885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22674_ _00886_ _00887_ _00888_ _00889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22675_ _00890_ _00891_ _00892_ _00893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22676_ _00895_ _00894_ _00896_ _00897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22677_ _00898_ _00899_ _00900_ _00901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22678_ _00903_ _00902_ _00904_ _00905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22679_ _00906_ _00907_ _00908_ _00909_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22680_ _00911_ _00910_ _00912_ _00913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22681_ _00914_ _00915_ _00916_ _00917_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22682_ _00918_ _00919_ _00920_ _00921_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22683_ _00922_ _00923_ _00924_ _00925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22684_ _00926_ _00927_ _00928_ _00929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22685_ _00930_ _00931_ _00932_ _00933_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22686_ _00934_ _00935_ _00936_ _00937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22687_ _00938_ _00939_ _00940_ _00941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22688_ _09470_ _00943_ _00944_ _11551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22689_ _08008_ _00946_ _00947_ _00948_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22690_ _08008_ _00949_ _00950_ _11552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22691_ _08009_ _00946_ _00952_ _11553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22692_ _00953_ _00954_ _00955_ _00956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22693_ cs_registers_i.priv_mode_id_o\[0\] _00957_ _00958_
+ _00959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22694_ cs_registers_i.pc_id_i\[1\] cs_registers_i.pc_id_i\[2\]
+ _00960_ _00961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22695_ _00962_ _00963_ _00964_ _00965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22696_ _00962_ _00963_ _00966_ _11554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22697_ _00962_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ _00967_ _11555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22698_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ _00963_ _00968_ _11556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22699_ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\] _00969_
+ _11557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22700_ _00970_ _00971_ _11558_ _00972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22701_ _11558_ _00973_ _11559_ _00974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22702_ _11559_ _11108_ _11560_ _00975_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22703_ _00976_ _00977_ _11115_ _00978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22704_ _11107_ _00979_ _11561_ _11562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22705_ _11560_ _11562_ _11563_ _00980_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22706_ _11117_ _11561_ _11564_ _11565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22707_ _11565_ _11563_ _11566_ _00981_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22708_ _11113_ _00982_ _11128_ _00983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22709_ _11116_ _00984_ _11567_ _11568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22710_ _11568_ _11564_ _11569_ _11570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22711_ _11570_ _11566_ _11571_ _00985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22712_ _00986_ _00987_ _11136_ _11572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22713_ _00988_ _11572_ _11139_ _00989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22714_ _11130_ _11567_ _11573_ _11574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22715_ _11569_ _11574_ _00990_ _11575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22716_ _11571_ _11575_ _00991_ _00992_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22717_ _11141_ _11129_ _11576_ _11577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22718_ _11577_ _11573_ _11578_ _00993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22719_ _00990_ _00993_ _00994_ _00995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22720_ _00996_ _11137_ _11158_ _00997_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22721_ _11140_ _00998_ _11579_ _11580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22722_ _11576_ _11580_ _11581_ _11582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22723_ _11578_ _11582_ _00999_ _01000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22724_ _01001_ _01002_ _11583_ _11584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22725_ _11584_ _11147_ _11170_ _01003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22726_ _11160_ _11579_ _11585_ _11586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22727_ _11581_ _11586_ _01004_ _01005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22728_ _11583_ _01006_ _11185_ _11587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22729_ _11587_ _11155_ _11187_ _01007_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22730_ _11159_ _11172_ _11588_ _11589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22731_ _11585_ _11589_ _01008_ _01009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22732_ _11171_ _11189_ _11590_ _11591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22733_ _11588_ _11591_ _01010_ _01011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22734_ _01012_ _01013_ _11592_ _01014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22735_ _11188_ _01015_ _11593_ _11594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22736_ _11590_ _11594_ _01016_ _01017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22737_ _11592_ _01018_ _11239_ _01019_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22738_ _01020_ _01021_ _11595_ _11596_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22739_ _11593_ _11596_ _01022_ _01023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22740_ _01024_ _11216_ _11597_ _11598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22741_ _11598_ _11217_ _11260_ _01025_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22742_ _11595_ _11241_ _01026_ _01027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22743_ _01028_ _01029_ _11280_ _11599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22744_ _11599_ _11234_ _01030_ _11600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22745_ _11597_ _11600_ _11283_ _11601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22746_ _11601_ _11236_ _11285_ _01031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22747_ _11262_ _11240_ _01032_ _01033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22748_ _11261_ _11287_ _01034_ _01035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22749_ _11281_ _01036_ _11326_ _01037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22750_ _01038_ _11286_ _01039_ _01040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22751_ _01041_ _01042_ _11348_ _11327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22752_ _01043_ _01044_ _01045_ _01046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22753_ _01047_ _01048_ _11368_ _11349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22754_ _01049_ _01050_ _01051_ _01052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22755_ _01053_ _01054_ _11388_ _11369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22756_ _01055_ _01056_ _01057_ _01058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22757_ _01059_ _01060_ _11407_ _11389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22758_ _01061_ _01062_ _01063_ _01064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22759_ _01065_ _01066_ _11427_ _11408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22760_ _01067_ _01068_ _01069_ _01070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22761_ _01071_ _01072_ _11442_ _11428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22762_ _01073_ _01074_ _01075_ _01076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22763_ _01077_ _01078_ _11458_ _11443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22764_ _01079_ _01080_ _01081_ _01082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22765_ _01083_ _01084_ _11473_ _11459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22766_ _01085_ _01086_ _01087_ _01088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22767_ _01089_ _01090_ _11488_ _11474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22768_ _01091_ _01092_ _01093_ _01094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22769_ _01095_ _01096_ _11503_ _11489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22770_ _01097_ _01098_ _01099_ _01100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22771_ _01101_ _01102_ _11519_ _11504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22772_ _01103_ _01104_ _01105_ _01106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22773_ _01107_ _01108_ _11528_ _11520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22774_ _01109_ _01110_ _01111_ _01112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22775_ _01113_ _01114_ _11539_ _11529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22776_ _01115_ _01116_ _01117_ _01118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22777_ _01119_ _01120_ _11548_ _11540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22778_ _01121_ _01122_ _01123_ _01124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22779_ _11546_ _00728_ _11602_ _01125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22780_ _01126_ _11547_ _01127_ _11549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22781_ _01128_ _01129_ _01130_ _01131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22782_ cs_registers_i.pc_if_i\[2\] _01132_ _01133_ _01134_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22783_ net2289 net1703 _01137_ _01138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22784_ _01139_ net1612 _01141_ _01142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22785_ _01143_ net1703 _01144_ _11603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22786_ _01145_ net1586 _01147_ _01148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22787_ _01149_ net2289 _01150_ _11604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22788_ _01151_ net1611 _01153_ _01154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22789_ _01155_ _07773_ _01157_ _11605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22790_ net2103 _01159_ _01160_ _01161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22791_ _01162_ net1702 _01164_ _11606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22792_ _01165_ _01166_ _01167_ _01168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22793_ _01169_ net1701 _01171_ _11607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22794_ net1692 net1700 _01174_ _01175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22795_ _01176_ _07859_ _01178_ _11608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22796_ net1691 _01180_ _01181_ _01182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22797_ _01183_ _01184_ _01185_ _11609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22798_ net2116 _01187_ _01188_ _01189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22799_ _01190_ net2068 _01192_ _11610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22800_ net2072 net1699 _01195_ _01196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22801_ _01197_ _01198_ _01199_ _11611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22802_ net2097 net1698 _01202_ _01203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22803_ _01204_ _01205_ _01206_ _11612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22804_ net2102 net1697 _01209_ _01210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22805_ _01211_ _01212_ _01213_ _11613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22806_ net2159 net1610 _01216_ _01217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22807_ _01218_ net1696 _01220_ _11614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22808_ _01221_ _01222_ _01223_ _01224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22809_ net2150 net1704 _01227_ _11615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22810_ net2070 net2096 _01230_ _01231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22811_ _01232_ _01233_ _01234_ _11616_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22812_ net1685 net2176 _01237_ _01238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22813_ _01239_ _01240_ _01241_ _11617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22814_ net1684 _01243_ _01244_ _01245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22815_ _01246_ _01247_ _01248_ _11618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22816_ net1683 _01250_ _01251_ _01252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22817_ _01253_ _01254_ _01255_ _11619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22818_ _01256_ _01257_ _01258_ _01259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22819_ _01260_ _01261_ _01262_ _11620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22820_ net1682 net2482 _01265_ _01266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22821_ _01267_ _01268_ _01269_ _11621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22822_ net1681 _01271_ _01272_ _01273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22823_ _01274_ _01275_ _01276_ _11622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22824_ net2135 _01278_ _01279_ _01280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22825_ _01281_ _01282_ _01283_ _11623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22826_ net1680 _01285_ _01286_ _01287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22827_ _01288_ _01289_ _01290_ _11624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22828_ net1679 _01292_ _01293_ _01294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22829_ _01295_ _01296_ _01297_ _11625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22830_ net1678 _01299_ _01300_ _01301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22831_ _01302_ _01303_ _01304_ _11626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22832_ net1677 _01306_ _01307_ _01308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22833_ _01309_ _01310_ _01311_ _11627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22834_ _01312_ _01313_ _01314_ _01315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22835_ _01316_ _01317_ _01318_ _11628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22836_ _01319_ _01320_ _01321_ _01322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22837_ _01323_ _01324_ _01325_ _11629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22838_ _01326_ _01327_ _01328_ _01329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22839_ _01330_ _01331_ _01332_ _11630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22840_ net1676 _01334_ _01335_ _01336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22841_ _01337_ _01338_ _01339_ _11631_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22842_ net1675 _01341_ _01342_ _01343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22843_ _01344_ _01345_ _01346_ _11632_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22844_ _01347_ _01348_ _01349_ _01350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22845_ _01351_ _01352_ _01353_ _11633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22846_ net1885 net1520 _01356_ _01357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22847_ net1539 alu_adder_result_ex\[0\] _01358_ _01359_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22848_ net1539 alu_adder_result_ex\[0\] _01360_ _11634_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22849_ net1539 net1540 _01361_ _11635_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22850_ net1539 net1540 _01362_ _11636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22851_ _01363_ alu_adder_result_ex\[0\] _01364_ _11637_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22852_ _01363_ alu_adder_result_ex\[0\] _01365_ _11638_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
X_22853_ _01363_ net1540 _01366_ _11639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22854_ cs_registers_i.mhpmcounter\[1856\] cs_registers_i.mhpmcounter\[1857\]
+ _01367_ _01368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22855_ cs_registers_i.mcycle_counter_i.counter_val_o\[0\]
+ cs_registers_i.mcycle_counter_i.counter_val_o\[1\] _01369_
+ _01370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22856_ _01371_ _01372_ _01373_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22857_ _01373_ _01374_ _01375_ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_d\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_22858_ _01376_ net2037 clknet_leaf_32_clk load_store_unit_i.data_type_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22859_ _01377_ net2036 clknet_leaf_32_clk load_store_unit_i.data_type_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22860_ _01378_ net2037 clknet_leaf_29_clk ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22861_ _01379_ net2037 clknet_leaf_29_clk ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22862_ _01380_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22863_ _01381_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22864_ _01382_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
Xinput42 data_rdata_i[18] net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput41 data_rdata_i[17] net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput40 data_rdata_i[16] net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput39 data_rdata_i[15] net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput38 data_rdata_i[14] net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput37 data_rdata_i[13] net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput36 data_rdata_i[12] net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput35 data_rdata_i[11] net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput34 data_rdata_i[10] net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput33 data_rdata_i[0] net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput32 data_gnt_i net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput31 data_err_i net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput30 boot_addr_i[9] net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput29 boot_addr_i[8] net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput28 boot_addr_i[31] net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput27 boot_addr_i[30] net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput26 boot_addr_i[29] net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput25 boot_addr_i[28] net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput24 boot_addr_i[27] net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput23 boot_addr_i[26] net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput22 boot_addr_i[25] net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput21 boot_addr_i[24] net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput20 boot_addr_i[23] net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput19 boot_addr_i[22] net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput18 boot_addr_i[21] net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput17 boot_addr_i[20] net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput16 boot_addr_i[19] net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput15 boot_addr_i[18] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput14 boot_addr_i[17] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput13 boot_addr_i[16] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput12 boot_addr_i[15] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 boot_addr_i[14] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput10 boot_addr_i[13] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 boot_addr_i[12] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 boot_addr_i[11] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 boot_addr_i[10] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xcore_busy_q$_DFF_PN0_ core_busy_d net2034 clknet_leaf_2_clk_i_regs
+ core_busy_q VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcore_clock_gate_i.en_latch$_DLATCH_N_ _00006_ clknet_leaf_2_clk_i_regs
+ _unconnected_69 core_clock_gate_i.en_latch VDD VSS gf180mcu_fd_sc_mcu9t5v0__latsnq_1
Xcs_registers_i.mcountinhibit_q\[0\]$_DFFE_PN0P_ _01383_ net2034
+ clknet_leaf_24_clk cs_registers_i.mcountinhibit_q\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcountinhibit_q\[2\]$_DFFE_PN0P_ _01384_ net2034
+ clknet_leaf_24_clk cs_registers_i.mcountinhibit_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[0\]$_DFFE_PN0P_
+ _01385_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[10\]$_DFFE_PN0P_
+ _01386_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[11\]$_DFFE_PN0P_
+ _01387_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[12\]$_DFFE_PN0P_
+ _01388_ net2034 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[13\]$_DFFE_PN0P_
+ _01389_ net2034 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[14\]$_DFFE_PN0P_
+ _01390_ net2034 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[15\]$_DFFE_PN0P_
+ _01391_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[16\]$_DFFE_PN0P_
+ _01392_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[17\]$_DFFE_PN0P_
+ _01393_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[18\]$_DFFE_PN0P_
+ _01394_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[19\]$_DFFE_PN0P_
+ _01395_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[1\]$_DFFE_PN0P_
+ _01396_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[20\]$_DFFE_PN0P_
+ _01397_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[21\]$_DFFE_PN0P_
+ _01398_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[22\]$_DFFE_PN0P_
+ _01399_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[23\]$_DFFE_PN0P_
+ _01400_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[24\]$_DFFE_PN0P_
+ _01401_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[25\]$_DFFE_PN0P_
+ _01402_ net2034 clknet_leaf_21_clk cs_registers_i.mcycle_counter_i.counter_val_o\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[26\]$_DFFE_PN0P_
+ _01403_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[27\]$_DFFE_PN0P_
+ _01404_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[28\]$_DFFE_PN0P_
+ _01405_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[29\]$_DFFE_PN0P_
+ _01406_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[2\]$_DFFE_PN0P_
+ _01407_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[30\]$_DFFE_PN0P_
+ _01408_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[31\]$_DFFE_PN0P_
+ _01409_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[32\]$_DFFE_PN0P_
+ _01410_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[32\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[33\]$_DFFE_PN0P_
+ _01411_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[33\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[34\]$_DFFE_PN0P_
+ _01412_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[34\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[35\]$_DFFE_PN0P_
+ _01413_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[35\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[36\]$_DFFE_PN0P_
+ _01414_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[36\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[37\]$_DFFE_PN0P_
+ _01415_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[37\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[38\]$_DFFE_PN0P_
+ _01416_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[38\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[39\]$_DFFE_PN0P_
+ _01417_ net2037 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[39\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[3\]$_DFFE_PN0P_
+ _01418_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[40\]$_DFFE_PN0P_
+ _01419_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[40\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[41\]$_DFFE_PN0P_
+ _01420_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[41\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[42\]$_DFFE_PN0P_
+ _01421_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[42\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[43\]$_DFFE_PN0P_
+ _01422_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[43\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[44\]$_DFFE_PN0P_
+ _01423_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[44\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[45\]$_DFFE_PN0P_
+ _01424_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[45\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[46\]$_DFFE_PN0P_
+ _01425_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[46\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[47\]$_DFFE_PN0P_
+ _01426_ net2037 clknet_leaf_20_clk cs_registers_i.mcycle_counter_i.counter_val_o\[47\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[48\]$_DFFE_PN0P_
+ _01427_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[48\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[49\]$_DFFE_PN0P_
+ _01428_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[49\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[4\]$_DFFE_PN0P_
+ _01429_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[50\]$_DFFE_PN0P_
+ _01430_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[50\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[51\]$_DFFE_PN0P_
+ _01431_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[51\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[52\]$_DFFE_PN0P_
+ _01432_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[52\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[53\]$_DFFE_PN0P_
+ _01433_ net2035 clknet_leaf_18_clk cs_registers_i.mcycle_counter_i.counter_val_o\[53\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[54\]$_DFFE_PN0P_
+ _01434_ net2035 clknet_leaf_18_clk cs_registers_i.mcycle_counter_i.counter_val_o\[54\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[55\]$_DFFE_PN0P_
+ _01435_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[55\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[56\]$_DFFE_PN0P_
+ _01436_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[56\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[57\]$_DFFE_PN0P_
+ _01437_ net2035 clknet_leaf_18_clk cs_registers_i.mcycle_counter_i.counter_val_o\[57\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[58\]$_DFFE_PN0P_
+ _01438_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[58\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[59\]$_DFFE_PN0P_
+ _01439_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[59\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[5\]$_DFFE_PN0P_
+ _01440_ net2034 clknet_leaf_22_clk cs_registers_i.mcycle_counter_i.counter_val_o\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[60\]$_DFFE_PN0P_
+ _01441_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[60\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[61\]$_DFFE_PN0P_
+ _01442_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[61\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[62\]$_DFFE_PN0P_
+ _01443_ net2035 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[62\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[63\]$_DFFE_PN0P_
+ _01444_ net2037 clknet_leaf_19_clk cs_registers_i.mcycle_counter_i.counter_val_o\[63\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[6\]$_DFFE_PN0P_
+ _01445_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[7\]$_DFFE_PN0P_
+ _01446_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[8\]$_DFFE_PN0P_
+ _01447_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.mcycle_counter_i.counter_val_o\[9\]$_DFFE_PN0P_
+ _01448_ net2037 clknet_leaf_23_clk cs_registers_i.mcycle_counter_i.counter_val_o\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[0\]$_DFFE_PN0P_
+ _01449_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1856\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[10\]$_DFFE_PN0P_
+ _01450_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1866\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[11\]$_DFFE_PN0P_
+ _01451_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1867\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[12\]$_DFFE_PN0P_
+ _01452_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1868\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[13\]$_DFFE_PN0P_
+ _01453_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1869\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[14\]$_DFFE_PN0P_
+ _01454_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1870\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[15\]$_DFFE_PN0P_
+ _01455_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1871\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[16\]$_DFFE_PN0P_
+ _01456_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1872\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[17\]$_DFFE_PN0P_
+ _01457_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1873\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[18\]$_DFFE_PN0P_
+ _01458_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1874\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[19\]$_DFFE_PN0P_
+ _01459_ net2035 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1875\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[1\]$_DFFE_PN0P_
+ _01460_ net2034 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1857\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[20\]$_DFFE_PN0P_
+ _01461_ net2035 clknet_leaf_17_clk cs_registers_i.mhpmcounter\[1876\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[21\]$_DFFE_PN0P_
+ _01462_ net2035 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1877\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[22\]$_DFFE_PN0P_
+ _01463_ net2035 clknet_leaf_17_clk cs_registers_i.mhpmcounter\[1878\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[23\]$_DFFE_PN0P_
+ _01464_ net2035 clknet_leaf_17_clk cs_registers_i.mhpmcounter\[1879\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[24\]$_DFFE_PN0P_
+ _01465_ net2035 clknet_leaf_17_clk cs_registers_i.mhpmcounter\[1880\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[25\]$_DFFE_PN0P_
+ _01466_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1881\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[26\]$_DFFE_PN0P_
+ _01467_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1882\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[27\]$_DFFE_PN0P_
+ _01468_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1883\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[28\]$_DFFE_PN0P_
+ _01469_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1884\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[29\]$_DFFE_PN0P_
+ _01470_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1885\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[2\]$_DFFE_PN0P_
+ _01471_ net2034 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1858\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[30\]$_DFFE_PN0P_
+ _01472_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1886\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[31\]$_DFFE_PN0P_
+ _01473_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1887\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[32\]$_DFFE_PN0P_
+ _01474_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1888\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[33\]$_DFFE_PN0P_
+ _01475_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1889\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[34\]$_DFFE_PN0P_
+ _01476_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1890\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[35\]$_DFFE_PN0P_
+ _01477_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1891\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[36\]$_DFFE_PN0P_
+ _01478_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1892\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[37\]$_DFFE_PN0P_
+ _01479_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1893\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[38\]$_DFFE_PN0P_
+ _01480_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1894\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[39\]$_DFFE_PN0P_
+ _01481_ net2037 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1895\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[3\]$_DFFE_PN0P_
+ _01482_ net2034 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1859\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[40\]$_DFFE_PN0P_
+ _01483_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1896\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[41\]$_DFFE_PN0P_
+ _01484_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1897\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[42\]$_DFFE_PN0P_
+ _01485_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1898\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[43\]$_DFFE_PN0P_
+ _01486_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1899\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[44\]$_DFFE_PN0P_
+ _01487_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1900\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[45\]$_DFFE_PN0P_
+ _01488_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1901\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[46\]$_DFFE_PN0P_
+ _01489_ net2037 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1902\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[47\]$_DFFE_PN0P_
+ _01490_ net2037 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1903\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[48\]$_DFFE_PN0P_
+ _01491_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1904\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[49\]$_DFFE_PN0P_
+ _01492_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1905\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[4\]$_DFFE_PN0P_
+ _01493_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1860\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[50\]$_DFFE_PN0P_
+ _01494_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1906\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[51\]$_DFFE_PN0P_
+ _01495_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1907\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[52\]$_DFFE_PN0P_
+ _01496_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1908\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[53\]$_DFFE_PN0P_
+ _01497_ net2035 clknet_leaf_18_clk cs_registers_i.mhpmcounter\[1909\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[54\]$_DFFE_PN0P_
+ _01498_ net2035 clknet_leaf_18_clk cs_registers_i.mhpmcounter\[1910\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[55\]$_DFFE_PN0P_
+ _01499_ net2035 clknet_leaf_17_clk cs_registers_i.mhpmcounter\[1911\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[56\]$_DFFE_PN0P_
+ _01500_ net2035 clknet_leaf_18_clk cs_registers_i.mhpmcounter\[1912\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[57\]$_DFFE_PN0P_
+ _01501_ net2035 clknet_leaf_18_clk cs_registers_i.mhpmcounter\[1913\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[58\]$_DFFE_PN0P_
+ _01502_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1914\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[59\]$_DFFE_PN0P_
+ _01503_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1915\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[5\]$_DFFE_PN0P_
+ _01504_ net2034 clknet_leaf_21_clk cs_registers_i.mhpmcounter\[1861\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[60\]$_DFFE_PN0P_
+ _01505_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1916\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[61\]$_DFFE_PN0P_
+ _01506_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1917\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[62\]$_DFFE_PN0P_
+ _01507_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1918\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[63\]$_DFFE_PN0P_
+ _01508_ net2035 clknet_leaf_19_clk cs_registers_i.mhpmcounter\[1919\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[6\]$_DFFE_PN0P_
+ _01509_ net2034 clknet_leaf_22_clk cs_registers_i.mhpmcounter\[1862\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[7\]$_DFFE_PN0P_
+ _01510_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1863\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[8\]$_DFFE_PN0P_
+ _01511_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1864\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.minstret_counter_i.counter_val_o\[9\]$_DFFE_PN0P_
+ _01512_ net2034 clknet_leaf_20_clk cs_registers_i.mhpmcounter\[1865\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.priv_mode_id_o\[0\]$_DFFE_PN1P_ _01513_ net2034
+ clknet_leaf_11_clk cs_registers_i.priv_mode_id_o\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.priv_mode_id_o\[1\]$_DFFE_PN1P_ _01514_ net2034
+ clknet_leaf_10_clk cs_registers_i.priv_mode_id_o\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[0\]$_DFFE_PN1P_ _01515_
+ net2034 clknet_leaf_11_clk cs_registers_i.dcsr_q\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01516_
+ net2034 clknet_leaf_11_clk cs_registers_i.dcsr_q\[11\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01517_
+ net2034 clknet_leaf_11_clk cs_registers_i.dcsr_q\[12\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01518_
+ net2035 clknet_leaf_16_clk cs_registers_i.dcsr_q\[13\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01519_
+ net2035 clknet_leaf_16_clk cs_registers_i.dcsr_q\[15\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[1\]$_DFFE_PN1P_ _01520_
+ net2034 clknet_leaf_11_clk cs_registers_i.dcsr_q\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01521_
+ net2034 clknet_leaf_17_clk cs_registers_i.dcsr_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[6\]$_DFFE_PN0P_ _01522_
+ net2034 clknet_leaf_17_clk cs_registers_i.dcsr_q\[6\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[7\]$_DFFE_PN0P_ _01523_
+ net2035 clknet_leaf_6_clk cs_registers_i.dcsr_q\[7\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dcsr_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01524_
+ net2035 clknet_leaf_17_clk cs_registers_i.dcsr_q\[8\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[10\]$_DFFE_PN0P_ _01525_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_depc_o\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01526_
+ net2035 clknet_leaf_8_clk cs_registers_i.csr_depc_o\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01527_
+ net2034 clknet_leaf_10_clk cs_registers_i.csr_depc_o\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01528_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[14\]$_DFFE_PN0P_ _01529_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_depc_o\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01530_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_depc_o\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[16\]$_DFFE_PN0P_ _01531_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[17\]$_DFFE_PN0P_ _01532_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_depc_o\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[18\]$_DFFE_PN0P_ _01533_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_depc_o\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[19\]$_DFFE_PN0P_ _01534_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_depc_o\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01535_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_depc_o\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[20\]$_DFFE_PN0P_ _01536_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[21\]$_DFFE_PN0P_ _01537_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[22\]$_DFFE_PN0P_ _01538_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_depc_o\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[23\]$_DFFE_PN0P_ _01539_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[24\]$_DFFE_PN0P_ _01540_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_depc_o\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[25\]$_DFFE_PN0P_ _01541_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_depc_o\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[26\]$_DFFE_PN0P_ _01542_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_depc_o\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[27\]$_DFFE_PN0P_ _01543_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_depc_o\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[28\]$_DFFE_PN0P_ _01544_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_depc_o\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[29\]$_DFFE_PN0P_ _01545_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_depc_o\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01546_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_depc_o\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[30\]$_DFFE_PN0P_ _01547_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_depc_o\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[31\]$_DFFE_PN0P_ _01548_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_depc_o\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[3\]$_DFFE_PN0P_ _01549_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_depc_o\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[4\]$_DFFE_PN0P_ _01550_
+ net2034 clknet_leaf_9_clk cs_registers_i.csr_depc_o\[4\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[5\]$_DFFE_PN0P_ _01551_
+ net2034 clknet_leaf_10_clk cs_registers_i.csr_depc_o\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[6\]$_DFFE_PN0P_ _01552_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_depc_o\[6\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[7\]$_DFFE_PN0P_ _01553_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_depc_o\[7\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01554_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_depc_o\[8\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_depc_csr.rd_data_o\[9\]$_DFFE_PN0P_ _01555_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_depc_o\[9\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[0\]$_DFFE_PN0P_
+ _01556_ net2034 clknet_leaf_21_clk cs_registers_i.dscratch0_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[10\]$_DFFE_PN0P_
+ _01557_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[11\]$_DFFE_PN0P_
+ _01558_ net2034 clknet_leaf_24_clk cs_registers_i.dscratch0_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[12\]$_DFFE_PN0P_
+ _01559_ net2034 clknet_leaf_21_clk cs_registers_i.dscratch0_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[13\]$_DFFE_PN0P_
+ _01560_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch0_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[14\]$_DFFE_PN0P_
+ _01561_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[15\]$_DFFE_PN0P_
+ _01562_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch0_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[16\]$_DFFE_PN0P_
+ _01563_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[17\]$_DFFE_PN0P_
+ _01564_ net2035 clknet_leaf_15_clk cs_registers_i.dscratch0_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[18\]$_DFFE_PN0P_
+ _01565_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[19\]$_DFFE_PN0P_
+ _01566_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[1\]$_DFFE_PN0P_
+ _01567_ net2034 clknet_leaf_11_clk cs_registers_i.dscratch0_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[20\]$_DFFE_PN0P_
+ _01568_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[21\]$_DFFE_PN0P_
+ _01569_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[22\]$_DFFE_PN0P_
+ _01570_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[23\]$_DFFE_PN0P_
+ _01571_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[24\]$_DFFE_PN0P_
+ _01572_ net2035 clknet_leaf_15_clk cs_registers_i.dscratch0_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[25\]$_DFFE_PN0P_
+ _01573_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[26\]$_DFFE_PN0P_
+ _01574_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[27\]$_DFFE_PN0P_
+ _01575_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[28\]$_DFFE_PN0P_
+ _01576_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[29\]$_DFFE_PN0P_
+ _01577_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch0_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[2\]$_DFFE_PN0P_
+ _01578_ net2034 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[30\]$_DFFE_PN0P_
+ _01579_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[31\]$_DFFE_PN0P_
+ _01580_ net2034 clknet_leaf_21_clk cs_registers_i.dscratch0_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[3\]$_DFFE_PN0P_
+ _01581_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[4\]$_DFFE_PN0P_
+ _01582_ net2034 clknet_leaf_21_clk cs_registers_i.dscratch0_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[5\]$_DFFE_PN0P_
+ _01583_ net2034 clknet_leaf_24_clk cs_registers_i.dscratch0_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[6\]$_DFFE_PN0P_
+ _01584_ net2034 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[7\]$_DFFE_PN0P_
+ _01585_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch0_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[8\]$_DFFE_PN0P_
+ _01586_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch0_csr.rd_data_o\[9\]$_DFFE_PN0P_
+ _01587_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch0_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[0\]$_DFFE_PN0P_
+ _01588_ net2034 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[10\]$_DFFE_PN0P_
+ _01589_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch1_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[11\]$_DFFE_PN0P_
+ _01590_ net2034 clknet_leaf_11_clk cs_registers_i.dscratch1_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[12\]$_DFFE_PN0P_
+ _01591_ net2034 clknet_leaf_11_clk cs_registers_i.dscratch1_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[13\]$_DFFE_PN0P_
+ _01592_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[14\]$_DFFE_PN0P_
+ _01593_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[15\]$_DFFE_PN0P_
+ _01594_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[16\]$_DFFE_PN0P_
+ _01595_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[17\]$_DFFE_PN0P_
+ _01596_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[18\]$_DFFE_PN0P_
+ _01597_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[19\]$_DFFE_PN0P_
+ _01598_ net2035 clknet_leaf_15_clk cs_registers_i.dscratch1_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[1\]$_DFFE_PN0P_
+ _01599_ net2034 clknet_leaf_11_clk cs_registers_i.dscratch1_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[20\]$_DFFE_PN0P_
+ _01600_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[21\]$_DFFE_PN0P_
+ _01601_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[22\]$_DFFE_PN0P_
+ _01602_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[23\]$_DFFE_PN0P_
+ _01603_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[24\]$_DFFE_PN0P_
+ _01604_ net2035 clknet_leaf_15_clk cs_registers_i.dscratch1_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[25\]$_DFFE_PN0P_
+ _01605_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[26\]$_DFFE_PN0P_
+ _01606_ net2035 clknet_leaf_15_clk cs_registers_i.dscratch1_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[27\]$_DFFE_PN0P_
+ _01607_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[28\]$_DFFE_PN0P_
+ _01608_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[29\]$_DFFE_PN0P_
+ _01609_ net2035 clknet_leaf_18_clk cs_registers_i.dscratch1_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[2\]$_DFFE_PN0P_
+ _01610_ net2034 clknet_leaf_17_clk cs_registers_i.dscratch1_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[30\]$_DFFE_PN0P_
+ _01611_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch1_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[31\]$_DFFE_PN0P_
+ _01612_ net2034 clknet_leaf_11_clk cs_registers_i.dscratch1_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[3\]$_DFFE_PN0P_
+ _01613_ net2035 clknet_leaf_11_clk cs_registers_i.dscratch1_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[4\]$_DFFE_PN0P_
+ _01614_ net2034 clknet_leaf_24_clk cs_registers_i.dscratch1_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[5\]$_DFFE_PN0P_
+ _01615_ net2034 clknet_leaf_24_clk cs_registers_i.dscratch1_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[6\]$_DFFE_PN0P_
+ _01616_ net2035 clknet_leaf_17_clk cs_registers_i.dscratch1_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[7\]$_DFFE_PN0P_
+ _01617_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[8\]$_DFFE_PN0P_
+ _01618_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_dscratch1_csr.rd_data_o\[9\]$_DFFE_PN0P_
+ _01619_ net2035 clknet_leaf_16_clk cs_registers_i.dscratch1_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01620_
+ net2034 clknet_leaf_10_clk cs_registers_i.mcause_q\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01621_
+ net2035 clknet_leaf_6_clk cs_registers_i.mcause_q\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01622_
+ net2035 clknet_leaf_10_clk cs_registers_i.mcause_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[3\]$_DFFE_PN0P_ _01623_
+ net2035 clknet_leaf_10_clk cs_registers_i.mcause_q\[3\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[4\]$_DFFE_PN0P_ _01624_
+ net2035 clknet_leaf_8_clk cs_registers_i.mcause_q\[4\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mcause_csr.rd_data_o\[5\]$_DFFE_PN0P_ _01625_
+ net2035 clknet_leaf_10_clk cs_registers_i.mcause_q\[5\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01626_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_mepc_o\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[10\]$_DFFE_PN0P_ _01627_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mepc_o\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01628_
+ net2035 clknet_leaf_8_clk cs_registers_i.csr_mepc_o\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01629_
+ net2034 clknet_leaf_10_clk cs_registers_i.csr_mepc_o\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01630_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_mepc_o\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[14\]$_DFFE_PN0P_ _01631_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mepc_o\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01632_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mepc_o\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[16\]$_DFFE_PN0P_ _01633_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mepc_o\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[17\]$_DFFE_PN0P_ _01634_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mepc_o\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[18\]$_DFFE_PN0P_ _01635_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_mepc_o\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[19\]$_DFFE_PN0P_ _01636_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_mepc_o\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01637_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_mepc_o\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[20\]$_DFFE_PN0P_ _01638_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_mepc_o\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[21\]$_DFFE_PN0P_ _01639_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mepc_o\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[22\]$_DFFE_PN0P_ _01640_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mepc_o\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[23\]$_DFFE_PN0P_ _01641_
+ net2035 clknet_leaf_16_clk cs_registers_i.csr_mepc_o\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[24\]$_DFFE_PN0P_ _01642_
+ net2035 clknet_leaf_15_clk cs_registers_i.csr_mepc_o\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[25\]$_DFFE_PN0P_ _01643_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mepc_o\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[26\]$_DFFE_PN0P_ _01644_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mepc_o\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[27\]$_DFFE_PN0P_ _01645_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mepc_o\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[28\]$_DFFE_PN0P_ _01646_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mepc_o\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[29\]$_DFFE_PN0P_ _01647_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mepc_o\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01648_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mepc_o\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[30\]$_DFFE_PN0P_ _01649_
+ net2035 clknet_leaf_11_clk cs_registers_i.csr_mepc_o\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[31\]$_DFFE_PN0P_ _01650_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mepc_o\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[3\]$_DFFE_PN0P_ _01651_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mepc_o\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[4\]$_DFFE_PN0P_ _01652_
+ net2034 clknet_leaf_10_clk cs_registers_i.csr_mepc_o\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[5\]$_DFFE_PN0P_ _01653_
+ net2034 clknet_leaf_10_clk cs_registers_i.csr_mepc_o\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[6\]$_DFFE_PN0P_ _01654_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_mepc_o\[6\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[7\]$_DFFE_PN0P_ _01655_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_mepc_o\[7\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01656_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_mepc_o\[8\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mepc_csr.rd_data_o\[9\]$_DFFE_PN0P_ _01657_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mepc_o\[9\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01658_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[0\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[10\]$_DFFE_PN0P_ _01659_
+ net2035 clknet_leaf_14_clk cs_registers_i.mie_q\[10\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01660_
+ net2035 clknet_leaf_14_clk cs_registers_i.mie_q\[11\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01661_
+ net2035 clknet_leaf_14_clk cs_registers_i.mie_q\[12\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01662_
+ net2035 clknet_leaf_13_clk cs_registers_i.mie_q\[13\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[14\]$_DFFE_PN0P_ _01663_
+ net2035 clknet_leaf_12_clk cs_registers_i.mie_q\[14\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01664_
+ net2035 clknet_leaf_11_clk cs_registers_i.mie_q\[15\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[16\]$_DFFE_PN0P_ _01665_
+ net2035 clknet_leaf_11_clk cs_registers_i.mie_q\[16\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[17\]$_DFFE_PN0P_ _01666_
+ net2035 clknet_leaf_12_clk cs_registers_i.mie_q\[17\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01667_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[1\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01668_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[2\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[3\]$_DFFE_PN0P_ _01669_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[3\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[4\]$_DFFE_PN0P_ _01670_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[4\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[5\]$_DFFE_PN0P_ _01671_
+ net2035 clknet_leaf_16_clk cs_registers_i.mie_q\[5\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[6\]$_DFFE_PN0P_ _01672_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[6\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[7\]$_DFFE_PN0P_ _01673_
+ net2035 clknet_leaf_16_clk cs_registers_i.mie_q\[7\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01674_
+ net2035 clknet_leaf_15_clk cs_registers_i.mie_q\[8\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mie_csr.rd_data_o\[9\]$_DFFE_PN0P_ _01675_
+ net2035 clknet_leaf_14_clk cs_registers_i.mie_q\[9\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[0\]$_DFFE_PN0P_
+ _01676_ net2035 clknet_leaf_16_clk cs_registers_i.mscratch_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[10\]$_DFFE_PN0P_
+ _01677_ net2035 clknet_leaf_17_clk cs_registers_i.mscratch_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[11\]$_DFFE_PN0P_
+ _01678_ net2034 clknet_leaf_11_clk cs_registers_i.mscratch_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[12\]$_DFFE_PN0P_
+ _01679_ net2034 clknet_leaf_10_clk cs_registers_i.mscratch_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[13\]$_DFFE_PN0P_
+ _01680_ net2035 clknet_leaf_13_clk cs_registers_i.mscratch_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[14\]$_DFFE_PN0P_
+ _01681_ net2035 clknet_leaf_17_clk cs_registers_i.mscratch_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[15\]$_DFFE_PN0P_
+ _01682_ net2035 clknet_leaf_5_clk cs_registers_i.mscratch_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[16\]$_DFFE_PN0P_
+ _01683_ net2035 clknet_leaf_15_clk cs_registers_i.mscratch_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[17\]$_DFFE_PN0P_
+ _01684_ net2035 clknet_leaf_5_clk cs_registers_i.mscratch_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[18\]$_DFFE_PN0P_
+ _01685_ net2035 clknet_leaf_15_clk cs_registers_i.mscratch_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[19\]$_DFFE_PN0P_
+ _01686_ net2035 clknet_leaf_15_clk cs_registers_i.mscratch_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[1\]$_DFFE_PN0P_
+ _01687_ net2035 clknet_leaf_6_clk cs_registers_i.mscratch_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[20\]$_DFFE_PN0P_
+ _01688_ net2035 clknet_leaf_16_clk cs_registers_i.mscratch_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[21\]$_DFFE_PN0P_
+ _01689_ net2035 clknet_leaf_11_clk cs_registers_i.mscratch_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[22\]$_DFFE_PN0P_
+ _01690_ net2035 clknet_leaf_14_clk cs_registers_i.mscratch_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[23\]$_DFFE_PN0P_
+ _01691_ net2035 clknet_leaf_16_clk cs_registers_i.mscratch_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[24\]$_DFFE_PN0P_
+ _01692_ net2035 clknet_leaf_15_clk cs_registers_i.mscratch_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[25\]$_DFFE_PN0P_
+ _01693_ net2035 clknet_leaf_14_clk cs_registers_i.mscratch_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[26\]$_DFFE_PN0P_
+ _01694_ net2035 clknet_leaf_14_clk cs_registers_i.mscratch_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[27\]$_DFFE_PN0P_
+ _01695_ net2035 clknet_leaf_13_clk cs_registers_i.mscratch_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[28\]$_DFFE_PN0P_
+ _01696_ net2035 clknet_leaf_13_clk cs_registers_i.mscratch_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[29\]$_DFFE_PN0P_
+ _01697_ net2035 clknet_leaf_14_clk cs_registers_i.mscratch_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[2\]$_DFFE_PN0P_
+ _01698_ net2034 clknet_leaf_17_clk cs_registers_i.mscratch_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[30\]$_DFFE_PN0P_
+ _01699_ net2035 clknet_leaf_12_clk cs_registers_i.mscratch_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[31\]$_DFFE_PN0P_
+ _01700_ net2035 clknet_leaf_12_clk cs_registers_i.mscratch_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[3\]$_DFFE_PN0P_
+ _01701_ net2035 clknet_leaf_12_clk cs_registers_i.mscratch_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[4\]$_DFFE_PN0P_
+ _01702_ net2034 clknet_leaf_10_clk cs_registers_i.mscratch_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[5\]$_DFFE_PN0P_
+ _01703_ net2034 clknet_leaf_24_clk cs_registers_i.mscratch_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[6\]$_DFFE_PN0P_
+ _01704_ net2034 clknet_leaf_21_clk cs_registers_i.mscratch_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[7\]$_DFFE_PN0P_
+ _01705_ net2035 clknet_leaf_6_clk cs_registers_i.mscratch_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[8\]$_DFFE_PN0P_
+ _01706_ net2035 clknet_leaf_5_clk cs_registers_i.mscratch_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mscratch_csr.rd_data_o\[9\]$_DFFE_PN0P_
+ _01707_ net2035 clknet_leaf_16_clk cs_registers_i.mscratch_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[0\]$_DFFE_PN0P_
+ _01708_ net2034 clknet_leaf_10_clk cs_registers_i.mstack_cause_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[1\]$_DFFE_PN0P_
+ _01709_ net2035 clknet_leaf_8_clk cs_registers_i.mstack_cause_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[2\]$_DFFE_PN0P_
+ _01710_ net2035 clknet_leaf_12_clk cs_registers_i.mstack_cause_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[3\]$_DFFE_PN0P_
+ _01711_ net2035 clknet_leaf_12_clk cs_registers_i.mstack_cause_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[4\]$_DFFE_PN0P_
+ _01712_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_cause_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_cause_csr.rd_data_o\[5\]$_DFFE_PN0P_
+ _01713_ net2035 clknet_leaf_10_clk cs_registers_i.mstack_cause_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01714_
+ net2034 clknet_leaf_11_clk cs_registers_i.mstack_q\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01715_
+ net2034 clknet_leaf_10_clk cs_registers_i.mstack_q\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_csr.rd_data_o\[2\]$_DFFE_PN1P_ _01716_
+ net2035 clknet_leaf_11_clk cs_registers_i.mstack_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[0\]$_DFFE_PN0P_
+ _01717_ net2035 clknet_leaf_11_clk cs_registers_i.mstack_epc_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[10\]$_DFFE_PN0P_
+ _01718_ net2035 clknet_leaf_12_clk cs_registers_i.mstack_epc_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[11\]$_DFFE_PN0P_
+ _01719_ net2035 clknet_leaf_8_clk cs_registers_i.mstack_epc_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[12\]$_DFFE_PN0P_
+ _01720_ net2034 clknet_leaf_10_clk cs_registers_i.mstack_epc_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[13\]$_DFFE_PN0P_
+ _01721_ net2035 clknet_leaf_16_clk cs_registers_i.mstack_epc_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[14\]$_DFFE_PN0P_
+ _01722_ net2035 clknet_leaf_5_clk cs_registers_i.mstack_epc_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[15\]$_DFFE_PN0P_
+ _01723_ net2035 clknet_leaf_5_clk cs_registers_i.mstack_epc_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[16\]$_DFFE_PN0P_
+ _01724_ net2035 clknet_leaf_15_clk cs_registers_i.mstack_epc_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[17\]$_DFFE_PN0P_
+ _01725_ net2035 clknet_leaf_5_clk cs_registers_i.mstack_epc_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[18\]$_DFFE_PN0P_
+ _01726_ net2035 clknet_leaf_15_clk cs_registers_i.mstack_epc_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[19\]$_DFFE_PN0P_
+ _01727_ net2035 clknet_leaf_15_clk cs_registers_i.mstack_epc_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[1\]$_DFFE_PN0P_
+ _01728_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_epc_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[20\]$_DFFE_PN0P_
+ _01729_ net2035 clknet_leaf_16_clk cs_registers_i.mstack_epc_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[21\]$_DFFE_PN0P_
+ _01730_ net2035 clknet_leaf_13_clk cs_registers_i.mstack_epc_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[22\]$_DFFE_PN0P_
+ _01731_ net2035 clknet_leaf_14_clk cs_registers_i.mstack_epc_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[23\]$_DFFE_PN0P_
+ _01732_ net2035 clknet_leaf_15_clk cs_registers_i.mstack_epc_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[24\]$_DFFE_PN0P_
+ _01733_ net2035 clknet_leaf_15_clk cs_registers_i.mstack_epc_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[25\]$_DFFE_PN0P_
+ _01734_ net2035 clknet_leaf_14_clk cs_registers_i.mstack_epc_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[26\]$_DFFE_PN0P_
+ _01735_ net2035 clknet_leaf_4_clk cs_registers_i.mstack_epc_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[27\]$_DFFE_PN0P_
+ _01736_ net2035 clknet_leaf_4_clk cs_registers_i.mstack_epc_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[28\]$_DFFE_PN0P_
+ _01737_ net2035 clknet_leaf_4_clk cs_registers_i.mstack_epc_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[29\]$_DFFE_PN0P_
+ _01738_ net2035 clknet_leaf_14_clk cs_registers_i.mstack_epc_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[2\]$_DFFE_PN0P_
+ _01739_ net2035 clknet_leaf_12_clk cs_registers_i.mstack_epc_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[30\]$_DFFE_PN0P_
+ _01740_ net2035 clknet_leaf_11_clk cs_registers_i.mstack_epc_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[31\]$_DFFE_PN0P_
+ _01741_ net2035 clknet_leaf_12_clk cs_registers_i.mstack_epc_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[3\]$_DFFE_PN0P_
+ _01742_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_epc_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[4\]$_DFFE_PN0P_
+ _01743_ net2034 clknet_leaf_10_clk cs_registers_i.mstack_epc_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[5\]$_DFFE_PN0P_
+ _01744_ net2034 clknet_leaf_10_clk cs_registers_i.mstack_epc_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[6\]$_DFFE_PN0P_
+ _01745_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_epc_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[7\]$_DFFE_PN0P_
+ _01746_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_epc_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[8\]$_DFFE_PN0P_
+ _01747_ net2035 clknet_leaf_6_clk cs_registers_i.mstack_epc_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstack_epc_csr.rd_data_o\[9\]$_DFFE_PN0P_
+ _01748_ net2035 clknet_leaf_5_clk cs_registers_i.mstack_epc_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01749_
+ net2035 clknet_leaf_11_clk cs_registers_i.csr_mstatus_tw_o
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01750_
+ net2035 clknet_leaf_11_clk cs_registers_i.mstatus_q\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[2\]$_DFFE_PN0N_ _01751_
+ net2034 clknet_leaf_11_clk cs_registers_i.mstatus_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[3\]$_DFFE_PN0N_ _01752_
+ net2034 clknet_leaf_10_clk cs_registers_i.mstatus_q\[3\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[4\]$_DFFE_PN1N_ _01753_
+ net2035 clknet_leaf_11_clk cs_registers_i.mstatus_q\[4\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xcs_registers_i.u_mstatus_csr.rd_data_o\[5\]$_DFFE_PN0N_ _01754_
+ net2035 clknet_leaf_10_clk cs_registers_i.csr_mstatus_mie_o
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[0\]$_DFFE_PN0P_ _01755_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[0\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[10\]$_DFFE_PN0P_ _01756_
+ net2035 clknet_leaf_9_clk cs_registers_i.mtval_q\[10\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01757_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[11\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01758_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[12\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01759_
+ net2035 clknet_leaf_12_clk cs_registers_i.mtval_q\[13\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[14\]$_DFFE_PN0P_ _01760_
+ net2035 clknet_leaf_5_clk cs_registers_i.mtval_q\[14\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01761_
+ net2035 clknet_leaf_5_clk cs_registers_i.mtval_q\[15\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[16\]$_DFFE_PN0P_ _01762_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[16\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[17\]$_DFFE_PN0P_ _01763_
+ net2035 clknet_leaf_5_clk cs_registers_i.mtval_q\[17\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[18\]$_DFFE_PN0P_ _01764_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[18\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[19\]$_DFFE_PN0P_ _01765_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[19\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[1\]$_DFFE_PN0P_ _01766_
+ net2035 clknet_leaf_8_clk cs_registers_i.mtval_q\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[20\]$_DFFE_PN0P_ _01767_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[20\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[21\]$_DFFE_PN0P_ _01768_
+ net2035 clknet_leaf_12_clk cs_registers_i.mtval_q\[21\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[22\]$_DFFE_PN0P_ _01769_
+ net2035 clknet_leaf_14_clk cs_registers_i.mtval_q\[22\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[23\]$_DFFE_PN0P_ _01770_
+ net2035 clknet_leaf_12_clk cs_registers_i.mtval_q\[23\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[24\]$_DFFE_PN0P_ _01771_
+ net2035 clknet_leaf_5_clk cs_registers_i.mtval_q\[24\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[25\]$_DFFE_PN0P_ _01772_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[25\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[26\]$_DFFE_PN0P_ _01773_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[26\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[27\]$_DFFE_PN0P_ _01774_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[27\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[28\]$_DFFE_PN0P_ _01775_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[28\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[29\]$_DFFE_PN0P_ _01776_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[29\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[2\]$_DFFE_PN0P_ _01777_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[30\]$_DFFE_PN0P_ _01778_
+ net2035 clknet_leaf_13_clk cs_registers_i.mtval_q\[30\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[31\]$_DFFE_PN0P_ _01779_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[31\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[3\]$_DFFE_PN0P_ _01780_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[3\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[4\]$_DFFE_PN0P_ _01781_
+ net2034 clknet_leaf_9_clk cs_registers_i.mtval_q\[4\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[5\]$_DFFE_PN0P_ _01782_
+ net2034 clknet_leaf_10_clk cs_registers_i.mtval_q\[5\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[6\]$_DFFE_PN0P_ _01783_
+ net2034 clknet_leaf_8_clk cs_registers_i.mtval_q\[6\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[7\]$_DFFE_PN0P_ _01784_
+ net2035 clknet_leaf_8_clk cs_registers_i.mtval_q\[7\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01785_
+ net2035 clknet_leaf_6_clk cs_registers_i.mtval_q\[8\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtval_csr.rd_data_o\[9\]$_DFFE_PN0P_ _01786_
+ net2035 clknet_leaf_5_clk cs_registers_i.mtval_q\[9\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[10\]$_DFFE_PN0P_ _01787_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mtvec_o\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[11\]$_DFFE_PN0P_ _01788_
+ net2035 clknet_leaf_6_clk cs_registers_i.csr_mtvec_o\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[12\]$_DFFE_PN0P_ _01789_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mtvec_o\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[13\]$_DFFE_PN0P_ _01790_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[14\]$_DFFE_PN0P_ _01791_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mtvec_o\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[15\]$_DFFE_PN0P_ _01792_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mtvec_o\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[16\]$_DFFE_PN0P_ _01793_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[17\]$_DFFE_PN0P_ _01794_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mtvec_o\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[18\]$_DFFE_PN0P_ _01795_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[19\]$_DFFE_PN0P_ _01796_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mtvec_o\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[20\]$_DFFE_PN0P_ _01797_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[21\]$_DFFE_PN0P_ _01798_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[22\]$_DFFE_PN0P_ _01799_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mtvec_o\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[23\]$_DFFE_PN0P_ _01800_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[24\]$_DFFE_PN0P_ _01801_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mtvec_o\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[25\]$_DFFE_PN0P_ _01802_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mtvec_o\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[26\]$_DFFE_PN0P_ _01803_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mtvec_o\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[27\]$_DFFE_PN0P_ _01804_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mtvec_o\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[28\]$_DFFE_PN0P_ _01805_
+ net2035 clknet_leaf_4_clk cs_registers_i.csr_mtvec_o\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[29\]$_DFFE_PN0P_ _01806_
+ net2035 clknet_leaf_14_clk cs_registers_i.csr_mtvec_o\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[30\]$_DFFE_PN0P_ _01807_
+ net2035 clknet_leaf_13_clk cs_registers_i.csr_mtvec_o\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[31\]$_DFFE_PN0P_ _01808_
+ net2035 clknet_leaf_12_clk cs_registers_i.csr_mtvec_o\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[8\]$_DFFE_PN0P_ _01809_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mtvec_o\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcs_registers_i.u_mtvec_csr.rd_data_o\[9\]$_DFFE_PN0P_ _01810_
+ net2035 clknet_leaf_5_clk cs_registers_i.csr_mtvec_o\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_by_zero_q$_DFFE_PN0P_
+ _01811_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_by_zero_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]$_DFFE_PN0P_
+ _01812_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]$_DFFE_PN0P_
+ _01813_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]$_DFFE_PN0P_
+ _01814_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]$_DFFE_PN0P_
+ _01815_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]$_DFFE_PN0P_
+ _01816_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_counter_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]$_DFF_PN1_
+ _00000_ net2037 clknet_leaf_29_clk ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]$_DFF_PN0_
+ _00001_ net2037 clknet_leaf_29_clk ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[1\]$_DFF_PN0_
+ _00002_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[3\]$_DFF_PN0_
+ _00003_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.div_valid
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[4\]$_DFF_PN0_
+ _00004_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[6\]$_DFF_PN0_
+ _00005_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]$_DFFE_PN0P_
+ _01817_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]$_DFFE_PN0P_
+ _01818_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]$_DFFE_PN0P_
+ _01819_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]$_DFFE_PN0P_
+ _01820_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]$_DFFE_PN0P_
+ _01821_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]$_DFFE_PN0P_
+ _01822_ net2037 clknet_leaf_29_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]$_DFFE_PN0P_
+ _01823_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]$_DFFE_PN0P_
+ _01824_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]$_DFFE_PN0P_
+ _01825_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]$_DFFE_PN0P_
+ _01826_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]$_DFFE_PN0P_
+ _01827_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]$_DFFE_PN0P_
+ _01828_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]$_DFFE_PN0P_
+ _01829_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]$_DFFE_PN0P_
+ _01830_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]$_DFFE_PN0P_
+ _01831_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]$_DFFE_PN0P_
+ _01832_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]$_DFFE_PN0P_
+ _01833_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]$_DFFE_PN0P_
+ _01834_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]$_DFFE_PN0P_
+ _01835_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]$_DFFE_PN0P_
+ _01836_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]$_DFFE_PN0P_
+ _01837_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]$_DFFE_PN0P_
+ _01838_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]$_DFFE_PN0P_
+ _01839_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]$_DFFE_PN0P_
+ _01840_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]$_DFFE_PN0P_
+ _01841_ net2037 clknet_leaf_25_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]$_DFFE_PN0P_
+ _01842_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]$_DFFE_PN0P_
+ _01843_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]$_DFFE_PN0P_
+ _01844_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]$_DFFE_PN0P_
+ _01845_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]$_DFFE_PN0P_
+ _01846_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]$_DFFE_PN0P_
+ _01847_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]$_DFFE_PN0P_
+ _01848_ net2037 clknet_leaf_30_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_numerator_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]$_DFFE_PN0P_
+ _01849_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]$_DFFE_PN0P_
+ _01850_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]$_DFFE_PN0P_
+ _01851_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]$_DFFE_PN0P_
+ _01852_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]$_DFFE_PN0P_
+ _01853_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]$_DFFE_PN0P_
+ _01854_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]$_DFFE_PN0P_
+ _01855_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]$_DFFE_PN0P_
+ _01856_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]$_DFFE_PN0P_
+ _01857_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]$_DFFE_PN0P_
+ _01858_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]$_DFFE_PN0P_
+ _01859_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]$_DFFE_PN0P_
+ _01860_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]$_DFFE_PN0P_
+ _01861_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]$_DFFE_PN0P_
+ _01862_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]$_DFFE_PN0P_
+ _01863_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]$_DFFE_PN0P_
+ _01864_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]$_DFFE_PN0P_
+ _01865_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]$_DFFE_PN0P_
+ _01866_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]$_DFFE_PN0P_
+ _01867_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]$_DFFE_PN0P_
+ _01868_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]$_DFFE_PN0P_
+ _01869_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]$_DFFE_PN0P_
+ _01870_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]$_DFFE_PN0P_
+ _01871_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]$_DFFE_PN0P_
+ _01872_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]$_DFFE_PN0P_
+ _01873_ net2037 clknet_leaf_26_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]$_DFFE_PN0P_
+ _01874_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]$_DFFE_PN0P_
+ _01875_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]$_DFFE_PN0P_
+ _01876_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]$_DFFE_PN0P_
+ _01877_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]$_DFFE_PN0P_
+ _01878_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]$_DFFE_PN0P_
+ _01879_ net2037 clknet_leaf_27_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]$_DFFE_PN0P_
+ _01880_ net2037 clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.op_quotient_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xfetch_enable_q$_DFFE_PN0P_ _01881_ net2034 clknet_leaf_2_clk_i_regs
+ fetch_enable_q VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1000\]$_DFFE_PN0P_
+ _01882_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1000\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1001\]$_DFFE_PN0P_
+ _01883_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1001\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1002\]$_DFFE_PN0P_
+ _01884_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1002\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1003\]$_DFFE_PN0P_
+ _01885_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1003\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1004\]$_DFFE_PN0P_
+ _01886_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1004\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1005\]$_DFFE_PN0P_
+ _01887_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1005\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1006\]$_DFFE_PN0P_
+ _01888_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1006\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1007\]$_DFFE_PN0P_
+ _01889_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1007\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1008\]$_DFFE_PN0P_
+ _01890_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1008\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1009\]$_DFFE_PN0P_
+ _01891_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1009\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[100\]$_DFFE_PN0P_
+ _01892_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[100\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1010\]$_DFFE_PN0P_
+ _01893_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1010\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1011\]$_DFFE_PN0P_
+ _01894_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1011\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1012\]$_DFFE_PN0P_
+ _01895_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1012\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1013\]$_DFFE_PN0P_
+ _01896_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1013\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1014\]$_DFFE_PN0P_
+ _01897_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1014\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1015\]$_DFFE_PN0P_
+ _01898_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1015\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1016\]$_DFFE_PN0P_
+ _01899_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1016\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1017\]$_DFFE_PN0P_
+ _01900_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1017\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1018\]$_DFFE_PN0P_
+ _01901_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1018\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1019\]$_DFFE_PN0P_
+ _01902_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1019\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[101\]$_DFFE_PN0P_
+ _01903_ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[101\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1020\]$_DFFE_PN0P_
+ _01904_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1020\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1021\]$_DFFE_PN0P_
+ _01905_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1021\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1022\]$_DFFE_PN0P_
+ _01906_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1022\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[1023\]$_DFFE_PN0P_
+ _01907_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[1023\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[102\]$_DFFE_PN0P_
+ _01908_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[102\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[103\]$_DFFE_PN0P_
+ _01909_ net153 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[103\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[104\]$_DFFE_PN0P_
+ _01910_ net153 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[104\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[105\]$_DFFE_PN0P_
+ _01911_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[105\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[106\]$_DFFE_PN0P_
+ _01912_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[106\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[107\]$_DFFE_PN0P_
+ _01913_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[107\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[108\]$_DFFE_PN0P_
+ _01914_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[108\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[109\]$_DFFE_PN0P_
+ _01915_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[109\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[110\]$_DFFE_PN0P_
+ _01916_ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[110\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[111\]$_DFFE_PN0P_
+ _01917_ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[111\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[112\]$_DFFE_PN0P_
+ _01918_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[112\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[113\]$_DFFE_PN0P_
+ _01919_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[113\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[114\]$_DFFE_PN0P_
+ _01920_ net2036 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[114\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[115\]$_DFFE_PN0P_
+ _01921_ net2037 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[115\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[116\]$_DFFE_PN0P_
+ _01922_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[116\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[117\]$_DFFE_PN0P_
+ _01923_ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[117\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[118\]$_DFFE_PN0P_
+ _01924_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[118\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[119\]$_DFFE_PN0P_
+ _01925_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[119\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[120\]$_DFFE_PN0P_
+ _01926_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[120\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[121\]$_DFFE_PN0P_
+ _01927_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[121\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[122\]$_DFFE_PN0P_
+ _01928_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[122\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[123\]$_DFFE_PN0P_
+ _01929_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[123\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[124\]$_DFFE_PN0P_
+ _01930_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[124\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[125\]$_DFFE_PN0P_
+ _01931_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[125\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[126\]$_DFFE_PN0P_
+ _01932_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[126\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[127\]$_DFFE_PN0P_
+ _01933_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[127\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[128\]$_DFFE_PN0P_
+ _01934_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[128\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[129\]$_DFFE_PN0P_
+ _01935_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[129\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[130\]$_DFFE_PN0P_
+ _01936_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[130\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[131\]$_DFFE_PN0P_
+ _01937_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[131\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[132\]$_DFFE_PN0P_
+ _01938_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[132\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[133\]$_DFFE_PN0P_
+ _01939_ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[133\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[134\]$_DFFE_PN0P_
+ _01940_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[134\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[135\]$_DFFE_PN0P_
+ _01941_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[135\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[136\]$_DFFE_PN0P_
+ _01942_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[136\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[137\]$_DFFE_PN0P_
+ _01943_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[137\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[138\]$_DFFE_PN0P_
+ _01944_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[138\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[139\]$_DFFE_PN0P_
+ _01945_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[139\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[140\]$_DFFE_PN0P_
+ _01946_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[140\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[141\]$_DFFE_PN0P_
+ _01947_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[141\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[142\]$_DFFE_PN0P_
+ _01948_ net2033 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[142\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[143\]$_DFFE_PN0P_
+ _01949_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[143\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[144\]$_DFFE_PN0P_
+ _01950_ net153 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[144\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[145\]$_DFFE_PN0P_
+ _01951_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[145\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[146\]$_DFFE_PN0P_
+ _01952_ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[146\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[147\]$_DFFE_PN0P_
+ _01953_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[147\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[148\]$_DFFE_PN0P_
+ _01954_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[148\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[149\]$_DFFE_PN0P_
+ _01955_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[149\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[150\]$_DFFE_PN0P_
+ _01956_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[150\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[151\]$_DFFE_PN0P_
+ _01957_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[151\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[152\]$_DFFE_PN0P_
+ _01958_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[152\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[153\]$_DFFE_PN0P_
+ _01959_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[153\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[154\]$_DFFE_PN0P_
+ _01960_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[154\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[155\]$_DFFE_PN0P_
+ _01961_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[155\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[156\]$_DFFE_PN0P_
+ _01962_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[156\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[157\]$_DFFE_PN0P_
+ _01963_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[157\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[158\]$_DFFE_PN0P_
+ _01964_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[158\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[159\]$_DFFE_PN0P_
+ _01965_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[159\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[160\]$_DFFE_PN0P_
+ _01966_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[160\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[161\]$_DFFE_PN0P_
+ _01967_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[161\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[162\]$_DFFE_PN0P_
+ _01968_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[162\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[163\]$_DFFE_PN0P_
+ _01969_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[163\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[164\]$_DFFE_PN0P_
+ _01970_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[164\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[165\]$_DFFE_PN0P_
+ _01971_ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[165\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[166\]$_DFFE_PN0P_
+ _01972_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[166\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[167\]$_DFFE_PN0P_
+ _01973_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[167\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[168\]$_DFFE_PN0P_
+ _01974_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[168\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[169\]$_DFFE_PN0P_
+ _01975_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[169\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[170\]$_DFFE_PN0P_
+ _01976_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[170\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[171\]$_DFFE_PN0P_
+ _01977_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[171\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[172\]$_DFFE_PN0P_
+ _01978_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[172\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[173\]$_DFFE_PN0P_
+ _01979_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[173\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[174\]$_DFFE_PN0P_
+ _01980_ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[174\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[175\]$_DFFE_PN0P_
+ _01981_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[175\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[176\]$_DFFE_PN0P_
+ _01982_ net153 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[176\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[177\]$_DFFE_PN0P_
+ _01983_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[177\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[178\]$_DFFE_PN0P_
+ _01984_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[178\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[179\]$_DFFE_PN0P_
+ _01985_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[179\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[180\]$_DFFE_PN0P_
+ _01986_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[180\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[181\]$_DFFE_PN0P_
+ _01987_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[181\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[182\]$_DFFE_PN0P_
+ _01988_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[182\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[183\]$_DFFE_PN0P_
+ _01989_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[183\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[184\]$_DFFE_PN0P_
+ _01990_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[184\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[185\]$_DFFE_PN0P_
+ _01991_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[185\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[186\]$_DFFE_PN0P_
+ _01992_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[186\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[187\]$_DFFE_PN0P_
+ _01993_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[187\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[188\]$_DFFE_PN0P_
+ _01994_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[188\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[189\]$_DFFE_PN0P_
+ _01995_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[189\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[190\]$_DFFE_PN0P_
+ _01996_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[190\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[191\]$_DFFE_PN0P_
+ _01997_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[191\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[192\]$_DFFE_PN0P_
+ _01998_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[192\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[193\]$_DFFE_PN0P_
+ _01999_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[193\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[194\]$_DFFE_PN0P_
+ _02000_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[194\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[195\]$_DFFE_PN0P_
+ _02001_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[195\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[196\]$_DFFE_PN0P_
+ _02002_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[196\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[197\]$_DFFE_PN0P_
+ _02003_ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[197\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[198\]$_DFFE_PN0P_
+ _02004_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[198\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[199\]$_DFFE_PN0P_
+ _02005_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[199\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[200\]$_DFFE_PN0P_
+ _02006_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[200\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[201\]$_DFFE_PN0P_
+ _02007_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[201\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[202\]$_DFFE_PN0P_
+ _02008_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[202\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[203\]$_DFFE_PN0P_
+ _02009_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[203\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[204\]$_DFFE_PN0P_
+ _02010_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[204\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[205\]$_DFFE_PN0P_
+ _02011_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[205\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[206\]$_DFFE_PN0P_
+ _02012_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[206\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[207\]$_DFFE_PN0P_
+ _02013_ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[207\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[208\]$_DFFE_PN0P_
+ _02014_ net153 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[208\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[209\]$_DFFE_PN0P_
+ _02015_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[209\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[210\]$_DFFE_PN0P_
+ _02016_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[210\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[211\]$_DFFE_PN0P_
+ _02017_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[211\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[212\]$_DFFE_PN0P_
+ _02018_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[212\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[213\]$_DFFE_PN0P_
+ _02019_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[213\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[214\]$_DFFE_PN0P_
+ _02020_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[214\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[215\]$_DFFE_PN0P_
+ _02021_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[215\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[216\]$_DFFE_PN0P_
+ _02022_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[216\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[217\]$_DFFE_PN0P_
+ _02023_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[217\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[218\]$_DFFE_PN0P_
+ _02024_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[218\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[219\]$_DFFE_PN0P_
+ _02025_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[219\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[220\]$_DFFE_PN0P_
+ _02026_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[220\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[221\]$_DFFE_PN0P_
+ _02027_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[221\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[222\]$_DFFE_PN0P_
+ _02028_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[222\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[223\]$_DFFE_PN0P_
+ _02029_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[223\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[224\]$_DFFE_PN0P_
+ _02030_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[224\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[225\]$_DFFE_PN0P_
+ _02031_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[225\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[226\]$_DFFE_PN0P_
+ _02032_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[226\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[227\]$_DFFE_PN0P_
+ _02033_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[227\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[228\]$_DFFE_PN0P_
+ _02034_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[228\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[229\]$_DFFE_PN0P_
+ _02035_ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[229\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[230\]$_DFFE_PN0P_
+ _02036_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[230\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[231\]$_DFFE_PN0P_
+ _02037_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[231\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[232\]$_DFFE_PN0P_
+ _02038_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[232\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[233\]$_DFFE_PN0P_
+ _02039_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[233\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[234\]$_DFFE_PN0P_
+ _02040_ net2034 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[234\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[235\]$_DFFE_PN0P_
+ _02041_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[235\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[236\]$_DFFE_PN0P_
+ _02042_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[236\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[237\]$_DFFE_PN0P_
+ _02043_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[237\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[238\]$_DFFE_PN0P_
+ _02044_ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[238\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[239\]$_DFFE_PN0P_
+ _02045_ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[239\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[240\]$_DFFE_PN0P_
+ _02046_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[240\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[241\]$_DFFE_PN0P_
+ _02047_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[241\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[242\]$_DFFE_PN0P_
+ _02048_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[242\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[243\]$_DFFE_PN0P_
+ _02049_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[243\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[244\]$_DFFE_PN0P_
+ _02050_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[244\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[245\]$_DFFE_PN0P_
+ _02051_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[245\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[246\]$_DFFE_PN0P_
+ _02052_ net2034 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[246\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[247\]$_DFFE_PN0P_
+ _02053_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[247\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[248\]$_DFFE_PN0P_
+ _02054_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[248\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[249\]$_DFFE_PN0P_
+ _02055_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[249\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[250\]$_DFFE_PN0P_
+ _02056_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[250\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[251\]$_DFFE_PN0P_
+ _02057_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[251\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[252\]$_DFFE_PN0P_
+ _02058_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[252\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[253\]$_DFFE_PN0P_
+ _02059_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[253\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[254\]$_DFFE_PN0P_
+ _02060_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[254\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[255\]$_DFFE_PN0P_
+ _02061_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[255\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[256\]$_DFFE_PN0P_
+ _02062_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[256\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[257\]$_DFFE_PN0P_
+ _02063_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[257\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[258\]$_DFFE_PN0P_
+ _02064_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[258\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[259\]$_DFFE_PN0P_
+ _02065_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[259\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[260\]$_DFFE_PN0P_
+ _02066_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[260\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[261\]$_DFFE_PN0P_
+ _02067_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[261\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[262\]$_DFFE_PN0P_
+ _02068_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[262\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[263\]$_DFFE_PN0P_
+ _02069_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[263\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[264\]$_DFFE_PN0P_
+ _02070_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[264\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[265\]$_DFFE_PN0P_
+ _02071_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[265\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[266\]$_DFFE_PN0P_
+ _02072_ net2033 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[266\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[267\]$_DFFE_PN0P_
+ _02073_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[267\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[268\]$_DFFE_PN0P_
+ _02074_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[268\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[269\]$_DFFE_PN0P_
+ _02075_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[269\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[270\]$_DFFE_PN0P_
+ _02076_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[270\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[271\]$_DFFE_PN0P_
+ _02077_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[271\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[272\]$_DFFE_PN0P_
+ _02078_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[272\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[273\]$_DFFE_PN0P_
+ _02079_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[273\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[274\]$_DFFE_PN0P_
+ _02080_ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[274\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[275\]$_DFFE_PN0P_
+ _02081_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[275\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[276\]$_DFFE_PN0P_
+ _02082_ net2037 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[276\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[277\]$_DFFE_PN0P_
+ _02083_ net153 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[277\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[278\]$_DFFE_PN0P_
+ _02084_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[278\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[279\]$_DFFE_PN0P_
+ _02085_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[279\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[280\]$_DFFE_PN0P_
+ _02086_ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[280\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[281\]$_DFFE_PN0P_
+ _02087_ net153 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[281\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[282\]$_DFFE_PN0P_
+ _02088_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[282\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[283\]$_DFFE_PN0P_
+ _02089_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[283\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[284\]$_DFFE_PN0P_
+ _02090_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[284\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[285\]$_DFFE_PN0P_
+ _02091_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[285\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[286\]$_DFFE_PN0P_
+ _02092_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[286\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[287\]$_DFFE_PN0P_
+ _02093_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[287\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[288\]$_DFFE_PN0P_
+ _02094_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[288\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[289\]$_DFFE_PN0P_
+ _02095_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[289\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[290\]$_DFFE_PN0P_
+ _02096_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[290\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[291\]$_DFFE_PN0P_
+ _02097_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[291\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[292\]$_DFFE_PN0P_
+ _02098_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[292\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[293\]$_DFFE_PN0P_
+ _02099_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[293\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[294\]$_DFFE_PN0P_
+ _02100_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[294\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[295\]$_DFFE_PN0P_
+ _02101_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[295\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[296\]$_DFFE_PN0P_
+ _02102_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[296\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[297\]$_DFFE_PN0P_
+ _02103_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[297\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[298\]$_DFFE_PN0P_
+ _02104_ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[298\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[299\]$_DFFE_PN0P_
+ _02105_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[299\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[300\]$_DFFE_PN0P_
+ _02106_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[300\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[301\]$_DFFE_PN0P_
+ _02107_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[301\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[302\]$_DFFE_PN0P_
+ _02108_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[302\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[303\]$_DFFE_PN0P_
+ _02109_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[303\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[304\]$_DFFE_PN0P_
+ _02110_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[304\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[305\]$_DFFE_PN0P_
+ _02111_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[305\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[306\]$_DFFE_PN0P_
+ _02112_ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[306\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[307\]$_DFFE_PN0P_
+ _02113_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[307\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[308\]$_DFFE_PN0P_
+ _02114_ net2037 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[308\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[309\]$_DFFE_PN0P_
+ _02115_ net153 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[309\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[310\]$_DFFE_PN0P_
+ _02116_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[310\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[311\]$_DFFE_PN0P_
+ _02117_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[311\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[312\]$_DFFE_PN0P_
+ _02118_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[312\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[313\]$_DFFE_PN0P_
+ _02119_ net153 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[313\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[314\]$_DFFE_PN0P_
+ _02120_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[314\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[315\]$_DFFE_PN0P_
+ _02121_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[315\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[316\]$_DFFE_PN0P_
+ _02122_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[316\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[317\]$_DFFE_PN0P_
+ _02123_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[317\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[318\]$_DFFE_PN0P_
+ _02124_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[318\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[319\]$_DFFE_PN0P_
+ _02125_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[319\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[320\]$_DFFE_PN0P_
+ _02126_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[320\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[321\]$_DFFE_PN0P_
+ _02127_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[321\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[322\]$_DFFE_PN0P_
+ _02128_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[322\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[323\]$_DFFE_PN0P_
+ _02129_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[323\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[324\]$_DFFE_PN0P_
+ _02130_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[324\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[325\]$_DFFE_PN0P_
+ _02131_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[325\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[326\]$_DFFE_PN0P_
+ _02132_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[326\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[327\]$_DFFE_PN0P_
+ _02133_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[327\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[328\]$_DFFE_PN0P_
+ _02134_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[328\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[329\]$_DFFE_PN0P_
+ _02135_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[329\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[32\]$_DFFE_PN0P_ _02136_
+ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[32\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[330\]$_DFFE_PN0P_
+ _02137_ net2033 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[330\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[331\]$_DFFE_PN0P_
+ _02138_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[331\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[332\]$_DFFE_PN0P_
+ _02139_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[332\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[333\]$_DFFE_PN0P_
+ _02140_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[333\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[334\]$_DFFE_PN0P_
+ _02141_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[334\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[335\]$_DFFE_PN0P_
+ _02142_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[335\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[336\]$_DFFE_PN0P_
+ _02143_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[336\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[337\]$_DFFE_PN0P_
+ _02144_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[337\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[338\]$_DFFE_PN0P_
+ _02145_ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[338\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[339\]$_DFFE_PN0P_
+ _02146_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[339\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[33\]$_DFFE_PN0P_ _02147_
+ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[33\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[340\]$_DFFE_PN0P_
+ _02148_ net2037 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[340\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[341\]$_DFFE_PN0P_
+ _02149_ net153 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[341\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[342\]$_DFFE_PN0P_
+ _02150_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[342\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[343\]$_DFFE_PN0P_
+ _02151_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[343\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[344\]$_DFFE_PN0P_
+ _02152_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[344\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[345\]$_DFFE_PN0P_
+ _02153_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[345\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[346\]$_DFFE_PN0P_
+ _02154_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[346\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[347\]$_DFFE_PN0P_
+ _02155_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[347\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[348\]$_DFFE_PN0P_
+ _02156_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[348\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[349\]$_DFFE_PN0P_
+ _02157_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[349\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[34\]$_DFFE_PN0P_ _02158_
+ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[34\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[350\]$_DFFE_PN0P_
+ _02159_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[350\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[351\]$_DFFE_PN0P_
+ _02160_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[351\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[352\]$_DFFE_PN0P_
+ _02161_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[352\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[353\]$_DFFE_PN0P_
+ _02162_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[353\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[354\]$_DFFE_PN0P_
+ _02163_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[354\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[355\]$_DFFE_PN0P_
+ _02164_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[355\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[356\]$_DFFE_PN0P_
+ _02165_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[356\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[357\]$_DFFE_PN0P_
+ _02166_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[357\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[358\]$_DFFE_PN0P_
+ _02167_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[358\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[359\]$_DFFE_PN0P_
+ _02168_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[359\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[35\]$_DFFE_PN0P_ _02169_
+ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[35\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[360\]$_DFFE_PN0P_
+ _02170_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[360\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[361\]$_DFFE_PN0P_
+ _02171_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[361\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[362\]$_DFFE_PN0P_
+ _02172_ net2033 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[362\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[363\]$_DFFE_PN0P_
+ _02173_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[363\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[364\]$_DFFE_PN0P_
+ _02174_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[364\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[365\]$_DFFE_PN0P_
+ _02175_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[365\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[366\]$_DFFE_PN0P_
+ _02176_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[366\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[367\]$_DFFE_PN0P_
+ _02177_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[367\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[368\]$_DFFE_PN0P_
+ _02178_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[368\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[369\]$_DFFE_PN0P_
+ _02179_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[369\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[36\]$_DFFE_PN0P_ _02180_
+ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[36\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[370\]$_DFFE_PN0P_
+ _02181_ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[370\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[371\]$_DFFE_PN0P_
+ _02182_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[371\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[372\]$_DFFE_PN0P_
+ _02183_ net2037 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[372\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[373\]$_DFFE_PN0P_
+ _02184_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[373\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[374\]$_DFFE_PN0P_
+ _02185_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[374\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[375\]$_DFFE_PN0P_
+ _02186_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[375\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[376\]$_DFFE_PN0P_
+ _02187_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[376\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[377\]$_DFFE_PN0P_
+ _02188_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[377\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[378\]$_DFFE_PN0P_
+ _02189_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[378\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[379\]$_DFFE_PN0P_
+ _02190_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[379\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[37\]$_DFFE_PN0P_ _02191_
+ net2034 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[37\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[380\]$_DFFE_PN0P_
+ _02192_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[380\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[381\]$_DFFE_PN0P_
+ _02193_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[381\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[382\]$_DFFE_PN0P_
+ _02194_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[382\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[383\]$_DFFE_PN0P_
+ _02195_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[383\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[384\]$_DFFE_PN0P_
+ _02196_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[384\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[385\]$_DFFE_PN0P_
+ _02197_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[385\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[386\]$_DFFE_PN0P_
+ _02198_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[386\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[387\]$_DFFE_PN0P_
+ _02199_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[387\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[388\]$_DFFE_PN0P_
+ _02200_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[388\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[389\]$_DFFE_PN0P_
+ _02201_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[389\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[38\]$_DFFE_PN0P_ _02202_
+ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[38\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[390\]$_DFFE_PN0P_
+ _02203_ net2033 clknet_leaf_2_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[390\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[391\]$_DFFE_PN0P_
+ _02204_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[391\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[392\]$_DFFE_PN0P_
+ _02205_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[392\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[393\]$_DFFE_PN0P_
+ _02206_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[393\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[394\]$_DFFE_PN0P_
+ _02207_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[394\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[395\]$_DFFE_PN0P_
+ _02208_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[395\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[396\]$_DFFE_PN0P_
+ _02209_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[396\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[397\]$_DFFE_PN0P_
+ _02210_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[397\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[398\]$_DFFE_PN0P_
+ _02211_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[398\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[399\]$_DFFE_PN0P_
+ _02212_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[399\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[39\]$_DFFE_PN0P_ _02213_
+ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[39\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[400\]$_DFFE_PN0P_
+ _02214_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[400\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[401\]$_DFFE_PN0P_
+ _02215_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[401\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[402\]$_DFFE_PN0P_
+ _02216_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[402\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[403\]$_DFFE_PN0P_
+ _02217_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[403\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[404\]$_DFFE_PN0P_
+ _02218_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[404\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[405\]$_DFFE_PN0P_
+ _02219_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[405\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[406\]$_DFFE_PN0P_
+ _02220_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[406\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[407\]$_DFFE_PN0P_
+ _02221_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[407\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[408\]$_DFFE_PN0P_
+ _02222_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[408\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[409\]$_DFFE_PN0P_
+ _02223_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[409\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[40\]$_DFFE_PN0P_ _02224_
+ net153 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[40\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[410\]$_DFFE_PN0P_
+ _02225_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[410\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[411\]$_DFFE_PN0P_
+ _02226_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[411\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[412\]$_DFFE_PN0P_
+ _02227_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[412\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[413\]$_DFFE_PN0P_
+ _02228_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[413\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[414\]$_DFFE_PN0P_
+ _02229_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[414\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[415\]$_DFFE_PN0P_
+ _02230_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[415\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[416\]$_DFFE_PN0P_
+ _02231_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[416\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[417\]$_DFFE_PN0P_
+ _02232_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[417\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[418\]$_DFFE_PN0P_
+ _02233_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[418\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[419\]$_DFFE_PN0P_
+ _02234_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[419\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[41\]$_DFFE_PN0P_ _02235_
+ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[41\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[420\]$_DFFE_PN0P_
+ _02236_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[420\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[421\]$_DFFE_PN0P_
+ _02237_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[421\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[422\]$_DFFE_PN0P_
+ _02238_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[422\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[423\]$_DFFE_PN0P_
+ _02239_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[423\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[424\]$_DFFE_PN0P_
+ _02240_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[424\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[425\]$_DFFE_PN0P_
+ _02241_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[425\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[426\]$_DFFE_PN0P_
+ _02242_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[426\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[427\]$_DFFE_PN0P_
+ _02243_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[427\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[428\]$_DFFE_PN0P_
+ _02244_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[428\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[429\]$_DFFE_PN0P_
+ _02245_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[429\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[42\]$_DFFE_PN0P_ _02246_
+ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[42\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[430\]$_DFFE_PN0P_
+ _02247_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[430\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[431\]$_DFFE_PN0P_
+ _02248_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[431\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[432\]$_DFFE_PN0P_
+ _02249_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[432\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[433\]$_DFFE_PN0P_
+ _02250_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[433\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[434\]$_DFFE_PN0P_
+ _02251_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[434\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[435\]$_DFFE_PN0P_
+ _02252_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[435\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[436\]$_DFFE_PN0P_
+ _02253_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[436\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[437\]$_DFFE_PN0P_
+ _02254_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[437\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[438\]$_DFFE_PN0P_
+ _02255_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[438\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[439\]$_DFFE_PN0P_
+ _02256_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[439\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[43\]$_DFFE_PN0P_ _02257_
+ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[43\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[440\]$_DFFE_PN0P_
+ _02258_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[440\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[441\]$_DFFE_PN0P_
+ _02259_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[441\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[442\]$_DFFE_PN0P_
+ _02260_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[442\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[443\]$_DFFE_PN0P_
+ _02261_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[443\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[444\]$_DFFE_PN0P_
+ _02262_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[444\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[445\]$_DFFE_PN0P_
+ _02263_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[445\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[446\]$_DFFE_PN0P_
+ _02264_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[446\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[447\]$_DFFE_PN0P_
+ _02265_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[447\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[448\]$_DFFE_PN0P_
+ _02266_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[448\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[449\]$_DFFE_PN0P_
+ _02267_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[449\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[44\]$_DFFE_PN0P_ _02268_
+ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[44\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[450\]$_DFFE_PN0P_
+ _02269_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[450\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[451\]$_DFFE_PN0P_
+ _02270_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[451\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[452\]$_DFFE_PN0P_
+ _02271_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[452\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[453\]$_DFFE_PN0P_
+ _02272_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[453\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[454\]$_DFFE_PN0P_
+ _02273_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[454\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[455\]$_DFFE_PN0P_
+ _02274_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[455\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[456\]$_DFFE_PN0P_
+ _02275_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[456\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[457\]$_DFFE_PN0P_
+ _02276_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[457\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[458\]$_DFFE_PN0P_
+ _02277_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[458\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[459\]$_DFFE_PN0P_
+ _02278_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[459\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[45\]$_DFFE_PN0P_ _02279_
+ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[45\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[460\]$_DFFE_PN0P_
+ _02280_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[460\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[461\]$_DFFE_PN0P_
+ _02281_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[461\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[462\]$_DFFE_PN0P_
+ _02282_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[462\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[463\]$_DFFE_PN0P_
+ _02283_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[463\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[464\]$_DFFE_PN0P_
+ _02284_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[464\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[465\]$_DFFE_PN0P_
+ _02285_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[465\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[466\]$_DFFE_PN0P_
+ _02286_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[466\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[467\]$_DFFE_PN0P_
+ _02287_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[467\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[468\]$_DFFE_PN0P_
+ _02288_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[468\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[469\]$_DFFE_PN0P_
+ _02289_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[469\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[46\]$_DFFE_PN0P_ _02290_
+ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[46\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[470\]$_DFFE_PN0P_
+ _02291_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[470\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[471\]$_DFFE_PN0P_
+ _02292_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[471\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[472\]$_DFFE_PN0P_
+ _02293_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[472\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[473\]$_DFFE_PN0P_
+ _02294_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[473\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[474\]$_DFFE_PN0P_
+ _02295_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[474\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[475\]$_DFFE_PN0P_
+ _02296_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[475\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[476\]$_DFFE_PN0P_
+ _02297_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[476\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[477\]$_DFFE_PN0P_
+ _02298_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[477\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[478\]$_DFFE_PN0P_
+ _02299_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[478\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[479\]$_DFFE_PN0P_
+ _02300_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[479\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[47\]$_DFFE_PN0P_ _02301_
+ net2033 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[47\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[480\]$_DFFE_PN0P_
+ _02302_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[480\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[481\]$_DFFE_PN0P_
+ _02303_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[481\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[482\]$_DFFE_PN0P_
+ _02304_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[482\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[483\]$_DFFE_PN0P_
+ _02305_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[483\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[484\]$_DFFE_PN0P_
+ _02306_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[484\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[485\]$_DFFE_PN0P_
+ _02307_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[485\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[486\]$_DFFE_PN0P_
+ _02308_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[486\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[487\]$_DFFE_PN0P_
+ _02309_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[487\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[488\]$_DFFE_PN0P_
+ _02310_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[488\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[489\]$_DFFE_PN0P_
+ _02311_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[489\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[48\]$_DFFE_PN0P_ _02312_
+ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[48\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[490\]$_DFFE_PN0P_
+ _02313_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[490\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[491\]$_DFFE_PN0P_
+ _02314_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[491\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[492\]$_DFFE_PN0P_
+ _02315_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[492\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[493\]$_DFFE_PN0P_
+ _02316_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[493\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[494\]$_DFFE_PN0P_
+ _02317_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[494\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[495\]$_DFFE_PN0P_
+ _02318_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[495\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[496\]$_DFFE_PN0P_
+ _02319_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[496\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[497\]$_DFFE_PN0P_
+ _02320_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[497\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[498\]$_DFFE_PN0P_
+ _02321_ net2037 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[498\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[499\]$_DFFE_PN0P_
+ _02322_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[499\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[49\]$_DFFE_PN0P_ _02323_
+ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[49\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[500\]$_DFFE_PN0P_
+ _02324_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[500\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[501\]$_DFFE_PN0P_
+ _02325_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[501\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[502\]$_DFFE_PN0P_
+ _02326_ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[502\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[503\]$_DFFE_PN0P_
+ _02327_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[503\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[504\]$_DFFE_PN0P_
+ _02328_ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[504\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[505\]$_DFFE_PN0P_
+ _02329_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[505\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[506\]$_DFFE_PN0P_
+ _02330_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[506\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[507\]$_DFFE_PN0P_
+ _02331_ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[507\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[508\]$_DFFE_PN0P_
+ _02332_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[508\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[509\]$_DFFE_PN0P_
+ _02333_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[509\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[50\]$_DFFE_PN0P_ _02334_
+ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[50\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[510\]$_DFFE_PN0P_
+ _02335_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[510\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[511\]$_DFFE_PN0P_
+ _02336_ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[511\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[512\]$_DFFE_PN0P_
+ _02337_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[512\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[513\]$_DFFE_PN0P_
+ _02338_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[513\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[514\]$_DFFE_PN0P_
+ _02339_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[514\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[515\]$_DFFE_PN0P_
+ _02340_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[515\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[516\]$_DFFE_PN0P_
+ _02341_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[516\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[517\]$_DFFE_PN0P_
+ _02342_ net2034 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[517\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[518\]$_DFFE_PN0P_
+ _02343_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[518\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[519\]$_DFFE_PN0P_
+ _02344_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[519\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[51\]$_DFFE_PN0P_ _02345_
+ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[51\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[520\]$_DFFE_PN0P_
+ _02346_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[520\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[521\]$_DFFE_PN0P_
+ _02347_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[521\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[522\]$_DFFE_PN0P_
+ _02348_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[522\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[523\]$_DFFE_PN0P_
+ _02349_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[523\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[524\]$_DFFE_PN0P_
+ _02350_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[524\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[525\]$_DFFE_PN0P_
+ _02351_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[525\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[526\]$_DFFE_PN0P_
+ _02352_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[526\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[527\]$_DFFE_PN0P_
+ _02353_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[527\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[528\]$_DFFE_PN0P_
+ _02354_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[528\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[529\]$_DFFE_PN0P_
+ _02355_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[529\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[52\]$_DFFE_PN0P_ _02356_
+ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[52\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[530\]$_DFFE_PN0P_
+ _02357_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[530\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[531\]$_DFFE_PN0P_
+ _02358_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[531\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[532\]$_DFFE_PN0P_
+ _02359_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[532\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[533\]$_DFFE_PN0P_
+ _02360_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[533\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[534\]$_DFFE_PN0P_
+ _02361_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[534\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[535\]$_DFFE_PN0P_
+ _02362_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[535\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[536\]$_DFFE_PN0P_
+ _02363_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[536\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[537\]$_DFFE_PN0P_
+ _02364_ net153 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[537\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[538\]$_DFFE_PN0P_
+ _02365_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[538\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[539\]$_DFFE_PN0P_
+ _02366_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[539\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[53\]$_DFFE_PN0P_ _02367_
+ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[53\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[540\]$_DFFE_PN0P_
+ _02368_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[540\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[541\]$_DFFE_PN0P_
+ _02369_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[541\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[542\]$_DFFE_PN0P_
+ _02370_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[542\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[543\]$_DFFE_PN0P_
+ _02371_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[543\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[544\]$_DFFE_PN0P_
+ _02372_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[544\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[545\]$_DFFE_PN0P_
+ _02373_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[545\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[546\]$_DFFE_PN0P_
+ _02374_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[546\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[547\]$_DFFE_PN0P_
+ _02375_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[547\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[548\]$_DFFE_PN0P_
+ _02376_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[548\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[549\]$_DFFE_PN0P_
+ _02377_ net2034 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[549\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[54\]$_DFFE_PN0P_ _02378_
+ net2034 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[54\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[550\]$_DFFE_PN0P_
+ _02379_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[550\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[551\]$_DFFE_PN0P_
+ _02380_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[551\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[552\]$_DFFE_PN0P_
+ _02381_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[552\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[553\]$_DFFE_PN0P_
+ _02382_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[553\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[554\]$_DFFE_PN0P_
+ _02383_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[554\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[555\]$_DFFE_PN0P_
+ _02384_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[555\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[556\]$_DFFE_PN0P_
+ _02385_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[556\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[557\]$_DFFE_PN0P_
+ _02386_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[557\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[558\]$_DFFE_PN0P_
+ _02387_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[558\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[559\]$_DFFE_PN0P_
+ _02388_ net2036 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[559\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[55\]$_DFFE_PN0P_ _02389_
+ net2036 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[55\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[560\]$_DFFE_PN0P_
+ _02390_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[560\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[561\]$_DFFE_PN0P_
+ _02391_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[561\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[562\]$_DFFE_PN0P_
+ _02392_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[562\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[563\]$_DFFE_PN0P_
+ _02393_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[563\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[564\]$_DFFE_PN0P_
+ _02394_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[564\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[565\]$_DFFE_PN0P_
+ _02395_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[565\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[566\]$_DFFE_PN0P_
+ _02396_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[566\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[567\]$_DFFE_PN0P_
+ _02397_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[567\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[568\]$_DFFE_PN0P_
+ _02398_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[568\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[569\]$_DFFE_PN0P_
+ _02399_ net153 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[569\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[56\]$_DFFE_PN0P_ _02400_
+ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[56\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[570\]$_DFFE_PN0P_
+ _02401_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[570\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[571\]$_DFFE_PN0P_
+ _02402_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[571\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[572\]$_DFFE_PN0P_
+ _02403_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[572\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[573\]$_DFFE_PN0P_
+ _02404_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[573\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[574\]$_DFFE_PN0P_
+ _02405_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[574\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[575\]$_DFFE_PN0P_
+ _02406_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[575\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[576\]$_DFFE_PN0P_
+ _02407_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[576\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[577\]$_DFFE_PN0P_
+ _02408_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[577\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[578\]$_DFFE_PN0P_
+ _02409_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[578\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[579\]$_DFFE_PN0P_
+ _02410_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[579\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[57\]$_DFFE_PN0P_ _02411_
+ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[57\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[580\]$_DFFE_PN0P_
+ _02412_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[580\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[581\]$_DFFE_PN0P_
+ _02413_ net2034 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[581\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[582\]$_DFFE_PN0P_
+ _02414_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[582\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[583\]$_DFFE_PN0P_
+ _02415_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[583\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[584\]$_DFFE_PN0P_
+ _02416_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[584\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[585\]$_DFFE_PN0P_
+ _02417_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[585\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[586\]$_DFFE_PN0P_
+ _02418_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[586\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[587\]$_DFFE_PN0P_
+ _02419_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[587\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[588\]$_DFFE_PN0P_
+ _02420_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[588\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[589\]$_DFFE_PN0P_
+ _02421_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[589\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[58\]$_DFFE_PN0P_ _02422_
+ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[58\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[590\]$_DFFE_PN0P_
+ _02423_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[590\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[591\]$_DFFE_PN0P_
+ _02424_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[591\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[592\]$_DFFE_PN0P_
+ _02425_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[592\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[593\]$_DFFE_PN0P_
+ _02426_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[593\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[594\]$_DFFE_PN0P_
+ _02427_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[594\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[595\]$_DFFE_PN0P_
+ _02428_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[595\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[596\]$_DFFE_PN0P_
+ _02429_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[596\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[597\]$_DFFE_PN0P_
+ _02430_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[597\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[598\]$_DFFE_PN0P_
+ _02431_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[598\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[599\]$_DFFE_PN0P_
+ _02432_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[599\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[59\]$_DFFE_PN0P_ _02433_
+ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[59\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[600\]$_DFFE_PN0P_
+ _02434_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[600\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[601\]$_DFFE_PN0P_
+ _02435_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[601\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[602\]$_DFFE_PN0P_
+ _02436_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[602\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[603\]$_DFFE_PN0P_
+ _02437_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[603\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[604\]$_DFFE_PN0P_
+ _02438_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[604\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[605\]$_DFFE_PN0P_
+ _02439_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[605\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[606\]$_DFFE_PN0P_
+ _02440_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[606\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[607\]$_DFFE_PN0P_
+ _02441_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[607\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[608\]$_DFFE_PN0P_
+ _02442_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[608\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[609\]$_DFFE_PN0P_
+ _02443_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[609\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[60\]$_DFFE_PN0P_ _02444_
+ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[60\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[610\]$_DFFE_PN0P_
+ _02445_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[610\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[611\]$_DFFE_PN0P_
+ _02446_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[611\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[612\]$_DFFE_PN0P_
+ _02447_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[612\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[613\]$_DFFE_PN0P_
+ _02448_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[613\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[614\]$_DFFE_PN0P_
+ _02449_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[614\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[615\]$_DFFE_PN0P_
+ _02450_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[615\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[616\]$_DFFE_PN0P_
+ _02451_ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[616\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[617\]$_DFFE_PN0P_
+ _02452_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[617\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[618\]$_DFFE_PN0P_
+ _02453_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[618\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[619\]$_DFFE_PN0P_
+ _02454_ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[619\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[61\]$_DFFE_PN0P_ _02455_
+ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[61\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[620\]$_DFFE_PN0P_
+ _02456_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[620\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[621\]$_DFFE_PN0P_
+ _02457_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[621\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[622\]$_DFFE_PN0P_
+ _02458_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[622\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[623\]$_DFFE_PN0P_
+ _02459_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[623\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[624\]$_DFFE_PN0P_
+ _02460_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[624\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[625\]$_DFFE_PN0P_
+ _02461_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[625\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[626\]$_DFFE_PN0P_
+ _02462_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[626\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[627\]$_DFFE_PN0P_
+ _02463_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[627\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[628\]$_DFFE_PN0P_
+ _02464_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[628\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[629\]$_DFFE_PN0P_
+ _02465_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[629\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[62\]$_DFFE_PN0P_ _02466_
+ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[62\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[630\]$_DFFE_PN0P_
+ _02467_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[630\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[631\]$_DFFE_PN0P_
+ _02468_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[631\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[632\]$_DFFE_PN0P_
+ _02469_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[632\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[633\]$_DFFE_PN0P_
+ _02470_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[633\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[634\]$_DFFE_PN0P_
+ _02471_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[634\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[635\]$_DFFE_PN0P_
+ _02472_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[635\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[636\]$_DFFE_PN0P_
+ _02473_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[636\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[637\]$_DFFE_PN0P_
+ _02474_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[637\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[638\]$_DFFE_PN0P_
+ _02475_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[638\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[639\]$_DFFE_PN0P_
+ _02476_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[639\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[63\]$_DFFE_PN0P_ _02477_
+ net2034 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[63\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[640\]$_DFFE_PN0P_
+ _02478_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[640\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[641\]$_DFFE_PN0P_
+ _02479_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[641\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[642\]$_DFFE_PN0P_
+ _02480_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[642\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[643\]$_DFFE_PN0P_
+ _02481_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[643\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[644\]$_DFFE_PN0P_
+ _02482_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[644\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[645\]$_DFFE_PN0P_
+ _02483_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[645\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[646\]$_DFFE_PN0P_
+ _02484_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[646\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[647\]$_DFFE_PN0P_
+ _02485_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[647\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[648\]$_DFFE_PN0P_
+ _02486_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[648\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[649\]$_DFFE_PN0P_
+ _02487_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[649\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[64\]$_DFFE_PN0P_ _02488_
+ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[64\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[650\]$_DFFE_PN0P_
+ _02489_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[650\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[651\]$_DFFE_PN0P_
+ _02490_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[651\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[652\]$_DFFE_PN0P_
+ _02491_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[652\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[653\]$_DFFE_PN0P_
+ _02492_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[653\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[654\]$_DFFE_PN0P_
+ _02493_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[654\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[655\]$_DFFE_PN0P_
+ _02494_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[655\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[656\]$_DFFE_PN0P_
+ _02495_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[656\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[657\]$_DFFE_PN0P_
+ _02496_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[657\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[658\]$_DFFE_PN0P_
+ _02497_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[658\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[659\]$_DFFE_PN0P_
+ _02498_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[659\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[65\]$_DFFE_PN0P_ _02499_
+ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[65\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[660\]$_DFFE_PN0P_
+ _02500_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[660\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[661\]$_DFFE_PN0P_
+ _02501_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[661\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[662\]$_DFFE_PN0P_
+ _02502_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[662\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[663\]$_DFFE_PN0P_
+ _02503_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[663\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[664\]$_DFFE_PN0P_
+ _02504_ net2033 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[664\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[665\]$_DFFE_PN0P_
+ _02505_ net153 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[665\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[666\]$_DFFE_PN0P_
+ _02506_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[666\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[667\]$_DFFE_PN0P_
+ _02507_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[667\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[668\]$_DFFE_PN0P_
+ _02508_ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[668\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[669\]$_DFFE_PN0P_
+ _02509_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[669\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[66\]$_DFFE_PN0P_ _02510_
+ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[66\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[670\]$_DFFE_PN0P_
+ _02511_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[670\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[671\]$_DFFE_PN0P_
+ _02512_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[671\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[672\]$_DFFE_PN0P_
+ _02513_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[672\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[673\]$_DFFE_PN0P_
+ _02514_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[673\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[674\]$_DFFE_PN0P_
+ _02515_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[674\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[675\]$_DFFE_PN0P_
+ _02516_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[675\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[676\]$_DFFE_PN0P_
+ _02517_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[676\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[677\]$_DFFE_PN0P_
+ _02518_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[677\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[678\]$_DFFE_PN0P_
+ _02519_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[678\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[679\]$_DFFE_PN0P_
+ _02520_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[679\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[67\]$_DFFE_PN0P_ _02521_
+ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[67\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[680\]$_DFFE_PN0P_
+ _02522_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[680\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[681\]$_DFFE_PN0P_
+ _02523_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[681\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[682\]$_DFFE_PN0P_
+ _02524_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[682\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[683\]$_DFFE_PN0P_
+ _02525_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[683\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[684\]$_DFFE_PN0P_
+ _02526_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[684\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[685\]$_DFFE_PN0P_
+ _02527_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[685\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[686\]$_DFFE_PN0P_
+ _02528_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[686\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[687\]$_DFFE_PN0P_
+ _02529_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[687\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[688\]$_DFFE_PN0P_
+ _02530_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[688\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[689\]$_DFFE_PN0P_
+ _02531_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[689\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[68\]$_DFFE_PN0P_ _02532_
+ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[68\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[690\]$_DFFE_PN0P_
+ _02533_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[690\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[691\]$_DFFE_PN0P_
+ _02534_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[691\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[692\]$_DFFE_PN0P_
+ _02535_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[692\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[693\]$_DFFE_PN0P_
+ _02536_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[693\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[694\]$_DFFE_PN0P_
+ _02537_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[694\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[695\]$_DFFE_PN0P_
+ _02538_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[695\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[696\]$_DFFE_PN0P_
+ _02539_ net2033 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[696\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[697\]$_DFFE_PN0P_
+ _02540_ net153 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[697\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[698\]$_DFFE_PN0P_
+ _02541_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[698\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[699\]$_DFFE_PN0P_
+ _02542_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[699\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[69\]$_DFFE_PN0P_ _02543_
+ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[69\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[700\]$_DFFE_PN0P_
+ _02544_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[700\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[701\]$_DFFE_PN0P_
+ _02545_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[701\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[702\]$_DFFE_PN0P_
+ _02546_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[702\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[703\]$_DFFE_PN0P_
+ _02547_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[703\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[704\]$_DFFE_PN0P_
+ _02548_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[704\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[705\]$_DFFE_PN0P_
+ _02549_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[705\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[706\]$_DFFE_PN0P_
+ _02550_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[706\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[707\]$_DFFE_PN0P_
+ _02551_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[707\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[708\]$_DFFE_PN0P_
+ _02552_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[708\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[709\]$_DFFE_PN0P_
+ _02553_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[709\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[70\]$_DFFE_PN0P_ _02554_
+ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[70\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[710\]$_DFFE_PN0P_
+ _02555_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[710\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[711\]$_DFFE_PN0P_
+ _02556_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[711\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[712\]$_DFFE_PN0P_
+ _02557_ net153 clknet_leaf_5_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[712\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[713\]$_DFFE_PN0P_
+ _02558_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[713\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[714\]$_DFFE_PN0P_
+ _02559_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[714\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[715\]$_DFFE_PN0P_
+ _02560_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[715\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[716\]$_DFFE_PN0P_
+ _02561_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[716\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[717\]$_DFFE_PN0P_
+ _02562_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[717\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[718\]$_DFFE_PN0P_
+ _02563_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[718\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[719\]$_DFFE_PN0P_
+ _02564_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[719\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[71\]$_DFFE_PN0P_ _02565_
+ net153 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[71\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[720\]$_DFFE_PN0P_
+ _02566_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[720\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[721\]$_DFFE_PN0P_
+ _02567_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[721\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[722\]$_DFFE_PN0P_
+ _02568_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[722\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[723\]$_DFFE_PN0P_
+ _02569_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[723\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[724\]$_DFFE_PN0P_
+ _02570_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[724\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[725\]$_DFFE_PN0P_
+ _02571_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[725\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[726\]$_DFFE_PN0P_
+ _02572_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[726\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[727\]$_DFFE_PN0P_
+ _02573_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[727\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[728\]$_DFFE_PN0P_
+ _02574_ net2033 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[728\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[729\]$_DFFE_PN0P_
+ _02575_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[729\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[72\]$_DFFE_PN0P_ _02576_
+ net153 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[72\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[730\]$_DFFE_PN0P_
+ _02577_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[730\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[731\]$_DFFE_PN0P_
+ _02578_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[731\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[732\]$_DFFE_PN0P_
+ _02579_ net2037 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[732\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[733\]$_DFFE_PN0P_
+ _02580_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[733\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[734\]$_DFFE_PN0P_
+ _02581_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[734\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[735\]$_DFFE_PN0P_
+ _02582_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[735\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[736\]$_DFFE_PN0P_
+ _02583_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[736\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[737\]$_DFFE_PN0P_
+ _02584_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[737\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[738\]$_DFFE_PN0P_
+ _02585_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[738\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[739\]$_DFFE_PN0P_
+ _02586_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[739\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[73\]$_DFFE_PN0P_ _02587_
+ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[73\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[740\]$_DFFE_PN0P_
+ _02588_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[740\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[741\]$_DFFE_PN0P_
+ _02589_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[741\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[742\]$_DFFE_PN0P_
+ _02590_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[742\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[743\]$_DFFE_PN0P_
+ _02591_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[743\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[744\]$_DFFE_PN0P_
+ _02592_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[744\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[745\]$_DFFE_PN0P_
+ _02593_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[745\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[746\]$_DFFE_PN0P_
+ _02594_ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[746\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[747\]$_DFFE_PN0P_
+ _02595_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[747\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[748\]$_DFFE_PN0P_
+ _02596_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[748\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[749\]$_DFFE_PN0P_
+ _02597_ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[749\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[74\]$_DFFE_PN0P_ _02598_
+ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[74\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[750\]$_DFFE_PN0P_
+ _02599_ net153 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[750\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[751\]$_DFFE_PN0P_
+ _02600_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[751\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[752\]$_DFFE_PN0P_
+ _02601_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[752\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[753\]$_DFFE_PN0P_
+ _02602_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[753\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[754\]$_DFFE_PN0P_
+ _02603_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[754\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[755\]$_DFFE_PN0P_
+ _02604_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[755\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[756\]$_DFFE_PN0P_
+ _02605_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[756\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[757\]$_DFFE_PN0P_
+ _02606_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[757\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[758\]$_DFFE_PN0P_
+ _02607_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[758\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[759\]$_DFFE_PN0P_
+ _02608_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[759\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[75\]$_DFFE_PN0P_ _02609_
+ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[75\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[760\]$_DFFE_PN0P_
+ _02610_ net2033 clknet_leaf_23_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[760\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[761\]$_DFFE_PN0P_
+ _02611_ net153 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[761\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[762\]$_DFFE_PN0P_
+ _02612_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[762\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[763\]$_DFFE_PN0P_
+ _02613_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[763\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[764\]$_DFFE_PN0P_
+ _02614_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[764\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[765\]$_DFFE_PN0P_
+ _02615_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[765\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[766\]$_DFFE_PN0P_
+ _02616_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[766\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[767\]$_DFFE_PN0P_
+ _02617_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[767\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[768\]$_DFFE_PN0P_
+ _02618_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[768\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[769\]$_DFFE_PN0P_
+ _02619_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[769\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[76\]$_DFFE_PN0P_ _02620_
+ net2033 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[76\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[770\]$_DFFE_PN0P_
+ _02621_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[770\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[771\]$_DFFE_PN0P_
+ _02622_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[771\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[772\]$_DFFE_PN0P_
+ _02623_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[772\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[773\]$_DFFE_PN0P_
+ _02624_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[773\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[774\]$_DFFE_PN0P_
+ _02625_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[774\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[775\]$_DFFE_PN0P_
+ _02626_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[775\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[776\]$_DFFE_PN0P_
+ _02627_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[776\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[777\]$_DFFE_PN0P_
+ _02628_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[777\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[778\]$_DFFE_PN0P_
+ _02629_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[778\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[779\]$_DFFE_PN0P_
+ _02630_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[779\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[77\]$_DFFE_PN0P_ _02631_
+ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[77\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[780\]$_DFFE_PN0P_
+ _02632_ net153 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[780\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[781\]$_DFFE_PN0P_
+ _02633_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[781\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[782\]$_DFFE_PN0P_
+ _02634_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[782\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[783\]$_DFFE_PN0P_
+ _02635_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[783\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[784\]$_DFFE_PN0P_
+ _02636_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[784\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[785\]$_DFFE_PN0P_
+ _02637_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[785\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[786\]$_DFFE_PN0P_
+ _02638_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[786\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[787\]$_DFFE_PN0P_
+ _02639_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[787\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[788\]$_DFFE_PN0P_
+ _02640_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[788\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[789\]$_DFFE_PN0P_
+ _02641_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[789\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[78\]$_DFFE_PN0P_ _02642_
+ net2033 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[78\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[790\]$_DFFE_PN0P_
+ _02643_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[790\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[791\]$_DFFE_PN0P_
+ _02644_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[791\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[792\]$_DFFE_PN0P_
+ _02645_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[792\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[793\]$_DFFE_PN0P_
+ _02646_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[793\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[794\]$_DFFE_PN0P_
+ _02647_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[794\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[795\]$_DFFE_PN0P_
+ _02648_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[795\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[796\]$_DFFE_PN0P_
+ _02649_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[796\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[797\]$_DFFE_PN0P_
+ _02650_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[797\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[798\]$_DFFE_PN0P_
+ _02651_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[798\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[799\]$_DFFE_PN0P_
+ _02652_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[799\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[79\]$_DFFE_PN0P_ _02653_
+ net153 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[79\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[800\]$_DFFE_PN0P_
+ _02654_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[800\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[801\]$_DFFE_PN0P_
+ _02655_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[801\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[802\]$_DFFE_PN0P_
+ _02656_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[802\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[803\]$_DFFE_PN0P_
+ _02657_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[803\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[804\]$_DFFE_PN0P_
+ _02658_ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[804\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[805\]$_DFFE_PN0P_
+ _02659_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[805\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[806\]$_DFFE_PN0P_
+ _02660_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[806\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[807\]$_DFFE_PN0P_
+ _02661_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[807\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[808\]$_DFFE_PN0P_
+ _02662_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[808\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[809\]$_DFFE_PN0P_
+ _02663_ net2033 clknet_leaf_25_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[809\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[80\]$_DFFE_PN0P_ _02664_
+ net153 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[80\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[810\]$_DFFE_PN0P_
+ _02665_ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[810\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[811\]$_DFFE_PN0P_
+ _02666_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[811\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[812\]$_DFFE_PN0P_
+ _02667_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[812\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[813\]$_DFFE_PN0P_
+ _02668_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[813\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[814\]$_DFFE_PN0P_
+ _02669_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[814\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[815\]$_DFFE_PN0P_
+ _02670_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[815\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[816\]$_DFFE_PN0P_
+ _02671_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[816\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[817\]$_DFFE_PN0P_
+ _02672_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[817\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[818\]$_DFFE_PN0P_
+ _02673_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[818\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[819\]$_DFFE_PN0P_
+ _02674_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[819\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[81\]$_DFFE_PN0P_ _02675_
+ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[81\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[820\]$_DFFE_PN0P_
+ _02676_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[820\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[821\]$_DFFE_PN0P_
+ _02677_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[821\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[822\]$_DFFE_PN0P_
+ _02678_ net153 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[822\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[823\]$_DFFE_PN0P_
+ _02679_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[823\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[824\]$_DFFE_PN0P_
+ _02680_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[824\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[825\]$_DFFE_PN0P_
+ _02681_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[825\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[826\]$_DFFE_PN0P_
+ _02682_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[826\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[827\]$_DFFE_PN0P_
+ _02683_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[827\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[828\]$_DFFE_PN0P_
+ _02684_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[828\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[829\]$_DFFE_PN0P_
+ _02685_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[829\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[82\]$_DFFE_PN0P_ _02686_
+ net2037 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[82\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[830\]$_DFFE_PN0P_
+ _02687_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[830\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[831\]$_DFFE_PN0P_
+ _02688_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[831\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[832\]$_DFFE_PN0P_
+ _02689_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[832\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[833\]$_DFFE_PN0P_
+ _02690_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[833\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[834\]$_DFFE_PN0P_
+ _02691_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[834\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[835\]$_DFFE_PN0P_
+ _02692_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[835\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[836\]$_DFFE_PN0P_
+ _02693_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[836\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[837\]$_DFFE_PN0P_
+ _02694_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[837\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[838\]$_DFFE_PN0P_
+ _02695_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[838\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[839\]$_DFFE_PN0P_
+ _02696_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[839\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[83\]$_DFFE_PN0P_ _02697_
+ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[83\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[840\]$_DFFE_PN0P_
+ _02698_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[840\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[841\]$_DFFE_PN0P_
+ _02699_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[841\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[842\]$_DFFE_PN0P_
+ _02700_ net2034 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[842\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[843\]$_DFFE_PN0P_
+ _02701_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[843\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[844\]$_DFFE_PN0P_
+ _02702_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[844\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[845\]$_DFFE_PN0P_
+ _02703_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[845\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[846\]$_DFFE_PN0P_
+ _02704_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[846\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[847\]$_DFFE_PN0P_
+ _02705_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[847\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[848\]$_DFFE_PN0P_
+ _02706_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[848\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[849\]$_DFFE_PN0P_
+ _02707_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[849\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[84\]$_DFFE_PN0P_ _02708_
+ net2037 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[84\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[850\]$_DFFE_PN0P_
+ _02709_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[850\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[851\]$_DFFE_PN0P_
+ _02710_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[851\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[852\]$_DFFE_PN0P_
+ _02711_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[852\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[853\]$_DFFE_PN0P_
+ _02712_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[853\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[854\]$_DFFE_PN0P_
+ _02713_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[854\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[855\]$_DFFE_PN0P_
+ _02714_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[855\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[856\]$_DFFE_PN0P_
+ _02715_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[856\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[857\]$_DFFE_PN0P_
+ _02716_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[857\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[858\]$_DFFE_PN0P_
+ _02717_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[858\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[859\]$_DFFE_PN0P_
+ _02718_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[859\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[85\]$_DFFE_PN0P_ _02719_
+ net2033 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[85\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[860\]$_DFFE_PN0P_
+ _02720_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[860\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[861\]$_DFFE_PN0P_
+ _02721_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[861\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[862\]$_DFFE_PN0P_
+ _02722_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[862\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[863\]$_DFFE_PN0P_
+ _02723_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[863\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[864\]$_DFFE_PN0P_
+ _02724_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[864\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[865\]$_DFFE_PN0P_
+ _02725_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[865\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[866\]$_DFFE_PN0P_
+ _02726_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[866\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[867\]$_DFFE_PN0P_
+ _02727_ net2034 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[867\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[868\]$_DFFE_PN0P_
+ _02728_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[868\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[869\]$_DFFE_PN0P_
+ _02729_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[869\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[86\]$_DFFE_PN0P_ _02730_
+ net2034 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[86\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[870\]$_DFFE_PN0P_
+ _02731_ net2033 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[870\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[871\]$_DFFE_PN0P_
+ _02732_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[871\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[872\]$_DFFE_PN0P_
+ _02733_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[872\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[873\]$_DFFE_PN0P_
+ _02734_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[873\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[874\]$_DFFE_PN0P_
+ _02735_ net2034 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[874\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[875\]$_DFFE_PN0P_
+ _02736_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[875\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[876\]$_DFFE_PN0P_
+ _02737_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[876\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[877\]$_DFFE_PN0P_
+ _02738_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[877\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[878\]$_DFFE_PN0P_
+ _02739_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[878\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[879\]$_DFFE_PN0P_
+ _02740_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[879\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[87\]$_DFFE_PN0P_ _02741_
+ net2036 clknet_leaf_18_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[87\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[880\]$_DFFE_PN0P_
+ _02742_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[880\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[881\]$_DFFE_PN0P_
+ _02743_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[881\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[882\]$_DFFE_PN0P_
+ _02744_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[882\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[883\]$_DFFE_PN0P_
+ _02745_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[883\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[884\]$_DFFE_PN0P_
+ _02746_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[884\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[885\]$_DFFE_PN0P_
+ _02747_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[885\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[886\]$_DFFE_PN0P_
+ _02748_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[886\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[887\]$_DFFE_PN0P_
+ _02749_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[887\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[888\]$_DFFE_PN0P_
+ _02750_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[888\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[889\]$_DFFE_PN0P_
+ _02751_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[889\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[88\]$_DFFE_PN0P_ _02752_
+ net2034 clknet_leaf_26_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[88\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[890\]$_DFFE_PN0P_
+ _02753_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[890\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[891\]$_DFFE_PN0P_
+ _02754_ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[891\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[892\]$_DFFE_PN0P_
+ _02755_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[892\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[893\]$_DFFE_PN0P_
+ _02756_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[893\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[894\]$_DFFE_PN0P_
+ _02757_ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[894\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[895\]$_DFFE_PN0P_
+ _02758_ net2034 clknet_leaf_1_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[895\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[896\]$_DFFE_PN0P_
+ _02759_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[896\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[897\]$_DFFE_PN0P_
+ _02760_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[897\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[898\]$_DFFE_PN0P_
+ _02761_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[898\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[899\]$_DFFE_PN0P_
+ _02762_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[899\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[89\]$_DFFE_PN0P_ _02763_
+ net2037 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[89\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[900\]$_DFFE_PN0P_
+ _02764_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[900\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[901\]$_DFFE_PN0P_
+ _02765_ net2034 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[901\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[902\]$_DFFE_PN0P_
+ _02766_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[902\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[903\]$_DFFE_PN0P_
+ _02767_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[903\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[904\]$_DFFE_PN0P_
+ _02768_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[904\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[905\]$_DFFE_PN0P_
+ _02769_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[905\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[906\]$_DFFE_PN0P_
+ _02770_ net2034 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[906\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[907\]$_DFFE_PN0P_
+ _02771_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[907\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[908\]$_DFFE_PN0P_
+ _02772_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[908\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[909\]$_DFFE_PN0P_
+ _02773_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[909\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[90\]$_DFFE_PN0P_ _02774_
+ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[90\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[910\]$_DFFE_PN0P_
+ _02775_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[910\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[911\]$_DFFE_PN0P_
+ _02776_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[911\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[912\]$_DFFE_PN0P_
+ _02777_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[912\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[913\]$_DFFE_PN0P_
+ _02778_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[913\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[914\]$_DFFE_PN0P_
+ _02779_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[914\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[915\]$_DFFE_PN0P_
+ _02780_ net2037 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[915\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[916\]$_DFFE_PN0P_
+ _02781_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[916\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[917\]$_DFFE_PN0P_
+ _02782_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[917\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[918\]$_DFFE_PN0P_
+ _02783_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[918\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[919\]$_DFFE_PN0P_
+ _02784_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[919\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[91\]$_DFFE_PN0P_ _02785_
+ net2036 clknet_leaf_14_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[91\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[920\]$_DFFE_PN0P_
+ _02786_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[920\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[921\]$_DFFE_PN0P_
+ _02787_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[921\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[922\]$_DFFE_PN0P_
+ _02788_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[922\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[923\]$_DFFE_PN0P_
+ _02789_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[923\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[924\]$_DFFE_PN0P_
+ _02790_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[924\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[925\]$_DFFE_PN0P_
+ _02791_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[925\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[926\]$_DFFE_PN0P_
+ _02792_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[926\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[927\]$_DFFE_PN0P_
+ _02793_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[927\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[928\]$_DFFE_PN0P_
+ _02794_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[928\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[929\]$_DFFE_PN0P_
+ _02795_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[929\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[92\]$_DFFE_PN0P_ _02796_
+ net153 clknet_leaf_6_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[92\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[930\]$_DFFE_PN0P_
+ _02797_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[930\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[931\]$_DFFE_PN0P_
+ _02798_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[931\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[932\]$_DFFE_PN0P_
+ _02799_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[932\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[933\]$_DFFE_PN0P_
+ _02800_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[933\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[934\]$_DFFE_PN0P_
+ _02801_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[934\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[935\]$_DFFE_PN0P_
+ _02802_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[935\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[936\]$_DFFE_PN0P_
+ _02803_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[936\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[937\]$_DFFE_PN0P_
+ _02804_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[937\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[938\]$_DFFE_PN0P_
+ _02805_ net2034 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[938\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[939\]$_DFFE_PN0P_
+ _02806_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[939\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[93\]$_DFFE_PN0P_ _02807_
+ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[93\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[940\]$_DFFE_PN0P_
+ _02808_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[940\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[941\]$_DFFE_PN0P_
+ _02809_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[941\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[942\]$_DFFE_PN0P_
+ _02810_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[942\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[943\]$_DFFE_PN0P_
+ _02811_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[943\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[944\]$_DFFE_PN0P_
+ _02812_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[944\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[945\]$_DFFE_PN0P_
+ _02813_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[945\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[946\]$_DFFE_PN0P_
+ _02814_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[946\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[947\]$_DFFE_PN0P_
+ _02815_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[947\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[948\]$_DFFE_PN0P_
+ _02816_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[948\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[949\]$_DFFE_PN0P_
+ _02817_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[949\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[94\]$_DFFE_PN0P_ _02818_
+ net2036 clknet_leaf_11_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[94\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[950\]$_DFFE_PN0P_
+ _02819_ net153 clknet_leaf_17_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[950\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[951\]$_DFFE_PN0P_
+ _02820_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[951\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[952\]$_DFFE_PN0P_
+ _02821_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[952\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[953\]$_DFFE_PN0P_
+ _02822_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[953\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[954\]$_DFFE_PN0P_
+ _02823_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[954\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[955\]$_DFFE_PN0P_
+ _02824_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[955\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[956\]$_DFFE_PN0P_
+ _02825_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[956\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[957\]$_DFFE_PN0P_
+ _02826_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[957\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[958\]$_DFFE_PN0P_
+ _02827_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[958\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[959\]$_DFFE_PN0P_
+ _02828_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[959\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[95\]$_DFFE_PN0P_ _02829_
+ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[95\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[960\]$_DFFE_PN0P_
+ _02830_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[960\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[961\]$_DFFE_PN0P_
+ _02831_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[961\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[962\]$_DFFE_PN0P_
+ _02832_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[962\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[963\]$_DFFE_PN0P_
+ _02833_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[963\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[964\]$_DFFE_PN0P_
+ _02834_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[964\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[965\]$_DFFE_PN0P_
+ _02835_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[965\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[966\]$_DFFE_PN0P_
+ _02836_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[966\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[967\]$_DFFE_PN0P_
+ _02837_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[967\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[968\]$_DFFE_PN0P_
+ _02838_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[968\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[969\]$_DFFE_PN0P_
+ _02839_ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[969\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[96\]$_DFFE_PN0P_ _02840_
+ net2033 clknet_leaf_33_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[96\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[970\]$_DFFE_PN0P_
+ _02841_ net2034 clknet_leaf_27_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[970\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[971\]$_DFFE_PN0P_
+ _02842_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[971\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[972\]$_DFFE_PN0P_
+ _02843_ net153 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[972\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[973\]$_DFFE_PN0P_
+ _02844_ net2036 clknet_leaf_20_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[973\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[974\]$_DFFE_PN0P_
+ _02845_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[974\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[975\]$_DFFE_PN0P_
+ _02846_ net153 clknet_leaf_21_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[975\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[976\]$_DFFE_PN0P_
+ _02847_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[976\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[977\]$_DFFE_PN0P_
+ _02848_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[977\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[978\]$_DFFE_PN0P_
+ _02849_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[978\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[979\]$_DFFE_PN0P_
+ _02850_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[979\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[97\]$_DFFE_PN0P_ _02851_
+ net2033 clknet_leaf_30_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[97\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[980\]$_DFFE_PN0P_
+ _02852_ net2037 clknet_leaf_8_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[980\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[981\]$_DFFE_PN0P_
+ _02853_ net153 clknet_leaf_22_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[981\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[982\]$_DFFE_PN0P_
+ _02854_ net153 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[982\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[983\]$_DFFE_PN0P_
+ _02855_ net2036 clknet_leaf_19_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[983\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[984\]$_DFFE_PN0P_
+ _02856_ net153 clknet_leaf_24_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[984\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[985\]$_DFFE_PN0P_
+ _02857_ net153 clknet_leaf_15_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[985\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[986\]$_DFFE_PN0P_
+ _02858_ net2036 clknet_leaf_9_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[986\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[987\]$_DFFE_PN0P_
+ _02859_ net2036 clknet_leaf_13_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[987\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[988\]$_DFFE_PN0P_
+ _02860_ net153 clknet_leaf_7_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[988\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[989\]$_DFFE_PN0P_
+ _02861_ net2036 clknet_leaf_10_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[989\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[98\]$_DFFE_PN0P_ _02862_
+ net2033 clknet_leaf_28_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[98\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[990\]$_DFFE_PN0P_
+ _02863_ net2036 clknet_leaf_12_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[990\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[991\]$_DFFE_PN0P_
+ _02864_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[991\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[992\]$_DFFE_PN0P_
+ _02865_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[992\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[993\]$_DFFE_PN0P_
+ _02866_ net2033 clknet_leaf_32_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[993\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[994\]$_DFFE_PN0P_
+ _02867_ net2033 clknet_leaf_31_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[994\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[995\]$_DFFE_PN0P_
+ _02868_ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[995\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[996\]$_DFFE_PN0P_
+ _02869_ net2033 clknet_leaf_29_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[996\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[997\]$_DFFE_PN0P_
+ _02870_ net2034 clknet_leaf_4_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[997\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[998\]$_DFFE_PN0P_
+ _02871_ net2033 clknet_leaf_0_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[998\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[999\]$_DFFE_PN0P_
+ _02872_ net153 clknet_leaf_3_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[999\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xgen_regfile_ff.register_file_i.rf_reg\[99\]$_DFFE_PN0P_ _02873_
+ net2034 clknet_leaf_16_clk_i_regs gen_regfile_ff.register_file_i.rf_reg\[99\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.branch_set$_DFF_PN0_ id_stage_i.branch_set_d net2034
+ clknet_leaf_33_clk id_stage_i.branch_set VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.ctrl_fsm_cs\[0\]$_DFFE_PN0P_ _02874_
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.ctrl_fsm_cs\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.ctrl_fsm_cs\[1\]$_DFFE_PN0P_ _02875_
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.ctrl_fsm_cs\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.ctrl_fsm_cs\[2\]$_DFFE_PN0P_ _02876_
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.ctrl_fsm_cs\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.ctrl_fsm_cs\[3\]$_DFFE_PN0P_ _02877_
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.ctrl_fsm_cs\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.debug_mode_o$_DFFE_PN0P_ _02878_
+ net2034 clknet_leaf_7_clk cs_registers_i.debug_mode_i VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.exc_req_q$_DFF_PN0_ id_stage_i.controller_i.exc_req_d
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.exc_req_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.illegal_insn_q$_DFF_PN0_ id_stage_i.controller_i.illegal_insn_d
+ net2034 clknet_leaf_8_clk id_stage_i.controller_i.illegal_insn_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.load_err_q$_DFF_PN0_ id_stage_i.controller_i.load_err_i
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.load_err_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.nmi_mode_o$_DFFE_PN0P_ _02879_ net2035
+ clknet_leaf_12_clk cs_registers_i.nmi_mode_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.controller_i.store_err_q$_DFF_PN0_ id_stage_i.controller_i.store_err_i
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.store_err_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.id_fsm_q$_DFFE_PN0P_ _02880_ net2034 clknet_leaf_33_clk
+ id_stage_i.id_fsm_q VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[0\]$_DFFE_PN0P_ _02881_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[0\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[10\]$_DFFE_PN0P_ _02882_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[10\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[11\]$_DFFE_PN0P_ _02883_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[11\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[12\]$_DFFE_PN0P_ _02884_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[12\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[13\]$_DFFE_PN0P_ _02885_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[13\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[14\]$_DFFE_PN0P_ _02886_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[14\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[15\]$_DFFE_PN0P_ _02887_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[15\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[16\]$_DFFE_PN0P_ _02888_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[16\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[17\]$_DFFE_PN0P_ _02889_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[17\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[18\]$_DFFE_PN0P_ _02890_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[18\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[19\]$_DFFE_PN0P_ _02891_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[19\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[1\]$_DFFE_PN0P_ _02892_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[1\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[20\]$_DFFE_PN0P_ _02893_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[20\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[21\]$_DFFE_PN0P_ _02894_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[21\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[22\]$_DFFE_PN0P_ _02895_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[22\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[23\]$_DFFE_PN0P_ _02896_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[23\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[24\]$_DFFE_PN0P_ _02897_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[24\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[25\]$_DFFE_PN0P_ _02898_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[25\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[26\]$_DFFE_PN0P_ _02899_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[26\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[27\]$_DFFE_PN0P_ _02900_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[27\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[28\]$_DFFE_PN0P_ _02901_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[28\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[29\]$_DFFE_PN0P_ _02902_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[29\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[2\]$_DFFE_PN0P_ _02903_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[2\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[30\]$_DFFE_PN0P_ _02904_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[30\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[31\]$_DFFE_PN0P_ _02905_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[31\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[34\]$_DFFE_PN0P_ _02906_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[32\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[35\]$_DFFE_PN0P_ _02907_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[33\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[36\]$_DFFE_PN0P_ _02908_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[34\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[37\]$_DFFE_PN0P_ _02909_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[35\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[38\]$_DFFE_PN0P_ _02910_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[36\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[39\]$_DFFE_PN0P_ _02911_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[37\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[3\]$_DFFE_PN0P_ _02912_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[3\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[40\]$_DFFE_PN0P_ _02913_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[38\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[41\]$_DFFE_PN0P_ _02914_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[39\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[42\]$_DFFE_PN0P_ _02915_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[40\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[43\]$_DFFE_PN0P_ _02916_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[41\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[44\]$_DFFE_PN0P_ _02917_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[42\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[45\]$_DFFE_PN0P_ _02918_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[43\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[46\]$_DFFE_PN0P_ _02919_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[44\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[47\]$_DFFE_PN0P_ _02920_ net2037
+ clknet_leaf_30_clk ex_block_i.alu_i.imd_val_q_i\[45\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[48\]$_DFFE_PN0P_ _02921_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[46\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[49\]$_DFFE_PN0P_ _02922_ net2037
+ clknet_leaf_25_clk ex_block_i.alu_i.imd_val_q_i\[47\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[4\]$_DFFE_PN0P_ _02923_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[4\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[50\]$_DFFE_PN0P_ _02924_ net2037
+ clknet_leaf_28_clk ex_block_i.alu_i.imd_val_q_i\[48\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[51\]$_DFFE_PN0P_ _02925_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[49\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[52\]$_DFFE_PN0P_ _02926_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[50\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[53\]$_DFFE_PN0P_ _02927_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[51\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[54\]$_DFFE_PN0P_ _02928_ net2037
+ clknet_leaf_28_clk ex_block_i.alu_i.imd_val_q_i\[52\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[55\]$_DFFE_PN0P_ _02929_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[53\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[56\]$_DFFE_PN0P_ _02930_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[54\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[57\]$_DFFE_PN0P_ _02931_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[55\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[58\]$_DFFE_PN0P_ _02932_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[56\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[59\]$_DFFE_PN0P_ _02933_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[57\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[5\]$_DFFE_PN0P_ _02934_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[5\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[60\]$_DFFE_PN0P_ _02935_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[58\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[61\]$_DFFE_PN0P_ _02936_ net2037
+ clknet_leaf_28_clk ex_block_i.alu_i.imd_val_q_i\[59\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[62\]$_DFFE_PN0P_ _02937_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[60\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[63\]$_DFFE_PN0P_ _02938_ net2037
+ clknet_leaf_28_clk ex_block_i.alu_i.imd_val_q_i\[61\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[64\]$_DFFE_PN0P_ _02939_ net2037
+ clknet_leaf_28_clk ex_block_i.alu_i.imd_val_q_i\[62\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[65\]$_DFFE_PN0P_ _02940_ net2037
+ clknet_leaf_26_clk ex_block_i.alu_i.imd_val_q_i\[63\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[66\]$_DFFE_PN0P_ _02941_ net2037
+ clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[66\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[67\]$_DFFE_PN0P_ _02942_ net2037
+ clknet_leaf_28_clk ex_block_i.gen_multdiv_fast.multdiv_i.imd_val_q_i\[67\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[6\]$_DFFE_PN0P_ _02943_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[6\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[7\]$_DFFE_PN0P_ _02944_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[7\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[8\]$_DFFE_PN0P_ _02945_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[8\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xid_stage_i.imd_val_q_ex_o\[9\]$_DFFE_PN0P_ _02946_ net2037
+ clknet_leaf_31_clk ex_block_i.alu_i.imd_val_q_i\[9\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[0\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_s\[1\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.branch_discard_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_d
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.discard_req_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]$_DFFE_PP_
+ _02947_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]$_DFFE_PP_
+ _02948_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]$_DFFE_PP_
+ _02949_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]$_DFFE_PP_
+ _02950_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]$_DFFE_PP_
+ _02951_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]$_DFFE_PP_
+ _02952_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]$_DFFE_PP_
+ _02953_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]$_DFFE_PP_
+ _02954_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]$_DFFE_PP_
+ _02955_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]$_DFFE_PP_
+ _02956_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]$_DFFE_PP_
+ _02957_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]$_DFFE_PP_
+ _02958_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]$_DFFE_PP_
+ _02959_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]$_DFFE_PP_
+ _02960_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]$_DFFE_PP_
+ _02961_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]$_DFFE_PP_
+ _02962_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]$_DFFE_PP_
+ _02963_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]$_DFFE_PP_
+ _02964_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]$_DFFE_PP_
+ _02965_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]$_DFFE_PP_
+ _02966_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]$_DFFE_PP_
+ _02967_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]$_DFFE_PP_
+ _02968_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]$_DFFE_PP_
+ _02969_ clknet_leaf_3_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]$_DFFE_PP_
+ _02970_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]$_DFFE_PP_
+ _02971_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]$_DFFE_PP_
+ _02972_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]$_DFFE_PP_
+ _02973_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]$_DFFE_PP_
+ _02974_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]$_DFFE_PP_
+ _02975_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]$_DFFE_PP_
+ _02976_ clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fetch_addr_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]$_DFFE_PP_
+ _02977_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]$_DFFE_PP_
+ _02978_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]$_DFFE_PP_
+ _02979_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.err_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[0\]$_DFFE_PP_
+ _02980_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[1\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[10\]$_DFFE_PP_
+ _02981_ clknet_leaf_7_clk cs_registers_i.pc_if_i\[11\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[11\]$_DFFE_PP_
+ _02982_ clknet_leaf_7_clk cs_registers_i.pc_if_i\[12\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[12\]$_DFFE_PP_
+ _02983_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[13\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[13\]$_DFFE_PP_
+ _02984_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[14\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[14\]$_DFFE_PP_
+ _02985_ clknet_leaf_7_clk cs_registers_i.pc_if_i\[15\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[15\]$_DFFE_PP_
+ _02986_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[16\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[16\]$_DFFE_PP_
+ _02987_ clknet_leaf_5_clk cs_registers_i.pc_if_i\[17\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[17\]$_DFFE_PP_
+ _02988_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[18\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[18\]$_DFFE_PP_
+ _02989_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[19\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[19\]$_DFFE_PP_
+ _02990_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[20\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[1\]$_DFFE_PP_
+ _02991_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[2\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[20\]$_DFFE_PP_
+ _02992_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[21\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[21\]$_DFFE_PP_
+ _02993_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[22\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[22\]$_DFFE_PP_
+ _02994_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[23\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[23\]$_DFFE_PP_
+ _02995_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[24\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[24\]$_DFFE_PP_
+ _02996_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[25\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[25\]$_DFFE_PP_
+ _02997_ clknet_leaf_3_clk cs_registers_i.pc_if_i\[26\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[26\]$_DFFE_PP_
+ _02998_ clknet_leaf_4_clk cs_registers_i.pc_if_i\[27\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[27\]$_DFFE_PP_
+ _02999_ clknet_leaf_4_clk cs_registers_i.pc_if_i\[28\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[28\]$_DFFE_PP_
+ _03000_ clknet_leaf_4_clk cs_registers_i.pc_if_i\[29\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[29\]$_DFFE_PP_
+ _03001_ clknet_leaf_4_clk cs_registers_i.pc_if_i\[30\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[2\]$_DFFE_PP_
+ _03002_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[3\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[30\]$_DFFE_PP_
+ _03003_ clknet_leaf_4_clk cs_registers_i.pc_if_i\[31\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[3\]$_DFFE_PP_
+ _03004_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[4\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[4\]$_DFFE_PP_
+ _03005_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[5\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[5\]$_DFFE_PP_
+ _03006_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[6\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[6\]$_DFFE_PP_
+ _03007_ clknet_leaf_7_clk cs_registers_i.pc_if_i\[7\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[7\]$_DFFE_PP_
+ _03008_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[8\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[8\]$_DFFE_PP_
+ _03009_ clknet_leaf_2_clk cs_registers_i.pc_if_i\[9\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.instr_addr_q\[9\]$_DFFE_PP_
+ _03010_ clknet_leaf_7_clk cs_registers_i.pc_if_i\[10\] VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]$_DFFE_PP_
+ _03011_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]$_DFFE_PP_
+ _03012_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]$_DFFE_PP_
+ _03013_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]$_DFFE_PP_
+ _03014_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]$_DFFE_PP_
+ _03015_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]$_DFFE_PP_
+ _03016_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]$_DFFE_PP_
+ _03017_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]$_DFFE_PP_
+ _03018_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]$_DFFE_PP_
+ _03019_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]$_DFFE_PP_
+ _03020_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]$_DFFE_PP_
+ _03021_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]$_DFFE_PP_
+ _03022_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]$_DFFE_PP_
+ _03023_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]$_DFFE_PP_
+ _03024_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]$_DFFE_PP_
+ _03025_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]$_DFFE_PP_
+ _03026_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]$_DFFE_PP_
+ _03027_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]$_DFFE_PP_
+ _03028_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]$_DFFE_PP_
+ _03029_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]$_DFFE_PP_
+ _03030_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]$_DFFE_PP_
+ _03031_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]$_DFFE_PP_
+ _03032_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]$_DFFE_PP_
+ _03033_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]$_DFFE_PP_
+ _03034_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]$_DFFE_PP_
+ _03035_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]$_DFFE_PP_
+ _03036_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[32\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]$_DFFE_PP_
+ _03037_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[33\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]$_DFFE_PP_
+ _03038_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[34\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]$_DFFE_PP_
+ _03039_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[35\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]$_DFFE_PP_
+ _03040_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[36\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]$_DFFE_PP_
+ _03041_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[37\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]$_DFFE_PP_
+ _03042_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[38\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]$_DFFE_PP_
+ _03043_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[39\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]$_DFFE_PP_
+ _03044_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]$_DFFE_PP_
+ _03045_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[40\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]$_DFFE_PP_
+ _03046_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[41\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]$_DFFE_PP_
+ _03047_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[42\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]$_DFFE_PP_
+ _03048_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[43\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]$_DFFE_PP_
+ _03049_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[44\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]$_DFFE_PP_
+ _03050_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[45\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]$_DFFE_PP_
+ _03051_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[46\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]$_DFFE_PP_
+ _03052_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[47\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]$_DFFE_PP_
+ _03053_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[48\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]$_DFFE_PP_
+ _03054_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[49\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]$_DFFE_PP_
+ _03055_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]$_DFFE_PP_
+ _03056_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[50\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]$_DFFE_PP_
+ _03057_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[51\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]$_DFFE_PP_
+ _03058_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[52\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]$_DFFE_PP_
+ _03059_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[53\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]$_DFFE_PP_
+ _03060_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[54\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]$_DFFE_PP_
+ _03061_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[55\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]$_DFFE_PP_
+ _03062_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[56\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]$_DFFE_PP_
+ _03063_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[57\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]$_DFFE_PP_
+ _03064_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[58\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]$_DFFE_PP_
+ _03065_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[59\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]$_DFFE_PP_
+ _03066_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]$_DFFE_PP_
+ _03067_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[60\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]$_DFFE_PP_
+ _03068_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[61\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]$_DFFE_PP_
+ _03069_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[62\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]$_DFFE_PP_
+ _03070_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[63\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]$_DFFE_PP_
+ _03071_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[64\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]$_DFFE_PP_
+ _03072_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[65\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]$_DFFE_PP_
+ _03073_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[66\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]$_DFFE_PP_
+ _03074_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[67\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]$_DFFE_PP_
+ _03075_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[68\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]$_DFFE_PP_
+ _03076_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[69\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]$_DFFE_PP_
+ _03077_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]$_DFFE_PP_
+ _03078_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[70\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]$_DFFE_PP_
+ _03079_ clknet_leaf_35_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[71\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]$_DFFE_PP_
+ _03080_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[72\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]$_DFFE_PP_
+ _03081_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[73\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]$_DFFE_PP_
+ _03082_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[74\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]$_DFFE_PP_
+ _03083_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[75\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]$_DFFE_PP_
+ _03084_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[76\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]$_DFFE_PP_
+ _03085_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[77\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]$_DFFE_PP_
+ _03086_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[78\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]$_DFFE_PP_
+ _03087_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[79\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]$_DFFE_PP_
+ _03088_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]$_DFFE_PP_
+ _03089_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[80\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]$_DFFE_PP_
+ _03090_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[81\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]$_DFFE_PP_
+ _03091_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[82\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]$_DFFE_PP_
+ _03092_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[83\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]$_DFFE_PP_
+ _03093_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[84\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]$_DFFE_PP_
+ _03094_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[85\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]$_DFFE_PP_
+ _03095_ clknet_leaf_36_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[86\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]$_DFFE_PP_
+ _03096_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[87\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]$_DFFE_PP_
+ _03097_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[88\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]$_DFFE_PP_
+ _03098_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[89\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]$_DFFE_PP_
+ _03099_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]$_DFFE_PP_
+ _03100_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[90\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]$_DFFE_PP_
+ _03101_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[91\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]$_DFFE_PP_
+ _03102_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[92\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]$_DFFE_PP_
+ _03103_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[93\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]$_DFFE_PP_
+ _03104_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[94\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]$_DFFE_PP_
+ _03105_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[95\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]$_DFFE_PP_
+ _03106_ clknet_leaf_37_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.rdata_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[0\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[1\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[2\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_d\[2\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[0\]
+ net2034 clknet_leaf_2_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_s\[1\]
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.rdata_outstanding_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]$_DFFE_PP_
+ _03107_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]$_DFFE_PP_
+ _03108_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]$_DFFE_PP_
+ _03109_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]$_DFFE_PP_
+ _03110_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]$_DFFE_PP_
+ _03111_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]$_DFFE_PP_
+ _03112_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]$_DFFE_PP_
+ _03113_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]$_DFFE_PP_
+ _03114_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]$_DFFE_PP_
+ _03115_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]$_DFFE_PP_
+ _03116_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]$_DFFE_PP_
+ _03117_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]$_DFFE_PP_
+ _03118_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]$_DFFE_PP_
+ _03119_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]$_DFFE_PP_
+ _03120_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]$_DFFE_PP_
+ _03121_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]$_DFFE_PP_
+ _03122_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]$_DFFE_PP_
+ _03123_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]$_DFFE_PP_
+ _03124_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]$_DFFE_PP_
+ _03125_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]$_DFFE_PP_
+ _03126_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]$_DFFE_PP_
+ _03127_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]$_DFFE_PP_
+ _03128_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]$_DFFE_PP_
+ _03129_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]$_DFFE_PP_
+ _03130_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]$_DFFE_PP_
+ _03131_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]$_DFFE_PP_
+ _03132_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]$_DFFE_PP_
+ _03133_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]$_DFFE_PP_
+ _03134_ clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]$_DFFE_PP_
+ _03135_ clknet_leaf_0_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]$_DFFE_PP_
+ _03136_ clknet_leaf_38_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.stored_addr_q\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q$_DFF_PN0_
+ if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_d
+ net2034 clknet_leaf_1_clk if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.valid_req_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xif_stage_i.illegal_c_insn_id_o$_DFFE_PN_ _03137_ clknet_leaf_34_clk
+ id_stage_i.decoder_i.illegal_c_insn_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_fetch_err_o$_DFFE_PN_ _03138_ clknet_leaf_2_clk
+ id_stage_i.controller_i.instr_fetch_err_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_fetch_err_plus2_o$_SDFFCE_PN0N_ _03139_
+ clknet_leaf_2_clk id_stage_i.controller_i.instr_fetch_err_plus2_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_is_compressed_id_o$_DFFE_PN_ _03140_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_is_compressed_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[0\]$_DFFE_PN_ _03141_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[10\]$_DFFE_PN_ _03142_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[11\]$_DFFE_PN_ _03143_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[12\]$_DFFE_PN_ _03144_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[13\]$_DFFE_PN_ _03145_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[14\]$_DFFE_PN_ _03146_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[15\]$_DFFE_PN_ _03147_ clknet_leaf_34_clk
+ id_stage_i.controller_i.instr_compressed_i\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[1\]$_DFFE_PN_ _03148_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[2\]$_DFFE_PN_ _03149_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[3\]$_DFFE_PN_ _03150_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_compressed_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[4\]$_DFFE_PN_ _03151_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[5\]$_DFFE_PN_ _03152_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[6\]$_DFFE_PN_ _03153_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[7\]$_DFFE_PN_ _03154_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[8\]$_DFFE_PN_ _03155_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_c_id_o\[9\]$_DFFE_PN_ _03156_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_compressed_i\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[0\]$_DFFE_PN_ _03157_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[10\]$_DFFE_PN_ _03158_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[11\]$_DFFE_PN_ _03159_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[12\]$_DFFE_PN_ _03160_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[13\]$_DFFE_PN_ _03161_ clknet_leaf_34_clk
+ id_stage_i.controller_i.instr_i\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[14\]$_DFFE_PN_ _03162_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[15\]$_DFFE_PN_ _03163_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[16\]$_DFFE_PN_ _03164_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[17\]$_DFFE_PN_ _03165_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[18\]$_DFFE_PN_ _03166_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[19\]$_DFFE_PN_ _03167_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_a_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[1\]$_DFFE_PN_ _03168_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[20\]$_DFFE_PN_ _03169_ clknet_leaf_35_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[21\]$_DFFE_PN_ _03170_ clknet_leaf_35_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[22\]$_DFFE_PN_ _03171_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[23\]$_DFFE_PN_ _03172_ clknet_leaf_35_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[24\]$_DFFE_PN_ _03173_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.raddr_b_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[25\]$_DFFE_PN_ _03174_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[26\]$_DFFE_PN_ _03175_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_i\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[27\]$_DFFE_PN_ _03176_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_i\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[28\]$_DFFE_PN_ _03177_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[29\]$_DFFE_PN_ _03178_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[2\]$_DFFE_PN_ _03179_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[30\]$_DFFE_PN_ _03180_ clknet_leaf_8_clk
+ id_stage_i.controller_i.instr_i\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[31\]$_DFFE_PN_ _03181_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[3\]$_DFFE_PN_ _03182_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[4\]$_DFFE_PN_ _03183_ clknet_leaf_7_clk
+ id_stage_i.controller_i.instr_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[5\]$_DFFE_PN_ _03184_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_4
Xif_stage_i.instr_rdata_id_o\[6\]$_DFFE_PN_ _03185_ clknet_leaf_33_clk
+ id_stage_i.controller_i.instr_i\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[7\]$_DFFE_PN_ _03186_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[8\]$_DFFE_PN_ _03187_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_rdata_id_o\[9\]$_DFFE_PN_ _03188_ clknet_leaf_34_clk
+ gen_regfile_ff.register_file_i.waddr_a_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.instr_valid_id_o$_DFF_PN0_ if_stage_i.instr_valid_id_d
+ net2034 clknet_leaf_7_clk id_stage_i.controller_i.instr_valid_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xif_stage_i.pc_id_o\[10\]$_DFFE_PN_ _03189_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[10\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[11\]$_DFFE_PN_ _03190_ clknet_leaf_8_clk
+ cs_registers_i.pc_id_i\[11\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[12\]$_DFFE_PN_ _03191_ clknet_leaf_8_clk
+ cs_registers_i.pc_id_i\[12\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[13\]$_DFFE_PN_ _03192_ clknet_leaf_5_clk
+ cs_registers_i.pc_id_i\[13\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[14\]$_DFFE_PN_ _03193_ clknet_leaf_5_clk
+ cs_registers_i.pc_id_i\[14\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[15\]$_DFFE_PN_ _03194_ clknet_leaf_7_clk
+ cs_registers_i.pc_id_i\[15\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[16\]$_DFFE_PN_ _03195_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[16\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[17\]$_DFFE_PN_ _03196_ clknet_leaf_5_clk
+ cs_registers_i.pc_id_i\[17\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[18\]$_DFFE_PN_ _03197_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[18\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[19\]$_DFFE_PN_ _03198_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[19\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[1\]$_DFFE_PN_ _03199_ clknet_leaf_7_clk
+ cs_registers_i.pc_id_i\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[20\]$_DFFE_PN_ _03200_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[20\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[21\]$_DFFE_PN_ _03201_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[21\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[22\]$_DFFE_PN_ _03202_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[22\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[23\]$_DFFE_PN_ _03203_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[23\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[24\]$_DFFE_PN_ _03204_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[24\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[25\]$_DFFE_PN_ _03205_ clknet_leaf_14_clk
+ cs_registers_i.pc_id_i\[25\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[26\]$_DFFE_PN_ _03206_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[26\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[27\]$_DFFE_PN_ _03207_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[27\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[28\]$_DFFE_PN_ _03208_ clknet_leaf_4_clk
+ cs_registers_i.pc_id_i\[28\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[29\]$_DFFE_PN_ _03209_ clknet_leaf_14_clk
+ cs_registers_i.pc_id_i\[29\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[2\]$_DFFE_PN_ _03210_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[30\]$_DFFE_PN_ _03211_ clknet_leaf_13_clk
+ cs_registers_i.pc_id_i\[30\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[31\]$_DFFE_PN_ _03212_ clknet_leaf_12_clk
+ cs_registers_i.pc_id_i\[31\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[3\]$_DFFE_PN_ _03213_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[4\]$_DFFE_PN_ _03214_ clknet_leaf_8_clk
+ cs_registers_i.pc_id_i\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[5\]$_DFFE_PN_ _03215_ clknet_leaf_8_clk
+ cs_registers_i.pc_id_i\[5\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[6\]$_DFFE_PN_ _03216_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[6\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[7\]$_DFFE_PN_ _03217_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[7\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[8\]$_DFFE_PN_ _03218_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[8\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xif_stage_i.pc_id_o\[9\]$_DFFE_PN_ _03219_ clknet_leaf_6_clk
+ cs_registers_i.pc_id_i\[9\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xload_store_unit_i.addr_last_o\[0\]$_DFFE_PN0P_ _03220_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[10\]$_DFFE_PN0P_ _03221_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[11\]$_DFFE_PN0P_ _03222_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[12\]$_DFFE_PN0P_ _03223_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[13\]$_DFFE_PN0P_ _03224_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[14\]$_DFFE_PN0P_ _03225_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[15\]$_DFFE_PN0P_ _03226_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[16\]$_DFFE_PN0P_ _03227_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[17\]$_DFFE_PN0P_ _03228_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[18\]$_DFFE_PN0P_ _03229_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[19\]$_DFFE_PN0P_ _03230_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[1\]$_DFFE_PN0P_ _03231_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[20\]$_DFFE_PN0P_ _03232_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[21\]$_DFFE_PN0P_ _03233_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[22\]$_DFFE_PN0P_ _03234_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[23\]$_DFFE_PN0P_ _03235_ net2034
+ clknet_leaf_24_clk id_stage_i.controller_i.lsu_addr_last_i\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[24\]$_DFFE_PN0P_ _03236_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[25\]$_DFFE_PN0P_ _03237_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[26\]$_DFFE_PN0P_ _03238_ net2034
+ clknet_leaf_24_clk id_stage_i.controller_i.lsu_addr_last_i\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[27\]$_DFFE_PN0P_ _03239_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[28\]$_DFFE_PN0P_ _03240_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[29\]$_DFFE_PN0P_ _03241_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[2\]$_DFFE_PN0P_ _03242_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[30\]$_DFFE_PN0P_ _03243_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[31\]$_DFFE_PN0P_ _03244_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[3\]$_DFFE_PN0P_ _03245_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[4\]$_DFFE_PN0P_ _03246_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[5\]$_DFFE_PN0P_ _03247_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[6\]$_DFFE_PN0P_ _03248_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[7\]$_DFFE_PN0P_ _03249_ net2034
+ clknet_leaf_8_clk id_stage_i.controller_i.lsu_addr_last_i\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[8\]$_DFFE_PN0P_ _03250_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.addr_last_o\[9\]$_DFFE_PN0P_ _03251_ net2034
+ clknet_leaf_9_clk id_stage_i.controller_i.lsu_addr_last_i\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.data_sign_ext_q$_DFFE_PN0P_ _03252_ net2037
+ clknet_leaf_31_clk load_store_unit_i.data_sign_ext_q VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.data_we_q$_DFFE_PN0P_ _03253_ net2034 clknet_leaf_33_clk
+ load_store_unit_i.data_we_q VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.handle_misaligned_q$_DFFE_PN0P_ _03254_
+ net153 clknet_leaf_33_clk load_store_unit_i.handle_misaligned_q
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xload_store_unit_i.ls_fsm_cs\[0\]$_DFFE_PN0P_ _03255_ net153
+ clknet_leaf_33_clk load_store_unit_i.ls_fsm_cs\[0\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xload_store_unit_i.ls_fsm_cs\[1\]$_DFFE_PN0P_ _03256_ net153
+ clknet_leaf_33_clk load_store_unit_i.ls_fsm_cs\[1\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xload_store_unit_i.ls_fsm_cs\[2\]$_DFFE_PN0P_ _03257_ net2034
+ clknet_leaf_33_clk load_store_unit_i.ls_fsm_cs\[2\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xload_store_unit_i.lsu_err_q$_DFFE_PN0P_ _03258_ net2034 clknet_leaf_33_clk
+ load_store_unit_i.lsu_err_q VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_offset_q\[0\]$_DFFE_PN0P_ _03259_
+ net2036 clknet_leaf_29_clk load_store_unit_i.rdata_offset_q\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_offset_q\[1\]$_DFFE_PN0P_ _03260_
+ net2036 clknet_leaf_29_clk load_store_unit_i.rdata_offset_q\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[0\]$_DFFE_PN0P_ _03261_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[0\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[10\]$_DFFE_PN0P_ _03262_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[10\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[11\]$_DFFE_PN0P_ _03263_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[11\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[12\]$_DFFE_PN0P_ _03264_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[12\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[13\]$_DFFE_PN0P_ _03265_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[13\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[14\]$_DFFE_PN0P_ _03266_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[14\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[15\]$_DFFE_PN0P_ _03267_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[15\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[16\]$_DFFE_PN0P_ _03268_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[16\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[17\]$_DFFE_PN0P_ _03269_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[17\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[18\]$_DFFE_PN0P_ _03270_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[18\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[19\]$_DFFE_PN0P_ _03271_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[19\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[1\]$_DFFE_PN0P_ _03272_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[1\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[20\]$_DFFE_PN0P_ _03273_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[20\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[21\]$_DFFE_PN0P_ _03274_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[21\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[22\]$_DFFE_PN0P_ _03275_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[22\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[23\]$_DFFE_PN0P_ _03276_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[23\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[2\]$_DFFE_PN0P_ _03277_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[2\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[3\]$_DFFE_PN0P_ _03278_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[3\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[4\]$_DFFE_PN0P_ _03279_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[4\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[5\]$_DFFE_PN0P_ _03280_ net2036
+ clknet_leaf_29_clk load_store_unit_i.rdata_q\[5\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[6\]$_DFFE_PN0P_ _03281_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[6\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[7\]$_DFFE_PN0P_ _03282_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[7\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[8\]$_DFFE_PN0P_ _03283_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[8\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xload_store_unit_i.rdata_q\[9\]$_DFFE_PN0P_ _03284_ net2036
+ clknet_leaf_32_clk load_store_unit_i.rdata_q\[9\] VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
X_22866__1 alert_major_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_22867__2 alert_minor_o VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_22868__3 data_addr_o[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_22869__4 data_addr_o[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_22900__5 instr_addr_o[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
X_22901__6 instr_addr_o[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__tiel
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Right_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Right_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Right_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Right_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Right_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Right_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Right_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Right_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Right_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Right_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Right_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Right_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Right_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Right_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Right_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Right_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Right_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Right_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Right_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Right_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Right_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Right_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Right_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Right_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Right_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Right_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Right_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Right_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Right_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Right_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Right_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Right_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Right_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Right_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Right_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Right_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Right_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Right_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Right_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Right_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Right_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Right_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Right_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Right_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Right_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Right_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Right_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Right_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Right_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Right_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Right_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Right_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Right_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Right_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Right_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Right_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Right_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Right_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Right_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Right_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Right_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Right_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Right_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Right_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Right_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Right_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Right_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Right_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Right_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Right_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Right_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Right_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Right_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Right_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Right_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Right_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Right_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Right_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Right_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Right_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Right_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Right_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Right_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Right_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Right_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Right_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Right_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Right_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Right_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Right_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Right_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Right_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Right_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Right_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Right_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Right_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_163_Right_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_164_Right_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_165_Right_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_166_Right_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_167_Right_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_168_Right_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_169_Right_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_170_Right_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_171_Right_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_172_Right_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_173_Right_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_174_Right_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_175_Right_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_176_Right_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_177_Right_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_178_Right_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_179_Right_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_180_Right_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_181_Right_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_182_Right_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_183_Right_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_184_Right_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_185_Right_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_186_Right_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_187_Right_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_188_Right_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_189_Right_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_190_Right_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_191_Right_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_192_Right_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_193_Right_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_194_Right_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_195_Right_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_196_Right_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_197_Right_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_198_Right_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_199_Right_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_200_Right_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_201_Right_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_202_Right_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_203_Right_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_204_Right_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_205_Right_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_206_Right_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_207_Right_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_208_Right_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_209_Right_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_210_Right_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_211_Right_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_212_Right_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_213_Right_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_214_Right_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_215_Right_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_216_Right_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_217_Right_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_218_Right_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_219_Right_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_220_Right_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_221_Right_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_222_Right_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_223_Right_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_224_Right_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_225_Right_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_226_Right_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_227_Right_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_228_Right_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_229_Right_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_230_Right_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_231_Right_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_232_Right_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_233_Right_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_234_Right_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Left_302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Left_303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Left_304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Left_305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Left_306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Left_307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Left_308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Left_309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Left_310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Left_311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Left_312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Left_313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Left_314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Left_315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Left_316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Left_317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Left_318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Left_319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Left_320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Left_321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Left_322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Left_323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Left_324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Left_325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Left_326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Left_327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Left_328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Left_329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Left_330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Left_331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Left_332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Left_333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Left_334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Left_335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Left_336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Left_337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Left_338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Left_339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Left_340 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Left_341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Left_342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Left_343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Left_344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Left_345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_111_Left_346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_112_Left_347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_113_Left_348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_114_Left_349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_115_Left_350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_116_Left_351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_117_Left_352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_118_Left_353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_119_Left_354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_120_Left_355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_121_Left_356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_122_Left_357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_123_Left_358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_124_Left_359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_125_Left_360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_126_Left_361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_127_Left_362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_128_Left_363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_129_Left_364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_130_Left_365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_131_Left_366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_132_Left_367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_133_Left_368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_134_Left_369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_135_Left_370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_136_Left_371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_137_Left_372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_138_Left_373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_139_Left_374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_140_Left_375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_141_Left_376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_142_Left_377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_143_Left_378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_144_Left_379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_145_Left_380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_146_Left_381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_147_Left_382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_148_Left_383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_149_Left_384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_150_Left_385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_151_Left_386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_152_Left_387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_153_Left_388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_154_Left_389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_155_Left_390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_156_Left_391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_157_Left_392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_158_Left_393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_159_Left_394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_160_Left_395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_161_Left_396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_162_Left_397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_163_Left_398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_164_Left_399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_165_Left_400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_166_Left_401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_167_Left_402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_168_Left_403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_169_Left_404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_170_Left_405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_171_Left_406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_172_Left_407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_173_Left_408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_174_Left_409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_175_Left_410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_176_Left_411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_177_Left_412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_178_Left_413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_179_Left_414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_180_Left_415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_181_Left_416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_182_Left_417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_183_Left_418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_184_Left_419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_185_Left_420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_186_Left_421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_187_Left_422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_188_Left_423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_189_Left_424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_190_Left_425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_191_Left_426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_192_Left_427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_193_Left_428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_194_Left_429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_195_Left_430 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_196_Left_431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_197_Left_432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_198_Left_433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_199_Left_434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_200_Left_435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_201_Left_436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_202_Left_437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_203_Left_438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_204_Left_439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_205_Left_440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_206_Left_441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_207_Left_442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_208_Left_443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_209_Left_444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_210_Left_445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_211_Left_446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_212_Left_447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_213_Left_448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_214_Left_449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_215_Left_450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_216_Left_451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_217_Left_452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_218_Left_453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_219_Left_454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_220_Left_455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_221_Left_456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_222_Left_457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_223_Left_458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_224_Left_459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_225_Left_460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_226_Left_461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_227_Left_462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_228_Left_463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_229_Left_464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_230_Left_465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_231_Left_466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_232_Left_467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_233_Left_468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_234_Left_469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_504 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_505 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_506 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_507 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_508 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_509 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_510 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_511 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_512 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_513 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_514 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_515 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_516 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_517 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_518 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_519 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_520 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_521 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_522 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_523 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_524 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_525 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_526 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_527 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_528 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_529 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_530 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_531 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_532 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_533 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_534 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_535 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_536 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_537 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_538 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_539 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_540 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_541 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_542 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_543 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_544 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_545 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_546 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_547 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_548 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_549 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_550 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_551 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_552 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_553 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_554 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_555 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_556 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_557 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_558 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_559 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_560 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_561 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_562 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_563 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_564 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_565 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_566 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_567 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_568 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_569 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_570 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_571 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_572 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_573 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_574 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_575 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_576 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_577 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_578 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_579 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_580 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_581 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_582 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_583 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_584 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_585 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_586 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_587 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_588 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_589 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_590 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_591 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_592 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_593 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_594 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_595 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_596 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_597 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_598 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_599 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_600 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_601 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_602 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_603 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_604 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_605 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_606 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_607 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_608 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_609 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_610 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_611 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_612 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_613 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_614 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_615 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_616 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_617 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_618 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_619 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_620 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_621 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_622 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_623 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_624 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_625 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_626 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_627 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_628 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_629 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_630 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_631 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_632 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_633 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_634 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_635 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_636 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_637 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_638 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_639 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_640 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_641 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_642 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_643 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_644 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_645 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_646 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_647 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_648 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_649 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_650 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_651 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_652 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_653 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_654 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_655 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_656 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_657 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_658 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_659 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_660 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_661 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_662 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_663 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_664 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_665 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_666 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_667 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_668 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_669 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_670 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_671 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_672 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_673 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_674 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_675 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_676 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_677 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_678 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_679 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_680 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_681 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_682 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_683 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_684 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_685 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_686 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_687 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_688 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_689 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_690 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_691 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_692 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_693 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_694 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_695 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_696 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_697 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_698 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_699 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_700 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_701 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_702 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_703 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_704 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_705 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_706 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_707 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_708 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_709 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_710 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_711 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_712 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_713 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_714 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_715 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_716 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_717 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_718 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_719 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_720 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_721 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_722 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_723 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_724 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_725 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_726 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_727 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_728 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_729 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_730 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_731 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_732 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_733 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_734 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_735 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_736 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_737 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_738 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_739 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_740 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_741 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_742 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_743 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_744 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_745 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_746 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_747 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_748 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_749 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_750 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_751 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_752 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_753 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_754 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_755 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_756 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_757 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_758 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_759 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_760 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_761 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_762 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_763 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_764 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_765 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_766 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_767 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_768 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_769 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_770 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_771 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_772 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_773 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_774 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_775 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_776 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_777 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_778 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_779 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_780 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_781 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_782 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_783 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_784 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_785 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_786 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_787 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_788 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_789 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_790 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_791 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_792 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_793 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_794 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_795 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_796 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_797 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_798 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_799 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_800 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_801 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_802 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_803 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_804 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_805 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_806 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_807 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_808 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_809 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_810 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_811 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_812 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_813 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_814 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_815 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_816 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_817 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_818 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_819 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_820 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_821 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_822 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_823 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_824 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_825 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_826 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_827 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_828 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_829 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_830 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_831 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_832 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_833 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_834 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_835 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_836 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_837 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_838 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_839 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_840 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_841 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_842 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_843 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_844 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_845 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_846 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_847 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_848 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_849 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_850 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_851 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_852 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_853 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_854 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_855 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_856 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_857 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_858 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_859 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_860 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_861 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_862 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_863 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_864 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_865 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_866 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_867 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_868 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_869 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_870 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_871 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_872 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_873 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_874 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_875 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_876 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_877 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_878 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_879 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_880 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_881 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_882 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_883 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_884 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_885 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_886 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_887 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_888 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_889 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_890 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_891 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_892 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_893 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_894 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_895 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_896 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_897 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_898 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_899 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_900 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_901 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_902 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_903 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_904 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_905 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_906 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_907 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_908 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_909 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_910 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_911 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_912 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_913 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_914 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_915 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_916 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_917 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_918 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_919 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_920 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_921 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_922 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_923 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_924 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_925 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_926 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_927 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_928 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_929 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_930 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_931 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_932 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_933 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_934 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_935 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_936 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_937 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_938 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_939 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_940 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_941 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_942 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_943 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_944 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_945 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_946 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_947 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_948 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_949 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_950 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_951 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_952 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_953 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_954 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_955 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_956 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_957 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_958 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_959 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_960 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_961 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_962 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_963 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_964 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_965 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_966 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_967 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_968 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_969 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_970 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_971 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_972 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_973 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_974 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_975 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_976 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_977 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_978 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_979 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_980 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_981 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_982 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_983 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_984 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_985 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_986 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_987 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_988 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_989 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_990 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_991 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_992 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_993 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_994 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_995 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_996 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_997 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_998 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_999 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_1000 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_1001 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_1002 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1003 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1004 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1005 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1006 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1007 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_1008 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_1009 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_1010 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_1011 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_1012 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_1013 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1014 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1015 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1016 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1017 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1018 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_1019 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_1020 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_1021 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_1022 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_1023 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_1024 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1025 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1026 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1027 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1028 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1029 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_1030 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_1031 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_1032 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_1033 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_1034 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_1035 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1036 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1037 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1038 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1039 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1040 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_1041 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_1042 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_1043 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_1044 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_1045 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_1046 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1047 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1048 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1049 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1050 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1051 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_1052 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_1053 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_1054 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_1055 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_1056 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_1057 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1058 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1059 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1060 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1061 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1062 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_1063 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_1064 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_1065 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_1066 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_1067 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_1068 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1069 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1070 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1071 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1072 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1073 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_1074 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_1075 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_1076 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_1077 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_1078 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_1079 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1080 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1081 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1082 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1083 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1084 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_1085 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_1086 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_1087 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_1088 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_1089 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_111_1090 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1091 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1092 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1093 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1094 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1095 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_112_1096 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_1097 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_1098 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_1099 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_1100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_113_1101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_114_1107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_1108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_1109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_1110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_1111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_115_1112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_116_1118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_1119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_1120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_1121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_1122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_117_1123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_118_1129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_1130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_1131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_1132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_1133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_119_1134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_120_1140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_1141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_1142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_1143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_1144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_121_1145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_122_1151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_1152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_1153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_1154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_1155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_123_1156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_124_1162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_1163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_1164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_1165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_1166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_125_1167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_126_1173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_1174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_1175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_1176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_1177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_127_1178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_128_1184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_1185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_1186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_1187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_1188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_129_1189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_130_1195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_1196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_1197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_1198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_1199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_131_1200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_132_1206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_1207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_1208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_1209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_1210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_133_1211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_134_1217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_135_1222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_136_1228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_137_1233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_138_1239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_139_1244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_140_1250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_141_1255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_142_1261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_143_1266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_144_1272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_145_1277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_146_1283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_147_1288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_148_1294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_149_1299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_150_1305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_151_1310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_152_1316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_153_1321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_154_1327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_155_1332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_156_1338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1340 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_157_1343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_158_1349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_159_1354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_160_1360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_161_1365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_162_1371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_163_1376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_164_1382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_165_1387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_166_1393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_167_1398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_168_1404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_169_1409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_170_1415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_171_1420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_172_1426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1430 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_173_1431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_174_1437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_175_1442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_176_1448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_177_1453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_178_1459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_179_1464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_180_1470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_181_1475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_182_1481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_183_1486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_184_1492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_185_1497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_186_1503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1504 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1505 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1506 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1507 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_187_1508 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1509 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1510 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1511 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1512 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1513 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_188_1514 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1515 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1516 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1517 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1518 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_189_1519 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1520 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1521 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1522 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1523 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1524 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_190_1525 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1526 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1527 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1528 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1529 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_191_1530 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1531 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1532 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1533 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1534 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1535 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_192_1536 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1537 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1538 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1539 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1540 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_193_1541 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1542 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1543 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1544 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1545 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1546 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_194_1547 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_195_1548 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_195_1549 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_195_1550 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_195_1551 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_195_1552 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1553 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1554 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1555 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1556 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1557 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_196_1558 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_197_1559 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_197_1560 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_197_1561 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_197_1562 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_197_1563 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1564 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1565 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1566 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1567 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1568 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_198_1569 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_199_1570 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_199_1571 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_199_1572 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_199_1573 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_199_1574 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1575 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1576 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1577 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1578 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1579 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_200_1580 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_201_1581 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_201_1582 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_201_1583 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_201_1584 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_201_1585 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1586 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1587 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1588 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1589 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1590 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_202_1591 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_203_1592 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_203_1593 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_203_1594 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_203_1595 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_203_1596 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1597 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1598 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1599 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1600 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1601 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_204_1602 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_205_1603 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_205_1604 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_205_1605 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_205_1606 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_205_1607 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1608 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1609 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1610 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1611 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1612 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_206_1613 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_207_1614 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_207_1615 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_207_1616 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_207_1617 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_207_1618 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1619 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1620 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1621 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1622 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1623 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_208_1624 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_209_1625 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_209_1626 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_209_1627 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_209_1628 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_209_1629 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1630 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1631 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1632 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1633 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1634 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_210_1635 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_211_1636 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_211_1637 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_211_1638 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_211_1639 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_211_1640 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1641 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1642 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1643 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1644 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1645 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_212_1646 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_213_1647 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_213_1648 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_213_1649 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_213_1650 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_213_1651 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1652 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1653 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1654 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1655 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1656 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_214_1657 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_215_1658 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_215_1659 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_215_1660 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_215_1661 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_215_1662 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1663 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1664 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1665 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1666 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1667 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_216_1668 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_217_1669 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_217_1670 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_217_1671 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_217_1672 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_217_1673 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1674 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1675 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1676 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1677 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1678 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_218_1679 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_219_1680 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_219_1681 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_219_1682 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_219_1683 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_219_1684 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1685 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1686 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1687 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1688 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1689 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_220_1690 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_221_1691 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_221_1692 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_221_1693 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_221_1694 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_221_1695 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1696 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1697 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1698 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1699 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1700 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_222_1701 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_223_1702 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_223_1703 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_223_1704 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_223_1705 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_223_1706 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1707 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1708 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1709 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1710 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1711 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_224_1712 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_225_1713 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_225_1714 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_225_1715 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_225_1716 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_225_1717 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1718 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1719 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1720 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1721 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1722 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_226_1723 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_227_1724 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_227_1725 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_227_1726 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_227_1727 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_227_1728 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1729 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1730 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1731 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1732 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1733 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_228_1734 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_229_1735 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_229_1736 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_229_1737 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_229_1738 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_229_1739 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1740 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1741 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1742 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1743 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1744 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_230_1745 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_231_1746 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_231_1747 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_231_1748 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_231_1749 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_231_1750 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1751 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1752 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1753 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1754 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1755 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_232_1756 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_233_1757 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_233_1758 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_233_1759 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_233_1760 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_233_1761 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1762 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1763 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1764 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1765 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1766 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1767 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1768 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1769 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1770 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1771 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_234_1772 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xplace1741 net1739 net1740 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1740 _07763_ net1739 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1747 _09965_ net1746 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1742 net2177 net1741 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1743 _07603_ net1742 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1744 _06969_ net1743 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1745 _06964_ net1744 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1746 _06936_ net1745 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1748 _09962_ net1747 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1749 _09840_ net1748 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1787 net1785 net1786 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1751 _09668_ net1750 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1752 _09660_ net1751 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1781 net1779 net1780 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1766 _08954_ net1765 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1753 _09421_ net1752 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1754 _09405_ net1753 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1755 _09374_ net1754 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1756 _09358_ net1755 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1757 _09322_ net1756 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1758 _09258_ net1757 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1759 _09223_ net1758 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1760 _09166_ net1759 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1761 _09131_ net1760 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1762 _09079_ net1761 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1763 _09042_ net1762 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1764 _08981_ net1763 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1765 _08961_ net1764 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1767 _08941_ net1766 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1768 _08889_ net1767 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1769 _08852_ net1768 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1770 _08793_ net1769 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1771 _08775_ net1770 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1772 _08755_ net1771 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1773 _08690_ net1772 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1774 _08649_ net1773 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1775 _08586_ net1774 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1776 _08427_ net1775 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1777 _08378_ net1776 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1778 _08361_ net1777 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1779 _08339_ net1778 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1780 _08291_ net1779 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1782 _08252_ net1781 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1783 _08214_ net1782 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1784 _08187_ net1783 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1785 _08098_ net1784 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1786 _08074_ net1785 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1788 _07993_ net1787 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1795 net1793 net1794 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1793 net1791 net1792 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1791 net1789 net1790 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1789 _07904_ net1788 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1790 _07880_ net1789 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1792 _07857_ net1791 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1794 _07829_ net1793 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1796 _07805_ net1795 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace2008 net2005 net2007 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1814 _08597_ net1813 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1797 _07740_ net1796 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1798 _07693_ net1797 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1813 _08704_ net1812 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1799 _07691_ net1798 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1800 _07647_ net1799 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1809 _09937_ net1808 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1801 _07636_ net1800 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xplace1804 net1802 net1803 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1802 _07610_ net1801 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1803 _07549_ net1802 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1805 _07030_ net1804 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1807 _05835_ net1806 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1808 _04342_ net1807 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1810 _09619_ net1809 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1811 _08949_ net1810 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1812 _08711_ net1811 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2007 net2005 net2006 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1816 net1814 net1815 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1815 _08182_ net1814 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2006 net2093 net2005 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace2005 net2137 net2004 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2004 net2002 net2003 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1822 _08657_ net1821 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1819 net2483 net1818 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1818 _07555_ net1817 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1817 _07620_ net1816 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1820 _06473_ net1819 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1821 _08657_ net1820 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2003 net2055 net2002 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace2002 net1999 net2001 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace2001 net1999 net2000 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1823 _08596_ net1822 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1824 _08199_ net1823 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1825 _08197_ net1824 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1826 _08181_ net1825 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1827 _07999_ net1826 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2000 net2093 net1999 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1828 _07842_ net1827 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1999 net1989 net1998 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1830 _07745_ net1829 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1829 _07745_ net1828 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1838 _09753_ net1837 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1831 _07684_ net1830 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1837 _09753_ net1836 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1832 _07596_ net1831 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1833 _07547_ net1832 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1834 _04560_ net1833 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1835 _10016_ net1834 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1836 _09930_ net1835 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1998 net1996 net1997 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xplace1839 _09749_ net1838 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1989 net1983 net1988 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1840 _09745_ net1839 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1988 net1983 net1987 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1841 _09650_ net1840 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1987 net1983 net1986 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1842 _08192_ net1841 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1845 _08010_ net1844 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1844 net1842 net1843 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1843 _08010_ net1842 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1986 net1983 net1985 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1984 net1972 net1983 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1983 net1976 net1982 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1852 net1847 net1851 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1982 net1980 net1981 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1853 net1847 net1852 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1985 net1983 net1984 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1846 _07947_ net1845 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1851 net1847 net1850 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1850 net1847 net1849 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1847 _07689_ net1846 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1849 net1847 net1848 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1848 _07681_ net1847 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1958 net2058 net1957 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1855 _07666_ net1854 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1854 _07666_ net1853 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1957 net2128 net1956 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1956 net2128 net1955 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1931 net1927 net1930 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1930 net1927 net1929 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1929 net1927 net1928 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1928 net1913 net1927 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1858 _07666_ net1857 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1857 _07666_ net1856 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1856 net1854 net1855 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1926 net1922 net1925 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1860 _07665_ net1859 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1859 _07665_ net1858 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1925 net1922 net1924 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1884 net1882 net1883 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1885 _07518_ net1884 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1861 _07657_ net1860 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1863 net1861 net1862 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1862 _07657_ net1861 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1883 _07518_ net1882 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1882 _07518_ net1881 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1880 net1877 net1879 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1876 net1874 net1875 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1875 net1871 net1874 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1881 net1877 net1880 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1874 net1872 net1873 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1873 net1871 net1872 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1868 _07537_ net1867 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1867 _07537_ net1866 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1866 net1864 net1865 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1865 _07537_ net1864 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1872 _07534_ net1871 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1869 _07534_ net1868 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1871 net1869 net1870 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1870 _07534_ net1869 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1877 _07523_ net1876 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1878 _07518_ net1877 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1924 net1922 net1923 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1918 net1916 net1917 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1917 net1913 net1916 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1916 net2179 net1915 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1915 net1913 net1914 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1914 net2090 net1913 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1887 load_store_unit_i.rdata_offset_q\[1\] net1886 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1886 _01354_ net1885 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1923 net1913 net1922 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1922 net1918 net1921 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1921 net1918 net1920 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1920 net1918 net1919 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1919 net1913 net1918 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1888 load_store_unit_i.rdata_offset_q\[0\] net1887 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1903 gen_regfile_ff.register_file_i.raddr_b_i\[3\] net1902
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1889 id_stage_i.controller_i.instr_i\[6\] net1888 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace1902 gen_regfile_ff.register_file_i.raddr_b_i\[3\] net1901
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1890 id_stage_i.controller_i.instr_i\[4\] net1889 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xplace1891 id_stage_i.controller_i.instr_i\[3\] net1890 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace1892 id_stage_i.controller_i.instr_i\[31\] net1891 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1893 id_stage_i.controller_i.instr_i\[30\] net1892 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1894 id_stage_i.controller_i.instr_i\[2\] net1893 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
Xplace1895 id_stage_i.controller_i.instr_i\[29\] net1894 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1896 id_stage_i.controller_i.instr_i\[28\] net1895 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1897 id_stage_i.controller_i.instr_i\[27\] net1896 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1898 id_stage_i.controller_i.instr_i\[26\] net1897 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1899 id_stage_i.controller_i.instr_i\[25\] net1898 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1900 gen_regfile_ff.register_file_i.raddr_b_i\[4\] net1899
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1901 gen_regfile_ff.register_file_i.raddr_b_i\[3\] net1900
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1906 net2101 net1905 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1905 gen_regfile_ff.register_file_i.raddr_b_i\[2\] net1904
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1904 gen_regfile_ff.register_file_i.raddr_b_i\[2\] net1903
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1913 net1909 net1912 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1907 net2090 net1906 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1912 net1909 net1911 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1911 net2089 net1910 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1908 net2090 net1907 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1910 net2090 net1909 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1909 net1907 net1908 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1932 gen_regfile_ff.register_file_i.raddr_b_i\[0\] net1931
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xplace1954 net1944 net1953 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1948 net2128 net1947 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1947 net1944 net1946 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1937 net1933 net1936 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1933 net2104 net1932 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1936 net1933 net1935 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1935 net1933 net1934 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1934 net2154 net1933 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1946 net2114 net1945 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1945 net2058 net1944 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1944 net2139 net1943 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xplace1943 net2141 net1942 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace1942 net2141 net1941 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1941 net2141 net1940 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1938 net2140 net1937 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1940 net2140 net1939 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1939 net2139 net1938 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1953 net1944 net1952 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1952 net2128 net1951 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1951 net1944 net1950 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1950 net1944 net1949 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1949 net2128 net1948 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1962 net1959 net1961 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1972 net1968 net1971 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1971 net1968 net1970 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1970 net1968 net1969 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1969 net1966 net1968 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1980 net1976 net1979 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1979 net1976 net1978 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1978 net1976 net1977 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1977 net1972 net1976 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1976 net1972 net1975 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1968 net1966 net1967 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1964 net1962 net1963 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1963 gen_regfile_ff.register_file_i.raddr_a_i\[2\] net1962
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1967 gen_regfile_ff.register_file_i.raddr_a_i\[1\] net1966
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1966 net1964 net1965 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1965 gen_regfile_ff.register_file_i.raddr_a_i\[1\] net1964
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1997 net1989 net1996 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1992 net1990 net1991 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1991 net1989 net1990 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace1990 net2093 net1989 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_20
Xplace1996 net1989 net1995 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1995 net1989 net1994 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1994 net1990 net1993 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1993 net1990 net1992 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2045 net144 net2044 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2038 net2036 net2037 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace2037 net153 net2036 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace2036 net2034 net2035 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace2023 net2021 net2022 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_8
Xplace2020 id_stage_i.controller_i.instr_i\[14\] net2019 VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xclkbuf_leaf_22_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_22_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_0_clk_i_regs clknet_2_0__leaf_clk_i_regs clknet_leaf_0_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_1_0__f_clk_i clknet_0_clk_i clknet_1_0__leaf_clk_i
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace2047 net142 net2046 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkbuf_0_clk_i clk_i clknet_0_clk_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_regs_0_core_clock delaynet_4_core_clock clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace2051 net134 net2050 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2050 net137 net2049 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2049 net138 net2048 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2048 net141 net2047 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xclkbuf_leaf_21_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_21_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_20_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_20_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_15_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_15_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_14_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_14_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_13_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_13_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_12_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_12_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_1_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_1_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_11_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_11_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_10_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_10_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_2_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_2_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_9_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_9_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_4_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_4_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_3_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_3_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_8_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_8_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_7_clk_i_regs clknet_2_1__leaf_clk_i_regs clknet_leaf_7_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_6_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_6_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_5_clk_i_regs clknet_2_3__leaf_clk_i_regs clknet_leaf_5_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_19_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_19_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_18_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_18_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_16_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_16_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_17_clk_i_regs clknet_2_2__leaf_clk_i_regs clknet_leaf_17_clk_i_regs
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xplace2025 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_busy\[0\]
+ net2024 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2026 if_stage_i.gen_prefetch_buffer.prefetch_buffer_i.fifo_i.valid_q\[0\]
+ net2025 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2029 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[4\]
+ net2028 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2030 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[1\]
+ net2029 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2031 ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[3\]
+ net2030 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2032 ex_block_i.gen_multdiv_fast.multdiv_i.md_state_q\[5\]
+ net2031 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2033 ex_block_i.gen_multdiv_fast.multdiv_i.gen_mult_fast.mult_state_q\[1\]
+ net2032 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2034 net153 net2033 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_16
Xplace2044 net145 net2043 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2042 net147 net2041 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2041 net148 net2040 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2040 net149 net2039 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace2039 net150 net2038 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace1363 _05009_ net1362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1369 _05065_ net1368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_12
Xplace1374 _04981_ net1373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
XANTENNA_5 data_rvalid_i VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_6 instr_rdata_i[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_7 instr_rdata_i[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_8 instr_rdata_i[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_9 instr_rdata_i[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_10 instr_rdata_i[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_11 instr_rdata_i[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_12 net1451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
XANTENNA_13 net1458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__antenna
.ENDS ibex_core
