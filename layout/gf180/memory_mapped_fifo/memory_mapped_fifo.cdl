* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT memory_mapped_fifo clk ext_empty ext_full ext_rd_data[0]
+ ext_rd_data[10] ext_rd_data[11] ext_rd_data[12] ext_rd_data[13]
+ ext_rd_data[14] ext_rd_data[15] ext_rd_data[16] ext_rd_data[17]
+ ext_rd_data[18] ext_rd_data[19] ext_rd_data[1] ext_rd_data[20]
+ ext_rd_data[21] ext_rd_data[22] ext_rd_data[23] ext_rd_data[24]
+ ext_rd_data[25] ext_rd_data[26] ext_rd_data[27] ext_rd_data[28]
+ ext_rd_data[29] ext_rd_data[2] ext_rd_data[30] ext_rd_data[31]
+ ext_rd_data[3] ext_rd_data[4] ext_rd_data[5] ext_rd_data[6]
+ ext_rd_data[7] ext_rd_data[8] ext_rd_data[9] ext_rd_en ext_wr_data[0]
+ ext_wr_data[10] ext_wr_data[11] ext_wr_data[12] ext_wr_data[13]
+ ext_wr_data[14] ext_wr_data[15] ext_wr_data[16] ext_wr_data[17]
+ ext_wr_data[18] ext_wr_data[19] ext_wr_data[1] ext_wr_data[20]
+ ext_wr_data[21] ext_wr_data[22] ext_wr_data[23] ext_wr_data[24]
+ ext_wr_data[25] ext_wr_data[26] ext_wr_data[27] ext_wr_data[28]
+ ext_wr_data[29] ext_wr_data[2] ext_wr_data[30] ext_wr_data[31]
+ ext_wr_data[3] ext_wr_data[4] ext_wr_data[5] ext_wr_data[6]
+ ext_wr_data[7] ext_wr_data[8] ext_wr_data[9] ext_wr_en mem_addr[0]
+ mem_addr[1] mem_addr[2] mem_addr[3] mem_rdata[0] mem_rdata[10]
+ mem_rdata[11] mem_rdata[12] mem_rdata[13] mem_rdata[14] mem_rdata[15]
+ mem_rdata[16] mem_rdata[17] mem_rdata[18] mem_rdata[19] mem_rdata[1]
+ mem_rdata[20] mem_rdata[21] mem_rdata[22] mem_rdata[23] mem_rdata[24]
+ mem_rdata[25] mem_rdata[26] mem_rdata[27] mem_rdata[28] mem_rdata[29]
+ mem_rdata[2] mem_rdata[30] mem_rdata[31] mem_rdata[3] mem_rdata[4]
+ mem_rdata[5] mem_rdata[6] mem_rdata[7] mem_rdata[8] mem_rdata[9]
+ mem_ready mem_valid mem_wdata[0] mem_wdata[10] mem_wdata[11]
+ mem_wdata[12] mem_wdata[13] mem_wdata[14] mem_wdata[15] mem_wdata[16]
+ mem_wdata[17] mem_wdata[18] mem_wdata[19] mem_wdata[1] mem_wdata[20]
+ mem_wdata[21] mem_wdata[22] mem_wdata[23] mem_wdata[24] mem_wdata[25]
+ mem_wdata[26] mem_wdata[27] mem_wdata[28] mem_wdata[29] mem_wdata[2]
+ mem_wdata[30] mem_wdata[31] mem_wdata[3] mem_wdata[4] mem_wdata[5]
+ mem_wdata[6] mem_wdata[7] mem_wdata[8] mem_wdata[9] mem_write
+ rst_n VSS VDD
X_1571_ net178 _1331_ _1332_ _1333_ _1334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_1572_ _0630_ _1334_ _0755_ _1335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1573_ net176 _1325_ _1330_ _1335_ _1336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_1574_ mem\[0\]\[9\] net164 _1336_ _1337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_1575_ _1322_ _0647_ _0650_ _1337_ _0058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xclkbuf_leaf_20_clk clknet_1_0__leaf_clk clknet_leaf_20_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1577_ net2 net40 net181 _1339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_19_clk clknet_1_0__leaf_clk clknet_leaf_19_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1579_ _0644_ _1341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1580_ _0639_ _1341_ net34 _1342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_1581_ _0615_ _0626_ _1342_ _1343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_4
Xclkbuf_leaf_18_clk clknet_1_0__leaf_clk clknet_leaf_18_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1583_ net73 _0022_ _1345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1584_ wr_ptr\[3\] _1346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1585_ wr_ptr\[2\] _1347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_1586_ _1346_ _1347_ _1348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1587_ net175 _1343_ _1345_ _1348_ _1349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xclkbuf_leaf_17_clk clknet_1_0__leaf_clk clknet_leaf_17_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1589_ mem\[0\]\[0\] _1339_ _1349_ _0059_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1590_ net3 net41 net181 _1351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_16_clk clknet_1_0__leaf_clk clknet_leaf_16_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1592_ mem\[0\]\[10\] _1351_ _1349_ _0060_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1593_ net4 net42 net181 _1353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_15_clk clknet_1_0__leaf_clk clknet_leaf_15_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1595_ mem\[0\]\[11\] _1353_ _1349_ _0061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1596_ net5 net43 net181 _1355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_14_clk clknet_1_0__leaf_clk clknet_leaf_14_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1598_ mem\[0\]\[12\] _1355_ _1349_ _0062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1599_ net6 net44 net181 _1357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_13_clk clknet_1_0__leaf_clk clknet_leaf_13_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1601_ mem\[0\]\[13\] _1357_ _1349_ _0063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1602_ net7 net45 net181 _1359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_12_clk clknet_1_1__leaf_clk clknet_leaf_12_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1604_ mem\[0\]\[14\] _1359_ _1349_ _0064_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1605_ net8 net46 net181 _1361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_11_clk clknet_1_1__leaf_clk clknet_leaf_11_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1607_ mem\[0\]\[15\] _1361_ _1349_ _0065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1608_ net9 net47 net181 _1363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_10_clk clknet_1_1__leaf_clk clknet_leaf_10_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1610_ mem\[0\]\[16\] _1363_ _1349_ _0066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1611_ net10 net48 net181 _1365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_9_clk clknet_1_1__leaf_clk clknet_leaf_9_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1613_ mem\[0\]\[17\] _1365_ _1349_ _0067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1614_ net11 net49 net181 _1367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_8_clk clknet_1_1__leaf_clk clknet_leaf_8_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1616_ mem\[0\]\[18\] _1367_ _1349_ _0068_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_7_clk clknet_1_1__leaf_clk clknet_leaf_7_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1618_ net12 net50 net181 _1370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_6_clk clknet_1_1__leaf_clk clknet_leaf_6_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkbuf_leaf_5_clk clknet_1_1__leaf_clk clknet_leaf_5_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1621_ mem\[0\]\[19\] _1370_ _1349_ _0069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1622_ net13 net51 net181 _1373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_4_clk clknet_1_1__leaf_clk clknet_leaf_4_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1624_ mem\[0\]\[1\] _1373_ _1349_ _0070_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1625_ net14 net52 net181 _1375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_3_clk clknet_1_1__leaf_clk clknet_leaf_3_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1627_ mem\[0\]\[20\] _1375_ _1349_ _0071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1628_ net15 net53 net181 _1377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_2_clk clknet_1_1__leaf_clk clknet_leaf_2_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1630_ mem\[0\]\[21\] _1377_ _1349_ _0072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1631_ net16 net54 net181 _1379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_1_clk clknet_1_0__leaf_clk clknet_leaf_1_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1633_ mem\[0\]\[22\] _1379_ _1349_ _0073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1634_ net17 net55 net181 _1381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace174 _0643_ net174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1636_ mem\[0\]\[23\] _1381_ _1349_ _0074_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1637_ net18 net56 net181 _1383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace172 _0020_ net172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1639_ mem\[0\]\[24\] _1383_ _1349_ _0075_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1640_ net19 net57 net181 _1385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace170 _0016_ net170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1642_ mem\[0\]\[25\] _1385_ _1349_ _0076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1643_ net20 net58 net181 _1387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace168 _0018_ net168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1645_ mem\[0\]\[26\] _1387_ _1349_ _0077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1646_ net21 net59 net181 _1389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace166 _0019_ net166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1648_ mem\[0\]\[27\] _1389_ _1349_ _0078_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace163 _1484_ net163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1650_ net22 net60 net181 _1392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace181 net39 net181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
Xplace180 net73 net180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1653_ mem\[0\]\[28\] _1392_ _1349_ _0079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1654_ net23 net61 net181 _1395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace177 _0630_ net177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1656_ mem\[0\]\[29\] _1395_ _1349_ _0080_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1657_ net24 net62 net181 _1397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace176 _0633_ net176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1659_ mem\[0\]\[2\] _1397_ _1349_ _0081_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1660_ net25 net63 net181 _1399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace167 _0018_ net167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1662_ mem\[0\]\[30\] _1399_ _1349_ _0082_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1663_ net26 net64 net181 _1401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace164 _0683_ net164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1665_ mem\[0\]\[31\] _1401_ _1349_ _0083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1666_ net27 net65 net181 _1403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xclkbuf_leaf_0_clk clknet_1_0__leaf_clk clknet_leaf_0_clk
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
X_1668_ mem\[0\]\[3\] _1403_ _1349_ _0084_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1669_ net28 net66 net181 _1405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace179 rd_ptr\[2\] net179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1671_ mem\[0\]\[4\] _1405_ _1349_ _0085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1672_ net29 net67 net181 _1407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace178 rd_ptr\[3\] net178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1674_ mem\[0\]\[5\] _1407_ _1349_ _0086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1675_ net30 net68 net181 _1409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace175 _0640_ net175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1677_ mem\[0\]\[6\] _1409_ _1349_ _0087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1678_ net31 net69 net181 _1411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace173 _0676_ net173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1680_ mem\[0\]\[7\] _1411_ _1349_ _0088_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1681_ net32 net70 net181 _1413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace171 _0020_ net171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1683_ mem\[0\]\[8\] _1413_ _1349_ _0089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1684_ net33 net71 net181 _1415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace169 _0016_ net169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1686_ mem\[0\]\[9\] _1415_ _1349_ _0090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xplace165 _0019_ net165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_4
X_1688_ net73 _0024_ _1418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1689_ wr_ptr\[3\] _1347_ _1419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1690_ net175 _1343_ _1418_ _1419_ _1420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput140 net140 mem_ready VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1692_ mem\[10\]\[0\] _1339_ _1420_ _0091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1693_ mem\[10\]\[10\] _1351_ _1420_ _0092_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1694_ mem\[10\]\[11\] _1353_ _1420_ _0093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1695_ mem\[10\]\[12\] _1355_ _1420_ _0094_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1696_ mem\[10\]\[13\] _1357_ _1420_ _0095_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1697_ mem\[10\]\[14\] _1359_ _1420_ _0096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1698_ mem\[10\]\[15\] _1361_ _1420_ _0097_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1699_ mem\[10\]\[16\] _1363_ _1420_ _0098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1700_ mem\[10\]\[17\] _1365_ _1420_ _0099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1701_ mem\[10\]\[18\] _1367_ _1420_ _0100_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput139 net139 mem_rdata[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1703_ mem\[10\]\[19\] _1370_ _1420_ _0101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1704_ mem\[10\]\[1\] _1373_ _1420_ _0102_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1705_ mem\[10\]\[20\] _1375_ _1420_ _0103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1706_ mem\[10\]\[21\] _1377_ _1420_ _0104_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1707_ mem\[10\]\[22\] _1379_ _1420_ _0105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1708_ mem\[10\]\[23\] _1381_ _1420_ _0106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1709_ mem\[10\]\[24\] _1383_ _1420_ _0107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1710_ mem\[10\]\[25\] _1385_ _1420_ _0108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1711_ mem\[10\]\[26\] _1387_ _1420_ _0109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1712_ mem\[10\]\[27\] _1389_ _1420_ _0110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput138 net138 mem_rdata[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1714_ mem\[10\]\[28\] _1392_ _1420_ _0111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1715_ mem\[10\]\[29\] _1395_ _1420_ _0112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1716_ mem\[10\]\[2\] _1397_ _1420_ _0113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1717_ mem\[10\]\[30\] _1399_ _1420_ _0114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1718_ mem\[10\]\[31\] _1401_ _1420_ _0115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1719_ mem\[10\]\[3\] _1403_ _1420_ _0116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1720_ mem\[10\]\[4\] _1405_ _1420_ _0117_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1721_ mem\[10\]\[5\] _1407_ _1420_ _0118_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1722_ mem\[10\]\[6\] _1409_ _1420_ _0119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1723_ mem\[10\]\[7\] _1411_ _1420_ _0120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1724_ mem\[10\]\[8\] _1413_ _1420_ _0121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1725_ mem\[10\]\[9\] _1415_ _1420_ _0122_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1726_ _0026_ net73 _1424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1727_ net175 _1343_ _1419_ _1424_ _1425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput137 net137 mem_rdata[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1729_ mem\[11\]\[0\] _1339_ _1425_ _0123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1730_ mem\[11\]\[10\] _1351_ _1425_ _0124_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1731_ mem\[11\]\[11\] _1353_ _1425_ _0125_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1732_ mem\[11\]\[12\] _1355_ _1425_ _0126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1733_ mem\[11\]\[13\] _1357_ _1425_ _0127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1734_ mem\[11\]\[14\] _1359_ _1425_ _0128_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1735_ mem\[11\]\[15\] _1361_ _1425_ _0129_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1736_ mem\[11\]\[16\] _1363_ _1425_ _0130_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1737_ mem\[11\]\[17\] _1365_ _1425_ _0131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1738_ mem\[11\]\[18\] _1367_ _1425_ _0132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput136 net136 mem_rdata[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1740_ mem\[11\]\[19\] _1370_ _1425_ _0133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1741_ mem\[11\]\[1\] _1373_ _1425_ _0134_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1742_ mem\[11\]\[20\] _1375_ _1425_ _0135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1743_ mem\[11\]\[21\] _1377_ _1425_ _0136_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1744_ mem\[11\]\[22\] _1379_ _1425_ _0137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1745_ mem\[11\]\[23\] _1381_ _1425_ _0138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1746_ mem\[11\]\[24\] _1383_ _1425_ _0139_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1747_ mem\[11\]\[25\] _1385_ _1425_ _0140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1748_ mem\[11\]\[26\] _1387_ _1425_ _0141_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1749_ mem\[11\]\[27\] _1389_ _1425_ _0142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput135 net135 mem_rdata[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1751_ mem\[11\]\[28\] _1392_ _1425_ _0143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1752_ mem\[11\]\[29\] _1395_ _1425_ _0144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1753_ mem\[11\]\[2\] _1397_ _1425_ _0145_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1754_ mem\[11\]\[30\] _1399_ _1425_ _0146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1755_ mem\[11\]\[31\] _1401_ _1425_ _0147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1756_ mem\[11\]\[3\] _1403_ _1425_ _0148_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1757_ mem\[11\]\[4\] _1405_ _1425_ _0149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1758_ mem\[11\]\[5\] _1407_ _1425_ _0150_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1759_ mem\[11\]\[6\] _1409_ _1425_ _0151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1760_ mem\[11\]\[7\] _1411_ _1425_ _0152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1761_ mem\[11\]\[8\] _1413_ _1425_ _0153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1762_ mem\[11\]\[9\] _1415_ _1425_ _0154_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1763_ wr_ptr\[3\] wr_ptr\[2\] _1429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_4
X_1764_ net175 _1343_ _1345_ _1429_ _1430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput134 net134 mem_rdata[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1766_ mem\[12\]\[0\] _1339_ _1430_ _0155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1767_ mem\[12\]\[10\] _1351_ _1430_ _0156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1768_ mem\[12\]\[11\] _1353_ _1430_ _0157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1769_ mem\[12\]\[12\] _1355_ _1430_ _0158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1770_ mem\[12\]\[13\] _1357_ _1430_ _0159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1771_ mem\[12\]\[14\] _1359_ _1430_ _0160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1772_ mem\[12\]\[15\] _1361_ _1430_ _0161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1773_ mem\[12\]\[16\] _1363_ _1430_ _0162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1774_ mem\[12\]\[17\] _1365_ _1430_ _0163_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1775_ mem\[12\]\[18\] _1367_ _1430_ _0164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput133 net133 mem_rdata[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1777_ mem\[12\]\[19\] _1370_ _1430_ _0165_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1778_ mem\[12\]\[1\] _1373_ _1430_ _0166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1779_ mem\[12\]\[20\] _1375_ _1430_ _0167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1780_ mem\[12\]\[21\] _1377_ _1430_ _0168_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1781_ mem\[12\]\[22\] _1379_ _1430_ _0169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1782_ mem\[12\]\[23\] _1381_ _1430_ _0170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1783_ mem\[12\]\[24\] _1383_ _1430_ _0171_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1784_ mem\[12\]\[25\] _1385_ _1430_ _0172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1785_ mem\[12\]\[26\] _1387_ _1430_ _0173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1786_ mem\[12\]\[27\] _1389_ _1430_ _0174_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput132 net132 mem_rdata[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1788_ mem\[12\]\[28\] _1392_ _1430_ _0175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1789_ mem\[12\]\[29\] _1395_ _1430_ _0176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1790_ mem\[12\]\[2\] _1397_ _1430_ _0177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1791_ mem\[12\]\[30\] _1399_ _1430_ _0178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1792_ mem\[12\]\[31\] _1401_ _1430_ _0179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1793_ mem\[12\]\[3\] _1403_ _1430_ _0180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1794_ mem\[12\]\[4\] _1405_ _1430_ _0181_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1795_ mem\[12\]\[5\] _1407_ _1430_ _0182_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1796_ mem\[12\]\[6\] _1409_ _1430_ _0183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1797_ mem\[12\]\[7\] _1411_ _1430_ _0184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1798_ mem\[12\]\[8\] _1413_ _1430_ _0185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1799_ mem\[12\]\[9\] _1415_ _1430_ _0186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1800_ net73 _0025_ _1434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_1801_ net175 _1343_ _1429_ _1434_ _1435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput131 net131 mem_rdata[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1803_ mem\[13\]\[0\] _1339_ _1435_ _0187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1804_ mem\[13\]\[10\] _1351_ _1435_ _0188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1805_ mem\[13\]\[11\] _1353_ _1435_ _0189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1806_ mem\[13\]\[12\] _1355_ _1435_ _0190_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1807_ mem\[13\]\[13\] _1357_ _1435_ _0191_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1808_ mem\[13\]\[14\] _1359_ _1435_ _0192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1809_ mem\[13\]\[15\] _1361_ _1435_ _0193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1810_ mem\[13\]\[16\] _1363_ _1435_ _0194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1811_ mem\[13\]\[17\] _1365_ _1435_ _0195_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1812_ mem\[13\]\[18\] _1367_ _1435_ _0196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput130 net130 mem_rdata[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1814_ mem\[13\]\[19\] _1370_ _1435_ _0197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1815_ mem\[13\]\[1\] _1373_ _1435_ _0198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1816_ mem\[13\]\[20\] _1375_ _1435_ _0199_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1817_ mem\[13\]\[21\] _1377_ _1435_ _0200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1818_ mem\[13\]\[22\] _1379_ _1435_ _0201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1819_ mem\[13\]\[23\] _1381_ _1435_ _0202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1820_ mem\[13\]\[24\] _1383_ _1435_ _0203_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1821_ mem\[13\]\[25\] _1385_ _1435_ _0204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1822_ mem\[13\]\[26\] _1387_ _1435_ _0205_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1823_ mem\[13\]\[27\] _1389_ _1435_ _0206_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput129 net129 mem_rdata[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1825_ mem\[13\]\[28\] _1392_ _1435_ _0207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1826_ mem\[13\]\[29\] _1395_ _1435_ _0208_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1827_ mem\[13\]\[2\] _1397_ _1435_ _0209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1828_ mem\[13\]\[30\] _1399_ _1435_ _0210_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1829_ mem\[13\]\[31\] _1401_ _1435_ _0211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1830_ mem\[13\]\[3\] _1403_ _1435_ _0212_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1831_ mem\[13\]\[4\] _1405_ _1435_ _0213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1832_ mem\[13\]\[5\] _1407_ _1435_ _0214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1833_ mem\[13\]\[6\] _1409_ _1435_ _0215_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1834_ mem\[13\]\[7\] _1411_ _1435_ _0216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1835_ mem\[13\]\[8\] _1413_ _1435_ _0217_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1836_ mem\[13\]\[9\] _1415_ _1435_ _0218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1837_ net175 _1343_ _1418_ _1429_ _1439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput128 net128 mem_rdata[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1839_ mem\[14\]\[0\] _1339_ _1439_ _0219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1840_ mem\[14\]\[10\] _1351_ _1439_ _0220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1841_ mem\[14\]\[11\] _1353_ _1439_ _0221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1842_ mem\[14\]\[12\] _1355_ _1439_ _0222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1843_ mem\[14\]\[13\] _1357_ _1439_ _0223_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1844_ mem\[14\]\[14\] _1359_ _1439_ _0224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1845_ mem\[14\]\[15\] _1361_ _1439_ _0225_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1846_ mem\[14\]\[16\] _1363_ _1439_ _0226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1847_ mem\[14\]\[17\] _1365_ _1439_ _0227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1848_ mem\[14\]\[18\] _1367_ _1439_ _0228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput127 net127 mem_rdata[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1850_ mem\[14\]\[19\] _1370_ _1439_ _0229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1851_ mem\[14\]\[1\] _1373_ _1439_ _0230_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1852_ mem\[14\]\[20\] _1375_ _1439_ _0231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1853_ mem\[14\]\[21\] _1377_ _1439_ _0232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1854_ mem\[14\]\[22\] _1379_ _1439_ _0233_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1855_ mem\[14\]\[23\] _1381_ _1439_ _0234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1856_ mem\[14\]\[24\] _1383_ _1439_ _0235_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1857_ mem\[14\]\[25\] _1385_ _1439_ _0236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1858_ mem\[14\]\[26\] _1387_ _1439_ _0237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1859_ mem\[14\]\[27\] _1389_ _1439_ _0238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput126 net126 mem_rdata[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1861_ mem\[14\]\[28\] _1392_ _1439_ _0239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1862_ mem\[14\]\[29\] _1395_ _1439_ _0240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1863_ mem\[14\]\[2\] _1397_ _1439_ _0241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1864_ mem\[14\]\[30\] _1399_ _1439_ _0242_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1865_ mem\[14\]\[31\] _1401_ _1439_ _0243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1866_ mem\[14\]\[3\] _1403_ _1439_ _0244_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1867_ mem\[14\]\[4\] _1405_ _1439_ _0245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1868_ mem\[14\]\[5\] _1407_ _1439_ _0246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1869_ mem\[14\]\[6\] _1409_ _1439_ _0247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1870_ mem\[14\]\[7\] _1411_ _1439_ _0248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1871_ mem\[14\]\[8\] _1413_ _1439_ _0249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1872_ mem\[14\]\[9\] _1415_ _1439_ _0250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1873_ net175 _1343_ _1424_ _1429_ _1443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput125 net125 mem_rdata[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1875_ mem\[15\]\[0\] _1339_ _1443_ _0251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1876_ mem\[15\]\[10\] _1351_ _1443_ _0252_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1877_ mem\[15\]\[11\] _1353_ _1443_ _0253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1878_ mem\[15\]\[12\] _1355_ _1443_ _0254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1879_ mem\[15\]\[13\] _1357_ _1443_ _0255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1880_ mem\[15\]\[14\] _1359_ _1443_ _0256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1881_ mem\[15\]\[15\] _1361_ _1443_ _0257_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1882_ mem\[15\]\[16\] _1363_ _1443_ _0258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1883_ mem\[15\]\[17\] _1365_ _1443_ _0259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1884_ mem\[15\]\[18\] _1367_ _1443_ _0260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput124 net124 mem_rdata[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1886_ mem\[15\]\[19\] _1370_ _1443_ _0261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1887_ mem\[15\]\[1\] _1373_ _1443_ _0262_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1888_ mem\[15\]\[20\] _1375_ _1443_ _0263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1889_ mem\[15\]\[21\] _1377_ _1443_ _0264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1890_ mem\[15\]\[22\] _1379_ _1443_ _0265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1891_ mem\[15\]\[23\] _1381_ _1443_ _0266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1892_ mem\[15\]\[24\] _1383_ _1443_ _0267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1893_ mem\[15\]\[25\] _1385_ _1443_ _0268_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1894_ mem\[15\]\[26\] _1387_ _1443_ _0269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1895_ mem\[15\]\[27\] _1389_ _1443_ _0270_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput123 net123 mem_rdata[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1897_ mem\[15\]\[28\] _1392_ _1443_ _0271_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1898_ mem\[15\]\[29\] _1395_ _1443_ _0272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1899_ mem\[15\]\[2\] _1397_ _1443_ _0273_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1900_ mem\[15\]\[30\] _1399_ _1443_ _0274_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1901_ mem\[15\]\[31\] _1401_ _1443_ _0275_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1902_ mem\[15\]\[3\] _1403_ _1443_ _0276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1903_ mem\[15\]\[4\] _1405_ _1443_ _0277_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1904_ mem\[15\]\[5\] _1407_ _1443_ _0278_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1905_ mem\[15\]\[6\] _1409_ _1443_ _0279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1906_ mem\[15\]\[7\] _1411_ _1443_ _0280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1907_ mem\[15\]\[8\] _1413_ _1443_ _0281_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1908_ mem\[15\]\[9\] _1415_ _1443_ _0282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1909_ net175 _1343_ _1348_ _1434_ _1447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput122 net122 mem_rdata[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1911_ mem\[1\]\[0\] _1339_ _1447_ _0283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1912_ mem\[1\]\[10\] _1351_ _1447_ _0284_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1913_ mem\[1\]\[11\] _1353_ _1447_ _0285_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1914_ mem\[1\]\[12\] _1355_ _1447_ _0286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1915_ mem\[1\]\[13\] _1357_ _1447_ _0287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1916_ mem\[1\]\[14\] _1359_ _1447_ _0288_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1917_ mem\[1\]\[15\] _1361_ _1447_ _0289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1918_ mem\[1\]\[16\] _1363_ _1447_ _0290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1919_ mem\[1\]\[17\] _1365_ _1447_ _0291_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1920_ mem\[1\]\[18\] _1367_ _1447_ _0292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput121 net121 mem_rdata[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1922_ mem\[1\]\[19\] _1370_ _1447_ _0293_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1923_ mem\[1\]\[1\] _1373_ _1447_ _0294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1924_ mem\[1\]\[20\] _1375_ _1447_ _0295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1925_ mem\[1\]\[21\] _1377_ _1447_ _0296_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1926_ mem\[1\]\[22\] _1379_ _1447_ _0297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1927_ mem\[1\]\[23\] _1381_ _1447_ _0298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1928_ mem\[1\]\[24\] _1383_ _1447_ _0299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1929_ mem\[1\]\[25\] _1385_ _1447_ _0300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1930_ mem\[1\]\[26\] _1387_ _1447_ _0301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1931_ mem\[1\]\[27\] _1389_ _1447_ _0302_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput120 net120 mem_rdata[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1933_ mem\[1\]\[28\] _1392_ _1447_ _0303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1934_ mem\[1\]\[29\] _1395_ _1447_ _0304_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1935_ mem\[1\]\[2\] _1397_ _1447_ _0305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1936_ mem\[1\]\[30\] _1399_ _1447_ _0306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1937_ mem\[1\]\[31\] _1401_ _1447_ _0307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1938_ mem\[1\]\[3\] _1403_ _1447_ _0308_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1939_ mem\[1\]\[4\] _1405_ _1447_ _0309_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1940_ mem\[1\]\[5\] _1407_ _1447_ _0310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1941_ mem\[1\]\[6\] _1409_ _1447_ _0311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1942_ mem\[1\]\[7\] _1411_ _1447_ _0312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1943_ mem\[1\]\[8\] _1413_ _1447_ _0313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1944_ mem\[1\]\[9\] _1415_ _1447_ _0314_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1945_ net175 _1343_ _1348_ _1418_ _1451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput119 net119 mem_rdata[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1947_ mem\[2\]\[0\] _1339_ _1451_ _0315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1948_ mem\[2\]\[10\] _1351_ _1451_ _0316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1949_ mem\[2\]\[11\] _1353_ _1451_ _0317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1950_ mem\[2\]\[12\] _1355_ _1451_ _0318_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1951_ mem\[2\]\[13\] _1357_ _1451_ _0319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1952_ mem\[2\]\[14\] _1359_ _1451_ _0320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1953_ mem\[2\]\[15\] _1361_ _1451_ _0321_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1954_ mem\[2\]\[16\] _1363_ _1451_ _0322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1955_ mem\[2\]\[17\] _1365_ _1451_ _0323_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1956_ mem\[2\]\[18\] _1367_ _1451_ _0324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput118 net118 mem_rdata[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1958_ mem\[2\]\[19\] _1370_ _1451_ _0325_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1959_ mem\[2\]\[1\] _1373_ _1451_ _0326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1960_ mem\[2\]\[20\] _1375_ _1451_ _0327_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1961_ mem\[2\]\[21\] _1377_ _1451_ _0328_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1962_ mem\[2\]\[22\] _1379_ _1451_ _0329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1963_ mem\[2\]\[23\] _1381_ _1451_ _0330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1964_ mem\[2\]\[24\] _1383_ _1451_ _0331_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1965_ mem\[2\]\[25\] _1385_ _1451_ _0332_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1966_ mem\[2\]\[26\] _1387_ _1451_ _0333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1967_ mem\[2\]\[27\] _1389_ _1451_ _0334_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput117 net117 mem_rdata[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1969_ mem\[2\]\[28\] _1392_ _1451_ _0335_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1970_ mem\[2\]\[29\] _1395_ _1451_ _0336_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1971_ mem\[2\]\[2\] _1397_ _1451_ _0337_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1972_ mem\[2\]\[30\] _1399_ _1451_ _0338_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1973_ mem\[2\]\[31\] _1401_ _1451_ _0339_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1974_ mem\[2\]\[3\] _1403_ _1451_ _0340_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1975_ mem\[2\]\[4\] _1405_ _1451_ _0341_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1976_ mem\[2\]\[5\] _1407_ _1451_ _0342_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1977_ mem\[2\]\[6\] _1409_ _1451_ _0343_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1978_ mem\[2\]\[7\] _1411_ _1451_ _0344_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1979_ mem\[2\]\[8\] _1413_ _1451_ _0345_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1980_ mem\[2\]\[9\] _1415_ _1451_ _0346_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1981_ net175 _1343_ _1348_ _1424_ _1455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput116 net116 mem_rdata[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1983_ mem\[3\]\[0\] _1339_ _1455_ _0347_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1984_ mem\[3\]\[10\] _1351_ _1455_ _0348_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1985_ mem\[3\]\[11\] _1353_ _1455_ _0349_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1986_ mem\[3\]\[12\] _1355_ _1455_ _0350_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1987_ mem\[3\]\[13\] _1357_ _1455_ _0351_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1988_ mem\[3\]\[14\] _1359_ _1455_ _0352_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1989_ mem\[3\]\[15\] _1361_ _1455_ _0353_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1990_ mem\[3\]\[16\] _1363_ _1455_ _0354_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1991_ mem\[3\]\[17\] _1365_ _1455_ _0355_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1992_ mem\[3\]\[18\] _1367_ _1455_ _0356_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput115 net115 mem_rdata[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_1994_ mem\[3\]\[19\] _1370_ _1455_ _0357_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1995_ mem\[3\]\[1\] _1373_ _1455_ _0358_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1996_ mem\[3\]\[20\] _1375_ _1455_ _0359_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1997_ mem\[3\]\[21\] _1377_ _1455_ _0360_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1998_ mem\[3\]\[22\] _1379_ _1455_ _0361_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_1999_ mem\[3\]\[23\] _1381_ _1455_ _0362_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2000_ mem\[3\]\[24\] _1383_ _1455_ _0363_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2001_ mem\[3\]\[25\] _1385_ _1455_ _0364_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2002_ mem\[3\]\[26\] _1387_ _1455_ _0365_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2003_ mem\[3\]\[27\] _1389_ _1455_ _0366_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput114 net114 mem_rdata[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2005_ mem\[3\]\[28\] _1392_ _1455_ _0367_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2006_ mem\[3\]\[29\] _1395_ _1455_ _0368_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2007_ mem\[3\]\[2\] _1397_ _1455_ _0369_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2008_ mem\[3\]\[30\] _1399_ _1455_ _0370_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2009_ mem\[3\]\[31\] _1401_ _1455_ _0371_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2010_ mem\[3\]\[3\] _1403_ _1455_ _0372_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2011_ mem\[3\]\[4\] _1405_ _1455_ _0373_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2012_ mem\[3\]\[5\] _1407_ _1455_ _0374_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2013_ mem\[3\]\[6\] _1409_ _1455_ _0375_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2014_ mem\[3\]\[7\] _1411_ _1455_ _0376_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2015_ mem\[3\]\[8\] _1413_ _1455_ _0377_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2016_ mem\[3\]\[9\] _1415_ _1455_ _0378_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2017_ _1346_ wr_ptr\[2\] _1459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2018_ net175 _1343_ _1345_ _1459_ _1460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput113 net113 mem_rdata[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2020_ mem\[4\]\[0\] _1339_ _1460_ _0379_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2021_ mem\[4\]\[10\] _1351_ _1460_ _0380_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2022_ mem\[4\]\[11\] _1353_ _1460_ _0381_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2023_ mem\[4\]\[12\] _1355_ _1460_ _0382_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2024_ mem\[4\]\[13\] _1357_ _1460_ _0383_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2025_ mem\[4\]\[14\] _1359_ _1460_ _0384_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2026_ mem\[4\]\[15\] _1361_ _1460_ _0385_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2027_ mem\[4\]\[16\] _1363_ _1460_ _0386_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2028_ mem\[4\]\[17\] _1365_ _1460_ _0387_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2029_ mem\[4\]\[18\] _1367_ _1460_ _0388_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput112 net112 mem_rdata[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2031_ mem\[4\]\[19\] _1370_ _1460_ _0389_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2032_ mem\[4\]\[1\] _1373_ _1460_ _0390_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2033_ mem\[4\]\[20\] _1375_ _1460_ _0391_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2034_ mem\[4\]\[21\] _1377_ _1460_ _0392_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2035_ mem\[4\]\[22\] _1379_ _1460_ _0393_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2036_ mem\[4\]\[23\] _1381_ _1460_ _0394_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2037_ mem\[4\]\[24\] _1383_ _1460_ _0395_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2038_ mem\[4\]\[25\] _1385_ _1460_ _0396_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2039_ mem\[4\]\[26\] _1387_ _1460_ _0397_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2040_ mem\[4\]\[27\] _1389_ _1460_ _0398_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput111 net111 mem_rdata[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2042_ mem\[4\]\[28\] _1392_ _1460_ _0399_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2043_ mem\[4\]\[29\] _1395_ _1460_ _0400_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2044_ mem\[4\]\[2\] _1397_ _1460_ _0401_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2045_ mem\[4\]\[30\] _1399_ _1460_ _0402_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2046_ mem\[4\]\[31\] _1401_ _1460_ _0403_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2047_ mem\[4\]\[3\] _1403_ _1460_ _0404_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2048_ mem\[4\]\[4\] _1405_ _1460_ _0405_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2049_ mem\[4\]\[5\] _1407_ _1460_ _0406_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2050_ mem\[4\]\[6\] _1409_ _1460_ _0407_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2051_ mem\[4\]\[7\] _1411_ _1460_ _0408_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2052_ mem\[4\]\[8\] _1413_ _1460_ _0409_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2053_ mem\[4\]\[9\] _1415_ _1460_ _0410_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2054_ net175 _1343_ _1434_ _1459_ _1464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput110 net110 mem_rdata[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2056_ mem\[5\]\[0\] _1339_ _1464_ _0411_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2057_ mem\[5\]\[10\] _1351_ _1464_ _0412_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2058_ mem\[5\]\[11\] _1353_ _1464_ _0413_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2059_ mem\[5\]\[12\] _1355_ _1464_ _0414_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2060_ mem\[5\]\[13\] _1357_ _1464_ _0415_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2061_ mem\[5\]\[14\] _1359_ _1464_ _0416_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2062_ mem\[5\]\[15\] _1361_ _1464_ _0417_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2063_ mem\[5\]\[16\] _1363_ _1464_ _0418_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2064_ mem\[5\]\[17\] _1365_ _1464_ _0419_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2065_ mem\[5\]\[18\] _1367_ _1464_ _0420_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput109 net109 mem_rdata[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2067_ mem\[5\]\[19\] _1370_ _1464_ _0421_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2068_ mem\[5\]\[1\] _1373_ _1464_ _0422_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2069_ mem\[5\]\[20\] _1375_ _1464_ _0423_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2070_ mem\[5\]\[21\] _1377_ _1464_ _0424_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2071_ mem\[5\]\[22\] _1379_ _1464_ _0425_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2072_ mem\[5\]\[23\] _1381_ _1464_ _0426_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2073_ mem\[5\]\[24\] _1383_ _1464_ _0427_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2074_ mem\[5\]\[25\] _1385_ _1464_ _0428_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2075_ mem\[5\]\[26\] _1387_ _1464_ _0429_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2076_ mem\[5\]\[27\] _1389_ _1464_ _0430_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput108 net108 mem_rdata[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2078_ mem\[5\]\[28\] _1392_ _1464_ _0431_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2079_ mem\[5\]\[29\] _1395_ _1464_ _0432_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2080_ mem\[5\]\[2\] _1397_ _1464_ _0433_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2081_ mem\[5\]\[30\] _1399_ _1464_ _0434_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2082_ mem\[5\]\[31\] _1401_ _1464_ _0435_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2083_ mem\[5\]\[3\] _1403_ _1464_ _0436_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2084_ mem\[5\]\[4\] _1405_ _1464_ _0437_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2085_ mem\[5\]\[5\] _1407_ _1464_ _0438_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2086_ mem\[5\]\[6\] _1409_ _1464_ _0439_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2087_ mem\[5\]\[7\] _1411_ _1464_ _0440_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2088_ mem\[5\]\[8\] _1413_ _1464_ _0441_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2089_ mem\[5\]\[9\] _1415_ _1464_ _0442_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2090_ net175 _1343_ _1418_ _1459_ _1468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput107 net107 ext_rd_data[9] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2092_ mem\[6\]\[0\] _1339_ _1468_ _0443_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2093_ mem\[6\]\[10\] _1351_ _1468_ _0444_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2094_ mem\[6\]\[11\] _1353_ _1468_ _0445_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2095_ mem\[6\]\[12\] _1355_ _1468_ _0446_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2096_ mem\[6\]\[13\] _1357_ _1468_ _0447_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2097_ mem\[6\]\[14\] _1359_ _1468_ _0448_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2098_ mem\[6\]\[15\] _1361_ _1468_ _0449_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2099_ mem\[6\]\[16\] _1363_ _1468_ _0450_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2100_ mem\[6\]\[17\] _1365_ _1468_ _0451_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2101_ mem\[6\]\[18\] _1367_ _1468_ _0452_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput106 net106 ext_rd_data[8] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2103_ mem\[6\]\[19\] _1370_ _1468_ _0453_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2104_ mem\[6\]\[1\] _1373_ _1468_ _0454_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2105_ mem\[6\]\[20\] _1375_ _1468_ _0455_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2106_ mem\[6\]\[21\] _1377_ _1468_ _0456_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2107_ mem\[6\]\[22\] _1379_ _1468_ _0457_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2108_ mem\[6\]\[23\] _1381_ _1468_ _0458_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2109_ mem\[6\]\[24\] _1383_ _1468_ _0459_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2110_ mem\[6\]\[25\] _1385_ _1468_ _0460_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2111_ mem\[6\]\[26\] _1387_ _1468_ _0461_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2112_ mem\[6\]\[27\] _1389_ _1468_ _0462_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput105 net105 ext_rd_data[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2114_ mem\[6\]\[28\] _1392_ _1468_ _0463_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2115_ mem\[6\]\[29\] _1395_ _1468_ _0464_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2116_ mem\[6\]\[2\] _1397_ _1468_ _0465_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2117_ mem\[6\]\[30\] _1399_ _1468_ _0466_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2118_ mem\[6\]\[31\] _1401_ _1468_ _0467_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2119_ mem\[6\]\[3\] _1403_ _1468_ _0468_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2120_ mem\[6\]\[4\] _1405_ _1468_ _0469_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2121_ mem\[6\]\[5\] _1407_ _1468_ _0470_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2122_ mem\[6\]\[6\] _1409_ _1468_ _0471_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2123_ mem\[6\]\[7\] _1411_ _1468_ _0472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2124_ mem\[6\]\[8\] _1413_ _1468_ _0473_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2125_ mem\[6\]\[9\] _1415_ _1468_ _0474_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2126_ net175 _1343_ _1424_ _1459_ _1472_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput104 net104 ext_rd_data[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2128_ mem\[7\]\[0\] _1339_ _1472_ _0475_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2129_ mem\[7\]\[10\] _1351_ _1472_ _0476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2130_ mem\[7\]\[11\] _1353_ _1472_ _0477_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2131_ mem\[7\]\[12\] _1355_ _1472_ _0478_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2132_ mem\[7\]\[13\] _1357_ _1472_ _0479_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2133_ mem\[7\]\[14\] _1359_ _1472_ _0480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2134_ mem\[7\]\[15\] _1361_ _1472_ _0481_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2135_ mem\[7\]\[16\] _1363_ _1472_ _0482_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2136_ mem\[7\]\[17\] _1365_ _1472_ _0483_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2137_ mem\[7\]\[18\] _1367_ _1472_ _0484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput103 net103 ext_rd_data[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2139_ mem\[7\]\[19\] _1370_ _1472_ _0485_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2140_ mem\[7\]\[1\] _1373_ _1472_ _0486_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2141_ mem\[7\]\[20\] _1375_ _1472_ _0487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2142_ mem\[7\]\[21\] _1377_ _1472_ _0488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2143_ mem\[7\]\[22\] _1379_ _1472_ _0489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2144_ mem\[7\]\[23\] _1381_ _1472_ _0490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2145_ mem\[7\]\[24\] _1383_ _1472_ _0491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2146_ mem\[7\]\[25\] _1385_ _1472_ _0492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2147_ mem\[7\]\[26\] _1387_ _1472_ _0493_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2148_ mem\[7\]\[27\] _1389_ _1472_ _0494_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput102 net102 ext_rd_data[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2150_ mem\[7\]\[28\] _1392_ _1472_ _0495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2151_ mem\[7\]\[29\] _1395_ _1472_ _0496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2152_ mem\[7\]\[2\] _1397_ _1472_ _0497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2153_ mem\[7\]\[30\] _1399_ _1472_ _0498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2154_ mem\[7\]\[31\] _1401_ _1472_ _0499_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2155_ mem\[7\]\[3\] _1403_ _1472_ _0500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2156_ mem\[7\]\[4\] _1405_ _1472_ _0501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2157_ mem\[7\]\[5\] _1407_ _1472_ _0502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2158_ mem\[7\]\[6\] _1409_ _1472_ _0503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2159_ mem\[7\]\[7\] _1411_ _1472_ _0504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2160_ mem\[7\]\[8\] _1413_ _1472_ _0505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2161_ mem\[7\]\[9\] _1415_ _1472_ _0506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2162_ net175 _1343_ _1345_ _1419_ _1476_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput101 net101 ext_rd_data[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2164_ mem\[8\]\[0\] _1339_ _1476_ _0507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2165_ mem\[8\]\[10\] _1351_ _1476_ _0508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2166_ mem\[8\]\[11\] _1353_ _1476_ _0509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2167_ mem\[8\]\[12\] _1355_ _1476_ _0510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2168_ mem\[8\]\[13\] _1357_ _1476_ _0511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2169_ mem\[8\]\[14\] _1359_ _1476_ _0512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2170_ mem\[8\]\[15\] _1361_ _1476_ _0513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2171_ mem\[8\]\[16\] _1363_ _1476_ _0514_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2172_ mem\[8\]\[17\] _1365_ _1476_ _0515_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2173_ mem\[8\]\[18\] _1367_ _1476_ _0516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput100 net100 ext_rd_data[31] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2175_ mem\[8\]\[19\] _1370_ _1476_ _0517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2176_ mem\[8\]\[1\] _1373_ _1476_ _0518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2177_ mem\[8\]\[20\] _1375_ _1476_ _0519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2178_ mem\[8\]\[21\] _1377_ _1476_ _0520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2179_ mem\[8\]\[22\] _1379_ _1476_ _0521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2180_ mem\[8\]\[23\] _1381_ _1476_ _0522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2181_ mem\[8\]\[24\] _1383_ _1476_ _0523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2182_ mem\[8\]\[25\] _1385_ _1476_ _0524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2183_ mem\[8\]\[26\] _1387_ _1476_ _0525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2184_ mem\[8\]\[27\] _1389_ _1476_ _0526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput99 net99 ext_rd_data[30] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2186_ mem\[8\]\[28\] _1392_ _1476_ _0527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2187_ mem\[8\]\[29\] _1395_ _1476_ _0528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2188_ mem\[8\]\[2\] _1397_ _1476_ _0529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2189_ mem\[8\]\[30\] _1399_ _1476_ _0530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2190_ mem\[8\]\[31\] _1401_ _1476_ _0531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2191_ mem\[8\]\[3\] _1403_ _1476_ _0532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2192_ mem\[8\]\[4\] _1405_ _1476_ _0533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2193_ mem\[8\]\[5\] _1407_ _1476_ _0534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2194_ mem\[8\]\[6\] _1409_ _1476_ _0535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2195_ mem\[8\]\[7\] _1411_ _1476_ _0536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2196_ mem\[8\]\[8\] _1413_ _1476_ _0537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2197_ mem\[8\]\[9\] _1415_ _1476_ _0538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2198_ net175 _1343_ _1419_ _1434_ _1480_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_4
Xoutput98 net98 ext_rd_data[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2200_ mem\[9\]\[0\] _1339_ _1480_ _0539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2201_ mem\[9\]\[10\] _1351_ _1480_ _0540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2202_ mem\[9\]\[11\] _1353_ _1480_ _0541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2203_ mem\[9\]\[12\] _1355_ _1480_ _0542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2204_ mem\[9\]\[13\] _1357_ _1480_ _0543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2205_ mem\[9\]\[14\] _1359_ _1480_ _0544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2206_ mem\[9\]\[15\] _1361_ _1480_ _0545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2207_ mem\[9\]\[16\] _1363_ _1480_ _0546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2208_ mem\[9\]\[17\] _1365_ _1480_ _0547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2209_ mem\[9\]\[18\] _1367_ _1480_ _0548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput97 net97 ext_rd_data[29] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2211_ mem\[9\]\[19\] _1370_ _1480_ _0549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2212_ mem\[9\]\[1\] _1373_ _1480_ _0550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2213_ mem\[9\]\[20\] _1375_ _1480_ _0551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2214_ mem\[9\]\[21\] _1377_ _1480_ _0552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2215_ mem\[9\]\[22\] _1379_ _1480_ _0553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2216_ mem\[9\]\[23\] _1381_ _1480_ _0554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2217_ mem\[9\]\[24\] _1383_ _1480_ _0555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2218_ mem\[9\]\[25\] _1385_ _1480_ _0556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2219_ mem\[9\]\[26\] _1387_ _1480_ _0557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2220_ mem\[9\]\[27\] _1389_ _1480_ _0558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xoutput96 net96 ext_rd_data[28] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2222_ mem\[9\]\[28\] _1392_ _1480_ _0559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2223_ mem\[9\]\[29\] _1395_ _1480_ _0560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2224_ mem\[9\]\[2\] _1397_ _1480_ _0561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2225_ mem\[9\]\[30\] _1399_ _1480_ _0562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2226_ mem\[9\]\[31\] _1401_ _1480_ _0563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2227_ mem\[9\]\[3\] _1403_ _1480_ _0564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2228_ mem\[9\]\[4\] _1405_ _1480_ _0565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2229_ mem\[9\]\[5\] _1407_ _1480_ _0566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2230_ mem\[9\]\[6\] _1409_ _1480_ _0567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2231_ mem\[9\]\[7\] _1411_ _1480_ _0568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2232_ mem\[9\]\[8\] _1413_ _1480_ _0569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2233_ mem\[9\]\[9\] _1415_ _1480_ _0570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2234_ _0628_ _0615_ _0629_ _0645_ _1484_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_4
Xoutput95 net95 ext_rd_data[27] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput94 net94 ext_rd_data[26] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2237_ net38 _1487_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2238_ net36 net35 _1488_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2239_ net181 _0642_ net37 _1488_ _1489_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2240_ _1487_ _0621_ _0627_ _1489_ _1490_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2241_ _0615_ _0629_ _1491_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2242_ net38 _0617_ _1489_ _1492_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2243_ net108 net174 _1490_ _1491_ _1492_ _1493_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2244_ _0719_ net163 _1493_ _0571_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xoutput93 net93 ext_rd_data[25] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2246_ net109 net174 _1495_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2247_ _0753_ net163 _1495_ _0572_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2248_ net110 net174 _1496_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2249_ _0780_ net163 _1496_ _0573_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2250_ net111 net174 _1497_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2251_ _0805_ net163 _1497_ _0574_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2252_ net112 net174 _1498_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2253_ _0833_ net163 _1498_ _0575_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xoutput92 net92 ext_rd_data[24] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2255_ net113 net174 _1500_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2256_ _0852_ _0853_ net163 _1500_ _0576_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2257_ net114 net174 _1501_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2258_ _0873_ net163 _1501_ _0577_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2259_ net115 net174 _1502_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2260_ _0892_ net163 _1502_ _0578_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2261_ net116 net174 _1503_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2262_ _0911_ net163 _1503_ _0579_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2263_ _0615_ _0629_ _1504_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2264_ _0628_ _1504_ _0645_ _0927_ _1505_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2265_ net117 net174 _1506_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2266_ _1505_ _1506_ _0580_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2267_ net118 net174 _1507_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2268_ _0944_ net163 _1507_ _0581_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2269_ _1487_ net75 _1489_ _1508_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2270_ net38 _0003_ _1489_ _1509_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2271_ _0965_ net163 _1510_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2272_ net119 net174 _1511_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2273_ _1508_ _1509_ _1510_ _1511_ _0582_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2274_ net120 net174 _1512_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2275_ _0986_ _0987_ net163 _1512_ _0583_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2276_ net121 net174 _1513_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2277_ _1010_ net163 _1513_ _0584_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
Xoutput91 net91 ext_rd_data[23] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput90 net90 ext_rd_data[22] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2280_ net122 net174 _1516_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2281_ _1027_ net163 _1516_ _0585_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2282_ net123 net174 _1517_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2283_ _1043_ net163 _1517_ _0586_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2284_ net124 net174 _1518_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2285_ _1064_ net163 _1518_ _0587_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2286_ net125 net174 _1519_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2287_ _1082_ net163 _1519_ _0588_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2288_ net126 net174 _1520_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2289_ _1102_ net163 _1520_ _0589_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2290_ net127 net174 _1521_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2291_ _1122_ net163 _1521_ _0590_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2292_ net128 net174 _1522_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2293_ _1139_ net163 _1522_ _0591_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2294_ net129 net174 _1523_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2295_ _1160_ net163 _1523_ _0592_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2296_ _1489_ _1524_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2297_ _0003_ _0006_ _1525_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_2298_ net38 _0618_ _1524_ _1525_ _1526_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2299_ net38 _1489_ _1527_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2300_ net130 net174 _1527_ _0618_ _1528_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2301_ _1179_ net163 _1526_ _1504_ _1528_ _0593_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_2302_ net131 net174 _1529_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2303_ _1199_ net163 _1529_ _0594_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2304_ mem\[0\]\[31\] net164 _1211_ _1530_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2305_ net132 net174 _1531_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2306_ _1530_ net163 _1531_ _0595_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2307_ _0620_ _0621_ _1487_ _1532_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2308_ _1487_ _0615_ _0629_ _1532_ _1533_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2309_ net133 net174 _1534_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2310_ _1230_ net163 _1533_ _1524_ _1534_ _0596_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_2311_ net134 net174 _1527_ _0615_ _1535_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2312_ _1244_ net163 _1535_ _0597_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2313_ net135 net174 _1536_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2314_ _1265_ net163 _1536_ _0598_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2315_ net136 net174 _1537_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2316_ _1281_ net163 _1537_ _0599_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2317_ net137 net174 _1538_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2318_ _1300_ net163 _1538_ _0600_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2319_ net138 net174 _1539_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2320_ _1321_ net163 _1539_ _0601_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2321_ net139 net174 _1540_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2322_ _1337_ net163 _1540_ _0602_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2323_ rd_ptr\[0\] _0646_ _1541_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_2324_ net175 _1541_ _0603_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2325_ _0017_ rd_ptr\[1\] _0646_ _1542_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2326_ net175 _1542_ _0604_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2327_ _0972_ _0646_ rd_ptr\[2\] _1543_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2328_ rd_ptr\[2\] _0972_ _0646_ _1544_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2329_ _1543_ _1544_ _0649_ _0605_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2330_ net178 net175 _1545_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2331_ net176 net175 _1546_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2332_ net177 _0015_ _0000_ _0646_ _1547_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_2333_ _1545_ _1546_ _1547_ _0606_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2334_ rd_ptr\[4\] net175 _1548_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2335_ rd_ptr\[4\] _0649_ _1549_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2336_ _0972_ _0646_ _0723_ _1550_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_2337_ _1548_ _1549_ _1550_ _0607_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2338_ _0004_ _1343_ _1551_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_2339_ net175 _1551_ _0608_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2340_ wr_ptr\[1\] _0023_ _1343_ _1552_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2341_ net175 _1552_ _0609_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2342_ wr_ptr\[2\] net175 _1553_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2343_ _1347_ net175 _1554_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2344_ _0026_ _1343_ _1555_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2345_ _1553_ _1554_ _1555_ _0610_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2346_ _1346_ net175 _1556_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2347_ wr_ptr\[3\] net175 _1557_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2348_ wr_ptr\[4\] rd_ptr\[4\] _0614_ _1558_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor3_2
X_2349_ _0639_ _1341_ _1559_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2350_ _0628_ _1558_ _0629_ _1559_ net34 _1560_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2351_ _1347_ _0004_ _0021_ _1560_ _1561_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2352_ _1556_ _1557_ _1561_ _0611_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2353_ _0026_ _1429_ _1562_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2354_ _1560_ _1562_ wr_ptr\[4\] _1563_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2355_ wr_ptr\[4\] _1560_ _1562_ _1564_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2356_ _1563_ _1564_ _0649_ _0612_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2357_ _0011_ _0014_ _0002_ _0613_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_4
X_2358_ _0014_ _0010_ _0013_ _0613_ _0614_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_4
X_2359_ wr_ptr\[4\] rd_ptr\[4\] _0614_ _0615_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor3_2
Xoutput89 net89 ext_rd_data[21] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2361_ _0006_ _0617_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2362_ _0011_ _0002_ _0618_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_4
X_2363_ _0014_ _0003_ _0617_ _0618_ _0619_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_2364_ _0003_ _0620_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2365_ _0011_ _0002_ _0621_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_2366_ _0014_ _0620_ _0006_ _0621_ _0622_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2367_ _0011_ _0008_ _0623_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2368_ _0011_ _0007_ _0010_ _0624_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2369_ _0005_ _0623_ _0624_ _0625_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2370_ _0619_ _0622_ _0625_ _0626_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2371_ _0615_ _0626_ net75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2372_ _0620_ _0006_ _0627_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2373_ _0621_ _0627_ _0628_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2374_ _0014_ _0625_ _0629_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_2375_ _0628_ _0615_ _0629_ net74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_2376_ _0005_ _0001_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2377_ rd_ptr\[2\] _0630_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xoutput88 net88 ext_rd_data[20] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput87 net87 ext_rd_data[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput86 net86 ext_rd_data[19] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2381_ rd_ptr\[3\] _0633_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xoutput85 net85 ext_rd_data[18] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput84 net84 ext_rd_data[17] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput83 net83 ext_rd_data[16] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2385_ rd_ptr\[0\] _0015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2386_ wr_ptr\[0\] _0004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2387_ rd_ptr\[1\] _0000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2388_ wr_ptr\[1\] _0021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2389_ net76 _0636_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2390_ net36 net35 net37 _0637_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_2391_ net40 net51 _0638_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2392_ net181 net72 _0639_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2393_ net38 _0637_ _0638_ _0639_ _0640_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
Xoutput82 net82 ext_rd_data[15] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2395_ net72 _0642_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2396_ net181 _0642_ _0643_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2397_ net36 net35 net37 net38 _0644_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2398_ _0643_ _0644_ _0645_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2399_ _0628_ _0615_ _0629_ _0645_ net1 _0646_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_4
X_2400_ net175 _0646_ _0647_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xoutput81 net81 ext_rd_data[14] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2402_ net38 _0637_ _0638_ _0639_ _0649_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2403_ _0649_ _0646_ _0650_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xoutput80 net80 ext_rd_data[13] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput79 net79 ext_rd_data[12] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput78 net78 ext_rd_data[11] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput77 net77 ext_rd_data[10] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput76 net76 ext_rd_data[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput75 net75 ext_full VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput74 net74 ext_empty VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput73 net182 net73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xinput72 mem_write net72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2413_ net178 mem\[10\]\[0\] net168 _0660_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput71 mem_wdata[9] net71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput70 mem_wdata[8] net70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput69 mem_wdata[7] net69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput68 mem_wdata[6] net68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2418_ net176 mem\[1\]\[0\] net166 _0665_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2419_ _0660_ _0665_ _0666_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xinput67 mem_wdata[5] net67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput66 mem_wdata[4] net66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2422_ mem\[13\]\[0\] net166 _0669_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput65 mem_wdata[3] net65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2424_ mem\[8\]\[0\] net170 _0671_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput64 mem_wdata[31] net64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2426_ _0669_ _0671_ net177 _0673_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput63 mem_wdata[30] net63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput62 mem_wdata[2] net62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2429_ rd_ptr\[3\] net179 _0676_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xinput61 mem_wdata[29] net61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2431_ net172 mem\[3\]\[0\] net173 _0678_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2432_ net178 _0673_ _0678_ _0679_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2433_ _0020_ _0018_ _0019_ _0680_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
Xinput60 mem_wdata[28] net60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2435_ rd_ptr\[3\] net179 _0016_ _0682_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2436_ _0680_ _0682_ _0683_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_4
Xinput59 mem_wdata[27] net59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2438_ rd_ptr\[2\] _0666_ _0679_ net164 _0685_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xinput58 mem_wdata[26] net58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput57 mem_wdata[25] net57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput56 mem_wdata[24] net56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput55 mem_wdata[23] net55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2443_ net172 mem\[7\]\[0\] mem\[5\]\[0\] net166 _0690_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xinput54 mem_wdata[22] net54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput53 mem_wdata[21] net53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput52 mem_wdata[20] net52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput51 mem_wdata[1] net51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput50 mem_wdata[19] net50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2449_ net172 mem\[15\]\[0\] mem\[14\]\[0\] net168 _0696_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xinput49 mem_wdata[18] net49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput48 mem_wdata[17] net48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2452_ mem\[12\]\[0\] net170 _0699_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2453_ net178 _0696_ _0699_ _0700_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2454_ net176 _0690_ _0700_ net177 _0701_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xinput47 mem_wdata[16] net47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput46 mem_wdata[15] net46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput45 mem_wdata[14] net45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2458_ mem\[4\]\[0\] net170 net168 mem\[6\]\[0\] _0705_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xinput44 mem_wdata[13] net44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2460_ _0633_ net179 _0707_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput43 mem_wdata[12] net43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput42 mem_wdata[11] net42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput41 mem_wdata[10] net41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2464_ net172 mem\[11\]\[0\] mem\[9\]\[0\] net166 _0711_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2465_ rd_ptr\[3\] net177 _0712_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2466_ _0711_ _0712_ _0713_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
Xinput40 mem_wdata[0] net40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2468_ net168 net173 _0715_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2469_ mem\[2\]\[0\] _0715_ _0716_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2470_ _0705_ _0707_ _0713_ _0716_ _0717_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
Xinput39 mem_valid net39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2472_ _0685_ _0701_ _0717_ net164 mem\[0\]\[0\] _0719_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2473_ _0636_ _0647_ _0650_ _0719_ _0027_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2474_ net77 _0720_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput38 mem_addr[3] net38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput37 mem_addr[2] net37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2477_ rd_ptr\[3\] net179 _0723_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
Xinput36 mem_addr[1] net36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput35 mem_addr[0] net35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput34 ext_wr_en net34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2481_ mem\[14\]\[10\] net167 net166 mem\[13\]\[10\] _0727_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2482_ _0723_ _0727_ _0728_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
Xinput33 ext_wr_data[9] net33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2484_ net176 net179 net171 mem\[7\]\[10\] _0730_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2485_ mem\[2\]\[10\] _0715_ _0728_ _0730_ _0731_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
Xinput32 ext_wr_data[8] net32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2487_ mem\[12\]\[10\] net169 _0733_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2488_ mem\[5\]\[10\] net166 _0734_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2489_ _0733_ _0734_ net176 _0735_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput31 ext_wr_data[7] net31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput30 ext_wr_data[6] net30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2492_ mem\[3\]\[10\] mem\[11\]\[10\] rd_ptr\[3\] _0738_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput29 ext_wr_data[5] net29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2494_ rd_ptr\[3\] mem\[10\]\[10\] net167 _0740_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2495_ net171 _0738_ _0740_ _0741_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
Xinput28 ext_wr_data[4] net28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2497_ _0735_ _0741_ net177 _0743_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2498_ net171 mem\[15\]\[10\] _0744_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2499_ mem\[8\]\[10\] net169 net166 mem\[9\]\[10\] _0745_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2500_ _0744_ _0745_ net177 _0746_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2501_ mem\[1\]\[10\] net166 _0747_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2502_ mem\[4\]\[10\] net169 net167 mem\[6\]\[10\] _0748_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2503_ _0747_ _0748_ net179 _0749_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput27 ext_wr_data[3] net27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2505_ _0746_ _0749_ net176 _0751_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2506_ net164 _0731_ _0743_ _0751_ _0752_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_2507_ mem\[0\]\[10\] net164 _0752_ _0753_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2508_ _0720_ _0647_ _0650_ _0753_ _0028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xinput26 ext_wr_data[31] net26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2510_ _0680_ _0682_ _0755_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput25 ext_wr_data[30] net25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput24 ext_wr_data[2] net24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput23 ext_wr_data[29] net23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2514_ mem\[9\]\[11\] mem\[13\]\[11\] net179 _0759_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2515_ rd_ptr\[3\] net166 _0759_ _0760_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2516_ _0755_ _0760_ _0761_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2517_ rd_ptr\[3\] _0630_ mem\[10\]\[11\] net168 _0762_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
Xinput22 ext_wr_data[28] net22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2519_ _0633_ net179 _0764_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2520_ mem\[4\]\[11\] net170 _0764_ _0765_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2521_ mem\[5\]\[11\] net166 _0764_ _0766_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2522_ rd_ptr\[3\] net179 _0767_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput21 ext_wr_data[27] net21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2524_ net172 mem\[15\]\[11\] _0767_ _0769_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2525_ _0762_ _0765_ _0766_ _0769_ _0770_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2526_ net172 mem\[11\]\[11\] mem\[8\]\[11\] net170 _0771_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2527_ net172 mem\[3\]\[11\] mem\[2\]\[11\] net168 net166
+ mem\[1\]\[11\] _0772_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2528_ _0771_ _0772_ _0633_ _0773_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
Xinput20 ext_wr_data[26] net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput19 ext_wr_data[25] net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput18 ext_wr_data[24] net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2532_ mem\[12\]\[11\] net170 net168 mem\[14\]\[11\] _0777_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2533_ net172 mem\[7\]\[11\] mem\[6\]\[11\] net168 _0707_
+ _0778_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2534_ _0630_ _0773_ _0777_ _0767_ _0778_ _0779_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2535_ _0761_ _0770_ _0779_ _0683_ mem\[0\]\[11\] _0780_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
Xinput17 ext_wr_data[23] net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2537_ net78 net175 _0646_ _0782_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2538_ _0649_ _0646_ _0780_ _0782_ _0029_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2539_ net79 _0783_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput16 ext_wr_data[22] net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2541_ net167 _0785_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2542_ mem\[2\]\[12\] _0676_ _0767_ mem\[14\]\[12\] _0786_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2543_ net172 mem\[11\]\[12\] mem\[10\]\[12\] net168 _0787_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xinput15 ext_wr_data[21] net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput14 ext_wr_data[20] net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2546_ mem\[8\]\[12\] net170 net166 mem\[9\]\[12\] net179
+ _0790_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2547_ net172 mem\[15\]\[12\] mem\[13\]\[12\] net166 _0791_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2548_ mem\[12\]\[12\] net170 _0792_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2549_ net179 _0791_ _0792_ _0793_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2550_ _0633_ _0790_ _0793_ _0794_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2551_ _0785_ _0786_ _0787_ _0712_ _0794_ _0795_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
Xinput13 ext_wr_data[1] net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput12 ext_wr_data[19] net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput11 ext_wr_data[18] net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2555_ net171 mem\[3\]\[12\] mem\[1\]\[12\] net166 net179
+ _0799_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2556_ net172 mem\[7\]\[12\] mem\[5\]\[12\] net166 _0800_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2557_ mem\[4\]\[12\] net170 net168 mem\[6\]\[12\] _0801_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2558_ net179 _0800_ _0801_ _0802_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput10 ext_wr_data[17] net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2560_ rd_ptr\[3\] _0799_ _0802_ _0683_ _0804_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2561_ mem\[0\]\[12\] _0683_ _0795_ _0804_ _0805_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2562_ _0783_ _0647_ _0650_ _0805_ _0030_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2563_ net80 _0806_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2564_ mem\[0\]\[13\] _0807_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2565_ net179 net171 _0808_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2566_ mem\[7\]\[13\] _0808_ _0809_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput9 ext_wr_data[16] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2568_ net177 mem\[2\]\[13\] net167 _0811_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
Xinput8 ext_wr_data[15] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2570_ net171 mem\[11\]\[13\] mem\[8\]\[13\] net169 _0813_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2571_ net179 mem\[12\]\[13\] net169 _0814_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2572_ net179 _0813_ _0814_ net178 _0815_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2573_ net178 _0809_ _0811_ _0815_ _0816_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2574_ net171 mem\[15\]\[13\] _0817_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2575_ mem\[10\]\[13\] net167 _0818_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2576_ mem\[4\]\[13\] net169 _0819_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2577_ net171 mem\[3\]\[13\] _0820_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2578_ _0817_ _0818_ _0819_ _0820_ net177 net176 _0821_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
Xinput7 ext_wr_data[14] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2580_ mem\[6\]\[13\] net167 net166 mem\[5\]\[13\] _0823_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2581_ _0823_ _0824_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2582_ net167 _0767_ _0825_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2583_ _0764_ _0824_ _0825_ mem\[14\]\[13\] _0826_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2584_ mem\[9\]\[13\] mem\[13\]\[13\] net179 _0827_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2585_ net178 _0827_ _0828_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
Xinput6 ext_wr_data[13] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2587_ net176 net177 mem\[1\]\[13\] _0830_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2588_ _0828_ _0830_ net166 _0831_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2589_ _0816_ _0821_ _0826_ _0831_ _0832_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2590_ _0807_ _0832_ net164 _0833_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2591_ _0806_ _0647_ _0650_ _0833_ _0031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
Xinput5 ext_wr_data[12] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 ext_wr_data[11] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2594_ net177 mem\[2\]\[14\] _0836_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2595_ mem\[10\]\[14\] mem\[14\]\[14\] net179 _0837_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2596_ _0633_ _0837_ _0838_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2597_ _0633_ _0836_ _0838_ _0785_ _0839_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2598_ mem\[6\]\[14\] net167 net166 mem\[5\]\[14\] _0840_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2599_ net171 mem\[3\]\[14\] mem\[1\]\[14\] net166 _0841_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
Xinput3 ext_wr_data[10] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2601_ _0840_ _0841_ net177 _0843_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2602_ rd_ptr\[3\] _0843_ _0683_ _0844_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2603_ net171 mem\[7\]\[14\] mem\[4\]\[14\] net170 _0845_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2604_ mem\[12\]\[14\] net170 net166 mem\[13\]\[14\] _0846_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2605_ _0707_ _0845_ _0846_ _0723_ _0847_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2606_ net171 mem\[15\]\[14\] _0848_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2607_ net171 mem\[11\]\[14\] mem\[8\]\[14\] net169 _0849_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2608_ mem\[9\]\[14\] net166 net179 _0850_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2609_ net179 _0848_ _0849_ _0850_ _0633_ _0851_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2610_ _0839_ _0844_ _0847_ _0851_ _0852_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_2611_ mem\[0\]\[14\] _0683_ _0853_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2612_ _0646_ _0852_ _0853_ _0854_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2613_ net81 _0646_ _0855_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2614_ _0854_ _0855_ _0649_ _0032_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2615_ net82 _0856_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2616_ _0633_ net177 _0857_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2617_ net172 mem\[3\]\[15\] mem\[2\]\[15\] net168 _0858_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2618_ mem\[4\]\[15\] net170 net166 mem\[5\]\[15\] _0859_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2619_ net178 net177 _0860_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2620_ mem\[6\]\[15\] _0764_ _0860_ mem\[10\]\[15\] _0861_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2621_ _0857_ _0858_ _0859_ _0707_ _0861_ _0785_ _0862_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai222_2
X_2622_ mem\[8\]\[15\] net170 net166 mem\[9\]\[15\] _0863_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2623_ net172 mem\[15\]\[15\] mem\[14\]\[15\] net168 _0864_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2624_ mem\[12\]\[15\] net170 _0630_ _0865_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2625_ _0630_ _0863_ _0864_ _0865_ _0633_ _0866_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2626_ net172 mem\[7\]\[15\] _0867_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2627_ mem\[1\]\[15\] net166 _0868_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2628_ mem\[13\]\[15\] net166 _0869_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2629_ net172 mem\[11\]\[15\] _0870_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2630_ _0867_ _0868_ _0869_ _0870_ net177 rd_ptr\[3\] _0871_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2631_ _0683_ _0871_ _0872_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2632_ _0862_ _0866_ _0872_ _0683_ mem\[0\]\[15\] _0873_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2633_ _0856_ _0647_ _0650_ _0873_ _0033_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2634_ net83 _0874_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2635_ _0630_ _0020_ _0875_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2636_ net179 mem\[14\]\[16\] net168 _0876_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2637_ mem\[11\]\[16\] _0875_ _0876_ _0877_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2638_ mem\[1\]\[16\] net173 _0767_ mem\[13\]\[16\] _0878_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2639_ net166 _0879_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2640_ _0633_ _0877_ _0878_ _0879_ _0880_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2641_ mem\[2\]\[16\] _0715_ _0881_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2642_ mem\[10\]\[16\] net168 net165 mem\[9\]\[16\] _0882_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2643_ net172 mem\[7\]\[16\] mem\[5\]\[16\] net165 _0883_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2644_ _0712_ _0882_ _0883_ _0707_ _0884_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2645_ _0755_ _0881_ _0884_ _0885_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2646_ net172 mem\[15\]\[16\] mem\[12\]\[16\] net170 _0886_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2647_ mem\[4\]\[16\] net170 net168 mem\[6\]\[16\] _0887_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2648_ mem\[8\]\[16\] net170 _0888_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2649_ net172 mem\[3\]\[16\] _0889_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2650_ _0886_ _0887_ _0888_ _0889_ _0633_ _0630_ _0890_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2651_ _0890_ _0891_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2652_ _0880_ _0885_ _0891_ _0683_ mem\[0\]\[16\] _0892_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2653_ _0874_ _0647_ _0650_ _0892_ _0034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2654_ net84 _0893_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2655_ mem\[11\]\[17\] mem\[15\]\[17\] net179 _0894_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2656_ _0630_ mem\[9\]\[17\] net166 _0895_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2657_ net172 _0894_ _0895_ _0633_ _0896_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2658_ _0630_ mem\[10\]\[17\] net168 _0897_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2659_ net179 mem\[12\]\[17\] net170 _0898_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2660_ _0897_ _0898_ _0899_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2661_ net172 mem\[7\]\[17\] mem\[6\]\[17\] net168 net166
+ mem\[5\]\[17\] _0900_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2662_ _0630_ _0900_ _0901_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2663_ mem\[3\]\[17\] _0875_ _0901_ rd_ptr\[3\] _0902_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2664_ _0896_ _0899_ _0902_ _0903_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2665_ mem\[14\]\[17\] net167 _0904_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2666_ mem\[4\]\[17\] net169 _0905_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2667_ mem\[8\]\[17\] net169 _0906_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2668_ mem\[2\]\[17\] net167 _0907_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2669_ _0904_ _0905_ _0906_ _0907_ _0633_ net177 _0908_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2670_ mem\[1\]\[17\] _0676_ _0767_ mem\[13\]\[17\] _0909_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2671_ _0879_ _0909_ _0683_ _0910_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2672_ _0903_ _0908_ _0910_ _0683_ mem\[0\]\[17\] _0911_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2673_ _0893_ _0647_ _0650_ _0911_ _0035_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2674_ mem\[0\]\[18\] _0912_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2675_ mem\[14\]\[18\] net167 net166 mem\[13\]\[18\] mem\[12\]\[18\]
+ net169 _0913_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2676_ net179 _0913_ _0914_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2677_ mem\[10\]\[18\] net167 net166 mem\[9\]\[18\] mem\[8\]\[18\]
+ net169 _0915_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2678_ net177 _0915_ _0633_ _0916_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2679_ net171 mem\[7\]\[18\] mem\[4\]\[18\] net169 _0917_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2680_ net171 mem\[3\]\[18\] mem\[2\]\[18\] net167 net179
+ _0918_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2681_ net179 _0917_ _0918_ rd_ptr\[3\] _0919_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2682_ _0914_ _0916_ _0919_ _0920_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2683_ mem\[6\]\[18\] net167 net166 mem\[5\]\[18\] _0921_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2684_ rd_ptr\[3\] net177 _0921_ _0922_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2685_ mem\[11\]\[18\] mem\[15\]\[18\] net179 _0923_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2686_ rd_ptr\[3\] net172 _0923_ _0924_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2687_ mem\[1\]\[18\] net166 net173 _0925_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2688_ _0683_ _0922_ _0924_ _0925_ _0926_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2689_ _0912_ _0755_ _0920_ _0926_ _0927_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2690_ _0927_ net85 _0646_ _0928_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2691_ net175 _0928_ _0036_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2692_ net86 _0929_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2693_ mem\[8\]\[19\] net169 _0930_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2694_ net171 mem\[3\]\[19\] _0931_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2695_ mem\[13\]\[19\] _0019_ _0932_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2696_ mem\[4\]\[19\] net169 net167 mem\[6\]\[19\] _0933_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2697_ _0930_ _0931_ _0932_ _0933_ net176 net179 _0934_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2698_ mem\[7\]\[19\] mem\[15\]\[19\] net178 _0935_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2699_ mem\[14\]\[19\] _0825_ _0935_ _0808_ _0936_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2700_ net176 _0019_ _0937_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2701_ mem\[1\]\[19\] mem\[5\]\[19\] net179 _0938_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2702_ net171 mem\[11\]\[19\] mem\[10\]\[19\] net167 _0019_
+ mem\[9\]\[19\] _0939_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2703_ net179 mem\[12\]\[19\] net169 _0940_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2704_ net179 _0939_ _0940_ _0941_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2705_ mem\[2\]\[19\] _0715_ _0937_ _0938_ _0941_ net178
+ _0942_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2706_ net164 _0934_ _0936_ _0942_ _0943_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand4_2
X_2707_ mem\[0\]\[19\] net164 _0943_ _0944_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2708_ _0929_ _0647_ _0650_ _0944_ _0037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2709_ net87 _0945_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2710_ rd_ptr\[2\] net168 _0946_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2711_ net178 mem\[14\]\[1\] _0946_ _0947_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2712_ net176 net177 mem\[1\]\[1\] _0019_ _0948_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2713_ _0947_ _0948_ _0949_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2714_ mem\[4\]\[1\] net169 _0019_ mem\[5\]\[1\] _0950_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2715_ net171 mem\[7\]\[1\] mem\[6\]\[1\] net167 _0951_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2716_ _0950_ _0951_ _0952_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2717_ net171 mem\[3\]\[1\] _0953_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2718_ net171 mem\[15\]\[1\] _0954_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2719_ net171 mem\[11\]\[1\] mem\[10\]\[1\] net167 _0955_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2720_ _0955_ _0956_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2721_ _0952_ _0953_ _0954_ _0956_ net177 net178 _0957_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2722_ mem\[8\]\[1\] mem\[12\]\[1\] rd_ptr\[2\] _0958_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2723_ net178 net170 _0958_ _0959_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2724_ mem\[9\]\[1\] mem\[13\]\[1\] rd_ptr\[2\] _0960_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2725_ net178 _0019_ _0960_ _0961_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2726_ mem\[2\]\[1\] net167 net173 _0962_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2727_ _0755_ _0959_ _0961_ _0962_ _0963_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2728_ mem\[0\]\[1\] net164 _0964_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2729_ _0949_ _0957_ _0963_ _0964_ _0965_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2730_ _0945_ _0647_ _0650_ _0965_ _0038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2731_ mem\[4\]\[20\] net169 _0019_ mem\[5\]\[20\] _0966_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2732_ net177 _0966_ _0967_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2733_ net177 net171 mem\[3\]\[20\] _0968_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2734_ mem\[12\]\[20\] net169 _0969_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2735_ mem\[10\]\[20\] net167 _0970_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2736_ _0969_ _0970_ net177 _0971_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2737_ net171 _0972_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2738_ mem\[11\]\[20\] _0973_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2739_ rd_ptr\[2\] _0972_ _0973_ net178 _0974_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2740_ net178 _0967_ _0968_ _0971_ _0974_ _0975_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2741_ mem\[8\]\[20\] net169 _0976_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2742_ mem\[2\]\[20\] net167 _0977_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2743_ mem\[14\]\[20\] net167 _0978_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2744_ net171 mem\[7\]\[20\] mem\[6\]\[20\] net167 _0979_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2745_ _0976_ _0977_ _0978_ _0979_ net176 rd_ptr\[2\] _0980_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2746_ mem\[9\]\[20\] mem\[13\]\[20\] rd_ptr\[2\] _0981_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2747_ mem\[1\]\[20\] net173 _0981_ net178 _0982_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2748_ _0879_ _0982_ _0983_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2749_ net172 _0767_ _0984_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2750_ mem\[15\]\[20\] _0984_ _0755_ _0985_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2751_ _0975_ _0980_ _0983_ _0985_ _0986_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2752_ mem\[0\]\[20\] net164 _0987_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2753_ _0646_ _0986_ _0987_ _0988_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2754_ net88 _0646_ _0989_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2755_ _0988_ _0989_ _0649_ _0039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2756_ net89 _0990_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput2 ext_wr_data[0] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2758_ mem\[12\]\[21\] net169 _0019_ mem\[13\]\[21\] _0992_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2759_ net177 _0992_ _0993_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2760_ net177 mem\[10\]\[21\] net167 _0994_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2761_ _0993_ _0994_ net176 _0995_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2762_ mem\[2\]\[21\] net167 _0019_ mem\[1\]\[21\] _0996_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2763_ mem\[8\]\[21\] net170 _0019_ mem\[9\]\[21\] _0997_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2764_ net178 net171 mem\[15\]\[21\] _0998_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2765_ net176 mem\[5\]\[21\] _0019_ _0999_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2766_ net177 _0998_ _0999_ _1000_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_2767_ net173 _0996_ _0997_ _0860_ _1000_ _1001_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2768_ mem\[3\]\[21\] mem\[7\]\[21\] rd_ptr\[2\] _1002_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2769_ net176 _1002_ _1003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2770_ net178 net177 mem\[11\]\[21\] _1004_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2771_ _1003_ _1004_ net171 _1005_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2772_ mem\[4\]\[21\] net170 _1006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2773_ mem\[6\]\[21\] mem\[14\]\[21\] net178 _1007_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2774_ _0764_ _1006_ _1007_ _0946_ _1008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2775_ net164 _1005_ _1008_ _1009_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2776_ _0995_ _1001_ _1009_ net164 mem\[0\]\[21\] _1010_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2777_ _0990_ _0647_ _0650_ _1010_ _0040_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2778_ net90 _1011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
Xinput1 ext_rd_en net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
X_2780_ net171 mem\[11\]\[22\] mem\[8\]\[22\] net170 _1013_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2781_ mem\[14\]\[22\] _0825_ _1014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2782_ _0712_ _1013_ _1014_ _1015_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2783_ net172 mem\[7\]\[22\] mem\[4\]\[22\] net170 _1016_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2784_ net172 mem\[3\]\[22\] mem\[2\]\[22\] net168 _1017_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2785_ mem\[15\]\[22\] _0984_ _1018_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2786_ _0707_ _1016_ _1017_ _0857_ _1018_ _1019_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_2787_ mem\[12\]\[22\] net170 net166 mem\[13\]\[22\] _0723_
+ _1020_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2788_ mem\[10\]\[22\] net167 net166 mem\[9\]\[22\] _0712_
+ _1021_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2789_ net177 _0019_ _1022_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2790_ mem\[6\]\[22\] net167 net166 mem\[5\]\[22\] _1023_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2791_ net177 _1023_ _1024_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2792_ mem\[1\]\[22\] _1022_ _1024_ rd_ptr\[3\] _1025_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2793_ _1020_ _1021_ _1025_ net164 _1026_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2794_ _1015_ _1019_ _1026_ net164 mem\[0\]\[22\] _1027_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2795_ _1011_ _0647_ _0650_ _1027_ _0041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2796_ net91 _1028_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2797_ mem\[2\]\[23\] mem\[6\]\[23\] rd_ptr\[2\] _1029_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2798_ mem\[3\]\[23\] mem\[7\]\[23\] rd_ptr\[2\] _1030_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2799_ net167 _1029_ _1030_ net171 _1031_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2800_ mem\[14\]\[23\] net167 _0019_ mem\[13\]\[23\] _1032_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2801_ mem\[8\]\[23\] net169 net167 mem\[10\]\[23\] _1033_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2802_ _1032_ _1033_ net177 _1034_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2803_ net171 mem\[15\]\[23\] mem\[12\]\[23\] net169 _1035_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2804_ net171 mem\[11\]\[23\] mem\[9\]\[23\] _0019_ _1036_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2805_ _1035_ _1036_ net177 _1037_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2806_ net178 _1034_ _1037_ _1038_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2807_ net176 _1031_ _1038_ _1039_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2808_ mem\[4\]\[23\] net169 _0019_ mem\[5\]\[23\] _1040_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2809_ net176 mem\[1\]\[23\] _1022_ _1041_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2810_ _0707_ _1040_ _1041_ net164 _1042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2811_ mem\[0\]\[23\] net164 _1039_ _1042_ _1043_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2812_ _1028_ _0647_ _0650_ _1043_ _0042_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2813_ net92 _1044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2814_ net178 mem\[8\]\[24\] net169 _1045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2815_ mem\[10\]\[24\] net167 _0019_ mem\[9\]\[24\] _1046_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2816_ net176 _1046_ _1047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2817_ mem\[1\]\[24\] _0937_ _1045_ _1047_ _1048_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2818_ net178 mem\[12\]\[24\] net169 _1049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2819_ net176 net171 mem\[7\]\[24\] _1050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2820_ net171 mem\[15\]\[24\] mem\[13\]\[24\] _0019_ _1051_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2821_ mem\[6\]\[24\] net167 _1052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2822_ _1051_ _1052_ net176 _1053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2823_ rd_ptr\[2\] _1049_ _1050_ _1053_ _1054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2824_ net177 _1048_ _1054_ _1055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2825_ mem\[14\]\[24\] net167 _1056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2826_ net171 mem\[11\]\[24\] _1057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2827_ _1056_ _1057_ net177 _1058_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2828_ net171 mem\[3\]\[24\] mem\[2\]\[24\] net167 _1059_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2829_ mem\[4\]\[24\] net169 _0019_ mem\[5\]\[24\] _1060_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2830_ _1059_ _1060_ rd_ptr\[2\] _1061_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2831_ _1058_ _1061_ net176 _1062_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2832_ net164 _1062_ _1063_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2833_ mem\[0\]\[24\] net164 _1055_ _1063_ _1064_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2834_ _1044_ _0647_ _0650_ _1064_ _0043_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2835_ net93 _1065_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2836_ mem\[13\]\[25\] _0019_ _1066_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2837_ net171 mem\[7\]\[25\] _1067_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2838_ net171 mem\[11\]\[25\] mem\[8\]\[25\] net169 _1068_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2839_ mem\[1\]\[25\] _0019_ _1069_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2840_ _1066_ _1067_ _1068_ _1069_ net176 net177 _1070_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2841_ net171 mem\[15\]\[25\] _1071_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2842_ mem\[4\]\[25\] net169 _1072_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2843_ mem\[10\]\[25\] net167 _1073_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2844_ net171 mem\[3\]\[25\] mem\[2\]\[25\] net167 _1074_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2845_ _1071_ _1072_ _1073_ _1074_ net176 net177 _1075_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_2846_ _1070_ _1075_ _1076_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2847_ mem\[9\]\[25\] _0019_ _1077_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2848_ mem\[12\]\[25\] net169 net167 mem\[14\]\[25\] _1078_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2849_ _1077_ _1078_ rd_ptr\[2\] _1079_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2850_ mem\[6\]\[25\] net167 _0019_ mem\[5\]\[25\] _1080_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2851_ net176 _1079_ _1080_ _0707_ net164 _1081_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_2852_ mem\[0\]\[25\] net164 _1076_ _1081_ _1082_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2853_ _1065_ _0647_ _0650_ _1082_ _0044_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2854_ net94 _1083_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2855_ mem\[6\]\[26\] _0764_ _0860_ mem\[10\]\[26\] _1084_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2856_ mem\[13\]\[26\] net166 _1085_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2857_ net172 mem\[11\]\[26\] _1086_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2858_ _1085_ _1086_ net177 _1087_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2859_ _0633_ net179 mem\[4\]\[26\] net170 _1088_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2860_ rd_ptr\[3\] _1087_ _1088_ _0755_ _1089_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2861_ _0785_ _1084_ _1089_ _1090_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2862_ net177 mem\[8\]\[26\] net170 _1091_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2863_ mem\[15\]\[26\] _0808_ _1091_ net176 _1092_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2864_ net179 mem\[5\]\[26\] net166 _1093_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2865_ mem\[3\]\[26\] _0875_ _1093_ rd_ptr\[3\] _1094_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2866_ mem\[12\]\[26\] net170 net168 mem\[14\]\[26\] _1095_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2867_ _1095_ _1096_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2868_ mem\[1\]\[26\] mem\[9\]\[26\] rd_ptr\[3\] _1097_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2869_ _0767_ _1096_ _1097_ _1022_ _1098_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2870_ net172 mem\[7\]\[26\] _1099_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2871_ mem\[2\]\[26\] _0715_ _0764_ _1099_ _1100_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2872_ _1092_ _1094_ _1098_ _1100_ _1101_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2873_ mem\[0\]\[26\] net164 _1090_ _1101_ _1102_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2874_ _1083_ _0647_ _0650_ _1102_ _0045_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2875_ net95 _1103_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2876_ net171 mem\[7\]\[27\] mem\[5\]\[27\] _0019_ _1104_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2877_ net177 _1104_ _1105_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2878_ mem\[14\]\[27\] net167 _0019_ mem\[13\]\[27\] _0723_
+ _1106_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2879_ mem\[10\]\[27\] net167 _0019_ mem\[9\]\[27\] rd_ptr\[2\]
+ _1107_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2880_ _1106_ _1107_ _1108_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2881_ mem\[15\]\[27\] _0808_ _1109_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2882_ net176 _1105_ _1108_ _1109_ _1110_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2883_ rd_ptr\[2\] mem\[4\]\[27\] net169 _1111_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2884_ net177 mem\[1\]\[27\] _0019_ _1112_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2885_ _1111_ _1112_ _1113_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2886_ mem\[12\]\[27\] net169 _1114_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2887_ mem\[6\]\[27\] net167 _1115_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2888_ _1114_ _1115_ net176 _1116_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2889_ net171 mem\[3\]\[27\] mem\[2\]\[27\] net167 _1117_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2890_ net171 mem\[11\]\[27\] mem\[8\]\[27\] net169 _1118_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2891_ _1117_ _1118_ net178 _1119_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2892_ _1116_ _1119_ net177 _1120_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2893_ net178 _1113_ _1120_ net164 _1121_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2894_ mem\[0\]\[27\] net164 _1110_ _1121_ _1122_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2895_ _1103_ _0647_ _0650_ _1122_ _0046_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2896_ net96 _1123_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2897_ mem\[12\]\[28\] _0016_ net165 mem\[13\]\[28\] _1124_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2898_ net172 mem\[11\]\[28\] mem\[8\]\[28\] _0016_ _1125_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2899_ mem\[10\]\[28\] net168 _0712_ _1126_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2900_ net179 mem\[4\]\[28\] _0016_ _1127_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2901_ mem\[3\]\[28\] _0875_ _1127_ rd_ptr\[3\] _1128_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2902_ _0767_ _1124_ _1125_ _1126_ _1128_ _1129_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2903_ net172 mem\[7\]\[28\] mem\[5\]\[28\] net165 _1130_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2904_ mem\[14\]\[28\] net168 net176 _1131_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2905_ net176 _1130_ _1131_ _0630_ _1132_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2906_ mem\[15\]\[28\] _0984_ _1133_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2907_ mem\[2\]\[28\] mem\[6\]\[28\] net179 _1134_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2908_ net176 net168 _1134_ _1135_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2909_ mem\[1\]\[28\] mem\[9\]\[28\] net178 _1136_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2910_ _1022_ _1136_ _1137_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2911_ _0755_ _1133_ _1135_ _1137_ _1138_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2912_ _1129_ _1132_ _1138_ _0683_ mem\[0\]\[28\] _1139_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_2913_ _1123_ _0647_ _0650_ _1139_ _0047_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2914_ net97 _1140_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2915_ net172 mem\[15\]\[29\] mem\[13\]\[29\] net166 _1141_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2916_ _0630_ _1141_ _1142_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_2917_ mem\[11\]\[29\] _0875_ _1022_ mem\[9\]\[29\] _1142_
+ _1143_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2918_ _0630_ mem\[2\]\[29\] net168 _1144_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2919_ mem\[1\]\[29\] _1022_ _1144_ rd_ptr\[3\] _1145_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2920_ rd_ptr\[3\] _1143_ _1145_ _1146_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2921_ net170 _1147_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2922_ mem\[4\]\[29\] _0764_ _0860_ mem\[8\]\[29\] _1148_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2923_ net172 mem\[3\]\[29\] net179 _1149_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2924_ net172 mem\[7\]\[29\] mem\[5\]\[29\] net165 _1150_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2925_ mem\[6\]\[29\] net168 _1151_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2926_ net179 _1150_ _1151_ _1152_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2927_ rd_ptr\[3\] _1149_ _1152_ _1153_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_2928_ mem\[12\]\[29\] net170 net168 mem\[14\]\[29\] _1154_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2929_ _1154_ _1155_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2930_ mem\[10\]\[29\] net168 _1156_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2931_ _0767_ _1155_ _1156_ _0860_ _1157_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2932_ _1147_ _1148_ _1153_ _1157_ _1158_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2933_ mem\[0\]\[29\] _0683_ _1159_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_2934_ _0755_ _1146_ _1158_ _1159_ _1160_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2935_ _1140_ _0647_ _0650_ _1160_ _0048_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2936_ net98 _1161_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2937_ net177 mem\[9\]\[2\] net165 _1162_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2938_ mem\[15\]\[2\] _0808_ _1162_ net176 _1163_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_2939_ mem\[6\]\[2\] _0946_ net178 _1164_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2940_ mem\[12\]\[2\] _0016_ _0018_ mem\[14\]\[2\] _1165_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2941_ mem\[13\]\[2\] net165 _1166_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2942_ _0767_ _1165_ _1166_ _1167_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2943_ _0020_ mem\[7\]\[2\] mem\[4\]\[2\] _0016_ _1168_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2944_ mem\[5\]\[2\] net165 _1169_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2945_ net176 rd_ptr\[2\] _1168_ _1169_ _1170_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2946_ _0020_ mem\[11\]\[2\] mem\[10\]\[2\] _0018_ _1171_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2947_ mem\[8\]\[2\] _0016_ _1172_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2948_ net178 _0630_ _1171_ _1172_ _1173_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_2949_ net172 mem\[3\]\[2\] mem\[1\]\[2\] net165 _1174_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2950_ mem\[2\]\[2\] net168 _1175_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2951_ net173 _1174_ _1175_ _1176_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2952_ _1167_ _1170_ _1173_ _1176_ _1177_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2953_ _1163_ _1164_ _0683_ _1177_ _1178_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2954_ mem\[0\]\[2\] _0683_ _1178_ _1179_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2955_ _1161_ _0647_ _0650_ _1179_ _0049_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2956_ net99 _1180_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2957_ net172 mem\[11\]\[30\] mem\[10\]\[30\] net168 _1181_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2958_ mem\[2\]\[30\] mem\[6\]\[30\] net179 _1182_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2959_ net176 net168 _1182_ _1183_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2960_ _0712_ _1181_ _1183_ _1184_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2961_ net178 mem\[9\]\[30\] _1022_ _1185_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2962_ net176 mem\[7\]\[30\] _0808_ _1186_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2963_ mem\[8\]\[30\] _0016_ _1187_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2964_ _0020_ mem\[3\]\[30\] _1188_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2965_ _1187_ _1188_ net176 _1189_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2966_ _0020_ mem\[15\]\[30\] mem\[14\]\[30\] _0018_ _1190_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2967_ mem\[12\]\[30\] _0016_ net165 mem\[13\]\[30\] _1191_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2968_ _1190_ _1191_ _1192_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_2969_ net179 _1189_ _1192_ _0723_ _1193_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2970_ _1184_ _1185_ _1186_ _1193_ _1194_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_2971_ mem\[4\]\[30\] _0016_ net165 mem\[5\]\[30\] _1195_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2972_ mem\[1\]\[30\] net165 _1196_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2973_ _1195_ _1196_ _0630_ _1197_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2974_ net178 _1197_ _0683_ _1198_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2975_ mem\[0\]\[30\] _0683_ _1194_ _1198_ _1199_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2976_ _1180_ _0647_ _0650_ _1199_ _0050_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_2977_ mem\[14\]\[31\] _0018_ net165 mem\[13\]\[31\] mem\[12\]\[31\]
+ _0016_ _1200_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2978_ mem\[10\]\[31\] _0018_ net165 mem\[9\]\[31\] mem\[8\]\[31\]
+ _0016_ _1201_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_2979_ _1200_ _1201_ _0630_ _1202_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2980_ _0020_ mem\[3\]\[31\] mem\[1\]\[31\] net165 _1203_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2981_ _0630_ _1203_ net178 _1204_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2982_ _0020_ mem\[7\]\[31\] mem\[6\]\[31\] _0018_ _1205_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2983_ mem\[4\]\[31\] _0016_ net165 mem\[5\]\[31\] _1206_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_2984_ net179 _1205_ _1206_ _1207_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2985_ mem\[11\]\[31\] mem\[15\]\[31\] rd_ptr\[2\] _1208_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2986_ net178 _0020_ _1208_ _1209_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_2987_ mem\[2\]\[31\] _0715_ _1204_ _1207_ _1209_ _1210_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2988_ net176 _1202_ _1210_ _0683_ _1211_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2989_ mem\[0\]\[31\] net164 _1211_ net175 _1212_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_2990_ net100 net175 _0646_ _1213_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_2991_ _0646_ _1212_ _1213_ _0051_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_2992_ net101 _1214_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_2993_ _0020_ mem\[7\]\[3\] mem\[4\]\[3\] _0016_ net178 _1215_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_2994_ mem\[12\]\[3\] _0016_ net176 _1216_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2995_ mem\[1\]\[3\] mem\[5\]\[3\] rd_ptr\[2\] _1217_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_2996_ _0937_ _1217_ _0755_ _1218_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_2997_ net177 _1215_ _1216_ _1218_ _1219_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_2998_ mem\[6\]\[3\] _0018_ _1220_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_2999_ _0020_ mem\[3\]\[3\] mem\[2\]\[3\] _0018_ rd_ptr\[2\]
+ _1221_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_3000_ rd_ptr\[2\] _1220_ _1221_ _1222_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_3001_ _0020_ mem\[11\]\[3\] mem\[9\]\[3\] net165 _1223_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3002_ rd_ptr\[2\] mem\[13\]\[3\] net165 _1224_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_3003_ mem\[10\]\[3\] mem\[14\]\[3\] rd_ptr\[2\] _1225_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3004_ mem\[8\]\[3\] _0016_ _1226_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3005_ mem\[15\]\[3\] _0808_ _1225_ _0018_ _1226_ net177
+ _1227_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_3006_ rd_ptr\[2\] _1223_ _1224_ _1227_ _1228_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_3007_ _1222_ _1228_ net178 _1229_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3008_ mem\[0\]\[3\] net164 _1219_ _1229_ _1230_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3009_ _1214_ _0647_ _0650_ _1230_ _0052_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3010_ _0020_ mem\[11\]\[4\] mem\[10\]\[4\] _0018_ net165
+ mem\[9\]\[4\] _1231_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_3011_ _0712_ _1231_ _1232_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_3012_ net178 rd_ptr\[2\] mem\[12\]\[4\] _0016_ _1233_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_3013_ net176 mem\[3\]\[4\] _0875_ _1234_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3014_ mem\[1\]\[4\] mem\[5\]\[4\] rd_ptr\[2\] _1235_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3015_ _0937_ _1235_ _1236_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3016_ _0755_ _1233_ _1234_ _1236_ _1237_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_3017_ _0020_ mem\[7\]\[4\] mem\[4\]\[4\] _0016_ _0018_ mem\[6\]\[4\]
+ _1238_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_3018_ _0020_ mem\[15\]\[4\] mem\[14\]\[4\] _0018_ net165
+ mem\[13\]\[4\] _1239_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_3019_ mem\[2\]\[4\] _0018_ _1240_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3020_ mem\[8\]\[4\] _0016_ _1241_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3021_ _1238_ _1239_ _1240_ _1241_ net178 _0630_ _1242_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_3022_ _1242_ _1243_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3023_ _1232_ _1237_ _1243_ _0683_ mem\[0\]\[4\] _1244_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_3024_ net1 _0645_ _1245_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor2_2
X_3025_ net74 _1245_ net175 net102 _1246_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_3026_ _0650_ _1244_ _1246_ _0053_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai21_2
X_3027_ mem\[0\]\[5\] _0683_ _1247_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_3028_ mem\[2\]\[5\] net168 net173 _1248_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3029_ mem\[4\]\[5\] net170 _0764_ _1249_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3030_ mem\[10\]\[5\] net168 net165 mem\[9\]\[5\] mem\[8\]\[5\]
+ net170 _1250_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi222_2
X_3031_ mem\[5\]\[5\] net165 _1251_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3032_ _0712_ _1250_ _1251_ _0707_ _0683_ _1252_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
X_3033_ mem\[6\]\[5\] net168 _1253_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3034_ mem\[1\]\[5\] net166 _1254_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3035_ rd_ptr\[3\] net172 mem\[11\]\[5\] _1255_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3036_ _0633_ _1254_ _1255_ net179 _1256_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_3037_ mem\[12\]\[5\] net170 net165 mem\[13\]\[5\] _1257_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3038_ mem\[14\]\[5\] net168 _1258_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3039_ _0767_ _1257_ _1258_ _1259_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3040_ _0764_ _1253_ _1256_ _1259_ _1260_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_3041_ _1248_ _1249_ _1252_ _1260_ _1261_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_3042_ mem\[3\]\[5\] mem\[7\]\[5\] net179 _1262_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3043_ net179 mem\[15\]\[5\] _1263_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3044_ _1262_ _1263_ rd_ptr\[3\] _1264_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3045_ _1247_ _1261_ _1264_ net172 _1265_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3046_ net103 net175 _0646_ _1266_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_3047_ _0649_ _0646_ _1265_ _1266_ _0054_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai31_2
X_3048_ net104 _1267_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3049_ net172 mem\[15\]\[6\] mem\[13\]\[6\] net165 _1268_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3050_ mem\[12\]\[6\] _0016_ _0723_ _1269_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_3051_ mem\[4\]\[6\] _0016_ net165 mem\[5\]\[6\] _1270_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3052_ net172 mem\[7\]\[6\] mem\[6\]\[6\] net168 _1271_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3053_ _1270_ _1271_ _1272_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3054_ mem\[3\]\[6\] _0875_ _1272_ net179 _1273_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3055_ net172 mem\[11\]\[6\] mem\[9\]\[6\] net165 _1274_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3056_ mem\[8\]\[6\] _0016_ net168 mem\[10\]\[6\] _1275_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3057_ _0860_ _1274_ _1275_ _1276_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3058_ _1268_ _1269_ _1273_ net176 _1276_ _1277_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_3059_ mem\[2\]\[6\] net173 _0767_ mem\[14\]\[6\] _1278_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3060_ mem\[1\]\[6\] net165 net173 _1279_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_3061_ _0785_ _1278_ _1279_ _0683_ _1280_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_3062_ mem\[0\]\[6\] _0683_ _1277_ _1280_ _1281_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3063_ _1267_ _0647_ _0650_ _1281_ _0055_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3064_ net105 _1282_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3065_ mem\[0\]\[7\] _1283_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3066_ _0020_ mem\[11\]\[7\] mem\[10\]\[7\] _0018_ _1284_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3067_ _0020_ mem\[3\]\[7\] mem\[1\]\[7\] net165 _1285_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3068_ mem\[4\]\[7\] _0016_ _1286_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3069_ _1285_ _1286_ net179 _1287_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3070_ mem\[12\]\[7\] _0016_ _0018_ mem\[14\]\[7\] _1288_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3071_ mem\[13\]\[7\] net165 _1289_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3072_ _0767_ _1288_ _1289_ _1290_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3073_ _0860_ _1284_ _1287_ net176 _1290_ _1291_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_3074_ mem\[2\]\[7\] _0715_ _1292_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3075_ mem\[8\]\[7\] _0016_ net165 mem\[9\]\[7\] _1293_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3076_ _0020_ mem\[7\]\[7\] _1294_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3077_ _0712_ _1293_ _1294_ _0707_ _1295_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3078_ mem\[6\]\[7\] _0018_ net165 mem\[5\]\[7\] _1296_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3079_ _0020_ mem\[15\]\[7\] net176 _1297_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_3080_ net176 _1296_ _1297_ _0630_ _1298_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_3081_ _1291_ _1292_ _1295_ _1298_ _1299_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor4_2
X_3082_ _1283_ _1299_ _0683_ _1300_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3083_ _1282_ _0647_ _0650_ _1300_ _0056_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3084_ net106 _1301_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3085_ _0020_ mem\[7\]\[8\] mem\[6\]\[8\] _0018_ _1302_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3086_ net178 net177 _1302_ _1303_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nor3_2
X_3087_ _0020_ mem\[11\]\[8\] mem\[8\]\[8\] _0016_ _1304_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3088_ rd_ptr\[2\] _1304_ _1305_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or2_2
X_3089_ mem\[15\]\[8\] _0808_ _1306_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3090_ _1305_ _1306_ net176 _1307_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_3091_ mem\[9\]\[8\] mem\[13\]\[8\] rd_ptr\[2\] _1308_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3092_ mem\[1\]\[8\] net173 _1308_ net178 _1309_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3093_ mem\[12\]\[8\] net169 _1310_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3094_ mem\[10\]\[8\] net168 _1311_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3095_ mem\[5\]\[8\] _0019_ _1312_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3096_ net172 mem\[3\]\[8\] _1313_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_3097_ _1310_ _1311_ _1312_ _1313_ net177 net176 _1314_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux4_2
X_3098_ mem\[14\]\[8\] net168 _1315_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3099_ mem\[4\]\[8\] net170 _1316_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_3100_ _1315_ _1316_ net176 _1317_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3101_ net176 net177 mem\[2\]\[8\] net168 _1318_ VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
X_3102_ rd_ptr\[2\] _1317_ _1318_ _0755_ _1319_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_3103_ _0879_ _1309_ _1314_ _1319_ _1320_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_3104_ _1303_ _1307_ _1320_ net164 mem\[0\]\[8\] _1321_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__oai32_2
X_3105_ _1301_ _0647_ _0650_ _1321_ _0057_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai22_2
X_3106_ net107 _1322_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_3107_ mem\[9\]\[9\] mem\[13\]\[9\] rd_ptr\[2\] _1323_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_3108_ rd_ptr\[2\] mem\[12\]\[9\] _0016_ _1324_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3109_ mem\[11\]\[9\] _0875_ _1323_ net165 _1324_ _1325_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_3110_ _0020_ mem\[15\]\[9\] mem\[14\]\[9\] _0018_ net176
+ _1326_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi221_2
X_3111_ mem\[4\]\[9\] _0016_ net165 mem\[5\]\[9\] _1327_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3112_ _0020_ mem\[7\]\[9\] mem\[6\]\[9\] _0018_ _1328_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3113_ net176 _1327_ _1328_ _1329_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and3_2
X_3114_ _0630_ _1326_ _1329_ _1330_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_3115_ mem\[8\]\[9\] _0016_ _0018_ mem\[10\]\[9\] _1331_
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3116_ _0020_ mem\[3\]\[9\] mem\[1\]\[9\] net165 _1332_ VDD
+ VSS gf180mcu_fd_sc_mcu9t5v0__aoi22_2
X_3117_ mem\[2\]\[9\] _0018_ net178 _1333_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi21_2
X_3118_ _0000_ wr_ptr\[1\] _0001_ _0002_ _0003_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addf_1
X_3119_ rd_ptr\[0\] _0004_ _0005_ _0006_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3120_ _0000_ wr_ptr\[1\] _0007_ _0008_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3121_ _0630_ wr_ptr\[2\] _0010_ _0011_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3122_ _0633_ wr_ptr\[3\] _0013_ _0014_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3123_ _0015_ _0000_ _0016_ _0017_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_3124_ _0015_ rd_ptr\[1\] _0018_ _1565_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_3125_ rd_ptr\[0\] _0000_ _0019_ _1566_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_3126_ rd_ptr\[0\] rd_ptr\[1\] _0020_ _1567_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_4
X_3127_ _0004_ _0021_ _0022_ _0023_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3128_ _0004_ wr_ptr\[1\] _0024_ _1568_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3129_ wr_ptr\[0\] _0021_ _0025_ _1569_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
X_3130_ wr_ptr\[0\] wr_ptr\[1\] _0026_ _1570_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_1
Xext_data_reg\[0\]$_DFFE_PN0P_ _0027_ net180 clknet_leaf_13_clk
+ net76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[10\]$_DFFE_PN0P_ _0028_ net180 clknet_leaf_10_clk
+ net77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[11\]$_DFFE_PN0P_ _0029_ net180 clknet_leaf_13_clk
+ net78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[12\]$_DFFE_PN0P_ _0030_ net180 clknet_leaf_10_clk
+ net79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[13\]$_DFFE_PN0P_ _0031_ net180 clknet_leaf_10_clk
+ net80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[14\]$_DFFE_PN0P_ _0032_ net180 clknet_leaf_13_clk
+ net81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[15\]$_DFFE_PN0P_ _0033_ net180 clknet_leaf_11_clk
+ net82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[16\]$_DFFE_PN0P_ _0034_ net180 clknet_leaf_11_clk
+ net83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[17\]$_DFFE_PN0P_ _0035_ net180 clknet_leaf_10_clk
+ net84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[18\]$_DFFE_PN0P_ _0036_ net180 clknet_leaf_14_clk
+ net85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[19\]$_DFFE_PN0P_ _0037_ net180 clknet_leaf_10_clk
+ net86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[1\]$_DFFE_PN0P_ _0038_ net180 clknet_leaf_14_clk
+ net87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[20\]$_DFFE_PN0P_ _0039_ net180 clknet_leaf_13_clk
+ net88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[21\]$_DFFE_PN0P_ _0040_ net180 clknet_leaf_11_clk
+ net89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[22\]$_DFFE_PN0P_ _0041_ net180 clknet_leaf_11_clk
+ net90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[23\]$_DFFE_PN0P_ _0042_ net180 clknet_leaf_10_clk
+ net91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[24\]$_DFFE_PN0P_ _0043_ net180 clknet_leaf_10_clk
+ net92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[25\]$_DFFE_PN0P_ _0044_ net180 clknet_leaf_10_clk
+ net93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[26\]$_DFFE_PN0P_ _0045_ net180 clknet_leaf_11_clk
+ net94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[27\]$_DFFE_PN0P_ _0046_ net180 clknet_leaf_11_clk
+ net95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[28\]$_DFFE_PN0P_ _0047_ net180 clknet_leaf_14_clk
+ net96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[29\]$_DFFE_PN0P_ _0048_ net180 clknet_leaf_14_clk
+ net97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[2\]$_DFFE_PN0P_ _0049_ net180 clknet_leaf_14_clk
+ net98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[30\]$_DFFE_PN0P_ _0050_ net180 clknet_leaf_14_clk
+ net99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[31\]$_DFFE_PN0P_ _0051_ net180 clknet_leaf_14_clk
+ net100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[3\]$_DFFE_PN0P_ _0052_ net180 clknet_leaf_14_clk
+ net101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[4\]$_DFFE_PN0P_ _0053_ net180 clknet_leaf_14_clk
+ net102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[5\]$_DFFE_PN0P_ _0054_ net180 clknet_leaf_14_clk
+ net103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[6\]$_DFFE_PN0P_ _0055_ net180 clknet_leaf_14_clk
+ net104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[7\]$_DFFE_PN0P_ _0056_ net180 clknet_leaf_14_clk
+ net105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[8\]$_DFFE_PN0P_ _0057_ net180 clknet_leaf_14_clk
+ net106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xext_data_reg\[9\]$_DFFE_PN0P_ _0058_ net73 clknet_leaf_14_clk
+ net107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem\[0\]\[0\]$_DFFE_PP_ _0059_ clknet_leaf_12_clk mem\[0\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[10\]$_DFFE_PP_ _0060_ clknet_leaf_5_clk mem\[0\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[11\]$_DFFE_PP_ _0061_ clknet_leaf_2_clk mem\[0\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[12\]$_DFFE_PP_ _0062_ clknet_leaf_4_clk mem\[0\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[13\]$_DFFE_PP_ _0063_ clknet_leaf_8_clk mem\[0\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[14\]$_DFFE_PP_ _0064_ clknet_leaf_2_clk mem\[0\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[15\]$_DFFE_PP_ _0065_ clknet_leaf_6_clk mem\[0\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[16\]$_DFFE_PP_ _0066_ clknet_leaf_2_clk mem\[0\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[17\]$_DFFE_PP_ _0067_ clknet_leaf_4_clk mem\[0\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[18\]$_DFFE_PP_ _0068_ clknet_leaf_6_clk mem\[0\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[19\]$_DFFE_PP_ _0069_ clknet_leaf_8_clk mem\[0\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[1\]$_DFFE_PP_ _0070_ clknet_leaf_13_clk mem\[0\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[20\]$_DFFE_PP_ _0071_ clknet_leaf_13_clk mem\[0\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[21\]$_DFFE_PP_ _0072_ clknet_leaf_12_clk mem\[0\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[22\]$_DFFE_PP_ _0073_ clknet_leaf_7_clk mem\[0\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[23\]$_DFFE_PP_ _0074_ clknet_leaf_10_clk mem\[0\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[24\]$_DFFE_PP_ _0075_ clknet_leaf_10_clk mem\[0\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[25\]$_DFFE_PP_ _0076_ clknet_leaf_10_clk mem\[0\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[26\]$_DFFE_PP_ _0077_ clknet_leaf_12_clk mem\[0\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[27\]$_DFFE_PP_ _0078_ clknet_leaf_11_clk mem\[0\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[28\]$_DFFE_PP_ _0079_ clknet_leaf_1_clk mem\[0\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[29\]$_DFFE_PP_ _0080_ clknet_leaf_1_clk mem\[0\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[2\]$_DFFE_PP_ _0081_ clknet_leaf_17_clk mem\[0\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[30\]$_DFFE_PP_ _0082_ clknet_leaf_17_clk mem\[0\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[31\]$_DFFE_PP_ _0083_ clknet_leaf_16_clk mem\[0\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[3\]$_DFFE_PP_ _0084_ clknet_leaf_15_clk mem\[0\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[4\]$_DFFE_PP_ _0085_ clknet_leaf_16_clk mem\[0\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[5\]$_DFFE_PP_ _0086_ clknet_leaf_1_clk mem\[0\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[6\]$_DFFE_PP_ _0087_ clknet_leaf_1_clk mem\[0\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[7\]$_DFFE_PP_ _0088_ clknet_leaf_19_clk mem\[0\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[8\]$_DFFE_PP_ _0089_ clknet_leaf_13_clk mem\[0\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[0\]\[9\]$_DFFE_PP_ _0090_ clknet_leaf_15_clk mem\[0\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[0\]$_DFFE_PP_ _0091_ clknet_leaf_17_clk mem\[10\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[10\]$_DFFE_PP_ _0092_ clknet_leaf_5_clk mem\[10\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[11\]$_DFFE_PP_ _0093_ clknet_leaf_2_clk mem\[10\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[12\]$_DFFE_PP_ _0094_ clknet_leaf_3_clk mem\[10\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[13\]$_DFFE_PP_ _0095_ clknet_leaf_8_clk mem\[10\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[14\]$_DFFE_PP_ _0096_ clknet_leaf_6_clk mem\[10\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[15\]$_DFFE_PP_ _0097_ clknet_leaf_2_clk mem\[10\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[16\]$_DFFE_PP_ _0098_ clknet_leaf_3_clk mem\[10\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[17\]$_DFFE_PP_ _0099_ clknet_leaf_2_clk mem\[10\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[18\]$_DFFE_PP_ _0100_ clknet_leaf_5_clk mem\[10\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[19\]$_DFFE_PP_ _0101_ clknet_leaf_8_clk mem\[10\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[1\]$_DFFE_PP_ _0102_ clknet_leaf_13_clk mem\[10\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[20\]$_DFFE_PP_ _0103_ clknet_leaf_12_clk mem\[10\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[21\]$_DFFE_PP_ _0104_ clknet_leaf_12_clk mem\[10\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[22\]$_DFFE_PP_ _0105_ clknet_leaf_7_clk mem\[10\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[23\]$_DFFE_PP_ _0106_ clknet_leaf_8_clk mem\[10\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[24\]$_DFFE_PP_ _0107_ clknet_leaf_9_clk mem\[10\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[25\]$_DFFE_PP_ _0108_ clknet_leaf_9_clk mem\[10\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[26\]$_DFFE_PP_ _0109_ clknet_leaf_2_clk mem\[10\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[27\]$_DFFE_PP_ _0110_ clknet_leaf_10_clk mem\[10\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[28\]$_DFFE_PP_ _0111_ clknet_leaf_0_clk mem\[10\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[29\]$_DFFE_PP_ _0112_ clknet_leaf_0_clk mem\[10\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[2\]$_DFFE_PP_ _0113_ clknet_leaf_18_clk mem\[10\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[30\]$_DFFE_PP_ _0114_ clknet_leaf_18_clk mem\[10\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[31\]$_DFFE_PP_ _0115_ clknet_leaf_19_clk mem\[10\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[3\]$_DFFE_PP_ _0116_ clknet_leaf_15_clk mem\[10\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[4\]$_DFFE_PP_ _0117_ clknet_leaf_18_clk mem\[10\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[5\]$_DFFE_PP_ _0118_ clknet_leaf_0_clk mem\[10\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[6\]$_DFFE_PP_ _0119_ clknet_leaf_20_clk mem\[10\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[7\]$_DFFE_PP_ _0120_ clknet_leaf_19_clk mem\[10\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[8\]$_DFFE_PP_ _0121_ clknet_leaf_17_clk mem\[10\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[10\]\[9\]$_DFFE_PP_ _0122_ clknet_leaf_15_clk mem\[10\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[0\]$_DFFE_PP_ _0123_ clknet_leaf_17_clk mem\[11\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[10\]$_DFFE_PP_ _0124_ clknet_leaf_6_clk mem\[11\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[11\]$_DFFE_PP_ _0125_ clknet_leaf_3_clk mem\[11\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[12\]$_DFFE_PP_ _0126_ clknet_leaf_3_clk mem\[11\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[13\]$_DFFE_PP_ _0127_ clknet_leaf_5_clk mem\[11\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[14\]$_DFFE_PP_ _0128_ clknet_leaf_4_clk mem\[11\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[15\]$_DFFE_PP_ _0129_ clknet_leaf_6_clk mem\[11\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[16\]$_DFFE_PP_ _0130_ clknet_leaf_2_clk mem\[11\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[17\]$_DFFE_PP_ _0131_ clknet_leaf_4_clk mem\[11\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[18\]$_DFFE_PP_ _0132_ clknet_leaf_6_clk mem\[11\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[19\]$_DFFE_PP_ _0133_ clknet_leaf_8_clk mem\[11\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[1\]$_DFFE_PP_ _0134_ clknet_leaf_13_clk mem\[11\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[20\]$_DFFE_PP_ _0135_ clknet_leaf_12_clk mem\[11\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[21\]$_DFFE_PP_ _0136_ clknet_leaf_12_clk mem\[11\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[22\]$_DFFE_PP_ _0137_ clknet_leaf_7_clk mem\[11\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[23\]$_DFFE_PP_ _0138_ clknet_leaf_9_clk mem\[11\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[24\]$_DFFE_PP_ _0139_ clknet_leaf_9_clk mem\[11\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[25\]$_DFFE_PP_ _0140_ clknet_leaf_9_clk mem\[11\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[26\]$_DFFE_PP_ _0141_ clknet_leaf_2_clk mem\[11\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[27\]$_DFFE_PP_ _0142_ clknet_leaf_11_clk mem\[11\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[28\]$_DFFE_PP_ _0143_ clknet_leaf_20_clk mem\[11\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[29\]$_DFFE_PP_ _0144_ clknet_leaf_1_clk mem\[11\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[2\]$_DFFE_PP_ _0145_ clknet_leaf_18_clk mem\[11\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[30\]$_DFFE_PP_ _0146_ clknet_leaf_18_clk mem\[11\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[31\]$_DFFE_PP_ _0147_ clknet_leaf_16_clk mem\[11\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[3\]$_DFFE_PP_ _0148_ clknet_leaf_15_clk mem\[11\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[4\]$_DFFE_PP_ _0149_ clknet_leaf_18_clk mem\[11\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[5\]$_DFFE_PP_ _0150_ clknet_leaf_1_clk mem\[11\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[6\]$_DFFE_PP_ _0151_ clknet_leaf_0_clk mem\[11\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[7\]$_DFFE_PP_ _0152_ clknet_leaf_19_clk mem\[11\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[8\]$_DFFE_PP_ _0153_ clknet_leaf_16_clk mem\[11\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[11\]\[9\]$_DFFE_PP_ _0154_ clknet_leaf_15_clk mem\[11\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[0\]$_DFFE_PP_ _0155_ clknet_leaf_17_clk mem\[12\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[10\]$_DFFE_PP_ _0156_ clknet_leaf_6_clk mem\[12\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[11\]$_DFFE_PP_ _0157_ clknet_leaf_3_clk mem\[12\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[12\]$_DFFE_PP_ _0158_ clknet_leaf_4_clk mem\[12\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[13\]$_DFFE_PP_ _0159_ clknet_leaf_5_clk mem\[12\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[14\]$_DFFE_PP_ _0160_ clknet_leaf_4_clk mem\[12\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[15\]$_DFFE_PP_ _0161_ clknet_leaf_2_clk mem\[12\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[16\]$_DFFE_PP_ _0162_ clknet_leaf_0_clk mem\[12\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[17\]$_DFFE_PP_ _0163_ clknet_leaf_3_clk mem\[12\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[18\]$_DFFE_PP_ _0164_ clknet_leaf_5_clk mem\[12\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[19\]$_DFFE_PP_ _0165_ clknet_leaf_8_clk mem\[12\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[1\]$_DFFE_PP_ _0166_ clknet_leaf_12_clk mem\[12\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[20\]$_DFFE_PP_ _0167_ clknet_leaf_12_clk mem\[12\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[21\]$_DFFE_PP_ _0168_ clknet_leaf_12_clk mem\[12\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[22\]$_DFFE_PP_ _0169_ clknet_leaf_7_clk mem\[12\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[23\]$_DFFE_PP_ _0170_ clknet_leaf_9_clk mem\[12\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[24\]$_DFFE_PP_ _0171_ clknet_leaf_10_clk mem\[12\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[25\]$_DFFE_PP_ _0172_ clknet_leaf_9_clk mem\[12\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[26\]$_DFFE_PP_ _0173_ clknet_leaf_12_clk mem\[12\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[27\]$_DFFE_PP_ _0174_ clknet_leaf_10_clk mem\[12\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[28\]$_DFFE_PP_ _0175_ clknet_leaf_0_clk mem\[12\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[29\]$_DFFE_PP_ _0176_ clknet_leaf_0_clk mem\[12\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[2\]$_DFFE_PP_ _0177_ clknet_leaf_19_clk mem\[12\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[30\]$_DFFE_PP_ _0178_ clknet_leaf_19_clk mem\[12\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[31\]$_DFFE_PP_ _0179_ clknet_leaf_19_clk mem\[12\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[3\]$_DFFE_PP_ _0180_ clknet_leaf_15_clk mem\[12\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[4\]$_DFFE_PP_ _0181_ clknet_leaf_16_clk mem\[12\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[5\]$_DFFE_PP_ _0182_ clknet_leaf_0_clk mem\[12\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[6\]$_DFFE_PP_ _0183_ clknet_leaf_19_clk mem\[12\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[7\]$_DFFE_PP_ _0184_ clknet_leaf_20_clk mem\[12\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[8\]$_DFFE_PP_ _0185_ clknet_leaf_13_clk mem\[12\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[12\]\[9\]$_DFFE_PP_ _0186_ clknet_leaf_16_clk mem\[12\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[0\]$_DFFE_PP_ _0187_ clknet_leaf_17_clk mem\[13\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[10\]$_DFFE_PP_ _0188_ clknet_leaf_6_clk mem\[13\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[11\]$_DFFE_PP_ _0189_ clknet_leaf_2_clk mem\[13\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[12\]$_DFFE_PP_ _0190_ clknet_leaf_4_clk mem\[13\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[13\]$_DFFE_PP_ _0191_ clknet_leaf_8_clk mem\[13\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[14\]$_DFFE_PP_ _0192_ clknet_leaf_4_clk mem\[13\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[15\]$_DFFE_PP_ _0193_ clknet_leaf_6_clk mem\[13\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[16\]$_DFFE_PP_ _0194_ clknet_leaf_2_clk mem\[13\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[17\]$_DFFE_PP_ _0195_ clknet_leaf_2_clk mem\[13\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[18\]$_DFFE_PP_ _0196_ clknet_leaf_5_clk mem\[13\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[19\]$_DFFE_PP_ _0197_ clknet_leaf_8_clk mem\[13\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[1\]$_DFFE_PP_ _0198_ clknet_leaf_12_clk mem\[13\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[20\]$_DFFE_PP_ _0199_ clknet_leaf_12_clk mem\[13\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[21\]$_DFFE_PP_ _0200_ clknet_leaf_12_clk mem\[13\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[22\]$_DFFE_PP_ _0201_ clknet_leaf_7_clk mem\[13\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[23\]$_DFFE_PP_ _0202_ clknet_leaf_8_clk mem\[13\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[24\]$_DFFE_PP_ _0203_ clknet_leaf_10_clk mem\[13\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[25\]$_DFFE_PP_ _0204_ clknet_leaf_9_clk mem\[13\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[26\]$_DFFE_PP_ _0205_ clknet_leaf_2_clk mem\[13\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[27\]$_DFFE_PP_ _0206_ clknet_leaf_10_clk mem\[13\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[28\]$_DFFE_PP_ _0207_ clknet_leaf_0_clk mem\[13\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[29\]$_DFFE_PP_ _0208_ clknet_leaf_1_clk mem\[13\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[2\]$_DFFE_PP_ _0209_ clknet_leaf_19_clk mem\[13\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[30\]$_DFFE_PP_ _0210_ clknet_leaf_19_clk mem\[13\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[31\]$_DFFE_PP_ _0211_ clknet_leaf_19_clk mem\[13\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[3\]$_DFFE_PP_ _0212_ clknet_leaf_15_clk mem\[13\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[4\]$_DFFE_PP_ _0213_ clknet_leaf_19_clk mem\[13\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[5\]$_DFFE_PP_ _0214_ clknet_leaf_0_clk mem\[13\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[6\]$_DFFE_PP_ _0215_ clknet_leaf_19_clk mem\[13\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[7\]$_DFFE_PP_ _0216_ clknet_leaf_20_clk mem\[13\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[8\]$_DFFE_PP_ _0217_ clknet_leaf_17_clk mem\[13\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[13\]\[9\]$_DFFE_PP_ _0218_ clknet_leaf_16_clk mem\[13\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[0\]$_DFFE_PP_ _0219_ clknet_leaf_17_clk mem\[14\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[10\]$_DFFE_PP_ _0220_ clknet_leaf_5_clk mem\[14\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[11\]$_DFFE_PP_ _0221_ clknet_leaf_3_clk mem\[14\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[12\]$_DFFE_PP_ _0222_ clknet_leaf_3_clk mem\[14\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[13\]$_DFFE_PP_ _0223_ clknet_leaf_8_clk mem\[14\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[14\]$_DFFE_PP_ _0224_ clknet_leaf_6_clk mem\[14\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[15\]$_DFFE_PP_ _0225_ clknet_leaf_3_clk mem\[14\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[16\]$_DFFE_PP_ _0226_ clknet_leaf_2_clk mem\[14\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[17\]$_DFFE_PP_ _0227_ clknet_leaf_4_clk mem\[14\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[18\]$_DFFE_PP_ _0228_ clknet_leaf_5_clk mem\[14\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[19\]$_DFFE_PP_ _0229_ clknet_leaf_8_clk mem\[14\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[1\]$_DFFE_PP_ _0230_ clknet_leaf_12_clk mem\[14\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[20\]$_DFFE_PP_ _0231_ clknet_leaf_11_clk mem\[14\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[21\]$_DFFE_PP_ _0232_ clknet_leaf_12_clk mem\[14\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[22\]$_DFFE_PP_ _0233_ clknet_leaf_7_clk mem\[14\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[23\]$_DFFE_PP_ _0234_ clknet_leaf_8_clk mem\[14\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[24\]$_DFFE_PP_ _0235_ clknet_leaf_9_clk mem\[14\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[25\]$_DFFE_PP_ _0236_ clknet_leaf_9_clk mem\[14\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[26\]$_DFFE_PP_ _0237_ clknet_leaf_7_clk mem\[14\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[27\]$_DFFE_PP_ _0238_ clknet_leaf_10_clk mem\[14\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[28\]$_DFFE_PP_ _0239_ clknet_leaf_18_clk mem\[14\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[29\]$_DFFE_PP_ _0240_ clknet_leaf_0_clk mem\[14\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[2\]$_DFFE_PP_ _0241_ clknet_leaf_19_clk mem\[14\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[30\]$_DFFE_PP_ _0242_ clknet_leaf_19_clk mem\[14\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[31\]$_DFFE_PP_ _0243_ clknet_leaf_19_clk mem\[14\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[3\]$_DFFE_PP_ _0244_ clknet_leaf_15_clk mem\[14\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[4\]$_DFFE_PP_ _0245_ clknet_leaf_19_clk mem\[14\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[5\]$_DFFE_PP_ _0246_ clknet_leaf_0_clk mem\[14\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[6\]$_DFFE_PP_ _0247_ clknet_leaf_20_clk mem\[14\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[7\]$_DFFE_PP_ _0248_ clknet_leaf_20_clk mem\[14\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[8\]$_DFFE_PP_ _0249_ clknet_leaf_17_clk mem\[14\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[14\]\[9\]$_DFFE_PP_ _0250_ clknet_leaf_16_clk mem\[14\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[0\]$_DFFE_PP_ _0251_ clknet_leaf_17_clk mem\[15\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[10\]$_DFFE_PP_ _0252_ clknet_leaf_5_clk mem\[15\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[11\]$_DFFE_PP_ _0253_ clknet_leaf_3_clk mem\[15\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[12\]$_DFFE_PP_ _0254_ clknet_leaf_4_clk mem\[15\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[13\]$_DFFE_PP_ _0255_ clknet_leaf_8_clk mem\[15\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[14\]$_DFFE_PP_ _0256_ clknet_leaf_5_clk mem\[15\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[15\]$_DFFE_PP_ _0257_ clknet_leaf_3_clk mem\[15\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[16\]$_DFFE_PP_ _0258_ clknet_leaf_1_clk mem\[15\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[17\]$_DFFE_PP_ _0259_ clknet_leaf_4_clk mem\[15\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[18\]$_DFFE_PP_ _0260_ clknet_leaf_6_clk mem\[15\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[19\]$_DFFE_PP_ _0261_ clknet_leaf_8_clk mem\[15\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[1\]$_DFFE_PP_ _0262_ clknet_leaf_13_clk mem\[15\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[20\]$_DFFE_PP_ _0263_ clknet_leaf_12_clk mem\[15\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[21\]$_DFFE_PP_ _0264_ clknet_leaf_7_clk mem\[15\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[22\]$_DFFE_PP_ _0265_ clknet_leaf_6_clk mem\[15\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[23\]$_DFFE_PP_ _0266_ clknet_leaf_9_clk mem\[15\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[24\]$_DFFE_PP_ _0267_ clknet_leaf_10_clk mem\[15\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[25\]$_DFFE_PP_ _0268_ clknet_leaf_9_clk mem\[15\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[26\]$_DFFE_PP_ _0269_ clknet_leaf_7_clk mem\[15\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[27\]$_DFFE_PP_ _0270_ clknet_leaf_11_clk mem\[15\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[28\]$_DFFE_PP_ _0271_ clknet_leaf_17_clk mem\[15\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[29\]$_DFFE_PP_ _0272_ clknet_leaf_1_clk mem\[15\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[2\]$_DFFE_PP_ _0273_ clknet_leaf_18_clk mem\[15\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[30\]$_DFFE_PP_ _0274_ clknet_leaf_19_clk mem\[15\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[31\]$_DFFE_PP_ _0275_ clknet_leaf_18_clk mem\[15\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[3\]$_DFFE_PP_ _0276_ clknet_leaf_15_clk mem\[15\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[4\]$_DFFE_PP_ _0277_ clknet_leaf_19_clk mem\[15\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[5\]$_DFFE_PP_ _0278_ clknet_leaf_1_clk mem\[15\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[6\]$_DFFE_PP_ _0279_ clknet_leaf_20_clk mem\[15\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[7\]$_DFFE_PP_ _0280_ clknet_leaf_19_clk mem\[15\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[8\]$_DFFE_PP_ _0281_ clknet_leaf_16_clk mem\[15\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[15\]\[9\]$_DFFE_PP_ _0282_ clknet_leaf_16_clk mem\[15\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[0\]$_DFFE_PP_ _0283_ clknet_leaf_17_clk mem\[1\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[10\]$_DFFE_PP_ _0284_ clknet_leaf_5_clk mem\[1\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[11\]$_DFFE_PP_ _0285_ clknet_leaf_3_clk mem\[1\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[12\]$_DFFE_PP_ _0286_ clknet_leaf_4_clk mem\[1\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[13\]$_DFFE_PP_ _0287_ clknet_leaf_8_clk mem\[1\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[14\]$_DFFE_PP_ _0288_ clknet_leaf_4_clk mem\[1\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[15\]$_DFFE_PP_ _0289_ clknet_leaf_6_clk mem\[1\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[16\]$_DFFE_PP_ _0290_ clknet_leaf_2_clk mem\[1\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[17\]$_DFFE_PP_ _0291_ clknet_leaf_2_clk mem\[1\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[18\]$_DFFE_PP_ _0292_ clknet_leaf_6_clk mem\[1\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[19\]$_DFFE_PP_ _0293_ clknet_leaf_8_clk mem\[1\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[1\]$_DFFE_PP_ _0294_ clknet_leaf_13_clk mem\[1\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[20\]$_DFFE_PP_ _0295_ clknet_leaf_12_clk mem\[1\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[21\]$_DFFE_PP_ _0296_ clknet_leaf_7_clk mem\[1\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[22\]$_DFFE_PP_ _0297_ clknet_leaf_6_clk mem\[1\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[23\]$_DFFE_PP_ _0298_ clknet_leaf_7_clk mem\[1\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[24\]$_DFFE_PP_ _0299_ clknet_leaf_8_clk mem\[1\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[25\]$_DFFE_PP_ _0300_ clknet_leaf_9_clk mem\[1\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[26\]$_DFFE_PP_ _0301_ clknet_leaf_7_clk mem\[1\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[27\]$_DFFE_PP_ _0302_ clknet_leaf_11_clk mem\[1\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[28\]$_DFFE_PP_ _0303_ clknet_leaf_17_clk mem\[1\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[29\]$_DFFE_PP_ _0304_ clknet_leaf_1_clk mem\[1\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[2\]$_DFFE_PP_ _0305_ clknet_leaf_17_clk mem\[1\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[30\]$_DFFE_PP_ _0306_ clknet_leaf_18_clk mem\[1\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[31\]$_DFFE_PP_ _0307_ clknet_leaf_18_clk mem\[1\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[3\]$_DFFE_PP_ _0308_ clknet_leaf_16_clk mem\[1\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[4\]$_DFFE_PP_ _0309_ clknet_leaf_16_clk mem\[1\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[5\]$_DFFE_PP_ _0310_ clknet_leaf_1_clk mem\[1\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[6\]$_DFFE_PP_ _0311_ clknet_leaf_1_clk mem\[1\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[7\]$_DFFE_PP_ _0312_ clknet_leaf_19_clk mem\[1\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[8\]$_DFFE_PP_ _0313_ clknet_leaf_16_clk mem\[1\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[1\]\[9\]$_DFFE_PP_ _0314_ clknet_leaf_16_clk mem\[1\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[0\]$_DFFE_PP_ _0315_ clknet_leaf_1_clk mem\[2\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[10\]$_DFFE_PP_ _0316_ clknet_leaf_6_clk mem\[2\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[11\]$_DFFE_PP_ _0317_ clknet_leaf_3_clk mem\[2\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[12\]$_DFFE_PP_ _0318_ clknet_leaf_3_clk mem\[2\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[13\]$_DFFE_PP_ _0319_ clknet_leaf_5_clk mem\[2\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[14\]$_DFFE_PP_ _0320_ clknet_leaf_4_clk mem\[2\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[15\]$_DFFE_PP_ _0321_ clknet_leaf_2_clk mem\[2\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[16\]$_DFFE_PP_ _0322_ clknet_leaf_1_clk mem\[2\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[17\]$_DFFE_PP_ _0323_ clknet_leaf_4_clk mem\[2\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[18\]$_DFFE_PP_ _0324_ clknet_leaf_4_clk mem\[2\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[19\]$_DFFE_PP_ _0325_ clknet_leaf_8_clk mem\[2\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[1\]$_DFFE_PP_ _0326_ clknet_leaf_12_clk mem\[2\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[20\]$_DFFE_PP_ _0327_ clknet_leaf_11_clk mem\[2\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[21\]$_DFFE_PP_ _0328_ clknet_leaf_7_clk mem\[2\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[22\]$_DFFE_PP_ _0329_ clknet_leaf_6_clk mem\[2\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[23\]$_DFFE_PP_ _0330_ clknet_leaf_9_clk mem\[2\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[24\]$_DFFE_PP_ _0331_ clknet_leaf_9_clk mem\[2\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[25\]$_DFFE_PP_ _0332_ clknet_leaf_9_clk mem\[2\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[26\]$_DFFE_PP_ _0333_ clknet_leaf_12_clk mem\[2\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[27\]$_DFFE_PP_ _0334_ clknet_leaf_11_clk mem\[2\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[28\]$_DFFE_PP_ _0335_ clknet_leaf_17_clk mem\[2\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[29\]$_DFFE_PP_ _0336_ clknet_leaf_1_clk mem\[2\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[2\]$_DFFE_PP_ _0337_ clknet_leaf_17_clk mem\[2\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[30\]$_DFFE_PP_ _0338_ clknet_leaf_18_clk mem\[2\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[31\]$_DFFE_PP_ _0339_ clknet_leaf_18_clk mem\[2\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[3\]$_DFFE_PP_ _0340_ clknet_leaf_15_clk mem\[2\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[4\]$_DFFE_PP_ _0341_ clknet_leaf_19_clk mem\[2\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[5\]$_DFFE_PP_ _0342_ clknet_leaf_1_clk mem\[2\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[6\]$_DFFE_PP_ _0343_ clknet_leaf_20_clk mem\[2\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[7\]$_DFFE_PP_ _0344_ clknet_leaf_19_clk mem\[2\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[8\]$_DFFE_PP_ _0345_ clknet_leaf_17_clk mem\[2\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[2\]\[9\]$_DFFE_PP_ _0346_ clknet_leaf_16_clk mem\[2\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[0\]$_DFFE_PP_ _0347_ clknet_leaf_17_clk mem\[3\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[10\]$_DFFE_PP_ _0348_ clknet_leaf_6_clk mem\[3\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[11\]$_DFFE_PP_ _0349_ clknet_leaf_3_clk mem\[3\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[12\]$_DFFE_PP_ _0350_ clknet_leaf_4_clk mem\[3\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[13\]$_DFFE_PP_ _0351_ clknet_leaf_5_clk mem\[3\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[14\]$_DFFE_PP_ _0352_ clknet_leaf_4_clk mem\[3\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[15\]$_DFFE_PP_ _0353_ clknet_leaf_6_clk mem\[3\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[16\]$_DFFE_PP_ _0354_ clknet_leaf_3_clk mem\[3\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[17\]$_DFFE_PP_ _0355_ clknet_leaf_2_clk mem\[3\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[18\]$_DFFE_PP_ _0356_ clknet_leaf_4_clk mem\[3\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[19\]$_DFFE_PP_ _0357_ clknet_leaf_8_clk mem\[3\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[1\]$_DFFE_PP_ _0358_ clknet_leaf_13_clk mem\[3\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[20\]$_DFFE_PP_ _0359_ clknet_leaf_12_clk mem\[3\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[21\]$_DFFE_PP_ _0360_ clknet_leaf_12_clk mem\[3\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[22\]$_DFFE_PP_ _0361_ clknet_leaf_6_clk mem\[3\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[23\]$_DFFE_PP_ _0362_ clknet_leaf_9_clk mem\[3\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[24\]$_DFFE_PP_ _0363_ clknet_leaf_9_clk mem\[3\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[25\]$_DFFE_PP_ _0364_ clknet_leaf_9_clk mem\[3\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[26\]$_DFFE_PP_ _0365_ clknet_leaf_7_clk mem\[3\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[27\]$_DFFE_PP_ _0366_ clknet_leaf_11_clk mem\[3\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[28\]$_DFFE_PP_ _0367_ clknet_leaf_1_clk mem\[3\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[29\]$_DFFE_PP_ _0368_ clknet_leaf_1_clk mem\[3\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[2\]$_DFFE_PP_ _0369_ clknet_leaf_17_clk mem\[3\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[30\]$_DFFE_PP_ _0370_ clknet_leaf_18_clk mem\[3\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[31\]$_DFFE_PP_ _0371_ clknet_leaf_18_clk mem\[3\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[3\]$_DFFE_PP_ _0372_ clknet_leaf_15_clk mem\[3\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[4\]$_DFFE_PP_ _0373_ clknet_leaf_16_clk mem\[3\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[5\]$_DFFE_PP_ _0374_ clknet_leaf_1_clk mem\[3\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[6\]$_DFFE_PP_ _0375_ clknet_leaf_20_clk mem\[3\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[7\]$_DFFE_PP_ _0376_ clknet_leaf_19_clk mem\[3\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[8\]$_DFFE_PP_ _0377_ clknet_leaf_17_clk mem\[3\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[3\]\[9\]$_DFFE_PP_ _0378_ clknet_leaf_16_clk mem\[3\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[0\]$_DFFE_PP_ _0379_ clknet_leaf_2_clk mem\[4\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[10\]$_DFFE_PP_ _0380_ clknet_leaf_5_clk mem\[4\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[11\]$_DFFE_PP_ _0381_ clknet_leaf_3_clk mem\[4\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[12\]$_DFFE_PP_ _0382_ clknet_leaf_3_clk mem\[4\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[13\]$_DFFE_PP_ _0383_ clknet_leaf_8_clk mem\[4\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[14\]$_DFFE_PP_ _0384_ clknet_leaf_4_clk mem\[4\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[15\]$_DFFE_PP_ _0385_ clknet_leaf_2_clk mem\[4\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[16\]$_DFFE_PP_ _0386_ clknet_leaf_2_clk mem\[4\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[17\]$_DFFE_PP_ _0387_ clknet_leaf_4_clk mem\[4\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[18\]$_DFFE_PP_ _0388_ clknet_leaf_5_clk mem\[4\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[19\]$_DFFE_PP_ _0389_ clknet_leaf_8_clk mem\[4\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[1\]$_DFFE_PP_ _0390_ clknet_leaf_13_clk mem\[4\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[20\]$_DFFE_PP_ _0391_ clknet_leaf_12_clk mem\[4\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[21\]$_DFFE_PP_ _0392_ clknet_leaf_7_clk mem\[4\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[22\]$_DFFE_PP_ _0393_ clknet_leaf_6_clk mem\[4\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[23\]$_DFFE_PP_ _0394_ clknet_leaf_7_clk mem\[4\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[24\]$_DFFE_PP_ _0395_ clknet_leaf_9_clk mem\[4\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[25\]$_DFFE_PP_ _0396_ clknet_leaf_9_clk mem\[4\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[26\]$_DFFE_PP_ _0397_ clknet_leaf_2_clk mem\[4\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[27\]$_DFFE_PP_ _0398_ clknet_leaf_11_clk mem\[4\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[28\]$_DFFE_PP_ _0399_ clknet_leaf_1_clk mem\[4\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[29\]$_DFFE_PP_ _0400_ clknet_leaf_0_clk mem\[4\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[2\]$_DFFE_PP_ _0401_ clknet_leaf_19_clk mem\[4\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[30\]$_DFFE_PP_ _0402_ clknet_leaf_19_clk mem\[4\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[31\]$_DFFE_PP_ _0403_ clknet_leaf_20_clk mem\[4\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[3\]$_DFFE_PP_ _0404_ clknet_leaf_16_clk mem\[4\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[4\]$_DFFE_PP_ _0405_ clknet_leaf_18_clk mem\[4\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[5\]$_DFFE_PP_ _0406_ clknet_leaf_0_clk mem\[4\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[6\]$_DFFE_PP_ _0407_ clknet_leaf_20_clk mem\[4\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[7\]$_DFFE_PP_ _0408_ clknet_leaf_19_clk mem\[4\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[8\]$_DFFE_PP_ _0409_ clknet_leaf_17_clk mem\[4\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[4\]\[9\]$_DFFE_PP_ _0410_ clknet_leaf_15_clk mem\[4\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[0\]$_DFFE_PP_ _0411_ clknet_leaf_12_clk mem\[5\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[10\]$_DFFE_PP_ _0412_ clknet_leaf_5_clk mem\[5\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[11\]$_DFFE_PP_ _0413_ clknet_leaf_3_clk mem\[5\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[12\]$_DFFE_PP_ _0414_ clknet_leaf_4_clk mem\[5\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[13\]$_DFFE_PP_ _0415_ clknet_leaf_8_clk mem\[5\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[14\]$_DFFE_PP_ _0416_ clknet_leaf_4_clk mem\[5\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[15\]$_DFFE_PP_ _0417_ clknet_leaf_2_clk mem\[5\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[16\]$_DFFE_PP_ _0418_ clknet_leaf_3_clk mem\[5\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[17\]$_DFFE_PP_ _0419_ clknet_leaf_3_clk mem\[5\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[18\]$_DFFE_PP_ _0420_ clknet_leaf_6_clk mem\[5\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[19\]$_DFFE_PP_ _0421_ clknet_leaf_8_clk mem\[5\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[1\]$_DFFE_PP_ _0422_ clknet_leaf_13_clk mem\[5\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[20\]$_DFFE_PP_ _0423_ clknet_leaf_12_clk mem\[5\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[21\]$_DFFE_PP_ _0424_ clknet_leaf_7_clk mem\[5\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[22\]$_DFFE_PP_ _0425_ clknet_leaf_6_clk mem\[5\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[23\]$_DFFE_PP_ _0426_ clknet_leaf_8_clk mem\[5\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[24\]$_DFFE_PP_ _0427_ clknet_leaf_9_clk mem\[5\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[25\]$_DFFE_PP_ _0428_ clknet_leaf_9_clk mem\[5\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[26\]$_DFFE_PP_ _0429_ clknet_leaf_7_clk mem\[5\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[27\]$_DFFE_PP_ _0430_ clknet_leaf_10_clk mem\[5\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[28\]$_DFFE_PP_ _0431_ clknet_leaf_1_clk mem\[5\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[29\]$_DFFE_PP_ _0432_ clknet_leaf_0_clk mem\[5\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[2\]$_DFFE_PP_ _0433_ clknet_leaf_16_clk mem\[5\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[30\]$_DFFE_PP_ _0434_ clknet_leaf_19_clk mem\[5\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[31\]$_DFFE_PP_ _0435_ clknet_leaf_20_clk mem\[5\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[3\]$_DFFE_PP_ _0436_ clknet_leaf_16_clk mem\[5\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[4\]$_DFFE_PP_ _0437_ clknet_leaf_16_clk mem\[5\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[5\]$_DFFE_PP_ _0438_ clknet_leaf_1_clk mem\[5\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[6\]$_DFFE_PP_ _0439_ clknet_leaf_20_clk mem\[5\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[7\]$_DFFE_PP_ _0440_ clknet_leaf_19_clk mem\[5\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[8\]$_DFFE_PP_ _0441_ clknet_leaf_13_clk mem\[5\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[5\]\[9\]$_DFFE_PP_ _0442_ clknet_leaf_15_clk mem\[5\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[0\]$_DFFE_PP_ _0443_ clknet_leaf_1_clk mem\[6\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[10\]$_DFFE_PP_ _0444_ clknet_leaf_5_clk mem\[6\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[11\]$_DFFE_PP_ _0445_ clknet_leaf_3_clk mem\[6\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[12\]$_DFFE_PP_ _0446_ clknet_leaf_3_clk mem\[6\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[13\]$_DFFE_PP_ _0447_ clknet_leaf_8_clk mem\[6\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[14\]$_DFFE_PP_ _0448_ clknet_leaf_4_clk mem\[6\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[15\]$_DFFE_PP_ _0449_ clknet_leaf_2_clk mem\[6\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[16\]$_DFFE_PP_ _0450_ clknet_leaf_2_clk mem\[6\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[17\]$_DFFE_PP_ _0451_ clknet_leaf_3_clk mem\[6\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[18\]$_DFFE_PP_ _0452_ clknet_leaf_6_clk mem\[6\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[19\]$_DFFE_PP_ _0453_ clknet_leaf_8_clk mem\[6\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[1\]$_DFFE_PP_ _0454_ clknet_leaf_13_clk mem\[6\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[20\]$_DFFE_PP_ _0455_ clknet_leaf_11_clk mem\[6\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[21\]$_DFFE_PP_ _0456_ clknet_leaf_12_clk mem\[6\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[22\]$_DFFE_PP_ _0457_ clknet_leaf_6_clk mem\[6\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[23\]$_DFFE_PP_ _0458_ clknet_leaf_9_clk mem\[6\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[24\]$_DFFE_PP_ _0459_ clknet_leaf_10_clk mem\[6\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[25\]$_DFFE_PP_ _0460_ clknet_leaf_9_clk mem\[6\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[26\]$_DFFE_PP_ _0461_ clknet_leaf_2_clk mem\[6\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[27\]$_DFFE_PP_ _0462_ clknet_leaf_11_clk mem\[6\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[28\]$_DFFE_PP_ _0463_ clknet_leaf_17_clk mem\[6\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[29\]$_DFFE_PP_ _0464_ clknet_leaf_0_clk mem\[6\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[2\]$_DFFE_PP_ _0465_ clknet_leaf_17_clk mem\[6\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[30\]$_DFFE_PP_ _0466_ clknet_leaf_18_clk mem\[6\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[31\]$_DFFE_PP_ _0467_ clknet_leaf_20_clk mem\[6\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[3\]$_DFFE_PP_ _0468_ clknet_leaf_15_clk mem\[6\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[4\]$_DFFE_PP_ _0469_ clknet_leaf_18_clk mem\[6\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[5\]$_DFFE_PP_ _0470_ clknet_leaf_0_clk mem\[6\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[6\]$_DFFE_PP_ _0471_ clknet_leaf_0_clk mem\[6\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[7\]$_DFFE_PP_ _0472_ clknet_leaf_19_clk mem\[6\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[8\]$_DFFE_PP_ _0473_ clknet_leaf_16_clk mem\[6\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[6\]\[9\]$_DFFE_PP_ _0474_ clknet_leaf_15_clk mem\[6\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[0\]$_DFFE_PP_ _0475_ clknet_leaf_12_clk mem\[7\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[10\]$_DFFE_PP_ _0476_ clknet_leaf_6_clk mem\[7\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[11\]$_DFFE_PP_ _0477_ clknet_leaf_3_clk mem\[7\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[12\]$_DFFE_PP_ _0478_ clknet_leaf_3_clk mem\[7\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[13\]$_DFFE_PP_ _0479_ clknet_leaf_5_clk mem\[7\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[14\]$_DFFE_PP_ _0480_ clknet_leaf_4_clk mem\[7\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[15\]$_DFFE_PP_ _0481_ clknet_leaf_6_clk mem\[7\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[16\]$_DFFE_PP_ _0482_ clknet_leaf_3_clk mem\[7\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[17\]$_DFFE_PP_ _0483_ clknet_leaf_3_clk mem\[7\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[18\]$_DFFE_PP_ _0484_ clknet_leaf_5_clk mem\[7\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[19\]$_DFFE_PP_ _0485_ clknet_leaf_8_clk mem\[7\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[1\]$_DFFE_PP_ _0486_ clknet_leaf_13_clk mem\[7\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[20\]$_DFFE_PP_ _0487_ clknet_leaf_11_clk mem\[7\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[21\]$_DFFE_PP_ _0488_ clknet_leaf_12_clk mem\[7\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[22\]$_DFFE_PP_ _0489_ clknet_leaf_6_clk mem\[7\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[23\]$_DFFE_PP_ _0490_ clknet_leaf_9_clk mem\[7\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[24\]$_DFFE_PP_ _0491_ clknet_leaf_10_clk mem\[7\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[25\]$_DFFE_PP_ _0492_ clknet_leaf_9_clk mem\[7\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[26\]$_DFFE_PP_ _0493_ clknet_leaf_12_clk mem\[7\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[27\]$_DFFE_PP_ _0494_ clknet_leaf_10_clk mem\[7\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[28\]$_DFFE_PP_ _0495_ clknet_leaf_1_clk mem\[7\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[29\]$_DFFE_PP_ _0496_ clknet_leaf_0_clk mem\[7\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[2\]$_DFFE_PP_ _0497_ clknet_leaf_16_clk mem\[7\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[30\]$_DFFE_PP_ _0498_ clknet_leaf_17_clk mem\[7\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[31\]$_DFFE_PP_ _0499_ clknet_leaf_20_clk mem\[7\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[3\]$_DFFE_PP_ _0500_ clknet_leaf_15_clk mem\[7\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[4\]$_DFFE_PP_ _0501_ clknet_leaf_18_clk mem\[7\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[5\]$_DFFE_PP_ _0502_ clknet_leaf_1_clk mem\[7\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[6\]$_DFFE_PP_ _0503_ clknet_leaf_0_clk mem\[7\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[7\]$_DFFE_PP_ _0504_ clknet_leaf_20_clk mem\[7\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[8\]$_DFFE_PP_ _0505_ clknet_leaf_13_clk mem\[7\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[7\]\[9\]$_DFFE_PP_ _0506_ clknet_leaf_15_clk mem\[7\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[0\]$_DFFE_PP_ _0507_ clknet_leaf_17_clk mem\[8\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[10\]$_DFFE_PP_ _0508_ clknet_leaf_5_clk mem\[8\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[11\]$_DFFE_PP_ _0509_ clknet_leaf_3_clk mem\[8\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[12\]$_DFFE_PP_ _0510_ clknet_leaf_4_clk mem\[8\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[13\]$_DFFE_PP_ _0511_ clknet_leaf_5_clk mem\[8\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[14\]$_DFFE_PP_ _0512_ clknet_leaf_4_clk mem\[8\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[15\]$_DFFE_PP_ _0513_ clknet_leaf_3_clk mem\[8\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[16\]$_DFFE_PP_ _0514_ clknet_leaf_0_clk mem\[8\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[17\]$_DFFE_PP_ _0515_ clknet_leaf_4_clk mem\[8\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[18\]$_DFFE_PP_ _0516_ clknet_leaf_5_clk mem\[8\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[19\]$_DFFE_PP_ _0517_ clknet_leaf_8_clk mem\[8\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[1\]$_DFFE_PP_ _0518_ clknet_leaf_12_clk mem\[8\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[20\]$_DFFE_PP_ _0519_ clknet_leaf_11_clk mem\[8\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[21\]$_DFFE_PP_ _0520_ clknet_leaf_7_clk mem\[8\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[22\]$_DFFE_PP_ _0521_ clknet_leaf_7_clk mem\[8\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[23\]$_DFFE_PP_ _0522_ clknet_leaf_8_clk mem\[8\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[24\]$_DFFE_PP_ _0523_ clknet_leaf_8_clk mem\[8\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[25\]$_DFFE_PP_ _0524_ clknet_leaf_9_clk mem\[8\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[26\]$_DFFE_PP_ _0525_ clknet_leaf_2_clk mem\[8\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[27\]$_DFFE_PP_ _0526_ clknet_leaf_11_clk mem\[8\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[28\]$_DFFE_PP_ _0527_ clknet_leaf_0_clk mem\[8\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[29\]$_DFFE_PP_ _0528_ clknet_leaf_0_clk mem\[8\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[2\]$_DFFE_PP_ _0529_ clknet_leaf_18_clk mem\[8\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[30\]$_DFFE_PP_ _0530_ clknet_leaf_18_clk mem\[8\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[31\]$_DFFE_PP_ _0531_ clknet_leaf_19_clk mem\[8\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[3\]$_DFFE_PP_ _0532_ clknet_leaf_15_clk mem\[8\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[4\]$_DFFE_PP_ _0533_ clknet_leaf_19_clk mem\[8\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[5\]$_DFFE_PP_ _0534_ clknet_leaf_0_clk mem\[8\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[6\]$_DFFE_PP_ _0535_ clknet_leaf_20_clk mem\[8\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[7\]$_DFFE_PP_ _0536_ clknet_leaf_20_clk mem\[8\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[8\]$_DFFE_PP_ _0537_ clknet_leaf_16_clk mem\[8\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[8\]\[9\]$_DFFE_PP_ _0538_ clknet_leaf_15_clk mem\[8\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[0\]$_DFFE_PP_ _0539_ clknet_leaf_1_clk mem\[9\]\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[10\]$_DFFE_PP_ _0540_ clknet_leaf_5_clk mem\[9\]\[10\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[11\]$_DFFE_PP_ _0541_ clknet_leaf_2_clk mem\[9\]\[11\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[12\]$_DFFE_PP_ _0542_ clknet_leaf_4_clk mem\[9\]\[12\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[13\]$_DFFE_PP_ _0543_ clknet_leaf_8_clk mem\[9\]\[13\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[14\]$_DFFE_PP_ _0544_ clknet_leaf_4_clk mem\[9\]\[14\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[15\]$_DFFE_PP_ _0545_ clknet_leaf_3_clk mem\[9\]\[15\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[16\]$_DFFE_PP_ _0546_ clknet_leaf_3_clk mem\[9\]\[16\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[17\]$_DFFE_PP_ _0547_ clknet_leaf_2_clk mem\[9\]\[17\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[18\]$_DFFE_PP_ _0548_ clknet_leaf_5_clk mem\[9\]\[18\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[19\]$_DFFE_PP_ _0549_ clknet_leaf_8_clk mem\[9\]\[19\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[1\]$_DFFE_PP_ _0550_ clknet_leaf_12_clk mem\[9\]\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[20\]$_DFFE_PP_ _0551_ clknet_leaf_12_clk mem\[9\]\[20\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[21\]$_DFFE_PP_ _0552_ clknet_leaf_7_clk mem\[9\]\[21\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[22\]$_DFFE_PP_ _0553_ clknet_leaf_7_clk mem\[9\]\[22\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[23\]$_DFFE_PP_ _0554_ clknet_leaf_9_clk mem\[9\]\[23\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[24\]$_DFFE_PP_ _0555_ clknet_leaf_8_clk mem\[9\]\[24\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[25\]$_DFFE_PP_ _0556_ clknet_leaf_9_clk mem\[9\]\[25\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[26\]$_DFFE_PP_ _0557_ clknet_leaf_7_clk mem\[9\]\[26\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[27\]$_DFFE_PP_ _0558_ clknet_leaf_10_clk mem\[9\]\[27\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[28\]$_DFFE_PP_ _0559_ clknet_leaf_17_clk mem\[9\]\[28\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[29\]$_DFFE_PP_ _0560_ clknet_leaf_1_clk mem\[9\]\[29\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[2\]$_DFFE_PP_ _0561_ clknet_leaf_17_clk mem\[9\]\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[30\]$_DFFE_PP_ _0562_ clknet_leaf_18_clk mem\[9\]\[30\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[31\]$_DFFE_PP_ _0563_ clknet_leaf_19_clk mem\[9\]\[31\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[3\]$_DFFE_PP_ _0564_ clknet_leaf_15_clk mem\[9\]\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[4\]$_DFFE_PP_ _0565_ clknet_leaf_18_clk mem\[9\]\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[5\]$_DFFE_PP_ _0566_ clknet_leaf_0_clk mem\[9\]\[5\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[6\]$_DFFE_PP_ _0567_ clknet_leaf_0_clk mem\[9\]\[6\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[7\]$_DFFE_PP_ _0568_ clknet_leaf_20_clk mem\[9\]\[7\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[8\]$_DFFE_PP_ _0569_ clknet_leaf_17_clk mem\[9\]\[8\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem\[9\]\[9\]$_DFFE_PP_ _0570_ clknet_leaf_16_clk mem\[9\]\[9\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffq_2
Xmem_rdata\[0\]$_DFFE_PN0P_ _0571_ net180 clknet_leaf_14_clk
+ net108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[10\]$_DFFE_PN0P_ _0572_ net180 clknet_leaf_10_clk
+ net109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[11\]$_DFFE_PN0P_ _0573_ net180 clknet_leaf_11_clk
+ net110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[12\]$_DFFE_PN0P_ _0574_ net180 clknet_leaf_10_clk
+ net111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[13\]$_DFFE_PN0P_ _0575_ net180 clknet_leaf_10_clk
+ net112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[14\]$_DFFE_PN0P_ _0576_ net180 clknet_leaf_13_clk
+ net113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[15\]$_DFFE_PN0P_ _0577_ net180 clknet_leaf_11_clk
+ net114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[16\]$_DFFE_PN0P_ _0578_ net180 clknet_leaf_11_clk
+ net115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[17\]$_DFFE_PN0P_ _0579_ net180 clknet_leaf_10_clk
+ net116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[18\]$_DFFE_PN0P_ _0580_ net180 clknet_leaf_14_clk
+ net117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[19\]$_DFFE_PN0P_ _0581_ net180 clknet_leaf_10_clk
+ net118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[1\]$_DFFE_PN0P_ _0582_ net73 clknet_leaf_15_clk
+ net119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[20\]$_DFFE_PN0P_ _0583_ net180 clknet_leaf_13_clk
+ net120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[21\]$_DFFE_PN0P_ _0584_ net180 clknet_leaf_11_clk
+ net121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[22\]$_DFFE_PN0P_ _0585_ net180 clknet_leaf_11_clk
+ net122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[23\]$_DFFE_PN0P_ _0586_ net180 clknet_leaf_10_clk
+ net123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[24\]$_DFFE_PN0P_ _0587_ net180 clknet_leaf_10_clk
+ net124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[25\]$_DFFE_PN0P_ _0588_ net180 clknet_leaf_10_clk
+ net125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[26\]$_DFFE_PN0P_ _0589_ net180 clknet_leaf_11_clk
+ net126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[27\]$_DFFE_PN0P_ _0590_ net180 clknet_leaf_11_clk
+ net127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[28\]$_DFFE_PN0P_ _0591_ net180 clknet_leaf_14_clk
+ net128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[29\]$_DFFE_PN0P_ _0592_ net180 clknet_leaf_14_clk
+ net129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[2\]$_DFFE_PN0P_ _0593_ net73 clknet_leaf_14_clk
+ net130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[30\]$_DFFE_PN0P_ _0594_ net180 clknet_leaf_14_clk
+ net131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[31\]$_DFFE_PN0P_ _0595_ net180 clknet_leaf_14_clk
+ net132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[3\]$_DFFE_PN0P_ _0596_ net73 clknet_leaf_15_clk
+ net133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[4\]$_DFFE_PN0P_ _0597_ net73 clknet_leaf_14_clk
+ net134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[5\]$_DFFE_PN0P_ _0598_ net180 clknet_leaf_14_clk
+ net135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[6\]$_DFFE_PN0P_ _0599_ net180 clknet_leaf_14_clk
+ net136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[7\]$_DFFE_PN0P_ _0600_ net73 clknet_leaf_14_clk
+ net137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[8\]$_DFFE_PN0P_ _0601_ net180 clknet_leaf_14_clk
+ net138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_rdata\[9\]$_DFFE_PN0P_ _0602_ net73 clknet_leaf_15_clk
+ net139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xmem_ready$_DFF_PN0_ net181 net180 clknet_leaf_14_clk net140
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrd_ptr\[0\]$_DFFE_PN0P_ _0603_ net180 clknet_leaf_14_clk
+ rd_ptr\[0\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrd_ptr\[1\]$_DFFE_PN0P_ _0604_ net180 clknet_leaf_13_clk
+ rd_ptr\[1\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xrd_ptr\[2\]$_DFFE_PN0P_ _0605_ net180 clknet_leaf_13_clk
+ rd_ptr\[2\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xrd_ptr\[3\]$_DFFE_PN0P_ _0606_ net180 clknet_leaf_17_clk
+ rd_ptr\[3\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
Xrd_ptr\[4\]$_DFFE_PN0P_ _0607_ net180 clknet_leaf_14_clk
+ rd_ptr\[4\] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ptr\[0\]$_DFFE_PN0P_ _0608_ net73 clknet_leaf_15_clk wr_ptr\[0\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ptr\[1\]$_DFFE_PN0P_ _0609_ net73 clknet_leaf_15_clk wr_ptr\[1\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ptr\[2\]$_DFFE_PN0P_ _0610_ net73 clknet_leaf_15_clk wr_ptr\[2\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ptr\[3\]$_DFFE_PN0P_ _0611_ net73 clknet_leaf_15_clk wr_ptr\[3\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xwr_ptr\[4\]$_DFFE_PN0P_ _0612_ net73 clknet_leaf_15_clk wr_ptr\[4\]
+ VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Right_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Right_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Right_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Right_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Right_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Right_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Right_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Right_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Right_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Right_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Right_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Right_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Right_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Right_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Right_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Right_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Right_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Right_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Right_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Right_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Right_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Right_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Right_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Right_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Right_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Right_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Right_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Right_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Right_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Right_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Right_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Right_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Right_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Right_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Right_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Right_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Right_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Right_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Right_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Right_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Right_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Right_68 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Right_69 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Right_70 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Right_71 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Right_72 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Right_73 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Right_74 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Right_75 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Right_76 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Right_77 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Right_78 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Right_79 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Right_80 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Right_81 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Right_82 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Right_83 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Right_84 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Right_85 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Right_86 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Right_87 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Right_88 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Right_89 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Right_90 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Right_91 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Right_92 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Right_93 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Right_94 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Right_95 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Right_96 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Right_97 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Right_98 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Right_99 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Right_100 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Right_101 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Right_102 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Right_103 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Right_104 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Right_105 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Right_106 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Right_107 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Right_108 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Right_109 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Right_110 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_111 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_112 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_113 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_114 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_115 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_116 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_117 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_118 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_119 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_120 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_121 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_122 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_123 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_124 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_125 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_126 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_127 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_128 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_129 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_130 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_131 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_132 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_133 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_134 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_135 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_136 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_137 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_27_Left_138 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_28_Left_139 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_29_Left_140 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_30_Left_141 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_31_Left_142 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_32_Left_143 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_33_Left_144 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_34_Left_145 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_35_Left_146 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_36_Left_147 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_37_Left_148 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_38_Left_149 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_39_Left_150 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_40_Left_151 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_41_Left_152 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_42_Left_153 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_43_Left_154 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_44_Left_155 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_45_Left_156 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_46_Left_157 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_47_Left_158 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_48_Left_159 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_49_Left_160 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_50_Left_161 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_51_Left_162 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_52_Left_163 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_53_Left_164 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_54_Left_165 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_55_Left_166 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_56_Left_167 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_57_Left_168 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_58_Left_169 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_59_Left_170 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_60_Left_171 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_61_Left_172 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_62_Left_173 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_63_Left_174 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_64_Left_175 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_65_Left_176 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_66_Left_177 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_67_Left_178 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_68_Left_179 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_69_Left_180 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_70_Left_181 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_71_Left_182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_72_Left_183 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_73_Left_184 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_74_Left_185 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_75_Left_186 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_76_Left_187 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_77_Left_188 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_78_Left_189 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_79_Left_190 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_80_Left_191 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_81_Left_192 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_82_Left_193 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_83_Left_194 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_84_Left_195 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_85_Left_196 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_86_Left_197 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_87_Left_198 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_88_Left_199 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_89_Left_200 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_90_Left_201 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_91_Left_202 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_92_Left_203 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_93_Left_204 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_94_Left_205 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_95_Left_206 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_96_Left_207 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_97_Left_208 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_98_Left_209 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_99_Left_210 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_100_Left_211 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_101_Left_212 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_102_Left_213 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_103_Left_214 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_104_Left_215 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_105_Left_216 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_106_Left_217 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_107_Left_218 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_108_Left_219 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_109_Left_220 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_110_Left_221 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_222 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_223 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_224 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_225 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_0_226 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_227 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_1_228 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_229 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_230 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_231 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_232 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_3_233 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_234 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_235 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_236 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_237 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_5_238 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_239 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_240 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_241 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_242 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_7_243 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_244 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_245 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_246 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_247 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_9_248 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_249 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_250 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_251 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_252 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_11_253 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_254 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_255 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_256 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_257 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_13_258 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_259 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_260 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_261 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_262 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_15_263 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_264 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_265 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_266 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_267 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_17_268 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_269 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_270 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_271 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_272 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_19_273 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_274 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_275 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_276 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_277 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_21_278 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_279 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_280 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_281 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_282 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_23_283 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_284 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_285 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_286 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_287 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_25_288 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_289 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_290 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_291 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_292 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_27_293 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_294 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_295 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_28_296 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_297 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_29_298 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_299 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_300 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_30_301 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_302 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_31_303 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_304 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_305 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_32_306 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_307 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_33_308 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_309 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_310 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_34_311 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_312 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_35_313 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_314 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_315 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_36_316 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_317 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_37_318 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_319 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_320 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_38_321 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_322 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_39_323 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_324 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_325 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_40_326 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_327 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_41_328 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_329 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_330 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_42_331 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_332 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_43_333 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_334 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_335 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_44_336 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_337 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_45_338 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_339 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_340 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_46_341 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_342 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_47_343 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_344 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_345 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_48_346 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_347 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_49_348 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_349 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_350 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_50_351 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_352 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_51_353 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_354 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_355 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_52_356 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_357 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_53_358 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_359 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_360 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_54_361 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_362 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_55_363 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_364 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_365 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_56_366 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_367 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_57_368 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_369 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_370 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_58_371 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_372 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_59_373 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_374 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_375 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_60_376 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_377 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_61_378 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_379 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_380 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_62_381 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_382 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_63_383 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_384 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_385 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_64_386 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_387 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_65_388 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_389 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_390 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_66_391 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_392 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_67_393 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_394 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_395 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_68_396 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_397 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_69_398 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_399 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_400 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_70_401 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_402 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_71_403 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_404 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_405 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_72_406 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_407 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_73_408 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_409 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_410 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_74_411 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_412 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_75_413 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_414 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_415 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_76_416 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_417 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_77_418 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_419 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_420 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_78_421 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_422 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_79_423 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_424 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_425 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_80_426 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_427 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_81_428 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_429 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_430 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_82_431 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_432 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_83_433 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_434 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_435 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_84_436 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_437 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_85_438 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_439 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_440 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_86_441 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_442 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_87_443 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_444 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_445 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_88_446 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_447 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_89_448 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_449 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_450 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_90_451 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_452 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_91_453 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_454 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_455 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_92_456 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_457 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_93_458 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_459 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_460 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_94_461 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_462 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_95_463 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_464 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_465 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_96_466 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_467 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_97_468 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_469 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_470 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_98_471 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_472 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_99_473 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_474 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_475 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_100_476 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_477 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_101_478 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_479 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_480 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_102_481 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_482 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_103_483 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_484 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_485 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_104_486 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_487 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_105_488 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_489 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_490 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_106_491 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_492 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_107_493 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_494 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_495 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_108_496 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_497 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_109_498 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_499 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_500 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_501 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_502 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_110_503 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload0 clknet_1_0__leaf_clk _unconnected_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload1 clknet_leaf_0_clk _unconnected_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload2 clknet_leaf_1_clk _unconnected_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
Xclkload3 clknet_leaf_13_clk _unconnected_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload4 clknet_leaf_14_clk _unconnected_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload5 clknet_leaf_15_clk _unconnected_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload6 clknet_leaf_16_clk _unconnected_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_8
Xclkload7 clknet_leaf_17_clk _unconnected_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xclkload8 clknet_leaf_18_clk _unconnected_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_8
Xclkload9 clknet_leaf_20_clk _unconnected_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_12
Xclkload10 clknet_leaf_2_clk _unconnected_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload11 clknet_leaf_3_clk _unconnected_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xclkload12 clknet_leaf_4_clk _unconnected_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload13 clknet_leaf_5_clk _unconnected_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
Xclkload14 clknet_leaf_6_clk _unconnected_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload15 clknet_leaf_7_clk _unconnected_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
Xclkload16 clknet_leaf_9_clk _unconnected_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_3
Xclkload17 clknet_leaf_10_clk _unconnected_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_2
Xclkload18 clknet_leaf_11_clk _unconnected_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
Xclkload19 clknet_leaf_12_clk _unconnected_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
Xhold182 rst_n net182 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS memory_mapped_fifo
