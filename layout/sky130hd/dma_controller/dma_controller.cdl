* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT dma_controller channel_busy[0] channel_busy[1] channel_busy[2]
+ channel_busy[3] channel_done[0] channel_done[1] channel_done[2]
+ channel_done[3] channel_dst_addr[0] channel_dst_addr[100]
+ channel_dst_addr[101] channel_dst_addr[102] channel_dst_addr[103]
+ channel_dst_addr[104] channel_dst_addr[105] channel_dst_addr[106]
+ channel_dst_addr[107] channel_dst_addr[108] channel_dst_addr[109]
+ channel_dst_addr[10] channel_dst_addr[110] channel_dst_addr[111]
+ channel_dst_addr[112] channel_dst_addr[113] channel_dst_addr[114]
+ channel_dst_addr[115] channel_dst_addr[116] channel_dst_addr[117]
+ channel_dst_addr[118] channel_dst_addr[119] channel_dst_addr[11]
+ channel_dst_addr[120] channel_dst_addr[121] channel_dst_addr[122]
+ channel_dst_addr[123] channel_dst_addr[124] channel_dst_addr[125]
+ channel_dst_addr[126] channel_dst_addr[127] channel_dst_addr[12]
+ channel_dst_addr[13] channel_dst_addr[14] channel_dst_addr[15]
+ channel_dst_addr[16] channel_dst_addr[17] channel_dst_addr[18]
+ channel_dst_addr[19] channel_dst_addr[1] channel_dst_addr[20]
+ channel_dst_addr[21] channel_dst_addr[22] channel_dst_addr[23]
+ channel_dst_addr[24] channel_dst_addr[25] channel_dst_addr[26]
+ channel_dst_addr[27] channel_dst_addr[28] channel_dst_addr[29]
+ channel_dst_addr[2] channel_dst_addr[30] channel_dst_addr[31]
+ channel_dst_addr[32] channel_dst_addr[33] channel_dst_addr[34]
+ channel_dst_addr[35] channel_dst_addr[36] channel_dst_addr[37]
+ channel_dst_addr[38] channel_dst_addr[39] channel_dst_addr[3]
+ channel_dst_addr[40] channel_dst_addr[41] channel_dst_addr[42]
+ channel_dst_addr[43] channel_dst_addr[44] channel_dst_addr[45]
+ channel_dst_addr[46] channel_dst_addr[47] channel_dst_addr[48]
+ channel_dst_addr[49] channel_dst_addr[4] channel_dst_addr[50]
+ channel_dst_addr[51] channel_dst_addr[52] channel_dst_addr[53]
+ channel_dst_addr[54] channel_dst_addr[55] channel_dst_addr[56]
+ channel_dst_addr[57] channel_dst_addr[58] channel_dst_addr[59]
+ channel_dst_addr[5] channel_dst_addr[60] channel_dst_addr[61]
+ channel_dst_addr[62] channel_dst_addr[63] channel_dst_addr[64]
+ channel_dst_addr[65] channel_dst_addr[66] channel_dst_addr[67]
+ channel_dst_addr[68] channel_dst_addr[69] channel_dst_addr[6]
+ channel_dst_addr[70] channel_dst_addr[71] channel_dst_addr[72]
+ channel_dst_addr[73] channel_dst_addr[74] channel_dst_addr[75]
+ channel_dst_addr[76] channel_dst_addr[77] channel_dst_addr[78]
+ channel_dst_addr[79] channel_dst_addr[7] channel_dst_addr[80]
+ channel_dst_addr[81] channel_dst_addr[82] channel_dst_addr[83]
+ channel_dst_addr[84] channel_dst_addr[85] channel_dst_addr[86]
+ channel_dst_addr[87] channel_dst_addr[88] channel_dst_addr[89]
+ channel_dst_addr[8] channel_dst_addr[90] channel_dst_addr[91]
+ channel_dst_addr[92] channel_dst_addr[93] channel_dst_addr[94]
+ channel_dst_addr[95] channel_dst_addr[96] channel_dst_addr[97]
+ channel_dst_addr[98] channel_dst_addr[99] channel_dst_addr[9]
+ channel_enable[0] channel_enable[1] channel_enable[2] channel_enable[3]
+ channel_error[0] channel_error[1] channel_error[2] channel_error[3]
+ channel_length[0] channel_length[100] channel_length[101]
+ channel_length[102] channel_length[103] channel_length[104]
+ channel_length[105] channel_length[106] channel_length[107]
+ channel_length[108] channel_length[109] channel_length[10]
+ channel_length[110] channel_length[111] channel_length[112]
+ channel_length[113] channel_length[114] channel_length[115]
+ channel_length[116] channel_length[117] channel_length[118]
+ channel_length[119] channel_length[11] channel_length[120]
+ channel_length[121] channel_length[122] channel_length[123]
+ channel_length[124] channel_length[125] channel_length[126]
+ channel_length[127] channel_length[12] channel_length[13]
+ channel_length[14] channel_length[15] channel_length[16] channel_length[17]
+ channel_length[18] channel_length[19] channel_length[1] channel_length[20]
+ channel_length[21] channel_length[22] channel_length[23] channel_length[24]
+ channel_length[25] channel_length[26] channel_length[27] channel_length[28]
+ channel_length[29] channel_length[2] channel_length[30] channel_length[31]
+ channel_length[32] channel_length[33] channel_length[34] channel_length[35]
+ channel_length[36] channel_length[37] channel_length[38] channel_length[39]
+ channel_length[3] channel_length[40] channel_length[41] channel_length[42]
+ channel_length[43] channel_length[44] channel_length[45] channel_length[46]
+ channel_length[47] channel_length[48] channel_length[49] channel_length[4]
+ channel_length[50] channel_length[51] channel_length[52] channel_length[53]
+ channel_length[54] channel_length[55] channel_length[56] channel_length[57]
+ channel_length[58] channel_length[59] channel_length[5] channel_length[60]
+ channel_length[61] channel_length[62] channel_length[63] channel_length[64]
+ channel_length[65] channel_length[66] channel_length[67] channel_length[68]
+ channel_length[69] channel_length[6] channel_length[70] channel_length[71]
+ channel_length[72] channel_length[73] channel_length[74] channel_length[75]
+ channel_length[76] channel_length[77] channel_length[78] channel_length[79]
+ channel_length[7] channel_length[80] channel_length[81] channel_length[82]
+ channel_length[83] channel_length[84] channel_length[85] channel_length[86]
+ channel_length[87] channel_length[88] channel_length[89] channel_length[8]
+ channel_length[90] channel_length[91] channel_length[92] channel_length[93]
+ channel_length[94] channel_length[95] channel_length[96] channel_length[97]
+ channel_length[98] channel_length[99] channel_length[9] channel_mode[0]
+ channel_mode[1] channel_mode[2] channel_mode[3] channel_mode[4]
+ channel_mode[5] channel_mode[6] channel_mode[7] channel_src_addr[0]
+ channel_src_addr[100] channel_src_addr[101] channel_src_addr[102]
+ channel_src_addr[103] channel_src_addr[104] channel_src_addr[105]
+ channel_src_addr[106] channel_src_addr[107] channel_src_addr[108]
+ channel_src_addr[109] channel_src_addr[10] channel_src_addr[110]
+ channel_src_addr[111] channel_src_addr[112] channel_src_addr[113]
+ channel_src_addr[114] channel_src_addr[115] channel_src_addr[116]
+ channel_src_addr[117] channel_src_addr[118] channel_src_addr[119]
+ channel_src_addr[11] channel_src_addr[120] channel_src_addr[121]
+ channel_src_addr[122] channel_src_addr[123] channel_src_addr[124]
+ channel_src_addr[125] channel_src_addr[126] channel_src_addr[127]
+ channel_src_addr[12] channel_src_addr[13] channel_src_addr[14]
+ channel_src_addr[15] channel_src_addr[16] channel_src_addr[17]
+ channel_src_addr[18] channel_src_addr[19] channel_src_addr[1]
+ channel_src_addr[20] channel_src_addr[21] channel_src_addr[22]
+ channel_src_addr[23] channel_src_addr[24] channel_src_addr[25]
+ channel_src_addr[26] channel_src_addr[27] channel_src_addr[28]
+ channel_src_addr[29] channel_src_addr[2] channel_src_addr[30]
+ channel_src_addr[31] channel_src_addr[32] channel_src_addr[33]
+ channel_src_addr[34] channel_src_addr[35] channel_src_addr[36]
+ channel_src_addr[37] channel_src_addr[38] channel_src_addr[39]
+ channel_src_addr[3] channel_src_addr[40] channel_src_addr[41]
+ channel_src_addr[42] channel_src_addr[43] channel_src_addr[44]
+ channel_src_addr[45] channel_src_addr[46] channel_src_addr[47]
+ channel_src_addr[48] channel_src_addr[49] channel_src_addr[4]
+ channel_src_addr[50] channel_src_addr[51] channel_src_addr[52]
+ channel_src_addr[53] channel_src_addr[54] channel_src_addr[55]
+ channel_src_addr[56] channel_src_addr[57] channel_src_addr[58]
+ channel_src_addr[59] channel_src_addr[5] channel_src_addr[60]
+ channel_src_addr[61] channel_src_addr[62] channel_src_addr[63]
+ channel_src_addr[64] channel_src_addr[65] channel_src_addr[66]
+ channel_src_addr[67] channel_src_addr[68] channel_src_addr[69]
+ channel_src_addr[6] channel_src_addr[70] channel_src_addr[71]
+ channel_src_addr[72] channel_src_addr[73] channel_src_addr[74]
+ channel_src_addr[75] channel_src_addr[76] channel_src_addr[77]
+ channel_src_addr[78] channel_src_addr[79] channel_src_addr[7]
+ channel_src_addr[80] channel_src_addr[81] channel_src_addr[82]
+ channel_src_addr[83] channel_src_addr[84] channel_src_addr[85]
+ channel_src_addr[86] channel_src_addr[87] channel_src_addr[88]
+ channel_src_addr[89] channel_src_addr[8] channel_src_addr[90]
+ channel_src_addr[91] channel_src_addr[92] channel_src_addr[93]
+ channel_src_addr[94] channel_src_addr[95] channel_src_addr[96]
+ channel_src_addr[97] channel_src_addr[98] channel_src_addr[99]
+ channel_src_addr[9] channel_start[0] channel_start[1] channel_start[2]
+ channel_start[3] clk debug_active_channels[0] debug_active_channels[1]
+ debug_active_channels[2] debug_active_channels[3] debug_channel_state[0]
+ debug_channel_state[10] debug_channel_state[11] debug_channel_state[1]
+ debug_channel_state[2] debug_channel_state[3] debug_channel_state[4]
+ debug_channel_state[5] debug_channel_state[6] debug_channel_state[7]
+ debug_channel_state[8] debug_channel_state[9] debug_has_active_channels
+ debug_transfer_count[0] debug_transfer_count[100] debug_transfer_count[101]
+ debug_transfer_count[102] debug_transfer_count[103] debug_transfer_count[104]
+ debug_transfer_count[105] debug_transfer_count[106] debug_transfer_count[107]
+ debug_transfer_count[108] debug_transfer_count[109] debug_transfer_count[10]
+ debug_transfer_count[110] debug_transfer_count[111] debug_transfer_count[112]
+ debug_transfer_count[113] debug_transfer_count[114] debug_transfer_count[115]
+ debug_transfer_count[116] debug_transfer_count[117] debug_transfer_count[118]
+ debug_transfer_count[119] debug_transfer_count[11] debug_transfer_count[120]
+ debug_transfer_count[121] debug_transfer_count[122] debug_transfer_count[123]
+ debug_transfer_count[124] debug_transfer_count[125] debug_transfer_count[126]
+ debug_transfer_count[127] debug_transfer_count[12] debug_transfer_count[13]
+ debug_transfer_count[14] debug_transfer_count[15] debug_transfer_count[16]
+ debug_transfer_count[17] debug_transfer_count[18] debug_transfer_count[19]
+ debug_transfer_count[1] debug_transfer_count[20] debug_transfer_count[21]
+ debug_transfer_count[22] debug_transfer_count[23] debug_transfer_count[24]
+ debug_transfer_count[25] debug_transfer_count[26] debug_transfer_count[27]
+ debug_transfer_count[28] debug_transfer_count[29] debug_transfer_count[2]
+ debug_transfer_count[30] debug_transfer_count[31] debug_transfer_count[32]
+ debug_transfer_count[33] debug_transfer_count[34] debug_transfer_count[35]
+ debug_transfer_count[36] debug_transfer_count[37] debug_transfer_count[38]
+ debug_transfer_count[39] debug_transfer_count[3] debug_transfer_count[40]
+ debug_transfer_count[41] debug_transfer_count[42] debug_transfer_count[43]
+ debug_transfer_count[44] debug_transfer_count[45] debug_transfer_count[46]
+ debug_transfer_count[47] debug_transfer_count[48] debug_transfer_count[49]
+ debug_transfer_count[4] debug_transfer_count[50] debug_transfer_count[51]
+ debug_transfer_count[52] debug_transfer_count[53] debug_transfer_count[54]
+ debug_transfer_count[55] debug_transfer_count[56] debug_transfer_count[57]
+ debug_transfer_count[58] debug_transfer_count[59] debug_transfer_count[5]
+ debug_transfer_count[60] debug_transfer_count[61] debug_transfer_count[62]
+ debug_transfer_count[63] debug_transfer_count[64] debug_transfer_count[65]
+ debug_transfer_count[66] debug_transfer_count[67] debug_transfer_count[68]
+ debug_transfer_count[69] debug_transfer_count[6] debug_transfer_count[70]
+ debug_transfer_count[71] debug_transfer_count[72] debug_transfer_count[73]
+ debug_transfer_count[74] debug_transfer_count[75] debug_transfer_count[76]
+ debug_transfer_count[77] debug_transfer_count[78] debug_transfer_count[79]
+ debug_transfer_count[7] debug_transfer_count[80] debug_transfer_count[81]
+ debug_transfer_count[82] debug_transfer_count[83] debug_transfer_count[84]
+ debug_transfer_count[85] debug_transfer_count[86] debug_transfer_count[87]
+ debug_transfer_count[88] debug_transfer_count[89] debug_transfer_count[8]
+ debug_transfer_count[90] debug_transfer_count[91] debug_transfer_count[92]
+ debug_transfer_count[93] debug_transfer_count[94] debug_transfer_count[95]
+ debug_transfer_count[96] debug_transfer_count[97] debug_transfer_count[98]
+ debug_transfer_count[99] debug_transfer_count[9] dst_addr[0]
+ dst_addr[100] dst_addr[101] dst_addr[102] dst_addr[103] dst_addr[104]
+ dst_addr[105] dst_addr[106] dst_addr[107] dst_addr[108] dst_addr[109]
+ dst_addr[10] dst_addr[110] dst_addr[111] dst_addr[112] dst_addr[113]
+ dst_addr[114] dst_addr[115] dst_addr[116] dst_addr[117] dst_addr[118]
+ dst_addr[119] dst_addr[11] dst_addr[120] dst_addr[121] dst_addr[122]
+ dst_addr[123] dst_addr[124] dst_addr[125] dst_addr[126] dst_addr[127]
+ dst_addr[12] dst_addr[13] dst_addr[14] dst_addr[15] dst_addr[16]
+ dst_addr[17] dst_addr[18] dst_addr[19] dst_addr[1] dst_addr[20]
+ dst_addr[21] dst_addr[22] dst_addr[23] dst_addr[24] dst_addr[25]
+ dst_addr[26] dst_addr[27] dst_addr[28] dst_addr[29] dst_addr[2]
+ dst_addr[30] dst_addr[31] dst_addr[32] dst_addr[33] dst_addr[34]
+ dst_addr[35] dst_addr[36] dst_addr[37] dst_addr[38] dst_addr[39]
+ dst_addr[3] dst_addr[40] dst_addr[41] dst_addr[42] dst_addr[43]
+ dst_addr[44] dst_addr[45] dst_addr[46] dst_addr[47] dst_addr[48]
+ dst_addr[49] dst_addr[4] dst_addr[50] dst_addr[51] dst_addr[52]
+ dst_addr[53] dst_addr[54] dst_addr[55] dst_addr[56] dst_addr[57]
+ dst_addr[58] dst_addr[59] dst_addr[5] dst_addr[60] dst_addr[61]
+ dst_addr[62] dst_addr[63] dst_addr[64] dst_addr[65] dst_addr[66]
+ dst_addr[67] dst_addr[68] dst_addr[69] dst_addr[6] dst_addr[70]
+ dst_addr[71] dst_addr[72] dst_addr[73] dst_addr[74] dst_addr[75]
+ dst_addr[76] dst_addr[77] dst_addr[78] dst_addr[79] dst_addr[7]
+ dst_addr[80] dst_addr[81] dst_addr[82] dst_addr[83] dst_addr[84]
+ dst_addr[85] dst_addr[86] dst_addr[87] dst_addr[88] dst_addr[89]
+ dst_addr[8] dst_addr[90] dst_addr[91] dst_addr[92] dst_addr[93]
+ dst_addr[94] dst_addr[95] dst_addr[96] dst_addr[97] dst_addr[98]
+ dst_addr[99] dst_addr[9] dst_wdata[0] dst_wdata[100] dst_wdata[101]
+ dst_wdata[102] dst_wdata[103] dst_wdata[104] dst_wdata[105]
+ dst_wdata[106] dst_wdata[107] dst_wdata[108] dst_wdata[109]
+ dst_wdata[10] dst_wdata[110] dst_wdata[111] dst_wdata[112]
+ dst_wdata[113] dst_wdata[114] dst_wdata[115] dst_wdata[116]
+ dst_wdata[117] dst_wdata[118] dst_wdata[119] dst_wdata[11]
+ dst_wdata[120] dst_wdata[121] dst_wdata[122] dst_wdata[123]
+ dst_wdata[124] dst_wdata[125] dst_wdata[126] dst_wdata[127]
+ dst_wdata[12] dst_wdata[13] dst_wdata[14] dst_wdata[15] dst_wdata[16]
+ dst_wdata[17] dst_wdata[18] dst_wdata[19] dst_wdata[1] dst_wdata[20]
+ dst_wdata[21] dst_wdata[22] dst_wdata[23] dst_wdata[24] dst_wdata[25]
+ dst_wdata[26] dst_wdata[27] dst_wdata[28] dst_wdata[29] dst_wdata[2]
+ dst_wdata[30] dst_wdata[31] dst_wdata[32] dst_wdata[33] dst_wdata[34]
+ dst_wdata[35] dst_wdata[36] dst_wdata[37] dst_wdata[38] dst_wdata[39]
+ dst_wdata[3] dst_wdata[40] dst_wdata[41] dst_wdata[42] dst_wdata[43]
+ dst_wdata[44] dst_wdata[45] dst_wdata[46] dst_wdata[47] dst_wdata[48]
+ dst_wdata[49] dst_wdata[4] dst_wdata[50] dst_wdata[51] dst_wdata[52]
+ dst_wdata[53] dst_wdata[54] dst_wdata[55] dst_wdata[56] dst_wdata[57]
+ dst_wdata[58] dst_wdata[59] dst_wdata[5] dst_wdata[60] dst_wdata[61]
+ dst_wdata[62] dst_wdata[63] dst_wdata[64] dst_wdata[65] dst_wdata[66]
+ dst_wdata[67] dst_wdata[68] dst_wdata[69] dst_wdata[6] dst_wdata[70]
+ dst_wdata[71] dst_wdata[72] dst_wdata[73] dst_wdata[74] dst_wdata[75]
+ dst_wdata[76] dst_wdata[77] dst_wdata[78] dst_wdata[79] dst_wdata[7]
+ dst_wdata[80] dst_wdata[81] dst_wdata[82] dst_wdata[83] dst_wdata[84]
+ dst_wdata[85] dst_wdata[86] dst_wdata[87] dst_wdata[88] dst_wdata[89]
+ dst_wdata[8] dst_wdata[90] dst_wdata[91] dst_wdata[92] dst_wdata[93]
+ dst_wdata[94] dst_wdata[95] dst_wdata[96] dst_wdata[97] dst_wdata[98]
+ dst_wdata[99] dst_wdata[9] dst_wready[0] dst_wready[1] dst_wready[2]
+ dst_wready[3] dst_write[0] dst_write[1] dst_write[2] dst_write[3]
+ dst_wstrb[0] dst_wstrb[10] dst_wstrb[11] dst_wstrb[12] dst_wstrb[13]
+ dst_wstrb[14] dst_wstrb[15] dst_wstrb[1] dst_wstrb[2] dst_wstrb[3]
+ dst_wstrb[4] dst_wstrb[5] dst_wstrb[6] dst_wstrb[7] dst_wstrb[8]
+ dst_wstrb[9] rst_n src_addr[0] src_addr[100] src_addr[101]
+ src_addr[102] src_addr[103] src_addr[104] src_addr[105] src_addr[106]
+ src_addr[107] src_addr[108] src_addr[109] src_addr[10] src_addr[110]
+ src_addr[111] src_addr[112] src_addr[113] src_addr[114] src_addr[115]
+ src_addr[116] src_addr[117] src_addr[118] src_addr[119] src_addr[11]
+ src_addr[120] src_addr[121] src_addr[122] src_addr[123] src_addr[124]
+ src_addr[125] src_addr[126] src_addr[127] src_addr[12] src_addr[13]
+ src_addr[14] src_addr[15] src_addr[16] src_addr[17] src_addr[18]
+ src_addr[19] src_addr[1] src_addr[20] src_addr[21] src_addr[22]
+ src_addr[23] src_addr[24] src_addr[25] src_addr[26] src_addr[27]
+ src_addr[28] src_addr[29] src_addr[2] src_addr[30] src_addr[31]
+ src_addr[32] src_addr[33] src_addr[34] src_addr[35] src_addr[36]
+ src_addr[37] src_addr[38] src_addr[39] src_addr[3] src_addr[40]
+ src_addr[41] src_addr[42] src_addr[43] src_addr[44] src_addr[45]
+ src_addr[46] src_addr[47] src_addr[48] src_addr[49] src_addr[4]
+ src_addr[50] src_addr[51] src_addr[52] src_addr[53] src_addr[54]
+ src_addr[55] src_addr[56] src_addr[57] src_addr[58] src_addr[59]
+ src_addr[5] src_addr[60] src_addr[61] src_addr[62] src_addr[63]
+ src_addr[64] src_addr[65] src_addr[66] src_addr[67] src_addr[68]
+ src_addr[69] src_addr[6] src_addr[70] src_addr[71] src_addr[72]
+ src_addr[73] src_addr[74] src_addr[75] src_addr[76] src_addr[77]
+ src_addr[78] src_addr[79] src_addr[7] src_addr[80] src_addr[81]
+ src_addr[82] src_addr[83] src_addr[84] src_addr[85] src_addr[86]
+ src_addr[87] src_addr[88] src_addr[89] src_addr[8] src_addr[90]
+ src_addr[91] src_addr[92] src_addr[93] src_addr[94] src_addr[95]
+ src_addr[96] src_addr[97] src_addr[98] src_addr[99] src_addr[9]
+ src_rdata[0] src_rdata[100] src_rdata[101] src_rdata[102]
+ src_rdata[103] src_rdata[104] src_rdata[105] src_rdata[106]
+ src_rdata[107] src_rdata[108] src_rdata[109] src_rdata[10]
+ src_rdata[110] src_rdata[111] src_rdata[112] src_rdata[113]
+ src_rdata[114] src_rdata[115] src_rdata[116] src_rdata[117]
+ src_rdata[118] src_rdata[119] src_rdata[11] src_rdata[120]
+ src_rdata[121] src_rdata[122] src_rdata[123] src_rdata[124]
+ src_rdata[125] src_rdata[126] src_rdata[127] src_rdata[12]
+ src_rdata[13] src_rdata[14] src_rdata[15] src_rdata[16] src_rdata[17]
+ src_rdata[18] src_rdata[19] src_rdata[1] src_rdata[20] src_rdata[21]
+ src_rdata[22] src_rdata[23] src_rdata[24] src_rdata[25] src_rdata[26]
+ src_rdata[27] src_rdata[28] src_rdata[29] src_rdata[2] src_rdata[30]
+ src_rdata[31] src_rdata[32] src_rdata[33] src_rdata[34] src_rdata[35]
+ src_rdata[36] src_rdata[37] src_rdata[38] src_rdata[39] src_rdata[3]
+ src_rdata[40] src_rdata[41] src_rdata[42] src_rdata[43] src_rdata[44]
+ src_rdata[45] src_rdata[46] src_rdata[47] src_rdata[48] src_rdata[49]
+ src_rdata[4] src_rdata[50] src_rdata[51] src_rdata[52] src_rdata[53]
+ src_rdata[54] src_rdata[55] src_rdata[56] src_rdata[57] src_rdata[58]
+ src_rdata[59] src_rdata[5] src_rdata[60] src_rdata[61] src_rdata[62]
+ src_rdata[63] src_rdata[64] src_rdata[65] src_rdata[66] src_rdata[67]
+ src_rdata[68] src_rdata[69] src_rdata[6] src_rdata[70] src_rdata[71]
+ src_rdata[72] src_rdata[73] src_rdata[74] src_rdata[75] src_rdata[76]
+ src_rdata[77] src_rdata[78] src_rdata[79] src_rdata[7] src_rdata[80]
+ src_rdata[81] src_rdata[82] src_rdata[83] src_rdata[84] src_rdata[85]
+ src_rdata[86] src_rdata[87] src_rdata[88] src_rdata[89] src_rdata[8]
+ src_rdata[90] src_rdata[91] src_rdata[92] src_rdata[93] src_rdata[94]
+ src_rdata[95] src_rdata[96] src_rdata[97] src_rdata[98] src_rdata[99]
+ src_rdata[9] src_read[0] src_read[1] src_read[2] src_read[3]
+ src_rready[0] src_rready[1] src_rready[2] src_rready[3] src_rvalid[0]
+ src_rvalid[1] src_rvalid[2] src_rvalid[3]
X_1443_ transfer_count\[1\]\[2\] transfer_count\[1\]\[3\]
+ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__nand2_1
X_1444_ transfer_count\[1\]\[4\] transfer_count\[1\]\[5\]
+ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__nand2_2
X_1445_ transfer_count\[1\]\[0\] transfer_count\[1\]\[1\]
+ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__nand2_1
X_1446_ transfer_count\[1\]\[6\] VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__clkbuf_2
X_1447_ transfer_count\[1\]\[7\] _0800_ VSS VSS VDD VDD _0801_
+ sky130_fd_sc_hd__nand2_1
X_1448_ _0797_ _0798_ _0799_ _0801_ VSS VSS VDD VDD _0802_
+ sky130_fd_sc_hd__nor4_2
X_1449_ _0802_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__clkbuf_4
X_1450_ transfer_count\[1\]\[10\] transfer_count\[1\]\[9\]
+ transfer_count\[1\]\[8\] VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__and3_1
X_1451_ transfer_count\[1\]\[12\] transfer_count\[1\]\[11\]
+ _0803_ _0804_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__and4_1
X_1452_ transfer_count\[1\]\[13\] _0805_ VSS VSS VDD VDD _1039_
+ sky130_fd_sc_hd__xnor2_1
X_1453_ transfer_count\[1\]\[8\] _0803_ VSS VSS VDD VDD _0806_
+ sky130_fd_sc_hd__nand2_1
X_1454_ transfer_count\[1\]\[9\] _0806_ VSS VSS VDD VDD _1051_
+ sky130_fd_sc_hd__xor2_1
X_1455_ transfer_count\[1\]\[28\] transfer_count\[1\]\[27\]
+ transfer_count\[1\]\[26\] VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__and3_1
X_1456_ transfer_count\[1\]\[16\] VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__inv_1
X_1457_ transfer_count\[1\]\[10\] transfer_count\[1\]\[9\]
+ transfer_count\[1\]\[8\] VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__nand3_2
X_1458_ transfer_count\[1\]\[13\] transfer_count\[1\]\[12\]
+ transfer_count\[1\]\[11\] VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__nand3_1
X_1459_ transfer_count\[1\]\[14\] transfer_count\[1\]\[15\]
+ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__nand2_1
X_1460_ _0808_ _0809_ _0810_ _0811_ VSS VSS VDD VDD _0812_
+ sky130_fd_sc_hd__nor4_4
X_1461_ transfer_count\[1\]\[17\] VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__clkbuf_2
X_1462_ transfer_count\[1\]\[20\] transfer_count\[1\]\[19\]
+ transfer_count\[1\]\[18\] _0813_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__nand4_1
X_1463_ transfer_count\[1\]\[22\] transfer_count\[1\]\[21\]
+ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__nand2_1
X_1464_ _0814_ _0815_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__nor2_1
X_1465_ _0812_ _0816_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__and2_0
X_1466_ _0817_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__buf_4
X_1467_ transfer_count\[1\]\[25\] transfer_count\[1\]\[24\]
+ transfer_count\[1\]\[23\] VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__and3_2
X_1468_ _0802_ _0807_ _0818_ _0819_ VSS VSS VDD VDD _0820_
+ sky130_fd_sc_hd__nand4_4
X_1469_ transfer_count\[1\]\[29\] _0820_ VSS VSS VDD VDD _1063_
+ sky130_fd_sc_hd__xor2_1
X_1470_ transfer_count\[1\]\[25\] VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__inv_1
X_1471_ transfer_count\[1\]\[24\] transfer_count\[1\]\[23\]
+ _0803_ _0818_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__nand4_1
X_1472_ _0821_ _0822_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__xnor2_1
X_1473_ _0803_ _0812_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__nand2_2
X_1474_ _0814_ _0823_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__nor2_1
X_1475_ transfer_count\[1\]\[21\] _0824_ VSS VSS VDD VDD _1087_
+ sky130_fd_sc_hd__xnor2_1
X_1476_ _0813_ _0823_ VSS VSS VDD VDD _1099_ sky130_fd_sc_hd__xor2_1
X_1477_ channel_state\[1\]\[0\] VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__clkbuf_4
X_1478_ channel_state\[1\]\[1\] VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__buf_2
X_1479_ _0825_ _0826_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__nor2_2
X_1480_ net139 channel_state\[1\]\[2\] _0827_ VSS VSS VDD
+ VDD _0828_ sky130_fd_sc_hd__nand3_4
X_1481_ _0828_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__clkbuf_4
X_1482_ _1101_ _1103_ _1100_ _1097_ VSS VSS VDD VDD _0830_
+ sky130_fd_sc_hd__a211oi_1
X_1483_ _1098_ _1097_ _1095_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__o21ai_0
X_1484_ _1091_ _1094_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__nor2_1
X_1485_ _0830_ _0831_ _0832_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__o21a_1
X_1486_ _1092_ _1091_ _1083_ _1089_ _1086_ VSS VSS VDD VDD
+ _0834_ sky130_fd_sc_hd__o2111ai_1
X_1487_ _1086_ _1088_ _1085_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__a21o_1
X_1488_ _1083_ _0835_ _1082_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__a21oi_1
X_1489_ _0833_ _0834_ _0836_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__o21ai_1
X_1490_ _1059_ _1062_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__nand2_1
X_1491_ _1065_ _1068_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__nand2_1
X_1492_ _0838_ _0839_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__nor2_1
X_1493_ _1077_ _1079_ _1076_ VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__a21oi_1
X_1494_ _1071_ _1074_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__nand2_1
X_1495_ _1071_ _1073_ _1070_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__a21oi_1
X_1496_ _0841_ _0842_ _0843_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__o21ai_2
X_1497_ _1065_ _1067_ _1064_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__a21oi_1
X_1498_ _1059_ _1061_ _1058_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__a21oi_1
X_1499_ _0838_ _0845_ _0846_ VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__o21ai_0
X_1500_ _0840_ _0844_ _0847_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__a21oi_1
X_1501_ _1035_ _1041_ _1038_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__and3_1
X_1502_ _1053_ _1055_ _1052_ _1049_ VSS VSS VDD VDD _0850_
+ sky130_fd_sc_hd__a211oi_1
X_1503_ _1050_ _1049_ _1047_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__o21ai_0
X_1504_ _1043_ _1046_ VSS VSS VDD VDD _0852_ sky130_fd_sc_hd__nor2_1
X_1505_ _0850_ _0851_ _0852_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__o21ai_0
X_1506_ _1044_ _1043_ _0849_ _0853_ VSS VSS VDD VDD _0854_
+ sky130_fd_sc_hd__o211ai_2
X_1507_ _1410_ _1416_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__nor2b_1
X_1508_ _1415_ _0855_ _1419_ _1422_ VSS VSS VDD VDD _0856_
+ sky130_fd_sc_hd__o211ai_1
X_1509_ _1419_ _1421_ _1418_ VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__a21oi_1
X_1510_ _1053_ _1044_ _1050_ _1056_ VSS VSS VDD VDD _0858_
+ sky130_fd_sc_hd__and4_1
X_1511_ _1425_ _1431_ _1428_ _1434_ VSS VSS VDD VDD _0859_
+ sky130_fd_sc_hd__and4_1
X_1512_ _1047_ _0858_ _0849_ _0859_ VSS VSS VDD VDD _0860_
+ sky130_fd_sc_hd__nand4_2
X_1513_ _0856_ _0857_ _0860_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__a21o_1
X_1514_ _1047_ _0858_ _0849_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__and3_1
X_1515_ _1425_ _1428_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__nand2_1
X_1516_ _1431_ _1433_ _1430_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__a21oi_1
X_1517_ _1425_ _1427_ _1424_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__a21oi_1
X_1518_ _0863_ _0864_ _0865_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__o21ai_1
X_1519_ _1038_ _1040_ _1037_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__a21o_1
X_1520_ _0862_ _0866_ _0867_ _1035_ _1034_ VSS VSS VDD VDD
+ _0868_ sky130_fd_sc_hd__a221oi_1
X_1521_ _0848_ _0854_ _0861_ _0868_ VSS VSS VDD VDD _0869_
+ sky130_fd_sc_hd__nand4_1
X_1522_ _1083_ _1089_ _1101_ _1086_ VSS VSS VDD VDD _0870_
+ sky130_fd_sc_hd__nand4_1
X_1523_ _1095_ _1092_ _1098_ _1104_ VSS VSS VDD VDD _0871_
+ sky130_fd_sc_hd__nand4_1
X_1524_ _1419_ _1416_ _1411_ _1422_ VSS VSS VDD VDD _0872_
+ sky130_fd_sc_hd__nand4_1
X_1525_ _0870_ _0871_ _0860_ _0872_ VSS VSS VDD VDD _0873_
+ sky130_fd_sc_hd__nor4_1
X_1526_ _1077_ _1080_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__nand2_1
X_1527_ _0842_ _0874_ VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__nor2_1
X_1528_ _0840_ _0875_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__nand2_1
X_1529_ _0873_ _0848_ _0876_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__mux2i_1
X_1530_ _0870_ _0871_ _0847_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__o21bai_1
X_1531_ _0840_ _0844_ _0878_ _0837_ VSS VSS VDD VDD _0879_
+ sky130_fd_sc_hd__a211o_1
X_1532_ _0837_ _0869_ _0877_ _0879_ VSS VSS VDD VDD _0880_
+ sky130_fd_sc_hd__o211a_1
X_1533_ channel_state\[1\]\[2\] net3 VSS VSS VDD VDD _0881_
+ sky130_fd_sc_hd__nor2b_1
X_1534_ net135 _0881_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__nand2_2
X_1535_ _0825_ _0826_ _0882_ VSS VSS VDD VDD _0883_ sky130_fd_sc_hd__nor3_1
X_1536_ _0829_ _0880_ _0883_ net147 VSS VSS VDD VDD _0005_
+ sky130_fd_sc_hd__o22a_1
X_1537_ transfer_count\[3\]\[24\] VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__buf_6
X_1538_ transfer_count\[3\]\[26\] transfer_count\[3\]\[25\]
+ _0884_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__and3_1
X_1539_ transfer_count\[3\]\[28\] transfer_count\[3\]\[27\]
+ _0885_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__nand3_1
X_1540_ transfer_count\[3\]\[23\] VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__buf_6
X_1541_ transfer_count\[3\]\[20\] transfer_count\[3\]\[19\]
+ transfer_count\[3\]\[18\] VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__nand3_2
X_1542_ transfer_count\[3\]\[22\] transfer_count\[3\]\[21\]
+ VSS VSS VDD VDD _0889_ sky130_fd_sc_hd__nand2_1
X_1543_ _0888_ _0889_ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__nor2_1
X_1544_ transfer_count\[3\]\[5\] transfer_count\[3\]\[4\]
+ transfer_count\[3\]\[3\] transfer_count\[3\]\[2\] VSS VSS
+ VDD VDD _0891_ sky130_fd_sc_hd__nand4_4
X_1545_ transfer_count\[3\]\[6\] transfer_count\[3\]\[1\]
+ transfer_count\[3\]\[0\] VSS VSS VDD VDD _0892_ sky130_fd_sc_hd__nand3_1
X_1546_ _0891_ _0892_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__nor2_2
X_1547_ transfer_count\[3\]\[15\] VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__clkbuf_2
X_1548_ transfer_count\[3\]\[17\] transfer_count\[3\]\[16\]
+ _0894_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__nand3_2
X_1549_ transfer_count\[3\]\[14\] transfer_count\[3\]\[13\]
+ transfer_count\[3\]\[12\] transfer_count\[3\]\[11\] VSS VSS
+ VDD VDD _0896_ sky130_fd_sc_hd__nand4_2
X_1550_ transfer_count\[3\]\[10\] transfer_count\[3\]\[9\]
+ transfer_count\[3\]\[8\] transfer_count\[3\]\[7\] VSS VSS
+ VDD VDD _0897_ sky130_fd_sc_hd__nand4_4
X_1551_ _0895_ _0896_ _0897_ VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__nor3_4
X_1552_ _0887_ _0890_ _0893_ _0898_ VSS VSS VDD VDD _0899_
+ sky130_fd_sc_hd__nand4_2
X_1553_ _0886_ _0899_ VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__nor2_1
X_1554_ transfer_count\[3\]\[29\] _0900_ VSS VSS VDD VDD _1111_
+ sky130_fd_sc_hd__xnor2_1
X_1555_ transfer_count\[3\]\[26\] transfer_count\[3\]\[25\]
+ _0884_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__nand3_1
X_1556_ _0901_ _0899_ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__nor2_1
X_1557_ transfer_count\[3\]\[27\] _0902_ VSS VSS VDD VDD _1117_
+ sky130_fd_sc_hd__xnor2_1
X_1558_ _0895_ _0896_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__or2_1
X_1559_ _0897_ _0891_ _0892_ VSS VSS VDD VDD _0904_ sky130_fd_sc_hd__or3_1
X_1560_ _0904_ VSS VSS VDD VDD _0905_ sky130_fd_sc_hd__buf_6
X_1561_ _0888_ _0889_ _0903_ _0905_ VSS VSS VDD VDD _0906_
+ sky130_fd_sc_hd__nor4_4
X_1562_ _0884_ _0887_ _0906_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__nand3_1
X_1563_ transfer_count\[3\]\[25\] _0907_ VSS VSS VDD VDD _1123_
+ sky130_fd_sc_hd__xor2_1
X_1564_ _0887_ _0906_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__xnor2_1
X_1565_ _0888_ _0895_ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__nor2_1
X_1566_ _0896_ _0905_ VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__nor2_2
X_1567_ _0908_ _0909_ VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__nand2_1
X_1568_ transfer_count\[3\]\[21\] _0910_ VSS VSS VDD VDD _1135_
+ sky130_fd_sc_hd__xor2_1
X_1569_ _0903_ _0905_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__nor2_1
X_1570_ transfer_count\[3\]\[18\] _0911_ VSS VSS VDD VDD _0912_
+ sky130_fd_sc_hd__nand2_1
X_1571_ transfer_count\[3\]\[19\] _0912_ VSS VSS VDD VDD _1141_
+ sky130_fd_sc_hd__xor2_1
X_1572_ _0894_ _0909_ VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__xnor2_1
X_1573_ transfer_count\[3\]\[12\] transfer_count\[3\]\[11\]
+ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__nand2_1
X_1574_ _0913_ _0905_ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__nor2_1
X_1575_ transfer_count\[3\]\[13\] _0914_ VSS VSS VDD VDD _1159_
+ sky130_fd_sc_hd__xnor2_1
X_1576_ transfer_count\[3\]\[11\] VSS VSS VDD VDD _0915_ sky130_fd_sc_hd__inv_1
X_1577_ _0915_ _0905_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__xnor2_1
X_1578_ transfer_count\[3\]\[8\] transfer_count\[3\]\[7\]
+ _0893_ VSS VSS VDD VDD _0916_ sky130_fd_sc_hd__and3_1
X_1579_ transfer_count\[3\]\[9\] _0916_ VSS VSS VDD VDD _1171_
+ sky130_fd_sc_hd__xnor2_1
X_1580_ transfer_count\[3\]\[7\] _0893_ VSS VSS VDD VDD _1177_
+ sky130_fd_sc_hd__xnor2_1
X_1581_ transfer_count\[3\]\[4\] transfer_count\[3\]\[3\]
+ transfer_count\[3\]\[2\] VSS VSS VDD VDD _0917_ sky130_fd_sc_hd__and3_1
X_1582_ transfer_count\[3\]\[1\] transfer_count\[3\]\[0\]
+ _0917_ VSS VSS VDD VDD _0918_ sky130_fd_sc_hd__nand3_1
X_1583_ transfer_count\[3\]\[5\] _0918_ VSS VSS VDD VDD _1183_
+ sky130_fd_sc_hd__xor2_1
X_1584_ transfer_count\[3\]\[2\] transfer_count\[3\]\[1\]
+ transfer_count\[3\]\[0\] VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__nand3_1
X_1585_ transfer_count\[3\]\[3\] _0919_ VSS VSS VDD VDD _1189_
+ sky130_fd_sc_hd__xor2_1
X_1586_ channel_state\[3\]\[2\] VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__buf_2
X_1587_ channel_state\[3\]\[0\] channel_state\[3\]\[1\] VSS
+ VSS VDD VDD _0921_ sky130_fd_sc_hd__nor2_1
X_1588_ net141 _0920_ _0921_ VSS VSS VDD VDD _0922_ sky130_fd_sc_hd__nand3_2
X_1589_ _0922_ VSS VSS VDD VDD _0923_ sky130_fd_sc_hd__clkbuf_4
X_1590_ _1115_ _1113_ _1112_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__a21oi_1
X_1591_ _1107_ _1110_ VSS VSS VDD VDD _0925_ sky130_fd_sc_hd__nand2_1
X_1592_ _1107_ _1109_ _1106_ VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__a21oi_1
X_1593_ _0924_ _0925_ _0926_ VSS VSS VDD VDD _0927_ sky130_fd_sc_hd__o21ai_0
X_1594_ _1107_ _1110_ _1116_ _1113_ VSS VSS VDD VDD _0928_
+ sky130_fd_sc_hd__nand4_1
X_1595_ _1127_ _1122_ _1125_ VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__nand3_1
X_1596_ _1122_ _1124_ _1121_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__a21oi_1
X_1597_ _0929_ _0930_ VSS VSS VDD VDD _0931_ sky130_fd_sc_hd__nand2_1
X_1598_ _1119_ _1122_ _1128_ _1125_ VSS VSS VDD VDD _0932_
+ sky130_fd_sc_hd__nand4_1
X_1599_ _1131_ _1133_ _1130_ VSS VSS VDD VDD _0933_ sky130_fd_sc_hd__a21oi_1
X_1600_ _0932_ _0933_ VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__nor2_1
X_1601_ _1119_ _0931_ _0934_ _1118_ VSS VSS VDD VDD _0935_
+ sky130_fd_sc_hd__a211oi_1
X_1602_ _1139_ _1140_ _1137_ VSS VSS VDD VDD _0936_ sky130_fd_sc_hd__o21a_1
X_1603_ _1131_ _1134_ VSS VSS VDD VDD _0937_ sky130_fd_sc_hd__nand2_1
X_1604_ _0928_ _0932_ _0937_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__nor3_1
X_1605_ _1151_ _1149_ _1148_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__a21oi_1
X_1606_ _1143_ _1146_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__nand2_1
X_1607_ _1143_ _1145_ _1136_ _1139_ _1142_ VSS VSS VDD VDD
+ _0941_ sky130_fd_sc_hd__a2111oi_0
X_1608_ _0939_ _0940_ _0941_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__o21ai_0
X_1609_ _1136_ _0936_ _0938_ _0942_ VSS VSS VDD VDD _0943_
+ sky130_fd_sc_hd__o211ai_1
X_1610_ _0928_ _0935_ _0943_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__o21ai_0
X_1611_ _0928_ _0932_ _0937_ VSS VSS VDD VDD _0945_ sky130_fd_sc_hd__nor3_1
X_1612_ _1143_ _1140_ VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__and2_0
X_1613_ _1146_ _1149_ _1152_ _1137_ VSS VSS VDD VDD _0947_
+ sky130_fd_sc_hd__and4_1
X_1614_ _1155_ _1167_ _1164_ _1173_ VSS VSS VDD VDD _0948_
+ sky130_fd_sc_hd__nand4_1
X_1615_ _1158_ _1170_ _1176_ _1161_ VSS VSS VDD VDD _0949_
+ sky130_fd_sc_hd__nand4_1
X_1616_ _1179_ _1182_ _1188_ _1185_ VSS VSS VDD VDD _0950_
+ sky130_fd_sc_hd__nand4_1
X_1617_ _1191_ _1199_ _1203_ _1194_ VSS VSS VDD VDD _0951_
+ sky130_fd_sc_hd__nand4_1
X_1618_ _0948_ _0949_ _0950_ _0951_ VSS VSS VDD VDD _0952_
+ sky130_fd_sc_hd__nor4_2
X_1619_ _0945_ _0946_ _0947_ _0952_ VSS VSS VDD VDD _0953_
+ sky130_fd_sc_hd__nand4_1
X_1620_ _0927_ _0944_ _0953_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__o21a_1
X_1621_ _1202_ _1199_ VSS VSS VDD VDD _0955_ sky130_fd_sc_hd__nor2b_1
X_1622_ _1198_ _0955_ _1191_ _1194_ VSS VSS VDD VDD _0956_
+ sky130_fd_sc_hd__o211ai_1
X_1623_ _1191_ _1193_ _1190_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__a21oi_1
X_1624_ _0956_ _0957_ _0950_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__a21oi_1
X_1625_ _1187_ _1182_ _1185_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__nand3_1
X_1626_ _1182_ _1184_ _1181_ VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__a21oi_1
X_1627_ _0959_ _0960_ _1179_ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__a21boi_0
X_1628_ _0948_ _0949_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__nor2_1
X_1629_ _1178_ _0958_ _0961_ _0962_ VSS VSS VDD VDD _0963_
+ sky130_fd_sc_hd__o31ai_2
X_1630_ _1155_ _1157_ _1160_ _1163_ VSS VSS VDD VDD _0964_
+ sky130_fd_sc_hd__a211oi_1
X_1631_ _1175_ _1170_ _1173_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__nand3_1
X_1632_ _1170_ _1172_ _1169_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__a21oi_1
X_1633_ _1167_ _1164_ VSS VSS VDD VDD _0967_ sky130_fd_sc_hd__nand2_1
X_1634_ _0965_ _0966_ _0967_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__a21o_1
X_1635_ _1164_ _1166_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__nand2_1
X_1636_ _1161_ _1160_ _1158_ VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__o21a_1
X_1637_ _1157_ _0970_ _1155_ VSS VSS VDD VDD _0971_ sky130_fd_sc_hd__o21ai_0
X_1638_ _0964_ _0968_ _0969_ _0971_ VSS VSS VDD VDD _0972_
+ sky130_fd_sc_hd__a31oi_1
X_1639_ _1154_ _0972_ VSS VSS VDD VDD _0973_ sky130_fd_sc_hd__nor2_1
X_1640_ _0945_ _0946_ _0947_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__nand3_1
X_1641_ _0963_ _0973_ _0952_ _0974_ VSS VSS VDD VDD _0975_
+ sky130_fd_sc_hd__a211oi_4
X_1642_ channel_state\[3\]\[0\] VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__buf_2
X_1643_ channel_state\[3\]\[2\] net5 VSS VSS VDD VDD _0977_
+ sky130_fd_sc_hd__nor2b_1
X_1644_ net137 _0977_ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__nand2_1
X_1645_ _0976_ channel_state\[3\]\[1\] _0978_ VSS VSS VDD
+ VDD _0979_ sky130_fd_sc_hd__nor3_1
X_1646_ _0923_ _0954_ _0975_ _0979_ net149 VSS VSS VDD VDD
+ _0007_ sky130_fd_sc_hd__o32a_1
X_1647_ channel_state\[0\]\[0\] VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__buf_2
X_1648_ channel_state\[0\]\[1\] VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__clkbuf_2
X_1649_ net134 channel_state\[0\]\[2\] VSS VSS VDD VDD _0982_
+ sky130_fd_sc_hd__nor2b_1
X_1650_ channel_state\[0\]\[2\] net2 net134 VSS VSS VDD VDD
+ _0983_ sky130_fd_sc_hd__nand3b_1
X_1651_ _0981_ _0983_ VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__nor2_1
X_1652_ _0981_ _0982_ _0984_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__a21oi_1
X_1653_ _0980_ _0985_ net154 VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__o21a_1
X_1654_ transfer_count\[0\]\[2\] transfer_count\[0\]\[1\]
+ transfer_count\[0\]\[0\] VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__and3_1
X_1655_ _0986_ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__clkbuf_2
X_1656_ transfer_count\[0\]\[3\] transfer_count\[0\]\[4\]
+ _0987_ VSS VSS VDD VDD _0988_ sky130_fd_sc_hd__nand3_1
X_1657_ transfer_count\[0\]\[5\] _0988_ VSS VSS VDD VDD _1225_
+ sky130_fd_sc_hd__xor2_1
X_1658_ transfer_count\[0\]\[8\] VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__clkbuf_2
X_1659_ transfer_count\[0\]\[10\] transfer_count\[0\]\[9\]
+ _0989_ VSS VSS VDD VDD _0990_ sky130_fd_sc_hd__nand3_1
X_1660_ transfer_count\[0\]\[7\] VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__buf_2
X_1661_ transfer_count\[0\]\[3\] transfer_count\[0\]\[5\]
+ transfer_count\[0\]\[4\] VSS VSS VDD VDD _0992_ sky130_fd_sc_hd__and3_2
X_1662_ transfer_count\[0\]\[6\] _0991_ _0987_ _0992_ VSS
+ VSS VDD VDD _0993_ sky130_fd_sc_hd__nand4_4
X_1663_ _0990_ _0993_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__nor2_1
X_1664_ transfer_count\[0\]\[12\] transfer_count\[0\]\[11\]
+ _0994_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__nand3_1
X_1665_ transfer_count\[0\]\[13\] _0995_ VSS VSS VDD VDD _1237_
+ sky130_fd_sc_hd__xor2_1
X_1666_ transfer_count\[0\]\[6\] _0987_ _0992_ VSS VSS VDD
+ VDD _0996_ sky130_fd_sc_hd__and3_1
X_1667_ _0996_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__clkbuf_2
X_1668_ _0991_ _0989_ _0997_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__nand3_1
X_1669_ transfer_count\[0\]\[9\] _0998_ VSS VSS VDD VDD _1249_
+ sky130_fd_sc_hd__xor2_1
X_1670_ transfer_count\[0\]\[22\] VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__clkbuf_2
X_1671_ transfer_count\[0\]\[25\] transfer_count\[0\]\[24\]
+ transfer_count\[0\]\[23\] _0999_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__and4_1
X_1672_ _1000_ VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1673_ transfer_count\[0\]\[28\] transfer_count\[0\]\[27\]
+ transfer_count\[0\]\[26\] _1001_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__and4_1
X_1674_ transfer_count\[0\]\[16\] VSS VSS VDD VDD _1003_ sky130_fd_sc_hd__buf_2
X_1675_ transfer_count\[0\]\[18\] transfer_count\[0\]\[17\]
+ _1003_ VSS VSS VDD VDD _1004_ sky130_fd_sc_hd__and3_1
X_1676_ transfer_count\[0\]\[21\] transfer_count\[0\]\[20\]
+ transfer_count\[0\]\[19\] _1004_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__nand4_4
X_1677_ transfer_count\[0\]\[10\] transfer_count\[0\]\[9\]
+ _0989_ VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__and3_2
X_1678_ transfer_count\[0\]\[13\] transfer_count\[0\]\[12\]
+ transfer_count\[0\]\[11\] VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__and3_1
X_1679_ transfer_count\[0\]\[14\] transfer_count\[0\]\[15\]
+ _1006_ _1007_ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__nand4_4
X_1680_ _0993_ _1005_ _1008_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__nor3_4
X_1681_ _1002_ _1009_ VSS VSS VDD VDD _1010_ sky130_fd_sc_hd__nand2_1
X_1682_ transfer_count\[0\]\[29\] _1010_ VSS VSS VDD VDD _1261_
+ sky130_fd_sc_hd__xor2_1
X_1683_ transfer_count\[0\]\[24\] transfer_count\[0\]\[23\]
+ _0999_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__and3_1
X_1684_ _1011_ _1009_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__nand2_1
X_1685_ transfer_count\[0\]\[25\] _1012_ VSS VSS VDD VDD _1273_
+ sky130_fd_sc_hd__xor2_1
X_1686_ transfer_count\[0\]\[20\] transfer_count\[0\]\[19\]
+ _1004_ VSS VSS VDD VDD _1013_ sky130_fd_sc_hd__and3_1
X_1687_ transfer_count\[0\]\[14\] _1006_ _1007_ VSS VSS VDD
+ VDD _1014_ sky130_fd_sc_hd__nand3_1
X_1688_ _0993_ _1014_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__nor2_2
X_1689_ transfer_count\[0\]\[15\] _1013_ _1015_ VSS VSS VDD
+ VDD _1016_ sky130_fd_sc_hd__and3_1
X_1690_ transfer_count\[0\]\[21\] _1016_ VSS VSS VDD VDD _1285_
+ sky130_fd_sc_hd__xnor2_1
X_1691_ transfer_count\[0\]\[15\] _1003_ _1015_ VSS VSS VDD
+ VDD _0146_ sky130_fd_sc_hd__nand3_1
X_1692_ transfer_count\[0\]\[17\] _0146_ VSS VSS VDD VDD _1297_
+ sky130_fd_sc_hd__xor2_1
X_1693_ net138 channel_state\[0\]\[2\] VSS VSS VDD VDD _0147_
+ sky130_fd_sc_hd__nand2_1
X_1694_ _0980_ _0981_ _0147_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__nor3_1
X_1695_ _0148_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__clkbuf_4
X_1696_ _0149_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__clkbuf_4
X_1697_ _1257_ _1263_ _1260_ _1266_ VSS VSS VDD VDD _0151_
+ sky130_fd_sc_hd__nand4_2
X_1698_ _1269_ _1275_ _1272_ _1278_ VSS VSS VDD VDD _0152_
+ sky130_fd_sc_hd__nand4_1
X_1699_ _1281_ _1287_ _1284_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__nand3_1
X_1700_ _0151_ _0152_ _0153_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__nor3_2
X_1701_ _1293_ _1290_ _1296_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__and3_1
X_1702_ _1299_ _1302_ _0154_ _0155_ VSS VSS VDD VDD _0156_
+ sky130_fd_sc_hd__nand4_2
X_1703_ _1233_ _1239_ _1236_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__nand3_1
X_1704_ _1251_ _1242_ _1248_ _1254_ VSS VSS VDD VDD _0158_
+ sky130_fd_sc_hd__nand4_1
X_1705_ _0157_ _0158_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__nor2_1
X_1706_ _1215_ _1218_ _1230_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__nand3_1
X_1707_ _1207_ _1221_ _1227_ _1224_ VSS VSS VDD VDD _0161_
+ sky130_fd_sc_hd__nand4_1
X_1708_ _0160_ _0161_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__nor2_1
X_1709_ _1212_ _1245_ _0159_ _0162_ VSS VSS VDD VDD _0163_
+ sky130_fd_sc_hd__nand4_2
X_1710_ _1293_ _1295_ _1292_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__a21o_1
X_1711_ _1299_ _1301_ _1298_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__a21o_1
X_1712_ _1290_ _0164_ _0165_ _0155_ _1289_ VSS VSS VDD VDD
+ _0166_ sky130_fd_sc_hd__a221oi_1
X_1713_ _0166_ _0154_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__nor2b_1
X_1714_ _1275_ _1277_ _1274_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__a21o_1
X_1715_ _1269_ _1272_ _0168_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__nand3_1
X_1716_ _1269_ _1271_ _1268_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__a21oi_1
X_1717_ _0169_ _0170_ _0151_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__a21oi_1
X_1718_ _1284_ _1286_ _1283_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__a21o_1
X_1719_ _1281_ _0172_ _1280_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__a21oi_1
X_1720_ _1263_ _1265_ _1262_ _1259_ VSS VSS VDD VDD _0174_
+ sky130_fd_sc_hd__a211oi_1
X_1721_ _1260_ _1259_ _1257_ VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__o21ai_0
X_1722_ _0151_ _0152_ _0173_ _0174_ _0175_ VSS VSS VDD VDD
+ _0176_ sky130_fd_sc_hd__o32ai_1
X_1723_ _1256_ _0167_ _0171_ _0176_ VSS VSS VDD VDD _0177_
+ sky130_fd_sc_hd__or4_2
X_1724_ _1236_ _1238_ _1235_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__a21o_1
X_1725_ _1233_ _0178_ _1232_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__a21oi_1
X_1726_ _1224_ _1226_ _1223_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__a21o_1
X_1727_ _1221_ _0180_ _1229_ _1220_ VSS VSS VDD VDD _0181_
+ sky130_fd_sc_hd__a211o_1
X_1728_ _1211_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__inv_1
X_1729_ _1206_ _1212_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__nand2b_1
X_1730_ _0182_ _0183_ _0160_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__a21oi_1
X_1731_ _1215_ _1217_ _1214_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__a21oi_1
X_1732_ _0185_ _1230_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__nor2b_1
X_1733_ _1227_ _1223_ _1226_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__nor3_1
X_1734_ _1224_ _1223_ _1221_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__o21ai_0
X_1735_ _0187_ _0188_ _1220_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__o21bai_1
X_1736_ _1245_ _1254_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__nand2_1
X_1737_ _1251_ _1242_ _1248_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__nand3_1
X_1738_ _0157_ _0190_ _0191_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__nor3_1
X_1739_ _0181_ _0184_ _0186_ _0189_ _0192_ VSS VSS VDD VDD
+ _0193_ sky130_fd_sc_hd__o311ai_2
X_1740_ _1251_ _1253_ _1250_ _1247_ VSS VSS VDD VDD _0194_
+ sky130_fd_sc_hd__a211oi_1
X_1741_ _1248_ _1247_ _1245_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__o21ai_0
X_1742_ _0194_ _0195_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__nor2_1
X_1743_ _1242_ _1241_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__nor2_1
X_1744_ _0157_ _0197_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__nor2_1
X_1745_ _1241_ _1244_ _0196_ _0198_ VSS VSS VDD VDD _0199_
+ sky130_fd_sc_hd__o31ai_1
X_1746_ _0179_ _0193_ _0199_ _0156_ VSS VSS VDD VDD _0200_
+ sky130_fd_sc_hd__a31oi_2
X_1747_ _0156_ _0163_ _0177_ _0200_ VSS VSS VDD VDD _0201_
+ sky130_fd_sc_hd__o22ai_4
X_1748_ _0980_ _0981_ _0983_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__nor3_2
X_1749_ net146 _0202_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__nor2_1
X_1750_ _0150_ _0201_ _0203_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__a21oi_1
X_1751_ transfer_count\[3\]\[0\] VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__inv_1
X_1752_ _0923_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__clkbuf_4
X_1753_ net141 channel_state\[3\]\[2\] _0921_ VSS VSS VDD
+ VDD _0205_ sky130_fd_sc_hd__and3_1
X_1754_ _0205_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__buf_2
X_1755_ _0206_ _0979_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__nor2_1
X_1756_ _0207_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__clkbuf_4
X_1757_ transfer_count\[3\]\[0\] _0208_ VSS VSS VDD VDD _0209_
+ sky130_fd_sc_hd__nand2_1
X_1758_ transfer_count\[3\]\[0\] _0204_ _0209_ VSS VSS VDD
+ VDD _0109_ sky130_fd_sc_hd__o21ai_0
X_1759_ _1196_ VSS VSS VDD VDD _1197_ sky130_fd_sc_hd__inv_1
X_1760_ transfer_count\[3\]\[1\] _0208_ VSS VSS VDD VDD _0210_
+ sky130_fd_sc_hd__nand2_1
X_1761_ _1197_ _0204_ _0210_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__o21ai_0
X_1762_ _1195_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__clkbuf_2
X_1763_ _0206_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__clkbuf_4
X_1764_ _0211_ _0212_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__nand2_1
X_1765_ _0922_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__clkbuf_4
X_1766_ _0976_ channel_state\[3\]\[1\] _0978_ _0922_ VSS VSS
+ VDD VDD _0215_ sky130_fd_sc_hd__o31ai_2
X_1767_ _0215_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__clkbuf_4
X_1768_ _0211_ _0214_ _0216_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__o21ai_0
X_1769_ transfer_count\[3\]\[2\] _0217_ VSS VSS VDD VDD _0218_
+ sky130_fd_sc_hd__nand2_1
X_1770_ transfer_count\[3\]\[2\] _0213_ _0218_ VSS VSS VDD
+ VDD _0131_ sky130_fd_sc_hd__o21ai_0
X_1771_ transfer_count\[3\]\[3\] _0208_ VSS VSS VDD VDD _0219_
+ sky130_fd_sc_hd__nand2_1
X_1772_ _1189_ _0204_ _0219_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__o21ai_0
X_1773_ transfer_count\[3\]\[3\] transfer_count\[3\]\[2\]
+ _0211_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__nand3_1
X_1774_ transfer_count\[3\]\[4\] _0220_ VSS VSS VDD VDD _1186_
+ sky130_fd_sc_hd__xor2_1
X_1775_ transfer_count\[3\]\[4\] _0208_ VSS VSS VDD VDD _0221_
+ sky130_fd_sc_hd__nand2_1
X_1776_ _0204_ _1186_ _0221_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__o21ai_0
X_1777_ transfer_count\[3\]\[5\] _0208_ VSS VSS VDD VDD _0222_
+ sky130_fd_sc_hd__nand2_1
X_1778_ _1183_ _0204_ _0222_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__o21ai_0
X_1779_ _0923_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__clkbuf_4
X_1780_ transfer_count\[3\]\[5\] _0917_ VSS VSS VDD VDD _0224_
+ sky130_fd_sc_hd__and2_0
X_1781_ _0211_ _0224_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__nand2_1
X_1782_ _0207_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__buf_4
X_1783_ _0211_ _0224_ _0214_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__a21oi_1
X_1784_ _0226_ _0227_ transfer_count\[3\]\[6\] VSS VSS VDD
+ VDD _0228_ sky130_fd_sc_hd__o21ai_0
X_1785_ transfer_count\[3\]\[6\] _0223_ _0225_ _0228_ VSS
+ VSS VDD VDD _0137_ sky130_fd_sc_hd__o31ai_1
X_1786_ _0893_ _0214_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__nor2_1
X_1787_ _0226_ _0229_ transfer_count\[3\]\[7\] VSS VSS VDD
+ VDD _0230_ sky130_fd_sc_hd__o21ai_0
X_1788_ transfer_count\[3\]\[7\] _0891_ _0892_ _0223_ _0230_
+ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__o41ai_1
X_1789_ transfer_count\[3\]\[6\] _0211_ VSS VSS VDD VDD _0231_
+ sky130_fd_sc_hd__nand2_1
X_1790_ _0891_ _0231_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__nor2_2
X_1791_ transfer_count\[3\]\[7\] _0232_ VSS VSS VDD VDD _0233_
+ sky130_fd_sc_hd__nand2_1
X_1792_ transfer_count\[3\]\[8\] _0233_ VSS VSS VDD VDD _1174_
+ sky130_fd_sc_hd__xor2_1
X_1793_ transfer_count\[3\]\[8\] _0208_ VSS VSS VDD VDD _0234_
+ sky130_fd_sc_hd__nand2_1
X_1794_ _0204_ _1174_ _0234_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__o21ai_0
X_1795_ transfer_count\[3\]\[9\] _0208_ VSS VSS VDD VDD _0235_
+ sky130_fd_sc_hd__nand2_1
X_1796_ _1171_ _0204_ _0235_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__o21ai_0
X_1797_ transfer_count\[3\]\[9\] transfer_count\[3\]\[8\]
+ transfer_count\[3\]\[7\] _0232_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__and4_1
X_1798_ transfer_count\[3\]\[10\] _0236_ VSS VSS VDD VDD _1168_
+ sky130_fd_sc_hd__xnor2_1
X_1799_ transfer_count\[3\]\[10\] _0208_ VSS VSS VDD VDD _0237_
+ sky130_fd_sc_hd__nand2_1
X_1800_ _0204_ _1168_ _0237_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__o21ai_0
X_1801_ _0905_ _0206_ _0207_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__a21oi_1
X_1802_ transfer_count\[3\]\[11\] _0905_ _0922_ VSS VSS VDD
+ VDD _0239_ sky130_fd_sc_hd__or3_1
X_1803_ _0915_ _0238_ _0239_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__o21ai_0
X_1804_ _0915_ _0897_ _0891_ _0231_ VSS VSS VDD VDD _0240_
+ sky130_fd_sc_hd__nor4_1
X_1805_ transfer_count\[3\]\[12\] _0240_ VSS VSS VDD VDD _1162_
+ sky130_fd_sc_hd__xnor2_1
X_1806_ transfer_count\[3\]\[12\] _0208_ VSS VSS VDD VDD _0241_
+ sky130_fd_sc_hd__nand2_1
X_1807_ _0204_ _1162_ _0241_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__o21ai_0
X_1808_ _0914_ _0212_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__nand2_1
X_1809_ _0914_ _0214_ _0216_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__o21ai_0
X_1810_ transfer_count\[3\]\[13\] _0243_ VSS VSS VDD VDD _0244_
+ sky130_fd_sc_hd__nand2_1
X_1811_ transfer_count\[3\]\[13\] _0242_ _0244_ VSS VSS VDD
+ VDD _0113_ sky130_fd_sc_hd__o21ai_0
X_1812_ transfer_count\[3\]\[13\] transfer_count\[3\]\[12\]
+ transfer_count\[3\]\[11\] VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__nand3_1
X_1813_ _0245_ _0897_ _0891_ _0231_ VSS VSS VDD VDD _0246_
+ sky130_fd_sc_hd__nor4_2
X_1814_ _0212_ _0246_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__nand2_1
X_1815_ _0923_ _0246_ _0216_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__o21ai_0
X_1816_ transfer_count\[3\]\[14\] _0248_ VSS VSS VDD VDD _0249_
+ sky130_fd_sc_hd__nand2_1
X_1817_ transfer_count\[3\]\[14\] _0247_ _0249_ VSS VSS VDD
+ VDD _0114_ sky130_fd_sc_hd__o21ai_0
X_1818_ _0909_ _0923_ _0215_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__o21ai_0
X_1819_ _0894_ _0214_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__nor2_1
X_1820_ _0894_ _0250_ _0251_ _0909_ VSS VSS VDD VDD _0115_
+ sky130_fd_sc_hd__a22o_1
X_1821_ _0894_ transfer_count\[3\]\[14\] _0246_ VSS VSS VDD
+ VDD _0252_ sky130_fd_sc_hd__and3_1
X_1822_ _0212_ _0252_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__nand2_1
X_1823_ _0923_ _0252_ _0216_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__o21ai_0
X_1824_ transfer_count\[3\]\[16\] _0254_ VSS VSS VDD VDD _0255_
+ sky130_fd_sc_hd__nand2_1
X_1825_ transfer_count\[3\]\[16\] _0253_ _0255_ VSS VSS VDD
+ VDD _0116_ sky130_fd_sc_hd__o21ai_0
X_1826_ transfer_count\[3\]\[16\] _0894_ _0909_ VSS VSS VDD
+ VDD _0256_ sky130_fd_sc_hd__nand3_1
X_1827_ transfer_count\[3\]\[16\] _0894_ _0909_ _0923_ VSS
+ VSS VDD VDD _0257_ sky130_fd_sc_hd__a31oi_1
X_1828_ _0226_ _0257_ transfer_count\[3\]\[17\] VSS VSS VDD
+ VDD _0258_ sky130_fd_sc_hd__o21ai_0
X_1829_ transfer_count\[3\]\[17\] _0223_ _0256_ _0258_ VSS
+ VSS VDD VDD _0117_ sky130_fd_sc_hd__o31ai_1
X_1830_ _0898_ _0232_ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__nand2_1
X_1831_ _0898_ _0232_ _0214_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__a21oi_1
X_1832_ _0226_ _0260_ transfer_count\[3\]\[18\] VSS VSS VDD
+ VDD _0261_ sky130_fd_sc_hd__o21ai_0
X_1833_ transfer_count\[3\]\[18\] _0223_ _0259_ _0261_ VSS
+ VSS VDD VDD _0118_ sky130_fd_sc_hd__o31ai_1
X_1834_ transfer_count\[3\]\[19\] _0226_ VSS VSS VDD VDD _0262_
+ sky130_fd_sc_hd__nand2_1
X_1835_ _1141_ _0204_ _0262_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__o21ai_0
X_1836_ transfer_count\[3\]\[19\] transfer_count\[3\]\[18\]
+ _0898_ _0232_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__and4_1
X_1837_ _0923_ _0263_ _0215_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__o21ai_0
X_1838_ transfer_count\[3\]\[20\] _0214_ VSS VSS VDD VDD _0265_
+ sky130_fd_sc_hd__nor2_1
X_1839_ transfer_count\[3\]\[20\] _0264_ _0265_ _0263_ VSS
+ VSS VDD VDD _0121_ sky130_fd_sc_hd__a22o_1
X_1840_ _0908_ _0909_ _0214_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__a21oi_1
X_1841_ _0226_ _0266_ transfer_count\[3\]\[21\] VSS VSS VDD
+ VDD _0267_ sky130_fd_sc_hd__o21ai_0
X_1842_ transfer_count\[3\]\[21\] _0910_ _0223_ _0267_ VSS
+ VSS VDD VDD _0122_ sky130_fd_sc_hd__o31ai_1
X_1843_ transfer_count\[3\]\[21\] transfer_count\[3\]\[20\]
+ _0263_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__and3_1
X_1844_ _0268_ _0206_ VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__nand2b_1
X_1845_ _0212_ _0268_ transfer_count\[3\]\[22\] VSS VSS VDD
+ VDD _0270_ sky130_fd_sc_hd__a21oi_1
X_1846_ transfer_count\[3\]\[22\] _0216_ _0269_ _0270_ VSS
+ VSS VDD VDD _0123_ sky130_fd_sc_hd__a31oi_1
X_1847_ _0906_ _0212_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__nand2_1
X_1848_ _0906_ _0214_ _0216_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__o21ai_0
X_1849_ _0887_ _0272_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__nand2_1
X_1850_ _0887_ _0271_ _0273_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__o21ai_0
X_1851_ _0887_ _0890_ _0898_ _0232_ VSS VSS VDD VDD _0274_
+ sky130_fd_sc_hd__nand4_4
X_1852_ _0206_ _0274_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__and2_0
X_1853_ _0226_ _0275_ _0884_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__o21ai_0
X_1854_ _0884_ _0223_ _0274_ _0276_ VSS VSS VDD VDD _0125_
+ sky130_fd_sc_hd__o31ai_1
X_1855_ _0884_ _0887_ _0906_ _0923_ VSS VSS VDD VDD _0277_
+ sky130_fd_sc_hd__a31oi_1
X_1856_ _0226_ _0277_ transfer_count\[3\]\[25\] VSS VSS VDD
+ VDD _0278_ sky130_fd_sc_hd__o21ai_0
X_1857_ transfer_count\[3\]\[25\] _0907_ _0223_ _0278_ VSS
+ VSS VDD VDD _0126_ sky130_fd_sc_hd__o31ai_1
X_1858_ transfer_count\[3\]\[25\] _0884_ VSS VSS VDD VDD _0279_
+ sky130_fd_sc_hd__nand2_1
X_1859_ _0279_ _0274_ _0206_ VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__o21ai_0
X_1860_ _0279_ _0274_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__nor2_1
X_1861_ _0212_ _0281_ transfer_count\[3\]\[26\] VSS VSS VDD
+ VDD _0282_ sky130_fd_sc_hd__a21oi_1
X_1862_ transfer_count\[3\]\[26\] _0216_ _0280_ _0282_ VSS
+ VSS VDD VDD _0127_ sky130_fd_sc_hd__a31oi_1
X_1863_ _0887_ _0906_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__nand2_1
X_1864_ _0887_ _0885_ _0906_ _0214_ VSS VSS VDD VDD _0284_
+ sky130_fd_sc_hd__a31oi_1
X_1865_ _0226_ _0284_ transfer_count\[3\]\[27\] VSS VSS VDD
+ VDD _0285_ sky130_fd_sc_hd__o21ai_0
X_1866_ transfer_count\[3\]\[27\] _0901_ _0283_ _0223_ _0285_
+ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__o41ai_1
X_1867_ transfer_count\[3\]\[27\] _0885_ VSS VSS VDD VDD _0286_
+ sky130_fd_sc_hd__nand2_1
X_1868_ _0286_ _0274_ _0206_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__o21ai_0
X_1869_ _0286_ _0274_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__nor2_1
X_1870_ _0212_ _0288_ transfer_count\[3\]\[28\] VSS VSS VDD
+ VDD _0289_ sky130_fd_sc_hd__a21oi_1
X_1871_ transfer_count\[3\]\[28\] _0216_ _0287_ _0289_ VSS
+ VSS VDD VDD _0129_ sky130_fd_sc_hd__a31oi_1
X_1872_ transfer_count\[3\]\[28\] transfer_count\[3\]\[27\]
+ _0885_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__and3_1
X_1873_ _0887_ _0290_ _0906_ _0923_ VSS VSS VDD VDD _0291_
+ sky130_fd_sc_hd__a31oi_1
X_1874_ _0226_ _0291_ transfer_count\[3\]\[29\] VSS VSS VDD
+ VDD _0292_ sky130_fd_sc_hd__o21ai_0
X_1875_ transfer_count\[3\]\[29\] _0886_ _0283_ _0223_ _0292_
+ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__o41ai_1
X_1876_ transfer_count\[3\]\[29\] _0290_ VSS VSS VDD VDD _0293_
+ sky130_fd_sc_hd__nand2_1
X_1877_ _0274_ _0293_ _0206_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__o21ai_0
X_1878_ _0274_ _0293_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__nor2_1
X_1879_ _0212_ _0295_ transfer_count\[3\]\[30\] VSS VSS VDD
+ VDD _0296_ sky130_fd_sc_hd__a21oi_1
X_1880_ transfer_count\[3\]\[30\] _0216_ _0294_ _0296_ VSS
+ VSS VDD VDD _0132_ sky130_fd_sc_hd__a31oi_1
X_1881_ transfer_count\[3\]\[30\] transfer_count\[3\]\[29\]
+ _0290_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__nand3_1
X_1882_ _0899_ _0297_ _0206_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__o21ai_0
X_1883_ _0899_ _0297_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__nor2_1
X_1884_ _0212_ _0299_ transfer_count\[3\]\[31\] VSS VSS VDD
+ VDD _0300_ sky130_fd_sc_hd__a21oi_1
X_1885_ transfer_count\[3\]\[31\] _0216_ _0298_ _0300_ VSS
+ VSS VDD VDD _0133_ sky130_fd_sc_hd__a31oi_1
X_1886_ transfer_count\[2\]\[0\] VSS VSS VDD VDD _1405_ sky130_fd_sc_hd__inv_1
X_1887_ channel_state\[2\]\[0\] channel_state\[2\]\[2\] VSS
+ VSS VDD VDD _0301_ sky130_fd_sc_hd__nand2b_1
X_1888_ channel_state\[2\]\[1\] _0301_ VSS VSS VDD VDD _0302_
+ sky130_fd_sc_hd__nor2_1
X_1889_ net140 _0302_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__nand2_2
X_1890_ _0303_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__buf_2
X_1891_ net140 _0302_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__and2_0
X_1892_ _0305_ VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__buf_2
X_1893_ channel_state\[2\]\[0\] VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__inv_1
X_1894_ channel_state\[2\]\[2\] VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__buf_2
X_1895_ _0308_ net4 VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__nor2b_1
X_1896_ _0307_ net136 _0309_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__and3_1
X_1897_ channel_state\[2\]\[1\] _0310_ VSS VSS VDD VDD _0311_
+ sky130_fd_sc_hd__nor2b_1
X_1898_ _0306_ _0311_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__nor2_2
X_1899_ _0312_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__buf_2
X_1900_ transfer_count\[2\]\[0\] _0313_ VSS VSS VDD VDD _0314_
+ sky130_fd_sc_hd__nand2_1
X_1901_ transfer_count\[2\]\[0\] _0304_ _0314_ VSS VSS VDD
+ VDD _0077_ sky130_fd_sc_hd__o21ai_0
X_1902_ _1400_ VSS VSS VDD VDD _1401_ sky130_fd_sc_hd__inv_1
X_1903_ transfer_count\[2\]\[1\] _0313_ VSS VSS VDD VDD _0315_
+ sky130_fd_sc_hd__nand2_1
X_1904_ _1401_ _0304_ _0315_ VSS VSS VDD VDD _0088_ sky130_fd_sc_hd__o21ai_0
X_1905_ _0306_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__clkbuf_4
X_1906_ _1399_ _0316_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__nand2_1
X_1907_ _0312_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__clkbuf_4
X_1908_ _0303_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__clkbuf_4
X_1909_ _1399_ _0319_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__nor2_1
X_1910_ _0318_ _0320_ transfer_count\[2\]\[2\] VSS VSS VDD
+ VDD _0321_ sky130_fd_sc_hd__o21ai_0
X_1911_ transfer_count\[2\]\[2\] _0317_ _0321_ VSS VSS VDD
+ VDD _0099_ sky130_fd_sc_hd__o21ai_0
X_1912_ transfer_count\[2\]\[0\] transfer_count\[2\]\[1\]
+ transfer_count\[2\]\[2\] VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__nand3_1
X_1913_ transfer_count\[2\]\[3\] _0322_ VSS VSS VDD VDD _1393_
+ sky130_fd_sc_hd__xor2_1
X_1914_ transfer_count\[2\]\[3\] _0313_ VSS VSS VDD VDD _0323_
+ sky130_fd_sc_hd__nand2_1
X_1915_ _0304_ _1393_ _0323_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__o21ai_0
X_1916_ transfer_count\[2\]\[4\] VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__buf_4
X_1917_ transfer_count\[2\]\[2\] transfer_count\[2\]\[3\]
+ _1399_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__and3_1
X_1918_ _0324_ _0325_ VSS VSS VDD VDD _1390_ sky130_fd_sc_hd__xnor2_2
X_1919_ _0324_ _0313_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__nand2_1
X_1920_ _0304_ _1390_ _0326_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__o21ai_0
X_1921_ transfer_count\[2\]\[0\] transfer_count\[2\]\[1\]
+ transfer_count\[2\]\[2\] transfer_count\[2\]\[3\] VSS VSS
+ VDD VDD _0327_ sky130_fd_sc_hd__and4_1
X_1922_ _0324_ _0327_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__nand2_1
X_1923_ transfer_count\[2\]\[5\] _0328_ VSS VSS VDD VDD _1387_
+ sky130_fd_sc_hd__xor2_1
X_1924_ _0324_ _0327_ _0319_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__a21oi_1
X_1925_ _0313_ _0329_ transfer_count\[2\]\[5\] VSS VSS VDD
+ VDD _0330_ sky130_fd_sc_hd__o21ai_0
X_1926_ transfer_count\[2\]\[5\] _0304_ _0328_ _0330_ VSS
+ VSS VDD VDD _0104_ sky130_fd_sc_hd__o31ai_1
X_1927_ _0324_ transfer_count\[2\]\[5\] _0325_ VSS VSS VDD
+ VDD _0331_ sky130_fd_sc_hd__and3_1
X_1928_ _0316_ _0331_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__nand2_1
X_1929_ _0319_ _0331_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__nor2_1
X_1930_ _0318_ _0333_ transfer_count\[2\]\[6\] VSS VSS VDD
+ VDD _0334_ sky130_fd_sc_hd__o21ai_0
X_1931_ transfer_count\[2\]\[6\] _0332_ _0334_ VSS VSS VDD
+ VDD _0105_ sky130_fd_sc_hd__o21ai_0
X_1932_ transfer_count\[2\]\[5\] transfer_count\[2\]\[6\]
+ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__and2_1
X_1933_ _0324_ _0327_ _0335_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__and3_1
X_1934_ _0336_ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__dlymetal6s2s_1
X_1935_ transfer_count\[2\]\[7\] _0337_ VSS VSS VDD VDD _1381_
+ sky130_fd_sc_hd__xnor2_1
X_1936_ _0324_ _0327_ _0335_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__nand3_2
X_1937_ _0319_ _0337_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__nor2_1
X_1938_ _0313_ _0339_ transfer_count\[2\]\[7\] VSS VSS VDD
+ VDD _0340_ sky130_fd_sc_hd__o21ai_0
X_1939_ transfer_count\[2\]\[7\] _0304_ _0338_ _0340_ VSS
+ VSS VDD VDD _0106_ sky130_fd_sc_hd__o31ai_1
X_1940_ transfer_count\[2\]\[6\] transfer_count\[2\]\[7\]
+ _0331_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__nand3_1
X_1941_ _0306_ _0341_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__and2_0
X_1942_ _0313_ _0342_ transfer_count\[2\]\[8\] VSS VSS VDD
+ VDD _0343_ sky130_fd_sc_hd__o21ai_0
X_1943_ transfer_count\[2\]\[8\] _0304_ _0341_ _0343_ VSS
+ VSS VDD VDD _0107_ sky130_fd_sc_hd__o31ai_1
X_1944_ transfer_count\[2\]\[7\] transfer_count\[2\]\[8\]
+ _0337_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__nand3_1
X_1945_ transfer_count\[2\]\[9\] _0344_ VSS VSS VDD VDD _1375_
+ sky130_fd_sc_hd__xor2_2
X_1946_ _0306_ _0344_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__and2_0
X_1947_ _0313_ _0345_ transfer_count\[2\]\[9\] VSS VSS VDD
+ VDD _0346_ sky130_fd_sc_hd__o21ai_0
X_1948_ transfer_count\[2\]\[9\] _0304_ _0344_ _0346_ VSS
+ VSS VDD VDD _0108_ sky130_fd_sc_hd__o31ai_1
X_1949_ transfer_count\[2\]\[10\] VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__clkbuf_2
X_1950_ transfer_count\[2\]\[7\] transfer_count\[2\]\[8\]
+ transfer_count\[2\]\[9\] VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__and3_2
X_1951_ _0324_ _0325_ _0335_ _0348_ VSS VSS VDD VDD _0349_
+ sky130_fd_sc_hd__nand4_4
X_1952_ net140 _0302_ _0349_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__and3_1
X_1953_ _0313_ _0350_ _0347_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__o21ai_0
X_1954_ _0347_ _0304_ _0349_ _0351_ VSS VSS VDD VDD _0078_
+ sky130_fd_sc_hd__o31ai_1
X_1955_ _0347_ _0337_ _0348_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__nand3_1
X_1956_ transfer_count\[2\]\[11\] _0352_ VSS VSS VDD VDD _1369_
+ sky130_fd_sc_hd__xor2_1
X_1957_ _0312_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__buf_2
X_1958_ _0306_ _0352_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__and2_0
X_1959_ _0353_ _0354_ transfer_count\[2\]\[11\] VSS VSS VDD
+ VDD _0355_ sky130_fd_sc_hd__o21ai_0
X_1960_ transfer_count\[2\]\[11\] _0304_ _0352_ _0355_ VSS
+ VSS VDD VDD _0079_ sky130_fd_sc_hd__o31ai_1
X_1961_ _0347_ transfer_count\[2\]\[11\] VSS VSS VDD VDD _0356_
+ sky130_fd_sc_hd__nand2_1
X_1962_ _0349_ _0356_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__nor2_1
X_1963_ _0316_ _0357_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__nand2_1
X_1964_ _0319_ _0357_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__nor2_1
X_1965_ _0318_ _0359_ transfer_count\[2\]\[12\] VSS VSS VDD
+ VDD _0360_ sky130_fd_sc_hd__o21ai_0
X_1966_ transfer_count\[2\]\[12\] _0358_ _0360_ VSS VSS VDD
+ VDD _0080_ sky130_fd_sc_hd__o21ai_0
X_1967_ transfer_count\[2\]\[11\] transfer_count\[2\]\[12\]
+ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__and2_0
X_1968_ _0347_ _0337_ _0348_ _0361_ VSS VSS VDD VDD _0362_
+ sky130_fd_sc_hd__nand4_1
X_1969_ transfer_count\[2\]\[13\] _0362_ VSS VSS VDD VDD _1363_
+ sky130_fd_sc_hd__xor2_1
X_1970_ _0303_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__clkbuf_4
X_1971_ _0306_ _0362_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__and2_0
X_1972_ _0353_ _0364_ transfer_count\[2\]\[13\] VSS VSS VDD
+ VDD _0365_ sky130_fd_sc_hd__o21ai_0
X_1973_ transfer_count\[2\]\[13\] _0363_ _0362_ _0365_ VSS
+ VSS VDD VDD _0081_ sky130_fd_sc_hd__o31ai_1
X_1974_ transfer_count\[2\]\[12\] transfer_count\[2\]\[13\]
+ _0357_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__nand3_1
X_1975_ _0303_ VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__buf_2
X_1976_ transfer_count\[2\]\[12\] transfer_count\[2\]\[13\]
+ _0357_ _0367_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__a31oi_1
X_1977_ _0353_ _0368_ transfer_count\[2\]\[14\] VSS VSS VDD
+ VDD _0369_ sky130_fd_sc_hd__o21ai_0
X_1978_ transfer_count\[2\]\[14\] _0363_ _0366_ _0369_ VSS
+ VSS VDD VDD _0082_ sky130_fd_sc_hd__o31ai_1
X_1979_ transfer_count\[2\]\[15\] VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__clkbuf_2
X_1980_ transfer_count\[2\]\[12\] transfer_count\[2\]\[13\]
+ transfer_count\[2\]\[14\] VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__and3_1
X_1981_ _0347_ transfer_count\[2\]\[11\] _0348_ _0371_ VSS
+ VSS VDD VDD _0372_ sky130_fd_sc_hd__nand4_2
X_1982_ _0338_ _0372_ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__nor2_4
X_1983_ _0370_ _0373_ VSS VSS VDD VDD _1357_ sky130_fd_sc_hd__xnor2_1
X_1984_ _0316_ _0373_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__nand2_1
X_1985_ _0367_ _0373_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__nor2_1
X_1986_ _0318_ _0375_ _0370_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__o21ai_0
X_1987_ _0370_ _0374_ _0376_ VSS VSS VDD VDD _0083_ sky130_fd_sc_hd__o21ai_0
X_1988_ _0347_ transfer_count\[2\]\[11\] _0371_ VSS VSS VDD
+ VDD _0377_ sky130_fd_sc_hd__nand3_1
X_1989_ _0349_ _0377_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__nor2_1
X_1990_ _0378_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__buf_2
X_1991_ _0370_ _0379_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__nand2_1
X_1992_ _0370_ _0379_ _0319_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__a21oi_1
X_1993_ _0353_ _0381_ transfer_count\[2\]\[16\] VSS VSS VDD
+ VDD _0382_ sky130_fd_sc_hd__o21ai_0
X_1994_ transfer_count\[2\]\[16\] _0363_ _0380_ _0382_ VSS
+ VSS VDD VDD _0084_ sky130_fd_sc_hd__o31ai_1
X_1995_ _0370_ transfer_count\[2\]\[16\] _0373_ VSS VSS VDD
+ VDD _0383_ sky130_fd_sc_hd__nand3_1
X_1996_ _0370_ transfer_count\[2\]\[16\] _0373_ _0367_ VSS
+ VSS VDD VDD _0384_ sky130_fd_sc_hd__a31oi_1
X_1997_ _0353_ _0384_ transfer_count\[2\]\[17\] VSS VSS VDD
+ VDD _0385_ sky130_fd_sc_hd__o21ai_0
X_1998_ transfer_count\[2\]\[17\] _0363_ _0383_ _0385_ VSS
+ VSS VDD VDD _0085_ sky130_fd_sc_hd__o31ai_1
X_1999_ _0370_ transfer_count\[2\]\[16\] transfer_count\[2\]\[17\]
+ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__and3_1
X_2000_ _0386_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__clkbuf_2
X_2001_ _0379_ _0387_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__nand2_1
X_2002_ _0379_ _0387_ _0319_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__a21oi_1
X_2003_ _0353_ _0389_ transfer_count\[2\]\[18\] VSS VSS VDD
+ VDD _0390_ sky130_fd_sc_hd__o21ai_0
X_2004_ transfer_count\[2\]\[18\] _0363_ _0388_ _0390_ VSS
+ VSS VDD VDD _0086_ sky130_fd_sc_hd__o31ai_1
X_2005_ transfer_count\[2\]\[18\] _0373_ _0387_ VSS VSS VDD
+ VDD _0391_ sky130_fd_sc_hd__nand3_1
X_2006_ transfer_count\[2\]\[19\] _0391_ VSS VSS VDD VDD _1345_
+ sky130_fd_sc_hd__xor2_1
X_2007_ transfer_count\[2\]\[18\] _0373_ _0387_ _0367_ VSS
+ VSS VDD VDD _0392_ sky130_fd_sc_hd__a31oi_1
X_2008_ _0353_ _0392_ transfer_count\[2\]\[19\] VSS VSS VDD
+ VDD _0393_ sky130_fd_sc_hd__o21ai_0
X_2009_ transfer_count\[2\]\[19\] _0363_ _0391_ _0393_ VSS
+ VSS VDD VDD _0087_ sky130_fd_sc_hd__o31ai_1
X_2010_ _0370_ transfer_count\[2\]\[16\] transfer_count\[2\]\[17\]
+ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__nand3_1
X_2011_ transfer_count\[2\]\[18\] transfer_count\[2\]\[19\]
+ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__nand2_1
X_2012_ _0349_ _0377_ _0394_ _0395_ VSS VSS VDD VDD _0396_
+ sky130_fd_sc_hd__nor4_1
X_2013_ _0316_ _0396_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__nand2_1
X_2014_ _0367_ _0396_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__nor2_1
X_2015_ _0318_ _0398_ transfer_count\[2\]\[20\] VSS VSS VDD
+ VDD _0399_ sky130_fd_sc_hd__o21ai_0
X_2016_ transfer_count\[2\]\[20\] _0397_ _0399_ VSS VSS VDD
+ VDD _0089_ sky130_fd_sc_hd__o21ai_0
X_2017_ transfer_count\[2\]\[18\] transfer_count\[2\]\[19\]
+ transfer_count\[2\]\[20\] VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__and3_1
X_2018_ _0373_ _0387_ _0400_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__nand3_1
X_2019_ transfer_count\[2\]\[21\] _0401_ VSS VSS VDD VDD _1339_
+ sky130_fd_sc_hd__xor2_1
X_2020_ _0373_ _0387_ _0400_ _0367_ VSS VSS VDD VDD _0402_
+ sky130_fd_sc_hd__a31oi_1
X_2021_ _0353_ _0402_ transfer_count\[2\]\[21\] VSS VSS VDD
+ VDD _0403_ sky130_fd_sc_hd__o21ai_0
X_2022_ transfer_count\[2\]\[21\] _0363_ _0401_ _0403_ VSS
+ VSS VDD VDD _0090_ sky130_fd_sc_hd__o31ai_1
X_2023_ transfer_count\[2\]\[22\] VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__inv_1
X_2024_ transfer_count\[2\]\[21\] _0378_ _0387_ _0400_ VSS
+ VSS VDD VDD _0405_ sky130_fd_sc_hd__nand4_1
X_2025_ _0316_ _0405_ _0312_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__a21oi_1
X_2026_ transfer_count\[2\]\[22\] _0303_ _0405_ VSS VSS VDD
+ VDD _0407_ sky130_fd_sc_hd__or3_1
X_2027_ _0404_ _0406_ _0407_ VSS VSS VDD VDD _0091_ sky130_fd_sc_hd__o21ai_0
X_2028_ transfer_count\[2\]\[23\] VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__clkbuf_2
X_2029_ transfer_count\[2\]\[21\] transfer_count\[2\]\[22\]
+ _0387_ _0400_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__and4_1
X_2030_ _0409_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__clkbuf_2
X_2031_ _0338_ _0372_ _0410_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__nor3b_1
X_2032_ _0411_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__buf_2
X_2033_ _0408_ _0412_ VSS VSS VDD VDD _1333_ sky130_fd_sc_hd__xnor2_1
X_2034_ _0316_ _0412_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__nand2_1
X_2035_ _0367_ _0412_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__nor2_1
X_2036_ _0318_ _0414_ _0408_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__o21ai_0
X_2037_ _0408_ _0413_ _0415_ VSS VSS VDD VDD _0092_ sky130_fd_sc_hd__o21ai_0
X_2038_ _0408_ _0379_ _0410_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__nand3_1
X_2039_ _0408_ _0379_ _0410_ _0367_ VSS VSS VDD VDD _0417_
+ sky130_fd_sc_hd__a31oi_1
X_2040_ _0353_ _0417_ transfer_count\[2\]\[24\] VSS VSS VDD
+ VDD _0418_ sky130_fd_sc_hd__o21ai_0
X_2041_ transfer_count\[2\]\[24\] _0363_ _0416_ _0418_ VSS
+ VSS VDD VDD _0093_ sky130_fd_sc_hd__o31ai_1
X_2042_ _0408_ transfer_count\[2\]\[24\] _0412_ VSS VSS VDD
+ VDD _0419_ sky130_fd_sc_hd__nand3_1
X_2043_ transfer_count\[2\]\[25\] _0419_ VSS VSS VDD VDD _1327_
+ sky130_fd_sc_hd__xor2_1
X_2044_ _0408_ transfer_count\[2\]\[24\] _0412_ _0367_ VSS
+ VSS VDD VDD _0420_ sky130_fd_sc_hd__a31oi_1
X_2045_ _0353_ _0420_ transfer_count\[2\]\[25\] VSS VSS VDD
+ VDD _0421_ sky130_fd_sc_hd__o21ai_0
X_2046_ transfer_count\[2\]\[25\] _0363_ _0419_ _0421_ VSS
+ VSS VDD VDD _0094_ sky130_fd_sc_hd__o31ai_1
X_2047_ _0408_ transfer_count\[2\]\[24\] transfer_count\[2\]\[25\]
+ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__and3_1
X_2048_ _0379_ _0410_ _0422_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__nand3_1
X_2049_ _0379_ _0410_ _0422_ _0367_ VSS VSS VDD VDD _0424_
+ sky130_fd_sc_hd__a31oi_1
X_2050_ _0318_ _0424_ transfer_count\[2\]\[26\] VSS VSS VDD
+ VDD _0425_ sky130_fd_sc_hd__o21ai_0
X_2051_ transfer_count\[2\]\[26\] _0363_ _0423_ _0425_ VSS
+ VSS VDD VDD _0095_ sky130_fd_sc_hd__o31ai_1
X_2052_ transfer_count\[2\]\[26\] _0411_ _0422_ VSS VSS VDD
+ VDD _0426_ sky130_fd_sc_hd__and3_1
X_2053_ transfer_count\[2\]\[27\] _0426_ VSS VSS VDD VDD _1321_
+ sky130_fd_sc_hd__xnor2_1
X_2054_ _0316_ _0426_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__nand2_1
X_2055_ transfer_count\[2\]\[26\] _0412_ _0422_ _0303_ VSS
+ VSS VDD VDD _0428_ sky130_fd_sc_hd__a31oi_1
X_2056_ _0312_ _0428_ transfer_count\[2\]\[27\] VSS VSS VDD
+ VDD _0429_ sky130_fd_sc_hd__o21ai_0
X_2057_ transfer_count\[2\]\[27\] _0427_ _0429_ VSS VSS VDD
+ VDD _0096_ sky130_fd_sc_hd__o21ai_0
X_2058_ transfer_count\[2\]\[26\] transfer_count\[2\]\[27\]
+ _0422_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__and3_1
X_2059_ _0379_ _0410_ _0430_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__nand3_1
X_2060_ _0379_ _0410_ _0430_ _0303_ VSS VSS VDD VDD _0432_
+ sky130_fd_sc_hd__a31oi_1
X_2061_ _0318_ _0432_ transfer_count\[2\]\[28\] VSS VSS VDD
+ VDD _0433_ sky130_fd_sc_hd__o21ai_0
X_2062_ transfer_count\[2\]\[28\] _0319_ _0431_ _0433_ VSS
+ VSS VDD VDD _0097_ sky130_fd_sc_hd__o31ai_1
X_2063_ transfer_count\[2\]\[28\] _0412_ _0430_ VSS VSS VDD
+ VDD _0434_ sky130_fd_sc_hd__nand3_1
X_2064_ transfer_count\[2\]\[29\] _0434_ VSS VSS VDD VDD _1315_
+ sky130_fd_sc_hd__xor2_1
X_2065_ transfer_count\[2\]\[28\] _0412_ _0430_ _0303_ VSS
+ VSS VDD VDD _0435_ sky130_fd_sc_hd__a31oi_1
X_2066_ _0318_ _0435_ transfer_count\[2\]\[29\] VSS VSS VDD
+ VDD _0436_ sky130_fd_sc_hd__o21ai_0
X_2067_ transfer_count\[2\]\[29\] _0319_ _0434_ _0436_ VSS
+ VSS VDD VDD _0098_ sky130_fd_sc_hd__o31ai_1
X_2068_ transfer_count\[2\]\[28\] transfer_count\[2\]\[29\]
+ _0430_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__and3_1
X_2069_ _0378_ _0410_ _0437_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__and3_1
X_2070_ _0438_ _0306_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__nand2b_1
X_2071_ _0312_ transfer_count\[2\]\[30\] VSS VSS VDD VDD _0440_
+ sky130_fd_sc_hd__nor2b_1
X_2072_ _0316_ _0438_ transfer_count\[2\]\[30\] VSS VSS VDD
+ VDD _0441_ sky130_fd_sc_hd__a21oi_1
X_2073_ _0439_ _0440_ _0441_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__a21oi_1
X_2074_ transfer_count\[2\]\[30\] _0412_ _0437_ VSS VSS VDD
+ VDD _0442_ sky130_fd_sc_hd__nand3_1
X_2075_ transfer_count\[2\]\[30\] _0412_ _0437_ _0303_ VSS
+ VSS VDD VDD _0443_ sky130_fd_sc_hd__a31oi_1
X_2076_ _0318_ _0443_ transfer_count\[2\]\[31\] VSS VSS VDD
+ VDD _0444_ sky130_fd_sc_hd__o21ai_0
X_2077_ transfer_count\[2\]\[31\] _0319_ _0442_ _0444_ VSS
+ VSS VDD VDD _0101_ sky130_fd_sc_hd__o31ai_1
X_2078_ transfer_count\[1\]\[0\] VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__inv_1
X_2079_ channel_state\[1\]\[2\] VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__buf_2
X_2080_ net139 _0445_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__nand2_2
X_2081_ _0446_ _0882_ _0827_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__a21boi_4
X_2082_ _0447_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__clkbuf_4
X_2083_ _0825_ _0826_ _0446_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__nor3_4
X_2084_ _0449_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__clkbuf_4
X_2085_ transfer_count\[1\]\[0\] _0450_ VSS VSS VDD VDD _0451_
+ sky130_fd_sc_hd__nor2_1
X_2086_ transfer_count\[1\]\[0\] _0448_ _0451_ VSS VSS VDD
+ VDD _0045_ sky130_fd_sc_hd__a21oi_1
X_2087_ _1413_ VSS VSS VDD VDD _1414_ sky130_fd_sc_hd__inv_1
X_2088_ _0828_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__buf_2
X_2089_ _0446_ _0882_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__nand2_1
X_2090_ _0827_ _0453_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__nand2_4
X_2091_ _0454_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__clkbuf_4
X_2092_ transfer_count\[1\]\[1\] _0455_ VSS VSS VDD VDD _0456_
+ sky130_fd_sc_hd__nand2_1
X_2093_ _1414_ _0452_ _0456_ VSS VSS VDD VDD _0056_ sky130_fd_sc_hd__o21ai_0
X_2094_ _1412_ _0450_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__nand2_1
X_2095_ _1412_ _0828_ _0447_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__o21ai_0
X_2096_ transfer_count\[1\]\[2\] _0458_ VSS VSS VDD VDD _0459_
+ sky130_fd_sc_hd__nand2_1
X_2097_ transfer_count\[1\]\[2\] _0457_ _0459_ VSS VSS VDD
+ VDD _0067_ sky130_fd_sc_hd__o21ai_0
X_2098_ transfer_count\[1\]\[0\] transfer_count\[1\]\[1\]
+ transfer_count\[1\]\[2\] VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__nand3_1
X_2099_ _0449_ _0460_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__and2_0
X_2100_ _0454_ _0461_ transfer_count\[1\]\[3\] VSS VSS VDD
+ VDD _0462_ sky130_fd_sc_hd__o21ai_0
X_2101_ transfer_count\[1\]\[3\] _0829_ _0460_ _0462_ VSS
+ VSS VDD VDD _0070_ sky130_fd_sc_hd__o31ai_1
X_2102_ _1412_ transfer_count\[1\]\[2\] transfer_count\[1\]\[3\]
+ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__nand3_2
X_2103_ transfer_count\[1\]\[4\] _0463_ VSS VSS VDD VDD _1432_
+ sky130_fd_sc_hd__xor2_1
X_2104_ transfer_count\[1\]\[4\] _0455_ VSS VSS VDD VDD _0464_
+ sky130_fd_sc_hd__nand2_1
X_2105_ _0452_ _1432_ _0464_ VSS VSS VDD VDD _0071_ sky130_fd_sc_hd__o21ai_0
X_2106_ transfer_count\[1\]\[3\] transfer_count\[1\]\[4\]
+ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__nand2_1
X_2107_ _0460_ _0465_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__nor2_1
X_2108_ transfer_count\[1\]\[5\] _0466_ VSS VSS VDD VDD _1429_
+ sky130_fd_sc_hd__xnor2_1
X_2109_ transfer_count\[1\]\[5\] _0455_ VSS VSS VDD VDD _0467_
+ sky130_fd_sc_hd__nand2_1
X_2110_ _0452_ _1429_ _0467_ VSS VSS VDD VDD _0072_ sky130_fd_sc_hd__o21ai_0
X_2111_ _0798_ _0463_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__nor2_1
X_2112_ _0450_ _0468_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__nand2_1
X_2113_ _0828_ _0468_ _0447_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__o21ai_0
X_2114_ _0800_ _0470_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__nand2_1
X_2115_ _0800_ _0469_ _0471_ VSS VSS VDD VDD _0073_ sky130_fd_sc_hd__o21ai_0
X_2116_ _0797_ _0798_ _0799_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__nor3_1
X_2117_ _0800_ _0472_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__nand2_1
X_2118_ _0800_ _0472_ _0829_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__a21oi_1
X_2119_ _0454_ _0474_ transfer_count\[1\]\[7\] VSS VSS VDD
+ VDD _0475_ sky130_fd_sc_hd__o21ai_0
X_2120_ transfer_count\[1\]\[7\] _0829_ _0473_ _0475_ VSS
+ VSS VDD VDD _0074_ sky130_fd_sc_hd__o31ai_1
X_2121_ transfer_count\[1\]\[7\] _0800_ _0468_ VSS VSS VDD
+ VDD _0476_ sky130_fd_sc_hd__nand3_1
X_2122_ _0798_ _0801_ _0463_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__nor3_4
X_2123_ _0829_ _0477_ _0447_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__o21ai_0
X_2124_ transfer_count\[1\]\[8\] _0478_ VSS VSS VDD VDD _0479_
+ sky130_fd_sc_hd__nand2_1
X_2125_ transfer_count\[1\]\[8\] _0829_ _0476_ _0479_ VSS
+ VSS VDD VDD _0075_ sky130_fd_sc_hd__o31ai_1
X_2126_ transfer_count\[1\]\[9\] _0455_ VSS VSS VDD VDD _0480_
+ sky130_fd_sc_hd__nand2_1
X_2127_ _1051_ _0452_ _0480_ VSS VSS VDD VDD _0076_ sky130_fd_sc_hd__o21ai_0
X_2128_ transfer_count\[1\]\[9\] transfer_count\[1\]\[8\]
+ _0477_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__and3_1
X_2129_ transfer_count\[1\]\[10\] _0481_ VSS VSS VDD VDD _1048_
+ sky130_fd_sc_hd__xnor2_1
X_2130_ transfer_count\[1\]\[10\] _0455_ VSS VSS VDD VDD _0482_
+ sky130_fd_sc_hd__nand2_1
X_2131_ _0452_ _1048_ _0482_ VSS VSS VDD VDD _0046_ sky130_fd_sc_hd__o21ai_0
X_2132_ _0803_ _0804_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__nand2_1
X_2133_ transfer_count\[1\]\[11\] _0483_ VSS VSS VDD VDD _1045_
+ sky130_fd_sc_hd__xor2_1
X_2134_ transfer_count\[1\]\[11\] _0455_ VSS VSS VDD VDD _0484_
+ sky130_fd_sc_hd__nand2_1
X_2135_ _0452_ _1045_ _0484_ VSS VSS VDD VDD _0047_ sky130_fd_sc_hd__o21ai_0
X_2136_ transfer_count\[1\]\[11\] _0804_ _0477_ VSS VSS VDD
+ VDD _0485_ sky130_fd_sc_hd__and3_1
X_2137_ transfer_count\[1\]\[12\] _0485_ VSS VSS VDD VDD _1042_
+ sky130_fd_sc_hd__xnor2_1
X_2138_ transfer_count\[1\]\[12\] _0455_ VSS VSS VDD VDD _0486_
+ sky130_fd_sc_hd__nand2_1
X_2139_ _0452_ _1042_ _0486_ VSS VSS VDD VDD _0048_ sky130_fd_sc_hd__o21ai_0
X_2140_ _0805_ _0450_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__nand2_1
X_2141_ _0805_ _0828_ _0447_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__o21ai_0
X_2142_ transfer_count\[1\]\[13\] _0488_ VSS VSS VDD VDD _0489_
+ sky130_fd_sc_hd__nand2_1
X_2143_ transfer_count\[1\]\[13\] _0487_ _0489_ VSS VSS VDD
+ VDD _0049_ sky130_fd_sc_hd__o21ai_0
X_2144_ _0809_ _0810_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__or2_0
X_2145_ _0490_ _0476_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__nor2_1
X_2146_ transfer_count\[1\]\[14\] _0491_ VSS VSS VDD VDD _1036_
+ sky130_fd_sc_hd__xnor2_1
X_2147_ transfer_count\[1\]\[14\] _0455_ VSS VSS VDD VDD _0492_
+ sky130_fd_sc_hd__nand2_1
X_2148_ _0452_ _1036_ _0492_ VSS VSS VDD VDD _0050_ sky130_fd_sc_hd__o21ai_0
X_2149_ _0490_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__inv_1
X_2150_ transfer_count\[1\]\[14\] _0803_ _0493_ VSS VSS VDD
+ VDD _0494_ sky130_fd_sc_hd__nand3_1
X_2151_ transfer_count\[1\]\[15\] _0494_ VSS VSS VDD VDD _1033_
+ sky130_fd_sc_hd__xor2_1
X_2152_ transfer_count\[1\]\[15\] _0455_ VSS VSS VDD VDD _0495_
+ sky130_fd_sc_hd__nand2_1
X_2153_ _0452_ _1033_ _0495_ VSS VSS VDD VDD _0051_ sky130_fd_sc_hd__o21ai_0
X_2154_ _0490_ _0811_ _0477_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__nor3b_1
X_2155_ _0450_ _0496_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__nand2_1
X_2156_ _0828_ _0496_ _0447_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__o21ai_0
X_2157_ transfer_count\[1\]\[16\] _0498_ VSS VSS VDD VDD _0499_
+ sky130_fd_sc_hd__nand2_1
X_2158_ transfer_count\[1\]\[16\] _0497_ _0499_ VSS VSS VDD
+ VDD _0052_ sky130_fd_sc_hd__o21ai_0
X_2159_ _0803_ _0812_ _0829_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__a21oi_1
X_2160_ _0454_ _0500_ _0813_ VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__o21ai_0
X_2161_ _0813_ _0823_ _0829_ _0501_ VSS VSS VDD VDD _0053_
+ sky130_fd_sc_hd__o31ai_1
X_2162_ _0812_ _0477_ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__and2_0
X_2163_ _0502_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__clkbuf_2
X_2164_ _0813_ _0503_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__nand2_1
X_2165_ _0450_ _0504_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__nand2_1
X_2166_ _0813_ _0449_ _0503_ transfer_count\[1\]\[18\] VSS
+ VSS VDD VDD _0506_ sky130_fd_sc_hd__a31oi_1
X_2167_ transfer_count\[1\]\[18\] _0448_ _0505_ _0506_ VSS
+ VSS VDD VDD _0054_ sky130_fd_sc_hd__a31oi_1
X_2168_ transfer_count\[1\]\[18\] _0813_ VSS VSS VDD VDD _0507_
+ sky130_fd_sc_hd__nand2_1
X_2169_ _0449_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__buf_2
X_2170_ _0507_ _0823_ _0508_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__o21ai_0
X_2171_ _0507_ _0823_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__nor2_1
X_2172_ _0510_ _0508_ transfer_count\[1\]\[19\] VSS VSS VDD
+ VDD _0511_ sky130_fd_sc_hd__a21oi_1
X_2173_ transfer_count\[1\]\[19\] _0448_ _0509_ _0511_ VSS
+ VSS VDD VDD _0055_ sky130_fd_sc_hd__a31oi_1
X_2174_ transfer_count\[1\]\[19\] transfer_count\[1\]\[18\]
+ _0813_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__and3_1
X_2175_ _0512_ _0503_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__nand2_1
X_2176_ _0450_ _0513_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__nand2_1
X_2177_ _0512_ _0449_ _0503_ transfer_count\[1\]\[20\] VSS
+ VSS VDD VDD _0515_ sky130_fd_sc_hd__a31oi_1
X_2178_ transfer_count\[1\]\[20\] _0448_ _0514_ _0515_ VSS
+ VSS VDD VDD _0057_ sky130_fd_sc_hd__a31oi_1
X_2179_ _0814_ _0823_ _0508_ VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__o21ai_0
X_2180_ _0824_ _0508_ transfer_count\[1\]\[21\] VSS VSS VDD
+ VDD _0517_ sky130_fd_sc_hd__a21oi_1
X_2181_ transfer_count\[1\]\[21\] _0448_ _0516_ _0517_ VSS
+ VSS VDD VDD _0058_ sky130_fd_sc_hd__a31oi_1
X_2182_ transfer_count\[1\]\[21\] transfer_count\[1\]\[20\]
+ _0512_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__and3_1
X_2183_ _0518_ _0503_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__nand2_1
X_2184_ _0450_ _0519_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__nand2_1
X_2185_ _0518_ _0449_ _0503_ transfer_count\[1\]\[22\] VSS
+ VSS VDD VDD _0521_ sky130_fd_sc_hd__a31oi_1
X_2186_ transfer_count\[1\]\[22\] _0448_ _0520_ _0521_ VSS
+ VSS VDD VDD _0059_ sky130_fd_sc_hd__a31oi_1
X_2187_ _0803_ _0818_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__nand2_1
X_2188_ _0522_ _0508_ VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__nand2_1
X_2189_ _0803_ _0818_ _0449_ transfer_count\[1\]\[23\] VSS
+ VSS VDD VDD _0524_ sky130_fd_sc_hd__a31oi_1
X_2190_ transfer_count\[1\]\[23\] _0448_ _0523_ _0524_ VSS
+ VSS VDD VDD _0060_ sky130_fd_sc_hd__a31oi_1
X_2191_ transfer_count\[1\]\[23\] _0818_ _0477_ VSS VSS VDD
+ VDD _0525_ sky130_fd_sc_hd__nand3_1
X_2192_ _0450_ _0525_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__nand2_1
X_2193_ transfer_count\[1\]\[23\] _0818_ _0449_ _0477_ transfer_count\[1\]\[24\]
+ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__a41oi_1
X_2194_ transfer_count\[1\]\[24\] _0448_ _0526_ _0527_ VSS
+ VSS VDD VDD _0061_ sky130_fd_sc_hd__a31oi_1
X_2195_ _0822_ _0449_ _0454_ VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__a21oi_1
X_2196_ transfer_count\[1\]\[25\] _0822_ _0828_ VSS VSS VDD
+ VDD _0529_ sky130_fd_sc_hd__or3_1
X_2197_ _0821_ _0528_ _0529_ VSS VSS VDD VDD _0062_ sky130_fd_sc_hd__o21ai_0
X_2198_ _0812_ _0816_ _0819_ _0477_ VSS VSS VDD VDD _0530_
+ sky130_fd_sc_hd__nand4_2
X_2199_ _0450_ _0530_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__nand2_1
X_2200_ _0829_ _0530_ VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__nor2_1
X_2201_ transfer_count\[1\]\[26\] _0532_ VSS VSS VDD VDD _0533_
+ sky130_fd_sc_hd__nor2_1
X_2202_ transfer_count\[1\]\[26\] _0448_ _0531_ _0533_ VSS
+ VSS VDD VDD _0063_ sky130_fd_sc_hd__a31oi_1
X_2203_ transfer_count\[1\]\[27\] VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__inv_1
X_2204_ transfer_count\[1\]\[26\] _0803_ _0818_ _0819_ VSS
+ VSS VDD VDD _0535_ sky130_fd_sc_hd__nand4_1
X_2205_ _0449_ _0535_ _0454_ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__a21oi_1
X_2206_ transfer_count\[1\]\[27\] _0828_ _0535_ VSS VSS VDD
+ VDD _0537_ sky130_fd_sc_hd__or3_1
X_2207_ _0534_ _0536_ _0537_ VSS VSS VDD VDD _0064_ sky130_fd_sc_hd__o21ai_0
X_2208_ transfer_count\[1\]\[27\] transfer_count\[1\]\[26\]
+ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__nand2_1
X_2209_ _0538_ _0530_ _0508_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__o21ai_0
X_2210_ _0538_ _0530_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__nor2_1
X_2211_ _0508_ _0540_ transfer_count\[1\]\[28\] VSS VSS VDD
+ VDD _0541_ sky130_fd_sc_hd__a21oi_1
X_2212_ transfer_count\[1\]\[28\] _0448_ _0539_ _0541_ VSS
+ VSS VDD VDD _0065_ sky130_fd_sc_hd__a31oi_1
X_2213_ _0820_ _0508_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__nand2_1
X_2214_ _0820_ _0828_ transfer_count\[1\]\[29\] VSS VSS VDD
+ VDD _0543_ sky130_fd_sc_hd__o21ba_1
X_2215_ transfer_count\[1\]\[29\] _0447_ _0542_ _0543_ VSS
+ VSS VDD VDD _0066_ sky130_fd_sc_hd__a31oi_1
X_2216_ transfer_count\[1\]\[29\] _0807_ _0819_ VSS VSS VDD
+ VDD _0544_ sky130_fd_sc_hd__and3_1
X_2217_ _0812_ _0816_ _0477_ _0544_ VSS VSS VDD VDD _0545_
+ sky130_fd_sc_hd__nand4_2
X_2218_ _0508_ _0545_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__nand2_1
X_2219_ _0829_ _0545_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__nor2_1
X_2220_ transfer_count\[1\]\[30\] _0547_ VSS VSS VDD VDD _0548_
+ sky130_fd_sc_hd__nor2_1
X_2221_ transfer_count\[1\]\[30\] _0447_ _0546_ _0548_ VSS
+ VSS VDD VDD _0068_ sky130_fd_sc_hd__a31oi_1
X_2222_ transfer_count\[1\]\[30\] transfer_count\[1\]\[29\]
+ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__nand2_1
X_2223_ _0820_ _0549_ _0508_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__o21ai_0
X_2224_ transfer_count\[1\]\[31\] VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__inv_1
X_2225_ _0820_ _0828_ _0549_ _0551_ VSS VSS VDD VDD _0552_
+ sky130_fd_sc_hd__o31a_1
X_2226_ transfer_count\[1\]\[31\] _0447_ _0550_ _0552_ VSS
+ VSS VDD VDD _0069_ sky130_fd_sc_hd__a31oi_1
X_2227_ transfer_count\[0\]\[0\] VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__inv_1
X_2228_ channel_state\[0\]\[2\] VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__buf_2
X_2229_ _0980_ _0981_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__nor2_1
X_2230_ net138 _0553_ _0554_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__nand3_2
X_2231_ _0555_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__buf_2
X_2232_ _0148_ _0202_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__nor2_2
X_2233_ _0557_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__clkbuf_4
X_2234_ transfer_count\[0\]\[0\] _0558_ VSS VSS VDD VDD _0559_
+ sky130_fd_sc_hd__nand2_1
X_2235_ transfer_count\[0\]\[0\] _0556_ _0559_ VSS VSS VDD
+ VDD _0013_ sky130_fd_sc_hd__o21ai_0
X_2236_ _1209_ VSS VSS VDD VDD _1210_ sky130_fd_sc_hd__inv_1
X_2237_ _0555_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__clkbuf_4
X_2238_ transfer_count\[0\]\[1\] _0560_ VSS VSS VDD VDD _0561_
+ sky130_fd_sc_hd__nand2_1
X_2239_ _1210_ _0556_ _0202_ _0561_ VSS VSS VDD VDD _0024_
+ sky130_fd_sc_hd__o22ai_1
X_2240_ _1208_ _0150_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__nand2_1
X_2241_ _0557_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__clkbuf_4
X_2242_ _0555_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__clkbuf_4
X_2243_ _1208_ _0564_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__nor2_1
X_2244_ _0563_ _0565_ transfer_count\[0\]\[2\] VSS VSS VDD
+ VDD _0566_ sky130_fd_sc_hd__o21ai_0
X_2245_ transfer_count\[0\]\[2\] _0562_ _0566_ VSS VSS VDD
+ VDD _0035_ sky130_fd_sc_hd__o21ai_0
X_2246_ _0987_ _0150_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__nand2_1
X_2247_ _0987_ _0564_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__nor2_1
X_2248_ _0557_ _0568_ transfer_count\[0\]\[3\] VSS VSS VDD
+ VDD _0569_ sky130_fd_sc_hd__o21ai_0
X_2249_ transfer_count\[0\]\[3\] _0567_ _0569_ VSS VSS VDD
+ VDD _0038_ sky130_fd_sc_hd__o21ai_0
X_2250_ transfer_count\[0\]\[2\] transfer_count\[0\]\[3\]
+ _1208_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__nand3_1
X_2251_ transfer_count\[0\]\[4\] _0570_ VSS VSS VDD VDD _1228_
+ sky130_fd_sc_hd__xor2_1
X_2252_ transfer_count\[0\]\[4\] _0560_ VSS VSS VDD VDD _0571_
+ sky130_fd_sc_hd__nand2_1
X_2253_ _0556_ _1228_ _0571_ _0202_ VSS VSS VDD VDD _0039_
+ sky130_fd_sc_hd__o22ai_1
X_2254_ transfer_count\[0\]\[5\] _0558_ VSS VSS VDD VDD _0572_
+ sky130_fd_sc_hd__nand2_1
X_2255_ _1225_ _0556_ _0572_ VSS VSS VDD VDD _0040_ sky130_fd_sc_hd__o21ai_0
X_2256_ transfer_count\[0\]\[2\] _1208_ _0992_ VSS VSS VDD
+ VDD _0573_ sky130_fd_sc_hd__nand3_2
X_2257_ _0149_ _0573_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__and2_0
X_2258_ _0558_ _0574_ transfer_count\[0\]\[6\] VSS VSS VDD
+ VDD _0575_ sky130_fd_sc_hd__o21ai_0
X_2259_ transfer_count\[0\]\[6\] _0560_ _0573_ _0575_ VSS
+ VSS VDD VDD _0041_ sky130_fd_sc_hd__o31ai_1
X_2260_ _0997_ _0150_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__nand2_1
X_2261_ _0997_ _0564_ VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__nor2_1
X_2262_ _0557_ _0577_ _0991_ VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__o21ai_0
X_2263_ _0991_ _0576_ _0578_ VSS VSS VDD VDD _0042_ sky130_fd_sc_hd__o21ai_0
X_2264_ transfer_count\[0\]\[6\] _0991_ VSS VSS VDD VDD _0579_
+ sky130_fd_sc_hd__and2_0
X_2265_ transfer_count\[0\]\[2\] _1208_ _0992_ _0579_ VSS
+ VSS VDD VDD _0580_ sky130_fd_sc_hd__nand4_4
X_2266_ _0573_ _0579_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__nor2b_1
X_2267_ _0564_ _0581_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__nor2_1
X_2268_ _0558_ _0582_ _0989_ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__o21ai_0
X_2269_ _0989_ _0560_ _0580_ _0583_ VSS VSS VDD VDD _0043_
+ sky130_fd_sc_hd__o31ai_1
X_2270_ _0555_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__clkbuf_4
X_2271_ _0991_ _0989_ _0997_ _0584_ VSS VSS VDD VDD _0585_
+ sky130_fd_sc_hd__a31oi_1
X_2272_ _0558_ _0585_ transfer_count\[0\]\[9\] VSS VSS VDD
+ VDD _0586_ sky130_fd_sc_hd__o21ai_0
X_2273_ transfer_count\[0\]\[9\] _0998_ _0556_ _0586_ VSS
+ VSS VDD VDD _0044_ sky130_fd_sc_hd__o31ai_1
X_2274_ transfer_count\[0\]\[9\] _0989_ _0581_ VSS VSS VDD
+ VDD _0587_ sky130_fd_sc_hd__nand3_1
X_2275_ transfer_count\[0\]\[10\] _0587_ VSS VSS VDD VDD _1246_
+ sky130_fd_sc_hd__xor2_1
X_2276_ transfer_count\[0\]\[10\] _0558_ VSS VSS VDD VDD _0588_
+ sky130_fd_sc_hd__nand2_1
X_2277_ _0556_ _1246_ _0588_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__o21ai_0
X_2278_ _0991_ _1006_ _0997_ VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__and3_1
X_2279_ _0589_ _0150_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__nand2_1
X_2280_ _0149_ _0202_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__or2_0
X_2281_ _0591_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__buf_2
X_2282_ _0994_ _0564_ _0592_ VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__o21ai_0
X_2283_ transfer_count\[0\]\[11\] _0593_ VSS VSS VDD VDD _0594_
+ sky130_fd_sc_hd__nand2_1
X_2284_ transfer_count\[0\]\[11\] _0590_ _0594_ VSS VSS VDD
+ VDD _0015_ sky130_fd_sc_hd__o21ai_0
X_2285_ transfer_count\[0\]\[11\] _1006_ _0581_ VSS VSS VDD
+ VDD _0595_ sky130_fd_sc_hd__nand3_1
X_2286_ transfer_count\[0\]\[12\] _0595_ VSS VSS VDD VDD _1240_
+ sky130_fd_sc_hd__xor2_1
X_2287_ transfer_count\[0\]\[12\] _0558_ VSS VSS VDD VDD _0596_
+ sky130_fd_sc_hd__nand2_1
X_2288_ _0556_ _1240_ _0596_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__o21ai_0
X_2289_ transfer_count\[0\]\[12\] transfer_count\[0\]\[11\]
+ _0589_ _0584_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__a31oi_1
X_2290_ _0558_ _0597_ transfer_count\[0\]\[13\] VSS VSS VDD
+ VDD _0598_ sky130_fd_sc_hd__o21ai_0
X_2291_ transfer_count\[0\]\[13\] _0995_ _0556_ _0598_ VSS
+ VSS VDD VDD _0017_ sky130_fd_sc_hd__o31ai_1
X_2292_ _1006_ _1007_ _0581_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__nand3_1
X_2293_ transfer_count\[0\]\[14\] _0599_ VSS VSS VDD VDD _1234_
+ sky130_fd_sc_hd__xor2_1
X_2294_ transfer_count\[0\]\[14\] _0558_ VSS VSS VDD VDD _0600_
+ sky130_fd_sc_hd__nand2_1
X_2295_ _0556_ _1234_ _0600_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__o21ai_0
X_2296_ _1015_ _0149_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__nand2_1
X_2297_ _1015_ _0584_ _0592_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__o21ai_0
X_2298_ transfer_count\[0\]\[15\] _0602_ VSS VSS VDD VDD _0603_
+ sky130_fd_sc_hd__nand2_1
X_2299_ transfer_count\[0\]\[15\] _0601_ _0603_ VSS VSS VDD
+ VDD _0019_ sky130_fd_sc_hd__o21ai_0
X_2300_ _1008_ _0580_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__nor2_2
X_2301_ _0150_ _0604_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__nand2_1
X_2302_ _0555_ _0604_ _0592_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__o21ai_0
X_2303_ _1003_ _0606_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__nand2_1
X_2304_ _1003_ _0605_ _0607_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__o21ai_0
X_2305_ transfer_count\[0\]\[15\] _1003_ _1015_ _0584_ VSS
+ VSS VDD VDD _0608_ sky130_fd_sc_hd__a31oi_1
X_2306_ _0563_ _0608_ transfer_count\[0\]\[17\] VSS VSS VDD
+ VDD _0609_ sky130_fd_sc_hd__o21ai_0
X_2307_ transfer_count\[0\]\[17\] _0146_ _0556_ _0609_ VSS
+ VSS VDD VDD _0021_ sky130_fd_sc_hd__o31ai_1
X_2308_ transfer_count\[0\]\[17\] _1003_ _0604_ VSS VSS VDD
+ VDD _0610_ sky130_fd_sc_hd__nand3_1
X_2309_ transfer_count\[0\]\[17\] _1003_ _0604_ _0584_ VSS
+ VSS VDD VDD _0611_ sky130_fd_sc_hd__a31oi_1
X_2310_ _0563_ _0611_ transfer_count\[0\]\[18\] VSS VSS VDD
+ VDD _0612_ sky130_fd_sc_hd__o21ai_0
X_2311_ transfer_count\[0\]\[18\] _0560_ _0610_ _0612_ VSS
+ VSS VDD VDD _0022_ sky130_fd_sc_hd__o31ai_1
X_2312_ transfer_count\[0\]\[18\] transfer_count\[0\]\[17\]
+ _1003_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__nand3_1
X_2313_ _0993_ _0613_ _1008_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__nor3_1
X_2314_ _0150_ _0614_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__nand2_1
X_2315_ _0555_ _0614_ _0592_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__o21ai_0
X_2316_ transfer_count\[0\]\[19\] _0616_ VSS VSS VDD VDD _0617_
+ sky130_fd_sc_hd__nand2_1
X_2317_ transfer_count\[0\]\[19\] _0615_ _0617_ VSS VSS VDD
+ VDD _0023_ sky130_fd_sc_hd__o21ai_0
X_2318_ transfer_count\[0\]\[19\] _1004_ _0604_ VSS VSS VDD
+ VDD _0618_ sky130_fd_sc_hd__nand3_1
X_2319_ transfer_count\[0\]\[19\] _1004_ _0604_ _0584_ VSS
+ VSS VDD VDD _0619_ sky130_fd_sc_hd__a31oi_1
X_2320_ _0563_ _0619_ transfer_count\[0\]\[20\] VSS VSS VDD
+ VDD _0620_ sky130_fd_sc_hd__o21ai_0
X_2321_ transfer_count\[0\]\[20\] _0560_ _0618_ _0620_ VSS
+ VSS VDD VDD _0025_ sky130_fd_sc_hd__o31ai_1
X_2322_ _1016_ _0149_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__nand2b_1
X_2323_ _1016_ _0149_ transfer_count\[0\]\[21\] VSS VSS VDD
+ VDD _0622_ sky130_fd_sc_hd__a21oi_1
X_2324_ transfer_count\[0\]\[21\] _0592_ _0621_ _0622_ VSS
+ VSS VDD VDD _0026_ sky130_fd_sc_hd__a31oi_1
X_2325_ _1005_ _1008_ _0580_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__nor3_4
X_2326_ _0150_ _0623_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__nand2_1
X_2327_ _0584_ _0623_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__nor2_1
X_2328_ _0557_ _0625_ _0999_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__o21ai_0
X_2329_ _0999_ _0624_ _0626_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__o21ai_0
X_2330_ _0999_ _1009_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__nand2_1
X_2331_ _0149_ _0627_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__nand2_1
X_2332_ _0999_ _1009_ _0149_ transfer_count\[0\]\[23\] VSS
+ VSS VDD VDD _0629_ sky130_fd_sc_hd__a31oi_1
X_2333_ transfer_count\[0\]\[23\] _0592_ _0628_ _0629_ VSS
+ VSS VDD VDD _0028_ sky130_fd_sc_hd__a31oi_1
X_2334_ transfer_count\[0\]\[23\] _0999_ _0623_ VSS VSS VDD
+ VDD _0630_ sky130_fd_sc_hd__nand3_1
X_2335_ transfer_count\[0\]\[23\] _0999_ _0623_ _0584_ VSS
+ VSS VDD VDD _0631_ sky130_fd_sc_hd__a31oi_1
X_2336_ _0563_ _0631_ transfer_count\[0\]\[24\] VSS VSS VDD
+ VDD _0632_ sky130_fd_sc_hd__o21ai_0
X_2337_ transfer_count\[0\]\[24\] _0560_ _0630_ _0632_ VSS
+ VSS VDD VDD _0029_ sky130_fd_sc_hd__o31ai_1
X_2338_ _1011_ _1009_ _0564_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__a21oi_1
X_2339_ _0563_ _0633_ transfer_count\[0\]\[25\] VSS VSS VDD
+ VDD _0634_ sky130_fd_sc_hd__o21ai_0
X_2340_ transfer_count\[0\]\[25\] _1012_ _0560_ _0634_ VSS
+ VSS VDD VDD _0030_ sky130_fd_sc_hd__o31ai_1
X_2341_ _1001_ _0623_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__nand2_1
X_2342_ _1001_ _0623_ _0564_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__a21oi_1
X_2343_ _0563_ _0636_ transfer_count\[0\]\[26\] VSS VSS VDD
+ VDD _0637_ sky130_fd_sc_hd__o21ai_0
X_2344_ transfer_count\[0\]\[26\] _0560_ _0635_ _0637_ VSS
+ VSS VDD VDD _0031_ sky130_fd_sc_hd__o31ai_1
X_2345_ transfer_count\[0\]\[26\] _1001_ _1009_ VSS VSS VDD
+ VDD _0638_ sky130_fd_sc_hd__nand3_1
X_2346_ transfer_count\[0\]\[26\] _1001_ _1009_ _0584_ VSS
+ VSS VDD VDD _0639_ sky130_fd_sc_hd__a31oi_1
X_2347_ _0563_ _0639_ transfer_count\[0\]\[27\] VSS VSS VDD
+ VDD _0640_ sky130_fd_sc_hd__o21ai_0
X_2348_ transfer_count\[0\]\[27\] _0560_ _0638_ _0640_ VSS
+ VSS VDD VDD _0032_ sky130_fd_sc_hd__o31ai_1
X_2349_ transfer_count\[0\]\[27\] transfer_count\[0\]\[26\]
+ _1001_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__nand3_1
X_2350_ _0641_ _1005_ _1008_ _0580_ VSS VSS VDD VDD _0642_
+ sky130_fd_sc_hd__nor4_1
X_2351_ _0150_ _0642_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__nand2_1
X_2352_ _0555_ _0642_ _0592_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__o21ai_0
X_2353_ transfer_count\[0\]\[28\] _0644_ VSS VSS VDD VDD _0645_
+ sky130_fd_sc_hd__nand2_1
X_2354_ transfer_count\[0\]\[28\] _0643_ _0645_ VSS VSS VDD
+ VDD _0033_ sky130_fd_sc_hd__o21ai_0
X_2355_ _1010_ _0149_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__nand2_1
X_2356_ _1002_ _1009_ _0149_ transfer_count\[0\]\[29\] VSS
+ VSS VDD VDD _0647_ sky130_fd_sc_hd__a31oi_1
X_2357_ transfer_count\[0\]\[29\] _0592_ _0646_ _0647_ VSS
+ VSS VDD VDD _0034_ sky130_fd_sc_hd__a31oi_1
X_2358_ transfer_count\[0\]\[29\] _1002_ _0623_ VSS VSS VDD
+ VDD _0648_ sky130_fd_sc_hd__nand3_1
X_2359_ transfer_count\[0\]\[29\] _1002_ _0623_ _0584_ VSS
+ VSS VDD VDD _0649_ sky130_fd_sc_hd__a31oi_1
X_2360_ _0563_ _0649_ transfer_count\[0\]\[30\] VSS VSS VDD
+ VDD _0650_ sky130_fd_sc_hd__o21ai_0
X_2361_ transfer_count\[0\]\[30\] _0564_ _0648_ _0650_ VSS
+ VSS VDD VDD _0036_ sky130_fd_sc_hd__o31ai_1
X_2362_ transfer_count\[0\]\[30\] transfer_count\[0\]\[29\]
+ _1002_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__and3_1
X_2363_ _1009_ _0651_ VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__nand2_1
X_2364_ _1009_ _0651_ _0564_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__a21oi_1
X_2365_ _0563_ _0653_ transfer_count\[0\]\[31\] VSS VSS VDD
+ VDD _0654_ sky130_fd_sc_hd__o21ai_0
X_2366_ transfer_count\[0\]\[31\] _0564_ _0652_ _0654_ VSS
+ VSS VDD VDD _0037_ sky130_fd_sc_hd__o31ai_1
X_2367_ active_channel_count\[0\] VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__inv_1
X_2368_ _0980_ _0981_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__nand2b_1
X_2369_ _0981_ _0980_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__nand2b_2
X_2370_ _0655_ _0656_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__nand2_1
X_2371_ net2 net146 VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__nand2_1
X_2372_ channel_state\[0\]\[2\] _0657_ _0658_ VSS VSS VDD
+ VDD _0659_ sky130_fd_sc_hd__a21oi_1
X_2373_ _0825_ _0826_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__nor2b_1
X_2374_ channel_state\[1\]\[1\] channel_state\[1\]\[0\] VSS
+ VSS VDD VDD _0661_ sky130_fd_sc_hd__nand2b_1
X_2375_ _0660_ _0661_ VSS VSS VDD VDD _0662_ sky130_fd_sc_hd__nand2b_1
X_2376_ net147 net3 VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__nand2_1
X_2377_ _0445_ _0662_ _0663_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__a21oi_1
X_2378_ channel_state\[3\]\[1\] VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__inv_1
X_2379_ channel_state\[3\]\[0\] _0665_ VSS VSS VDD VDD _0666_
+ sky130_fd_sc_hd__nor2_1
X_2380_ _0976_ _0665_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__nand2_1
X_2381_ _0666_ _0667_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__nand2b_1
X_2382_ net149 net5 VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__nand2_1
X_2383_ _0920_ _0668_ _0669_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__a21oi_4
X_2384_ channel_state\[2\]\[1\] VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__clkbuf_2
X_2385_ channel_state\[2\]\[0\] _0671_ VSS VSS VDD VDD _0672_
+ sky130_fd_sc_hd__nor2b_1
X_2386_ channel_state\[2\]\[1\] channel_state\[2\]\[0\] VSS
+ VSS VDD VDD _0673_ sky130_fd_sc_hd__nand2b_1
X_2387_ _0672_ _0673_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__nand2b_1
X_2388_ net148 net4 VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__nand2_1
X_2389_ _0308_ _0674_ _0675_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__a21oi_1
X_2390_ _0659_ _0664_ _0670_ _0676_ VSS VSS VDD VDD _0677_
+ sky130_fd_sc_hd__nor4_2
X_2391_ active_channel_count\[0\] _0677_ VSS VSS VDD VDD _0000_
+ sky130_fd_sc_hd__nor2_1
X_2392_ _0677_ _1306_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__nor2b_1
X_2393_ _1307_ active_channel_count\[2\] VSS VSS VDD VDD _0678_
+ sky130_fd_sc_hd__xnor2_1
X_2394_ _0677_ _0678_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__nor2_1
X_2395_ active_channel_count\[0\] active_channel_count\[2\]
+ active_channel_count\[1\] VSS VSS VDD VDD _0679_ sky130_fd_sc_hd__nand3_1
X_2396_ active_channel_count\[3\] _0679_ VSS VSS VDD VDD _0680_
+ sky130_fd_sc_hd__xor2_1
X_2397_ _0677_ _0680_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__nor2_1
X_2398_ net134 _0553_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__nand2_1
X_2399_ _0553_ net142 VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__nand2b_1
X_2400_ _0656_ _0681_ _0682_ _0655_ _0558_ VSS VSS VDD VDD
+ _1030_ sky130_fd_sc_hd__o221ai_1
X_2401_ _0553_ _0656_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__nor2_2
X_2402_ _0982_ _0655_ _0656_ _0553_ VSS VSS VDD VDD _1031_
+ sky130_fd_sc_hd__o22ai_1
X_2403_ net134 _0657_ _0147_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__a21o_1
X_2404_ _0980_ _0981_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__nand2_1
X_2405_ net134 _0554_ _0684_ _0553_ VSS VSS VDD VDD _0685_
+ sky130_fd_sc_hd__o211ai_1
X_2406_ _0553_ _0684_ _0685_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__o21ai_0
X_2407_ _0201_ _0683_ _0686_ VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__o21a_1
X_2408_ _0826_ net135 VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__nand2b_1
X_2409_ _0445_ _0825_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__nand2_1
X_2410_ _0445_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__inv_1
X_2411_ _0689_ net143 _0660_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__nand3_1
X_2412_ _0687_ _0688_ _0690_ _0455_ VSS VSS VDD VDD _1027_
+ sky130_fd_sc_hd__o211ai_1
X_2413_ _0445_ _0661_ VSS VSS VDD VDD _1018_ sky130_fd_sc_hd__nor2_2
X_2414_ net135 _0660_ _0662_ _0689_ VSS VSS VDD VDD _1028_
+ sky130_fd_sc_hd__a22o_1
X_2415_ net139 VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__inv_1
X_2416_ _0445_ _0825_ net135 _0826_ _0691_ VSS VSS VDD VDD
+ _0692_ sky130_fd_sc_hd__a311oi_1
X_2417_ net135 _0826_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__nor2b_1
X_2418_ _0825_ _0693_ _0687_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__o21ai_0
X_2419_ _0689_ _0825_ _0826_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__and3_1
X_2420_ _0445_ _0694_ _0695_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__a21oi_1
X_2421_ _0880_ _0692_ _0696_ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__a21oi_1
X_2422_ _0671_ net136 VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__nand2b_1
X_2423_ _0308_ channel_state\[2\]\[0\] VSS VSS VDD VDD _0698_
+ sky130_fd_sc_hd__nand2_1
X_2424_ net144 _0672_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__nand2_1
X_2425_ _0697_ _0698_ _0699_ _0308_ _0313_ VSS VSS VDD VDD
+ _1024_ sky130_fd_sc_hd__o221ai_1
X_2426_ _0308_ _0673_ VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__nor2_2
X_2427_ _0308_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__inv_1
X_2428_ net136 _0672_ _0674_ _0700_ VSS VSS VDD VDD _1025_
+ sky130_fd_sc_hd__a22o_1
X_2429_ _0700_ channel_state\[2\]\[0\] _0671_ VSS VSS VDD
+ VDD _0701_ sky130_fd_sc_hd__nand3_1
X_2430_ net136 _0671_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__nor2b_1
X_2431_ channel_state\[2\]\[0\] _0702_ _0697_ VSS VSS VDD
+ VDD _0703_ sky130_fd_sc_hd__o21ai_0
X_2432_ _0308_ _0703_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__nand2_1
X_2433_ _0701_ _0704_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__nand2_1
X_2434_ _1311_ _1314_ _1317_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__and3_1
X_2435_ _1331_ _1329_ _1325_ _1328_ VSS VSS VDD VDD _0707_
+ sky130_fd_sc_hd__a211oi_1
X_2436_ _1326_ _1325_ _1323_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__o21ai_0
X_2437_ _1319_ _1322_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__nor2_1
X_2438_ _0707_ _0708_ _0709_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__o21ai_0
X_2439_ _1319_ _1320_ _0706_ _0710_ VSS VSS VDD VDD _0711_
+ sky130_fd_sc_hd__o211ai_1
X_2440_ _1314_ _1316_ _1313_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__a21oi_1
X_2441_ _0712_ _1311_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__nor2b_1
X_2442_ _1335_ _1337_ _1334_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__a21oi_1
X_2443_ _1320_ _1326_ _1332_ _1329_ VSS VSS VDD VDD _0715_
+ sky130_fd_sc_hd__nand4_2
X_2444_ _1311_ _1323_ _1314_ _1317_ VSS VSS VDD VDD _0716_
+ sky130_fd_sc_hd__nand4_2
X_2445_ _0714_ _0715_ _0716_ VSS VSS VDD VDD _0717_ sky130_fd_sc_hd__nor3_1
X_2446_ _1310_ _0713_ _0717_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__nor3_1
X_2447_ _1355_ _1353_ _1352_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__a21oi_1
X_2448_ _1347_ _1344_ _1350_ VSS VSS VDD VDD _0720_ sky130_fd_sc_hd__nand3_1
X_2449_ _1347_ _1344_ _1349_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__nand3_1
X_2450_ _1344_ _1346_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__nand2_1
X_2451_ _0719_ _0720_ _0721_ _0722_ VSS VSS VDD VDD _0723_
+ sky130_fd_sc_hd__o211ai_1
X_2452_ _1335_ _1338_ VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__nand2_1
X_2453_ _1341_ _1340_ VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__nor2_1
X_2454_ _0715_ _0716_ _0724_ _0725_ VSS VSS VDD VDD _0726_
+ sky130_fd_sc_hd__nor4_1
X_2455_ _1343_ _1340_ _0723_ _0726_ VSS VSS VDD VDD _0727_
+ sky130_fd_sc_hd__o31ai_1
X_2456_ _0711_ _0718_ _0727_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__and3_1
X_2457_ _1406_ _1403_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__nor2b_1
X_2458_ _1402_ _0729_ _1395_ _1398_ VSS VSS VDD VDD _0730_
+ sky130_fd_sc_hd__o211ai_1
X_2459_ _1395_ _1397_ _1394_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__a21oi_1
X_2460_ _1383_ _1386_ _1392_ _1389_ VSS VSS VDD VDD _0732_
+ sky130_fd_sc_hd__nand4_1
X_2461_ _0730_ _0731_ _0732_ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__a21oi_1
X_2462_ _1383_ _1386_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__nand2_1
X_2463_ _1391_ _1389_ _1388_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__a21oi_1
X_2464_ _0734_ _0735_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__nor2_1
X_2465_ _1359_ _1361_ _1358_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__a21oi_1
X_2466_ _1383_ _1385_ _1382_ VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__a21oi_1
X_2467_ _0737_ _0738_ VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__nand2_1
X_2468_ _1368_ _1374_ _1380_ _1365_ VSS VSS VDD VDD _0740_
+ sky130_fd_sc_hd__nand4_1
X_2469_ _1359_ _1371_ _1362_ _1377_ VSS VSS VDD VDD _0741_
+ sky130_fd_sc_hd__nand4_1
X_2470_ _0740_ _0741_ _0737_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__o21ai_0
X_2471_ _1347_ _1344_ _1356_ _1341_ VSS VSS VDD VDD _0743_
+ sky130_fd_sc_hd__and4_1
X_2472_ _1350_ _1353_ _0743_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__nand3_1
X_2473_ _0715_ _0716_ _0724_ _0744_ VSS VSS VDD VDD _0745_
+ sky130_fd_sc_hd__nor4_2
X_2474_ _0733_ _0736_ _0739_ _0742_ _0745_ VSS VSS VDD VDD
+ _0746_ sky130_fd_sc_hd__o311ai_2
X_2475_ _1379_ _1377_ _1376_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__a21o_1
X_2476_ _1374_ _0747_ _1373_ VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__a21oi_1
X_2477_ _1371_ _1368_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__nand2_1
X_2478_ _1368_ _1370_ _1364_ _1367_ VSS VSS VDD VDD _0750_
+ sky130_fd_sc_hd__a211oi_1
X_2479_ _0748_ _0749_ _0750_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__o21ai_0
X_2480_ _1365_ _1364_ _1359_ _1362_ VSS VSS VDD VDD _0752_
+ sky130_fd_sc_hd__o211a_1
X_2481_ _0751_ _0752_ _0745_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__nand3_1
X_2482_ _0705_ _0728_ _0746_ _0753_ VSS VSS VDD VDD _0754_
+ sky130_fd_sc_hd__nand4_1
X_2483_ _1395_ _1403_ _1407_ _1398_ VSS VSS VDD VDD _0755_
+ sky130_fd_sc_hd__nand4_1
X_2484_ _0732_ _0740_ _0741_ _0755_ VSS VSS VDD VDD _0756_
+ sky130_fd_sc_hd__nor4_1
X_2485_ net140 _0671_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__nor2_1
X_2486_ net136 _0671_ _0757_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__a21oi_1
X_2487_ _0671_ net136 VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__nor2b_1
X_2488_ _0671_ _0759_ _0308_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__mux2i_1
X_2489_ _0301_ _0758_ _0760_ _0307_ VSS VSS VDD VDD _0761_
+ sky130_fd_sc_hd__o22ai_1
X_2490_ _0705_ _0745_ _0756_ _0761_ VSS VSS VDD VDD _0762_
+ sky130_fd_sc_hd__a31oi_1
X_2491_ _0754_ _0762_ VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__nand2_1
X_2492_ _0920_ _0667_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__nor2_1
X_2493_ net137 _0665_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__nand2_1
X_2494_ _0920_ _0976_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__nand2_1
X_2495_ _0920_ VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__inv_1
X_2496_ _0765_ net145 _0666_ VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__nand3_1
X_2497_ _0763_ _0764_ _0766_ _0208_ VSS VSS VDD VDD _1021_
+ sky130_fd_sc_hd__o211ai_1
X_2498_ net137 _0666_ _0668_ _0765_ VSS VSS VDD VDD _1022_
+ sky130_fd_sc_hd__a22o_1
X_2499_ net137 _0665_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__nor2_1
X_2500_ _0976_ _0767_ _0763_ VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__o21ai_0
X_2501_ _0765_ _0976_ channel_state\[3\]\[1\] VSS VSS VDD
+ VDD _0769_ sky130_fd_sc_hd__and3_1
X_2502_ _0920_ _0768_ _0769_ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__a21oi_1
X_2503_ channel_state\[3\]\[1\] net137 VSS VSS VDD VDD _0771_
+ sky130_fd_sc_hd__nor2b_1
X_2504_ channel_state\[3\]\[1\] _0771_ _0920_ VSS VSS VDD
+ VDD _0772_ sky130_fd_sc_hd__mux2_1
X_2505_ net141 _0665_ _0767_ _0765_ _0976_ VSS VSS VDD VDD
+ _0773_ sky130_fd_sc_hd__a2111oi_0
X_2506_ _0976_ _0772_ _0773_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__a21oi_1
X_2507_ _0954_ _0975_ _0770_ _0774_ VSS VSS VDD VDD _1023_
+ sky130_fd_sc_hd__o31ai_1
X_2508_ net142 _0655_ _0656_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__o21a_1
X_2509_ _0553_ _0775_ VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__nor2_2
X_2510_ _0980_ _0983_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__nor2_1
X_2511_ _0980_ _0982_ _0776_ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__a21oi_1
X_2512_ _0981_ _0777_ net150 VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__o21ai_0
X_2513_ _0150_ _0201_ _0778_ VSS VSS VDD VDD _1441_ sky130_fd_sc_hd__a21bo_1
X_2514_ net143 _0660_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__nand2b_1
X_2515_ _0661_ _0779_ _0445_ VSS VSS VDD VDD _1440_ sky130_fd_sc_hd__a21oi_2
X_2516_ _0825_ _0882_ _0688_ net135 VSS VSS VDD VDD _0780_
+ sky130_fd_sc_hd__o22a_1
X_2517_ _0826_ _0780_ net151 VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__o21ai_0
X_2518_ _0452_ _0880_ _0781_ VSS VSS VDD VDD _1439_ sky130_fd_sc_hd__o21ai_0
X_2519_ _0976_ _0978_ _0764_ net137 VSS VSS VDD VDD _0782_
+ sky130_fd_sc_hd__o22a_1
X_2520_ channel_state\[3\]\[1\] _0782_ net153 VSS VSS VDD
+ VDD _0783_ sky130_fd_sc_hd__o21ai_0
X_2521_ _0223_ _0954_ _0975_ _0783_ VSS VSS VDD VDD _1438_
+ sky130_fd_sc_hd__o31ai_1
X_2522_ net144 _0672_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__nand2b_1
X_2523_ _0673_ _0784_ _0308_ VSS VSS VDD VDD _1437_ sky130_fd_sc_hd__a21oi_2
X_2524_ _0306_ _0728_ _0746_ _0753_ VSS VSS VDD VDD _0785_
+ sky130_fd_sc_hd__nand4_1
X_2525_ _0316_ _0745_ _0756_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__nand3_1
X_2526_ net136 _0698_ _0310_ VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__o21ba_1
X_2527_ _0671_ _0787_ net152 VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__o21ai_0
X_2528_ _0785_ _0786_ _0788_ VSS VSS VDD VDD _1436_ sky130_fd_sc_hd__nand3_1
X_2529_ active_channel_count\[2\] active_channel_count\[3\]
+ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__nor2_1
X_2530_ _1305_ _0789_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__nand2_1
X_2531_ _0977_ _0771_ _0767_ _0920_ VSS VSS VDD VDD _0790_
+ sky130_fd_sc_hd__a22oi_1
X_2532_ _0976_ _0790_ net157 VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__o21a_1
X_2533_ _0309_ _0759_ _0702_ _0308_ VSS VSS VDD VDD _0791_
+ sky130_fd_sc_hd__a22oi_1
X_2534_ channel_state\[2\]\[0\] _0791_ net156 VSS VSS VDD
+ VDD _0010_ sky130_fd_sc_hd__o21a_1
X_2535_ net148 _0311_ _0785_ _0786_ VSS VSS VDD VDD _0006_
+ sky130_fd_sc_hd__o211a_1
X_2536_ _0826_ net135 VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__nor2b_1
X_2537_ _0881_ _0792_ _0693_ _0445_ VSS VSS VDD VDD _0793_
+ sky130_fd_sc_hd__a22oi_1
X_2538_ _0825_ _0793_ net155 VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__o21a_1
X_2539_ net129 VSS VSS VDD VDD _1200_ sky130_fd_sc_hd__inv_1
X_2540_ net6 VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__inv_1
X_2541_ transfer_count\[2\]\[30\] _0438_ VSS VSS VDD VDD _1312_
+ sky130_fd_sc_hd__xnor2_1
X_2542_ transfer_count\[2\]\[26\] _0423_ VSS VSS VDD VDD _1324_
+ sky130_fd_sc_hd__xor2_1
X_2543_ net94 VSS VSS VDD VDD _1404_ sky130_fd_sc_hd__inv_1
X_2544_ net59 VSS VSS VDD VDD _1408_ sky130_fd_sc_hd__inv_1
X_2545_ transfer_count\[1\]\[8\] _0477_ VSS VSS VDD VDD _1054_
+ sky130_fd_sc_hd__xnor2_1
X_2546_ _0820_ _0549_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__nor2_1
X_2547_ transfer_count\[1\]\[31\] _0794_ VSS VSS VDD VDD _1057_
+ sky130_fd_sc_hd__xnor2_1
X_2548_ transfer_count\[1\]\[30\] _0545_ VSS VSS VDD VDD _1060_
+ sky130_fd_sc_hd__xor2_1
X_2549_ transfer_count\[1\]\[28\] _0540_ VSS VSS VDD VDD _1066_
+ sky130_fd_sc_hd__xnor2_1
X_2550_ _0534_ _0535_ VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__xnor2_1
X_2551_ transfer_count\[1\]\[26\] _0530_ VSS VSS VDD VDD _1072_
+ sky130_fd_sc_hd__xor2_1
X_2552_ transfer_count\[1\]\[24\] _0525_ VSS VSS VDD VDD _1078_
+ sky130_fd_sc_hd__xor2_1
X_2553_ transfer_count\[1\]\[23\] _0522_ VSS VSS VDD VDD _1081_
+ sky130_fd_sc_hd__xor2_1
X_2554_ transfer_count\[1\]\[22\] _0519_ VSS VSS VDD VDD _1084_
+ sky130_fd_sc_hd__xor2_1
X_2555_ transfer_count\[1\]\[20\] _0513_ VSS VSS VDD VDD _1090_
+ sky130_fd_sc_hd__xor2_1
X_2556_ transfer_count\[1\]\[19\] _0510_ VSS VSS VDD VDD _1093_
+ sky130_fd_sc_hd__xnor2_1
X_2557_ transfer_count\[1\]\[18\] _0504_ VSS VSS VDD VDD _1096_
+ sky130_fd_sc_hd__xor2_1
X_2558_ transfer_count\[1\]\[16\] _0496_ VSS VSS VDD VDD _1102_
+ sky130_fd_sc_hd__xnor2_1
X_2559_ transfer_count\[3\]\[31\] _0299_ VSS VSS VDD VDD _1105_
+ sky130_fd_sc_hd__xnor2_1
X_2560_ transfer_count\[3\]\[30\] _0295_ VSS VSS VDD VDD _1108_
+ sky130_fd_sc_hd__xnor2_1
X_2561_ transfer_count\[3\]\[28\] _0288_ VSS VSS VDD VDD _1114_
+ sky130_fd_sc_hd__xnor2_1
X_2562_ transfer_count\[3\]\[26\] _0281_ VSS VSS VDD VDD _1120_
+ sky130_fd_sc_hd__xnor2_1
X_2563_ _0884_ _0274_ VSS VSS VDD VDD _1126_ sky130_fd_sc_hd__xor2_1
X_2564_ transfer_count\[3\]\[22\] _0268_ VSS VSS VDD VDD _1132_
+ sky130_fd_sc_hd__xnor2_1
X_2565_ transfer_count\[3\]\[20\] _0263_ VSS VSS VDD VDD _1138_
+ sky130_fd_sc_hd__xnor2_1
X_2566_ transfer_count\[3\]\[18\] _0259_ VSS VSS VDD VDD _1144_
+ sky130_fd_sc_hd__xor2_1
X_2567_ transfer_count\[3\]\[17\] _0256_ VSS VSS VDD VDD _1147_
+ sky130_fd_sc_hd__xor2_1
X_2568_ transfer_count\[3\]\[16\] _0252_ VSS VSS VDD VDD _1150_
+ sky130_fd_sc_hd__xnor2_1
X_2569_ transfer_count\[3\]\[14\] _0246_ VSS VSS VDD VDD _1156_
+ sky130_fd_sc_hd__xnor2_1
X_2570_ transfer_count\[3\]\[6\] _0225_ VSS VSS VDD VDD _1180_
+ sky130_fd_sc_hd__xor2_1
X_2571_ transfer_count\[3\]\[2\] _0211_ VSS VSS VDD VDD _1192_
+ sky130_fd_sc_hd__xnor2_1
X_2572_ transfer_count\[0\]\[3\] _0987_ VSS VSS VDD VDD _1213_
+ sky130_fd_sc_hd__xnor2_1
X_2573_ transfer_count\[0\]\[2\] _1208_ VSS VSS VDD VDD _1216_
+ sky130_fd_sc_hd__xnor2_1
X_2574_ _0991_ _0997_ VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__xnor2_1
X_2575_ transfer_count\[0\]\[6\] _0573_ VSS VSS VDD VDD _1222_
+ sky130_fd_sc_hd__xor2_1
X_2576_ transfer_count\[0\]\[15\] _1015_ VSS VSS VDD VDD _1231_
+ sky130_fd_sc_hd__xnor2_1
X_2577_ transfer_count\[0\]\[11\] _0589_ VSS VSS VDD VDD _1243_
+ sky130_fd_sc_hd__xnor2_1
X_2578_ _0989_ _0580_ VSS VSS VDD VDD _1252_ sky130_fd_sc_hd__xor2_1
X_2579_ transfer_count\[0\]\[31\] _0652_ VSS VSS VDD VDD _1255_
+ sky130_fd_sc_hd__xor2_1
X_2580_ transfer_count\[0\]\[30\] _0648_ VSS VSS VDD VDD _1258_
+ sky130_fd_sc_hd__xor2_1
X_2581_ transfer_count\[0\]\[28\] _0642_ VSS VSS VDD VDD _1264_
+ sky130_fd_sc_hd__xnor2_1
X_2582_ transfer_count\[0\]\[27\] _0638_ VSS VSS VDD VDD _1267_
+ sky130_fd_sc_hd__xor2_1
X_2583_ transfer_count\[0\]\[26\] _0635_ VSS VSS VDD VDD _1270_
+ sky130_fd_sc_hd__xor2_1
X_2584_ transfer_count\[0\]\[24\] _0630_ VSS VSS VDD VDD _1276_
+ sky130_fd_sc_hd__xor2_1
X_2585_ transfer_count\[0\]\[23\] _0627_ VSS VSS VDD VDD _1279_
+ sky130_fd_sc_hd__xor2_1
X_2586_ _0999_ _0623_ VSS VSS VDD VDD _1282_ sky130_fd_sc_hd__xnor2_1
X_2587_ transfer_count\[0\]\[20\] _0618_ VSS VSS VDD VDD _1288_
+ sky130_fd_sc_hd__xor2_1
X_2588_ transfer_count\[0\]\[19\] _0614_ VSS VSS VDD VDD _1291_
+ sky130_fd_sc_hd__xnor2_1
X_2589_ transfer_count\[0\]\[18\] _0610_ VSS VSS VDD VDD _1294_
+ sky130_fd_sc_hd__xor2_1
X_2590_ _1003_ _0604_ VSS VSS VDD VDD _1300_ sky130_fd_sc_hd__xnor2_1
X_2591_ active_channel_count\[1\] VSS VSS VDD VDD _1304_ sky130_fd_sc_hd__inv_1
X_2592_ transfer_count\[2\]\[31\] _0442_ VSS VSS VDD VDD _1309_
+ sky130_fd_sc_hd__xor2_1
X_2593_ transfer_count\[2\]\[28\] _0431_ VSS VSS VDD VDD _1318_
+ sky130_fd_sc_hd__xor2_1
X_2594_ transfer_count\[2\]\[24\] _0416_ VSS VSS VDD VDD _1330_
+ sky130_fd_sc_hd__xor2_1
X_2595_ transfer_count\[2\]\[22\] _0405_ VSS VSS VDD VDD _1336_
+ sky130_fd_sc_hd__xor2_1
X_2596_ transfer_count\[2\]\[20\] _0396_ VSS VSS VDD VDD _1342_
+ sky130_fd_sc_hd__xnor2_1
X_2597_ transfer_count\[2\]\[18\] _0388_ VSS VSS VDD VDD _1348_
+ sky130_fd_sc_hd__xor2_1
X_2598_ transfer_count\[2\]\[17\] _0383_ VSS VSS VDD VDD _1351_
+ sky130_fd_sc_hd__xor2_1
X_2599_ transfer_count\[2\]\[16\] _0380_ VSS VSS VDD VDD _1354_
+ sky130_fd_sc_hd__xor2_1
X_2600_ transfer_count\[2\]\[14\] _0366_ VSS VSS VDD VDD _1360_
+ sky130_fd_sc_hd__xor2_2
X_2601_ transfer_count\[2\]\[12\] _0357_ VSS VSS VDD VDD _1366_
+ sky130_fd_sc_hd__xnor2_1
X_2602_ _0347_ _0349_ VSS VSS VDD VDD _1372_ sky130_fd_sc_hd__xor2_1
X_2603_ transfer_count\[2\]\[8\] _0341_ VSS VSS VDD VDD _1378_
+ sky130_fd_sc_hd__xor2_2
X_2604_ transfer_count\[2\]\[6\] _0331_ VSS VSS VDD VDD _1384_
+ sky130_fd_sc_hd__xnor2_1
X_2605_ transfer_count\[2\]\[2\] _1399_ VSS VSS VDD VDD _1396_
+ sky130_fd_sc_hd__xnor2_1
X_2606_ transfer_count\[1\]\[3\] _0460_ VSS VSS VDD VDD _1417_
+ sky130_fd_sc_hd__xor2_1
X_2607_ _1412_ transfer_count\[1\]\[2\] VSS VSS VDD VDD _1420_
+ sky130_fd_sc_hd__xnor2_1
X_2608_ transfer_count\[1\]\[7\] _0473_ VSS VSS VDD VDD _1423_
+ sky130_fd_sc_hd__xor2_1
X_2609_ _0800_ _0468_ VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__xnor2_1
X_2610_ _0553_ _0554_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__nand2_1
X_2611_ _0553_ _0684_ _0795_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__o21ai_1
X_2612_ _0445_ _0827_ _0695_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__a21o_1
X_2613_ _0671_ _0301_ _0701_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__o21ai_0
X_2614_ _0920_ _0921_ _0769_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__a21o_1
X_2615_ net145 _0666_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__nand2b_1
X_2616_ _0667_ _0796_ _0920_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__a21oi_1
X_2617_ net75 _1033_ VSS VSS VDD VDD _1034_ _1035_ sky130_fd_sc_hd__ha_1
X_2618_ net74 _1036_ VSS VSS VDD VDD _1037_ _1038_ sky130_fd_sc_hd__ha_1
X_2619_ net73 _1039_ VSS VSS VDD VDD _1040_ _1041_ sky130_fd_sc_hd__ha_1
X_2620_ net72 _1042_ VSS VSS VDD VDD _1043_ _1044_ sky130_fd_sc_hd__ha_1
X_2621_ net71 _1045_ VSS VSS VDD VDD _1046_ _1047_ sky130_fd_sc_hd__ha_1
X_2622_ net70 _1048_ VSS VSS VDD VDD _1049_ _1050_ sky130_fd_sc_hd__ha_1
X_2623_ net69 _1051_ VSS VSS VDD VDD _1052_ _1053_ sky130_fd_sc_hd__ha_1
X_2624_ net68 _1054_ VSS VSS VDD VDD _1055_ _1056_ sky130_fd_sc_hd__ha_1
X_2625_ net93 _1057_ VSS VSS VDD VDD _1058_ _1059_ sky130_fd_sc_hd__ha_1
X_2626_ net92 _1060_ VSS VSS VDD VDD _1061_ _1062_ sky130_fd_sc_hd__ha_1
X_2627_ net91 _1063_ VSS VSS VDD VDD _1064_ _1065_ sky130_fd_sc_hd__ha_1
X_2628_ net90 _1066_ VSS VSS VDD VDD _1067_ _1068_ sky130_fd_sc_hd__ha_1
X_2629_ net88 _1069_ VSS VSS VDD VDD _1070_ _1071_ sky130_fd_sc_hd__ha_1
X_2630_ net87 _1072_ VSS VSS VDD VDD _1073_ _1074_ sky130_fd_sc_hd__ha_1
X_2631_ net86 _1075_ VSS VSS VDD VDD _1076_ _1077_ sky130_fd_sc_hd__ha_1
X_2632_ net85 _1078_ VSS VSS VDD VDD _1079_ _1080_ sky130_fd_sc_hd__ha_1
X_2633_ net84 _1081_ VSS VSS VDD VDD _1082_ _1083_ sky130_fd_sc_hd__ha_1
X_2634_ net83 _1084_ VSS VSS VDD VDD _1085_ _1086_ sky130_fd_sc_hd__ha_1
X_2635_ net82 _1087_ VSS VSS VDD VDD _1088_ _1089_ sky130_fd_sc_hd__ha_1
X_2636_ net81 _1090_ VSS VSS VDD VDD _1091_ _1092_ sky130_fd_sc_hd__ha_1
X_2637_ net80 _1093_ VSS VSS VDD VDD _1094_ _1095_ sky130_fd_sc_hd__ha_1
X_2638_ net79 _1096_ VSS VSS VDD VDD _1097_ _1098_ sky130_fd_sc_hd__ha_1
X_2639_ net77 _1099_ VSS VSS VDD VDD _1100_ _1101_ sky130_fd_sc_hd__ha_1
X_2640_ net76 _1102_ VSS VSS VDD VDD _1103_ _1104_ sky130_fd_sc_hd__ha_1
X_2641_ net36 _1105_ VSS VSS VDD VDD _1106_ _1107_ sky130_fd_sc_hd__ha_1
X_2642_ net35 _1108_ VSS VSS VDD VDD _1109_ _1110_ sky130_fd_sc_hd__ha_1
X_2643_ net34 _1111_ VSS VSS VDD VDD _1112_ _1113_ sky130_fd_sc_hd__ha_1
X_2644_ net33 _1114_ VSS VSS VDD VDD _1115_ _1116_ sky130_fd_sc_hd__ha_1
X_2645_ net32 _1117_ VSS VSS VDD VDD _1118_ _1119_ sky130_fd_sc_hd__ha_1
X_2646_ net31 _1120_ VSS VSS VDD VDD _1121_ _1122_ sky130_fd_sc_hd__ha_1
X_2647_ net30 _1123_ VSS VSS VDD VDD _1124_ _1125_ sky130_fd_sc_hd__ha_1
X_2648_ net29 _1126_ VSS VSS VDD VDD _1127_ _1128_ sky130_fd_sc_hd__ha_1
X_2649_ net27 _1129_ VSS VSS VDD VDD _1130_ _1131_ sky130_fd_sc_hd__ha_1
X_2650_ net26 _1132_ VSS VSS VDD VDD _1133_ _1134_ sky130_fd_sc_hd__ha_1
X_2651_ net25 _1135_ VSS VSS VDD VDD _1136_ _1137_ sky130_fd_sc_hd__ha_1
X_2652_ net24 _1138_ VSS VSS VDD VDD _1139_ _1140_ sky130_fd_sc_hd__ha_1
X_2653_ net23 _1141_ VSS VSS VDD VDD _1142_ _1143_ sky130_fd_sc_hd__ha_1
X_2654_ net22 _1144_ VSS VSS VDD VDD _1145_ _1146_ sky130_fd_sc_hd__ha_1
X_2655_ net21 _1147_ VSS VSS VDD VDD _1148_ _1149_ sky130_fd_sc_hd__ha_1
X_2656_ net20 _1150_ VSS VSS VDD VDD _1151_ _1152_ sky130_fd_sc_hd__ha_1
X_2657_ net19 _1153_ VSS VSS VDD VDD _1154_ _1155_ sky130_fd_sc_hd__ha_1
X_2658_ net18 _1156_ VSS VSS VDD VDD _1157_ _1158_ sky130_fd_sc_hd__ha_1
X_2659_ net16 _1159_ VSS VSS VDD VDD _1160_ _1161_ sky130_fd_sc_hd__ha_1
X_2660_ net15 _1162_ VSS VSS VDD VDD _1163_ _1164_ sky130_fd_sc_hd__ha_1
X_2661_ net14 _1165_ VSS VSS VDD VDD _1166_ _1167_ sky130_fd_sc_hd__ha_1
X_2662_ net13 _1168_ VSS VSS VDD VDD _1169_ _1170_ sky130_fd_sc_hd__ha_1
X_2663_ net12 _1171_ VSS VSS VDD VDD _1172_ _1173_ sky130_fd_sc_hd__ha_1
X_2664_ net11 _1174_ VSS VSS VDD VDD _1175_ _1176_ sky130_fd_sc_hd__ha_1
X_2665_ net10 _1177_ VSS VSS VDD VDD _1178_ _1179_ sky130_fd_sc_hd__ha_1
X_2666_ net9 _1180_ VSS VSS VDD VDD _1181_ _1182_ sky130_fd_sc_hd__ha_1
X_2667_ net8 _1183_ VSS VSS VDD VDD _1184_ _1185_ sky130_fd_sc_hd__ha_1
X_2668_ net7 _1186_ VSS VSS VDD VDD _1187_ _1188_ sky130_fd_sc_hd__ha_1
X_2669_ net132 _1189_ VSS VSS VDD VDD _1190_ _1191_ sky130_fd_sc_hd__ha_1
X_2670_ net131 _1192_ VSS VSS VDD VDD _1193_ _1194_ sky130_fd_sc_hd__ha_1
X_2671_ transfer_count\[3\]\[0\] transfer_count\[3\]\[1\]
+ VSS VSS VDD VDD _1195_ _1196_ sky130_fd_sc_hd__ha_1
X_2672_ net130 _1197_ VSS VSS VDD VDD _1198_ _1199_ sky130_fd_sc_hd__ha_1
X_2673_ _1200_ _1201_ VSS VSS VDD VDD _1202_ _1203_ sky130_fd_sc_hd__ha_1
X_2674_ _1204_ _1205_ VSS VSS VDD VDD _1206_ _1207_ sky130_fd_sc_hd__ha_1
X_2675_ transfer_count\[0\]\[0\] transfer_count\[0\]\[1\]
+ VSS VSS VDD VDD _1208_ _1209_ sky130_fd_sc_hd__ha_2
X_2676_ net45 _1210_ VSS VSS VDD VDD _1211_ _1212_ sky130_fd_sc_hd__ha_1
X_2677_ net67 _1213_ VSS VSS VDD VDD _1214_ _1215_ sky130_fd_sc_hd__ha_1
X_2678_ net56 _1216_ VSS VSS VDD VDD _1217_ _1218_ sky130_fd_sc_hd__ha_1
X_2679_ net111 _1219_ VSS VSS VDD VDD _1220_ _1221_ sky130_fd_sc_hd__ha_1
X_2680_ net100 _1222_ VSS VSS VDD VDD _1223_ _1224_ sky130_fd_sc_hd__ha_1
X_2681_ net89 _1225_ VSS VSS VDD VDD _1226_ _1227_ sky130_fd_sc_hd__ha_1
X_2682_ net78 _1228_ VSS VSS VDD VDD _1229_ _1230_ sky130_fd_sc_hd__ha_1
X_2683_ net40 _1231_ VSS VSS VDD VDD _1232_ _1233_ sky130_fd_sc_hd__ha_1
X_2684_ net39 _1234_ VSS VSS VDD VDD _1235_ _1236_ sky130_fd_sc_hd__ha_1
X_2685_ net38 _1237_ VSS VSS VDD VDD _1238_ _1239_ sky130_fd_sc_hd__ha_1
X_2686_ net37 _1240_ VSS VSS VDD VDD _1241_ _1242_ sky130_fd_sc_hd__ha_1
X_2687_ net28 _1243_ VSS VSS VDD VDD _1244_ _1245_ sky130_fd_sc_hd__ha_1
X_2688_ net17 _1246_ VSS VSS VDD VDD _1247_ _1248_ sky130_fd_sc_hd__ha_1
X_2689_ net133 _1249_ VSS VSS VDD VDD _1250_ _1251_ sky130_fd_sc_hd__ha_1
X_2690_ net122 _1252_ VSS VSS VDD VDD _1253_ _1254_ sky130_fd_sc_hd__ha_1
X_2691_ net58 _1255_ VSS VSS VDD VDD _1256_ _1257_ sky130_fd_sc_hd__ha_1
X_2692_ net57 _1258_ VSS VSS VDD VDD _1259_ _1260_ sky130_fd_sc_hd__ha_1
X_2693_ net55 _1261_ VSS VSS VDD VDD _1262_ _1263_ sky130_fd_sc_hd__ha_1
X_2694_ net54 _1264_ VSS VSS VDD VDD _1265_ _1266_ sky130_fd_sc_hd__ha_1
X_2695_ net53 _1267_ VSS VSS VDD VDD _1268_ _1269_ sky130_fd_sc_hd__ha_1
X_2696_ net52 _1270_ VSS VSS VDD VDD _1271_ _1272_ sky130_fd_sc_hd__ha_1
X_2697_ net51 _1273_ VSS VSS VDD VDD _1274_ _1275_ sky130_fd_sc_hd__ha_1
X_2698_ net50 _1276_ VSS VSS VDD VDD _1277_ _1278_ sky130_fd_sc_hd__ha_1
X_2699_ net49 _1279_ VSS VSS VDD VDD _1280_ _1281_ sky130_fd_sc_hd__ha_1
X_2700_ net48 _1282_ VSS VSS VDD VDD _1283_ _1284_ sky130_fd_sc_hd__ha_1
X_2701_ net47 _1285_ VSS VSS VDD VDD _1286_ _1287_ sky130_fd_sc_hd__ha_1
X_2702_ net46 _1288_ VSS VSS VDD VDD _1289_ _1290_ sky130_fd_sc_hd__ha_1
X_2703_ net44 _1291_ VSS VSS VDD VDD _1292_ _1293_ sky130_fd_sc_hd__ha_1
X_2704_ net43 _1294_ VSS VSS VDD VDD _1295_ _1296_ sky130_fd_sc_hd__ha_1
X_2705_ net42 _1297_ VSS VSS VDD VDD _1298_ _1299_ sky130_fd_sc_hd__ha_1
X_2706_ net41 _1300_ VSS VSS VDD VDD _1301_ _1302_ sky130_fd_sc_hd__ha_1
X_2707_ _1303_ _1304_ VSS VSS VDD VDD _1305_ _1306_ sky130_fd_sc_hd__ha_1
X_2708_ active_channel_count\[0\] active_channel_count\[1\]
+ VSS VSS VDD VDD _1307_ _1308_ sky130_fd_sc_hd__ha_1
X_2709_ net128 _1309_ VSS VSS VDD VDD _1310_ _1311_ sky130_fd_sc_hd__ha_1
X_2710_ _1312_ net127 VSS VSS VDD VDD _1313_ _1314_ sky130_fd_sc_hd__ha_1
X_2711_ _1315_ net126 VSS VSS VDD VDD _1316_ _1317_ sky130_fd_sc_hd__ha_1
X_2712_ net125 _1318_ VSS VSS VDD VDD _1319_ _1320_ sky130_fd_sc_hd__ha_1
X_2713_ _1321_ net124 VSS VSS VDD VDD _1322_ _1323_ sky130_fd_sc_hd__ha_1
X_2714_ _1324_ net123 VSS VSS VDD VDD _1325_ _1326_ sky130_fd_sc_hd__ha_1
X_2715_ net121 _1327_ VSS VSS VDD VDD _1328_ _1329_ sky130_fd_sc_hd__ha_1
X_2716_ net120 _1330_ VSS VSS VDD VDD _1331_ _1332_ sky130_fd_sc_hd__ha_1
X_2717_ net119 _1333_ VSS VSS VDD VDD _1334_ _1335_ sky130_fd_sc_hd__ha_1
X_2718_ net118 _1336_ VSS VSS VDD VDD _1337_ _1338_ sky130_fd_sc_hd__ha_1
X_2719_ net117 _1339_ VSS VSS VDD VDD _1340_ _1341_ sky130_fd_sc_hd__ha_1
X_2720_ net116 _1342_ VSS VSS VDD VDD _1343_ _1344_ sky130_fd_sc_hd__ha_1
X_2721_ net115 _1345_ VSS VSS VDD VDD _1346_ _1347_ sky130_fd_sc_hd__ha_1
X_2722_ net114 _1348_ VSS VSS VDD VDD _1349_ _1350_ sky130_fd_sc_hd__ha_1
X_2723_ net113 _1351_ VSS VSS VDD VDD _1352_ _1353_ sky130_fd_sc_hd__ha_1
X_2724_ net112 _1354_ VSS VSS VDD VDD _1355_ _1356_ sky130_fd_sc_hd__ha_1
X_2725_ net110 _1357_ VSS VSS VDD VDD _1358_ _1359_ sky130_fd_sc_hd__ha_1
X_2726_ net109 _1360_ VSS VSS VDD VDD _1361_ _1362_ sky130_fd_sc_hd__ha_1
X_2727_ net108 _1363_ VSS VSS VDD VDD _1364_ _1365_ sky130_fd_sc_hd__ha_1
X_2728_ net107 _1366_ VSS VSS VDD VDD _1367_ _1368_ sky130_fd_sc_hd__ha_1
X_2729_ net106 _1369_ VSS VSS VDD VDD _1370_ _1371_ sky130_fd_sc_hd__ha_1
X_2730_ net105 _1372_ VSS VSS VDD VDD _1373_ _1374_ sky130_fd_sc_hd__ha_1
X_2731_ net104 _1375_ VSS VSS VDD VDD _1376_ _1377_ sky130_fd_sc_hd__ha_1
X_2732_ net103 _1378_ VSS VSS VDD VDD _1379_ _1380_ sky130_fd_sc_hd__ha_1
X_2733_ net102 _1381_ VSS VSS VDD VDD _1382_ _1383_ sky130_fd_sc_hd__ha_1
X_2734_ net101 _1384_ VSS VSS VDD VDD _1385_ _1386_ sky130_fd_sc_hd__ha_1
X_2735_ net99 _1387_ VSS VSS VDD VDD _1388_ _1389_ sky130_fd_sc_hd__ha_1
X_2736_ net98 _1390_ VSS VSS VDD VDD _1391_ _1392_ sky130_fd_sc_hd__ha_1
X_2737_ net97 _1393_ VSS VSS VDD VDD _1394_ _1395_ sky130_fd_sc_hd__ha_1
X_2738_ net96 _1396_ VSS VSS VDD VDD _1397_ _1398_ sky130_fd_sc_hd__ha_1
X_2739_ transfer_count\[2\]\[0\] transfer_count\[2\]\[1\]
+ VSS VSS VDD VDD _1399_ _1400_ sky130_fd_sc_hd__ha_1
X_2740_ net95 _1401_ VSS VSS VDD VDD _1402_ _1403_ sky130_fd_sc_hd__ha_1
X_2741_ _1404_ _1405_ VSS VSS VDD VDD _1406_ _1407_ sky130_fd_sc_hd__ha_1
X_2742_ _1408_ _1409_ VSS VSS VDD VDD _1410_ _1411_ sky130_fd_sc_hd__ha_1
X_2743_ transfer_count\[1\]\[0\] transfer_count\[1\]\[1\]
+ VSS VSS VDD VDD _1412_ _1413_ sky130_fd_sc_hd__ha_1
X_2744_ net60 _1414_ VSS VSS VDD VDD _1415_ _1416_ sky130_fd_sc_hd__ha_1
X_2745_ net62 _1417_ VSS VSS VDD VDD _1418_ _1419_ sky130_fd_sc_hd__ha_1
X_2746_ net61 _1420_ VSS VSS VDD VDD _1421_ _1422_ sky130_fd_sc_hd__ha_1
X_2747_ net66 _1423_ VSS VSS VDD VDD _1424_ _1425_ sky130_fd_sc_hd__ha_1
X_2748_ net65 _1426_ VSS VSS VDD VDD _1427_ _1428_ sky130_fd_sc_hd__ha_1
X_2749_ net64 _1429_ VSS VSS VDD VDD _1430_ _1431_ sky130_fd_sc_hd__ha_1
X_2750_ net63 _1432_ VSS VSS VDD VDD _1433_ _1434_ sky130_fd_sc_hd__ha_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_2752_ net175 VSS VSS VDD VDD debug_channel_state[0] sky130_fd_sc_hd__buf_4
X_2753_ net176 VSS VSS VDD VDD debug_channel_state[1] sky130_fd_sc_hd__buf_4
X_2754_ net177 VSS VSS VDD VDD debug_channel_state[2] sky130_fd_sc_hd__buf_4
X_2755_ net178 VSS VSS VDD VDD debug_channel_state[3] sky130_fd_sc_hd__buf_4
X_2756_ net179 VSS VSS VDD VDD debug_channel_state[4] sky130_fd_sc_hd__buf_4
X_2757_ net180 VSS VSS VDD VDD debug_channel_state[5] sky130_fd_sc_hd__buf_4
X_2758_ net181 VSS VSS VDD VDD debug_channel_state[6] sky130_fd_sc_hd__buf_4
X_2759_ net182 VSS VSS VDD VDD debug_channel_state[7] sky130_fd_sc_hd__buf_4
X_2760_ net183 VSS VSS VDD VDD debug_channel_state[8] sky130_fd_sc_hd__buf_4
X_2761_ net184 VSS VSS VDD VDD debug_channel_state[9] sky130_fd_sc_hd__buf_4
X_2762_ net185 VSS VSS VDD VDD debug_channel_state[10] sky130_fd_sc_hd__buf_4
X_2763_ net186 VSS VSS VDD VDD debug_channel_state[11] sky130_fd_sc_hd__buf_4
X_2764_ net187 VSS VSS VDD VDD debug_transfer_count[0] sky130_fd_sc_hd__buf_4
X_2765_ net188 VSS VSS VDD VDD debug_transfer_count[1] sky130_fd_sc_hd__buf_4
X_2766_ net189 VSS VSS VDD VDD debug_transfer_count[2] sky130_fd_sc_hd__buf_4
X_2767_ net190 VSS VSS VDD VDD debug_transfer_count[3] sky130_fd_sc_hd__buf_4
X_2768_ net191 VSS VSS VDD VDD debug_transfer_count[4] sky130_fd_sc_hd__buf_4
X_2769_ net192 VSS VSS VDD VDD debug_transfer_count[5] sky130_fd_sc_hd__buf_4
X_2770_ net193 VSS VSS VDD VDD debug_transfer_count[6] sky130_fd_sc_hd__buf_4
X_2771_ net194 VSS VSS VDD VDD debug_transfer_count[7] sky130_fd_sc_hd__buf_4
X_2772_ net195 VSS VSS VDD VDD debug_transfer_count[8] sky130_fd_sc_hd__buf_4
X_2773_ net196 VSS VSS VDD VDD debug_transfer_count[9] sky130_fd_sc_hd__buf_4
X_2774_ net197 VSS VSS VDD VDD debug_transfer_count[10] sky130_fd_sc_hd__buf_4
X_2775_ net198 VSS VSS VDD VDD debug_transfer_count[11] sky130_fd_sc_hd__buf_4
X_2776_ net199 VSS VSS VDD VDD debug_transfer_count[12] sky130_fd_sc_hd__buf_4
X_2777_ net200 VSS VSS VDD VDD debug_transfer_count[13] sky130_fd_sc_hd__buf_4
X_2778_ net201 VSS VSS VDD VDD debug_transfer_count[14] sky130_fd_sc_hd__buf_4
X_2779_ net202 VSS VSS VDD VDD debug_transfer_count[15] sky130_fd_sc_hd__buf_4
X_2780_ net203 VSS VSS VDD VDD debug_transfer_count[16] sky130_fd_sc_hd__buf_4
X_2781_ net204 VSS VSS VDD VDD debug_transfer_count[17] sky130_fd_sc_hd__buf_4
X_2782_ net205 VSS VSS VDD VDD debug_transfer_count[18] sky130_fd_sc_hd__buf_4
X_2783_ net206 VSS VSS VDD VDD debug_transfer_count[19] sky130_fd_sc_hd__buf_4
X_2784_ net207 VSS VSS VDD VDD debug_transfer_count[20] sky130_fd_sc_hd__buf_4
X_2785_ net208 VSS VSS VDD VDD debug_transfer_count[21] sky130_fd_sc_hd__buf_4
X_2786_ net209 VSS VSS VDD VDD debug_transfer_count[22] sky130_fd_sc_hd__buf_4
X_2787_ net210 VSS VSS VDD VDD debug_transfer_count[23] sky130_fd_sc_hd__buf_4
X_2788_ net211 VSS VSS VDD VDD debug_transfer_count[24] sky130_fd_sc_hd__buf_4
X_2789_ net212 VSS VSS VDD VDD debug_transfer_count[25] sky130_fd_sc_hd__buf_4
X_2790_ net213 VSS VSS VDD VDD debug_transfer_count[26] sky130_fd_sc_hd__buf_4
X_2791_ net214 VSS VSS VDD VDD debug_transfer_count[27] sky130_fd_sc_hd__buf_4
X_2792_ net215 VSS VSS VDD VDD debug_transfer_count[28] sky130_fd_sc_hd__buf_4
X_2793_ net216 VSS VSS VDD VDD debug_transfer_count[29] sky130_fd_sc_hd__buf_4
X_2794_ net217 VSS VSS VDD VDD debug_transfer_count[30] sky130_fd_sc_hd__buf_4
X_2795_ net218 VSS VSS VDD VDD debug_transfer_count[31] sky130_fd_sc_hd__buf_4
X_2796_ net219 VSS VSS VDD VDD debug_transfer_count[32] sky130_fd_sc_hd__buf_4
X_2797_ net220 VSS VSS VDD VDD debug_transfer_count[33] sky130_fd_sc_hd__buf_4
X_2798_ net221 VSS VSS VDD VDD debug_transfer_count[34] sky130_fd_sc_hd__buf_4
X_2799_ net222 VSS VSS VDD VDD debug_transfer_count[35] sky130_fd_sc_hd__buf_4
X_2800_ net223 VSS VSS VDD VDD debug_transfer_count[36] sky130_fd_sc_hd__buf_4
X_2801_ net224 VSS VSS VDD VDD debug_transfer_count[37] sky130_fd_sc_hd__buf_4
X_2802_ net225 VSS VSS VDD VDD debug_transfer_count[38] sky130_fd_sc_hd__buf_4
X_2803_ net226 VSS VSS VDD VDD debug_transfer_count[39] sky130_fd_sc_hd__buf_4
X_2804_ net227 VSS VSS VDD VDD debug_transfer_count[40] sky130_fd_sc_hd__buf_4
X_2805_ net228 VSS VSS VDD VDD debug_transfer_count[41] sky130_fd_sc_hd__buf_4
X_2806_ net229 VSS VSS VDD VDD debug_transfer_count[42] sky130_fd_sc_hd__buf_4
X_2807_ net230 VSS VSS VDD VDD debug_transfer_count[43] sky130_fd_sc_hd__buf_4
X_2808_ net231 VSS VSS VDD VDD debug_transfer_count[44] sky130_fd_sc_hd__buf_4
X_2809_ net232 VSS VSS VDD VDD debug_transfer_count[45] sky130_fd_sc_hd__buf_4
X_2810_ net233 VSS VSS VDD VDD debug_transfer_count[46] sky130_fd_sc_hd__buf_4
X_2811_ net234 VSS VSS VDD VDD debug_transfer_count[47] sky130_fd_sc_hd__buf_4
X_2812_ net235 VSS VSS VDD VDD debug_transfer_count[48] sky130_fd_sc_hd__buf_4
X_2813_ net236 VSS VSS VDD VDD debug_transfer_count[49] sky130_fd_sc_hd__buf_4
X_2814_ net237 VSS VSS VDD VDD debug_transfer_count[50] sky130_fd_sc_hd__buf_4
X_2815_ net238 VSS VSS VDD VDD debug_transfer_count[51] sky130_fd_sc_hd__buf_4
X_2816_ net239 VSS VSS VDD VDD debug_transfer_count[52] sky130_fd_sc_hd__buf_4
X_2817_ net240 VSS VSS VDD VDD debug_transfer_count[53] sky130_fd_sc_hd__buf_4
X_2818_ net241 VSS VSS VDD VDD debug_transfer_count[54] sky130_fd_sc_hd__buf_4
X_2819_ net242 VSS VSS VDD VDD debug_transfer_count[55] sky130_fd_sc_hd__buf_4
X_2820_ net243 VSS VSS VDD VDD debug_transfer_count[56] sky130_fd_sc_hd__buf_4
X_2821_ net244 VSS VSS VDD VDD debug_transfer_count[57] sky130_fd_sc_hd__buf_4
X_2822_ net245 VSS VSS VDD VDD debug_transfer_count[58] sky130_fd_sc_hd__buf_4
X_2823_ net246 VSS VSS VDD VDD debug_transfer_count[59] sky130_fd_sc_hd__buf_4
X_2824_ net247 VSS VSS VDD VDD debug_transfer_count[60] sky130_fd_sc_hd__buf_4
X_2825_ net248 VSS VSS VDD VDD debug_transfer_count[61] sky130_fd_sc_hd__buf_4
X_2826_ net249 VSS VSS VDD VDD debug_transfer_count[62] sky130_fd_sc_hd__buf_4
X_2827_ net250 VSS VSS VDD VDD debug_transfer_count[63] sky130_fd_sc_hd__buf_4
X_2828_ net251 VSS VSS VDD VDD debug_transfer_count[64] sky130_fd_sc_hd__buf_4
X_2829_ net252 VSS VSS VDD VDD debug_transfer_count[65] sky130_fd_sc_hd__buf_4
X_2830_ net253 VSS VSS VDD VDD debug_transfer_count[66] sky130_fd_sc_hd__buf_4
X_2831_ net254 VSS VSS VDD VDD debug_transfer_count[67] sky130_fd_sc_hd__buf_4
X_2832_ net255 VSS VSS VDD VDD debug_transfer_count[68] sky130_fd_sc_hd__buf_4
X_2833_ net256 VSS VSS VDD VDD debug_transfer_count[69] sky130_fd_sc_hd__buf_4
X_2834_ net257 VSS VSS VDD VDD debug_transfer_count[70] sky130_fd_sc_hd__buf_4
X_2835_ net258 VSS VSS VDD VDD debug_transfer_count[71] sky130_fd_sc_hd__buf_4
X_2836_ net259 VSS VSS VDD VDD debug_transfer_count[72] sky130_fd_sc_hd__buf_4
X_2837_ net260 VSS VSS VDD VDD debug_transfer_count[73] sky130_fd_sc_hd__buf_4
X_2838_ net261 VSS VSS VDD VDD debug_transfer_count[74] sky130_fd_sc_hd__buf_4
X_2839_ net262 VSS VSS VDD VDD debug_transfer_count[75] sky130_fd_sc_hd__buf_4
X_2840_ net263 VSS VSS VDD VDD debug_transfer_count[76] sky130_fd_sc_hd__buf_4
X_2841_ net264 VSS VSS VDD VDD debug_transfer_count[77] sky130_fd_sc_hd__buf_4
X_2842_ net265 VSS VSS VDD VDD debug_transfer_count[78] sky130_fd_sc_hd__buf_4
X_2843_ net266 VSS VSS VDD VDD debug_transfer_count[79] sky130_fd_sc_hd__buf_4
X_2844_ net267 VSS VSS VDD VDD debug_transfer_count[80] sky130_fd_sc_hd__buf_4
X_2845_ net268 VSS VSS VDD VDD debug_transfer_count[81] sky130_fd_sc_hd__buf_4
X_2846_ net269 VSS VSS VDD VDD debug_transfer_count[82] sky130_fd_sc_hd__buf_4
X_2847_ net270 VSS VSS VDD VDD debug_transfer_count[83] sky130_fd_sc_hd__buf_4
X_2848_ net271 VSS VSS VDD VDD debug_transfer_count[84] sky130_fd_sc_hd__buf_4
X_2849_ net272 VSS VSS VDD VDD debug_transfer_count[85] sky130_fd_sc_hd__buf_4
X_2850_ net273 VSS VSS VDD VDD debug_transfer_count[86] sky130_fd_sc_hd__buf_4
X_2851_ net274 VSS VSS VDD VDD debug_transfer_count[87] sky130_fd_sc_hd__buf_4
X_2852_ net275 VSS VSS VDD VDD debug_transfer_count[88] sky130_fd_sc_hd__buf_4
X_2853_ net276 VSS VSS VDD VDD debug_transfer_count[89] sky130_fd_sc_hd__buf_4
X_2854_ net277 VSS VSS VDD VDD debug_transfer_count[90] sky130_fd_sc_hd__buf_4
X_2855_ net278 VSS VSS VDD VDD debug_transfer_count[91] sky130_fd_sc_hd__buf_4
X_2856_ net279 VSS VSS VDD VDD debug_transfer_count[92] sky130_fd_sc_hd__buf_4
X_2857_ net280 VSS VSS VDD VDD debug_transfer_count[93] sky130_fd_sc_hd__buf_4
X_2858_ net281 VSS VSS VDD VDD debug_transfer_count[94] sky130_fd_sc_hd__buf_4
X_2859_ net282 VSS VSS VDD VDD debug_transfer_count[95] sky130_fd_sc_hd__buf_4
X_2860_ net283 VSS VSS VDD VDD debug_transfer_count[96] sky130_fd_sc_hd__buf_4
X_2861_ net284 VSS VSS VDD VDD debug_transfer_count[97] sky130_fd_sc_hd__buf_4
X_2862_ net285 VSS VSS VDD VDD debug_transfer_count[98] sky130_fd_sc_hd__buf_4
X_2863_ net286 VSS VSS VDD VDD debug_transfer_count[99] sky130_fd_sc_hd__buf_4
X_2864_ net287 VSS VSS VDD VDD debug_transfer_count[100] sky130_fd_sc_hd__buf_4
X_2865_ net288 VSS VSS VDD VDD debug_transfer_count[101] sky130_fd_sc_hd__buf_4
X_2866_ net289 VSS VSS VDD VDD debug_transfer_count[102] sky130_fd_sc_hd__buf_4
X_2867_ net290 VSS VSS VDD VDD debug_transfer_count[103] sky130_fd_sc_hd__buf_4
X_2868_ net291 VSS VSS VDD VDD debug_transfer_count[104] sky130_fd_sc_hd__buf_4
X_2869_ net292 VSS VSS VDD VDD debug_transfer_count[105] sky130_fd_sc_hd__buf_4
X_2870_ net293 VSS VSS VDD VDD debug_transfer_count[106] sky130_fd_sc_hd__buf_4
X_2871_ net294 VSS VSS VDD VDD debug_transfer_count[107] sky130_fd_sc_hd__buf_4
X_2872_ net295 VSS VSS VDD VDD debug_transfer_count[108] sky130_fd_sc_hd__buf_4
X_2873_ net296 VSS VSS VDD VDD debug_transfer_count[109] sky130_fd_sc_hd__buf_4
X_2874_ net297 VSS VSS VDD VDD debug_transfer_count[110] sky130_fd_sc_hd__buf_4
X_2875_ net298 VSS VSS VDD VDD debug_transfer_count[111] sky130_fd_sc_hd__buf_4
X_2876_ net299 VSS VSS VDD VDD debug_transfer_count[112] sky130_fd_sc_hd__buf_4
X_2877_ net300 VSS VSS VDD VDD debug_transfer_count[113] sky130_fd_sc_hd__buf_4
X_2878_ net301 VSS VSS VDD VDD debug_transfer_count[114] sky130_fd_sc_hd__buf_4
X_2879_ net302 VSS VSS VDD VDD debug_transfer_count[115] sky130_fd_sc_hd__buf_4
X_2880_ net303 VSS VSS VDD VDD debug_transfer_count[116] sky130_fd_sc_hd__buf_4
X_2881_ net304 VSS VSS VDD VDD debug_transfer_count[117] sky130_fd_sc_hd__buf_4
X_2882_ net305 VSS VSS VDD VDD debug_transfer_count[118] sky130_fd_sc_hd__buf_4
X_2883_ net306 VSS VSS VDD VDD debug_transfer_count[119] sky130_fd_sc_hd__buf_4
X_2884_ net307 VSS VSS VDD VDD debug_transfer_count[120] sky130_fd_sc_hd__buf_4
X_2885_ net308 VSS VSS VDD VDD debug_transfer_count[121] sky130_fd_sc_hd__buf_4
X_2886_ net309 VSS VSS VDD VDD debug_transfer_count[122] sky130_fd_sc_hd__buf_4
X_2887_ net310 VSS VSS VDD VDD debug_transfer_count[123] sky130_fd_sc_hd__buf_4
X_2888_ net311 VSS VSS VDD VDD debug_transfer_count[124] sky130_fd_sc_hd__buf_4
X_2889_ net312 VSS VSS VDD VDD debug_transfer_count[125] sky130_fd_sc_hd__buf_4
X_2890_ net313 VSS VSS VDD VDD debug_transfer_count[126] sky130_fd_sc_hd__buf_4
X_2891_ net314 VSS VSS VDD VDD debug_transfer_count[127] sky130_fd_sc_hd__buf_4
X_2892_ net315 VSS VSS VDD VDD dst_addr[0] sky130_fd_sc_hd__buf_4
X_2893_ net316 VSS VSS VDD VDD dst_addr[1] sky130_fd_sc_hd__buf_4
X_2894_ net317 VSS VSS VDD VDD dst_addr[2] sky130_fd_sc_hd__buf_4
X_2895_ net318 VSS VSS VDD VDD dst_addr[3] sky130_fd_sc_hd__buf_4
X_2896_ net319 VSS VSS VDD VDD dst_addr[4] sky130_fd_sc_hd__buf_4
X_2897_ net320 VSS VSS VDD VDD dst_addr[5] sky130_fd_sc_hd__buf_4
X_2898_ net321 VSS VSS VDD VDD dst_addr[6] sky130_fd_sc_hd__buf_4
X_2899_ net322 VSS VSS VDD VDD dst_addr[7] sky130_fd_sc_hd__buf_4
X_2900_ net323 VSS VSS VDD VDD dst_addr[8] sky130_fd_sc_hd__buf_4
X_2901_ net324 VSS VSS VDD VDD dst_addr[9] sky130_fd_sc_hd__buf_4
X_2902_ net325 VSS VSS VDD VDD dst_addr[10] sky130_fd_sc_hd__buf_4
X_2903_ net326 VSS VSS VDD VDD dst_addr[11] sky130_fd_sc_hd__buf_4
X_2904_ net327 VSS VSS VDD VDD dst_addr[12] sky130_fd_sc_hd__buf_4
X_2905_ net328 VSS VSS VDD VDD dst_addr[13] sky130_fd_sc_hd__buf_4
X_2906_ net329 VSS VSS VDD VDD dst_addr[14] sky130_fd_sc_hd__buf_4
X_2907_ net330 VSS VSS VDD VDD dst_addr[15] sky130_fd_sc_hd__buf_4
X_2908_ net331 VSS VSS VDD VDD dst_addr[16] sky130_fd_sc_hd__buf_4
X_2909_ net332 VSS VSS VDD VDD dst_addr[17] sky130_fd_sc_hd__buf_4
X_2910_ net333 VSS VSS VDD VDD dst_addr[18] sky130_fd_sc_hd__buf_4
X_2911_ net334 VSS VSS VDD VDD dst_addr[19] sky130_fd_sc_hd__buf_4
X_2912_ net335 VSS VSS VDD VDD dst_addr[20] sky130_fd_sc_hd__buf_4
X_2913_ net336 VSS VSS VDD VDD dst_addr[21] sky130_fd_sc_hd__buf_4
X_2914_ net337 VSS VSS VDD VDD dst_addr[22] sky130_fd_sc_hd__buf_4
X_2915_ net338 VSS VSS VDD VDD dst_addr[23] sky130_fd_sc_hd__buf_4
X_2916_ net339 VSS VSS VDD VDD dst_addr[24] sky130_fd_sc_hd__buf_4
X_2917_ net340 VSS VSS VDD VDD dst_addr[25] sky130_fd_sc_hd__buf_4
X_2918_ net341 VSS VSS VDD VDD dst_addr[26] sky130_fd_sc_hd__buf_4
X_2919_ net342 VSS VSS VDD VDD dst_addr[27] sky130_fd_sc_hd__buf_4
X_2920_ net343 VSS VSS VDD VDD dst_addr[28] sky130_fd_sc_hd__buf_4
X_2921_ net344 VSS VSS VDD VDD dst_addr[29] sky130_fd_sc_hd__buf_4
X_2922_ net345 VSS VSS VDD VDD dst_addr[30] sky130_fd_sc_hd__buf_4
X_2923_ net346 VSS VSS VDD VDD dst_addr[31] sky130_fd_sc_hd__buf_4
X_2924_ net347 VSS VSS VDD VDD dst_addr[32] sky130_fd_sc_hd__buf_4
X_2925_ net348 VSS VSS VDD VDD dst_addr[33] sky130_fd_sc_hd__buf_4
X_2926_ net349 VSS VSS VDD VDD dst_addr[34] sky130_fd_sc_hd__buf_4
X_2927_ net350 VSS VSS VDD VDD dst_addr[35] sky130_fd_sc_hd__buf_4
X_2928_ net351 VSS VSS VDD VDD dst_addr[36] sky130_fd_sc_hd__buf_4
X_2929_ net352 VSS VSS VDD VDD dst_addr[37] sky130_fd_sc_hd__buf_4
X_2930_ net353 VSS VSS VDD VDD dst_addr[38] sky130_fd_sc_hd__buf_4
X_2931_ net354 VSS VSS VDD VDD dst_addr[39] sky130_fd_sc_hd__buf_4
X_2932_ net355 VSS VSS VDD VDD dst_addr[40] sky130_fd_sc_hd__buf_4
X_2933_ net356 VSS VSS VDD VDD dst_addr[41] sky130_fd_sc_hd__buf_4
X_2934_ net357 VSS VSS VDD VDD dst_addr[42] sky130_fd_sc_hd__buf_4
X_2935_ net358 VSS VSS VDD VDD dst_addr[43] sky130_fd_sc_hd__buf_4
X_2936_ net359 VSS VSS VDD VDD dst_addr[44] sky130_fd_sc_hd__buf_4
X_2937_ net360 VSS VSS VDD VDD dst_addr[45] sky130_fd_sc_hd__buf_4
X_2938_ net361 VSS VSS VDD VDD dst_addr[46] sky130_fd_sc_hd__buf_4
X_2939_ net362 VSS VSS VDD VDD dst_addr[47] sky130_fd_sc_hd__buf_4
X_2940_ net363 VSS VSS VDD VDD dst_addr[48] sky130_fd_sc_hd__buf_4
X_2941_ net364 VSS VSS VDD VDD dst_addr[49] sky130_fd_sc_hd__buf_4
X_2942_ net365 VSS VSS VDD VDD dst_addr[50] sky130_fd_sc_hd__buf_4
X_2943_ net366 VSS VSS VDD VDD dst_addr[51] sky130_fd_sc_hd__buf_4
X_2944_ net367 VSS VSS VDD VDD dst_addr[52] sky130_fd_sc_hd__buf_4
X_2945_ net368 VSS VSS VDD VDD dst_addr[53] sky130_fd_sc_hd__buf_4
X_2946_ net369 VSS VSS VDD VDD dst_addr[54] sky130_fd_sc_hd__buf_4
X_2947_ net370 VSS VSS VDD VDD dst_addr[55] sky130_fd_sc_hd__buf_4
X_2948_ net371 VSS VSS VDD VDD dst_addr[56] sky130_fd_sc_hd__buf_4
X_2949_ net372 VSS VSS VDD VDD dst_addr[57] sky130_fd_sc_hd__buf_4
X_2950_ net373 VSS VSS VDD VDD dst_addr[58] sky130_fd_sc_hd__buf_4
X_2951_ net374 VSS VSS VDD VDD dst_addr[59] sky130_fd_sc_hd__buf_4
X_2952_ net375 VSS VSS VDD VDD dst_addr[60] sky130_fd_sc_hd__buf_4
X_2953_ net376 VSS VSS VDD VDD dst_addr[61] sky130_fd_sc_hd__buf_4
X_2954_ net377 VSS VSS VDD VDD dst_addr[62] sky130_fd_sc_hd__buf_4
X_2955_ net378 VSS VSS VDD VDD dst_addr[63] sky130_fd_sc_hd__buf_4
X_2956_ net379 VSS VSS VDD VDD dst_addr[64] sky130_fd_sc_hd__buf_4
X_2957_ net380 VSS VSS VDD VDD dst_addr[65] sky130_fd_sc_hd__buf_4
X_2958_ net381 VSS VSS VDD VDD dst_addr[66] sky130_fd_sc_hd__buf_4
X_2959_ net382 VSS VSS VDD VDD dst_addr[67] sky130_fd_sc_hd__buf_4
X_2960_ net383 VSS VSS VDD VDD dst_addr[68] sky130_fd_sc_hd__buf_4
X_2961_ net384 VSS VSS VDD VDD dst_addr[69] sky130_fd_sc_hd__buf_4
X_2962_ net385 VSS VSS VDD VDD dst_addr[70] sky130_fd_sc_hd__buf_4
X_2963_ net386 VSS VSS VDD VDD dst_addr[71] sky130_fd_sc_hd__buf_4
X_2964_ net387 VSS VSS VDD VDD dst_addr[72] sky130_fd_sc_hd__buf_4
X_2965_ net388 VSS VSS VDD VDD dst_addr[73] sky130_fd_sc_hd__buf_4
X_2966_ net389 VSS VSS VDD VDD dst_addr[74] sky130_fd_sc_hd__buf_4
X_2967_ net390 VSS VSS VDD VDD dst_addr[75] sky130_fd_sc_hd__buf_4
X_2968_ net391 VSS VSS VDD VDD dst_addr[76] sky130_fd_sc_hd__buf_4
X_2969_ net392 VSS VSS VDD VDD dst_addr[77] sky130_fd_sc_hd__buf_4
X_2970_ net393 VSS VSS VDD VDD dst_addr[78] sky130_fd_sc_hd__buf_4
X_2971_ net394 VSS VSS VDD VDD dst_addr[79] sky130_fd_sc_hd__buf_4
X_2972_ net395 VSS VSS VDD VDD dst_addr[80] sky130_fd_sc_hd__buf_4
X_2973_ net396 VSS VSS VDD VDD dst_addr[81] sky130_fd_sc_hd__buf_4
X_2974_ net397 VSS VSS VDD VDD dst_addr[82] sky130_fd_sc_hd__buf_4
X_2975_ net398 VSS VSS VDD VDD dst_addr[83] sky130_fd_sc_hd__buf_4
X_2976_ net399 VSS VSS VDD VDD dst_addr[84] sky130_fd_sc_hd__buf_4
X_2977_ net400 VSS VSS VDD VDD dst_addr[85] sky130_fd_sc_hd__buf_4
X_2978_ net401 VSS VSS VDD VDD dst_addr[86] sky130_fd_sc_hd__buf_4
X_2979_ net402 VSS VSS VDD VDD dst_addr[87] sky130_fd_sc_hd__buf_4
X_2980_ net403 VSS VSS VDD VDD dst_addr[88] sky130_fd_sc_hd__buf_4
X_2981_ net404 VSS VSS VDD VDD dst_addr[89] sky130_fd_sc_hd__buf_4
X_2982_ net405 VSS VSS VDD VDD dst_addr[90] sky130_fd_sc_hd__buf_4
X_2983_ net406 VSS VSS VDD VDD dst_addr[91] sky130_fd_sc_hd__buf_4
X_2984_ net407 VSS VSS VDD VDD dst_addr[92] sky130_fd_sc_hd__buf_4
X_2985_ net408 VSS VSS VDD VDD dst_addr[93] sky130_fd_sc_hd__buf_4
X_2986_ net409 VSS VSS VDD VDD dst_addr[94] sky130_fd_sc_hd__buf_4
X_2987_ net410 VSS VSS VDD VDD dst_addr[95] sky130_fd_sc_hd__buf_4
X_2988_ net411 VSS VSS VDD VDD dst_addr[96] sky130_fd_sc_hd__buf_4
X_2989_ net412 VSS VSS VDD VDD dst_addr[97] sky130_fd_sc_hd__buf_4
X_2990_ net413 VSS VSS VDD VDD dst_addr[98] sky130_fd_sc_hd__buf_4
X_2991_ net414 VSS VSS VDD VDD dst_addr[99] sky130_fd_sc_hd__buf_4
X_2992_ net415 VSS VSS VDD VDD dst_addr[100] sky130_fd_sc_hd__buf_4
X_2993_ net416 VSS VSS VDD VDD dst_addr[101] sky130_fd_sc_hd__buf_4
X_2994_ net417 VSS VSS VDD VDD dst_addr[102] sky130_fd_sc_hd__buf_4
X_2995_ net418 VSS VSS VDD VDD dst_addr[103] sky130_fd_sc_hd__buf_4
X_2996_ net419 VSS VSS VDD VDD dst_addr[104] sky130_fd_sc_hd__buf_4
X_2997_ net420 VSS VSS VDD VDD dst_addr[105] sky130_fd_sc_hd__buf_4
X_2998_ net421 VSS VSS VDD VDD dst_addr[106] sky130_fd_sc_hd__buf_4
X_2999_ net422 VSS VSS VDD VDD dst_addr[107] sky130_fd_sc_hd__buf_4
X_3000_ net423 VSS VSS VDD VDD dst_addr[108] sky130_fd_sc_hd__buf_4
X_3001_ net424 VSS VSS VDD VDD dst_addr[109] sky130_fd_sc_hd__buf_4
X_3002_ net425 VSS VSS VDD VDD dst_addr[110] sky130_fd_sc_hd__buf_4
X_3003_ net426 VSS VSS VDD VDD dst_addr[111] sky130_fd_sc_hd__buf_4
X_3004_ net427 VSS VSS VDD VDD dst_addr[112] sky130_fd_sc_hd__buf_4
X_3005_ net428 VSS VSS VDD VDD dst_addr[113] sky130_fd_sc_hd__buf_4
X_3006_ net429 VSS VSS VDD VDD dst_addr[114] sky130_fd_sc_hd__buf_4
X_3007_ net430 VSS VSS VDD VDD dst_addr[115] sky130_fd_sc_hd__buf_4
X_3008_ net431 VSS VSS VDD VDD dst_addr[116] sky130_fd_sc_hd__buf_4
X_3009_ net432 VSS VSS VDD VDD dst_addr[117] sky130_fd_sc_hd__buf_4
X_3010_ net433 VSS VSS VDD VDD dst_addr[118] sky130_fd_sc_hd__buf_4
X_3011_ net434 VSS VSS VDD VDD dst_addr[119] sky130_fd_sc_hd__buf_4
X_3012_ net435 VSS VSS VDD VDD dst_addr[120] sky130_fd_sc_hd__buf_4
X_3013_ net436 VSS VSS VDD VDD dst_addr[121] sky130_fd_sc_hd__buf_4
X_3014_ net437 VSS VSS VDD VDD dst_addr[122] sky130_fd_sc_hd__buf_4
X_3015_ net438 VSS VSS VDD VDD dst_addr[123] sky130_fd_sc_hd__buf_4
X_3016_ net439 VSS VSS VDD VDD dst_addr[124] sky130_fd_sc_hd__buf_4
X_3017_ net440 VSS VSS VDD VDD dst_addr[125] sky130_fd_sc_hd__buf_4
X_3018_ net441 VSS VSS VDD VDD dst_addr[126] sky130_fd_sc_hd__buf_4
X_3019_ net442 VSS VSS VDD VDD dst_addr[127] sky130_fd_sc_hd__buf_4
X_3020_ net443 VSS VSS VDD VDD dst_wdata[0] sky130_fd_sc_hd__buf_4
X_3021_ net444 VSS VSS VDD VDD dst_wdata[1] sky130_fd_sc_hd__buf_4
X_3022_ net445 VSS VSS VDD VDD dst_wdata[2] sky130_fd_sc_hd__buf_4
X_3023_ net446 VSS VSS VDD VDD dst_wdata[3] sky130_fd_sc_hd__buf_4
X_3024_ net447 VSS VSS VDD VDD dst_wdata[4] sky130_fd_sc_hd__buf_4
X_3025_ net448 VSS VSS VDD VDD dst_wdata[5] sky130_fd_sc_hd__buf_4
X_3026_ net449 VSS VSS VDD VDD dst_wdata[6] sky130_fd_sc_hd__buf_4
X_3027_ net450 VSS VSS VDD VDD dst_wdata[7] sky130_fd_sc_hd__buf_4
X_3028_ net451 VSS VSS VDD VDD dst_wdata[8] sky130_fd_sc_hd__buf_4
X_3029_ net452 VSS VSS VDD VDD dst_wdata[9] sky130_fd_sc_hd__buf_4
X_3030_ net453 VSS VSS VDD VDD dst_wdata[10] sky130_fd_sc_hd__buf_4
X_3031_ net454 VSS VSS VDD VDD dst_wdata[11] sky130_fd_sc_hd__buf_4
X_3032_ net455 VSS VSS VDD VDD dst_wdata[12] sky130_fd_sc_hd__buf_4
X_3033_ net456 VSS VSS VDD VDD dst_wdata[13] sky130_fd_sc_hd__buf_4
X_3034_ net457 VSS VSS VDD VDD dst_wdata[14] sky130_fd_sc_hd__buf_4
X_3035_ net458 VSS VSS VDD VDD dst_wdata[15] sky130_fd_sc_hd__buf_4
X_3036_ net459 VSS VSS VDD VDD dst_wdata[16] sky130_fd_sc_hd__buf_4
X_3037_ net460 VSS VSS VDD VDD dst_wdata[17] sky130_fd_sc_hd__buf_4
X_3038_ net461 VSS VSS VDD VDD dst_wdata[18] sky130_fd_sc_hd__buf_4
X_3039_ net462 VSS VSS VDD VDD dst_wdata[19] sky130_fd_sc_hd__buf_4
X_3040_ net463 VSS VSS VDD VDD dst_wdata[20] sky130_fd_sc_hd__buf_4
X_3041_ net464 VSS VSS VDD VDD dst_wdata[21] sky130_fd_sc_hd__buf_4
X_3042_ net465 VSS VSS VDD VDD dst_wdata[22] sky130_fd_sc_hd__buf_4
X_3043_ net466 VSS VSS VDD VDD dst_wdata[23] sky130_fd_sc_hd__buf_4
X_3044_ net467 VSS VSS VDD VDD dst_wdata[24] sky130_fd_sc_hd__buf_4
X_3045_ net468 VSS VSS VDD VDD dst_wdata[25] sky130_fd_sc_hd__buf_4
X_3046_ net469 VSS VSS VDD VDD dst_wdata[26] sky130_fd_sc_hd__buf_4
X_3047_ net470 VSS VSS VDD VDD dst_wdata[27] sky130_fd_sc_hd__buf_4
X_3048_ net471 VSS VSS VDD VDD dst_wdata[28] sky130_fd_sc_hd__buf_4
X_3049_ net472 VSS VSS VDD VDD dst_wdata[29] sky130_fd_sc_hd__buf_4
X_3050_ net473 VSS VSS VDD VDD dst_wdata[30] sky130_fd_sc_hd__buf_4
X_3051_ net474 VSS VSS VDD VDD dst_wdata[31] sky130_fd_sc_hd__buf_4
X_3052_ net475 VSS VSS VDD VDD dst_wdata[32] sky130_fd_sc_hd__buf_4
X_3053_ net476 VSS VSS VDD VDD dst_wdata[33] sky130_fd_sc_hd__buf_4
X_3054_ net477 VSS VSS VDD VDD dst_wdata[34] sky130_fd_sc_hd__buf_4
X_3055_ net478 VSS VSS VDD VDD dst_wdata[35] sky130_fd_sc_hd__buf_4
X_3056_ net479 VSS VSS VDD VDD dst_wdata[36] sky130_fd_sc_hd__buf_4
X_3057_ net480 VSS VSS VDD VDD dst_wdata[37] sky130_fd_sc_hd__buf_4
X_3058_ net481 VSS VSS VDD VDD dst_wdata[38] sky130_fd_sc_hd__buf_4
X_3059_ net482 VSS VSS VDD VDD dst_wdata[39] sky130_fd_sc_hd__buf_4
X_3060_ net483 VSS VSS VDD VDD dst_wdata[40] sky130_fd_sc_hd__buf_4
X_3061_ net484 VSS VSS VDD VDD dst_wdata[41] sky130_fd_sc_hd__buf_4
X_3062_ net485 VSS VSS VDD VDD dst_wdata[42] sky130_fd_sc_hd__buf_4
X_3063_ net486 VSS VSS VDD VDD dst_wdata[43] sky130_fd_sc_hd__buf_4
X_3064_ net487 VSS VSS VDD VDD dst_wdata[44] sky130_fd_sc_hd__buf_4
X_3065_ net488 VSS VSS VDD VDD dst_wdata[45] sky130_fd_sc_hd__buf_4
X_3066_ net489 VSS VSS VDD VDD dst_wdata[46] sky130_fd_sc_hd__buf_4
X_3067_ net490 VSS VSS VDD VDD dst_wdata[47] sky130_fd_sc_hd__buf_4
X_3068_ net491 VSS VSS VDD VDD dst_wdata[48] sky130_fd_sc_hd__buf_4
X_3069_ net492 VSS VSS VDD VDD dst_wdata[49] sky130_fd_sc_hd__buf_4
X_3070_ net493 VSS VSS VDD VDD dst_wdata[50] sky130_fd_sc_hd__buf_4
X_3071_ net494 VSS VSS VDD VDD dst_wdata[51] sky130_fd_sc_hd__buf_4
X_3072_ net495 VSS VSS VDD VDD dst_wdata[52] sky130_fd_sc_hd__buf_4
X_3073_ net496 VSS VSS VDD VDD dst_wdata[53] sky130_fd_sc_hd__buf_4
X_3074_ net497 VSS VSS VDD VDD dst_wdata[54] sky130_fd_sc_hd__buf_4
X_3075_ net498 VSS VSS VDD VDD dst_wdata[55] sky130_fd_sc_hd__buf_4
X_3076_ net499 VSS VSS VDD VDD dst_wdata[56] sky130_fd_sc_hd__buf_4
X_3077_ net500 VSS VSS VDD VDD dst_wdata[57] sky130_fd_sc_hd__buf_4
X_3078_ net501 VSS VSS VDD VDD dst_wdata[58] sky130_fd_sc_hd__buf_4
X_3079_ net502 VSS VSS VDD VDD dst_wdata[59] sky130_fd_sc_hd__buf_4
X_3080_ net503 VSS VSS VDD VDD dst_wdata[60] sky130_fd_sc_hd__buf_4
X_3081_ net504 VSS VSS VDD VDD dst_wdata[61] sky130_fd_sc_hd__buf_4
X_3082_ net505 VSS VSS VDD VDD dst_wdata[62] sky130_fd_sc_hd__buf_4
X_3083_ net506 VSS VSS VDD VDD dst_wdata[63] sky130_fd_sc_hd__buf_4
X_3084_ net507 VSS VSS VDD VDD dst_wdata[64] sky130_fd_sc_hd__buf_4
X_3085_ net508 VSS VSS VDD VDD dst_wdata[65] sky130_fd_sc_hd__buf_4
X_3086_ net509 VSS VSS VDD VDD dst_wdata[66] sky130_fd_sc_hd__buf_4
X_3087_ net510 VSS VSS VDD VDD dst_wdata[67] sky130_fd_sc_hd__buf_4
X_3088_ net511 VSS VSS VDD VDD dst_wdata[68] sky130_fd_sc_hd__buf_4
X_3089_ net512 VSS VSS VDD VDD dst_wdata[69] sky130_fd_sc_hd__buf_4
X_3090_ net513 VSS VSS VDD VDD dst_wdata[70] sky130_fd_sc_hd__buf_4
X_3091_ net514 VSS VSS VDD VDD dst_wdata[71] sky130_fd_sc_hd__buf_4
X_3092_ net515 VSS VSS VDD VDD dst_wdata[72] sky130_fd_sc_hd__buf_4
X_3093_ net516 VSS VSS VDD VDD dst_wdata[73] sky130_fd_sc_hd__buf_4
X_3094_ net517 VSS VSS VDD VDD dst_wdata[74] sky130_fd_sc_hd__buf_4
X_3095_ net518 VSS VSS VDD VDD dst_wdata[75] sky130_fd_sc_hd__buf_4
X_3096_ net519 VSS VSS VDD VDD dst_wdata[76] sky130_fd_sc_hd__buf_4
X_3097_ net520 VSS VSS VDD VDD dst_wdata[77] sky130_fd_sc_hd__buf_4
X_3098_ net521 VSS VSS VDD VDD dst_wdata[78] sky130_fd_sc_hd__buf_4
X_3099_ net522 VSS VSS VDD VDD dst_wdata[79] sky130_fd_sc_hd__buf_4
X_3100_ net523 VSS VSS VDD VDD dst_wdata[80] sky130_fd_sc_hd__buf_4
X_3101_ net524 VSS VSS VDD VDD dst_wdata[81] sky130_fd_sc_hd__buf_4
X_3102_ net525 VSS VSS VDD VDD dst_wdata[82] sky130_fd_sc_hd__buf_4
X_3103_ net526 VSS VSS VDD VDD dst_wdata[83] sky130_fd_sc_hd__buf_4
X_3104_ net527 VSS VSS VDD VDD dst_wdata[84] sky130_fd_sc_hd__buf_4
X_3105_ net528 VSS VSS VDD VDD dst_wdata[85] sky130_fd_sc_hd__buf_4
X_3106_ net529 VSS VSS VDD VDD dst_wdata[86] sky130_fd_sc_hd__buf_4
X_3107_ net530 VSS VSS VDD VDD dst_wdata[87] sky130_fd_sc_hd__buf_4
X_3108_ net531 VSS VSS VDD VDD dst_wdata[88] sky130_fd_sc_hd__buf_4
X_3109_ net532 VSS VSS VDD VDD dst_wdata[89] sky130_fd_sc_hd__buf_4
X_3110_ net533 VSS VSS VDD VDD dst_wdata[90] sky130_fd_sc_hd__buf_4
X_3111_ net534 VSS VSS VDD VDD dst_wdata[91] sky130_fd_sc_hd__buf_4
X_3112_ net535 VSS VSS VDD VDD dst_wdata[92] sky130_fd_sc_hd__buf_4
X_3113_ net536 VSS VSS VDD VDD dst_wdata[93] sky130_fd_sc_hd__buf_4
X_3114_ net537 VSS VSS VDD VDD dst_wdata[94] sky130_fd_sc_hd__buf_4
X_3115_ net538 VSS VSS VDD VDD dst_wdata[95] sky130_fd_sc_hd__buf_4
X_3116_ net539 VSS VSS VDD VDD dst_wdata[96] sky130_fd_sc_hd__buf_4
X_3117_ net540 VSS VSS VDD VDD dst_wdata[97] sky130_fd_sc_hd__buf_4
X_3118_ net541 VSS VSS VDD VDD dst_wdata[98] sky130_fd_sc_hd__buf_4
X_3119_ net542 VSS VSS VDD VDD dst_wdata[99] sky130_fd_sc_hd__buf_4
X_3120_ net543 VSS VSS VDD VDD dst_wdata[100] sky130_fd_sc_hd__buf_4
X_3121_ net544 VSS VSS VDD VDD dst_wdata[101] sky130_fd_sc_hd__buf_4
X_3122_ net545 VSS VSS VDD VDD dst_wdata[102] sky130_fd_sc_hd__buf_4
X_3123_ net546 VSS VSS VDD VDD dst_wdata[103] sky130_fd_sc_hd__buf_4
X_3124_ net547 VSS VSS VDD VDD dst_wdata[104] sky130_fd_sc_hd__buf_4
X_3125_ net548 VSS VSS VDD VDD dst_wdata[105] sky130_fd_sc_hd__buf_4
X_3126_ net549 VSS VSS VDD VDD dst_wdata[106] sky130_fd_sc_hd__buf_4
X_3127_ net550 VSS VSS VDD VDD dst_wdata[107] sky130_fd_sc_hd__buf_4
X_3128_ net551 VSS VSS VDD VDD dst_wdata[108] sky130_fd_sc_hd__buf_4
X_3129_ net552 VSS VSS VDD VDD dst_wdata[109] sky130_fd_sc_hd__buf_4
X_3130_ net553 VSS VSS VDD VDD dst_wdata[110] sky130_fd_sc_hd__buf_4
X_3131_ net554 VSS VSS VDD VDD dst_wdata[111] sky130_fd_sc_hd__buf_4
X_3132_ net555 VSS VSS VDD VDD dst_wdata[112] sky130_fd_sc_hd__buf_4
X_3133_ net556 VSS VSS VDD VDD dst_wdata[113] sky130_fd_sc_hd__buf_4
X_3134_ net557 VSS VSS VDD VDD dst_wdata[114] sky130_fd_sc_hd__buf_4
X_3135_ net558 VSS VSS VDD VDD dst_wdata[115] sky130_fd_sc_hd__buf_4
X_3136_ net559 VSS VSS VDD VDD dst_wdata[116] sky130_fd_sc_hd__buf_4
X_3137_ net560 VSS VSS VDD VDD dst_wdata[117] sky130_fd_sc_hd__buf_4
X_3138_ net561 VSS VSS VDD VDD dst_wdata[118] sky130_fd_sc_hd__buf_4
X_3139_ net562 VSS VSS VDD VDD dst_wdata[119] sky130_fd_sc_hd__buf_4
X_3140_ net563 VSS VSS VDD VDD dst_wdata[120] sky130_fd_sc_hd__buf_4
X_3141_ net564 VSS VSS VDD VDD dst_wdata[121] sky130_fd_sc_hd__buf_4
X_3142_ net565 VSS VSS VDD VDD dst_wdata[122] sky130_fd_sc_hd__buf_4
X_3143_ net566 VSS VSS VDD VDD dst_wdata[123] sky130_fd_sc_hd__buf_4
X_3144_ net567 VSS VSS VDD VDD dst_wdata[124] sky130_fd_sc_hd__buf_4
X_3145_ net568 VSS VSS VDD VDD dst_wdata[125] sky130_fd_sc_hd__buf_4
X_3146_ net569 VSS VSS VDD VDD dst_wdata[126] sky130_fd_sc_hd__buf_4
X_3147_ net570 VSS VSS VDD VDD dst_wdata[127] sky130_fd_sc_hd__buf_4
X_3148_ net571 VSS VSS VDD VDD dst_wstrb[0] sky130_fd_sc_hd__buf_4
X_3149_ net572 VSS VSS VDD VDD dst_wstrb[1] sky130_fd_sc_hd__buf_4
X_3150_ net573 VSS VSS VDD VDD dst_wstrb[2] sky130_fd_sc_hd__buf_4
X_3151_ net574 VSS VSS VDD VDD dst_wstrb[3] sky130_fd_sc_hd__buf_4
X_3152_ net575 VSS VSS VDD VDD dst_wstrb[4] sky130_fd_sc_hd__buf_4
X_3153_ net576 VSS VSS VDD VDD dst_wstrb[5] sky130_fd_sc_hd__buf_4
X_3154_ net577 VSS VSS VDD VDD dst_wstrb[6] sky130_fd_sc_hd__buf_4
X_3155_ net578 VSS VSS VDD VDD dst_wstrb[7] sky130_fd_sc_hd__buf_4
X_3156_ net579 VSS VSS VDD VDD dst_wstrb[8] sky130_fd_sc_hd__buf_4
X_3157_ net580 VSS VSS VDD VDD dst_wstrb[9] sky130_fd_sc_hd__buf_4
X_3158_ net581 VSS VSS VDD VDD dst_wstrb[10] sky130_fd_sc_hd__buf_4
X_3159_ net582 VSS VSS VDD VDD dst_wstrb[11] sky130_fd_sc_hd__buf_4
X_3160_ net583 VSS VSS VDD VDD dst_wstrb[12] sky130_fd_sc_hd__buf_4
X_3161_ net584 VSS VSS VDD VDD dst_wstrb[13] sky130_fd_sc_hd__buf_4
X_3162_ net585 VSS VSS VDD VDD dst_wstrb[14] sky130_fd_sc_hd__buf_4
X_3163_ net586 VSS VSS VDD VDD dst_wstrb[15] sky130_fd_sc_hd__buf_4
X_3164_ net587 VSS VSS VDD VDD src_addr[0] sky130_fd_sc_hd__buf_4
X_3165_ net588 VSS VSS VDD VDD src_addr[1] sky130_fd_sc_hd__buf_4
X_3166_ net589 VSS VSS VDD VDD src_addr[2] sky130_fd_sc_hd__buf_4
X_3167_ net590 VSS VSS VDD VDD src_addr[3] sky130_fd_sc_hd__buf_4
X_3168_ net591 VSS VSS VDD VDD src_addr[4] sky130_fd_sc_hd__buf_4
X_3169_ net592 VSS VSS VDD VDD src_addr[5] sky130_fd_sc_hd__buf_4
X_3170_ net593 VSS VSS VDD VDD src_addr[6] sky130_fd_sc_hd__buf_4
X_3171_ net594 VSS VSS VDD VDD src_addr[7] sky130_fd_sc_hd__buf_4
X_3172_ net595 VSS VSS VDD VDD src_addr[8] sky130_fd_sc_hd__buf_4
X_3173_ net596 VSS VSS VDD VDD src_addr[9] sky130_fd_sc_hd__buf_4
X_3174_ net597 VSS VSS VDD VDD src_addr[10] sky130_fd_sc_hd__buf_4
X_3175_ net598 VSS VSS VDD VDD src_addr[11] sky130_fd_sc_hd__buf_4
X_3176_ net599 VSS VSS VDD VDD src_addr[12] sky130_fd_sc_hd__buf_4
X_3177_ net600 VSS VSS VDD VDD src_addr[13] sky130_fd_sc_hd__buf_4
X_3178_ net601 VSS VSS VDD VDD src_addr[14] sky130_fd_sc_hd__buf_4
X_3179_ net602 VSS VSS VDD VDD src_addr[15] sky130_fd_sc_hd__buf_4
X_3180_ net603 VSS VSS VDD VDD src_addr[16] sky130_fd_sc_hd__buf_4
X_3181_ net604 VSS VSS VDD VDD src_addr[17] sky130_fd_sc_hd__buf_4
X_3182_ net605 VSS VSS VDD VDD src_addr[18] sky130_fd_sc_hd__buf_4
X_3183_ net606 VSS VSS VDD VDD src_addr[19] sky130_fd_sc_hd__buf_4
X_3184_ net607 VSS VSS VDD VDD src_addr[20] sky130_fd_sc_hd__buf_4
X_3185_ net608 VSS VSS VDD VDD src_addr[21] sky130_fd_sc_hd__buf_4
X_3186_ net609 VSS VSS VDD VDD src_addr[22] sky130_fd_sc_hd__buf_4
X_3187_ net610 VSS VSS VDD VDD src_addr[23] sky130_fd_sc_hd__buf_4
X_3188_ net611 VSS VSS VDD VDD src_addr[24] sky130_fd_sc_hd__buf_4
X_3189_ net612 VSS VSS VDD VDD src_addr[25] sky130_fd_sc_hd__buf_4
X_3190_ net613 VSS VSS VDD VDD src_addr[26] sky130_fd_sc_hd__buf_4
X_3191_ net614 VSS VSS VDD VDD src_addr[27] sky130_fd_sc_hd__buf_4
X_3192_ net615 VSS VSS VDD VDD src_addr[28] sky130_fd_sc_hd__buf_4
X_3193_ net616 VSS VSS VDD VDD src_addr[29] sky130_fd_sc_hd__buf_4
X_3194_ net617 VSS VSS VDD VDD src_addr[30] sky130_fd_sc_hd__buf_4
X_3195_ net618 VSS VSS VDD VDD src_addr[31] sky130_fd_sc_hd__buf_4
X_3196_ net619 VSS VSS VDD VDD src_addr[32] sky130_fd_sc_hd__buf_4
X_3197_ net620 VSS VSS VDD VDD src_addr[33] sky130_fd_sc_hd__buf_4
X_3198_ net621 VSS VSS VDD VDD src_addr[34] sky130_fd_sc_hd__buf_4
X_3199_ net622 VSS VSS VDD VDD src_addr[35] sky130_fd_sc_hd__buf_4
X_3200_ net623 VSS VSS VDD VDD src_addr[36] sky130_fd_sc_hd__buf_4
X_3201_ net624 VSS VSS VDD VDD src_addr[37] sky130_fd_sc_hd__buf_4
X_3202_ net625 VSS VSS VDD VDD src_addr[38] sky130_fd_sc_hd__buf_4
X_3203_ net626 VSS VSS VDD VDD src_addr[39] sky130_fd_sc_hd__buf_4
X_3204_ net627 VSS VSS VDD VDD src_addr[40] sky130_fd_sc_hd__buf_4
X_3205_ net628 VSS VSS VDD VDD src_addr[41] sky130_fd_sc_hd__buf_4
X_3206_ net629 VSS VSS VDD VDD src_addr[42] sky130_fd_sc_hd__buf_4
X_3207_ net630 VSS VSS VDD VDD src_addr[43] sky130_fd_sc_hd__buf_4
X_3208_ net631 VSS VSS VDD VDD src_addr[44] sky130_fd_sc_hd__buf_4
X_3209_ net632 VSS VSS VDD VDD src_addr[45] sky130_fd_sc_hd__buf_4
X_3210_ net633 VSS VSS VDD VDD src_addr[46] sky130_fd_sc_hd__buf_4
X_3211_ net634 VSS VSS VDD VDD src_addr[47] sky130_fd_sc_hd__buf_4
X_3212_ net635 VSS VSS VDD VDD src_addr[48] sky130_fd_sc_hd__buf_4
X_3213_ net636 VSS VSS VDD VDD src_addr[49] sky130_fd_sc_hd__buf_4
X_3214_ net637 VSS VSS VDD VDD src_addr[50] sky130_fd_sc_hd__buf_4
X_3215_ net638 VSS VSS VDD VDD src_addr[51] sky130_fd_sc_hd__buf_4
X_3216_ net639 VSS VSS VDD VDD src_addr[52] sky130_fd_sc_hd__buf_4
X_3217_ net640 VSS VSS VDD VDD src_addr[53] sky130_fd_sc_hd__buf_4
X_3218_ net641 VSS VSS VDD VDD src_addr[54] sky130_fd_sc_hd__buf_4
X_3219_ net642 VSS VSS VDD VDD src_addr[55] sky130_fd_sc_hd__buf_4
X_3220_ net643 VSS VSS VDD VDD src_addr[56] sky130_fd_sc_hd__buf_4
X_3221_ net644 VSS VSS VDD VDD src_addr[57] sky130_fd_sc_hd__buf_4
X_3222_ net645 VSS VSS VDD VDD src_addr[58] sky130_fd_sc_hd__buf_4
X_3223_ net646 VSS VSS VDD VDD src_addr[59] sky130_fd_sc_hd__buf_4
X_3224_ net647 VSS VSS VDD VDD src_addr[60] sky130_fd_sc_hd__buf_4
X_3225_ net648 VSS VSS VDD VDD src_addr[61] sky130_fd_sc_hd__buf_4
X_3226_ net649 VSS VSS VDD VDD src_addr[62] sky130_fd_sc_hd__buf_4
X_3227_ net650 VSS VSS VDD VDD src_addr[63] sky130_fd_sc_hd__buf_4
X_3228_ net651 VSS VSS VDD VDD src_addr[64] sky130_fd_sc_hd__buf_4
X_3229_ net652 VSS VSS VDD VDD src_addr[65] sky130_fd_sc_hd__buf_4
X_3230_ net653 VSS VSS VDD VDD src_addr[66] sky130_fd_sc_hd__buf_4
X_3231_ net654 VSS VSS VDD VDD src_addr[67] sky130_fd_sc_hd__buf_4
X_3232_ net655 VSS VSS VDD VDD src_addr[68] sky130_fd_sc_hd__buf_4
X_3233_ net656 VSS VSS VDD VDD src_addr[69] sky130_fd_sc_hd__buf_4
X_3234_ net657 VSS VSS VDD VDD src_addr[70] sky130_fd_sc_hd__buf_4
X_3235_ net658 VSS VSS VDD VDD src_addr[71] sky130_fd_sc_hd__buf_4
X_3236_ net659 VSS VSS VDD VDD src_addr[72] sky130_fd_sc_hd__buf_4
X_3237_ net660 VSS VSS VDD VDD src_addr[73] sky130_fd_sc_hd__buf_4
X_3238_ net661 VSS VSS VDD VDD src_addr[74] sky130_fd_sc_hd__buf_4
X_3239_ net662 VSS VSS VDD VDD src_addr[75] sky130_fd_sc_hd__buf_4
X_3240_ net663 VSS VSS VDD VDD src_addr[76] sky130_fd_sc_hd__buf_4
X_3241_ net664 VSS VSS VDD VDD src_addr[77] sky130_fd_sc_hd__buf_4
X_3242_ net665 VSS VSS VDD VDD src_addr[78] sky130_fd_sc_hd__buf_4
X_3243_ net666 VSS VSS VDD VDD src_addr[79] sky130_fd_sc_hd__buf_4
X_3244_ net667 VSS VSS VDD VDD src_addr[80] sky130_fd_sc_hd__buf_4
X_3245_ net668 VSS VSS VDD VDD src_addr[81] sky130_fd_sc_hd__buf_4
X_3246_ net669 VSS VSS VDD VDD src_addr[82] sky130_fd_sc_hd__buf_4
X_3247_ net670 VSS VSS VDD VDD src_addr[83] sky130_fd_sc_hd__buf_4
X_3248_ net671 VSS VSS VDD VDD src_addr[84] sky130_fd_sc_hd__buf_4
X_3249_ net672 VSS VSS VDD VDD src_addr[85] sky130_fd_sc_hd__buf_4
X_3250_ net673 VSS VSS VDD VDD src_addr[86] sky130_fd_sc_hd__buf_4
X_3251_ net674 VSS VSS VDD VDD src_addr[87] sky130_fd_sc_hd__buf_4
X_3252_ net675 VSS VSS VDD VDD src_addr[88] sky130_fd_sc_hd__buf_4
X_3253_ net676 VSS VSS VDD VDD src_addr[89] sky130_fd_sc_hd__buf_4
X_3254_ net677 VSS VSS VDD VDD src_addr[90] sky130_fd_sc_hd__buf_4
X_3255_ net678 VSS VSS VDD VDD src_addr[91] sky130_fd_sc_hd__buf_4
X_3256_ net679 VSS VSS VDD VDD src_addr[92] sky130_fd_sc_hd__buf_4
X_3257_ net680 VSS VSS VDD VDD src_addr[93] sky130_fd_sc_hd__buf_4
X_3258_ net681 VSS VSS VDD VDD src_addr[94] sky130_fd_sc_hd__buf_4
X_3259_ net682 VSS VSS VDD VDD src_addr[95] sky130_fd_sc_hd__buf_4
X_3260_ net683 VSS VSS VDD VDD src_addr[96] sky130_fd_sc_hd__buf_4
X_3261_ net684 VSS VSS VDD VDD src_addr[97] sky130_fd_sc_hd__buf_4
X_3262_ net685 VSS VSS VDD VDD src_addr[98] sky130_fd_sc_hd__buf_4
X_3263_ net686 VSS VSS VDD VDD src_addr[99] sky130_fd_sc_hd__buf_4
X_3264_ net687 VSS VSS VDD VDD src_addr[100] sky130_fd_sc_hd__buf_4
X_3265_ net688 VSS VSS VDD VDD src_addr[101] sky130_fd_sc_hd__buf_4
X_3266_ net689 VSS VSS VDD VDD src_addr[102] sky130_fd_sc_hd__buf_4
X_3267_ net690 VSS VSS VDD VDD src_addr[103] sky130_fd_sc_hd__buf_4
X_3268_ net691 VSS VSS VDD VDD src_addr[104] sky130_fd_sc_hd__buf_4
X_3269_ net692 VSS VSS VDD VDD src_addr[105] sky130_fd_sc_hd__buf_4
X_3270_ net693 VSS VSS VDD VDD src_addr[106] sky130_fd_sc_hd__buf_4
X_3271_ net694 VSS VSS VDD VDD src_addr[107] sky130_fd_sc_hd__buf_4
X_3272_ net695 VSS VSS VDD VDD src_addr[108] sky130_fd_sc_hd__buf_4
X_3273_ net696 VSS VSS VDD VDD src_addr[109] sky130_fd_sc_hd__buf_4
X_3274_ net697 VSS VSS VDD VDD src_addr[110] sky130_fd_sc_hd__buf_4
X_3275_ net698 VSS VSS VDD VDD src_addr[111] sky130_fd_sc_hd__buf_4
X_3276_ net699 VSS VSS VDD VDD src_addr[112] sky130_fd_sc_hd__buf_4
X_3277_ net700 VSS VSS VDD VDD src_addr[113] sky130_fd_sc_hd__buf_4
X_3278_ net701 VSS VSS VDD VDD src_addr[114] sky130_fd_sc_hd__buf_4
X_3279_ net702 VSS VSS VDD VDD src_addr[115] sky130_fd_sc_hd__buf_4
X_3280_ net703 VSS VSS VDD VDD src_addr[116] sky130_fd_sc_hd__buf_4
X_3281_ net704 VSS VSS VDD VDD src_addr[117] sky130_fd_sc_hd__buf_4
X_3282_ net705 VSS VSS VDD VDD src_addr[118] sky130_fd_sc_hd__buf_4
X_3283_ net706 VSS VSS VDD VDD src_addr[119] sky130_fd_sc_hd__buf_4
X_3284_ net707 VSS VSS VDD VDD src_addr[120] sky130_fd_sc_hd__buf_4
X_3285_ net708 VSS VSS VDD VDD src_addr[121] sky130_fd_sc_hd__buf_4
X_3286_ net709 VSS VSS VDD VDD src_addr[122] sky130_fd_sc_hd__buf_4
X_3287_ net710 VSS VSS VDD VDD src_addr[123] sky130_fd_sc_hd__buf_4
X_3288_ net711 VSS VSS VDD VDD src_addr[124] sky130_fd_sc_hd__buf_4
X_3289_ net712 VSS VSS VDD VDD src_addr[125] sky130_fd_sc_hd__buf_4
X_3290_ net713 VSS VSS VDD VDD src_addr[126] sky130_fd_sc_hd__buf_4
X_3291_ net714 VSS VSS VDD VDD src_addr[127] sky130_fd_sc_hd__buf_4
Xactive_channel_count\[0\]$_DFF_PN0_ clknet_4_10_0_clk _0000_
+ net1 VSS VSS VDD VDD active_channel_count\[0\] sky130_fd_sc_hd__dfrtp_1
Xactive_channel_count\[1\]$_DFF_PN0_ clknet_4_10_0_clk _0001_
+ net1 VSS VSS VDD VDD active_channel_count\[1\] sky130_fd_sc_hd__dfrtp_1
Xactive_channel_count\[2\]$_DFF_PN0_ clknet_4_10_0_clk _0002_
+ net1 VSS VSS VDD VDD active_channel_count\[2\] sky130_fd_sc_hd__dfrtp_1
Xactive_channel_count\[3\]$_DFF_PN0_ clknet_4_10_0_clk _0003_
+ net1 VSS VSS VDD VDD active_channel_count\[3\] sky130_fd_sc_hd__dfrtp_1
Xchannel_busy\[0\]$_DFF_PN0_ clknet_4_14_0_clk _0004_ net1
+ VSS VSS VDD VDD net146 sky130_fd_sc_hd__dfrtp_1
Xchannel_busy\[1\]$_DFF_PN0_ clknet_4_12_0_clk _0005_ net1
+ VSS VSS VDD VDD net147 sky130_fd_sc_hd__dfrtp_1
Xchannel_busy\[2\]$_DFF_PN0_ clknet_4_8_0_clk _0006_ net1
+ VSS VSS VDD VDD net148 sky130_fd_sc_hd__dfrtp_1
Xchannel_busy\[3\]$_DFF_PN0_ clknet_4_4_0_clk _0007_ net1
+ VSS VSS VDD VDD net149 sky130_fd_sc_hd__dfrtp_2
Xchannel_done\[0\]$_DFF_PN0_ clknet_4_14_0_clk _1441_ net1
+ VSS VSS VDD VDD net150 sky130_fd_sc_hd__dfrtp_1
Xchannel_done\[1\]$_DFF_PN0_ clknet_4_15_0_clk _1439_ net1
+ VSS VSS VDD VDD net151 sky130_fd_sc_hd__dfrtp_1
Xchannel_done\[2\]$_DFF_PN0_ clknet_4_8_0_clk _1436_ net1
+ VSS VSS VDD VDD net152 sky130_fd_sc_hd__dfrtp_1
Xchannel_done\[3\]$_DFF_PN0_ clknet_4_6_0_clk _1438_ net1
+ VSS VSS VDD VDD net153 sky130_fd_sc_hd__dfrtp_1
Xchannel_error\[0\]$_DFF_PN0_ clknet_4_14_0_clk _0008_ net1
+ VSS VSS VDD VDD net154 sky130_fd_sc_hd__dfrtp_1
Xchannel_error\[1\]$_DFF_PN0_ clknet_4_9_0_clk _0009_ net1
+ VSS VSS VDD VDD net155 sky130_fd_sc_hd__dfrtp_1
Xchannel_error\[2\]$_DFF_PN0_ clknet_4_11_0_clk _0010_ net1
+ VSS VSS VDD VDD net156 sky130_fd_sc_hd__dfrtp_1
Xchannel_error\[3\]$_DFF_PN0_ clknet_4_6_0_clk _0011_ net1
+ VSS VSS VDD VDD net157 sky130_fd_sc_hd__dfrtp_4
Xchannel_state\[0\]\[0\]$_DFF_PN0_ clknet_4_14_0_clk _1030_
+ net1 VSS VSS VDD VDD channel_state\[0\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[0\]\[1\]$_DFF_PN0_ clknet_4_15_0_clk _1031_
+ net1 VSS VSS VDD VDD channel_state\[0\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[0\]\[2\]$_DFF_PN0_ clknet_4_14_0_clk _1032_
+ net1 VSS VSS VDD VDD channel_state\[0\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[1\]\[0\]$_DFF_PN0_ clknet_4_15_0_clk _1027_
+ net1 VSS VSS VDD VDD channel_state\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[1\]\[1\]$_DFF_PN0_ clknet_4_14_0_clk _1028_
+ net1 VSS VSS VDD VDD channel_state\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[1\]\[2\]$_DFF_PN0_ clknet_4_9_0_clk _1029_
+ net1 VSS VSS VDD VDD channel_state\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[2\]\[0\]$_DFF_PN0_ clknet_4_9_0_clk _1024_
+ net1 VSS VSS VDD VDD channel_state\[2\]\[0\] sky130_fd_sc_hd__dfrtp_2
Xchannel_state\[2\]\[1\]$_DFF_PN0_ clknet_4_11_0_clk _1025_
+ net1 VSS VSS VDD VDD channel_state\[2\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[2\]\[2\]$_DFF_PN0_ clknet_4_8_0_clk _1026_
+ net1 VSS VSS VDD VDD channel_state\[2\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[3\]\[0\]$_DFF_PN0_ clknet_4_6_0_clk _1021_
+ net1 VSS VSS VDD VDD channel_state\[3\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xchannel_state\[3\]\[1\]$_DFF_PN0_ clknet_4_4_0_clk _1022_
+ net1 VSS VSS VDD VDD channel_state\[3\]\[1\] sky130_fd_sc_hd__dfrtp_2
Xchannel_state\[3\]\[2\]$_DFF_PN0_ clknet_4_6_0_clk _1023_
+ net1 VSS VSS VDD VDD channel_state\[3\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xdebug_active_channels\[0\]$_DFF_PN0_ clknet_4_10_0_clk active_channel_count\[0\]
+ net1 VSS VSS VDD VDD net158 sky130_fd_sc_hd__dfrtp_1
Xdebug_active_channels\[1\]$_DFF_PN0_ clknet_4_10_0_clk active_channel_count\[1\]
+ net1 VSS VSS VDD VDD net159 sky130_fd_sc_hd__dfrtp_1
Xdebug_active_channels\[2\]$_DFF_PN0_ clknet_4_10_0_clk active_channel_count\[2\]
+ net1 VSS VSS VDD VDD net160 sky130_fd_sc_hd__dfrtp_1
Xdebug_active_channels\[3\]$_DFF_PN0_ clknet_4_10_0_clk active_channel_count\[3\]
+ net1 VSS VSS VDD VDD net161 sky130_fd_sc_hd__dfrtp_1
Xdebug_has_active_channels$_DFF_PN0_ clknet_4_10_0_clk _0012_
+ net1 VSS VSS VDD VDD net162 sky130_fd_sc_hd__dfrtp_1
Xdst_write\[0\]$_DFFE_PN0P_ clknet_4_14_0_clk _0141_ net1
+ VSS VSS VDD VDD net163 sky130_fd_sc_hd__dfrtp_1
Xdst_write\[1\]$_DFFE_PN0P_ clknet_4_15_0_clk _0142_ net1
+ VSS VSS VDD VDD net164 sky130_fd_sc_hd__dfrtp_1
Xdst_write\[2\]$_DFFE_PN0P_ clknet_4_11_0_clk _0143_ net1
+ VSS VSS VDD VDD net165 sky130_fd_sc_hd__dfrtp_1
Xdst_write\[3\]$_DFFE_PN0P_ clknet_4_3_0_clk _0144_ net1 VSS
+ VSS VDD VDD net166 sky130_fd_sc_hd__dfrtp_4
Xsrc_read\[0\]$_DFF_PN0_ clknet_4_3_0_clk _1019_ net1 VSS
+ VSS VDD VDD net167 sky130_fd_sc_hd__dfrtp_2
Xsrc_read\[1\]$_DFF_PN0_ clknet_4_3_0_clk _1018_ net1 VSS
+ VSS VDD VDD net168 sky130_fd_sc_hd__dfrtp_4
Xsrc_read\[2\]$_DFF_PN0_ clknet_4_3_0_clk _1017_ net1 VSS
+ VSS VDD VDD net169 sky130_fd_sc_hd__dfrtp_4
Xsrc_read\[3\]$_DFF_PN0_ clknet_4_4_0_clk _1020_ net1 VSS
+ VSS VDD VDD net170 sky130_fd_sc_hd__dfrtp_4
Xsrc_rready\[0\]$_DFF_PN0_ clknet_4_3_0_clk _1442_ net1 VSS
+ VSS VDD VDD net171 sky130_fd_sc_hd__dfrtp_2
Xsrc_rready\[1\]$_DFF_PN0_ clknet_4_3_0_clk _1440_ net1 VSS
+ VSS VDD VDD net172 sky130_fd_sc_hd__dfrtp_4
Xsrc_rready\[2\]$_DFF_PN0_ clknet_4_3_0_clk _1437_ net1 VSS
+ VSS VDD VDD net173 sky130_fd_sc_hd__dfrtp_4
Xsrc_rready\[3\]$_DFFE_PN0P_ clknet_4_6_0_clk _0145_ net1
+ VSS VSS VDD VDD net174 sky130_fd_sc_hd__dfrtp_4
Xtransfer_count\[0\]\[0\]$_DFF_PN0_ clknet_4_10_0_clk _0013_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[10\]$_DFF_PN0_ clknet_4_10_0_clk _0014_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[10\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[11\]$_DFF_PN0_ clknet_4_11_0_clk _0015_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[11\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[12\]$_DFF_PN0_ clknet_4_14_0_clk _0016_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[12\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[13\]$_DFF_PN0_ clknet_4_14_0_clk _0017_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[13\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[14\]$_DFF_PN0_ clknet_4_14_0_clk _0018_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[14\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[15\]$_DFF_PN0_ clknet_4_14_0_clk _0019_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[15\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[16\]$_DFF_PN0_ clknet_4_14_0_clk _0020_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[16\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[17\]$_DFF_PN0_ clknet_4_14_0_clk _0021_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[17\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[18\]$_DFF_PN0_ clknet_4_10_0_clk _0022_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[18\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[19\]$_DFF_PN0_ clknet_4_10_0_clk _0023_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[19\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[1\]$_DFF_PN0_ clknet_4_11_0_clk _0024_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[20\]$_DFF_PN0_ clknet_4_14_0_clk _0025_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[20\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[21\]$_DFF_PN0_ clknet_4_14_0_clk _0026_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[21\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[22\]$_DFF_PN0_ clknet_4_14_0_clk _0027_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[22\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[23\]$_DFF_PN0_ clknet_4_15_0_clk _0028_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[23\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[24\]$_DFF_PN0_ clknet_4_15_0_clk _0029_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[24\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[25\]$_DFF_PN0_ clknet_4_15_0_clk _0030_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[25\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[26\]$_DFF_PN0_ clknet_4_15_0_clk _0031_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[26\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[27\]$_DFF_PN0_ clknet_4_15_0_clk _0032_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[27\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[28\]$_DFF_PN0_ clknet_4_15_0_clk _0033_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[28\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[29\]$_DFF_PN0_ clknet_4_14_0_clk _0034_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[29\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[2\]$_DFF_PN0_ clknet_4_11_0_clk _0035_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xtransfer_count\[0\]\[30\]$_DFF_PN0_ clknet_4_14_0_clk _0036_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[30\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[31\]$_DFF_PN0_ clknet_4_14_0_clk _0037_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[31\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[3\]$_DFF_PN0_ clknet_4_14_0_clk _0038_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[3\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[4\]$_DFF_PN0_ clknet_4_11_0_clk _0039_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[5\]$_DFF_PN0_ clknet_4_11_0_clk _0040_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[5\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[6\]$_DFF_PN0_ clknet_4_11_0_clk _0041_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[6\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[0\]\[7\]$_DFF_PN0_ clknet_4_11_0_clk _0042_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[7\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[8\]$_DFF_PN0_ clknet_4_14_0_clk _0043_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[8\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[0\]\[9\]$_DFF_PN0_ clknet_4_14_0_clk _0044_
+ net1 VSS VSS VDD VDD transfer_count\[0\]\[9\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[0\]$_DFF_PN0_ clknet_4_13_0_clk _0045_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[10\]$_DFF_PN0_ clknet_4_2_0_clk _0046_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[10\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[11\]$_DFF_PN0_ clknet_4_3_0_clk _0047_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[11\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[12\]$_DFF_PN0_ clknet_4_3_0_clk _0048_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[12\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[13\]$_DFF_PN0_ clknet_4_13_0_clk _0049_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[13\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[14\]$_DFF_PN0_ clknet_4_12_0_clk _0050_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[14\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[15\]$_DFF_PN0_ clknet_4_12_0_clk _0051_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[15\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[16\]$_DFF_PN0_ clknet_4_12_0_clk _0052_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[16\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[17\]$_DFF_PN0_ clknet_4_13_0_clk _0053_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[17\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[18\]$_DFF_PN0_ clknet_4_15_0_clk _0054_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[18\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[1\]\[19\]$_DFF_PN0_ clknet_4_13_0_clk _0055_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[19\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[1\]$_DFF_PN0_ clknet_4_15_0_clk _0056_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[20\]$_DFF_PN0_ clknet_4_15_0_clk _0057_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[20\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[21\]$_DFF_PN0_ clknet_4_13_0_clk _0058_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[21\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[22\]$_DFF_PN0_ clknet_4_13_0_clk _0059_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[22\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[23\]$_DFF_PN0_ clknet_4_13_0_clk _0060_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[23\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[1\]\[24\]$_DFF_PN0_ clknet_4_13_0_clk _0061_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[24\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[25\]$_DFF_PN0_ clknet_4_13_0_clk _0062_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[25\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[26\]$_DFF_PN0_ clknet_4_13_0_clk _0063_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[26\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[27\]$_DFF_PN0_ clknet_4_13_0_clk _0064_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[27\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[28\]$_DFF_PN0_ clknet_4_13_0_clk _0065_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[28\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[29\]$_DFF_PN0_ clknet_4_13_0_clk _0066_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[29\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[2\]$_DFF_PN0_ clknet_4_12_0_clk _0067_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[2\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[1\]\[30\]$_DFF_PN0_ clknet_4_13_0_clk _0068_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[30\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[31\]$_DFF_PN0_ clknet_4_12_0_clk _0069_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[31\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[3\]$_DFF_PN0_ clknet_4_12_0_clk _0070_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[3\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[1\]\[4\]$_DFF_PN0_ clknet_4_12_0_clk _0071_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[5\]$_DFF_PN0_ clknet_4_12_0_clk _0072_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[5\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[6\]$_DFF_PN0_ clknet_4_12_0_clk _0073_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[6\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[7\]$_DFF_PN0_ clknet_4_12_0_clk _0074_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[7\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[1\]\[8\]$_DFF_PN0_ clknet_4_12_0_clk _0075_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[1\]\[9\]$_DFF_PN0_ clknet_4_2_0_clk _0076_
+ net1 VSS VSS VDD VDD transfer_count\[1\]\[9\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[0\]$_DFF_PN0_ clknet_4_9_0_clk _0077_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[0\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[10\]$_DFF_PN0_ clknet_4_2_0_clk _0078_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[10\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[11\]$_DFF_PN0_ clknet_4_2_0_clk _0079_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[11\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[2\]\[12\]$_DFF_PN0_ clknet_4_1_0_clk _0080_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[12\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[13\]$_DFF_PN0_ clknet_4_2_0_clk _0081_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[13\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[14\]$_DFF_PN0_ clknet_4_1_0_clk _0082_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[14\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[15\]$_DFF_PN0_ clknet_4_0_0_clk _0083_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[15\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[16\]$_DFF_PN0_ clknet_4_0_0_clk _0084_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[16\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[17\]$_DFF_PN0_ clknet_4_1_0_clk _0085_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[17\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[18\]$_DFF_PN0_ clknet_4_0_0_clk _0086_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[18\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[19\]$_DFF_PN0_ clknet_4_0_0_clk _0087_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[19\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[1\]$_DFF_PN0_ clknet_4_8_0_clk _0088_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[20\]$_DFF_PN0_ clknet_4_0_0_clk _0089_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[20\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[21\]$_DFF_PN0_ clknet_4_0_0_clk _0090_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[21\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[22\]$_DFF_PN0_ clknet_4_1_0_clk _0091_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[22\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[23\]$_DFF_PN0_ clknet_4_0_0_clk _0092_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[23\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[24\]$_DFF_PN0_ clknet_4_8_0_clk _0093_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[24\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[25\]$_DFF_PN0_ clknet_4_0_0_clk _0094_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[25\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[26\]$_DFF_PN0_ clknet_4_1_0_clk _0095_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[26\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[27\]$_DFF_PN0_ clknet_4_1_0_clk _0096_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[27\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[28\]$_DFF_PN0_ clknet_4_8_0_clk _0097_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[28\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[29\]$_DFF_PN0_ clknet_4_8_0_clk _0098_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[29\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[2\]$_DFF_PN0_ clknet_4_8_0_clk _0099_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[2\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[30\]$_DFF_PN0_ clknet_4_8_0_clk _0100_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[30\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[31\]$_DFF_PN0_ clknet_4_8_0_clk _0101_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[31\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[3\]$_DFF_PN0_ clknet_4_9_0_clk _0102_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[3\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[4\]$_DFF_PN0_ clknet_4_9_0_clk _0103_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[5\]$_DFF_PN0_ clknet_4_9_0_clk _0104_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[5\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[6\]$_DFF_PN0_ clknet_4_9_0_clk _0105_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[6\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[7\]$_DFF_PN0_ clknet_4_2_0_clk _0106_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[7\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[2\]\[8\]$_DFF_PN0_ clknet_4_9_0_clk _0107_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[2\]\[9\]$_DFF_PN0_ clknet_4_2_0_clk _0108_
+ net1 VSS VSS VDD VDD transfer_count\[2\]\[9\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[0\]$_DFF_PN0_ clknet_4_5_0_clk _0109_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[0\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[10\]$_DFF_PN0_ clknet_4_7_0_clk _0110_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[10\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[11\]$_DFF_PN0_ clknet_4_5_0_clk _0111_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[11\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[12\]$_DFF_PN0_ clknet_4_4_0_clk _0112_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[12\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[13\]$_DFF_PN0_ clknet_4_4_0_clk _0113_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[13\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[14\]$_DFF_PN0_ clknet_4_4_0_clk _0114_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[14\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[15\]$_DFF_PN0_ clknet_4_4_0_clk _0115_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[15\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[16\]$_DFF_PN0_ clknet_4_4_0_clk _0116_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[16\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[17\]$_DFF_PN0_ clknet_4_4_0_clk _0117_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[17\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[18\]$_DFF_PN0_ clknet_4_7_0_clk _0118_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[18\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[19\]$_DFF_PN0_ clknet_4_7_0_clk _0119_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[19\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[1\]$_DFF_PN0_ clknet_4_7_0_clk _0120_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[1\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[20\]$_DFF_PN0_ clknet_4_5_0_clk _0121_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[20\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[21\]$_DFF_PN0_ clknet_4_6_0_clk _0122_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[21\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[22\]$_DFF_PN0_ clknet_4_6_0_clk _0123_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[22\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[23\]$_DFF_PN0_ clknet_4_7_0_clk _0124_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[23\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[24\]$_DFF_PN0_ clknet_4_7_0_clk _0125_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[24\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[25\]$_DFF_PN0_ clknet_4_7_0_clk _0126_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[25\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[26\]$_DFF_PN0_ clknet_4_7_0_clk _0127_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[26\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[27\]$_DFF_PN0_ clknet_4_7_0_clk _0128_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[27\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[28\]$_DFF_PN0_ clknet_4_6_0_clk _0129_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[28\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[29\]$_DFF_PN0_ clknet_4_7_0_clk _0130_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[29\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[2\]$_DFF_PN0_ clknet_4_7_0_clk _0131_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[2\] sky130_fd_sc_hd__dfrtp_4
Xtransfer_count\[3\]\[30\]$_DFF_PN0_ clknet_4_6_0_clk _0132_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[30\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[31\]$_DFF_PN0_ clknet_4_6_0_clk _0133_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[31\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[3\]$_DFF_PN0_ clknet_4_5_0_clk _0134_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[3\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[4\]$_DFF_PN0_ clknet_4_5_0_clk _0135_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[4\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[5\]$_DFF_PN0_ clknet_4_5_0_clk _0136_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[5\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[6\]$_DFF_PN0_ clknet_4_7_0_clk _0137_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[6\] sky130_fd_sc_hd__dfrtp_1
Xtransfer_count\[3\]\[7\]$_DFF_PN0_ clknet_4_5_0_clk _0138_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[7\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[8\]$_DFF_PN0_ clknet_4_7_0_clk _0139_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[8\] sky130_fd_sc_hd__dfrtp_2
Xtransfer_count\[3\]\[9\]$_DFF_PN0_ clknet_4_7_0_clk _0140_
+ net1 VSS VSS VDD VDD transfer_count\[3\]\[9\] sky130_fd_sc_hd__dfrtp_1
Xhold1 rst_n VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_16
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_1028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_1086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_1115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_1144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_1231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_1260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_117_1724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_122_1797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_123_1811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_124_1826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_125_1840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_126_1855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_127_1869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_128_1884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_129_1898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_130_1913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_131_1927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_132_1942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_133_1956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_134_1971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_135_1985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_1999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_136_2000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_137_2014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_138_2029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_139_2043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_140_2058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_141_2072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_142_2087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_143_2101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_144_2116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_145_2130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_146_2145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_147_2159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_148_2174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_149_2203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 channel_enable[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput2 channel_enable[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput3 channel_enable[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 channel_enable[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_4
Xinput5 channel_length[0] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 channel_length[100] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 channel_length[101] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 channel_length[102] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 channel_length[103] VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 channel_length[104] VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xinput11 channel_length[105] VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_1
Xinput12 channel_length[106] VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_1
Xinput13 channel_length[107] VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_1
Xinput14 channel_length[108] VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_1
Xinput15 channel_length[109] VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_1
Xinput16 channel_length[10] VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_1
Xinput17 channel_length[110] VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_1
Xinput18 channel_length[111] VSS VSS VDD VDD net19 sky130_fd_sc_hd__clkbuf_1
Xinput19 channel_length[112] VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_1
Xinput20 channel_length[113] VSS VSS VDD VDD net21 sky130_fd_sc_hd__clkbuf_1
Xinput21 channel_length[114] VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_1
Xinput22 channel_length[115] VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_1
Xinput23 channel_length[116] VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_1
Xinput24 channel_length[117] VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_1
Xinput25 channel_length[118] VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_1
Xinput26 channel_length[119] VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_1
Xinput27 channel_length[11] VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_1
Xinput28 channel_length[120] VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_1
Xinput29 channel_length[121] VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_1
Xinput30 channel_length[122] VSS VSS VDD VDD net31 sky130_fd_sc_hd__clkbuf_1
Xinput31 channel_length[123] VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_1
Xinput32 channel_length[124] VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_1
Xinput33 channel_length[125] VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_1
Xinput34 channel_length[126] VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_1
Xinput35 channel_length[127] VSS VSS VDD VDD net36 sky130_fd_sc_hd__buf_4
Xinput36 channel_length[12] VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_1
Xinput37 channel_length[13] VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_1
Xinput38 channel_length[14] VSS VSS VDD VDD net39 sky130_fd_sc_hd__clkbuf_1
Xinput39 channel_length[15] VSS VSS VDD VDD net40 sky130_fd_sc_hd__clkbuf_1
Xinput40 channel_length[16] VSS VSS VDD VDD net41 sky130_fd_sc_hd__clkbuf_1
Xinput41 channel_length[17] VSS VSS VDD VDD net42 sky130_fd_sc_hd__clkbuf_1
Xinput42 channel_length[18] VSS VSS VDD VDD net43 sky130_fd_sc_hd__clkbuf_1
Xinput43 channel_length[19] VSS VSS VDD VDD net44 sky130_fd_sc_hd__clkbuf_1
Xinput44 channel_length[1] VSS VSS VDD VDD net45 sky130_fd_sc_hd__clkbuf_1
Xinput45 channel_length[20] VSS VSS VDD VDD net46 sky130_fd_sc_hd__clkbuf_1
Xinput46 channel_length[21] VSS VSS VDD VDD net47 sky130_fd_sc_hd__buf_2
Xinput47 channel_length[22] VSS VSS VDD VDD net48 sky130_fd_sc_hd__buf_2
Xinput48 channel_length[23] VSS VSS VDD VDD net49 sky130_fd_sc_hd__buf_2
Xinput49 channel_length[24] VSS VSS VDD VDD net50 sky130_fd_sc_hd__buf_2
Xinput50 channel_length[25] VSS VSS VDD VDD net51 sky130_fd_sc_hd__buf_2
Xinput51 channel_length[26] VSS VSS VDD VDD net52 sky130_fd_sc_hd__buf_2
Xinput52 channel_length[27] VSS VSS VDD VDD net53 sky130_fd_sc_hd__buf_2
Xinput53 channel_length[28] VSS VSS VDD VDD net54 sky130_fd_sc_hd__clkbuf_1
Xinput54 channel_length[29] VSS VSS VDD VDD net55 sky130_fd_sc_hd__clkbuf_1
Xinput55 channel_length[2] VSS VSS VDD VDD net56 sky130_fd_sc_hd__clkbuf_1
Xinput56 channel_length[30] VSS VSS VDD VDD net57 sky130_fd_sc_hd__buf_2
Xinput57 channel_length[31] VSS VSS VDD VDD net58 sky130_fd_sc_hd__buf_2
Xinput58 channel_length[32] VSS VSS VDD VDD net59 sky130_fd_sc_hd__clkbuf_1
Xinput59 channel_length[33] VSS VSS VDD VDD net60 sky130_fd_sc_hd__clkbuf_1
Xinput60 channel_length[34] VSS VSS VDD VDD net61 sky130_fd_sc_hd__clkbuf_1
Xinput61 channel_length[35] VSS VSS VDD VDD net62 sky130_fd_sc_hd__clkbuf_1
Xinput62 channel_length[36] VSS VSS VDD VDD net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput63 channel_length[37] VSS VSS VDD VDD net64 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput64 channel_length[38] VSS VSS VDD VDD net65 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput65 channel_length[39] VSS VSS VDD VDD net66 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput66 channel_length[3] VSS VSS VDD VDD net67 sky130_fd_sc_hd__clkbuf_1
Xinput67 channel_length[40] VSS VSS VDD VDD net68 sky130_fd_sc_hd__buf_6
Xinput68 channel_length[41] VSS VSS VDD VDD net69 sky130_fd_sc_hd__buf_4
Xinput69 channel_length[42] VSS VSS VDD VDD net70 sky130_fd_sc_hd__buf_6
Xinput70 channel_length[43] VSS VSS VDD VDD net71 sky130_fd_sc_hd__buf_6
Xinput71 channel_length[44] VSS VSS VDD VDD net72 sky130_fd_sc_hd__buf_6
Xinput72 channel_length[45] VSS VSS VDD VDD net73 sky130_fd_sc_hd__buf_6
Xinput73 channel_length[46] VSS VSS VDD VDD net74 sky130_fd_sc_hd__clkbuf_8
Xinput74 channel_length[47] VSS VSS VDD VDD net75 sky130_fd_sc_hd__clkbuf_2
Xinput75 channel_length[48] VSS VSS VDD VDD net76 sky130_fd_sc_hd__clkbuf_1
Xinput76 channel_length[49] VSS VSS VDD VDD net77 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput77 channel_length[4] VSS VSS VDD VDD net78 sky130_fd_sc_hd__clkbuf_1
Xinput78 channel_length[50] VSS VSS VDD VDD net79 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput79 channel_length[51] VSS VSS VDD VDD net80 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput80 channel_length[52] VSS VSS VDD VDD net81 sky130_fd_sc_hd__clkbuf_1
Xinput81 channel_length[53] VSS VSS VDD VDD net82 sky130_fd_sc_hd__clkbuf_1
Xinput82 channel_length[54] VSS VSS VDD VDD net83 sky130_fd_sc_hd__clkbuf_4
Xinput83 channel_length[55] VSS VSS VDD VDD net84 sky130_fd_sc_hd__clkbuf_1
Xinput84 channel_length[56] VSS VSS VDD VDD net85 sky130_fd_sc_hd__clkbuf_4
Xinput85 channel_length[57] VSS VSS VDD VDD net86 sky130_fd_sc_hd__clkbuf_4
Xinput86 channel_length[58] VSS VSS VDD VDD net87 sky130_fd_sc_hd__clkbuf_4
Xinput87 channel_length[59] VSS VSS VDD VDD net88 sky130_fd_sc_hd__clkbuf_4
Xinput88 channel_length[5] VSS VSS VDD VDD net89 sky130_fd_sc_hd__clkbuf_1
Xinput89 channel_length[60] VSS VSS VDD VDD net90 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput90 channel_length[61] VSS VSS VDD VDD net91 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput91 channel_length[62] VSS VSS VDD VDD net92 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput92 channel_length[63] VSS VSS VDD VDD net93 sky130_fd_sc_hd__buf_6
Xinput93 channel_length[64] VSS VSS VDD VDD net94 sky130_fd_sc_hd__clkbuf_1
Xinput94 channel_length[65] VSS VSS VDD VDD net95 sky130_fd_sc_hd__clkbuf_1
Xinput95 channel_length[66] VSS VSS VDD VDD net96 sky130_fd_sc_hd__clkbuf_1
Xinput96 channel_length[67] VSS VSS VDD VDD net97 sky130_fd_sc_hd__clkbuf_1
Xinput97 channel_length[68] VSS VSS VDD VDD net98 sky130_fd_sc_hd__clkbuf_1
Xinput98 channel_length[69] VSS VSS VDD VDD net99 sky130_fd_sc_hd__clkbuf_1
Xinput99 channel_length[6] VSS VSS VDD VDD net100 sky130_fd_sc_hd__clkbuf_1
Xinput100 channel_length[70] VSS VSS VDD VDD net101 sky130_fd_sc_hd__clkbuf_1
Xinput101 channel_length[71] VSS VSS VDD VDD net102 sky130_fd_sc_hd__clkbuf_1
Xinput102 channel_length[72] VSS VSS VDD VDD net103 sky130_fd_sc_hd__clkbuf_1
Xinput103 channel_length[73] VSS VSS VDD VDD net104 sky130_fd_sc_hd__clkbuf_1
Xinput104 channel_length[74] VSS VSS VDD VDD net105 sky130_fd_sc_hd__clkbuf_1
Xinput105 channel_length[75] VSS VSS VDD VDD net106 sky130_fd_sc_hd__clkbuf_1
Xinput106 channel_length[76] VSS VSS VDD VDD net107 sky130_fd_sc_hd__clkbuf_1
Xinput107 channel_length[77] VSS VSS VDD VDD net108 sky130_fd_sc_hd__clkbuf_1
Xinput108 channel_length[78] VSS VSS VDD VDD net109 sky130_fd_sc_hd__clkbuf_1
Xinput109 channel_length[79] VSS VSS VDD VDD net110 sky130_fd_sc_hd__clkbuf_1
Xinput110 channel_length[7] VSS VSS VDD VDD net111 sky130_fd_sc_hd__clkbuf_1
Xinput111 channel_length[80] VSS VSS VDD VDD net112 sky130_fd_sc_hd__clkbuf_1
Xinput112 channel_length[81] VSS VSS VDD VDD net113 sky130_fd_sc_hd__clkbuf_1
Xinput113 channel_length[82] VSS VSS VDD VDD net114 sky130_fd_sc_hd__clkbuf_1
Xinput114 channel_length[83] VSS VSS VDD VDD net115 sky130_fd_sc_hd__clkbuf_1
Xinput115 channel_length[84] VSS VSS VDD VDD net116 sky130_fd_sc_hd__clkbuf_1
Xinput116 channel_length[85] VSS VSS VDD VDD net117 sky130_fd_sc_hd__clkbuf_1
Xinput117 channel_length[86] VSS VSS VDD VDD net118 sky130_fd_sc_hd__clkbuf_1
Xinput118 channel_length[87] VSS VSS VDD VDD net119 sky130_fd_sc_hd__clkbuf_1
Xinput119 channel_length[88] VSS VSS VDD VDD net120 sky130_fd_sc_hd__clkbuf_1
Xinput120 channel_length[89] VSS VSS VDD VDD net121 sky130_fd_sc_hd__clkbuf_1
Xinput121 channel_length[8] VSS VSS VDD VDD net122 sky130_fd_sc_hd__clkbuf_1
Xinput122 channel_length[90] VSS VSS VDD VDD net123 sky130_fd_sc_hd__clkbuf_1
Xinput123 channel_length[91] VSS VSS VDD VDD net124 sky130_fd_sc_hd__clkbuf_1
Xinput124 channel_length[92] VSS VSS VDD VDD net125 sky130_fd_sc_hd__clkbuf_1
Xinput125 channel_length[93] VSS VSS VDD VDD net126 sky130_fd_sc_hd__clkbuf_1
Xinput126 channel_length[94] VSS VSS VDD VDD net127 sky130_fd_sc_hd__clkbuf_1
Xinput127 channel_length[95] VSS VSS VDD VDD net128 sky130_fd_sc_hd__clkbuf_1
Xinput128 channel_length[96] VSS VSS VDD VDD net129 sky130_fd_sc_hd__clkbuf_1
Xinput129 channel_length[97] VSS VSS VDD VDD net130 sky130_fd_sc_hd__clkbuf_1
Xinput130 channel_length[98] VSS VSS VDD VDD net131 sky130_fd_sc_hd__clkbuf_1
Xinput131 channel_length[99] VSS VSS VDD VDD net132 sky130_fd_sc_hd__clkbuf_1
Xinput132 channel_length[9] VSS VSS VDD VDD net133 sky130_fd_sc_hd__clkbuf_1
Xinput133 channel_start[0] VSS VSS VDD VDD net134 sky130_fd_sc_hd__clkbuf_2
Xinput134 channel_start[1] VSS VSS VDD VDD net135 sky130_fd_sc_hd__buf_2
Xinput135 channel_start[2] VSS VSS VDD VDD net136 sky130_fd_sc_hd__clkbuf_2
Xinput136 channel_start[3] VSS VSS VDD VDD net137 sky130_fd_sc_hd__buf_4
Xinput137 dst_wready[0] VSS VSS VDD VDD net138 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput138 dst_wready[1] VSS VSS VDD VDD net139 sky130_fd_sc_hd__clkbuf_2
Xinput139 dst_wready[2] VSS VSS VDD VDD net140 sky130_fd_sc_hd__clkbuf_2
Xinput140 dst_wready[3] VSS VSS VDD VDD net141 sky130_fd_sc_hd__buf_4
Xinput141 src_rvalid[0] VSS VSS VDD VDD net142 sky130_fd_sc_hd__clkbuf_4
Xinput142 src_rvalid[1] VSS VSS VDD VDD net143 sky130_fd_sc_hd__buf_4
Xinput143 src_rvalid[2] VSS VSS VDD VDD net144 sky130_fd_sc_hd__buf_4
Xinput144 src_rvalid[3] VSS VSS VDD VDD net145 sky130_fd_sc_hd__buf_4
Xoutput145 net146 VSS VSS VDD VDD channel_busy[0] sky130_fd_sc_hd__clkbuf_1
Xoutput146 net147 VSS VSS VDD VDD channel_busy[1] sky130_fd_sc_hd__clkbuf_1
Xoutput147 net148 VSS VSS VDD VDD channel_busy[2] sky130_fd_sc_hd__clkbuf_1
Xoutput148 net149 VSS VSS VDD VDD channel_busy[3] sky130_fd_sc_hd__clkbuf_1
Xoutput149 net150 VSS VSS VDD VDD channel_done[0] sky130_fd_sc_hd__clkbuf_1
Xoutput150 net151 VSS VSS VDD VDD channel_done[1] sky130_fd_sc_hd__clkbuf_1
Xoutput151 net152 VSS VSS VDD VDD channel_done[2] sky130_fd_sc_hd__clkbuf_1
Xoutput152 net153 VSS VSS VDD VDD channel_done[3] sky130_fd_sc_hd__clkbuf_1
Xoutput153 net154 VSS VSS VDD VDD channel_error[0] sky130_fd_sc_hd__clkbuf_1
Xoutput154 net155 VSS VSS VDD VDD channel_error[1] sky130_fd_sc_hd__clkbuf_1
Xoutput155 net156 VSS VSS VDD VDD channel_error[2] sky130_fd_sc_hd__clkbuf_1
Xoutput156 net157 VSS VSS VDD VDD channel_error[3] sky130_fd_sc_hd__clkbuf_1
Xoutput157 net158 VSS VSS VDD VDD debug_active_channels[0]
+ sky130_fd_sc_hd__clkbuf_1
Xoutput158 net159 VSS VSS VDD VDD debug_active_channels[1]
+ sky130_fd_sc_hd__clkbuf_1
Xoutput159 net160 VSS VSS VDD VDD debug_active_channels[2]
+ sky130_fd_sc_hd__clkbuf_1
Xoutput160 net161 VSS VSS VDD VDD debug_active_channels[3]
+ sky130_fd_sc_hd__clkbuf_1
Xoutput161 net162 VSS VSS VDD VDD debug_has_active_channels
+ sky130_fd_sc_hd__clkbuf_1
Xoutput162 net163 VSS VSS VDD VDD dst_write[0] sky130_fd_sc_hd__clkbuf_1
Xoutput163 net164 VSS VSS VDD VDD dst_write[1] sky130_fd_sc_hd__clkbuf_1
Xoutput164 net165 VSS VSS VDD VDD dst_write[2] sky130_fd_sc_hd__clkbuf_1
Xoutput165 net166 VSS VSS VDD VDD dst_write[3] sky130_fd_sc_hd__clkbuf_1
Xoutput166 net167 VSS VSS VDD VDD src_read[0] sky130_fd_sc_hd__clkbuf_1
Xoutput167 net168 VSS VSS VDD VDD src_read[1] sky130_fd_sc_hd__clkbuf_1
Xoutput168 net169 VSS VSS VDD VDD src_read[2] sky130_fd_sc_hd__clkbuf_1
Xoutput169 net170 VSS VSS VDD VDD src_read[3] sky130_fd_sc_hd__clkbuf_1
Xoutput170 net171 VSS VSS VDD VDD src_rready[0] sky130_fd_sc_hd__clkbuf_1
Xoutput171 net172 VSS VSS VDD VDD src_rready[1] sky130_fd_sc_hd__clkbuf_1
Xoutput172 net173 VSS VSS VDD VDD src_rready[2] sky130_fd_sc_hd__clkbuf_1
Xoutput173 net174 VSS VSS VDD VDD src_rready[3] sky130_fd_sc_hd__clkbuf_1
X_2752__174 VSS VSS VDD VDD _unconnected_0 net175 sky130_fd_sc_hd__conb_1
X_2753__175 VSS VSS VDD VDD _unconnected_1 net176 sky130_fd_sc_hd__conb_1
X_2754__176 VSS VSS VDD VDD _unconnected_2 net177 sky130_fd_sc_hd__conb_1
X_2755__177 VSS VSS VDD VDD _unconnected_3 net178 sky130_fd_sc_hd__conb_1
X_2756__178 VSS VSS VDD VDD _unconnected_4 net179 sky130_fd_sc_hd__conb_1
X_2757__179 VSS VSS VDD VDD _unconnected_5 net180 sky130_fd_sc_hd__conb_1
X_2758__180 VSS VSS VDD VDD _unconnected_6 net181 sky130_fd_sc_hd__conb_1
X_2759__181 VSS VSS VDD VDD _unconnected_7 net182 sky130_fd_sc_hd__conb_1
X_2760__182 VSS VSS VDD VDD _unconnected_8 net183 sky130_fd_sc_hd__conb_1
X_2761__183 VSS VSS VDD VDD _unconnected_9 net184 sky130_fd_sc_hd__conb_1
X_2762__184 VSS VSS VDD VDD _unconnected_10 net185 sky130_fd_sc_hd__conb_1
X_2763__185 VSS VSS VDD VDD _unconnected_11 net186 sky130_fd_sc_hd__conb_1
X_2764__186 VSS VSS VDD VDD _unconnected_12 net187 sky130_fd_sc_hd__conb_1
X_2765__187 VSS VSS VDD VDD _unconnected_13 net188 sky130_fd_sc_hd__conb_1
X_2766__188 VSS VSS VDD VDD _unconnected_14 net189 sky130_fd_sc_hd__conb_1
X_2767__189 VSS VSS VDD VDD _unconnected_15 net190 sky130_fd_sc_hd__conb_1
X_2768__190 VSS VSS VDD VDD _unconnected_16 net191 sky130_fd_sc_hd__conb_1
X_2769__191 VSS VSS VDD VDD _unconnected_17 net192 sky130_fd_sc_hd__conb_1
X_2770__192 VSS VSS VDD VDD _unconnected_18 net193 sky130_fd_sc_hd__conb_1
X_2771__193 VSS VSS VDD VDD _unconnected_19 net194 sky130_fd_sc_hd__conb_1
X_2772__194 VSS VSS VDD VDD _unconnected_20 net195 sky130_fd_sc_hd__conb_1
X_2773__195 VSS VSS VDD VDD _unconnected_21 net196 sky130_fd_sc_hd__conb_1
X_2774__196 VSS VSS VDD VDD _unconnected_22 net197 sky130_fd_sc_hd__conb_1
X_2775__197 VSS VSS VDD VDD _unconnected_23 net198 sky130_fd_sc_hd__conb_1
X_2776__198 VSS VSS VDD VDD _unconnected_24 net199 sky130_fd_sc_hd__conb_1
X_2777__199 VSS VSS VDD VDD _unconnected_25 net200 sky130_fd_sc_hd__conb_1
X_2778__200 VSS VSS VDD VDD _unconnected_26 net201 sky130_fd_sc_hd__conb_1
X_2779__201 VSS VSS VDD VDD _unconnected_27 net202 sky130_fd_sc_hd__conb_1
X_2780__202 VSS VSS VDD VDD _unconnected_28 net203 sky130_fd_sc_hd__conb_1
X_2781__203 VSS VSS VDD VDD _unconnected_29 net204 sky130_fd_sc_hd__conb_1
X_2782__204 VSS VSS VDD VDD _unconnected_30 net205 sky130_fd_sc_hd__conb_1
X_2783__205 VSS VSS VDD VDD _unconnected_31 net206 sky130_fd_sc_hd__conb_1
X_2784__206 VSS VSS VDD VDD _unconnected_32 net207 sky130_fd_sc_hd__conb_1
X_2785__207 VSS VSS VDD VDD _unconnected_33 net208 sky130_fd_sc_hd__conb_1
X_2786__208 VSS VSS VDD VDD _unconnected_34 net209 sky130_fd_sc_hd__conb_1
X_2787__209 VSS VSS VDD VDD _unconnected_35 net210 sky130_fd_sc_hd__conb_1
X_2788__210 VSS VSS VDD VDD _unconnected_36 net211 sky130_fd_sc_hd__conb_1
X_2789__211 VSS VSS VDD VDD _unconnected_37 net212 sky130_fd_sc_hd__conb_1
X_2790__212 VSS VSS VDD VDD _unconnected_38 net213 sky130_fd_sc_hd__conb_1
X_2791__213 VSS VSS VDD VDD _unconnected_39 net214 sky130_fd_sc_hd__conb_1
X_2792__214 VSS VSS VDD VDD _unconnected_40 net215 sky130_fd_sc_hd__conb_1
X_2793__215 VSS VSS VDD VDD _unconnected_41 net216 sky130_fd_sc_hd__conb_1
X_2794__216 VSS VSS VDD VDD _unconnected_42 net217 sky130_fd_sc_hd__conb_1
X_2795__217 VSS VSS VDD VDD _unconnected_43 net218 sky130_fd_sc_hd__conb_1
X_2796__218 VSS VSS VDD VDD _unconnected_44 net219 sky130_fd_sc_hd__conb_1
X_2797__219 VSS VSS VDD VDD _unconnected_45 net220 sky130_fd_sc_hd__conb_1
X_2798__220 VSS VSS VDD VDD _unconnected_46 net221 sky130_fd_sc_hd__conb_1
X_2799__221 VSS VSS VDD VDD _unconnected_47 net222 sky130_fd_sc_hd__conb_1
X_2800__222 VSS VSS VDD VDD _unconnected_48 net223 sky130_fd_sc_hd__conb_1
X_2801__223 VSS VSS VDD VDD _unconnected_49 net224 sky130_fd_sc_hd__conb_1
X_2802__224 VSS VSS VDD VDD _unconnected_50 net225 sky130_fd_sc_hd__conb_1
X_2803__225 VSS VSS VDD VDD _unconnected_51 net226 sky130_fd_sc_hd__conb_1
X_2804__226 VSS VSS VDD VDD _unconnected_52 net227 sky130_fd_sc_hd__conb_1
X_2805__227 VSS VSS VDD VDD _unconnected_53 net228 sky130_fd_sc_hd__conb_1
X_2806__228 VSS VSS VDD VDD _unconnected_54 net229 sky130_fd_sc_hd__conb_1
X_2807__229 VSS VSS VDD VDD _unconnected_55 net230 sky130_fd_sc_hd__conb_1
X_2808__230 VSS VSS VDD VDD _unconnected_56 net231 sky130_fd_sc_hd__conb_1
X_2809__231 VSS VSS VDD VDD _unconnected_57 net232 sky130_fd_sc_hd__conb_1
X_2810__232 VSS VSS VDD VDD _unconnected_58 net233 sky130_fd_sc_hd__conb_1
X_2811__233 VSS VSS VDD VDD _unconnected_59 net234 sky130_fd_sc_hd__conb_1
X_2812__234 VSS VSS VDD VDD _unconnected_60 net235 sky130_fd_sc_hd__conb_1
X_2813__235 VSS VSS VDD VDD _unconnected_61 net236 sky130_fd_sc_hd__conb_1
X_2814__236 VSS VSS VDD VDD _unconnected_62 net237 sky130_fd_sc_hd__conb_1
X_2815__237 VSS VSS VDD VDD _unconnected_63 net238 sky130_fd_sc_hd__conb_1
X_2816__238 VSS VSS VDD VDD _unconnected_64 net239 sky130_fd_sc_hd__conb_1
X_2817__239 VSS VSS VDD VDD _unconnected_65 net240 sky130_fd_sc_hd__conb_1
X_2818__240 VSS VSS VDD VDD _unconnected_66 net241 sky130_fd_sc_hd__conb_1
X_2819__241 VSS VSS VDD VDD _unconnected_67 net242 sky130_fd_sc_hd__conb_1
X_2820__242 VSS VSS VDD VDD _unconnected_68 net243 sky130_fd_sc_hd__conb_1
X_2821__243 VSS VSS VDD VDD _unconnected_69 net244 sky130_fd_sc_hd__conb_1
X_2822__244 VSS VSS VDD VDD _unconnected_70 net245 sky130_fd_sc_hd__conb_1
X_2823__245 VSS VSS VDD VDD _unconnected_71 net246 sky130_fd_sc_hd__conb_1
X_2824__246 VSS VSS VDD VDD _unconnected_72 net247 sky130_fd_sc_hd__conb_1
X_2825__247 VSS VSS VDD VDD _unconnected_73 net248 sky130_fd_sc_hd__conb_1
X_2826__248 VSS VSS VDD VDD _unconnected_74 net249 sky130_fd_sc_hd__conb_1
X_2827__249 VSS VSS VDD VDD _unconnected_75 net250 sky130_fd_sc_hd__conb_1
X_2828__250 VSS VSS VDD VDD _unconnected_76 net251 sky130_fd_sc_hd__conb_1
X_2829__251 VSS VSS VDD VDD _unconnected_77 net252 sky130_fd_sc_hd__conb_1
X_2830__252 VSS VSS VDD VDD _unconnected_78 net253 sky130_fd_sc_hd__conb_1
X_2831__253 VSS VSS VDD VDD _unconnected_79 net254 sky130_fd_sc_hd__conb_1
X_2832__254 VSS VSS VDD VDD _unconnected_80 net255 sky130_fd_sc_hd__conb_1
X_2833__255 VSS VSS VDD VDD _unconnected_81 net256 sky130_fd_sc_hd__conb_1
X_2834__256 VSS VSS VDD VDD _unconnected_82 net257 sky130_fd_sc_hd__conb_1
X_2835__257 VSS VSS VDD VDD _unconnected_83 net258 sky130_fd_sc_hd__conb_1
X_2836__258 VSS VSS VDD VDD _unconnected_84 net259 sky130_fd_sc_hd__conb_1
X_2837__259 VSS VSS VDD VDD _unconnected_85 net260 sky130_fd_sc_hd__conb_1
X_2838__260 VSS VSS VDD VDD _unconnected_86 net261 sky130_fd_sc_hd__conb_1
X_2839__261 VSS VSS VDD VDD _unconnected_87 net262 sky130_fd_sc_hd__conb_1
X_2840__262 VSS VSS VDD VDD _unconnected_88 net263 sky130_fd_sc_hd__conb_1
X_2841__263 VSS VSS VDD VDD _unconnected_89 net264 sky130_fd_sc_hd__conb_1
X_2842__264 VSS VSS VDD VDD _unconnected_90 net265 sky130_fd_sc_hd__conb_1
X_2843__265 VSS VSS VDD VDD _unconnected_91 net266 sky130_fd_sc_hd__conb_1
X_2844__266 VSS VSS VDD VDD _unconnected_92 net267 sky130_fd_sc_hd__conb_1
X_2845__267 VSS VSS VDD VDD _unconnected_93 net268 sky130_fd_sc_hd__conb_1
X_2846__268 VSS VSS VDD VDD _unconnected_94 net269 sky130_fd_sc_hd__conb_1
X_2847__269 VSS VSS VDD VDD _unconnected_95 net270 sky130_fd_sc_hd__conb_1
X_2848__270 VSS VSS VDD VDD _unconnected_96 net271 sky130_fd_sc_hd__conb_1
X_2849__271 VSS VSS VDD VDD _unconnected_97 net272 sky130_fd_sc_hd__conb_1
X_2850__272 VSS VSS VDD VDD _unconnected_98 net273 sky130_fd_sc_hd__conb_1
X_2851__273 VSS VSS VDD VDD _unconnected_99 net274 sky130_fd_sc_hd__conb_1
X_2852__274 VSS VSS VDD VDD _unconnected_100 net275 sky130_fd_sc_hd__conb_1
X_2853__275 VSS VSS VDD VDD _unconnected_101 net276 sky130_fd_sc_hd__conb_1
X_2854__276 VSS VSS VDD VDD _unconnected_102 net277 sky130_fd_sc_hd__conb_1
X_2855__277 VSS VSS VDD VDD _unconnected_103 net278 sky130_fd_sc_hd__conb_1
X_2856__278 VSS VSS VDD VDD _unconnected_104 net279 sky130_fd_sc_hd__conb_1
X_2857__279 VSS VSS VDD VDD _unconnected_105 net280 sky130_fd_sc_hd__conb_1
X_2858__280 VSS VSS VDD VDD _unconnected_106 net281 sky130_fd_sc_hd__conb_1
X_2859__281 VSS VSS VDD VDD _unconnected_107 net282 sky130_fd_sc_hd__conb_1
X_2860__282 VSS VSS VDD VDD _unconnected_108 net283 sky130_fd_sc_hd__conb_1
X_2861__283 VSS VSS VDD VDD _unconnected_109 net284 sky130_fd_sc_hd__conb_1
X_2862__284 VSS VSS VDD VDD _unconnected_110 net285 sky130_fd_sc_hd__conb_1
X_2863__285 VSS VSS VDD VDD _unconnected_111 net286 sky130_fd_sc_hd__conb_1
X_2864__286 VSS VSS VDD VDD _unconnected_112 net287 sky130_fd_sc_hd__conb_1
X_2865__287 VSS VSS VDD VDD _unconnected_113 net288 sky130_fd_sc_hd__conb_1
X_2866__288 VSS VSS VDD VDD _unconnected_114 net289 sky130_fd_sc_hd__conb_1
X_2867__289 VSS VSS VDD VDD _unconnected_115 net290 sky130_fd_sc_hd__conb_1
X_2868__290 VSS VSS VDD VDD _unconnected_116 net291 sky130_fd_sc_hd__conb_1
X_2869__291 VSS VSS VDD VDD _unconnected_117 net292 sky130_fd_sc_hd__conb_1
X_2870__292 VSS VSS VDD VDD _unconnected_118 net293 sky130_fd_sc_hd__conb_1
X_2871__293 VSS VSS VDD VDD _unconnected_119 net294 sky130_fd_sc_hd__conb_1
X_2872__294 VSS VSS VDD VDD _unconnected_120 net295 sky130_fd_sc_hd__conb_1
X_2873__295 VSS VSS VDD VDD _unconnected_121 net296 sky130_fd_sc_hd__conb_1
X_2874__296 VSS VSS VDD VDD _unconnected_122 net297 sky130_fd_sc_hd__conb_1
X_2875__297 VSS VSS VDD VDD _unconnected_123 net298 sky130_fd_sc_hd__conb_1
X_2876__298 VSS VSS VDD VDD _unconnected_124 net299 sky130_fd_sc_hd__conb_1
X_2877__299 VSS VSS VDD VDD _unconnected_125 net300 sky130_fd_sc_hd__conb_1
X_2878__300 VSS VSS VDD VDD _unconnected_126 net301 sky130_fd_sc_hd__conb_1
X_2879__301 VSS VSS VDD VDD _unconnected_127 net302 sky130_fd_sc_hd__conb_1
X_2880__302 VSS VSS VDD VDD _unconnected_128 net303 sky130_fd_sc_hd__conb_1
X_2881__303 VSS VSS VDD VDD _unconnected_129 net304 sky130_fd_sc_hd__conb_1
X_2882__304 VSS VSS VDD VDD _unconnected_130 net305 sky130_fd_sc_hd__conb_1
X_2883__305 VSS VSS VDD VDD _unconnected_131 net306 sky130_fd_sc_hd__conb_1
X_2884__306 VSS VSS VDD VDD _unconnected_132 net307 sky130_fd_sc_hd__conb_1
X_2885__307 VSS VSS VDD VDD _unconnected_133 net308 sky130_fd_sc_hd__conb_1
X_2886__308 VSS VSS VDD VDD _unconnected_134 net309 sky130_fd_sc_hd__conb_1
X_2887__309 VSS VSS VDD VDD _unconnected_135 net310 sky130_fd_sc_hd__conb_1
X_2888__310 VSS VSS VDD VDD _unconnected_136 net311 sky130_fd_sc_hd__conb_1
X_2889__311 VSS VSS VDD VDD _unconnected_137 net312 sky130_fd_sc_hd__conb_1
X_2890__312 VSS VSS VDD VDD _unconnected_138 net313 sky130_fd_sc_hd__conb_1
X_2891__313 VSS VSS VDD VDD _unconnected_139 net314 sky130_fd_sc_hd__conb_1
X_2892__314 VSS VSS VDD VDD _unconnected_140 net315 sky130_fd_sc_hd__conb_1
X_2893__315 VSS VSS VDD VDD _unconnected_141 net316 sky130_fd_sc_hd__conb_1
X_2894__316 VSS VSS VDD VDD _unconnected_142 net317 sky130_fd_sc_hd__conb_1
X_2895__317 VSS VSS VDD VDD _unconnected_143 net318 sky130_fd_sc_hd__conb_1
X_2896__318 VSS VSS VDD VDD _unconnected_144 net319 sky130_fd_sc_hd__conb_1
X_2897__319 VSS VSS VDD VDD _unconnected_145 net320 sky130_fd_sc_hd__conb_1
X_2898__320 VSS VSS VDD VDD _unconnected_146 net321 sky130_fd_sc_hd__conb_1
X_2899__321 VSS VSS VDD VDD _unconnected_147 net322 sky130_fd_sc_hd__conb_1
X_2900__322 VSS VSS VDD VDD _unconnected_148 net323 sky130_fd_sc_hd__conb_1
X_2901__323 VSS VSS VDD VDD _unconnected_149 net324 sky130_fd_sc_hd__conb_1
X_2902__324 VSS VSS VDD VDD _unconnected_150 net325 sky130_fd_sc_hd__conb_1
X_2903__325 VSS VSS VDD VDD _unconnected_151 net326 sky130_fd_sc_hd__conb_1
X_2904__326 VSS VSS VDD VDD _unconnected_152 net327 sky130_fd_sc_hd__conb_1
X_2905__327 VSS VSS VDD VDD _unconnected_153 net328 sky130_fd_sc_hd__conb_1
X_2906__328 VSS VSS VDD VDD _unconnected_154 net329 sky130_fd_sc_hd__conb_1
X_2907__329 VSS VSS VDD VDD _unconnected_155 net330 sky130_fd_sc_hd__conb_1
X_2908__330 VSS VSS VDD VDD _unconnected_156 net331 sky130_fd_sc_hd__conb_1
X_2909__331 VSS VSS VDD VDD _unconnected_157 net332 sky130_fd_sc_hd__conb_1
X_2910__332 VSS VSS VDD VDD _unconnected_158 net333 sky130_fd_sc_hd__conb_1
X_2911__333 VSS VSS VDD VDD _unconnected_159 net334 sky130_fd_sc_hd__conb_1
X_2912__334 VSS VSS VDD VDD _unconnected_160 net335 sky130_fd_sc_hd__conb_1
X_2913__335 VSS VSS VDD VDD _unconnected_161 net336 sky130_fd_sc_hd__conb_1
X_2914__336 VSS VSS VDD VDD _unconnected_162 net337 sky130_fd_sc_hd__conb_1
X_2915__337 VSS VSS VDD VDD _unconnected_163 net338 sky130_fd_sc_hd__conb_1
X_2916__338 VSS VSS VDD VDD _unconnected_164 net339 sky130_fd_sc_hd__conb_1
X_2917__339 VSS VSS VDD VDD _unconnected_165 net340 sky130_fd_sc_hd__conb_1
X_2918__340 VSS VSS VDD VDD _unconnected_166 net341 sky130_fd_sc_hd__conb_1
X_2919__341 VSS VSS VDD VDD _unconnected_167 net342 sky130_fd_sc_hd__conb_1
X_2920__342 VSS VSS VDD VDD _unconnected_168 net343 sky130_fd_sc_hd__conb_1
X_2921__343 VSS VSS VDD VDD _unconnected_169 net344 sky130_fd_sc_hd__conb_1
X_2922__344 VSS VSS VDD VDD _unconnected_170 net345 sky130_fd_sc_hd__conb_1
X_2923__345 VSS VSS VDD VDD _unconnected_171 net346 sky130_fd_sc_hd__conb_1
X_2924__346 VSS VSS VDD VDD _unconnected_172 net347 sky130_fd_sc_hd__conb_1
X_2925__347 VSS VSS VDD VDD _unconnected_173 net348 sky130_fd_sc_hd__conb_1
X_2926__348 VSS VSS VDD VDD _unconnected_174 net349 sky130_fd_sc_hd__conb_1
X_2927__349 VSS VSS VDD VDD _unconnected_175 net350 sky130_fd_sc_hd__conb_1
X_2928__350 VSS VSS VDD VDD _unconnected_176 net351 sky130_fd_sc_hd__conb_1
X_2929__351 VSS VSS VDD VDD _unconnected_177 net352 sky130_fd_sc_hd__conb_1
X_2930__352 VSS VSS VDD VDD _unconnected_178 net353 sky130_fd_sc_hd__conb_1
X_2931__353 VSS VSS VDD VDD _unconnected_179 net354 sky130_fd_sc_hd__conb_1
X_2932__354 VSS VSS VDD VDD _unconnected_180 net355 sky130_fd_sc_hd__conb_1
X_2933__355 VSS VSS VDD VDD _unconnected_181 net356 sky130_fd_sc_hd__conb_1
X_2934__356 VSS VSS VDD VDD _unconnected_182 net357 sky130_fd_sc_hd__conb_1
X_2935__357 VSS VSS VDD VDD _unconnected_183 net358 sky130_fd_sc_hd__conb_1
X_2936__358 VSS VSS VDD VDD _unconnected_184 net359 sky130_fd_sc_hd__conb_1
X_2937__359 VSS VSS VDD VDD _unconnected_185 net360 sky130_fd_sc_hd__conb_1
X_2938__360 VSS VSS VDD VDD _unconnected_186 net361 sky130_fd_sc_hd__conb_1
X_2939__361 VSS VSS VDD VDD _unconnected_187 net362 sky130_fd_sc_hd__conb_1
X_2940__362 VSS VSS VDD VDD _unconnected_188 net363 sky130_fd_sc_hd__conb_1
X_2941__363 VSS VSS VDD VDD _unconnected_189 net364 sky130_fd_sc_hd__conb_1
X_2942__364 VSS VSS VDD VDD _unconnected_190 net365 sky130_fd_sc_hd__conb_1
X_2943__365 VSS VSS VDD VDD _unconnected_191 net366 sky130_fd_sc_hd__conb_1
X_2944__366 VSS VSS VDD VDD _unconnected_192 net367 sky130_fd_sc_hd__conb_1
X_2945__367 VSS VSS VDD VDD _unconnected_193 net368 sky130_fd_sc_hd__conb_1
X_2946__368 VSS VSS VDD VDD _unconnected_194 net369 sky130_fd_sc_hd__conb_1
X_2947__369 VSS VSS VDD VDD _unconnected_195 net370 sky130_fd_sc_hd__conb_1
X_2948__370 VSS VSS VDD VDD _unconnected_196 net371 sky130_fd_sc_hd__conb_1
X_2949__371 VSS VSS VDD VDD _unconnected_197 net372 sky130_fd_sc_hd__conb_1
X_2950__372 VSS VSS VDD VDD _unconnected_198 net373 sky130_fd_sc_hd__conb_1
X_2951__373 VSS VSS VDD VDD _unconnected_199 net374 sky130_fd_sc_hd__conb_1
X_2952__374 VSS VSS VDD VDD _unconnected_200 net375 sky130_fd_sc_hd__conb_1
X_2953__375 VSS VSS VDD VDD _unconnected_201 net376 sky130_fd_sc_hd__conb_1
X_2954__376 VSS VSS VDD VDD _unconnected_202 net377 sky130_fd_sc_hd__conb_1
X_2955__377 VSS VSS VDD VDD _unconnected_203 net378 sky130_fd_sc_hd__conb_1
X_2956__378 VSS VSS VDD VDD _unconnected_204 net379 sky130_fd_sc_hd__conb_1
X_2957__379 VSS VSS VDD VDD _unconnected_205 net380 sky130_fd_sc_hd__conb_1
X_2958__380 VSS VSS VDD VDD _unconnected_206 net381 sky130_fd_sc_hd__conb_1
X_2959__381 VSS VSS VDD VDD _unconnected_207 net382 sky130_fd_sc_hd__conb_1
X_2960__382 VSS VSS VDD VDD _unconnected_208 net383 sky130_fd_sc_hd__conb_1
X_2961__383 VSS VSS VDD VDD _unconnected_209 net384 sky130_fd_sc_hd__conb_1
X_2962__384 VSS VSS VDD VDD _unconnected_210 net385 sky130_fd_sc_hd__conb_1
X_2963__385 VSS VSS VDD VDD _unconnected_211 net386 sky130_fd_sc_hd__conb_1
X_2964__386 VSS VSS VDD VDD _unconnected_212 net387 sky130_fd_sc_hd__conb_1
X_2965__387 VSS VSS VDD VDD _unconnected_213 net388 sky130_fd_sc_hd__conb_1
X_2966__388 VSS VSS VDD VDD _unconnected_214 net389 sky130_fd_sc_hd__conb_1
X_2967__389 VSS VSS VDD VDD _unconnected_215 net390 sky130_fd_sc_hd__conb_1
X_2968__390 VSS VSS VDD VDD _unconnected_216 net391 sky130_fd_sc_hd__conb_1
X_2969__391 VSS VSS VDD VDD _unconnected_217 net392 sky130_fd_sc_hd__conb_1
X_2970__392 VSS VSS VDD VDD _unconnected_218 net393 sky130_fd_sc_hd__conb_1
X_2971__393 VSS VSS VDD VDD _unconnected_219 net394 sky130_fd_sc_hd__conb_1
X_2972__394 VSS VSS VDD VDD _unconnected_220 net395 sky130_fd_sc_hd__conb_1
X_2973__395 VSS VSS VDD VDD _unconnected_221 net396 sky130_fd_sc_hd__conb_1
X_2974__396 VSS VSS VDD VDD _unconnected_222 net397 sky130_fd_sc_hd__conb_1
X_2975__397 VSS VSS VDD VDD _unconnected_223 net398 sky130_fd_sc_hd__conb_1
X_2976__398 VSS VSS VDD VDD _unconnected_224 net399 sky130_fd_sc_hd__conb_1
X_2977__399 VSS VSS VDD VDD _unconnected_225 net400 sky130_fd_sc_hd__conb_1
X_2978__400 VSS VSS VDD VDD _unconnected_226 net401 sky130_fd_sc_hd__conb_1
X_2979__401 VSS VSS VDD VDD _unconnected_227 net402 sky130_fd_sc_hd__conb_1
X_2980__402 VSS VSS VDD VDD _unconnected_228 net403 sky130_fd_sc_hd__conb_1
X_2981__403 VSS VSS VDD VDD _unconnected_229 net404 sky130_fd_sc_hd__conb_1
X_2982__404 VSS VSS VDD VDD _unconnected_230 net405 sky130_fd_sc_hd__conb_1
X_2983__405 VSS VSS VDD VDD _unconnected_231 net406 sky130_fd_sc_hd__conb_1
X_2984__406 VSS VSS VDD VDD _unconnected_232 net407 sky130_fd_sc_hd__conb_1
X_2985__407 VSS VSS VDD VDD _unconnected_233 net408 sky130_fd_sc_hd__conb_1
X_2986__408 VSS VSS VDD VDD _unconnected_234 net409 sky130_fd_sc_hd__conb_1
X_2987__409 VSS VSS VDD VDD _unconnected_235 net410 sky130_fd_sc_hd__conb_1
X_2988__410 VSS VSS VDD VDD _unconnected_236 net411 sky130_fd_sc_hd__conb_1
X_2989__411 VSS VSS VDD VDD _unconnected_237 net412 sky130_fd_sc_hd__conb_1
X_2990__412 VSS VSS VDD VDD _unconnected_238 net413 sky130_fd_sc_hd__conb_1
X_2991__413 VSS VSS VDD VDD _unconnected_239 net414 sky130_fd_sc_hd__conb_1
X_2992__414 VSS VSS VDD VDD _unconnected_240 net415 sky130_fd_sc_hd__conb_1
X_2993__415 VSS VSS VDD VDD _unconnected_241 net416 sky130_fd_sc_hd__conb_1
X_2994__416 VSS VSS VDD VDD _unconnected_242 net417 sky130_fd_sc_hd__conb_1
X_2995__417 VSS VSS VDD VDD _unconnected_243 net418 sky130_fd_sc_hd__conb_1
X_2996__418 VSS VSS VDD VDD _unconnected_244 net419 sky130_fd_sc_hd__conb_1
X_2997__419 VSS VSS VDD VDD _unconnected_245 net420 sky130_fd_sc_hd__conb_1
X_2998__420 VSS VSS VDD VDD _unconnected_246 net421 sky130_fd_sc_hd__conb_1
X_2999__421 VSS VSS VDD VDD _unconnected_247 net422 sky130_fd_sc_hd__conb_1
X_3000__422 VSS VSS VDD VDD _unconnected_248 net423 sky130_fd_sc_hd__conb_1
X_3001__423 VSS VSS VDD VDD _unconnected_249 net424 sky130_fd_sc_hd__conb_1
X_3002__424 VSS VSS VDD VDD _unconnected_250 net425 sky130_fd_sc_hd__conb_1
X_3003__425 VSS VSS VDD VDD _unconnected_251 net426 sky130_fd_sc_hd__conb_1
X_3004__426 VSS VSS VDD VDD _unconnected_252 net427 sky130_fd_sc_hd__conb_1
X_3005__427 VSS VSS VDD VDD _unconnected_253 net428 sky130_fd_sc_hd__conb_1
X_3006__428 VSS VSS VDD VDD _unconnected_254 net429 sky130_fd_sc_hd__conb_1
X_3007__429 VSS VSS VDD VDD _unconnected_255 net430 sky130_fd_sc_hd__conb_1
X_3008__430 VSS VSS VDD VDD _unconnected_256 net431 sky130_fd_sc_hd__conb_1
X_3009__431 VSS VSS VDD VDD _unconnected_257 net432 sky130_fd_sc_hd__conb_1
X_3010__432 VSS VSS VDD VDD _unconnected_258 net433 sky130_fd_sc_hd__conb_1
X_3011__433 VSS VSS VDD VDD _unconnected_259 net434 sky130_fd_sc_hd__conb_1
X_3012__434 VSS VSS VDD VDD _unconnected_260 net435 sky130_fd_sc_hd__conb_1
X_3013__435 VSS VSS VDD VDD _unconnected_261 net436 sky130_fd_sc_hd__conb_1
X_3014__436 VSS VSS VDD VDD _unconnected_262 net437 sky130_fd_sc_hd__conb_1
X_3015__437 VSS VSS VDD VDD _unconnected_263 net438 sky130_fd_sc_hd__conb_1
X_3016__438 VSS VSS VDD VDD _unconnected_264 net439 sky130_fd_sc_hd__conb_1
X_3017__439 VSS VSS VDD VDD _unconnected_265 net440 sky130_fd_sc_hd__conb_1
X_3018__440 VSS VSS VDD VDD _unconnected_266 net441 sky130_fd_sc_hd__conb_1
X_3019__441 VSS VSS VDD VDD _unconnected_267 net442 sky130_fd_sc_hd__conb_1
X_3020__442 VSS VSS VDD VDD _unconnected_268 net443 sky130_fd_sc_hd__conb_1
X_3021__443 VSS VSS VDD VDD _unconnected_269 net444 sky130_fd_sc_hd__conb_1
X_3022__444 VSS VSS VDD VDD _unconnected_270 net445 sky130_fd_sc_hd__conb_1
X_3023__445 VSS VSS VDD VDD _unconnected_271 net446 sky130_fd_sc_hd__conb_1
X_3024__446 VSS VSS VDD VDD _unconnected_272 net447 sky130_fd_sc_hd__conb_1
X_3025__447 VSS VSS VDD VDD _unconnected_273 net448 sky130_fd_sc_hd__conb_1
X_3026__448 VSS VSS VDD VDD _unconnected_274 net449 sky130_fd_sc_hd__conb_1
X_3027__449 VSS VSS VDD VDD _unconnected_275 net450 sky130_fd_sc_hd__conb_1
X_3028__450 VSS VSS VDD VDD _unconnected_276 net451 sky130_fd_sc_hd__conb_1
X_3029__451 VSS VSS VDD VDD _unconnected_277 net452 sky130_fd_sc_hd__conb_1
X_3030__452 VSS VSS VDD VDD _unconnected_278 net453 sky130_fd_sc_hd__conb_1
X_3031__453 VSS VSS VDD VDD _unconnected_279 net454 sky130_fd_sc_hd__conb_1
X_3032__454 VSS VSS VDD VDD _unconnected_280 net455 sky130_fd_sc_hd__conb_1
X_3033__455 VSS VSS VDD VDD _unconnected_281 net456 sky130_fd_sc_hd__conb_1
X_3034__456 VSS VSS VDD VDD _unconnected_282 net457 sky130_fd_sc_hd__conb_1
X_3035__457 VSS VSS VDD VDD _unconnected_283 net458 sky130_fd_sc_hd__conb_1
X_3036__458 VSS VSS VDD VDD _unconnected_284 net459 sky130_fd_sc_hd__conb_1
X_3037__459 VSS VSS VDD VDD _unconnected_285 net460 sky130_fd_sc_hd__conb_1
X_3038__460 VSS VSS VDD VDD _unconnected_286 net461 sky130_fd_sc_hd__conb_1
X_3039__461 VSS VSS VDD VDD _unconnected_287 net462 sky130_fd_sc_hd__conb_1
X_3040__462 VSS VSS VDD VDD _unconnected_288 net463 sky130_fd_sc_hd__conb_1
X_3041__463 VSS VSS VDD VDD _unconnected_289 net464 sky130_fd_sc_hd__conb_1
X_3042__464 VSS VSS VDD VDD _unconnected_290 net465 sky130_fd_sc_hd__conb_1
X_3043__465 VSS VSS VDD VDD _unconnected_291 net466 sky130_fd_sc_hd__conb_1
X_3044__466 VSS VSS VDD VDD _unconnected_292 net467 sky130_fd_sc_hd__conb_1
X_3045__467 VSS VSS VDD VDD _unconnected_293 net468 sky130_fd_sc_hd__conb_1
X_3046__468 VSS VSS VDD VDD _unconnected_294 net469 sky130_fd_sc_hd__conb_1
X_3047__469 VSS VSS VDD VDD _unconnected_295 net470 sky130_fd_sc_hd__conb_1
X_3048__470 VSS VSS VDD VDD _unconnected_296 net471 sky130_fd_sc_hd__conb_1
X_3049__471 VSS VSS VDD VDD _unconnected_297 net472 sky130_fd_sc_hd__conb_1
X_3050__472 VSS VSS VDD VDD _unconnected_298 net473 sky130_fd_sc_hd__conb_1
X_3051__473 VSS VSS VDD VDD _unconnected_299 net474 sky130_fd_sc_hd__conb_1
X_3052__474 VSS VSS VDD VDD _unconnected_300 net475 sky130_fd_sc_hd__conb_1
X_3053__475 VSS VSS VDD VDD _unconnected_301 net476 sky130_fd_sc_hd__conb_1
X_3054__476 VSS VSS VDD VDD _unconnected_302 net477 sky130_fd_sc_hd__conb_1
X_3055__477 VSS VSS VDD VDD _unconnected_303 net478 sky130_fd_sc_hd__conb_1
X_3056__478 VSS VSS VDD VDD _unconnected_304 net479 sky130_fd_sc_hd__conb_1
X_3057__479 VSS VSS VDD VDD _unconnected_305 net480 sky130_fd_sc_hd__conb_1
X_3058__480 VSS VSS VDD VDD _unconnected_306 net481 sky130_fd_sc_hd__conb_1
X_3059__481 VSS VSS VDD VDD _unconnected_307 net482 sky130_fd_sc_hd__conb_1
X_3060__482 VSS VSS VDD VDD _unconnected_308 net483 sky130_fd_sc_hd__conb_1
X_3061__483 VSS VSS VDD VDD _unconnected_309 net484 sky130_fd_sc_hd__conb_1
X_3062__484 VSS VSS VDD VDD _unconnected_310 net485 sky130_fd_sc_hd__conb_1
X_3063__485 VSS VSS VDD VDD _unconnected_311 net486 sky130_fd_sc_hd__conb_1
X_3064__486 VSS VSS VDD VDD _unconnected_312 net487 sky130_fd_sc_hd__conb_1
X_3065__487 VSS VSS VDD VDD _unconnected_313 net488 sky130_fd_sc_hd__conb_1
X_3066__488 VSS VSS VDD VDD _unconnected_314 net489 sky130_fd_sc_hd__conb_1
X_3067__489 VSS VSS VDD VDD _unconnected_315 net490 sky130_fd_sc_hd__conb_1
X_3068__490 VSS VSS VDD VDD _unconnected_316 net491 sky130_fd_sc_hd__conb_1
X_3069__491 VSS VSS VDD VDD _unconnected_317 net492 sky130_fd_sc_hd__conb_1
X_3070__492 VSS VSS VDD VDD _unconnected_318 net493 sky130_fd_sc_hd__conb_1
X_3071__493 VSS VSS VDD VDD _unconnected_319 net494 sky130_fd_sc_hd__conb_1
X_3072__494 VSS VSS VDD VDD _unconnected_320 net495 sky130_fd_sc_hd__conb_1
X_3073__495 VSS VSS VDD VDD _unconnected_321 net496 sky130_fd_sc_hd__conb_1
X_3074__496 VSS VSS VDD VDD _unconnected_322 net497 sky130_fd_sc_hd__conb_1
X_3075__497 VSS VSS VDD VDD _unconnected_323 net498 sky130_fd_sc_hd__conb_1
X_3076__498 VSS VSS VDD VDD _unconnected_324 net499 sky130_fd_sc_hd__conb_1
X_3077__499 VSS VSS VDD VDD _unconnected_325 net500 sky130_fd_sc_hd__conb_1
X_3078__500 VSS VSS VDD VDD _unconnected_326 net501 sky130_fd_sc_hd__conb_1
X_3079__501 VSS VSS VDD VDD _unconnected_327 net502 sky130_fd_sc_hd__conb_1
X_3080__502 VSS VSS VDD VDD _unconnected_328 net503 sky130_fd_sc_hd__conb_1
X_3081__503 VSS VSS VDD VDD _unconnected_329 net504 sky130_fd_sc_hd__conb_1
X_3082__504 VSS VSS VDD VDD _unconnected_330 net505 sky130_fd_sc_hd__conb_1
X_3083__505 VSS VSS VDD VDD _unconnected_331 net506 sky130_fd_sc_hd__conb_1
X_3084__506 VSS VSS VDD VDD _unconnected_332 net507 sky130_fd_sc_hd__conb_1
X_3085__507 VSS VSS VDD VDD _unconnected_333 net508 sky130_fd_sc_hd__conb_1
X_3086__508 VSS VSS VDD VDD _unconnected_334 net509 sky130_fd_sc_hd__conb_1
X_3087__509 VSS VSS VDD VDD _unconnected_335 net510 sky130_fd_sc_hd__conb_1
X_3088__510 VSS VSS VDD VDD _unconnected_336 net511 sky130_fd_sc_hd__conb_1
X_3089__511 VSS VSS VDD VDD _unconnected_337 net512 sky130_fd_sc_hd__conb_1
X_3090__512 VSS VSS VDD VDD _unconnected_338 net513 sky130_fd_sc_hd__conb_1
X_3091__513 VSS VSS VDD VDD _unconnected_339 net514 sky130_fd_sc_hd__conb_1
X_3092__514 VSS VSS VDD VDD _unconnected_340 net515 sky130_fd_sc_hd__conb_1
X_3093__515 VSS VSS VDD VDD _unconnected_341 net516 sky130_fd_sc_hd__conb_1
X_3094__516 VSS VSS VDD VDD _unconnected_342 net517 sky130_fd_sc_hd__conb_1
X_3095__517 VSS VSS VDD VDD _unconnected_343 net518 sky130_fd_sc_hd__conb_1
X_3096__518 VSS VSS VDD VDD _unconnected_344 net519 sky130_fd_sc_hd__conb_1
X_3097__519 VSS VSS VDD VDD _unconnected_345 net520 sky130_fd_sc_hd__conb_1
X_3098__520 VSS VSS VDD VDD _unconnected_346 net521 sky130_fd_sc_hd__conb_1
X_3099__521 VSS VSS VDD VDD _unconnected_347 net522 sky130_fd_sc_hd__conb_1
X_3100__522 VSS VSS VDD VDD _unconnected_348 net523 sky130_fd_sc_hd__conb_1
X_3101__523 VSS VSS VDD VDD _unconnected_349 net524 sky130_fd_sc_hd__conb_1
X_3102__524 VSS VSS VDD VDD _unconnected_350 net525 sky130_fd_sc_hd__conb_1
X_3103__525 VSS VSS VDD VDD _unconnected_351 net526 sky130_fd_sc_hd__conb_1
X_3104__526 VSS VSS VDD VDD _unconnected_352 net527 sky130_fd_sc_hd__conb_1
X_3105__527 VSS VSS VDD VDD _unconnected_353 net528 sky130_fd_sc_hd__conb_1
X_3106__528 VSS VSS VDD VDD _unconnected_354 net529 sky130_fd_sc_hd__conb_1
X_3107__529 VSS VSS VDD VDD _unconnected_355 net530 sky130_fd_sc_hd__conb_1
X_3108__530 VSS VSS VDD VDD _unconnected_356 net531 sky130_fd_sc_hd__conb_1
X_3109__531 VSS VSS VDD VDD _unconnected_357 net532 sky130_fd_sc_hd__conb_1
X_3110__532 VSS VSS VDD VDD _unconnected_358 net533 sky130_fd_sc_hd__conb_1
X_3111__533 VSS VSS VDD VDD _unconnected_359 net534 sky130_fd_sc_hd__conb_1
X_3112__534 VSS VSS VDD VDD _unconnected_360 net535 sky130_fd_sc_hd__conb_1
X_3113__535 VSS VSS VDD VDD _unconnected_361 net536 sky130_fd_sc_hd__conb_1
X_3114__536 VSS VSS VDD VDD _unconnected_362 net537 sky130_fd_sc_hd__conb_1
X_3115__537 VSS VSS VDD VDD _unconnected_363 net538 sky130_fd_sc_hd__conb_1
X_3116__538 VSS VSS VDD VDD _unconnected_364 net539 sky130_fd_sc_hd__conb_1
X_3117__539 VSS VSS VDD VDD _unconnected_365 net540 sky130_fd_sc_hd__conb_1
X_3118__540 VSS VSS VDD VDD _unconnected_366 net541 sky130_fd_sc_hd__conb_1
X_3119__541 VSS VSS VDD VDD _unconnected_367 net542 sky130_fd_sc_hd__conb_1
X_3120__542 VSS VSS VDD VDD _unconnected_368 net543 sky130_fd_sc_hd__conb_1
X_3121__543 VSS VSS VDD VDD _unconnected_369 net544 sky130_fd_sc_hd__conb_1
X_3122__544 VSS VSS VDD VDD _unconnected_370 net545 sky130_fd_sc_hd__conb_1
X_3123__545 VSS VSS VDD VDD _unconnected_371 net546 sky130_fd_sc_hd__conb_1
X_3124__546 VSS VSS VDD VDD _unconnected_372 net547 sky130_fd_sc_hd__conb_1
X_3125__547 VSS VSS VDD VDD _unconnected_373 net548 sky130_fd_sc_hd__conb_1
X_3126__548 VSS VSS VDD VDD _unconnected_374 net549 sky130_fd_sc_hd__conb_1
X_3127__549 VSS VSS VDD VDD _unconnected_375 net550 sky130_fd_sc_hd__conb_1
X_3128__550 VSS VSS VDD VDD _unconnected_376 net551 sky130_fd_sc_hd__conb_1
X_3129__551 VSS VSS VDD VDD _unconnected_377 net552 sky130_fd_sc_hd__conb_1
X_3130__552 VSS VSS VDD VDD _unconnected_378 net553 sky130_fd_sc_hd__conb_1
X_3131__553 VSS VSS VDD VDD _unconnected_379 net554 sky130_fd_sc_hd__conb_1
X_3132__554 VSS VSS VDD VDD _unconnected_380 net555 sky130_fd_sc_hd__conb_1
X_3133__555 VSS VSS VDD VDD _unconnected_381 net556 sky130_fd_sc_hd__conb_1
X_3134__556 VSS VSS VDD VDD _unconnected_382 net557 sky130_fd_sc_hd__conb_1
X_3135__557 VSS VSS VDD VDD _unconnected_383 net558 sky130_fd_sc_hd__conb_1
X_3136__558 VSS VSS VDD VDD _unconnected_384 net559 sky130_fd_sc_hd__conb_1
X_3137__559 VSS VSS VDD VDD _unconnected_385 net560 sky130_fd_sc_hd__conb_1
X_3138__560 VSS VSS VDD VDD _unconnected_386 net561 sky130_fd_sc_hd__conb_1
X_3139__561 VSS VSS VDD VDD _unconnected_387 net562 sky130_fd_sc_hd__conb_1
X_3140__562 VSS VSS VDD VDD _unconnected_388 net563 sky130_fd_sc_hd__conb_1
X_3141__563 VSS VSS VDD VDD _unconnected_389 net564 sky130_fd_sc_hd__conb_1
X_3142__564 VSS VSS VDD VDD _unconnected_390 net565 sky130_fd_sc_hd__conb_1
X_3143__565 VSS VSS VDD VDD _unconnected_391 net566 sky130_fd_sc_hd__conb_1
X_3144__566 VSS VSS VDD VDD _unconnected_392 net567 sky130_fd_sc_hd__conb_1
X_3145__567 VSS VSS VDD VDD _unconnected_393 net568 sky130_fd_sc_hd__conb_1
X_3146__568 VSS VSS VDD VDD _unconnected_394 net569 sky130_fd_sc_hd__conb_1
X_3147__569 VSS VSS VDD VDD _unconnected_395 net570 sky130_fd_sc_hd__conb_1
X_3148__570 VSS VSS VDD VDD _unconnected_396 net571 sky130_fd_sc_hd__conb_1
X_3149__571 VSS VSS VDD VDD _unconnected_397 net572 sky130_fd_sc_hd__conb_1
X_3150__572 VSS VSS VDD VDD _unconnected_398 net573 sky130_fd_sc_hd__conb_1
X_3151__573 VSS VSS VDD VDD _unconnected_399 net574 sky130_fd_sc_hd__conb_1
X_3152__574 VSS VSS VDD VDD _unconnected_400 net575 sky130_fd_sc_hd__conb_1
X_3153__575 VSS VSS VDD VDD _unconnected_401 net576 sky130_fd_sc_hd__conb_1
X_3154__576 VSS VSS VDD VDD _unconnected_402 net577 sky130_fd_sc_hd__conb_1
X_3155__577 VSS VSS VDD VDD _unconnected_403 net578 sky130_fd_sc_hd__conb_1
X_3156__578 VSS VSS VDD VDD _unconnected_404 net579 sky130_fd_sc_hd__conb_1
X_3157__579 VSS VSS VDD VDD _unconnected_405 net580 sky130_fd_sc_hd__conb_1
X_3158__580 VSS VSS VDD VDD _unconnected_406 net581 sky130_fd_sc_hd__conb_1
X_3159__581 VSS VSS VDD VDD _unconnected_407 net582 sky130_fd_sc_hd__conb_1
X_3160__582 VSS VSS VDD VDD _unconnected_408 net583 sky130_fd_sc_hd__conb_1
X_3161__583 VSS VSS VDD VDD _unconnected_409 net584 sky130_fd_sc_hd__conb_1
X_3162__584 VSS VSS VDD VDD _unconnected_410 net585 sky130_fd_sc_hd__conb_1
X_3163__585 VSS VSS VDD VDD _unconnected_411 net586 sky130_fd_sc_hd__conb_1
X_3164__586 VSS VSS VDD VDD _unconnected_412 net587 sky130_fd_sc_hd__conb_1
X_3165__587 VSS VSS VDD VDD _unconnected_413 net588 sky130_fd_sc_hd__conb_1
X_3166__588 VSS VSS VDD VDD _unconnected_414 net589 sky130_fd_sc_hd__conb_1
X_3167__589 VSS VSS VDD VDD _unconnected_415 net590 sky130_fd_sc_hd__conb_1
X_3168__590 VSS VSS VDD VDD _unconnected_416 net591 sky130_fd_sc_hd__conb_1
X_3169__591 VSS VSS VDD VDD _unconnected_417 net592 sky130_fd_sc_hd__conb_1
X_3170__592 VSS VSS VDD VDD _unconnected_418 net593 sky130_fd_sc_hd__conb_1
X_3171__593 VSS VSS VDD VDD _unconnected_419 net594 sky130_fd_sc_hd__conb_1
X_3172__594 VSS VSS VDD VDD _unconnected_420 net595 sky130_fd_sc_hd__conb_1
X_3173__595 VSS VSS VDD VDD _unconnected_421 net596 sky130_fd_sc_hd__conb_1
X_3174__596 VSS VSS VDD VDD _unconnected_422 net597 sky130_fd_sc_hd__conb_1
X_3175__597 VSS VSS VDD VDD _unconnected_423 net598 sky130_fd_sc_hd__conb_1
X_3176__598 VSS VSS VDD VDD _unconnected_424 net599 sky130_fd_sc_hd__conb_1
X_3177__599 VSS VSS VDD VDD _unconnected_425 net600 sky130_fd_sc_hd__conb_1
X_3178__600 VSS VSS VDD VDD _unconnected_426 net601 sky130_fd_sc_hd__conb_1
X_3179__601 VSS VSS VDD VDD _unconnected_427 net602 sky130_fd_sc_hd__conb_1
X_3180__602 VSS VSS VDD VDD _unconnected_428 net603 sky130_fd_sc_hd__conb_1
X_3181__603 VSS VSS VDD VDD _unconnected_429 net604 sky130_fd_sc_hd__conb_1
X_3182__604 VSS VSS VDD VDD _unconnected_430 net605 sky130_fd_sc_hd__conb_1
X_3183__605 VSS VSS VDD VDD _unconnected_431 net606 sky130_fd_sc_hd__conb_1
X_3184__606 VSS VSS VDD VDD _unconnected_432 net607 sky130_fd_sc_hd__conb_1
X_3185__607 VSS VSS VDD VDD _unconnected_433 net608 sky130_fd_sc_hd__conb_1
X_3186__608 VSS VSS VDD VDD _unconnected_434 net609 sky130_fd_sc_hd__conb_1
X_3187__609 VSS VSS VDD VDD _unconnected_435 net610 sky130_fd_sc_hd__conb_1
X_3188__610 VSS VSS VDD VDD _unconnected_436 net611 sky130_fd_sc_hd__conb_1
X_3189__611 VSS VSS VDD VDD _unconnected_437 net612 sky130_fd_sc_hd__conb_1
X_3190__612 VSS VSS VDD VDD _unconnected_438 net613 sky130_fd_sc_hd__conb_1
X_3191__613 VSS VSS VDD VDD _unconnected_439 net614 sky130_fd_sc_hd__conb_1
X_3192__614 VSS VSS VDD VDD _unconnected_440 net615 sky130_fd_sc_hd__conb_1
X_3193__615 VSS VSS VDD VDD _unconnected_441 net616 sky130_fd_sc_hd__conb_1
X_3194__616 VSS VSS VDD VDD _unconnected_442 net617 sky130_fd_sc_hd__conb_1
X_3195__617 VSS VSS VDD VDD _unconnected_443 net618 sky130_fd_sc_hd__conb_1
X_3196__618 VSS VSS VDD VDD _unconnected_444 net619 sky130_fd_sc_hd__conb_1
X_3197__619 VSS VSS VDD VDD _unconnected_445 net620 sky130_fd_sc_hd__conb_1
X_3198__620 VSS VSS VDD VDD _unconnected_446 net621 sky130_fd_sc_hd__conb_1
X_3199__621 VSS VSS VDD VDD _unconnected_447 net622 sky130_fd_sc_hd__conb_1
X_3200__622 VSS VSS VDD VDD _unconnected_448 net623 sky130_fd_sc_hd__conb_1
X_3201__623 VSS VSS VDD VDD _unconnected_449 net624 sky130_fd_sc_hd__conb_1
X_3202__624 VSS VSS VDD VDD _unconnected_450 net625 sky130_fd_sc_hd__conb_1
X_3203__625 VSS VSS VDD VDD _unconnected_451 net626 sky130_fd_sc_hd__conb_1
X_3204__626 VSS VSS VDD VDD _unconnected_452 net627 sky130_fd_sc_hd__conb_1
X_3205__627 VSS VSS VDD VDD _unconnected_453 net628 sky130_fd_sc_hd__conb_1
X_3206__628 VSS VSS VDD VDD _unconnected_454 net629 sky130_fd_sc_hd__conb_1
X_3207__629 VSS VSS VDD VDD _unconnected_455 net630 sky130_fd_sc_hd__conb_1
X_3208__630 VSS VSS VDD VDD _unconnected_456 net631 sky130_fd_sc_hd__conb_1
X_3209__631 VSS VSS VDD VDD _unconnected_457 net632 sky130_fd_sc_hd__conb_1
X_3210__632 VSS VSS VDD VDD _unconnected_458 net633 sky130_fd_sc_hd__conb_1
X_3211__633 VSS VSS VDD VDD _unconnected_459 net634 sky130_fd_sc_hd__conb_1
X_3212__634 VSS VSS VDD VDD _unconnected_460 net635 sky130_fd_sc_hd__conb_1
X_3213__635 VSS VSS VDD VDD _unconnected_461 net636 sky130_fd_sc_hd__conb_1
X_3214__636 VSS VSS VDD VDD _unconnected_462 net637 sky130_fd_sc_hd__conb_1
X_3215__637 VSS VSS VDD VDD _unconnected_463 net638 sky130_fd_sc_hd__conb_1
X_3216__638 VSS VSS VDD VDD _unconnected_464 net639 sky130_fd_sc_hd__conb_1
X_3217__639 VSS VSS VDD VDD _unconnected_465 net640 sky130_fd_sc_hd__conb_1
X_3218__640 VSS VSS VDD VDD _unconnected_466 net641 sky130_fd_sc_hd__conb_1
X_3219__641 VSS VSS VDD VDD _unconnected_467 net642 sky130_fd_sc_hd__conb_1
X_3220__642 VSS VSS VDD VDD _unconnected_468 net643 sky130_fd_sc_hd__conb_1
X_3221__643 VSS VSS VDD VDD _unconnected_469 net644 sky130_fd_sc_hd__conb_1
X_3222__644 VSS VSS VDD VDD _unconnected_470 net645 sky130_fd_sc_hd__conb_1
X_3223__645 VSS VSS VDD VDD _unconnected_471 net646 sky130_fd_sc_hd__conb_1
X_3224__646 VSS VSS VDD VDD _unconnected_472 net647 sky130_fd_sc_hd__conb_1
X_3225__647 VSS VSS VDD VDD _unconnected_473 net648 sky130_fd_sc_hd__conb_1
X_3226__648 VSS VSS VDD VDD _unconnected_474 net649 sky130_fd_sc_hd__conb_1
X_3227__649 VSS VSS VDD VDD _unconnected_475 net650 sky130_fd_sc_hd__conb_1
X_3228__650 VSS VSS VDD VDD _unconnected_476 net651 sky130_fd_sc_hd__conb_1
X_3229__651 VSS VSS VDD VDD _unconnected_477 net652 sky130_fd_sc_hd__conb_1
X_3230__652 VSS VSS VDD VDD _unconnected_478 net653 sky130_fd_sc_hd__conb_1
X_3231__653 VSS VSS VDD VDD _unconnected_479 net654 sky130_fd_sc_hd__conb_1
X_3232__654 VSS VSS VDD VDD _unconnected_480 net655 sky130_fd_sc_hd__conb_1
X_3233__655 VSS VSS VDD VDD _unconnected_481 net656 sky130_fd_sc_hd__conb_1
X_3234__656 VSS VSS VDD VDD _unconnected_482 net657 sky130_fd_sc_hd__conb_1
X_3235__657 VSS VSS VDD VDD _unconnected_483 net658 sky130_fd_sc_hd__conb_1
X_3236__658 VSS VSS VDD VDD _unconnected_484 net659 sky130_fd_sc_hd__conb_1
X_3237__659 VSS VSS VDD VDD _unconnected_485 net660 sky130_fd_sc_hd__conb_1
X_3238__660 VSS VSS VDD VDD _unconnected_486 net661 sky130_fd_sc_hd__conb_1
X_3239__661 VSS VSS VDD VDD _unconnected_487 net662 sky130_fd_sc_hd__conb_1
X_3240__662 VSS VSS VDD VDD _unconnected_488 net663 sky130_fd_sc_hd__conb_1
X_3241__663 VSS VSS VDD VDD _unconnected_489 net664 sky130_fd_sc_hd__conb_1
X_3242__664 VSS VSS VDD VDD _unconnected_490 net665 sky130_fd_sc_hd__conb_1
X_3243__665 VSS VSS VDD VDD _unconnected_491 net666 sky130_fd_sc_hd__conb_1
X_3244__666 VSS VSS VDD VDD _unconnected_492 net667 sky130_fd_sc_hd__conb_1
X_3245__667 VSS VSS VDD VDD _unconnected_493 net668 sky130_fd_sc_hd__conb_1
X_3246__668 VSS VSS VDD VDD _unconnected_494 net669 sky130_fd_sc_hd__conb_1
X_3247__669 VSS VSS VDD VDD _unconnected_495 net670 sky130_fd_sc_hd__conb_1
X_3248__670 VSS VSS VDD VDD _unconnected_496 net671 sky130_fd_sc_hd__conb_1
X_3249__671 VSS VSS VDD VDD _unconnected_497 net672 sky130_fd_sc_hd__conb_1
X_3250__672 VSS VSS VDD VDD _unconnected_498 net673 sky130_fd_sc_hd__conb_1
X_3251__673 VSS VSS VDD VDD _unconnected_499 net674 sky130_fd_sc_hd__conb_1
X_3252__674 VSS VSS VDD VDD _unconnected_500 net675 sky130_fd_sc_hd__conb_1
X_3253__675 VSS VSS VDD VDD _unconnected_501 net676 sky130_fd_sc_hd__conb_1
X_3254__676 VSS VSS VDD VDD _unconnected_502 net677 sky130_fd_sc_hd__conb_1
X_3255__677 VSS VSS VDD VDD _unconnected_503 net678 sky130_fd_sc_hd__conb_1
X_3256__678 VSS VSS VDD VDD _unconnected_504 net679 sky130_fd_sc_hd__conb_1
X_3257__679 VSS VSS VDD VDD _unconnected_505 net680 sky130_fd_sc_hd__conb_1
X_3258__680 VSS VSS VDD VDD _unconnected_506 net681 sky130_fd_sc_hd__conb_1
X_3259__681 VSS VSS VDD VDD _unconnected_507 net682 sky130_fd_sc_hd__conb_1
X_3260__682 VSS VSS VDD VDD _unconnected_508 net683 sky130_fd_sc_hd__conb_1
X_3261__683 VSS VSS VDD VDD _unconnected_509 net684 sky130_fd_sc_hd__conb_1
X_3262__684 VSS VSS VDD VDD _unconnected_510 net685 sky130_fd_sc_hd__conb_1
X_3263__685 VSS VSS VDD VDD _unconnected_511 net686 sky130_fd_sc_hd__conb_1
X_3264__686 VSS VSS VDD VDD _unconnected_512 net687 sky130_fd_sc_hd__conb_1
X_3265__687 VSS VSS VDD VDD _unconnected_513 net688 sky130_fd_sc_hd__conb_1
X_3266__688 VSS VSS VDD VDD _unconnected_514 net689 sky130_fd_sc_hd__conb_1
X_3267__689 VSS VSS VDD VDD _unconnected_515 net690 sky130_fd_sc_hd__conb_1
X_3268__690 VSS VSS VDD VDD _unconnected_516 net691 sky130_fd_sc_hd__conb_1
X_3269__691 VSS VSS VDD VDD _unconnected_517 net692 sky130_fd_sc_hd__conb_1
X_3270__692 VSS VSS VDD VDD _unconnected_518 net693 sky130_fd_sc_hd__conb_1
X_3271__693 VSS VSS VDD VDD _unconnected_519 net694 sky130_fd_sc_hd__conb_1
X_3272__694 VSS VSS VDD VDD _unconnected_520 net695 sky130_fd_sc_hd__conb_1
X_3273__695 VSS VSS VDD VDD _unconnected_521 net696 sky130_fd_sc_hd__conb_1
X_3274__696 VSS VSS VDD VDD _unconnected_522 net697 sky130_fd_sc_hd__conb_1
X_3275__697 VSS VSS VDD VDD _unconnected_523 net698 sky130_fd_sc_hd__conb_1
X_3276__698 VSS VSS VDD VDD _unconnected_524 net699 sky130_fd_sc_hd__conb_1
X_3277__699 VSS VSS VDD VDD _unconnected_525 net700 sky130_fd_sc_hd__conb_1
X_3278__700 VSS VSS VDD VDD _unconnected_526 net701 sky130_fd_sc_hd__conb_1
X_3279__701 VSS VSS VDD VDD _unconnected_527 net702 sky130_fd_sc_hd__conb_1
X_3280__702 VSS VSS VDD VDD _unconnected_528 net703 sky130_fd_sc_hd__conb_1
X_3281__703 VSS VSS VDD VDD _unconnected_529 net704 sky130_fd_sc_hd__conb_1
X_3282__704 VSS VSS VDD VDD _unconnected_530 net705 sky130_fd_sc_hd__conb_1
X_3283__705 VSS VSS VDD VDD _unconnected_531 net706 sky130_fd_sc_hd__conb_1
X_3284__706 VSS VSS VDD VDD _unconnected_532 net707 sky130_fd_sc_hd__conb_1
X_3285__707 VSS VSS VDD VDD _unconnected_533 net708 sky130_fd_sc_hd__conb_1
X_3286__708 VSS VSS VDD VDD _unconnected_534 net709 sky130_fd_sc_hd__conb_1
X_3287__709 VSS VSS VDD VDD _unconnected_535 net710 sky130_fd_sc_hd__conb_1
X_3288__710 VSS VSS VDD VDD _unconnected_536 net711 sky130_fd_sc_hd__conb_1
X_3289__711 VSS VSS VDD VDD _unconnected_537 net712 sky130_fd_sc_hd__conb_1
X_3290__712 VSS VSS VDD VDD _unconnected_538 net713 sky130_fd_sc_hd__conb_1
X_3291__713 VSS VSS VDD VDD _unconnected_539 net714 sky130_fd_sc_hd__conb_1
Xclkbuf_4_0_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_0_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_1_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_1_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_2_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_2_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_3_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_3_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_4_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_4_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_5_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_5_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_6_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_6_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_7_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_7_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_8_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_8_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_9_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_9_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_10_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_10_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_11_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_11_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_12_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_12_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_13_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_13_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_14_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_14_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_4_15_0_clk clknet_0_clk VSS VSS VDD VDD clknet_4_15_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_4_0_0_clk VSS VSS VDD VDD _unconnected_540
+ sky130_fd_sc_hd__inv_12
Xclkload1 clknet_4_1_0_clk VSS VSS VDD VDD _unconnected_541
+ sky130_fd_sc_hd__inv_12
Xclkload2 clknet_4_2_0_clk VSS VSS VDD VDD _unconnected_542
+ sky130_fd_sc_hd__inv_12
Xclkload3 clknet_4_3_0_clk VSS VSS VDD VDD _unconnected_543
+ sky130_fd_sc_hd__clkinv_8
Xclkload4 clknet_4_4_0_clk VSS VSS VDD VDD _unconnected_544
+ sky130_fd_sc_hd__clkinv_8
Xclkload5 clknet_4_5_0_clk VSS VSS VDD VDD _unconnected_545
+ sky130_fd_sc_hd__inv_12
Xclkload6 clknet_4_6_0_clk VSS VSS VDD VDD _unconnected_546
+ sky130_fd_sc_hd__clkinv_8
Xclkload7 clknet_4_7_0_clk VSS VSS VDD VDD _unconnected_547
+ sky130_fd_sc_hd__inv_6
Xclkload8 clknet_4_8_0_clk VSS VSS VDD VDD _unconnected_548
+ sky130_fd_sc_hd__clkinv_8
Xclkload9 clknet_4_9_0_clk VSS VSS VDD VDD _unconnected_549
+ sky130_fd_sc_hd__clkinv_8
Xclkload10 clknet_4_10_0_clk VSS VSS VDD VDD _unconnected_550
+ sky130_fd_sc_hd__inv_8
Xclkload11 clknet_4_11_0_clk VSS VSS VDD VDD _unconnected_551
+ sky130_fd_sc_hd__clkinv_8
Xclkload12 clknet_4_12_0_clk VSS VSS VDD VDD _unconnected_552
+ sky130_fd_sc_hd__inv_8
Xclkload13 clknet_4_13_0_clk VSS VSS VDD VDD _unconnected_553
+ sky130_fd_sc_hd__inv_6
Xclkload14 clknet_4_15_0_clk VSS VSS VDD VDD _unconnected_554
+ sky130_fd_sc_hd__inv_8
XANTENNA_1 _0144_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 net1 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 net70 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 net167 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 net168 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 net169 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_7 net172 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_8 net173 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_9 net174 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_10 net1 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_11 net1 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_12 net1 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_13 net1 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_14 _1442_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS dma_controller
