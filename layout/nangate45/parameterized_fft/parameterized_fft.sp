* cell parameterized_fft
* pin data_out_imag[101]
* pin data_out_imag[116]
* pin data_out_imag[117]
* pin data_out_imag[115]
* pin data_out_imag[114]
* pin data_out_imag[111]
* pin data_valid_in
* pin start
* pin data_valid_out
* pin rst_n
* pin data_ready
* pin busy
* pin data_out_real[95]
* pin data_out_real[9]
* pin PWELL
* pin NWELL
* pin data_out_imag[104]
* pin data_out_imag[0]
* pin data_out_imag[105]
* pin data_out_imag[102]
* pin data_out_imag[107]
* pin data_out_imag[100]
* pin data_out_imag[103]
* pin data_out_imag[106]
* pin data_out_imag[10]
* pin data_out_real[96]
* pin data_out_real[99]
* pin data_out_imag[109]
* pin data_out_imag[110]
* pin data_out_imag[108]
* pin data_out_real[97]
* pin data_out_imag[112]
* pin data_out_real[94]
* pin data_out_imag[113]
* pin data_out_real[90]
* pin data_out_real[8]
* pin data_out_real[89]
* pin data_out_imag[11]
* pin data_out_real[93]
* pin data_out_imag[118]
* pin data_out_imag[119]
* pin data_out_real[98]
* pin data_out_imag[120]
* pin data_out_imag[121]
* pin data_out_imag[123]
* pin data_in_real[4]
* pin data_in_imag[11]
* pin data_in_imag[7]
* pin data_out_imag[124]
* pin data_in_imag[4]
* pin data_in_imag[8]
* pin data_in_imag[6]
* pin data_in_imag[12]
* pin data_in_imag[14]
* pin data_in_real[9]
* pin data_in_real[8]
* pin data_in_real[5]
* pin data_in_real[7]
* pin data_in_imag[1]
* pin data_in_real[6]
* pin clk
* pin data_out_imag[125]
* pin data_out_imag[122]
* pin data_in_imag[2]
* pin data_in_imag[3]
* pin data_in_real[2]
* pin data_in_real[15]
* pin data_in_imag[15]
* pin data_in_imag[13]
* pin data_in_imag[10]
* pin data_in_imag[0]
* pin data_in_imag[9]
* pin data_in_imag[5]
* pin data_out_imag[73]
* pin data_out_imag[6]
* pin data_out_imag[70]
* pin data_out_imag[71]
* pin data_out_imag[68]
* pin data_out_imag[72]
* pin data_out_imag[69]
* pin data_out_imag[67]
* pin data_out_imag[66]
* pin data_out_imag[74]
* pin data_out_imag[77]
* pin data_out_imag[75]
* pin data_out_imag[76]
* pin data_out_imag[78]
* pin data_out_imag[79]
* pin data_out_imag[82]
* pin data_out_imag[65]
* pin data_out_imag[7]
* pin data_out_imag[81]
* pin data_out_imag[80]
* pin data_out_imag[98]
* pin data_out_imag[99]
* pin data_out_imag[83]
* pin data_out_imag[97]
* pin data_out_imag[86]
* pin data_out_imag[84]
* pin data_out_imag[85]
* pin data_out_imag[89]
* pin data_out_imag[90]
* pin data_out_imag[87]
* pin data_out_imag[92]
* pin data_out_imag[93]
* pin data_out_imag[95]
* pin data_out_imag[91]
* pin data_out_imag[88]
* pin data_out_imag[8]
* pin data_out_imag[64]
* pin data_out_imag[94]
* pin data_out_imag[5]
* pin data_out_imag[60]
* pin data_out_imag[61]
* pin data_out_imag[63]
* pin data_out_imag[62]
* pin data_out_imag[57]
* pin data_out_imag[59]
* pin data_out_real[44]
* pin data_out_real[10]
* pin data_out_real[78]
* pin data_out_imag[12]
* pin data_out_real[75]
* pin data_out_real[58]
* pin data_out_real[60]
* pin data_out_imag[24]
* pin data_out_imag[41]
* pin data_out_real[112]
* pin data_out_real[102]
* pin data_out_imag[16]
* pin data_out_real[0]
* pin data_out_real[79]
* pin data_out_real[69]
* pin data_in_real[10]
* pin data_out_real[62]
* pin data_out_real[63]
* pin data_out_real[91]
* pin data_in_real[14]
* pin data_in_real[12]
* pin data_out_real[72]
* pin data_out_imag[58]
* pin data_out_real[6]
* pin data_out_real[87]
* pin data_out_imag[56]
* pin data_out_real[61]
* pin data_out_imag[126]
* pin data_out_imag[13]
* pin data_out_imag[127]
* pin data_out_real[5]
* pin data_out_imag[27]
* pin data_out_real[86]
* pin data_out_real[113]
* pin data_out_imag[43]
* pin data_out_imag[26]
* pin data_out_imag[28]
* pin data_out_real[115]
* pin data_out_real[64]
* pin data_out_real[105]
* pin data_out_imag[25]
* pin data_out_imag[42]
* pin data_out_real[101]
* pin data_out_real[85]
* pin data_out_imag[45]
* pin data_out_real[117]
* pin data_out_real[68]
* pin data_out_imag[23]
* pin data_out_imag[54]
* pin data_out_imag[40]
* pin data_out_real[114]
* pin data_out_real[82]
* pin data_out_imag[29]
* pin data_out_real[104]
* pin data_out_real[109]
* pin data_out_imag[9]
* pin data_out_imag[39]
* pin data_out_imag[55]
* pin data_out_real[103]
* pin data_out_imag[30]
* pin data_out_real[108]
* pin data_out_real[116]
* pin data_out_imag[14]
* pin data_out_imag[46]
* pin data_out_real[7]
* pin data_out_imag[38]
* pin data_out_real[76]
* pin data_out_imag[22]
* pin data_out_real[110]
* pin data_out_imag[96]
* pin data_out_real[84]
* pin data_out_real[74]
* pin data_out_imag[37]
* pin data_out_imag[20]
* pin data_out_real[80]
* pin data_out_real[67]
* pin data_out_imag[21]
* pin data_out_real[121]
* pin data_out_imag[32]
* pin data_out_real[73]
* pin data_out_real[71]
* pin data_out_real[120]
* pin data_out_imag[52]
* pin data_out_real[11]
* pin data_out_imag[1]
* pin data_out_imag[4]
* pin data_out_imag[33]
* pin data_out_real[19]
* pin data_out_imag[3]
* pin data_out_imag[49]
* pin data_out_real[13]
* pin data_out_imag[53]
* pin data_out_real[125]
* pin data_out_imag[47]
* pin data_out_imag[48]
* pin data_out_real[14]
* pin data_out_imag[36]
* pin data_out_real[12]
* pin data_out_imag[51]
* pin data_out_imag[17]
* pin data_out_real[1]
* pin data_out_imag[50]
* pin data_out_real[16]
* pin data_out_imag[35]
* pin data_out_real[30]
* pin data_out_imag[19]
* pin data_out_real[18]
* pin data_out_imag[34]
* pin data_out_real[53]
* pin data_out_imag[31]
* pin data_out_real[49]
* pin data_out_imag[2]
* pin data_out_imag[15]
* pin data_out_real[33]
* pin data_out_real[29]
* pin data_out_imag[18]
* pin data_out_real[3]
* pin data_out_real[51]
* pin data_out_real[35]
* pin data_out_real[38]
* pin data_out_real[48]
* pin data_out_real[34]
* pin data_out_real[36]
* pin data_out_real[2]
* pin data_out_real[31]
* pin data_out_real[4]
* pin data_out_real[26]
* pin data_out_real[32]
* pin data_out_real[41]
* pin data_out_real[40]
* pin data_out_real[23]
* pin data_out_real[50]
* pin data_out_real[39]
* pin data_out_real[24]
* pin data_out_imag[44]
* pin data_out_real[47]
* pin data_out_real[25]
* pin data_out_real[22]
* pin data_out_real[57]
* pin data_out_real[54]
* pin data_out_real[55]
* pin data_out_real[56]
* pin data_in_real[0]
* pin data_in_real[3]
* pin data_out_real[42]
* pin data_in_real[11]
* pin data_out_real[52]
* pin data_in_real[1]
* pin data_out_real[21]
* pin data_out_real[28]
* pin data_out_real[37]
* pin data_in_real[13]
* pin data_out_real[46]
* pin data_out_real[20]
* pin data_out_real[27]
* pin data_out_real[45]
* pin data_out_real[43]
* pin data_out_real[123]
* pin data_out_real[83]
* pin data_out_real[122]
* pin data_out_real[92]
* pin data_out_real[17]
* pin data_out_real[15]
* pin data_out_real[126]
* pin data_out_real[127]
* pin data_out_real[124]
* pin data_out_real[65]
* pin data_out_real[77]
* pin data_out_real[59]
* pin data_out_real[70]
* pin data_out_real[106]
* pin data_out_real[81]
* pin data_out_real[118]
* pin data_out_real[111]
* pin data_out_real[107]
* pin data_out_real[88]
* pin data_out_real[66]
* pin data_out_real[119]
* pin data_out_real[100]
.SUBCKT parameterized_fft 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 27 4007 4008 4009
+ 4087 4088 4089 4207 4208 4802 4834 4835 4881 4882 4883 4923 4968 4997 5016
+ 5116 5160 5161 5182 5205 5235 5275 5276 5513 5514 5515 5620 5621 5685 5686
+ 5784 5785 5786 5856 5857 5931 5932 5933 6021 6022 6023 6119 6130 6131 6194
+ 6195 6196 6309 6310 6311 6387 6459 6460 6461 6526 6527 6613 6614 6666 6753
+ 6803 6804 6951 6952 7022 7104 7108 7267 7359 7360 7440 7532 7645 7646 7749
+ 7750 7848 7849 7920 7998 7999 8186 8187 8302 8399 8493 8494 8495 8565 8566
+ 8655 8656 8730 8731 8912 8964 9034 9170 9221 9928 10076 10100 10101 10102
+ 10103 10104 10105 10106 10108 10111 10116 10117 10118 10119 10120 10122 10123
+ 10124 10125 10126 10127 10128 10129 10130 10131 10132 10133 10134 10135 10136
+ 10137 10138 10139 10140 10141 10142 10143 10144 10145 10146 10147 10148 10149
+ 10150 10151 10152 10153 10154 10155 10156 10157 10158 10159 10160 10161 10162
+ 10163 10164 10165 10166 10167 10168 10169 10170 10171 10172 10173 10174 10175
+ 10176 10177 10178 10179 10180 10181 10182 10183 10184 10185 10186 10187 10188
+ 10189 10190 10191 10192 10193 10194 10195 10196 10197 10198 10199 10200 10201
+ 10202 10203 10204 10205 10206 10207 10208 10209 10210 10211 10212 10213 10214
+ 10215 10216 10217 10218 10219 10220 10221 10222 10223 10224 10225 10226 10227
+ 10228 10229 10230 10231 10232 10233 10234 10235 10236 10237 10238 10239 10240
+ 10241 10242 10243 10244 10245 10246 10247 10248 10249 10250 10251 10252 10253
+ 10254 10255 10256 10257 10258 10259 10260 10261 10262 10263 10264 10265 10266
+ 10267 10268 10269 10270 10271 10272 10273 10274 10275 10276 10277 10278 10279
+ 10280 10281 10282 10283 10284
* net 1 data_out_imag[101]
* net 2 data_out_imag[116]
* net 3 data_out_imag[117]
* net 4 data_out_imag[115]
* net 5 data_out_imag[114]
* net 6 data_out_imag[111]
* net 7 data_valid_in
* net 8 start
* net 9 data_valid_out
* net 10 rst_n
* net 11 data_ready
* net 12 busy
* net 13 data_out_real[95]
* net 14 data_out_real[9]
* net 15 PWELL
* net 27 NWELL
* net 4007 data_out_imag[104]
* net 4008 data_out_imag[0]
* net 4009 data_out_imag[105]
* net 4087 data_out_imag[102]
* net 4088 data_out_imag[107]
* net 4089 data_out_imag[100]
* net 4207 data_out_imag[103]
* net 4208 data_out_imag[106]
* net 4802 data_out_imag[10]
* net 4834 data_out_real[96]
* net 4835 data_out_real[99]
* net 4881 data_out_imag[109]
* net 4882 data_out_imag[110]
* net 4883 data_out_imag[108]
* net 4923 data_out_real[97]
* net 4968 data_out_imag[112]
* net 4997 data_out_real[94]
* net 5016 data_out_imag[113]
* net 5116 data_out_real[90]
* net 5160 data_out_real[8]
* net 5161 data_out_real[89]
* net 5182 data_out_imag[11]
* net 5205 data_out_real[93]
* net 5235 data_out_imag[118]
* net 5275 data_out_imag[119]
* net 5276 data_out_real[98]
* net 5513 data_out_imag[120]
* net 5514 data_out_imag[121]
* net 5515 data_out_imag[123]
* net 5620 data_in_real[4]
* net 5621 data_in_imag[11]
* net 5685 data_in_imag[7]
* net 5686 data_out_imag[124]
* net 5784 data_in_imag[4]
* net 5785 data_in_imag[8]
* net 5786 data_in_imag[6]
* net 5856 data_in_imag[12]
* net 5857 data_in_imag[14]
* net 5931 data_in_real[9]
* net 5932 data_in_real[8]
* net 5933 data_in_real[5]
* net 6021 data_in_real[7]
* net 6022 data_in_imag[1]
* net 6023 data_in_real[6]
* net 6119 clk
* net 6130 data_out_imag[125]
* net 6131 data_out_imag[122]
* net 6194 data_in_imag[2]
* net 6195 data_in_imag[3]
* net 6196 data_in_real[2]
* net 6309 data_in_real[15]
* net 6310 data_in_imag[15]
* net 6311 data_in_imag[13]
* net 6387 data_in_imag[10]
* net 6459 data_in_imag[0]
* net 6460 data_in_imag[9]
* net 6461 data_in_imag[5]
* net 6526 data_out_imag[73]
* net 6527 data_out_imag[6]
* net 6613 data_out_imag[70]
* net 6614 data_out_imag[71]
* net 6666 data_out_imag[68]
* net 6753 data_out_imag[72]
* net 6803 data_out_imag[69]
* net 6804 data_out_imag[67]
* net 6951 data_out_imag[66]
* net 6952 data_out_imag[74]
* net 7022 data_out_imag[77]
* net 7104 data_out_imag[75]
* net 7108 data_out_imag[76]
* net 7267 data_out_imag[78]
* net 7359 data_out_imag[79]
* net 7360 data_out_imag[82]
* net 7440 data_out_imag[65]
* net 7532 data_out_imag[7]
* net 7645 data_out_imag[81]
* net 7646 data_out_imag[80]
* net 7749 data_out_imag[98]
* net 7750 data_out_imag[99]
* net 7848 data_out_imag[83]
* net 7849 data_out_imag[97]
* net 7920 data_out_imag[86]
* net 7998 data_out_imag[84]
* net 7999 data_out_imag[85]
* net 8186 data_out_imag[89]
* net 8187 data_out_imag[90]
* net 8302 data_out_imag[87]
* net 8399 data_out_imag[92]
* net 8493 data_out_imag[93]
* net 8494 data_out_imag[95]
* net 8495 data_out_imag[91]
* net 8565 data_out_imag[88]
* net 8566 data_out_imag[8]
* net 8655 data_out_imag[64]
* net 8656 data_out_imag[94]
* net 8730 data_out_imag[5]
* net 8731 data_out_imag[60]
* net 8912 data_out_imag[61]
* net 8964 data_out_imag[63]
* net 9034 data_out_imag[62]
* net 9170 data_out_imag[57]
* net 9221 data_out_imag[59]
* net 9928 data_out_real[44]
* net 10076 data_out_real[10]
* net 10100 data_out_real[78]
* net 10101 data_out_imag[12]
* net 10102 data_out_real[75]
* net 10103 data_out_real[58]
* net 10104 data_out_real[60]
* net 10105 data_out_imag[24]
* net 10106 data_out_imag[41]
* net 10108 data_out_real[112]
* net 10111 data_out_real[102]
* net 10116 data_out_imag[16]
* net 10117 data_out_real[0]
* net 10118 data_out_real[79]
* net 10119 data_out_real[69]
* net 10120 data_in_real[10]
* net 10122 data_out_real[62]
* net 10123 data_out_real[63]
* net 10124 data_out_real[91]
* net 10125 data_in_real[14]
* net 10126 data_in_real[12]
* net 10127 data_out_real[72]
* net 10128 data_out_imag[58]
* net 10129 data_out_real[6]
* net 10130 data_out_real[87]
* net 10131 data_out_imag[56]
* net 10132 data_out_real[61]
* net 10133 data_out_imag[126]
* net 10134 data_out_imag[13]
* net 10135 data_out_imag[127]
* net 10136 data_out_real[5]
* net 10137 data_out_imag[27]
* net 10138 data_out_real[86]
* net 10139 data_out_real[113]
* net 10140 data_out_imag[43]
* net 10141 data_out_imag[26]
* net 10142 data_out_imag[28]
* net 10143 data_out_real[115]
* net 10144 data_out_real[64]
* net 10145 data_out_real[105]
* net 10146 data_out_imag[25]
* net 10147 data_out_imag[42]
* net 10148 data_out_real[101]
* net 10149 data_out_real[85]
* net 10150 data_out_imag[45]
* net 10151 data_out_real[117]
* net 10152 data_out_real[68]
* net 10153 data_out_imag[23]
* net 10154 data_out_imag[54]
* net 10155 data_out_imag[40]
* net 10156 data_out_real[114]
* net 10157 data_out_real[82]
* net 10158 data_out_imag[29]
* net 10159 data_out_real[104]
* net 10160 data_out_real[109]
* net 10161 data_out_imag[9]
* net 10162 data_out_imag[39]
* net 10163 data_out_imag[55]
* net 10164 data_out_real[103]
* net 10165 data_out_imag[30]
* net 10166 data_out_real[108]
* net 10167 data_out_real[116]
* net 10168 data_out_imag[14]
* net 10169 data_out_imag[46]
* net 10170 data_out_real[7]
* net 10171 data_out_imag[38]
* net 10172 data_out_real[76]
* net 10173 data_out_imag[22]
* net 10174 data_out_real[110]
* net 10175 data_out_imag[96]
* net 10176 data_out_real[84]
* net 10177 data_out_real[74]
* net 10178 data_out_imag[37]
* net 10179 data_out_imag[20]
* net 10180 data_out_real[80]
* net 10181 data_out_real[67]
* net 10182 data_out_imag[21]
* net 10183 data_out_real[121]
* net 10184 data_out_imag[32]
* net 10185 data_out_real[73]
* net 10186 data_out_real[71]
* net 10187 data_out_real[120]
* net 10188 data_out_imag[52]
* net 10189 data_out_real[11]
* net 10190 data_out_imag[1]
* net 10191 data_out_imag[4]
* net 10192 data_out_imag[33]
* net 10193 data_out_real[19]
* net 10194 data_out_imag[3]
* net 10195 data_out_imag[49]
* net 10196 data_out_real[13]
* net 10197 data_out_imag[53]
* net 10198 data_out_real[125]
* net 10199 data_out_imag[47]
* net 10200 data_out_imag[48]
* net 10201 data_out_real[14]
* net 10202 data_out_imag[36]
* net 10203 data_out_real[12]
* net 10204 data_out_imag[51]
* net 10205 data_out_imag[17]
* net 10206 data_out_real[1]
* net 10207 data_out_imag[50]
* net 10208 data_out_real[16]
* net 10209 data_out_imag[35]
* net 10210 data_out_real[30]
* net 10211 data_out_imag[19]
* net 10212 data_out_real[18]
* net 10213 data_out_imag[34]
* net 10214 data_out_real[53]
* net 10215 data_out_imag[31]
* net 10216 data_out_real[49]
* net 10217 data_out_imag[2]
* net 10218 data_out_imag[15]
* net 10219 data_out_real[33]
* net 10220 data_out_real[29]
* net 10221 data_out_imag[18]
* net 10222 data_out_real[3]
* net 10223 data_out_real[51]
* net 10224 data_out_real[35]
* net 10225 data_out_real[38]
* net 10226 data_out_real[48]
* net 10227 data_out_real[34]
* net 10228 data_out_real[36]
* net 10229 data_out_real[2]
* net 10230 data_out_real[31]
* net 10231 data_out_real[4]
* net 10232 data_out_real[26]
* net 10233 data_out_real[32]
* net 10234 data_out_real[41]
* net 10235 data_out_real[40]
* net 10236 data_out_real[23]
* net 10237 data_out_real[50]
* net 10238 data_out_real[39]
* net 10239 data_out_real[24]
* net 10240 data_out_imag[44]
* net 10241 data_out_real[47]
* net 10242 data_out_real[25]
* net 10243 data_out_real[22]
* net 10244 data_out_real[57]
* net 10245 data_out_real[54]
* net 10246 data_out_real[55]
* net 10247 data_out_real[56]
* net 10248 data_in_real[0]
* net 10249 data_in_real[3]
* net 10250 data_out_real[42]
* net 10251 data_in_real[11]
* net 10252 data_out_real[52]
* net 10253 data_in_real[1]
* net 10254 data_out_real[21]
* net 10255 data_out_real[28]
* net 10256 data_out_real[37]
* net 10257 data_in_real[13]
* net 10258 data_out_real[46]
* net 10259 data_out_real[20]
* net 10260 data_out_real[27]
* net 10261 data_out_real[45]
* net 10262 data_out_real[43]
* net 10263 data_out_real[123]
* net 10264 data_out_real[83]
* net 10265 data_out_real[122]
* net 10266 data_out_real[92]
* net 10267 data_out_real[17]
* net 10268 data_out_real[15]
* net 10269 data_out_real[126]
* net 10270 data_out_real[127]
* net 10271 data_out_real[124]
* net 10272 data_out_real[65]
* net 10273 data_out_real[77]
* net 10274 data_out_real[59]
* net 10275 data_out_real[70]
* net 10276 data_out_real[106]
* net 10277 data_out_real[81]
* net 10278 data_out_real[118]
* net 10279 data_out_real[111]
* net 10280 data_out_real[107]
* net 10281 data_out_real[88]
* net 10282 data_out_real[66]
* net 10283 data_out_real[119]
* net 10284 data_out_real[100]
* cell instance $2 r0 *1 49.97,1.4
X$2 29 15 27 1 BUF_X1
* cell instance $8 r0 *1 50.54,1.4
X$8 30 15 27 2 BUF_X1
* cell instance $14 r0 *1 51.3,1.4
X$14 33 15 27 3 BUF_X1
* cell instance $20 r0 *1 54.91,1.4
X$20 18 15 27 4 BUF_X1
* cell instance $26 r0 *1 56.05,1.4
X$26 34 15 27 5 BUF_X1
* cell instance $32 r0 *1 56.62,1.4
X$32 36 15 27 6 BUF_X1
* cell instance $38 r0 *1 69.35,1.4
X$38 7 15 27 16 BUF_X2
* cell instance $44 r0 *1 67.07,1.4
X$44 8 15 27 19 BUF_X2
* cell instance $50 r0 *1 67.83,1.4
X$50 38 15 27 9 BUF_X1
* cell instance $56 m0 *1 68.78,91
X$56 10 15 27 5285 BUF_X2
* cell instance $62 r0 *1 70.11,1.4
X$62 17 15 27 11 BUF_X1
* cell instance $68 r0 *1 70.68,1.4
X$68 39 15 27 12 BUF_X1
* cell instance $74 r0 *1 83.03,1.4
X$74 35 15 27 13 BUF_X1
* cell instance $80 r0 *1 82.46,1.4
X$80 37 15 27 14 BUF_X1
* cell instance $85 m0 *1 87.21,172.2
X$85 9220 15 27 CLKBUF_X1
* cell instance $86 m0 *1 83.6,172.2
X$86 15 9284 9220 10682 7868 27 DFF_X2
* cell instance $89 m0 *1 88.73,172.2
X$89 8515 9393 15 27 9564 NAND2_X1
* cell instance $93 m0 *1 91.77,172.2
X$93 8119 9471 15 27 9467 NAND2_X1
* cell instance $96 m0 *1 93.29,172.2
X$96 9528 9394 9395 15 9396 27 AOI21_X1
* cell instance $98 m0 *1 94.81,172.2
X$98 8122 9393 15 27 9397 NAND2_X1
* cell instance $101 m0 *1 97.66,172.2
X$101 8324 9393 15 27 9398 NAND2_X1
* cell instance $102 m0 *1 98.23,172.2
X$102 9528 9447 9398 15 9446 27 AOI21_X1
* cell instance $104 m0 *1 99.75,172.2
X$104 7096 9393 15 27 9470 NAND2_X1
* cell instance $108 r0 *1 83.6,172.2
X$108 15 10644 8209 9229 9220 27 DFF_X1
* cell instance $110 r0 *1 87.21,172.2
X$110 7868 9471 15 27 9466 NAND2_X1
* cell instance $113 r0 *1 91.2,172.2
X$113 8486 9393 15 27 9395 NAND2_X1
* cell instance $114 r0 *1 91.77,172.2
X$114 9528 9529 9467 15 9513 27 AOI21_X1
* cell instance $116 r0 *1 92.72,172.2
X$116 15 10585 9468 9396 9530 27 DFF_X1
* cell instance $118 r0 *1 96.14,172.2
X$118 15 10474 9514 9446 9232 27 DFF_X1
* cell instance $120 r0 *1 99.75,172.2
X$120 9528 9515 9470 15 9469 27 AOI21_X1
* cell instance $124 r0 *1 102.6,172.2
X$124 8420 15 27 9471 CLKBUF_X3
* cell instance $126 m0 *1 102.98,172.2
X$126 9297 9445 9295 15 9296 27 AOI21_X1
* cell instance $127 m0 *1 105.26,172.2
X$127 9299 9301 15 27 9445 NAND2_X1
* cell instance $129 m0 *1 107.35,172.2
X$129 9399 9301 15 27 9444 NAND2_X1
* cell instance $131 m0 *1 109.44,172.2
X$131 9297 9442 9375 15 9443 27 AOI21_X1
* cell instance $132 m0 *1 110.2,172.2
X$132 15 10327 9401 9443 9400 27 DFF_X1
* cell instance $134 m0 *1 113.62,172.2
X$134 9401 9301 15 27 9442 NAND2_X1
* cell instance $137 r0 *1 103.74,172.2
X$137 8124 9393 15 27 9734 NAND2_X1
* cell instance $140 r0 *1 104.88,172.2
X$140 9297 9516 9298 15 9565 27 AOI21_X1
* cell instance $143 r0 *1 106.21,172.2
X$143 9533 9301 15 27 9516 NAND2_X1
* cell instance $146 r0 *1 108.68,172.2
X$146 9307 15 27 9297 CLKBUF_X3
* cell instance $148 r0 *1 110.01,172.2
X$148 8387 9471 15 27 9592 NAND2_X1
* cell instance $149 r0 *1 110.58,172.2
X$149 8524 9471 15 27 9472 NAND2_X1
* cell instance $150 r0 *1 111.15,172.2
X$150 8522 9471 15 27 9473 NAND2_X1
* cell instance $151 r0 *1 111.72,172.2
X$151 9309 15 27 9301 CLKBUF_X3
* cell instance $154 m0 *1 114.57,172.2
X$154 15 10326 9441 9303 9234 27 DFF_X1
* cell instance $164 r0 *1 121.41,172.2
X$164 15 10626 9402 9308 9234 27 DFF_X1
* cell instance $165 m0 *1 122.93,172.2
X$165 15 10386 9403 9388 9234 27 DFF_X1
* cell instance $171 m0 *1 126.54,172.2
X$171 15 10389 9373 9311 9404 27 DFF_X1
* cell instance $174 r0 *1 127.49,172.2
X$174 9309 15 27 9310 CLKBUF_X3
* cell instance $177 r0 *1 129.58,172.2
X$177 15 10492 9475 9440 9404 27 DFF_X1
* cell instance $178 m0 *1 130.34,172.2
X$178 9307 27 8060 15 BUF_X4
* cell instance $180 m0 *1 131.67,172.2
X$180 9241 9512 9312 15 9440 27 AOI21_X1
* cell instance $183 m0 *1 134.14,172.2
X$183 9309 15 27 8899 CLKBUF_X3
* cell instance $185 r0 *1 132.81,172.2
X$185 9475 9310 15 27 9512 NAND2_X1
* cell instance $186 r0 *1 133.38,172.2
X$186 15 10609 9476 9438 9404 27 DFF_X1
* cell instance $187 m0 *1 136.23,172.2
X$187 9120 9510 8859 15 9405 27 AOI21_X1
* cell instance $188 m0 *1 135.47,172.2
X$188 9120 9511 8897 15 9438 27 AOI21_X1
* cell instance $189 m0 *1 136.99,172.2
X$189 15 10302 9406 9405 9179 27 DFF_X1
* cell instance $191 r0 *1 136.61,172.2
X$191 9476 8899 15 27 9511 NAND2_X1
* cell instance $195 r0 *1 138.51,172.2
X$195 9406 8899 15 27 9510 NAND2_X1
* cell instance $199 r0 *1 140.41,172.2
X$199 15 10527 9409 9408 9316 27 DFF_X1
* cell instance $201 m0 *1 140.6,172.2
X$201 9241 9407 9239 15 9408 27 AOI21_X1
* cell instance $202 m0 *1 142.12,172.2
X$202 9431 9310 15 27 9436 NAND2_X1
* cell instance $203 m0 *1 142.69,172.2
X$203 9409 9310 15 27 9407 NAND2_X1
* cell instance $209 r0 *1 144.02,172.2
X$209 9316 15 27 CLKBUF_X1
* cell instance $211 r0 *1 147.63,172.2
X$211 9434 15 27 9507 INV_X1
* cell instance $212 r0 *1 148.01,172.2
X$212 15 9507 9506 9505 9508 9479 27 FA_X1
* cell instance $214 m0 *1 148.96,172.2
X$214 15 9317 9434 9410 9433 9430 27 FA_X1
* cell instance $216 r0 *1 151.05,172.2
X$216 9020 9477 9432 9505 15 27 9503 NAND4_X1
* cell instance $217 r0 *1 152,172.2
X$217 9410 8712 9503 15 27 9626 NOR3_X1
* cell instance $219 m0 *1 153.33,172.2
X$219 9429 9245 9430 27 15 9428 HA_X1
* cell instance $221 m0 *1 155.23,172.2
X$221 9427 15 27 9429 INV_X1
* cell instance $222 m0 *1 155.61,172.2
X$222 9428 15 27 9501 INV_X1
* cell instance $224 m0 *1 156.75,172.2
X$224 9426 15 27 9411 INV_X1
* cell instance $225 m0 *1 157.13,172.2
X$225 9319 9425 9426 27 15 9500 HA_X1
* cell instance $227 m0 *1 159.22,172.2
X$227 9413 15 27 9425 INV_X1
* cell instance $232 r0 *1 155.42,172.2
X$232 15 9501 9478 9479 9320 9606 27 FA_X1
* cell instance $235 r0 *1 159.03,172.2
X$235 7489 8830 9480 27 15 9549 HA_X1
* cell instance $237 m0 *1 161.69,172.2
X$237 9357 9412 9413 27 15 9424 HA_X1
* cell instance $242 m0 *1 167.58,172.2
X$242 9321 15 27 9484 INV_X1
* cell instance $243 m0 *1 167.96,172.2
X$243 9322 15 27 9496 INV_X1
* cell instance $246 r0 *1 161.88,172.2
X$246 9497 9413 9481 27 15 9675 HA_X1
* cell instance $247 r0 *1 163.78,172.2
X$247 7489 8829 9548 27 15 9495 HA_X1
* cell instance $248 r0 *1 165.68,172.2
X$248 9424 9356 9497 27 15 9483 HA_X1
* cell instance $249 r0 *1 167.58,172.2
X$249 8257 9496 9482 27 15 9494 HA_X1
* cell instance $250 m0 *1 168.91,172.2
X$250 9205 15 27 9422 INV_X1
* cell instance $255 m0 *1 174.04,172.2
X$255 9328 9327 9423 27 15 9489 HA_X1
* cell instance $260 r0 *1 170.24,172.2
X$260 15 9494 9491 9547 9354 9325 27 FA_X1
* cell instance $265 r0 *1 173.66,172.2
X$265 9491 15 27 9490 INV_X1
* cell instance $268 r0 *1 176.32,172.2
X$268 9489 9422 9541 27 15 9485 HA_X1
* cell instance $271 m0 *1 178.6,172.2
X$271 9414 9487 9420 27 9249 15 OAI21_X1
* cell instance $274 r0 *1 178.98,172.2
X$274 9417 9486 9611 27 15 9487 HA_X1
* cell instance $276 m0 *1 182.21,172.2
X$276 9339 15 27 9418 INV_X1
* cell instance $285 m0 *1 1.9,124.6
X$285 15 10329 6850 6996 6388 27 DFF_X1
* cell instance $288 m0 *1 5.32,124.6
X$288 6529 6918 6876 15 6996 27 AOI21_X1
* cell instance $295 r0 *1 2.09,124.6
X$295 6999 15 27 6951 BUF_X1
* cell instance $301 r0 *1 7.22,124.6
X$301 15 10506 6999 7070 6852 27 DFF_X1
* cell instance $302 m0 *1 8.17,124.6
X$302 6880 6877 6953 15 6879 27 AOI21_X1
* cell instance $307 m0 *1 11.4,124.6
X$307 6880 6806 6881 15 6878 27 AOI21_X1
* cell instance $308 m0 *1 12.16,124.6
X$308 6957 6882 15 27 6709 NAND2_X1
* cell instance $309 m0 *1 12.73,124.6
X$309 6885 6882 15 27 6644 NAND2_X1
* cell instance $310 m0 *1 13.3,124.6
X$310 6883 6882 15 27 6953 NAND2_X1
* cell instance $315 r0 *1 10.45,124.6
X$315 6999 6531 15 27 6954 NAND2_X1
* cell instance $317 r0 *1 11.4,124.6
X$317 6880 6954 7145 15 7070 27 AOI21_X1
* cell instance $318 r0 *1 12.16,124.6
X$318 7026 6882 15 27 6998 NAND2_X1
* cell instance $319 r0 *1 12.73,124.6
X$319 7073 6882 15 27 6876 NAND2_X1
* cell instance $320 r0 *1 13.3,124.6
X$320 6955 6882 15 27 6881 NAND2_X1
* cell instance $324 r0 *1 17.48,124.6
X$324 15 7028 27 7027 BUF_X8
* cell instance $326 m0 *1 19.57,124.6
X$326 7112 6193 6922 6623 6956 6884 15 27 OAI221_X2
* cell instance $329 m0 *1 26.98,124.6
X$329 15 6923 6537 10653 6026 27 DFF_X2
* cell instance $333 m0 *1 35.34,124.6
X$333 7006 6626 15 27 6958 NAND2_X1
* cell instance $334 m0 *1 35.91,124.6
X$334 6674 6733 6958 5689 6729 27 15 6929 OAI221_X1
* cell instance $335 m0 *1 37.05,124.6
X$335 6674 6676 7007 5697 6729 27 15 6930 OAI221_X1
* cell instance $336 m0 *1 38.19,124.6
X$336 6626 6931 15 27 7007 NAND2_X1
* cell instance $340 r0 *1 19.95,124.6
X$340 15 6884 7113 10756 6883 27 DFF_X2
* cell instance $343 r0 *1 32.68,124.6
X$343 6957 7027 15 27 7031 NAND2_X1
* cell instance $344 r0 *1 33.25,124.6
X$344 15 6929 6959 10766 7006 27 DFF_X2
* cell instance $345 r0 *1 36.86,124.6
X$345 15 6930 6959 10746 6931 27 DFF_X2
* cell instance $347 r0 *1 41.23,124.6
X$347 15 10630 6886 7008 6959 27 DFF_X1
* cell instance $348 m0 *1 41.61,124.6
X$348 6885 6626 15 27 6932 NAND2_X1
* cell instance $353 m0 *1 44.08,124.6
X$353 6755 6960 15 27 6935 NAND2_X1
* cell instance $354 m0 *1 44.84,124.6
X$354 15 6809 6810 10648 6960 27 DFF_X2
* cell instance $356 m0 *1 49.97,124.6
X$356 6810 15 27 CLKBUF_X1
* cell instance $359 m0 *1 56.81,124.6
X$359 6887 7035 2126 15 27 6248 AND3_X4
* cell instance $360 m0 *1 58.9,124.6
X$360 6887 15 27 6962 BUF_X2
* cell instance $361 m0 *1 59.66,124.6
X$361 6962 7041 6889 15 27 6888 NAND3_X1
* cell instance $365 r0 *1 49.02,124.6
X$365 6523 15 27 6810 CLKBUF_X3
* cell instance $366 r0 *1 49.97,124.6
X$366 5440 7036 7037 15 7091 27 NAND3_X4
* cell instance $368 r0 *1 52.63,124.6
X$368 7035 7009 15 6712 27 NAND2_X4
* cell instance $369 r0 *1 54.34,124.6
X$369 7036 15 27 7009 INV_X8
* cell instance $371 r0 *1 56.24,124.6
X$371 6961 15 27 7037 CLKBUF_X3
* cell instance $373 r0 *1 57.38,124.6
X$373 15 7036 27 6887 BUF_X8
* cell instance $377 r0 *1 59.85,124.6
X$377 7009 6383 15 27 7038 NAND2_X2
* cell instance $378 m0 *1 60.99,124.6
X$378 6116 6756 6890 15 27 6963 MUX2_X1
* cell instance $380 m0 *1 62.32,124.6
X$380 6277 6800 7039 27 6890 15 OAI21_X1
* cell instance $381 m0 *1 63.08,124.6
X$381 6800 5424 6889 15 27 6814 NAND3_X1
* cell instance $386 r0 *1 60.99,124.6
X$386 15 10491 7040 6963 7042 27 DFF_X1
* cell instance $390 r0 *1 66.88,124.6
X$390 6964 27 7099 15 BUF_X4
* cell instance $392 m0 *1 68.02,124.6
X$392 2126 27 6961 15 BUF_X4
* cell instance $394 m0 *1 70.3,124.6
X$394 6891 6942 6966 15 27 6887 MUX2_X1
* cell instance $395 m0 *1 71.63,124.6
X$395 6815 6402 15 27 6965 NOR2_X1
* cell instance $396 m0 *1 72.2,124.6
X$396 6548 6817 15 27 6966 NAND2_X1
* cell instance $397 m0 *1 72.77,124.6
X$397 6817 6403 15 27 7119 NAND2_X1
* cell instance $398 m0 *1 73.34,124.6
X$398 6892 6967 15 27 6891 NAND2_X1
* cell instance $400 m0 *1 74.1,124.6
X$400 6891 6966 6687 27 15 7102 MUX2_X2
* cell instance $401 m0 *1 75.81,124.6
X$401 5929 15 27 6967 INV_X1
* cell instance $404 m0 *1 78.47,124.6
X$404 6473 6818 6947 15 27 6968 MUX2_X1
* cell instance $405 m0 *1 79.8,124.6
X$405 6759 6970 6969 15 27 6949 NAND3_X1
* cell instance $406 m0 *1 80.56,124.6
X$406 6209 15 27 6948 CLKBUF_X3
* cell instance $407 m0 *1 81.51,124.6
X$407 6408 6948 15 27 6819 NAND2_X1
* cell instance $408 m0 *1 82.08,124.6
X$408 6949 6950 15 27 6947 NAND2_X1
* cell instance $411 r0 *1 68.21,124.6
X$411 15 6549 6401 6964 5510 7035 27 NAND4_X4
* cell instance $412 r0 *1 71.63,124.6
X$412 6548 6965 15 27 7100 NAND2_X1
* cell instance $413 r0 *1 72.2,124.6
X$413 6965 6403 15 27 7118 NAND2_X1
* cell instance $416 r0 *1 73.91,124.6
X$416 7046 5802 6967 15 27 7044 NAND3_X1
* cell instance $417 r0 *1 74.67,124.6
X$417 7046 5802 5929 15 27 7045 NAND3_X1
* cell instance $418 r0 *1 75.43,124.6
X$418 6207 5802 6967 15 27 7048 NAND3_X1
* cell instance $419 r0 *1 76.19,124.6
X$419 5802 15 27 7049 INV_X1
* cell instance $422 r0 *1 78.28,124.6
X$422 15 6968 6821 10810 6970 27 DFF_X2
* cell instance $424 r0 *1 82.65,124.6
X$424 6821 15 27 CLKBUF_X1
* cell instance $425 r0 *1 83.22,124.6
X$425 6408 6818 7101 15 27 6971 MUX2_X1
* cell instance $426 m0 *1 84.74,124.6
X$426 6822 6286 15 6802 27 NAND2_X4
* cell instance $428 m0 *1 86.45,124.6
X$428 6759 5451 6972 15 27 7017 NAND3_X1
* cell instance $429 m0 *1 87.21,124.6
X$429 6759 15 27 7016 BUF_X1
* cell instance $431 r0 *1 84.55,124.6
X$431 6413 15 27 6821 CLKBUF_X3
* cell instance $433 r0 *1 85.69,124.6
X$433 7017 7016 6631 27 15 7101 OAI21_X2
* cell instance $434 r0 *1 87.02,124.6
X$434 15 6895 27 6286 BUF_X8
* cell instance $436 m0 *1 88.16,124.6
X$436 6894 6286 15 6893 27 NAND2_X4
* cell instance $437 r0 *1 89.49,124.6
X$437 15 7018 6821 10803 7050 27 DFF_X2
* cell instance $438 m0 *1 90.44,124.6
X$438 6296 6146 6823 6142 6946 7018 15 27 OAI221_X2
* cell instance $440 m0 *1 92.53,124.6
X$440 7050 6895 15 6946 27 NAND2_X4
* cell instance $444 r0 *1 93.29,124.6
X$444 15 6974 27 6286 BUF_X8
* cell instance $445 m0 *1 95.57,124.6
X$445 6604 6385 6825 15 27 7021 MUX2_X1
* cell instance $449 r0 *1 96.52,124.6
X$449 6515 6146 7021 6948 7020 7052 15 27 OAI221_X2
* cell instance $451 m0 *1 97.28,124.6
X$451 6385 27 6973 15 BUF_X4
* cell instance $452 m0 *1 98.8,124.6
X$452 6746 6973 6897 15 27 7019 MUX2_X1
* cell instance $455 m0 *1 102.41,124.6
X$455 6566 6973 6944 15 27 6977 MUX2_X1
* cell instance $456 m0 *1 103.74,124.6
X$456 6475 6745 15 27 6944 NAND2_X1
* cell instance $457 m0 *1 104.31,124.6
X$457 6638 6973 6943 15 27 6979 MUX2_X1
* cell instance $460 m0 *1 106.59,124.6
X$460 6475 6659 15 27 7013 NAND2_X1
* cell instance $461 m0 *1 107.16,124.6
X$461 6637 6973 6898 15 27 6940 MUX2_X1
* cell instance $463 m0 *1 109.25,124.6
X$463 6948 6941 7011 6636 6729 27 15 6937 OAI221_X1
* cell instance $464 m0 *1 110.39,124.6
X$464 6948 6940 6980 6789 6729 27 15 6938 OAI221_X1
* cell instance $465 m0 *1 111.53,124.6
X$465 6974 6939 15 27 7011 NAND2_X1
* cell instance $466 m0 *1 112.1,124.6
X$466 15 6937 6737 10686 6939 27 DFF_X2
* cell instance $469 m0 *1 117.42,124.6
X$469 6636 6899 6982 6764 6936 6900 15 27 OAI221_X2
* cell instance $471 m0 *1 119.7,124.6
X$471 6607 6899 6982 6746 6933 6934 15 27 OAI221_X2
* cell instance $472 m0 *1 121.79,124.6
X$472 15 6934 6737 10730 6279 27 DFF_X2
* cell instance $473 m0 *1 125.4,124.6
X$473 6789 6899 6982 6637 6984 6902 15 27 OAI221_X2
* cell instance $476 m0 *1 133.76,124.6
X$476 6903 15 27 6986 INV_X1
* cell instance $479 r0 *1 98.61,124.6
X$479 7096 6974 15 7020 27 NAND2_X4
* cell instance $480 r0 *1 100.32,124.6
X$480 6948 7019 6975 6607 6729 27 15 7095 OAI221_X1
* cell instance $481 r0 *1 101.46,124.6
X$481 6895 7053 15 27 6975 NAND2_X1
* cell instance $484 r0 *1 102.98,124.6
X$484 6948 6977 6978 6560 6729 27 15 6976 OAI221_X1
* cell instance $487 r0 *1 104.69,124.6
X$487 6895 7014 15 27 7015 NAND2_X1
* cell instance $488 r0 *1 105.26,124.6
X$488 6979 6948 7015 6605 6729 27 15 7093 OAI221_X1
* cell instance $491 r0 *1 107.35,124.6
X$491 6658 6973 7013 15 27 7012 MUX2_X1
* cell instance $494 r0 *1 109.63,124.6
X$494 6948 7012 7092 6222 6729 27 15 7089 OAI221_X1
* cell instance $496 r0 *1 110.96,124.6
X$496 6974 6981 15 27 6980 NAND2_X1
* cell instance $497 r0 *1 111.53,124.6
X$497 15 6938 7056 10747 6981 27 DFF_X2
* cell instance $502 r0 *1 115.33,124.6
X$502 6515 6899 6982 6604 7087 7010 15 27 OAI221_X2
* cell instance $503 r0 *1 117.42,124.6
X$503 15 7010 7056 10788 7057 27 DFF_X2
* cell instance $505 r0 *1 121.22,124.6
X$505 6832 6833 15 6936 27 NAND2_X4
* cell instance $506 r0 *1 122.93,124.6
X$506 7057 6833 15 7087 27 NAND2_X4
* cell instance $509 r0 *1 125.59,124.6
X$509 6983 6901 15 6984 27 NAND2_X4
* cell instance $512 r0 *1 128.25,124.6
X$512 6985 6983 15 7085 27 NAND2_X4
* cell instance $514 r0 *1 133,124.6
X$514 15 10535 6836 6986 7162 27 DFF_X1
* cell instance $516 m0 *1 136.04,124.6
X$516 6904 6836 15 27 6415 NAND2_X1
* cell instance $517 m0 *1 136.8,124.6
X$517 6252 6837 15 27 6905 NAND2_X1
* cell instance $519 m0 *1 137.56,124.6
X$519 6905 6987 27 6416 15 XOR2_X2
* cell instance $521 r0 *1 136.23,124.6
X$521 6252 6836 15 27 7081 NAND2_X1
* cell instance $522 r0 *1 136.8,124.6
X$522 6904 6837 15 27 7082 NAND2_X1
* cell instance $524 r0 *1 137.75,124.6
X$524 6988 6863 15 27 6987 NOR2_X1
* cell instance $526 m0 *1 140.79,124.6
X$526 7128 6838 27 15 6926 XNOR2_X1
* cell instance $527 m0 *1 139.65,124.6
X$527 6927 6926 27 15 6862 XNOR2_X1
* cell instance $529 m0 *1 142.12,124.6
X$529 6770 6863 15 27 6861 NOR2_X1
* cell instance $534 r0 *1 140.41,124.6
X$534 6988 7127 15 27 6841 NOR2_X1
* cell instance $536 r0 *1 141.36,124.6
X$536 7080 6989 4332 15 27 NOR2_X4
* cell instance $537 r0 *1 143.07,124.6
X$537 7131 6989 5089 15 27 NOR2_X4
* cell instance $538 m0 *1 146.3,124.6
X$538 6924 4594 27 15 6907 XNOR2_X1
* cell instance $539 m0 *1 144.59,124.6
X$539 6906 6989 4510 15 27 NOR2_X4
* cell instance $540 m0 *1 147.44,124.6
X$540 6721 6990 15 27 6924 NOR2_X1
* cell instance $543 m0 *1 150.29,124.6
X$543 6572 6844 15 27 6992 NOR2_X2
* cell instance $549 r0 *1 146.11,124.6
X$549 7077 6989 4417 15 27 NOR2_X4
* cell instance $550 r0 *1 147.82,124.6
X$550 7568 6844 4778 15 27 NOR2_X4
* cell instance $553 r0 *1 151.81,124.6
X$553 6990 27 6434 15 BUF_X4
* cell instance $554 m0 *1 152.57,124.6
X$554 5978 6990 5300 15 27 NOR2_X4
* cell instance $561 r0 *1 154.85,124.6
X$561 6992 6991 7003 27 15 7058 HA_X1
* cell instance $562 r0 *1 156.75,124.6
X$562 6842 7005 15 6912 27 NAND2_X4
* cell instance $563 m0 *1 157.13,124.6
X$563 5471 15 27 6842 INV_X1
* cell instance $569 r0 *1 159.22,124.6
X$569 6777 7005 15 6911 27 NAND2_X4
* cell instance $570 r0 *1 160.93,124.6
X$570 15 7002 7059 7004 6921 7003 27 FA_X1
* cell instance $571 m0 *1 161.88,124.6
X$571 15 6845 6908 6909 6992 6847 27 FA_X1
* cell instance $573 m0 *1 164.92,124.6
X$573 15 7000 6993 6910 6920 6851 27 FA_X1
* cell instance $575 m0 *1 168.72,124.6
X$575 6919 15 27 7000 INV_X1
* cell instance $576 m0 *1 169.1,124.6
X$576 15 6911 6919 7074 6913 6912 27 FA_X1
* cell instance $577 m0 *1 172.14,124.6
X$577 15 6848 7075 6995 6846 6913 27 FA_X1
* cell instance $579 m0 *1 175.94,124.6
X$579 15 6997 6914 6917 6849 6916 27 FA_X1
* cell instance $584 r0 *1 163.97,124.6
X$584 7004 15 27 6994 INV_X1
* cell instance $586 r0 *1 164.54,124.6
X$586 6993 15 27 7061 INV_X1
* cell instance $589 r0 *1 166.06,124.6
X$589 7001 15 27 7002 INV_X1
* cell instance $593 r0 *1 170.05,124.6
X$593 15 6913 7001 7063 6848 6912 27 FA_X1
* cell instance $600 r0 *1 175.56,124.6
X$600 6995 15 27 7064 INV_X1
* cell instance $603 r0 *1 177.08,124.6
X$603 7071 15 27 6997 INV_X1
* cell instance $604 r0 *1 177.46,124.6
X$604 6913 15 27 6915 INV_X1
* cell instance $607 r0 *1 178.79,124.6
X$607 6913 6848 7143 27 15 10919 HA_X1
* cell instance $608 r0 *1 180.69,124.6
X$608 6912 6913 7067 27 15 10917 HA_X1
* cell instance $615 m0 *1 45.98,155.4
X$615 15 10332 8505 8715 8789 27 DFF_X1
* cell instance $616 m0 *1 44.65,155.4
X$616 8713 8669 8786 15 27 8787 MUX2_X1
* cell instance $619 r0 *1 44.84,155.4
X$619 15 8787 8789 10740 7545 27 DFF_X2
* cell instance $622 r0 *1 49.4,155.4
X$622 15 10564 8407 8717 8388 27 DFF_X1
* cell instance $623 m0 *1 50.92,155.4
X$623 8718 6193 8738 27 15 8670 OAI21_X2
* cell instance $624 m0 *1 49.59,155.4
X$624 6525 8669 8670 15 27 8717 MUX2_X1
* cell instance $627 r0 *1 52.63,155.4
X$627 8407 6969 8739 15 8718 27 NAND3_X4
* cell instance $628 m0 *1 57,155.4
X$628 2126 8109 8579 27 15 8668 AND3_X2
* cell instance $629 m0 *1 53.39,155.4
X$629 15 8671 8388 10703 8314 27 DFF_X2
* cell instance $630 m0 *1 58.14,155.4
X$630 8579 8672 15 27 8667 NAND2_X2
* cell instance $631 m0 *1 59.09,155.4
X$631 7525 15 27 8388 CLKBUF_X3
* cell instance $632 m0 *1 60.04,155.4
X$632 8672 6383 15 27 8580 NAND2_X1
* cell instance $633 m0 *1 60.61,155.4
X$633 8109 15 27 8672 INV_X2
* cell instance $637 r0 *1 55.29,155.4
X$637 8641 27 8738 15 BUF_X4
* cell instance $638 r0 *1 56.62,155.4
X$638 15 8739 27 7259 BUF_X8
* cell instance $642 r0 *1 59.09,155.4
X$642 8278 6969 8739 15 8856 27 NAND3_X4
* cell instance $643 r0 *1 61.56,155.4
X$643 8388 15 27 CLKBUF_X1
* cell instance $646 m0 *1 63.27,155.4
X$646 8581 7169 7037 15 27 8673 NAND3_X1
* cell instance $648 m0 *1 64.03,155.4
X$648 6116 8579 8719 15 27 8720 MUX2_X1
* cell instance $650 m0 *1 65.55,155.4
X$650 15 8720 8388 10670 8392 27 DFF_X2
* cell instance $652 m0 *1 70.68,155.4
X$652 6684 6549 15 27 8814 NAND2_X2
* cell instance $653 m0 *1 71.63,155.4
X$653 6549 7768 15 27 8743 OR2_X1
* cell instance $656 r0 *1 63.08,155.4
X$656 6277 7169 8673 27 8795 15 OAI21_X1
* cell instance $657 r0 *1 63.84,155.4
X$657 8739 8557 6969 15 27 8794 NAND3_X1
* cell instance $659 r0 *1 64.79,155.4
X$659 6277 8738 8794 27 8740 15 OAI21_X1
* cell instance $660 r0 *1 65.55,155.4
X$660 8742 7099 15 27 8741 NAND2_X2
* cell instance $663 r0 *1 68.4,155.4
X$663 6684 6549 7099 15 8669 27 NAND3_X4
* cell instance $664 r0 *1 70.87,155.4
X$664 7768 6685 15 27 8742 NOR2_X2
* cell instance $665 r0 *1 71.82,155.4
X$665 6685 7768 15 27 8744 OR2_X1
* cell instance $666 r0 *1 72.58,155.4
X$666 8743 15 27 8736 CLKBUF_X3
* cell instance $667 m0 *1 73.72,155.4
X$667 6684 6549 6405 15 8815 27 NAND3_X4
* cell instance $670 m0 *1 76.38,155.4
X$670 8799 6518 15 27 8728 NAND2_X2
* cell instance $672 m0 *1 78.09,155.4
X$672 8727 7189 6631 27 15 8864 OAI21_X2
* cell instance $673 m0 *1 79.42,155.4
X$673 6972 8514 7189 15 27 8727 NAND3_X2
* cell instance $676 m0 *1 81.7,155.4
X$676 15 8803 8674 10688 8513 27 DFF_X2
* cell instance $680 m0 *1 90.63,155.4
X$680 6296 8750 8749 6553 8587 8748 15 27 OAI221_X2
* cell instance $682 m0 *1 93.48,155.4
X$682 15 10348 8122 8675 8288 27 DFF_X1
* cell instance $683 m0 *1 96.71,155.4
X$683 8588 8122 15 8802 27 NAND2_X4
* cell instance $684 m0 *1 98.42,155.4
X$684 8588 8324 15 8798 27 NAND2_X4
* cell instance $685 m0 *1 100.13,155.4
X$685 8588 8520 15 27 8676 NAND2_X2
* cell instance $690 r0 *1 74.48,155.4
X$690 6405 8742 15 27 8745 NAND2_X2
* cell instance $691 r0 *1 75.43,155.4
X$691 7188 15 27 8799 INV_X4
* cell instance $692 r0 *1 76.38,155.4
X$692 8511 8799 15 8746 27 NAND2_X4
* cell instance $695 r0 *1 78.66,155.4
X$695 15 10577 8514 8747 8674 27 DFF_X1
* cell instance $700 r0 *1 86.26,155.4
X$700 8746 27 8749 15 BUF_X4
* cell instance $704 r0 *1 89.68,155.4
X$704 15 10583 8486 8748 8288 27 DFF_X1
* cell instance $707 r0 *1 93.86,155.4
X$707 6747 8750 8749 6826 8802 8675 15 27 OAI221_X2
* cell instance $709 r0 *1 96.14,155.4
X$709 5925 8750 8749 6013 8798 8751 15 27 OAI221_X2
* cell instance $711 r0 *1 98.99,155.4
X$711 6604 8749 8676 6515 8750 27 15 8869 OAI221_X1
* cell instance $712 r0 *1 100.13,155.4
X$712 8752 15 27 8288 CLKBUF_X3
* cell instance $714 r0 *1 101.27,155.4
X$714 15 10468 8124 8796 8892 27 DFF_X1
* cell instance $715 m0 *1 102.41,155.4
X$715 6566 8749 8678 6560 8750 27 15 8796 OAI221_X1
* cell instance $717 m0 *1 103.55,155.4
X$717 8677 8124 15 27 8678 NAND2_X1
* cell instance $720 m0 *1 105.83,155.4
X$720 15 10320 8522 8679 8754 27 DFF_X1
* cell instance $725 r0 *1 106.78,155.4
X$725 6605 8750 8749 6638 8793 8679 15 27 OAI221_X2
* cell instance $726 r0 *1 108.87,155.4
X$726 8677 8522 15 8793 27 NAND2_X4
* cell instance $727 m0 *1 111.34,155.4
X$727 8677 8524 15 27 8725 NAND2_X2
* cell instance $728 m0 *1 110.2,155.4
X$728 6764 8749 8725 6636 8750 27 15 8726 OAI221_X1
* cell instance $732 r0 *1 111.34,155.4
X$732 15 10481 8524 8726 8754 27 DFF_X1
* cell instance $733 m0 *1 114.76,155.4
X$733 8680 8103 8681 15 27 8724 MUX2_X1
* cell instance $734 m0 *1 113.43,155.4
X$734 8680 7857 8681 15 27 8723 MUX2_X1
* cell instance $736 m0 *1 117.61,155.4
X$736 15 8722 8754 10719 7980 27 DFF_X2
* cell instance $743 r0 *1 116.28,155.4
X$743 6764 8419 8791 6636 8593 27 15 8865 OAI221_X1
* cell instance $746 r0 *1 117.99,155.4
X$746 8755 8031 15 27 8791 NAND2_X2
* cell instance $748 r0 *1 119.32,155.4
X$748 7945 8755 15 8825 27 NAND2_X4
* cell instance $751 m0 *1 26.41,186.2
X$751 15 10424 10021 10069 9615 27 DFF_X1
* cell instance $753 m0 *1 29.64,186.2
X$753 10021 9915 15 27 10023 NAND2_X1
* cell instance $754 m0 *1 30.21,186.2
X$754 9798 10023 9953 15 10069 27 AOI21_X1
* cell instance $756 m0 *1 31.16,186.2
X$756 15 10455 10025 10024 9856 27 DFF_X1
* cell instance $758 m0 *1 35.91,186.2
X$758 9911 15 27 10106 BUF_X1
* cell instance $759 m0 *1 36.48,186.2
X$759 15 10463 10027 10072 9856 27 DFF_X1
* cell instance $762 m0 *1 41.99,186.2
X$762 15 10426 10031 10030 9390 27 DFF_X1
* cell instance $763 m0 *1 45.22,186.2
X$763 10031 9915 15 27 10029 NAND2_X1
* cell instance $765 m0 *1 45.98,186.2
X$765 10074 9894 15 27 10032 NAND2_X1
* cell instance $766 m0 *1 46.55,186.2
X$766 15 10334 10033 10073 9660 27 DFF_X1
* cell instance $767 m0 *1 49.78,186.2
X$767 15 10448 10109 10077 9660 27 DFF_X1
* cell instance $768 m0 *1 53.01,186.2
X$768 15 10436 10079 10078 9660 27 DFF_X1
* cell instance $769 m0 *1 56.24,186.2
X$769 15 10420 10112 10035 9524 27 DFF_X1
* cell instance $770 m0 *1 59.47,186.2
X$770 15 10440 10114 9961 9707 27 DFF_X1
* cell instance $771 m0 *1 62.7,186.2
X$771 15 10388 10115 10036 9707 27 DFF_X1
* cell instance $773 m0 *1 66.12,186.2
X$773 9721 15 27 10116 BUF_X1
* cell instance $778 r0 *1 26.41,186.2
X$778 9909 15 27 10141 BUF_X1
* cell instance $779 r0 *1 26.98,186.2
X$779 9652 15 27 10142 BUF_X1
* cell instance $782 r0 *1 29.26,186.2
X$782 10021 15 27 10140 BUF_X1
* cell instance $784 r0 *1 30.02,186.2
X$784 10022 15 27 10240 BUF_X1
* cell instance $786 r0 *1 30.78,186.2
X$786 9624 15 27 10105 BUF_X1
* cell instance $788 r0 *1 31.73,186.2
X$788 9910 15 27 10147 BUF_X1
* cell instance $790 r0 *1 32.68,186.2
X$790 9795 15 27 10146 BUF_X1
* cell instance $792 r0 *1 33.63,186.2
X$792 10025 15 27 10150 BUF_X1
* cell instance $796 r0 *1 36.29,186.2
X$796 9754 15 27 10153 BUF_X1
* cell instance $797 r0 *1 36.86,186.2
X$797 10093 15 27 10155 BUF_X1
* cell instance $798 r0 *1 37.43,186.2
X$798 10093 9915 15 27 10026 NAND2_X1
* cell instance $799 r0 *1 38,186.2
X$799 9521 15 27 10154 BUF_X1
* cell instance $800 r0 *1 38.57,186.2
X$800 9913 15 27 10158 BUF_X1
* cell instance $802 r0 *1 39.33,186.2
X$802 10027 15 27 10162 BUF_X1
* cell instance $803 r0 *1 39.9,186.2
X$803 9658 15 27 10163 BUF_X1
* cell instance $806 r0 *1 41.42,186.2
X$806 9435 15 27 10161 BUF_X1
* cell instance $807 r0 *1 41.99,186.2
X$807 9914 15 27 10165 BUF_X1
* cell instance $808 r0 *1 42.56,186.2
X$808 9659 15 27 10168 BUF_X1
* cell instance $810 r0 *1 43.32,186.2
X$810 10028 15 27 10169 BUF_X1
* cell instance $811 r0 *1 43.89,186.2
X$811 9717 15 27 10173 BUF_X1
* cell instance $812 r0 *1 44.46,186.2
X$812 10031 15 27 10171 BUF_X1
* cell instance $815 r0 *1 45.98,186.2
X$815 9454 15 27 10175 BUF_X1
* cell instance $816 r0 *1 46.55,186.2
X$816 10074 15 27 10178 BUF_X1
* cell instance $817 r0 *1 47.12,186.2
X$817 9718 15 27 10182 BUF_X1
* cell instance $819 r0 *1 48.07,186.2
X$819 9797 15 27 10179 BUF_X1
* cell instance $821 r0 *1 48.83,186.2
X$821 10033 15 27 10184 BUF_X1
* cell instance $822 r0 *1 49.4,186.2
X$822 10033 9894 15 27 10107 NAND2_X1
* cell instance $823 r0 *1 49.97,186.2
X$823 9578 15 27 10188 BUF_X1
* cell instance $825 r0 *1 50.73,186.2
X$825 9770 15 27 10190 BUF_X1
* cell instance $827 r0 *1 51.49,186.2
X$827 10109 9894 15 27 10110 NAND2_X1
* cell instance $829 r0 *1 52.25,186.2
X$829 10109 15 27 10192 BUF_X1
* cell instance $831 r0 *1 53.01,186.2
X$831 9860 15 27 10191 BUF_X1
* cell instance $833 r0 *1 53.77,186.2
X$833 10079 15 27 10194 BUF_X1
* cell instance $834 r0 *1 54.34,186.2
X$834 9898 15 27 10195 BUF_X1
* cell instance $835 r0 *1 54.91,186.2
X$835 9523 15 27 10197 BUF_X1
* cell instance $837 r0 *1 56.24,186.2
X$837 9917 15 27 10200 BUF_X1
* cell instance $838 r0 *1 56.81,186.2
X$838 10112 9894 15 27 10034 NAND2_X1
* cell instance $839 r0 *1 57.38,186.2
X$839 9843 15 27 10199 BUF_X1
* cell instance $840 r0 *1 57.95,186.2
X$840 10112 15 27 10202 BUF_X1
* cell instance $841 r0 *1 58.52,186.2
X$841 9581 15 27 10204 BUF_X1
* cell instance $842 r0 *1 59.09,186.2
X$842 9662 15 27 10205 BUF_X1
* cell instance $843 r0 *1 59.66,186.2
X$843 9582 15 27 10207 BUF_X1
* cell instance $845 r0 *1 60.42,186.2
X$845 10114 15 27 10209 BUF_X1
* cell instance $847 r0 *1 61.37,186.2
X$847 10114 9894 15 27 9960 NAND2_X1
* cell instance $849 r0 *1 62.32,186.2
X$849 9663 15 27 10211 BUF_X1
* cell instance $851 r0 *1 63.08,186.2
X$851 10115 9894 15 27 9962 NAND2_X1
* cell instance $853 r0 *1 63.84,186.2
X$853 10115 15 27 10213 BUF_X1
* cell instance $855 r0 *1 64.6,186.2
X$855 9964 15 27 10215 BUF_X1
* cell instance $857 r0 *1 65.36,186.2
X$857 9918 15 27 10217 BUF_X1
* cell instance $858 r0 *1 65.93,186.2
X$858 9526 15 27 10218 BUF_X1
* cell instance $862 r0 *1 67.83,186.2
X$862 9664 15 27 10221 BUF_X1
* cell instance $865 m0 *1 71.82,186.2
X$865 9527 15 27 10117 BUF_X1
* cell instance $870 m0 *1 72.96,186.2
X$870 15 10430 10037 10039 9559 27 DFF_X1
* cell instance $872 m0 *1 76.19,186.2
X$872 10037 9869 15 27 10038 NAND2_X1
* cell instance $874 m0 *1 78.28,186.2
X$874 15 10456 10095 10011 9868 27 DFF_X1
* cell instance $875 m0 *1 81.51,186.2
X$875 15 10337 10096 10042 9868 27 DFF_X1
* cell instance $878 r0 *1 72.77,186.2
X$878 9723 15 27 10225 BUF_X1
* cell instance $879 r0 *1 73.34,186.2
X$879 9902 15 27 10227 BUF_X1
* cell instance $880 r0 *1 73.91,186.2
X$880 9966 15 27 10229 BUF_X1
* cell instance $883 r0 *1 75.05,186.2
X$883 9920 15 27 10230 BUF_X1
* cell instance $884 r0 *1 75.62,186.2
X$884 10037 15 27 10242 BUF_X1
* cell instance $885 r0 *1 76.19,186.2
X$885 9724 15 27 10234 BUF_X1
* cell instance $887 r0 *1 77.52,186.2
X$887 9922 15 27 10241 BUF_X1
* cell instance $891 r0 *1 80.75,186.2
X$891 10094 9926 15 27 10040 NAND2_X1
* cell instance $893 r0 *1 81.7,186.2
X$893 10095 9926 15 27 10041 NAND2_X1
* cell instance $897 r0 *1 83.6,186.2
X$897 9725 15 27 10243 BUF_X1
* cell instance $899 r0 *1 84.93,186.2
X$899 10094 15 27 10237 BUF_X1
* cell instance $900 r0 *1 85.5,186.2
X$900 10095 15 27 10244 BUF_X1
* cell instance $901 m0 *1 86.45,186.2
X$901 15 10286 10044 10085 9868 27 DFF_X1
* cell instance $902 m0 *1 85.88,186.2
X$902 10043 9926 15 27 10084 NAND2_X1
* cell instance $903 m0 *1 89.68,186.2
X$903 15 10310 10097 10087 9530 27 DFF_X1
* cell instance $904 m0 *1 92.91,186.2
X$904 15 10303 10047 10089 9530 27 DFF_X1
* cell instance $905 m0 *1 96.14,186.2
X$905 15 10314 10049 10048 9974 27 DFF_X1
* cell instance $907 r0 *1 86.07,186.2
X$907 10096 15 27 10245 BUF_X1
* cell instance $909 r0 *1 87.02,186.2
X$909 9904 15 27 10239 BUF_X1
* cell instance $911 r0 *1 87.97,186.2
X$911 10043 15 27 10247 BUF_X1
* cell instance $914 r0 *1 89.49,186.2
X$914 10044 15 27 10246 BUF_X1
* cell instance $917 r0 *1 90.63,186.2
X$917 9646 15 27 10238 BUF_X1
* cell instance $918 r0 *1 91.2,186.2
X$918 9952 15 27 10236 BUF_X1
* cell instance $919 r0 *1 91.77,186.2
X$919 10097 9926 15 27 10045 NAND2_X1
* cell instance $920 r0 *1 92.34,186.2
X$920 9730 15 27 10235 BUF_X1
* cell instance $923 r0 *1 93.48,186.2
X$923 9803 15 27 10233 BUF_X1
* cell instance $926 r0 *1 94.62,186.2
X$926 9531 15 27 10250 BUF_X1
* cell instance $927 r0 *1 95.19,186.2
X$927 10248 15 27 6691 BUF_X2
* cell instance $928 r0 *1 95.95,186.2
X$928 10249 15 27 6612 BUF_X2
* cell instance $929 r0 *1 96.71,186.2
X$929 10046 15 27 10232 BUF_X1
* cell instance $931 r0 *1 97.47,186.2
X$931 10097 15 27 10231 BUF_X1
* cell instance $932 r0 *1 98.04,186.2
X$932 9468 15 27 10228 BUF_X1
* cell instance $934 r0 *1 98.99,186.2
X$934 10120 15 27 6945 BUF_X2
* cell instance $935 r0 *1 99.75,186.2
X$935 9732 15 27 10226 BUF_X1
* cell instance $936 m0 *1 102.98,186.2
X$936 9974 15 27 CLKBUF_X1
* cell instance $937 m0 *1 99.75,186.2
X$937 15 10312 10098 10050 9974 27 DFF_X1
* cell instance $938 m0 *1 103.55,186.2
X$938 15 10343 10052 10051 9974 27 DFF_X1
* cell instance $939 m0 *1 106.78,186.2
X$939 15 10353 10054 10053 9974 27 DFF_X1
* cell instance $940 m0 *1 110.01,186.2
X$940 15 10347 9977 10055 9400 27 DFF_X1
* cell instance $941 m0 *1 113.24,186.2
X$941 15 10350 10056 10092 9595 27 DFF_X1
* cell instance $942 m0 *1 116.47,186.2
X$942 10056 9878 15 27 10057 NAND2_X1
* cell instance $943 m0 *1 117.04,186.2
X$943 9304 10057 9597 15 10092 27 AOI21_X1
* cell instance $944 m0 *1 117.8,186.2
X$944 10058 9878 15 27 10059 NAND2_X1
* cell instance $945 m0 *1 118.37,186.2
X$945 15 10407 10060 10088 9980 27 DFF_X1
* cell instance $946 m0 *1 121.6,186.2
X$946 15 10399 10061 10086 9980 27 DFF_X1
* cell instance $947 m0 *1 124.83,186.2
X$947 15 10398 9981 10062 9980 27 DFF_X1
* cell instance $948 m0 *1 128.06,186.2
X$948 15 10432 10063 10083 9980 27 DFF_X1
* cell instance $949 m0 *1 131.29,186.2
X$949 9775 15 27 10123 BUF_X1
* cell instance $950 m0 *1 131.86,186.2
X$950 9945 15 27 10122 BUF_X1
* cell instance $951 m0 *1 132.43,186.2
X$951 15 10427 9982 10099 9814 27 DFF_X1
* cell instance $952 m0 *1 135.66,186.2
X$952 9180 15 27 10118 BUF_X1
* cell instance $953 m0 *1 136.23,186.2
X$953 9602 15 27 10119 BUF_X1
* cell instance $955 m0 *1 136.99,186.2
X$955 10064 9672 15 27 10080 NAND2_X1
* cell instance $956 m0 *1 137.56,186.2
X$956 9934 10075 8552 15 10113 27 AOI21_X1
* cell instance $957 m0 *1 138.32,186.2
X$957 15 10457 10065 10113 9814 27 DFF_X1
* cell instance $958 m0 *1 141.55,186.2
X$958 10065 9672 15 27 10075 NAND2_X1
* cell instance $960 m0 *1 142.31,186.2
X$960 9740 15 27 10108 BUF_X1
* cell instance $961 m0 *1 142.88,186.2
X$961 9022 15 27 10111 BUF_X1
* cell instance $963 m0 *1 143.64,186.2
X$963 15 10433 10066 9987 9739 27 DFF_X1
* cell instance $964 m0 *1 146.87,186.2
X$964 15 10452 10067 10070 9739 27 DFF_X1
* cell instance $965 m0 *1 150.1,186.2
X$965 10067 9816 15 27 10068 NAND2_X1
* cell instance $966 m0 *1 150.67,186.2
X$966 9988 15 27 10104 BUF_X1
* cell instance $967 m0 *1 151.24,186.2
X$967 9936 15 27 10103 BUF_X1
* cell instance $969 r0 *1 100.32,186.2
X$969 10047 15 27 10252 BUF_X1
* cell instance $970 r0 *1 100.89,186.2
X$970 9668 15 27 10224 BUF_X1
* cell instance $971 r0 *1 101.46,186.2
X$971 9975 15 27 10223 BUF_X1
* cell instance $972 r0 *1 102.03,186.2
X$972 9532 15 27 10222 BUF_X1
* cell instance $974 r0 *1 102.98,186.2
X$974 10098 9869 15 27 9976 NAND2_X1
* cell instance $976 r0 *1 103.74,186.2
X$976 10253 15 27 6745 BUF_X2
* cell instance $977 r0 *1 104.5,186.2
X$977 10098 15 27 10220 BUF_X1
* cell instance $978 r0 *1 105.07,186.2
X$978 10251 15 27 6830 BUF_X2
* cell instance $979 r0 *1 105.83,186.2
X$979 9948 15 27 10254 BUF_X1
* cell instance $980 r0 *1 106.4,186.2
X$980 9788 15 27 10219 BUF_X1
* cell instance $981 r0 *1 106.97,186.2
X$981 10052 15 27 10216 BUF_X1
* cell instance $982 r0 *1 107.54,186.2
X$982 10125 15 27 6693 BUF_X2
* cell instance $983 r0 *1 108.3,186.2
X$983 10257 15 27 6831 BUF_X2
* cell instance $984 r0 *1 109.06,186.2
X$984 9514 15 27 10256 BUF_X1
* cell instance $985 r0 *1 109.63,186.2
X$985 10054 15 27 10255 BUF_X1
* cell instance $986 r0 *1 110.2,186.2
X$986 10049 15 27 10214 BUF_X1
* cell instance $987 r0 *1 110.77,186.2
X$987 10126 15 27 6659 BUF_X2
* cell instance $988 r0 *1 111.53,186.2
X$988 9533 15 27 10259 BUF_X1
* cell instance $989 r0 *1 112.1,186.2
X$989 9735 15 27 10258 BUF_X1
* cell instance $990 r0 *1 112.67,186.2
X$990 9929 15 27 10210 BUF_X1
* cell instance $991 r0 *1 113.24,186.2
X$991 9977 15 27 10260 BUF_X1
* cell instance $992 r0 *1 113.81,186.2
X$992 9299 15 27 10212 BUF_X1
* cell instance $993 r0 *1 114.38,186.2
X$993 9874 15 27 10261 BUF_X1
* cell instance $994 r0 *1 114.95,186.2
X$994 9300 15 27 10208 BUF_X1
* cell instance $995 r0 *1 115.52,186.2
X$995 9785 15 27 10262 BUF_X1
* cell instance $996 r0 *1 116.09,186.2
X$996 10056 15 27 10263 BUF_X1
* cell instance $997 r0 *1 116.66,186.2
X$997 9306 15 27 10267 BUF_X1
* cell instance $998 r0 *1 117.23,186.2
X$998 10058 15 27 10265 BUF_X1
* cell instance $999 r0 *1 117.8,186.2
X$999 9401 15 27 10206 BUF_X1
* cell instance $1000 r0 *1 118.37,186.2
X$1000 9596 15 27 10203 BUF_X1
* cell instance $1001 r0 *1 118.94,186.2
X$1001 9441 15 27 10268 BUF_X1
* cell instance $1002 r0 *1 119.51,186.2
X$1002 9235 15 27 10201 BUF_X1
* cell instance $1003 r0 *1 120.08,186.2
X$1003 9932 15 27 10269 BUF_X1
* cell instance $1006 r0 *1 121.22,186.2
X$1006 9979 15 27 10198 BUF_X1
* cell instance $1007 r0 *1 121.79,186.2
X$1007 9811 15 27 10270 BUF_X1
* cell instance $1008 r0 *1 122.36,186.2
X$1008 9645 15 27 10196 BUF_X1
* cell instance $1009 r0 *1 122.93,186.2
X$1009 9399 15 27 10193 BUF_X1
* cell instance $1010 r0 *1 123.5,186.2
X$1010 9178 15 27 10264 BUF_X1
* cell instance $1011 r0 *1 124.07,186.2
X$1011 10060 15 27 10271 BUF_X1
* cell instance $1012 r0 *1 124.64,186.2
X$1012 7393 15 27 10266 BUF_X1
* cell instance $1013 r0 *1 125.21,186.2
X$1013 9933 15 27 10189 BUF_X1
* cell instance $1014 r0 *1 125.78,186.2
X$1014 9402 15 27 10186 BUF_X1
* cell instance $1015 r0 *1 126.35,186.2
X$1015 9403 15 27 10185 BUF_X1
* cell instance $1016 r0 *1 126.92,186.2
X$1016 10061 15 27 10187 BUF_X1
* cell instance $1017 r0 *1 127.49,186.2
X$1017 9812 15 27 10272 BUF_X1
* cell instance $1018 r0 *1 128.06,186.2
X$1018 9981 15 27 10183 BUF_X1
* cell instance $1019 r0 *1 128.63,186.2
X$1019 9116 15 27 10180 BUF_X1
* cell instance $1020 r0 *1 129.2,186.2
X$1020 9600 15 27 10181 BUF_X1
* cell instance $1021 r0 *1 129.77,186.2
X$1021 9237 15 27 10273 BUF_X1
* cell instance $1022 r0 *1 130.34,186.2
X$1022 9373 15 27 10177 BUF_X1
* cell instance $1023 r0 *1 130.91,186.2
X$1023 9083 15 27 10176 BUF_X1
* cell instance $1024 r0 *1 131.48,186.2
X$1024 10063 15 27 10274 BUF_X1
* cell instance $1025 r0 *1 132.05,186.2
X$1025 7468 15 27 10124 BUF_X1
* cell instance $1026 r0 *1 132.62,186.2
X$1026 9475 15 27 10275 BUF_X1
* cell instance $1027 r0 *1 133.19,186.2
X$1027 9934 10081 10121 15 10099 27 AOI21_X1
* cell instance $1028 r0 *1 133.95,186.2
X$1028 9813 15 27 10174 BUF_X1
* cell instance $1029 r0 *1 134.52,186.2
X$1029 9118 15 27 10170 BUF_X1
* cell instance $1030 r0 *1 135.09,186.2
X$1030 9314 15 27 10172 BUF_X1
* cell instance $1031 r0 *1 135.66,186.2
X$1031 8980 15 27 10277 BUF_X1
* cell instance $1032 r0 *1 136.23,186.2
X$1032 9119 15 27 10276 BUF_X1
* cell instance $1033 r0 *1 136.8,186.2
X$1033 10064 15 27 10167 BUF_X1
* cell instance $1034 r0 *1 137.37,186.2
X$1034 9815 15 27 10279 BUF_X1
* cell instance $1035 r0 *1 137.94,186.2
X$1035 9476 15 27 10280 BUF_X1
* cell instance $1036 r0 *1 138.51,186.2
X$1036 9984 15 27 10278 BUF_X1
* cell instance $1037 r0 *1 139.08,186.2
X$1037 9274 15 27 10166 BUF_X1
* cell instance $1038 r0 *1 139.65,186.2
X$1038 9183 15 27 10160 BUF_X1
* cell instance $1039 r0 *1 140.22,186.2
X$1039 9406 15 27 10159 BUF_X1
* cell instance $1040 r0 *1 140.79,186.2
X$1040 8982 15 27 10164 BUF_X1
* cell instance $1041 r0 *1 141.36,186.2
X$1041 10065 15 27 10156 BUF_X1
* cell instance $1042 r0 *1 141.93,186.2
X$1042 8828 15 27 10157 BUF_X1
* cell instance $1043 r0 *1 142.5,186.2
X$1043 9891 15 27 10151 BUF_X1
* cell instance $1044 r0 *1 143.07,186.2
X$1044 8069 15 27 10281 BUF_X1
* cell instance $1045 r0 *1 143.64,186.2
X$1045 9553 15 27 10152 BUF_X1
* cell instance $1046 r0 *1 144.21,186.2
X$1046 8550 15 27 10149 BUF_X1
* cell instance $1047 r0 *1 144.78,186.2
X$1047 8984 15 27 10148 BUF_X1
* cell instance $1048 r0 *1 145.35,186.2
X$1048 9121 15 27 10145 BUF_X1
* cell instance $1050 r0 *1 146.11,186.2
X$1050 10066 9672 15 27 9986 NAND2_X1
* cell instance $1051 r0 *1 146.68,186.2
X$1051 9842 15 27 10144 BUF_X1
* cell instance $1052 r0 *1 147.25,186.2
X$1052 10066 15 27 10143 BUF_X1
* cell instance $1053 r0 *1 147.82,186.2
X$1053 9741 15 27 10282 BUF_X1
* cell instance $1054 r0 *1 148.39,186.2
X$1054 8164 15 27 10138 BUF_X1
* cell instance $1055 r0 *1 148.96,186.2
X$1055 9935 15 27 10139 BUF_X1
* cell instance $1056 r0 *1 149.53,186.2
X$1056 9673 15 27 10132 BUF_X1
* cell instance $1057 r0 *1 150.1,186.2
X$1057 10067 15 27 10136 BUF_X1
* cell instance $1058 r0 *1 150.67,186.2
X$1058 9982 15 27 10283 BUF_X1
* cell instance $1059 r0 *1 151.24,186.2
X$1059 9631 15 27 10129 BUF_X1
* cell instance $1067 m0 *1 150.1,177.8
X$1067 15 9243 9758 9695 9697 9605 27 FA_X1
* cell instance $1070 m0 *1 154.66,177.8
X$1070 9694 15 27 9690 INV_X1
* cell instance $1071 m0 *1 155.04,177.8
X$1071 9695 15 27 9692 INV_X1
* cell instance $1074 r0 *1 150.1,177.8
X$1074 9243 9697 9817 27 15 9818 HA_X1
* cell instance $1077 r0 *1 152.95,177.8
X$1077 9760 9540 9761 27 15 9757 HA_X1
* cell instance $1078 r0 *1 154.85,177.8
X$1078 15 9759 9820 9838 9758 9834 27 FA_X1
* cell instance $1079 m0 *1 155.99,177.8
X$1079 9693 15 27 9759 INV_X1
* cell instance $1082 m0 *1 156.56,177.8
X$1082 15 9674 9693 9623 9692 9691 27 FA_X1
* cell instance $1084 m0 *1 160.36,177.8
X$1084 9689 15 27 9691 INV_X1
* cell instance $1091 r0 *1 159.98,177.8
X$1091 9690 9757 9753 27 9744 15 OAI21_X1
* cell instance $1092 r0 *1 160.74,177.8
X$1092 9836 15 27 9835 INV_X1
* cell instance $1093 r0 *1 161.12,177.8
X$1093 15 9756 9887 9834 9831 9752 27 FA_X1
* cell instance $1094 r0 *1 164.16,177.8
X$1094 9833 9821 10894 27 15 9743 HA_X1
* cell instance $1095 m0 *1 165.87,177.8
X$1095 9688 15 27 9752 INV_X1
* cell instance $1099 r0 *1 166.06,177.8
X$1099 9743 9884 10903 27 15 9822 HA_X1
* cell instance $1102 m0 *1 168.15,177.8
X$1102 15 9687 9749 9751 9686 9685 27 FA_X1
* cell instance $1104 m0 *1 172.14,177.8
X$1104 15 9684 9682 9747 9683 9542 27 FA_X1
* cell instance $1106 r0 *1 168.34,177.8
X$1106 9823 9830 9753 27 15 9755 HA_X1
* cell instance $1107 r0 *1 170.24,177.8
X$1107 9755 15 27 9750 INV_X1
* cell instance $1109 r0 *1 171,177.8
X$1109 9745 9750 9744 15 9746 27 AOI21_X1
* cell instance $1113 r0 *1 171.76,177.8
X$1113 15 9749 9684 9825 9676 9545 27 FA_X1
* cell instance $1114 r0 *1 174.8,177.8
X$1114 9746 9824 9677 27 9748 15 OAI21_X1
* cell instance $1116 m0 *1 175.56,177.8
X$1116 9678 9682 9677 27 15 9681 HA_X1
* cell instance $1117 m0 *1 177.65,177.8
X$1117 9681 15 27 9680 INV_X1
* cell instance $1121 m0 *1 178.41,177.8
X$1121 9610 9748 9680 15 9414 27 AOI21_X1
* cell instance $1128 m0 *1 105.45,119
X$1128 15 6830 6633 6638 6555 6006 27 AOI22_X4
* cell instance $1129 m0 *1 102.22,119
X$1129 15 6745 6633 6566 6555 6660 27 AOI22_X4
* cell instance $1130 m0 *1 108.68,119
X$1130 6744 5939 6634 6181 6657 6656 15 27 OAI221_X2
* cell instance $1132 m0 *1 110.96,119
X$1132 15 6656 6290 10675 6559 27 DFF_X2
* cell instance $1135 m0 *1 98.61,119
X$1135 15 6945 6632 6746 6555 6124 27 AOI22_X4
* cell instance $1137 r0 *1 98.8,119
X$1137 15 6606 6632 27 BUF_X16
* cell instance $1141 r0 *1 106.02,119
X$1141 15 6693 6632 6637 6555 6694 27 AOI22_X4
* cell instance $1145 r0 *1 110.58,119
X$1145 15 6743 6290 10748 6742 27 DFF_X2
* cell instance $1147 m0 *1 117.42,119
X$1147 6636 6562 6564 6764 6695 6740 15 27 OAI221_X2
* cell instance $1148 m0 *1 114.95,119
X$1148 15 6564 27 6634 BUF_X8
* cell instance $1154 r0 *1 116.09,119
X$1154 15 6740 6737 10789 6738 27 DFF_X2
* cell instance $1156 m0 *1 124.64,119
X$1156 15 6567 27 6635 BUF_X8
* cell instance $1157 m0 *1 119.89,119
X$1157 15 6635 6482 27 BUF_X16
* cell instance $1158 m0 *1 127.11,119
X$1158 6789 6562 6564 6637 6653 6697 15 27 OAI221_X2
* cell instance $1161 m0 *1 130.15,119
X$1161 15 6652 6273 10695 6699 27 DFF_X2
* cell instance $1162 m0 *1 133.76,119
X$1162 5105 6727 15 27 6483 NAND2_X1
* cell instance $1163 m0 *1 134.33,119
X$1163 5155 15 27 6727 INV_X1
* cell instance $1167 m0 *1 138.7,119
X$1167 6726 6233 15 27 6639 NOR2_X1
* cell instance $1168 m0 *1 139.27,119
X$1168 6701 6639 27 15 6725 XNOR2_X1
* cell instance $1171 m0 *1 141.36,119
X$1171 6424 6700 15 6075 27 OR2_X4
* cell instance $1174 m0 *1 144.78,119
X$1174 6721 5572 15 27 6722 NOR2_X1
* cell instance $1180 r0 *1 121.98,119
X$1180 15 6766 6737 10814 6696 27 DFF_X2
* cell instance $1182 r0 *1 125.78,119
X$1182 15 6697 6737 10811 6698 27 DFF_X2
* cell instance $1184 r0 *1 129.58,119
X$1184 6222 6562 6564 6658 6788 6787 15 27 OAI221_X2
* cell instance $1188 r0 *1 133.76,119
X$1188 5105 15 27 6768 INV_X1
* cell instance $1193 r0 *1 139.27,119
X$1193 6725 6769 15 27 6111 XNOR2_X2
* cell instance $1195 r0 *1 141.55,119
X$1195 15 6859 6784 6108 6720 6717 27 FA_X1
* cell instance $1196 r0 *1 144.59,119
X$1196 6722 6782 6723 27 15 6720 HA_X1
* cell instance $1197 m0 *1 145.92,119
X$1197 6721 5570 15 27 6640 NOR2_X1
* cell instance $1200 m0 *1 148.01,119
X$1200 6715 15 27 6647 INV_X1
* cell instance $1206 r0 *1 149.72,119
X$1206 15 6716 6717 6345 6702 6714 27 FA_X1
* cell instance $1207 m0 *1 151.43,119
X$1207 6434 6487 15 27 6703 OR2_X1
* cell instance $1208 m0 *1 151.05,119
X$1208 6703 15 27 6716 INV_X1
* cell instance $1209 m0 *1 152.19,119
X$1209 15 6704 6715 6174 6703 5569 27 FA_X1
* cell instance $1212 r0 *1 152.76,119
X$1212 6773 15 27 6231 INV_X1
* cell instance $1214 r0 *1 153.33,119
X$1214 6704 15 27 6714 INV_X1
* cell instance $1216 r0 *1 153.9,119
X$1216 6434 5568 15 27 6704 OR2_X2
* cell instance $1218 r0 *1 155.04,119
X$1218 15 6421 6774 6711 5569 6710 27 FA_X1
* cell instance $1220 m0 *1 157.13,119
X$1220 6711 15 27 6502 INV_X1
* cell instance $1223 m0 *1 161.5,119
X$1223 6777 15 27 5990 INV_X4
* cell instance $1232 r0 *1 158.46,119
X$1232 6705 15 27 6710 INV_X1
* cell instance $1243 m0 *1 3.42,65.8
X$1243 15 3489 3631 3547 3401 3046 27 AOI22_X4
* cell instance $1244 m0 *1 2.47,65.8
X$1244 3630 2849 27 15 3401 AND2_X2
* cell instance $1245 m0 *1 6.65,65.8
X$1245 3110 2891 15 27 3632 NOR2_X2
* cell instance $1246 m0 *1 7.6,65.8
X$1246 3459 3632 3574 15 27 NOR2_X4
* cell instance $1248 m0 *1 10.83,65.8
X$1248 3016 3488 15 27 3724 NOR2_X1
* cell instance $1249 m0 *1 11.4,65.8
X$1249 3542 3016 15 27 3575 NOR2_X1
* cell instance $1250 m0 *1 11.97,65.8
X$1250 15 3172 3488 3486 3348 3576 27 NOR4_X4
* cell instance $1251 m0 *1 15.39,65.8
X$1251 3487 3346 3050 3388 15 3677 27 NAND4_X2
* cell instance $1252 m0 *1 17.1,65.8
X$1252 3487 3346 3050 3348 15 3727 27 NAND4_X2
* cell instance $1254 m0 *1 19.57,65.8
X$1254 15 3490 3547 3491 4012 27 NOR3_X4
* cell instance $1258 m0 *1 26.98,65.8
X$1258 388 3492 3408 27 15 3635 HA_X1
* cell instance $1261 m0 *1 29.83,65.8
X$1261 3548 3408 27 3681 15 XOR2_X2
* cell instance $1272 r0 *1 4.37,65.8
X$1272 15 3486 3263 3149 3673 27 NOR3_X4
* cell instance $1275 r0 *1 7.6,65.8
X$1275 2849 15 27 3835 INV_X1
* cell instance $1278 r0 *1 8.55,65.8
X$1278 15 3172 3488 3486 2854 27 NOR3_X4
* cell instance $1279 r0 *1 11.21,65.8
X$1279 3486 3172 15 27 3674 NOR2_X1
* cell instance $1281 r0 *1 11.97,65.8
X$1281 3404 3231 15 27 3725 NOR2_X1
* cell instance $1283 r0 *1 12.73,65.8
X$1283 3486 3488 3172 3388 27 3675 15 NOR4_X2
* cell instance $1284 r0 *1 14.44,65.8
X$1284 3404 3231 15 27 3634 NAND2_X1
* cell instance $1288 r0 *1 19.76,65.8
X$1288 3491 3490 3547 15 27 3679 OR3_X4
* cell instance $1289 r0 *1 21.85,65.8
X$1289 15 3547 3490 3491 3988 27 NOR3_X4
* cell instance $1292 r0 *1 26.79,65.8
X$1292 3635 15 27 3577 BUF_X2
* cell instance $1293 r0 *1 27.55,65.8
X$1293 3577 3408 3636 15 3680 27 AOI21_X2
* cell instance $1296 r0 *1 30.02,65.8
X$1296 1499 27 3643 15 BUF_X4
* cell instance $1298 m0 *1 32.87,65.8
X$1298 3410 15 27 3579 CLKBUF_X3
* cell instance $1302 m0 *1 35.53,65.8
X$1302 388 3579 3578 27 15 3729 HA_X1
* cell instance $1303 m0 *1 37.43,65.8
X$1303 3637 3578 27 3580 15 XOR2_X2
* cell instance $1306 m0 *1 41.42,65.8
X$1306 3550 3496 3685 3358 3553 27 15 AOI211_X2
* cell instance $1310 r0 *1 34.01,65.8
X$1310 3347 27 3496 15 BUF_X4
* cell instance $1311 r0 *1 35.34,65.8
X$1311 3637 3578 27 3682 15 AND2_X4
* cell instance $1312 r0 *1 37.05,65.8
X$1312 3578 3637 15 27 3584 XNOR2_X2
* cell instance $1313 r0 *1 38.95,65.8
X$1313 3580 3730 15 27 3683 NAND2_X1
* cell instance $1316 r0 *1 40.47,65.8
X$1316 15 3683 3684 3731 3359 3581 27 AOI22_X4
* cell instance $1317 m0 *1 43.7,65.8
X$1317 15 3551 3582 2632 3494 27 AOI21_X4
* cell instance $1319 m0 *1 46.17,65.8
X$1319 3582 3416 3583 3494 3552 27 15 AOI211_X2
* cell instance $1322 r0 *1 43.7,65.8
X$1322 3359 3581 27 15 3686 AND2_X1
* cell instance $1323 r0 *1 44.46,65.8
X$1323 3581 3359 15 27 3716 NAND2_X1
* cell instance $1325 r0 *1 45.22,65.8
X$1325 3579 3580 3583 27 15 3495 MUX2_X2
* cell instance $1326 r0 *1 46.93,65.8
X$1326 3417 3580 3416 15 27 3771 NAND3_X1
* cell instance $1327 r0 *1 47.69,65.8
X$1327 3417 3584 3496 15 27 3687 NAND3_X1
* cell instance $1330 r0 *1 49.4,65.8
X$1330 3551 15 27 3360 INV_X1
* cell instance $1333 m0 *1 49.78,65.8
X$1333 3419 3552 3553 27 15 3585 OAI21_X2
* cell instance $1334 m0 *1 52.63,65.8
X$1334 3419 3417 3495 15 27 3421 NAND3_X1
* cell instance $1335 m0 *1 53.39,65.8
X$1335 3421 3121 3170 15 3639 27 AOI21_X1
* cell instance $1339 r0 *1 51.87,65.8
X$1339 3415 3638 15 3720 27 OR2_X4
* cell instance $1340 r0 *1 53.58,65.8
X$1340 3417 3416 15 27 3689 NOR2_X1
* cell instance $1342 m0 *1 14.82,141.4
X$1342 6523 15 27 7537 CLKBUF_X3
* cell instance $1347 m0 *1 19.76,141.4
X$1347 15 7699 27 7855 BUF_X8
* cell instance $1349 m0 *1 22.42,141.4
X$1349 7856 27 7650 15 BUF_X4
* cell instance $1350 m0 *1 23.75,141.4
X$1350 7726 7855 15 27 7902 NAND2_X1
* cell instance $1351 m0 *1 24.32,141.4
X$1351 5689 7196 7902 7856 5690 27 15 7967 OAI221_X1
* cell instance $1353 m0 *1 28.5,141.4
X$1353 7279 7855 15 27 7968 NAND2_X1
* cell instance $1355 m0 *1 29.83,141.4
X$1355 7754 7857 6245 15 27 7904 MUX2_X1
* cell instance $1356 m0 *1 31.16,141.4
X$1356 7536 7857 5310 15 27 7970 MUX2_X1
* cell instance $1361 m0 *1 12.16,141.4
X$1361 7535 7854 15 27 7853 NAND2_X1
* cell instance $1362 m0 *1 12.92,141.4
X$1362 7329 7854 15 27 7894 NAND2_X1
* cell instance $1366 r0 *1 12.35,141.4
X$1366 7852 7924 15 27 7925 NAND2_X1
* cell instance $1367 r0 *1 12.92,141.4
X$1367 7537 15 27 CLKBUF_X1
* cell instance $1368 r0 *1 13.49,141.4
X$1368 15 10589 7888 7958 7537 27 DFF_X1
* cell instance $1369 r0 *1 16.72,141.4
X$1369 7888 7924 15 27 7926 NAND2_X1
* cell instance $1371 r0 *1 17.48,141.4
X$1371 8060 7926 7961 15 7958 27 AOI21_X1
* cell instance $1375 r0 *1 19.57,141.4
X$1375 6682 7196 8157 7650 6649 27 15 8065 OAI221_X1
* cell instance $1377 r0 *1 20.9,141.4
X$1377 15 8099 27 7855 BUF_X8
* cell instance $1379 r0 *1 24.13,141.4
X$1379 15 7967 7901 10752 7726 27 DFF_X2
* cell instance $1381 r0 *1 28.5,141.4
X$1381 5791 7196 7968 7856 5793 27 15 8068 OAI221_X1
* cell instance $1385 r0 *1 32.11,141.4
X$1385 7970 7858 7904 15 27 7971 MUX2_X1
* cell instance $1386 r0 *1 33.44,141.4
X$1386 5697 7196 7927 7856 5694 27 15 7974 OAI221_X1
* cell instance $1387 r0 *1 34.58,141.4
X$1387 7428 7855 15 27 7927 NAND2_X1
* cell instance $1388 r0 *1 35.15,141.4
X$1388 15 7974 7901 10737 7428 27 DFF_X2
* cell instance $1390 r0 *1 38.95,141.4
X$1390 7805 7914 5308 15 27 7977 MUX2_X1
* cell instance $1391 m0 *1 39.9,141.4
X$1391 7801 7908 5401 15 27 7860 MUX2_X1
* cell instance $1393 m0 *1 41.23,141.4
X$1393 7859 7757 6713 15 27 7827 MUX2_X1
* cell instance $1394 m0 *1 42.56,141.4
X$1394 7859 7862 6713 15 27 7861 MUX2_X1
* cell instance $1402 r0 *1 43.13,141.4
X$1402 7860 7938 7861 15 27 7978 MUX2_X1
* cell instance $1406 r0 *1 45.79,141.4
X$1406 15 6988 7928 8023 7978 27 AOI21_X4
* cell instance $1407 m0 *1 48.26,141.4
X$1407 7863 7757 5242 15 27 7830 MUX2_X1
* cell instance $1409 m0 *1 49.59,141.4
X$1409 7863 7762 5242 15 27 7929 MUX2_X1
* cell instance $1414 r0 *1 49.21,141.4
X$1414 6812 7931 15 27 7961 NAND2_X1
* cell instance $1417 r0 *1 50.35,141.4
X$1417 7831 8012 7929 15 27 7988 MUX2_X1
* cell instance $1419 m0 *1 53.01,141.4
X$1419 7659 7766 15 27 7856 NAND2_X2
* cell instance $1421 m0 *1 53.96,141.4
X$1421 7043 7659 6961 15 27 7855 AND3_X4
* cell instance $1423 m0 *1 57,141.4
X$1423 7913 6277 7864 27 7836 15 OAI21_X1
* cell instance $1424 m0 *1 56.43,141.4
X$1424 7043 15 27 7913 BUF_X1
* cell instance $1428 m0 *1 58.14,141.4
X$1428 15 7835 7378 10698 7657 27 DFF_X2
* cell instance $1429 m0 *1 62.51,141.4
X$1429 7657 7915 5337 15 27 7865 MUX2_X1
* cell instance $1438 r0 *1 61.37,141.4
X$1438 7177 7915 7040 15 27 7932 MUX2_X1
* cell instance $1439 r0 *1 62.7,141.4
X$1439 7932 7858 7865 15 27 7986 MUX2_X1
* cell instance $1440 r0 *1 64.03,141.4
X$1440 7987 7986 7658 27 15 5543 MUX2_X2
* cell instance $1444 m0 *1 68.02,141.4
X$1444 7383 27 7858 15 BUF_X4
* cell instance $1446 r0 *1 68.21,141.4
X$1446 15 7989 7934 27 BUF_X16
* cell instance $1447 m0 *1 69.92,141.4
X$1447 7383 27 7654 15 BUF_X4
* cell instance $1449 m0 *1 71.25,141.4
X$1449 15 7668 27 7933 BUF_X8
* cell instance $1451 r0 *1 72.96,141.4
X$1451 7934 15 27 7369 BUF_X1
* cell instance $1453 r0 *1 73.91,141.4
X$1453 15 7447 27 7734 BUF_X8
* cell instance $1454 m0 *1 75.43,141.4
X$1454 15 7914 27 5675 BUF_X8
* cell instance $1455 m0 *1 74.1,141.4
X$1455 7919 27 8022 15 BUF_X4
* cell instance $1456 m0 *1 77.9,141.4
X$1456 8095 7666 7936 15 27 7844 MUX2_X1
* cell instance $1459 r0 *1 76.38,141.4
X$1459 6550 7908 7935 15 27 7993 MUX2_X1
* cell instance $1461 r0 *1 79.23,141.4
X$1461 7553 7908 6970 15 27 7937 MUX2_X1
* cell instance $1463 m0 *1 80.37,141.4
X$1463 5879 7908 7380 15 27 7866 MUX2_X1
* cell instance $1465 m0 *1 85.5,141.4
X$1465 7642 7447 5451 15 27 7867 MUX2_X1
* cell instance $1466 m0 *1 86.83,141.4
X$1466 7867 7605 7771 15 27 8184 MUX2_X1
* cell instance $1467 m0 *1 88.16,141.4
X$1467 6210 7734 7868 15 27 7869 MUX2_X1
* cell instance $1470 m0 *1 90.44,141.4
X$1470 15 7131 7918 7870 7347 27 AOI21_X4
* cell instance $1471 m0 *1 92.91,141.4
X$1471 7994 7451 7667 15 27 7870 MUX2_X1
* cell instance $1472 m0 *1 94.24,141.4
X$1472 7871 7872 7282 27 15 5643 MUX2_X2
* cell instance $1474 m0 *1 96.71,141.4
X$1474 7295 7862 7389 15 27 7873 MUX2_X1
* cell instance $1476 m0 *1 98.23,141.4
X$1476 7916 7874 7282 27 15 6379 MUX2_X2
* cell instance $1480 r0 *1 80.56,141.4
X$1480 7937 7938 7866 15 27 8093 MUX2_X1
* cell instance $1483 r0 *1 85.31,141.4
X$1483 7642 7997 5451 15 27 7995 MUX2_X1
* cell instance $1484 r0 *1 86.64,141.4
X$1484 7996 7939 7658 27 15 6330 MUX2_X2
* cell instance $1487 r0 *1 88.92,141.4
X$1487 7869 7938 15 27 7940 NOR2_X1
* cell instance $1491 r0 *1 91.96,141.4
X$1491 7773 7283 6696 15 27 7994 MUX2_X1
* cell instance $1493 r0 *1 94.81,141.4
X$1493 7934 15 27 7388 BUF_X1
* cell instance $1494 r0 *1 95.38,141.4
X$1494 7462 7862 6828 15 27 7941 MUX2_X1
* cell instance $1495 r0 *1 96.71,141.4
X$1495 7941 8017 7873 15 27 8086 MUX2_X1
* cell instance $1496 r0 *1 98.04,141.4
X$1496 7877 7278 7985 15 27 7874 MUX2_X1
* cell instance $1499 r0 *1 100.51,141.4
X$1499 8182 7991 7282 27 15 6150 MUX2_X2
* cell instance $1502 r0 *1 102.79,141.4
X$1502 7990 7281 7875 15 27 7991 MUX2_X1
* cell instance $1505 m0 *1 104.12,141.4
X$1505 7199 7914 7562 15 27 7875 MUX2_X1
* cell instance $1507 r0 *1 104.5,141.4
X$1507 7199 7447 7562 15 27 7942 MUX2_X1
* cell instance $1510 r0 *1 107.54,141.4
X$1510 6181 7554 7943 6744 7274 27 15 7944 OAI221_X1
* cell instance $1513 m0 *1 108.87,141.4
X$1513 7912 7450 7777 15 27 7842 MUX2_X1
* cell instance $1514 m0 *1 111.72,141.4
X$1514 8217 7905 7658 27 15 5843 MUX2_X2
* cell instance $1516 r0 *1 109.06,141.4
X$1516 8030 7500 6559 15 27 7912 MUX2_X1
* cell instance $1519 r0 *1 111.34,141.4
X$1519 7254 7275 7513 15 27 7985 MUX2_X1
* cell instance $1522 m0 *1 81.89,26.6
X$1522 1331 1299 1441 15 27 1440 MUX2_X1
* cell instance $1523 m0 *1 81.32,26.6
X$1523 1330 1331 15 27 1441 NAND2_X1
* cell instance $1524 m0 *1 83.22,26.6
X$1524 1440 1394 15 27 1369 NOR2_X1
* cell instance $1525 m0 *1 83.79,26.6
X$1525 1330 1244 15 27 1439 NAND2_X1
* cell instance $1529 m0 *1 89.68,26.6
X$1529 1438 1366 1534 27 1395 15 OAI21_X1
* cell instance $1532 m0 *1 92.15,26.6
X$1532 1247 1332 1398 27 1364 15 OAI21_X1
* cell instance $1533 m0 *1 92.91,26.6
X$1533 15 10346 1399 1364 1563 27 DFF_X1
* cell instance $1535 m0 *1 97.66,26.6
X$1535 1363 15 27 LOGIC0_X1
* cell instance $1536 m0 *1 98.04,26.6
X$1536 1158 1363 1334 27 15 1336 HA_X1
* cell instance $1537 m0 *1 99.94,26.6
X$1537 1335 1336 1334 27 15 1337 OAI21_X2
* cell instance $1538 m0 *1 101.27,26.6
X$1538 1360 1400 1160 27 1436 15 OAI21_X1
* cell instance $1539 m0 *1 102.03,26.6
X$1539 1335 15 27 1360 INV_X1
* cell instance $1540 m0 *1 102.41,26.6
X$1540 1338 15 27 1160 INV_X1
* cell instance $1544 r0 *1 81.51,26.6
X$1544 1461 1299 1439 15 27 1529 MUX2_X1
* cell instance $1545 r0 *1 82.84,26.6
X$1545 1529 1394 15 27 1530 NOR2_X1
* cell instance $1549 r0 *1 88.35,26.6
X$1549 15 10513 1396 1395 1563 27 DFF_X1
* cell instance $1552 r0 *1 92.15,26.6
X$1552 1397 1399 15 27 1398 NAND2_X1
* cell instance $1553 r0 *1 92.72,26.6
X$1553 1246 1248 1333 15 27 1463 NAND3_X1
* cell instance $1559 r0 *1 99.37,26.6
X$1559 1336 1334 1435 15 1400 27 AOI21_X1
* cell instance $1561 r0 *1 100.51,26.6
X$1561 111 1250 1335 27 15 1338 HA_X1
* cell instance $1565 m0 *1 104.88,26.6
X$1565 1339 1436 27 15 1402 AND2_X1
* cell instance $1568 m0 *1 105.83,26.6
X$1568 1340 1402 15 27 1162 OR2_X1
* cell instance $1575 r0 *1 105.26,26.6
X$1575 1403 1401 1466 15 27 1341 MUX2_X1
* cell instance $1576 r0 *1 106.59,26.6
X$1576 212 1403 1570 27 15 1468 HA_X1
* cell instance $1578 r0 *1 108.87,26.6
X$1578 1543 1468 15 27 1469 NOR2_X1
* cell instance $1579 r0 *1 109.44,26.6
X$1579 1470 1401 1404 15 27 1342 MUX2_X1
* cell instance $1583 r0 *1 112.86,26.6
X$1583 1405 1471 27 15 1531 XNOR2_X1
* cell instance $1584 r0 *1 114,26.6
X$1584 1405 15 27 1472 INV_X1
* cell instance $1585 r0 *1 114.38,26.6
X$1585 1533 15 27 1535 INV_X1
* cell instance $1586 r0 *1 114.76,26.6
X$1586 1406 1401 1531 15 27 1000 MUX2_X1
* cell instance $1592 r0 *1 117.8,26.6
X$1592 1577 27 1407 15 BUF_X4
* cell instance $1594 r0 *1 119.32,26.6
X$1594 1473 1407 1528 15 27 1082 MUX2_X1
* cell instance $1597 r0 *1 121.22,26.6
X$1597 1408 1527 27 15 1528 XNOR2_X1
* cell instance $1598 r0 *1 122.36,26.6
X$1598 1408 15 27 1475 INV_X1
* cell instance $1600 r0 *1 122.93,26.6
X$1600 388 1479 1433 27 15 1477 HA_X1
* cell instance $1601 m0 *1 123.12,26.6
X$1601 1433 15 27 1432 BUF_X2
* cell instance $1604 m0 *1 124.07,26.6
X$1604 1432 1478 27 15 1409 XNOR2_X1
* cell instance $1607 r0 *1 124.83,26.6
X$1607 1479 1407 1409 15 27 1003 MUX2_X1
* cell instance $1608 r0 *1 126.16,26.6
X$1608 1407 1479 1710 15 27 1429 NOR3_X1
* cell instance $1609 r0 *1 126.92,26.6
X$1609 1410 15 27 1480 INV_X1
* cell instance $1611 r0 *1 128.06,26.6
X$1611 1481 1409 1411 15 27 1343 NOR3_X1
* cell instance $1612 m0 *1 128.82,26.6
X$1612 1343 1429 843 27 1005 15 OAI21_X1
* cell instance $1616 m0 *1 132.81,26.6
X$1616 1254 15 27 1344 BUF_X2
* cell instance $1617 m0 *1 133.57,26.6
X$1617 1344 1345 1346 27 15 1089 OAI21_X2
* cell instance $1618 m0 *1 134.9,26.6
X$1618 843 1287 1344 1094 15 27 1355 NAND4_X1
* cell instance $1619 m0 *1 135.85,26.6
X$1619 925 15 27 1177 BUF_X1
* cell instance $1621 m0 *1 136.61,26.6
X$1621 1344 1582 15 27 1347 NAND2_X2
* cell instance $1623 m0 *1 138.32,26.6
X$1623 1412 1510 15 27 1348 XNOR2_X2
* cell instance $1626 r0 *1 129.2,26.6
X$1626 15 1253 1522 1411 1580 27 AOI21_X4
* cell instance $1627 r0 *1 131.67,26.6
X$1627 1481 1515 1482 27 15 1128 OAI21_X4
* cell instance $1630 r0 *1 137.56,26.6
X$1630 1510 1412 27 1093 15 XOR2_X2
* cell instance $1632 m0 *1 140.79,26.6
X$1632 1257 1347 1348 1091 15 27 1182 NOR4_X1
* cell instance $1637 r0 *1 143.07,26.6
X$1637 1508 1407 1413 15 1258 27 AOI21_X2
* cell instance $1639 r0 *1 145.16,26.6
X$1639 1487 1592 27 15 948 AND2_X1
* cell instance $1640 r0 *1 145.92,26.6
X$1640 1413 1488 1482 27 15 1594 OAI21_X2
* cell instance $1641 r0 *1 147.25,26.6
X$1641 1484 1587 1586 1414 15 27 1415 NOR4_X1
* cell instance $1642 m0 *1 148.96,26.6
X$1642 1425 1415 15 27 1505 NAND2_X1
* cell instance $1643 m0 *1 148.2,26.6
X$1643 1415 1425 15 27 1349 OR2_X1
* cell instance $1645 m0 *1 149.72,26.6
X$1645 1349 1424 1188 15 27 1260 NAND3_X2
* cell instance $1646 m0 *1 151.05,26.6
X$1646 1188 1424 27 15 308 AND2_X1
* cell instance $1647 m0 *1 151.81,26.6
X$1647 1422 750 862 749 15 27 1276 NOR4_X1
* cell instance $1650 r0 *1 148.39,26.6
X$1650 1349 1411 1505 27 15 1259 OAI21_X2
* cell instance $1653 r0 *1 150.86,26.6
X$1653 1411 1417 15 27 1185 OR2_X2
* cell instance $1656 r0 *1 152.76,26.6
X$1656 1500 1490 15 27 1422 XOR2_X1
* cell instance $1657 m0 *1 153.33,26.6
X$1657 1416 1421 15 27 862 XNOR2_X2
* cell instance $1659 m0 *1 155.23,26.6
X$1659 1421 1416 27 932 15 XOR2_X2
* cell instance $1661 m0 *1 157.7,26.6
X$1661 1263 1185 15 27 1100 OR2_X1
* cell instance $1662 m0 *1 158.46,26.6
X$1662 1420 1185 1265 15 27 1192 NAND3_X1
* cell instance $1664 r0 *1 153.9,26.6
X$1664 1500 1490 15 27 751 XNOR2_X2
* cell instance $1666 r0 *1 157.32,26.6
X$1666 1497 1263 1417 15 27 1492 OR3_X1
* cell instance $1667 r0 *1 158.27,26.6
X$1667 1417 1497 1265 27 1498 15 OAI21_X1
* cell instance $1669 m0 *1 160.74,26.6
X$1669 1350 1264 15 27 1352 NAND2_X1
* cell instance $1670 m0 *1 159.6,26.6
X$1670 1188 1351 27 15 1350 XNOR2_X1
* cell instance $1671 m0 *1 161.31,26.6
X$1671 1185 1017 15 27 1351 NAND2_X1
* cell instance $1679 r0 *1 159.98,26.6
X$1679 1270 15 27 1493 INV_X1
* cell instance $1680 r0 *1 160.36,26.6
X$1680 1493 1188 27 15 1268 AND2_X1
* cell instance $1691 m0 *1 7.41,35
X$1691 1851 1767 1906 15 27 1852 MUX2_X1
* cell instance $1692 m0 *1 5.7,35
X$1692 1852 1849 1546 27 15 1763 MUX2_X2
* cell instance $1693 m0 *1 8.74,35
X$1693 1853 1877 1499 1766 27 15 1849 OAI22_X1
* cell instance $1694 m0 *1 9.69,35
X$1694 1877 1818 15 27 1851 NOR2_X1
* cell instance $1696 m0 *1 11.78,35
X$1696 1819 15 27 1767 INV_X4
* cell instance $1701 m0 *1 18.24,35
X$1701 1612 1821 1768 15 27 1820 MUX2_X1
* cell instance $1707 m0 *1 3.61,35
X$1707 1763 1673 1903 15 27 NOR2_X4
* cell instance $1716 r0 *1 5.32,35
X$1716 1906 1905 15 27 1904 NAND2_X1
* cell instance $1717 r0 *1 5.89,35
X$1717 1907 1767 1930 15 27 1875 MUX2_X1
* cell instance $1718 r0 *1 7.22,35
X$1718 408 1876 15 27 1907 NAND2_X1
* cell instance $1719 r0 *1 7.79,35
X$1719 1765 1876 357 1905 15 27 1908 AOI22_X1
* cell instance $1720 r0 *1 8.74,35
X$1720 1877 15 27 1876 INV_X2
* cell instance $1724 r0 *1 17.29,35
X$1724 1546 27 1821 15 BUF_X4
* cell instance $1727 m0 *1 21.47,35
X$1727 1503 1821 1769 15 27 2042 MUX2_X1
* cell instance $1728 m0 *1 23.56,35
X$1728 1682 1680 1681 15 1800 27 AOI21_X1
* cell instance $1730 m0 *1 25.08,35
X$1730 1680 1854 27 15 1878 XNOR2_X1
* cell instance $1736 r0 *1 24.51,35
X$1736 1504 1821 1878 15 27 2043 MUX2_X1
* cell instance $1738 m0 *1 27.17,35
X$1738 1822 1823 1801 27 15 1681 OAI21_X2
* cell instance $1739 m0 *1 26.6,35
X$1739 1802 1822 15 27 1737 NAND2_X1
* cell instance $1741 m0 *1 28.69,35
X$1741 1770 15 27 1823 INV_X1
* cell instance $1742 m0 *1 29.07,35
X$1742 1771 1770 1824 15 1854 27 AOI21_X1
* cell instance $1744 m0 *1 30.02,35
X$1744 1825 1826 1770 27 1802 15 OAI21_X1
* cell instance $1745 m0 *1 30.78,35
X$1745 1825 15 27 1879 INV_X1
* cell instance $1749 r0 *1 27.93,35
X$1749 1771 15 27 1822 INV_X1
* cell instance $1750 r0 *1 28.31,35
X$1750 1320 1821 1912 15 27 2045 MUX2_X1
* cell instance $1751 r0 *1 29.64,35
X$1751 1802 1913 27 15 1912 AND2_X1
* cell instance $1752 r0 *1 30.4,35
X$1752 1879 1880 1857 27 1824 15 OAI21_X1
* cell instance $1753 r0 *1 31.16,35
X$1753 1857 1823 1879 15 27 1913 NAND3_X1
* cell instance $1754 m0 *1 31.92,35
X$1754 1826 1825 1773 15 1801 27 AOI21_X1
* cell instance $1755 m0 *1 31.54,35
X$1755 1826 15 27 1857 INV_X1
* cell instance $1757 m0 *1 33.44,35
X$1757 43 1978 1915 27 15 1826 HA_X1
* cell instance $1760 m0 *1 38.57,35
X$1760 1861 15 27 LOGIC0_X1
* cell instance $1761 m0 *1 38.95,35
X$1761 43 1861 1452 27 15 1863 HA_X1
* cell instance $1762 m0 *1 40.85,35
X$1762 1775 1827 27 15 1774 XNOR2_X1
* cell instance $1763 m0 *1 41.99,35
X$1763 1683 1863 1452 27 15 1865 OAI21_X2
* cell instance $1764 m0 *1 43.32,35
X$1764 1777 1683 1827 15 1804 27 AOI21_X1
* cell instance $1766 m0 *1 44.27,35
X$1766 1865 1828 15 27 1684 NAND2_X2
* cell instance $1767 m0 *1 45.22,35
X$1767 1777 15 27 1828 INV_X1
* cell instance $1769 m0 *1 46.36,35
X$1769 1866 15 27 1602 INV_X1
* cell instance $1772 m0 *1 48.45,35
X$1772 548 1935 1150 15 27 1866 MUX2_X1
* cell instance $1774 m0 *1 50.54,35
X$1774 1829 1687 15 27 1150 XNOR2_X2
* cell instance $1775 m0 *1 52.44,35
X$1775 1779 1689 15 27 1688 NAND2_X1
* cell instance $1776 m0 *1 53.01,35
X$1776 1779 15 27 1829 INV_X1
* cell instance $1779 r0 *1 32.3,35
X$1779 1825 1880 27 15 1881 XNOR2_X1
* cell instance $1781 r0 *1 33.63,35
X$1781 1915 15 27 1825 BUF_X1
* cell instance $1785 r0 *1 41.23,35
X$1785 1863 15 27 1916 INV_X1
* cell instance $1786 r0 *1 41.61,35
X$1786 1772 1830 1452 27 1882 15 OAI21_X1
* cell instance $1787 r0 *1 42.37,35
X$1787 1882 1916 15 27 1827 NAND2_X1
* cell instance $1792 r0 *1 48.07,35
X$1792 1830 27 1435 15 BUF_X4
* cell instance $1794 r0 *1 49.59,35
X$1794 1030 1604 15 27 1830 OR2_X2
* cell instance $1796 r0 *1 50.73,35
X$1796 1883 1328 1772 27 15 1934 OAI21_X2
* cell instance $1800 m0 *1 53.77,35
X$1800 15 1619 1690 1807 1918 27 AOI21_X4
* cell instance $1803 r0 *1 54.53,35
X$1803 1030 1604 27 15 1883 AND2_X2
* cell instance $1807 r0 *1 57.95,35
X$1807 1919 1883 722 1884 15 1918 27 NAND4_X2
* cell instance $1809 m0 *1 58.14,35
X$1809 1691 15 27 1919 INV_X4
* cell instance $1816 r0 *1 61.37,35
X$1816 1939 15 27 1922 INV_X1
* cell instance $1817 r0 *1 61.75,35
X$1817 1885 1922 15 27 1886 NAND2_X1
* cell instance $1818 r0 *1 62.32,35
X$1818 1886 1831 1923 27 15 1561 OAI21_X2
* cell instance $1820 m0 *1 62.51,35
X$1820 1661 1831 1686 15 27 NOR2_X4
* cell instance $1821 m0 *1 64.98,35
X$1821 1830 43 1887 15 27 1444 MUX2_X1
* cell instance $1822 m0 *1 66.31,35
X$1822 1831 27 553 15 BUF_X4
* cell instance $1823 m0 *1 67.64,35
X$1823 1781 1889 1782 1780 1831 27 15 AOI211_X2
* cell instance $1825 r0 *1 63.65,35
X$1825 1883 212 1391 15 27 1888 NAND3_X1
* cell instance $1826 r0 *1 64.41,35
X$1826 1883 1887 787 15 27 NOR2_X4
* cell instance $1827 r0 *1 66.12,35
X$1827 1782 1780 1888 1889 15 27 456 AOI211_X4
* cell instance $1828 r0 *1 68.21,35
X$1828 1782 1780 1889 1628 15 27 1772 AOI211_X4
* cell instance $1830 m0 *1 69.73,35
X$1830 1693 1783 1814 27 15 1782 OAI21_X2
* cell instance $1831 m0 *1 71.25,35
X$1831 1832 15 27 1814 INV_X1
* cell instance $1833 m0 *1 71.82,35
X$1833 1693 15 27 1874 INV_X1
* cell instance $1834 m0 *1 72.2,35
X$1834 1874 1890 1832 15 1816 27 AOI21_X2
* cell instance $1836 m0 *1 73.72,35
X$1836 1832 1694 1833 15 27 1605 OR3_X2
* cell instance $1837 m0 *1 74.86,35
X$1837 1833 1696 15 111 27 NAND2_X4
* cell instance $1838 m0 *1 76.57,35
X$1838 1783 27 1526 15 BUF_X4
* cell instance $1839 m0 *1 77.9,35
X$1839 1670 15 27 1783 CLKBUF_X3
* cell instance $1840 m0 *1 78.85,35
X$1840 1873 27 1833 15 BUF_X4
* cell instance $1843 m0 *1 81.89,35
X$1843 1698 1784 10859 27 15 1873 HA_X1
* cell instance $1844 m0 *1 83.79,35
X$1844 1785 27 1694 15 BUF_X4
* cell instance $1848 r0 *1 70.68,35
X$1848 1783 15 27 1890 INV_X4
* cell instance $1849 r0 *1 71.63,35
X$1849 365 1890 1925 27 15 1889 OAI21_X2
* cell instance $1851 r0 *1 73.72,35
X$1851 1833 1694 1832 15 27 1925 NOR3_X1
* cell instance $1855 r0 *1 76.57,35
X$1855 1694 1783 15 388 27 NAND2_X4
* cell instance $1856 r0 *1 78.28,35
X$1856 1833 1526 15 295 27 NAND2_X4
* cell instance $1857 r0 *1 79.99,35
X$1857 15 1892 1245 1784 1630 27 DFF_X2
* cell instance $1859 r0 *1 84.36,35
X$1859 1630 15 27 1987 BUF_X2
* cell instance $1861 m0 *1 88.16,35
X$1861 1697 1784 10851 27 15 1871 HA_X1
* cell instance $1862 m0 *1 86.26,35
X$1862 1698 1784 10858 27 15 1872 HA_X1
* cell instance $1863 m0 *1 90.06,35
X$1863 1872 1699 15 27 1834 NAND2_X1
* cell instance $1866 m0 *1 91.58,35
X$1866 1834 1786 15 27 1815 XOR2_X1
* cell instance $1867 m0 *1 92.72,35
X$1867 1871 1787 15 27 1786 NAND2_X1
* cell instance $1871 r0 *1 87.59,35
X$1871 1891 1964 27 15 1893 AND2_X1
* cell instance $1875 r0 *1 89.68,35
X$1875 1701 1699 1893 27 15 2058 AND3_X1
* cell instance $1877 r0 *1 92.15,35
X$1877 1699 1871 1893 27 15 1894 AND3_X1
* cell instance $1878 r0 *1 93.1,35
X$1878 1701 1787 1893 27 15 1929 AND3_X1
* cell instance $1879 m0 *1 93.86,35
X$1879 1835 1815 27 15 1870 XNOR2_X1
* cell instance $1884 r0 *1 94.05,35
X$1884 1870 1893 15 27 1928 NAND2_X1
* cell instance $1885 r0 *1 94.62,35
X$1885 1700 1929 1927 27 15 1926 HA_X1
* cell instance $1886 r0 *1 96.52,35
X$1886 1399 1926 27 15 1895 XNOR2_X1
* cell instance $1889 m0 *1 104.88,35
X$1889 1158 1813 1703 27 15 1705 HA_X1
* cell instance $1890 m0 *1 104.5,35
X$1890 1813 15 27 LOGIC0_X1
* cell instance $1893 m0 *1 107.73,35
X$1893 111 1869 1788 27 15 1789 HA_X1
* cell instance $1895 m0 *1 110.39,35
X$1895 1836 1810 15 27 1811 XOR2_X1
* cell instance $1896 m0 *1 111.53,35
X$1896 212 1809 1836 27 15 1867 HA_X1
* cell instance $1897 m0 *1 113.43,35
X$1897 1868 1837 1867 27 15 1838 OAI21_X4
* cell instance $1901 r0 *1 107.92,35
X$1901 1869 1706 1760 15 27 1403 MUX2_X1
* cell instance $1904 r0 *1 110.96,35
X$1904 1810 1836 27 1837 15 AND2_X4
* cell instance $1907 r0 *1 114.57,35
X$1907 1868 1867 1837 15 27 1924 OR3_X1
* cell instance $1912 r0 *1 115.71,35
X$1912 1838 1924 27 15 1707 AND2_X1
* cell instance $1913 m0 *1 116.47,35
X$1913 1791 1838 15 1808 27 NAND2_X4
* cell instance $1916 m0 *1 118.37,35
X$1916 195 1792 1709 27 15 1896 HA_X1
* cell instance $1923 r0 *1 119.32,35
X$1923 1898 1896 1806 15 27 1897 OR3_X1
* cell instance $1926 r0 *1 121.22,35
X$1926 1898 1896 1806 27 15 1920 OAI21_X4
* cell instance $1927 m0 *1 121.6,35
X$1927 295 1864 1898 27 15 1960 HA_X1
* cell instance $1931 m0 *1 129.77,35
X$1931 1713 1862 1842 27 15 1710 MUX2_X2
* cell instance $1934 r0 *1 123.69,35
X$1934 1864 1706 1921 15 27 1479 MUX2_X1
* cell instance $1938 r0 *1 129.01,35
X$1938 1958 15 27 1862 INV_X1
* cell instance $1941 m0 *1 132.81,35
X$1941 1519 1579 15 27 1858 NOR2_X2
* cell instance $1944 m0 *1 135.28,35
X$1944 15 1840 1860 1583 1859 1858 1900 1842 27 AOI222_X2
* cell instance $1946 m0 *1 138.13,35
X$1946 1947 1842 15 27 1794 NOR2_X1
* cell instance $1950 r0 *1 134.14,35
X$1950 1750 15 27 1899 INV_X1
* cell instance $1952 r0 *1 134.71,35
X$1952 1995 1839 15 27 1917 NOR2_X1
* cell instance $1953 r0 *1 135.28,35
X$1953 1899 1944 1793 15 27 1839 NOR3_X1
* cell instance $1954 r0 *1 136.04,35
X$1954 15 1840 1860 1412 1842 1900 27 AOI22_X4
* cell instance $1956 m0 *1 141.36,35
X$1956 1843 1855 15 27 1795 NOR2_X1
* cell instance $1957 m0 *1 140.6,35
X$1957 1855 1843 15 27 1803 OR2_X1
* cell instance $1961 r0 *1 140.98,35
X$1961 1841 1949 15 27 1910 NAND2_X1
* cell instance $1962 r0 *1 141.55,35
X$1962 1812 1914 15 27 1855 NOR2_X1
* cell instance $1963 r0 *1 142.12,35
X$1963 1911 1597 15 27 1997 NOR2_X1
* cell instance $1964 r0 *1 142.69,35
X$1964 1841 15 27 1911 INV_X1
* cell instance $1967 m0 *1 145.35,35
X$1967 15 1488 1586 1587 1720 1645 27 OR4_X4
* cell instance $1968 m0 *1 148.01,35
X$1968 1909 1844 1482 1488 1847 15 27 OAI211_X2
* cell instance $1972 r0 *1 146.68,35
X$1972 1270 1954 1597 2078 1844 27 15 AOI211_X2
* cell instance $1973 r0 *1 148.39,35
X$1973 1951 1586 1414 27 1909 15 NOR3_X2
* cell instance $1975 m0 *1 153.52,35
X$1975 1797 1845 27 15 1723 AND2_X2
* cell instance $1976 m0 *1 150.1,35
X$1976 15 1491 1850 1489 1723 1500 27 NAND4_X4
* cell instance $1977 m0 *1 154.47,35
X$1977 1725 1730 15 27 1850 NAND2_X1
* cell instance $1978 m0 *1 155.04,35
X$1978 1489 1723 1491 27 15 2003 AND3_X1
* cell instance $1979 m0 *1 155.99,35
X$1979 1901 1489 1646 15 1848 27 AOI21_X2
* cell instance $1982 r0 *1 150.86,35
X$1982 1909 1716 1845 15 27 1796 NAND3_X1
* cell instance $1985 r0 *1 152.76,35
X$1985 15 1730 1491 1797 1845 1482 27 NAND4_X4
* cell instance $1988 r0 *1 156.75,35
X$1988 15 851 1902 1848 2007 27 AOI21_X4
* cell instance $1990 m0 *1 157.7,35
X$1990 1846 1847 15 27 938 XNOR2_X2
* cell instance $2008 m0 *1 114,141.4
X$2008 7983 7876 7658 27 15 6216 MUX2_X2
* cell instance $2012 r0 *1 114,141.4
X$2012 7982 7858 7910 15 27 7876 MUX2_X1
* cell instance $2017 r0 *1 115.71,141.4
X$2017 7945 7981 5461 15 27 7877 MUX2_X1
* cell instance $2019 m0 *1 116.09,141.4
X$2019 6832 7857 7558 15 27 7910 MUX2_X1
* cell instance $2023 r0 *1 118.18,141.4
X$2023 7980 7452 6480 15 27 7839 MUX2_X1
* cell instance $2025 m0 *1 121.03,141.4
X$2025 6834 7734 7298 15 27 7909 MUX2_X1
* cell instance $2027 m0 *1 122.36,141.4
X$2027 7640 7734 6829 15 27 7878 MUX2_X1
* cell instance $2031 r0 *1 121.22,141.4
X$2031 7945 7734 5461 15 27 7946 MUX2_X1
* cell instance $2034 r0 *1 123.5,141.4
X$2034 7878 8017 7909 15 27 7979 MUX2_X1
* cell instance $2035 m0 *1 125.02,141.4
X$2035 7906 7542 7907 15 27 7833 MUX2_X1
* cell instance $2037 m0 *1 126.35,141.4
X$2037 7124 7442 7779 15 27 7907 MUX2_X1
* cell instance $2039 m0 *1 128.44,141.4
X$2039 7620 7559 15 7677 27 NAND2_X4
* cell instance $2040 m0 *1 130.15,141.4
X$2040 7083 7653 7620 15 27 7879 MUX2_X1
* cell instance $2041 m0 *1 131.48,141.4
X$2041 7976 7654 7879 15 27 7905 MUX2_X1
* cell instance $2042 m0 *1 132.81,141.4
X$2042 7083 7762 7620 15 27 7780 MUX2_X1
* cell instance $2047 r0 *1 127.3,141.4
X$2047 7947 7442 6767 15 27 7906 MUX2_X1
* cell instance $2048 r0 *1 128.63,141.4
X$2048 8035 7653 6699 15 27 7976 MUX2_X1
* cell instance $2050 r0 *1 130.34,141.4
X$2050 7947 7948 6767 15 27 7975 MUX2_X1
* cell instance $2051 r0 *1 131.67,141.4
X$2051 7124 7948 7779 15 27 7973 MUX2_X1
* cell instance $2052 r0 *1 133,141.4
X$2052 7975 8012 7973 15 27 7972 MUX2_X1
* cell instance $2055 m0 *1 134.52,141.4
X$2055 7295 6224 15 27 7903 NAND2_X1
* cell instance $2057 m0 *1 138.7,141.4
X$2057 6700 7130 15 27 7781 OR2_X1
* cell instance $2064 r0 *1 143.45,141.4
X$2064 7158 15 27 7783 INV_X1
* cell instance $2067 r0 *1 144.78,141.4
X$2067 7969 7126 4594 15 27 NOR2_X4
* cell instance $2069 m0 *1 145.16,141.4
X$2069 6990 7158 15 27 7881 OR2_X2
* cell instance $2070 r0 *1 146.49,141.4
X$2070 7950 15 27 7785 INV_X2
* cell instance $2072 m0 *1 146.49,141.4
X$2072 7880 15 27 7679 INV_X1
* cell instance $2073 r0 *1 147.06,141.4
X$2073 5978 7126 15 7065 27 OR2_X4
* cell instance $2075 m0 *1 147.25,141.4
X$2075 7881 15 27 7786 INV_X1
* cell instance $2077 m0 *1 149.91,141.4
X$2077 7131 15 27 7882 INV_X1
* cell instance $2078 m0 *1 150.29,141.4
X$2078 7125 7418 15 27 7949 NAND2_X1
* cell instance $2082 r0 *1 148.77,141.4
X$2082 15 7949 7965 7964 7966 7880 27 FA_X1
* cell instance $2086 m0 *1 153.52,141.4
X$2086 15 7785 7817 7883 7818 7900 27 FA_X1
* cell instance $2087 m0 *1 159.6,141.4
X$2087 7884 15 27 7816 INV_X1
* cell instance $2091 r0 *1 153.9,141.4
X$2091 7964 15 27 7963 INV_X1
* cell instance $2092 r0 *1 154.28,141.4
X$2092 15 8039 8064 8235 7963 7883 27 FA_X1
* cell instance $2095 m0 *1 161.12,141.4
X$2095 8059 15 27 7815 INV_X1
* cell instance $2096 m0 *1 163.78,141.4
X$2096 7885 7899 15 27 7681 XNOR2_X2
* cell instance $2097 m0 *1 161.88,141.4
X$2097 7594 7962 7236 27 15 7899 HA_X1
* cell instance $2103 m0 *1 167.58,141.4
X$2103 7319 7881 7896 27 15 7898 HA_X1
* cell instance $2106 r0 *1 168.72,141.4
X$2106 7809 15 27 7951 INV_X1
* cell instance $2109 m0 *1 170.62,141.4
X$2109 7401 7406 10876 27 15 7897 HA_X1
* cell instance $2115 r0 *1 173.66,141.4
X$2115 7489 7950 7959 27 15 7960 HA_X1
* cell instance $2116 m0 *1 176.7,141.4
X$2116 15 7891 7804 8136 7141 7892 27 FA_X1
* cell instance $2117 m0 *1 173.66,141.4
X$2117 15 7960 7791 7952 7895 7896 27 FA_X1
* cell instance $2119 m0 *1 179.93,141.4
X$2119 7319 7406 8048 27 15 7891 HA_X1
* cell instance $2121 m0 *1 182.02,141.4
X$2121 15 7490 7793 7887 7065 7478 27 FA_X1
* cell instance $2126 r0 *1 178.6,141.4
X$2126 7687 15 27 7953 INV_X1
* cell instance $2131 r0 *1 183.35,141.4
X$2131 7693 15 27 7955 INV_X1
* cell instance $2133 r0 *1 183.92,141.4
X$2133 7954 7794 7956 27 15 8244 HA_X1
* cell instance $2136 m0 *1 1.33,57.4
X$2136 2109 2711 3047 27 15 3046 OAI21_X4
* cell instance $2138 m0 *1 3.8,57.4
X$2138 2711 3047 15 27 3109 OR2_X1
* cell instance $2140 m0 *1 4.75,57.4
X$2140 2249 2410 15 27 3048 OR2_X2
* cell instance $2141 m0 *1 5.7,57.4
X$2141 2410 2249 15 27 3147 NOR2_X2
* cell instance $2143 m0 *1 8.17,57.4
X$2143 3050 3051 3111 27 15 3013 OAI21_X2
* cell instance $2144 m0 *1 9.5,57.4
X$2144 2522 2853 2926 15 3111 27 AOI21_X2
* cell instance $2145 m0 *1 10.83,57.4
X$2145 2163 2621 27 15 3091 XNOR2_X1
* cell instance $2146 m0 *1 11.97,57.4
X$2146 2621 15 27 3112 INV_X1
* cell instance $2147 m0 *1 12.35,57.4
X$2147 2621 2927 15 27 3089 NOR2_X1
* cell instance $2148 m0 *1 12.92,57.4
X$2148 3090 3091 1499 3112 27 15 3312 OAI22_X1
* cell instance $2149 m0 *1 13.87,57.4
X$2149 2789 15 27 3114 INV_X1
* cell instance $2151 m0 *1 15.01,57.4
X$2151 3152 3090 15 27 3115 NOR2_X1
* cell instance $2157 r0 *1 2.66,57.4
X$2157 3146 3109 15 27 3307 NOR2_X1
* cell instance $2162 r0 *1 3.42,57.4
X$2162 2755 2614 15 27 3146 NOR2_X1
* cell instance $2165 r0 *1 4.56,57.4
X$2165 2614 2963 15 27 3110 OR2_X2
* cell instance $2167 r0 *1 5.7,57.4
X$2167 2572 3048 3049 2891 2614 2963 15 27 3148 OAI33_X1
* cell instance $2170 r0 *1 8.17,57.4
X$2170 3112 2163 15 27 3229 NOR2_X1
* cell instance $2171 r0 *1 8.74,57.4
X$2171 3089 3113 2852 27 15 3149 MUX2_X2
* cell instance $2172 r0 *1 10.45,57.4
X$2172 3173 2851 3172 15 27 3174 NAND3_X2
* cell instance $2173 r0 *1 11.78,57.4
X$2173 3310 3113 15 27 3152 NOR2_X1
* cell instance $2174 r0 *1 12.35,57.4
X$2174 2789 2927 15 27 3113 NOR2_X1
* cell instance $2175 r0 *1 12.92,57.4
X$2175 3112 3114 2853 27 15 3231 MUX2_X2
* cell instance $2177 r0 *1 14.82,57.4
X$2177 3115 3127 2789 15 3154 27 AOI21_X1
* cell instance $2178 r0 *1 15.58,57.4
X$2178 3175 3116 15 27 3117 OR2_X2
* cell instance $2180 m0 *1 15.96,57.4
X$2180 3092 3117 2621 357 15 27 3232 AOI22_X2
* cell instance $2182 m0 *1 19.38,57.4
X$2182 3094 3148 3020 27 15 3155 AND3_X1
* cell instance $2187 r0 *1 16.53,57.4
X$2187 3232 3154 2852 27 15 3050 MUX2_X2
* cell instance $2188 r0 *1 18.24,57.4
X$2188 3233 15 27 2929 BUF_X2
* cell instance $2190 r0 *1 22.04,57.4
X$2190 295 2928 3236 27 15 3235 HA_X1
* cell instance $2191 r0 *1 23.94,57.4
X$2191 3236 15 27 2966 BUF_X1
* cell instance $2192 r0 *1 24.51,57.4
X$2192 195 2497 3315 27 15 3237 HA_X1
* cell instance $2194 m0 *1 29.26,57.4
X$2194 138 2859 2930 27 15 3157 HA_X1
* cell instance $2196 m0 *1 31.16,57.4
X$2196 3052 3096 27 15 3161 AND2_X1
* cell instance $2201 r0 *1 29.83,57.4
X$2201 3157 15 27 3159 INV_X1
* cell instance $2202 r0 *1 30.21,57.4
X$2202 3052 3159 15 3178 27 NAND2_X4
* cell instance $2203 r0 *1 31.92,57.4
X$2203 2859 2858 3161 15 27 3179 MUX2_X1
* cell instance $2206 r0 *1 34.2,57.4
X$2206 3118 2863 3180 27 3269 15 OAI21_X1
* cell instance $2207 m0 *1 34.77,57.4
X$2207 2978 15 27 3118 INV_X1
* cell instance $2209 m0 *1 35.15,57.4
X$2209 3097 2968 3053 27 3238 15 OAI21_X1
* cell instance $2210 m0 *1 35.91,57.4
X$2210 3028 15 27 3053 INV_X1
* cell instance $2214 m0 *1 40.28,57.4
X$2214 2934 2052 3054 15 3162 27 AOI21_X1
* cell instance $2217 r0 *1 34.96,57.4
X$2217 2863 3118 15 27 3181 OR2_X1
* cell instance $2220 r0 *1 36.86,57.4
X$2220 15 2629 27 3239 BUF_X8
* cell instance $2221 r0 *1 39.33,57.4
X$2221 3239 27 2337 15 BUF_X4
* cell instance $2223 r0 *1 40.85,57.4
X$2223 195 3164 3056 27 15 3240 HA_X1
* cell instance $2224 m0 *1 44.84,57.4
X$2224 2934 15 27 3099 INV_X1
* cell instance $2225 m0 *1 42.18,57.4
X$2225 15 1981 3099 3396 3055 27 NOR3_X4
* cell instance $2226 m0 *1 45.22,57.4
X$2226 3164 2632 2980 15 27 3165 MUX2_X1
* cell instance $2227 m0 *1 46.55,57.4
X$2227 3119 15 27 2794 BUF_X1
* cell instance $2229 r0 *1 42.75,57.4
X$2229 15 3272 3240 3031 3056 27 AOI21_X4
* cell instance $2230 r0 *1 45.22,57.4
X$2230 3099 2052 2337 15 3120 27 AOI21_X2
* cell instance $2233 r0 *1 47.12,57.4
X$2233 295 3165 3119 27 15 3102 HA_X1
* cell instance $2234 m0 *1 47.69,57.4
X$2234 2981 3057 15 27 3058 NOR2_X1
* cell instance $2236 m0 *1 48.26,57.4
X$2236 3058 3102 2594 27 3035 15 OAI21_X1
* cell instance $2239 r0 *1 49.21,57.4
X$2239 3034 2934 2366 27 3168 15 OAI21_X1
* cell instance $2241 m0 *1 49.4,57.4
X$2241 15 3361 3102 2794 3103 27 AOI21_X4
* cell instance $2243 m0 *1 52.82,57.4
X$2243 3060 3121 3170 15 3123 27 AOI21_X2
* cell instance $2244 m0 *1 54.15,57.4
X$2244 2934 2936 3059 15 27 3060 OR3_X2
* cell instance $2245 m0 *1 55.29,57.4
X$2245 2936 1631 15 27 3171 NAND2_X1
* cell instance $2248 r0 *1 50.16,57.4
X$2248 3274 3034 15 27 3166 NAND2_X1
* cell instance $2249 r0 *1 50.73,57.4
X$2249 3165 3241 2935 27 15 3278 MUX2_X2
* cell instance $2250 r0 *1 52.44,57.4
X$2250 3243 3170 3121 3120 15 3125 27 NAND4_X2
* cell instance $2252 r0 *1 54.34,57.4
X$2252 15 3059 3122 3060 3124 3243 27 OAI22_X4
* cell instance $2254 m0 *1 56.24,57.4
X$2254 15 2937 2936 3186 2775 3184 27 OAI211_X4
* cell instance $2255 m0 *1 60.23,57.4
X$2255 2982 3040 2984 27 15 3276 OAI21_X4
* cell instance $2257 m0 *1 63.46,57.4
X$2257 357 27 3127 15 BUF_X4
* cell instance $2259 m0 *1 66.31,57.4
X$2259 295 3042 2868 27 15 3107 HA_X1
* cell instance $2260 m0 *1 68.21,57.4
X$2260 3107 15 27 2985 INV_X1
* cell instance $2263 m0 *1 69.54,57.4
X$2263 3042 2987 2780 27 15 3191 MUX2_X2
* cell instance $2268 m0 *1 76.76,57.4
X$2268 2801 2802 2989 27 3061 15 OAI21_X1
* cell instance $2270 r0 *1 57.57,57.4
X$2270 3123 3185 3124 15 27 2691 OR3_X1
* cell instance $2271 r0 *1 58.52,57.4
X$2271 15 3123 3185 3124 2804 27 NOR3_X4
* cell instance $2275 r0 *1 61.18,57.4
X$2275 3126 3125 3187 15 2805 27 NAND3_X4
* cell instance $2277 r0 *1 63.84,57.4
X$2277 2512 2972 15 27 3189 NAND2_X1
* cell instance $2280 r0 *1 64.98,57.4
X$2280 3127 27 244 15 BUF_X4
* cell instance $2283 r0 *1 72.58,57.4
X$2283 3252 15 27 3062 BUF_X2
* cell instance $2285 r0 *1 73.53,57.4
X$2285 295 3169 3252 27 15 3192 HA_X1
* cell instance $2287 r0 *1 75.62,57.4
X$2287 3192 3062 2988 27 3329 15 OAI21_X1
* cell instance $2289 r0 *1 76.57,57.4
X$2289 3192 15 27 3129 INV_X1
* cell instance $2290 r0 *1 76.95,57.4
X$2290 3167 2989 3129 27 3255 15 OAI21_X1
* cell instance $2292 m0 *1 78.09,57.4
X$2292 3062 15 27 3167 INV_X1
* cell instance $2294 m0 *1 78.47,57.4
X$2294 2934 2438 27 15 3108 XNOR2_X1
* cell instance $2295 m0 *1 79.61,57.4
X$2295 3166 3108 27 15 3106 XNOR2_X1
* cell instance $2296 m0 *1 80.75,57.4
X$2296 2804 3063 2990 2942 2946 27 15 AOI211_X2
* cell instance $2297 m0 *1 82.46,57.4
X$2297 2779 3281 3063 15 27 3064 NOR3_X1
* cell instance $2298 m0 *1 83.22,57.4
X$2298 3163 3064 1631 27 2994 15 OAI21_X1
* cell instance $2300 m0 *1 84.17,57.4
X$2300 3030 1631 3106 15 3156 27 AOI21_X2
* cell instance $2302 m0 *1 85.69,57.4
X$2302 2739 2946 2970 15 27 3282 OR3_X1
* cell instance $2303 m0 *1 86.64,57.4
X$2303 2970 2946 2739 27 3065 15 NOR3_X2
* cell instance $2305 r0 *1 77.9,57.4
X$2305 3129 3167 2941 27 15 3258 OAI21_X2
* cell instance $2309 r0 *1 81.7,57.4
X$2309 2691 3194 2805 15 27 3163 NOR3_X1
* cell instance $2313 r0 *1 86.64,57.4
X$2313 2517 15 27 3195 INV_X1
* cell instance $2314 r0 *1 87.02,57.4
X$2314 3065 3195 15 27 3130 NOR2_X1
* cell instance $2316 m0 *1 88.54,57.4
X$2316 3104 15 27 3260 INV_X2
* cell instance $2318 m0 *1 89.11,57.4
X$2318 2946 2970 15 27 2642 OR2_X1
* cell instance $2321 m0 *1 90.25,57.4
X$2321 2970 2946 2991 2947 27 3160 15 NOR4_X2
* cell instance $2322 m0 *1 92.15,57.4
X$2322 2947 2993 3068 27 3066 15 OAI21_X1
* cell instance $2324 m0 *1 93.1,57.4
X$2324 2784 2945 3044 15 27 3067 NOR3_X1
* cell instance $2325 m0 *1 93.86,57.4
X$2325 3068 3043 27 15 3201 AND2_X1
* cell instance $2329 r0 *1 90.82,57.4
X$2329 3131 15 27 2991 BUF_X2
* cell instance $2331 r0 *1 91.96,57.4
X$2331 2992 3066 3160 2642 3067 15 27 3197 AOI221_X1
* cell instance $2332 r0 *1 93.1,57.4
X$2332 3066 2992 15 27 3200 NAND2_X1
* cell instance $2333 r0 *1 93.67,57.4
X$2333 3160 2642 3067 15 3341 27 AOI21_X1
* cell instance $2334 r0 *1 94.43,57.4
X$2334 2805 3256 27 15 3254 XNOR2_X1
* cell instance $2336 m0 *1 95.95,57.4
X$2336 2919 27 3069 15 BUF_X4
* cell instance $2338 m0 *1 97.28,57.4
X$2338 3101 2994 2920 15 27 3158 OR3_X1
* cell instance $2339 m0 *1 98.23,57.4
X$2339 3156 3253 3070 27 15 2810 OAI21_X4
* cell instance $2340 m0 *1 100.7,57.4
X$2340 3071 2809 3100 15 27 3101 OR3_X2
* cell instance $2344 r0 *1 97.66,57.4
X$2344 15 2844 3253 3070 3101 3203 27 NOR4_X4
* cell instance $2346 r0 *1 101.84,57.4
X$2346 3204 15 27 3251 INV_X1
* cell instance $2348 m0 *1 102.22,57.4
X$2348 3204 2969 27 15 3100 AND2_X1
* cell instance $2351 m0 *1 106.97,57.4
X$2351 2995 15 27 3210 CLKBUF_X3
* cell instance $2352 m0 *1 107.92,57.4
X$2352 3132 2996 27 15 3072 XNOR2_X1
* cell instance $2353 m0 *1 109.06,57.4
X$2353 3072 2224 15 27 3074 NAND2_X1
* cell instance $2355 r0 *1 102.22,57.4
X$2355 388 3038 3204 27 15 3071 HA_X1
* cell instance $2358 r0 *1 106.02,57.4
X$2358 3249 15 27 3132 INV_X1
* cell instance $2359 r0 *1 106.4,57.4
X$2359 295 3073 3249 27 15 3247 HA_X1
* cell instance $2360 r0 *1 108.3,57.4
X$2360 3247 15 27 3248 INV_X1
* cell instance $2361 r0 *1 108.68,57.4
X$2361 3248 2996 3132 27 15 3392 OAI21_X4
* cell instance $2363 m0 *1 110.01,57.4
X$2363 3073 2224 3074 27 3075 15 OAI21_X1
* cell instance $2365 m0 *1 112.48,57.4
X$2365 3075 15 27 3133 INV_X1
* cell instance $2367 m0 *1 113.62,57.4
X$2367 2646 2997 3077 3076 2998 3440 27 15 AOI221_X2
* cell instance $2368 m0 *1 115.71,57.4
X$2368 3076 3078 27 15 3098 XNOR2_X1
* cell instance $2371 r0 *1 112.67,57.4
X$2371 388 3133 3076 27 15 3077 HA_X1
* cell instance $2372 r0 *1 114.57,57.4
X$2372 15 3206 3077 3076 3078 27 AOI21_X4
* cell instance $2377 m0 *1 117.42,57.4
X$2377 3075 3098 3000 27 15 2558 MUX2_X2
* cell instance $2382 r0 *1 120.46,57.4
X$2382 3210 15 27 3246 INV_X1
* cell instance $2386 r0 *1 121.41,57.4
X$2386 3246 3209 3134 27 15 3135 MUX2_X2
* cell instance $2387 m0 *1 122.74,57.4
X$2387 15 2224 27 3134 BUF_X8
* cell instance $2394 r0 *1 127.3,57.4
X$2394 3135 3214 15 27 3220 XNOR2_X2
* cell instance $2397 r0 *1 130.34,57.4
X$2397 3151 3215 3242 3095 3000 3006 15 27 3153 OAI33_X1
* cell instance $2398 r0 *1 131.67,57.4
X$2398 3137 2957 15 27 3136 NAND2_X2
* cell instance $2400 m0 *1 131.67,57.4
X$2400 3095 15 27 2957 INV_X2
* cell instance $2402 m0 *1 133.95,57.4
X$2402 3219 3005 3006 27 15 2816 OAI21_X2
* cell instance $2404 m0 *1 136.04,57.4
X$2404 2818 3093 15 27 3138 OR2_X1
* cell instance $2406 m0 *1 136.99,57.4
X$2406 3079 3151 2913 27 3019 15 OAI21_X1
* cell instance $2407 m0 *1 137.75,57.4
X$2407 2818 3079 15 27 3150 NOR2_X1
* cell instance $2409 m0 *1 139.84,57.4
X$2409 2959 2820 3080 15 27 3234 OR3_X1
* cell instance $2410 m0 *1 140.79,57.4
X$2410 3080 2820 2959 15 27 3088 NOR3_X1
* cell instance $2412 m0 *1 141.74,57.4
X$2412 3138 3080 27 15 3081 AND2_X1
* cell instance $2413 m0 *1 142.5,57.4
X$2413 3081 3088 2749 3083 2654 27 15 AOI211_X2
* cell instance $2415 r0 *1 132.62,57.4
X$2415 15 3002 3218 3080 3137 2957 27 AOI22_X4
* cell instance $2416 r0 *1 135.85,57.4
X$2416 3217 3216 15 27 2818 NOR2_X2
* cell instance $2417 r0 *1 136.8,57.4
X$2417 3150 3079 3321 27 15 2820 MUX2_X2
* cell instance $2420 r0 *1 139.46,57.4
X$2420 3080 3138 15 27 3139 NAND2_X1
* cell instance $2421 r0 *1 140.03,57.4
X$2421 3234 3139 2559 2560 3222 15 27 OAI211_X2
* cell instance $2422 r0 *1 141.74,57.4
X$2422 15 2671 3222 2564 3223 3224 27 AOI22_X4
* cell instance $2424 m0 *1 144.59,57.4
X$2424 3083 2749 15 27 2405 NAND2_X2
* cell instance $2425 r0 *1 144.97,57.4
X$2425 3230 3226 3303 27 15 2245 OAI21_X2
* cell instance $2427 m0 *1 145.92,57.4
X$2427 15 3082 3015 3018 3007 27 NOR3_X4
* cell instance $2430 r0 *1 146.3,57.4
X$2430 3140 3141 15 2156 27 NAND2_X4
* cell instance $2431 r0 *1 148.01,57.4
X$2431 15 3010 3142 3083 2961 27 AOI21_X4
* cell instance $2433 r0 *1 150.67,57.4
X$2433 15 2749 27 2961 BUF_X8
* cell instance $2435 m0 *1 152.76,57.4
X$2435 2888 3084 15 27 3087 NAND2_X1
* cell instance $2436 m0 *1 153.52,57.4
X$2436 3087 3227 3084 15 27 3008 MUX2_X1
* cell instance $2437 m0 *1 154.85,57.4
X$2437 3008 3144 15 27 1650 OR2_X1
* cell instance $2438 m0 *1 155.61,57.4
X$2438 3009 3010 15 27 2890 XNOR2_X2
* cell instance $2441 r0 *1 153.9,57.4
X$2441 2888 3009 3010 15 3144 27 AOI21_X1
* cell instance $2442 r0 *1 154.66,57.4
X$2442 3143 3145 15 27 3228 NOR2_X1
* cell instance $2443 r0 *1 155.23,57.4
X$2443 3228 3145 3227 27 15 2889 MUX2_X2
* cell instance $2444 r0 *1 156.94,57.4
X$2444 3084 15 27 3145 INV_X1
* cell instance $2447 m0 *1 157.89,57.4
X$2447 3084 1647 2962 15 3085 27 AOI21_X2
* cell instance $2463 m0 *1 52.63,9.8
X$2463 395 370 288 27 15 548 OAI21_X4
* cell instance $2464 m0 *1 52.06,9.8
X$2464 393 370 15 27 395 NAND2_X1
* cell instance $2467 r0 *1 52.06,9.8
X$2467 230 15 27 413 INV_X1
* cell instance $2469 r0 *1 52.63,9.8
X$2469 287 413 15 27 590 NOR2_X2
* cell instance $2472 r0 *1 55.48,9.8
X$2472 470 260 414 15 27 471 OR3_X4
* cell instance $2473 m0 *1 57.19,9.8
X$2473 399 456 193 27 455 15 NOR3_X2
* cell instance $2475 m0 *1 58.52,9.8
X$2475 231 370 15 27 232 NOR2_X1
* cell instance $2477 r0 *1 57.57,9.8
X$2477 472 415 15 27 470 NOR2_X1
* cell instance $2479 r0 *1 58.52,9.8
X$2479 456 399 193 15 27 593 OR3_X4
* cell instance $2483 m0 *1 59.66,9.8
X$2483 15 370 27 516 BUF_X8
* cell instance $2486 m0 *1 62.89,9.8
X$2486 401 290 70 15 27 177 MUX2_X1
* cell instance $2490 m0 *1 69.54,9.8
X$2490 15 75 154 335 237 475 27 NOR4_X4
* cell instance $2493 r0 *1 60.61,9.8
X$2493 177 98 516 27 15 416 MUX2_X2
* cell instance $2497 r0 *1 64.41,9.8
X$2497 290 15 27 334 INV_X4
* cell instance $2501 r0 *1 67.83,9.8
X$2501 295 551 22 27 15 474 HA_X1
* cell instance $2502 r0 *1 69.73,9.8
X$2502 236 474 154 27 15 290 OAI21_X4
* cell instance $2506 r0 *1 74.29,9.8
X$2506 477 290 15 27 476 NAND2_X1
* cell instance $2508 m0 *1 75.05,9.8
X$2508 477 402 15 27 156 NAND2_X1
* cell instance $2511 r0 *1 75.24,9.8
X$2511 479 478 371 15 27 NOR2_X4
* cell instance $2513 m0 *1 76,9.8
X$2513 642 371 15 27 402 NAND2_X1
* cell instance $2515 m0 *1 78.28,9.8
X$2515 292 260 15 27 236 NOR2_X2
* cell instance $2520 r0 *1 76.95,9.8
X$2520 371 15 27 520 INV_X2
* cell instance $2523 r0 *1 79.8,9.8
X$2523 43 456 603 27 15 481 HA_X1
* cell instance $2527 m0 *1 84.93,9.8
X$2527 388 15 27 292 INV_X1
* cell instance $2531 m0 *1 86.45,9.8
X$2531 292 341 400 27 15 293 HA_X1
* cell instance $2532 m0 *1 88.54,9.8
X$2532 293 400 372 15 373 27 AOI21_X1
* cell instance $2533 m0 *1 89.3,9.8
X$2533 373 15 27 454 INV_X1
* cell instance $2534 m0 *1 89.68,9.8
X$2534 398 238 15 27 419 NAND2_X1
* cell instance $2535 m0 *1 90.25,9.8
X$2535 294 394 398 27 15 397 HA_X1
* cell instance $2536 m0 *1 92.15,9.8
X$2536 396 397 238 15 453 27 AOI21_X1
* cell instance $2540 m0 *1 95.38,9.8
X$2540 296 299 344 27 341 15 OAI21_X1
* cell instance $2542 m0 *1 96.33,9.8
X$2542 296 390 297 27 394 15 OAI21_X1
* cell instance $2544 m0 *1 97.28,9.8
X$2544 345 296 391 27 524 15 OAI21_X1
* cell instance $2545 m0 *1 98.04,9.8
X$2545 347 160 15 27 344 NAND2_X1
* cell instance $2546 m0 *1 98.61,9.8
X$2546 108 160 15 27 391 NAND2_X1
* cell instance $2547 m0 *1 99.18,9.8
X$2547 374 15 27 239 INV_X1
* cell instance $2548 m0 *1 99.56,9.8
X$2548 138 390 374 27 15 348 HA_X1
* cell instance $2552 m0 *1 106.21,9.8
X$2552 388 345 452 27 15 189 HA_X1
* cell instance $2556 m0 *1 112.1,9.8
X$2556 389 302 375 27 15 339 AND3_X1
* cell instance $2557 m0 *1 113.05,9.8
X$2557 375 302 15 27 164 NAND2_X1
* cell instance $2558 m0 *1 113.62,9.8
X$2558 243 301 244 15 27 336 NAND3_X2
* cell instance $2562 r0 *1 86.45,9.8
X$2562 527 418 400 15 27 529 NAND3_X1
* cell instance $2563 r0 *1 87.21,9.8
X$2563 645 524 418 27 15 526 HA_X1
* cell instance $2564 r0 *1 89.11,9.8
X$2564 419 420 453 27 372 15 OAI21_X1
* cell instance $2565 r0 *1 89.87,9.8
X$2565 526 418 454 15 528 27 AOI21_X1
* cell instance $2571 r0 *1 96.52,9.8
X$2571 160 523 483 27 15 592 OAI21_X2
* cell instance $2574 r0 *1 98.42,9.8
X$2574 374 523 521 27 15 240 OAI21_X4
* cell instance $2579 r0 *1 106.4,9.8
X$2579 15 114 27 421 BUF_X8
* cell instance $2580 r0 *1 108.87,9.8
X$2580 421 27 429 15 BUF_X4
* cell instance $2583 r0 *1 110.77,9.8
X$2583 589 15 27 519 INV_X1
* cell instance $2584 r0 *1 111.15,9.8
X$2584 519 127 126 27 15 243 OAI21_X4
* cell instance $2585 r0 *1 113.62,9.8
X$2585 127 126 958 15 27 301 OR3_X2
* cell instance $2587 r0 *1 114.95,9.8
X$2587 15 336 517 427 422 84 27 NAND4_X4
* cell instance $2591 m0 *1 118.37,9.8
X$2591 247 256 423 15 27 302 NAND3_X1
* cell instance $2592 m0 *1 117.61,9.8
X$2592 336 517 27 15 424 AND2_X1
* cell instance $2594 m0 *1 119.32,9.8
X$2594 164 488 15 27 425 OR2_X1
* cell instance $2597 r0 *1 118.75,9.8
X$2597 486 424 425 163 383 15 27 OAI211_X2
* cell instance $2598 m0 *1 120.65,9.8
X$2598 163 164 15 27 386 OR2_X1
* cell instance $2602 m0 *1 122.36,9.8
X$2602 325 333 385 386 27 15 428 AND4_X1
* cell instance $2604 r0 *1 120.46,9.8
X$2604 422 427 15 27 426 NAND2_X1
* cell instance $2606 r0 *1 121.22,9.8
X$2606 426 424 163 27 15 304 AND3_X1
* cell instance $2607 r0 *1 122.17,9.8
X$2607 430 421 428 27 15 490 AND3_X1
* cell instance $2608 r0 *1 123.12,9.8
X$2608 430 428 429 15 330 27 AOI21_X1
* cell instance $2611 m0 *1 123.88,9.8
X$2611 491 384 27 15 385 AND2_X1
* cell instance $2612 m0 *1 124.83,9.8
X$2612 304 450 383 203 262 432 15 27 OAI221_X2
* cell instance $2615 r0 *1 124.45,9.8
X$2615 491 201 325 15 27 511 NAND3_X1
* cell instance $2616 r0 *1 125.21,9.8
X$2616 384 431 432 511 27 510 15 OR4_X2
* cell instance $2617 r0 *1 126.54,9.8
X$2617 512 432 431 15 27 492 NOR3_X1
* cell instance $2618 r0 *1 127.3,9.8
X$2618 429 447 15 27 493 NOR2_X1
* cell instance $2619 m0 *1 128.06,9.8
X$2619 84 204 15 27 494 NOR2_X1
* cell instance $2620 m0 *1 127.3,9.8
X$2620 383 382 447 27 168 15 OAI21_X1
* cell instance $2623 m0 *1 129.2,9.8
X$2623 448 376 15 27 245 NOR2_X2
* cell instance $2625 m0 *1 130.15,9.8
X$2625 245 169 15 27 382 NAND2_X1
* cell instance $2629 r0 *1 129.77,9.8
X$2629 433 15 27 448 INV_X1
* cell instance $2630 r0 *1 130.15,9.8
X$2630 433 495 15 27 119 XNOR2_X2
* cell instance $2631 m0 *1 132.05,9.8
X$2631 376 434 15 27 305 OR2_X1
* cell instance $2633 m0 *1 132.81,9.8
X$2633 305 259 436 93 435 27 15 AOI211_X2
* cell instance $2635 r0 *1 132.05,9.8
X$2635 434 306 15 27 507 NOR2_X1
* cell instance $2636 r0 *1 132.62,9.8
X$2636 435 496 27 15 447 XNOR2_X1
* cell instance $2637 r0 *1 133.76,9.8
X$2637 496 435 27 246 15 XOR2_X2
* cell instance $2639 m0 *1 134.9,9.8
X$2639 15 57 252 93 446 27 AOI21_X4
* cell instance $2642 m0 *1 139.84,9.8
X$2642 15 58 55 56 377 254 27 NOR4_X4
* cell instance $2645 m0 *1 144.21,9.8
X$2645 444 439 378 15 27 440 OR3_X1
* cell instance $2650 r0 *1 136.42,9.8
X$2650 436 15 27 446 BUF_X1
* cell instance $2653 r0 *1 137.56,9.8
X$2653 259 437 15 27 306 NOR2_X1
* cell instance $2655 r0 *1 138.32,9.8
X$2655 254 57 15 27 497 NAND2_X1
* cell instance $2659 r0 *1 140.22,9.8
X$2659 498 438 27 173 15 XOR2_X2
* cell instance $2660 r0 *1 141.93,9.8
X$2660 249 126 573 256 15 27 439 NAND4_X1
* cell instance $2661 r0 *1 142.88,9.8
X$2661 378 444 439 27 15 580 OAI21_X2
* cell instance $2662 r0 *1 144.21,9.8
X$2662 126 127 15 27 437 NOR2_X2
* cell instance $2664 r0 *1 145.54,9.8
X$2664 315 499 256 15 27 500 NAND3_X2
* cell instance $2665 m0 *1 146.49,9.8
X$2665 259 15 27 315 INV_X1
* cell instance $2667 m0 *1 146.87,9.8
X$2667 309 259 247 256 503 27 15 AOI211_X2
* cell instance $2668 m0 *1 148.58,9.8
X$2668 379 254 380 250 15 27 309 NAND4_X1
* cell instance $2669 m0 *1 149.53,9.8
X$2669 259 257 436 256 307 27 15 AOI211_X2
* cell instance $2670 m0 *1 151.24,9.8
X$2670 207 15 27 379 INV_X1
* cell instance $2680 r0 *1 146.87,9.8
X$2680 441 503 15 27 105 XNOR2_X2
* cell instance $2683 r0 *1 150.48,9.8
X$2683 442 308 27 380 15 XOR2_X2
* cell instance $2698 m0 *1 4.56,18.2
X$2698 15 939 756 1021 1104 861 27 OAI22_X4
* cell instance $2699 m0 *1 3.23,18.2
X$2699 697 698 792 27 15 939 OAI21_X2
* cell instance $2701 m0 *1 8.55,18.2
X$2701 859 15 27 613 BUF_X2
* cell instance $2704 m0 *1 13.87,18.2
X$2704 15 794 619 270 618 897 27 NOR4_X4
* cell instance $2705 m0 *1 17.29,18.2
X$2705 976 977 15 27 445 OR2_X2
* cell instance $2708 m0 *1 20.52,18.2
X$2708 410 795 355 15 27 865 NOR3_X1
* cell instance $2709 m0 *1 21.28,18.2
X$2709 15 458 795 623 508 27 AOI21_X4
* cell instance $2712 m0 *1 24.7,18.2
X$2712 796 704 362 15 27 868 NAND3_X2
* cell instance $2713 m0 *1 26.03,18.2
X$2713 15 794 978 868 797 27 AOI21_X4
* cell instance $2714 m0 *1 28.5,18.2
X$2714 795 387 15 27 797 NAND2_X1
* cell instance $2716 m0 *1 29.26,18.2
X$2716 798 1025 15 27 795 XNOR2_X2
* cell instance $2717 m0 *1 31.16,18.2
X$2717 942 27 362 15 BUF_X4
* cell instance $2718 m0 *1 32.49,18.2
X$2718 15 800 584 898 799 361 27 NAND4_X4
* cell instance $2719 m0 *1 35.91,18.2
X$2719 800 799 898 15 27 387 NAND3_X2
* cell instance $2721 m0 *1 37.43,18.2
X$2721 356 1063 947 711 981 710 15 27 OAI221_X2
* cell instance $2722 m0 *1 39.52,18.2
X$2722 899 946 15 27 800 NAND2_X2
* cell instance $2723 m0 *1 40.47,18.2
X$2723 946 801 15 27 802 OR2_X1
* cell instance $2724 m0 *1 41.23,18.2
X$2724 900 15 27 711 BUF_X2
* cell instance $2725 m0 *1 41.99,18.2
X$2725 631 950 900 15 27 799 OR3_X4
* cell instance $2726 m0 *1 44.08,18.2
X$2726 901 804 803 805 902 950 27 15 AOI221_X2
* cell instance $2727 m0 *1 46.17,18.2
X$2727 952 903 805 27 15 900 MUX2_X2
* cell instance $2728 m0 *1 47.88,18.2
X$2728 907 808 806 548 27 513 15 OR4_X2
* cell instance $2730 m0 *1 49.4,18.2
X$2730 1032 717 807 27 15 806 OAI21_X2
* cell instance $2731 m0 *1 50.73,18.2
X$2731 15 907 808 904 548 635 27 NOR4_X4
* cell instance $2732 m0 *1 54.15,18.2
X$2732 260 910 690 27 908 15 OAI21_X1
* cell instance $2745 r0 *1 3.8,18.2
X$2745 940 973 897 27 792 15 NOR3_X2
* cell instance $2746 r0 *1 5.13,18.2
X$2746 897 973 940 15 27 1105 OR3_X1
* cell instance $2751 r0 *1 16.34,18.2
X$2751 977 976 410 15 27 NOR2_X4
* cell instance $2756 r0 *1 23.56,18.2
X$2756 1061 508 623 15 27 1023 NAND3_X2
* cell instance $2757 r0 *1 24.89,18.2
X$2757 508 704 15 1062 27 NAND2_X4
* cell instance $2758 r0 *1 26.6,18.2
X$2758 540 705 355 15 27 978 NAND3_X1
* cell instance $2761 r0 *1 28.31,18.2
X$2761 706 15 27 798 INV_X1
* cell instance $2762 r0 *1 28.69,18.2
X$2762 980 15 27 540 INV_X4
* cell instance $2763 r0 *1 29.64,18.2
X$2763 15 541 798 941 979 27 AOI21_X4
* cell instance $2764 r0 *1 32.11,18.2
X$2764 15 584 800 799 898 508 27 AND4_X4
* cell instance $2766 r0 *1 34.77,18.2
X$2766 898 799 800 27 15 942 AND3_X1
* cell instance $2768 r0 *1 35.91,18.2
X$2768 543 509 980 1144 1028 709 27 15 AOI221_X2
* cell instance $2770 r0 *1 38.19,18.2
X$2770 365 1030 15 27 943 NAND2_X1
* cell instance $2772 r0 *1 38.95,18.2
X$2772 630 945 27 947 15 XOR2_X2
* cell instance $2774 r0 *1 41.42,18.2
X$2774 900 27 946 15 BUF_X4
* cell instance $2776 r0 *1 43.13,18.2
X$2776 945 15 27 632 BUF_X1
* cell instance $2777 r0 *1 43.7,18.2
X$2777 15 805 902 630 804 901 27 AOI22_X4
* cell instance $2778 r0 *1 46.93,18.2
X$2778 464 715 15 27 903 NOR2_X2
* cell instance $2779 r0 *1 47.88,18.2
X$2779 806 904 805 27 15 906 MUX2_X2
* cell instance $2780 r0 *1 49.59,18.2
X$2780 716 717 807 27 15 904 OAI21_X4
* cell instance $2781 r0 *1 52.06,18.2
X$2781 909 908 15 27 807 NAND2_X2
* cell instance $2782 r0 *1 53.01,18.2
X$2782 908 909 27 15 1033 AND2_X1
* cell instance $2783 r0 *1 53.77,18.2
X$2783 1034 365 15 27 909 NAND2_X1
* cell instance $2785 r0 *1 54.53,18.2
X$2785 1362 907 808 27 15 901 OAI21_X4
* cell instance $2786 m0 *1 57,18.2
X$2786 810 15 27 910 INV_X1
* cell instance $2788 m0 *1 57.38,18.2
X$2788 637 365 15 27 956 NAND2_X1
* cell instance $2789 m0 *1 57.95,18.2
X$2789 15 1037 890 719 956 637 910 808 27 OAI222_X2
* cell instance $2790 m0 *1 60.61,18.2
X$2790 15 717 690 809 985 27 AOI21_X4
* cell instance $2791 m0 *1 63.08,18.2
X$2791 960 810 27 15 811 XNOR2_X1
* cell instance $2792 m0 *1 64.22,18.2
X$2792 812 893 813 27 15 1212 OAI21_X4
* cell instance $2795 m0 *1 67.64,18.2
X$2795 964 915 815 15 988 27 NAND3_X4
* cell instance $2796 m0 *1 70.11,18.2
X$2796 15 784 965 964 815 27 AOI21_X4
* cell instance $2799 r0 *1 57,18.2
X$2799 1036 1038 907 15 27 NOR2_X4
* cell instance $2800 r0 *1 58.71,18.2
X$2800 639 911 637 27 1039 15 OAI21_X1
* cell instance $2804 r0 *1 59.47,18.2
X$2804 15 879 911 639 1038 27 NOR3_X4
* cell instance $2805 r0 *1 62.13,18.2
X$2805 983 15 27 1037 INV_X1
* cell instance $2807 r0 *1 62.89,18.2
X$2807 985 357 809 15 986 27 NAND3_X4
* cell instance $2808 r0 *1 65.36,18.2
X$2808 15 988 987 1043 893 27 NOR3_X4
* cell instance $2809 r0 *1 68.02,18.2
X$2809 15 638 913 912 914 985 27 NAND4_X4
* cell instance $2810 r0 *1 71.44,18.2
X$2810 915 964 815 27 15 913 AND3_X1
* cell instance $2814 r0 *1 73.72,18.2
X$2814 915 914 912 15 27 816 NAND3_X1
* cell instance $2815 m0 *1 73.91,18.2
X$2815 195 816 894 27 15 817 HA_X1
* cell instance $2823 r0 *1 78.28,18.2
X$2823 916 1053 27 15 1050 XNOR2_X1
* cell instance $2826 r0 *1 81.7,18.2
X$2826 1053 1054 990 15 27 NOR2_X4
* cell instance $2827 r0 *1 83.41,18.2
X$2827 916 15 27 1054 INV_X1
* cell instance $2830 m0 *1 87.02,18.2
X$2830 969 823 971 27 15 819 HA_X1
* cell instance $2834 r0 *1 87.21,18.2
X$2834 212 15 27 969 INV_X2
* cell instance $2836 r0 *1 87.97,18.2
X$2836 971 15 27 729 BUF_X1
* cell instance $2838 m0 *1 90.44,18.2
X$2838 822 114 821 15 27 972 MUX2_X1
* cell instance $2839 m0 *1 90.06,18.2
X$2839 972 15 27 820 INV_X1
* cell instance $2841 m0 *1 91.96,18.2
X$2841 822 970 821 27 15 778 HA_X1
* cell instance $2843 m0 *1 94.43,18.2
X$2843 1030 651 917 15 27 824 MUX2_X1
* cell instance $2845 m0 *1 95.76,18.2
X$2845 992 421 825 15 27 646 MUX2_X1
* cell instance $2846 m0 *1 97.09,18.2
X$2846 968 651 918 15 27 484 MUX2_X1
* cell instance $2849 m0 *1 100.13,18.2
X$2849 826 967 15 27 827 NAND2_X2
* cell instance $2851 m0 *1 101.27,18.2
X$2851 212 887 920 27 15 828 HA_X1
* cell instance $2853 m0 *1 103.36,18.2
X$2853 828 920 827 15 883 27 AOI21_X2
* cell instance $2854 m0 *1 104.69,18.2
X$2854 885 15 27 829 INV_X1
* cell instance $2856 m0 *1 105.26,18.2
X$2856 998 651 882 15 27 299 MUX2_X1
* cell instance $2857 m0 *1 106.59,18.2
X$2857 961 831 962 27 15 653 OAI21_X2
* cell instance $2858 m0 *1 107.92,18.2
X$2858 833 15 27 831 INV_X1
* cell instance $2860 m0 *1 108.49,18.2
X$2860 834 917 685 15 27 880 NAND3_X1
* cell instance $2861 m0 *1 109.25,18.2
X$2861 1051 999 739 880 27 869 15 NOR4_X2
* cell instance $2864 r0 *1 96.14,18.2
X$2864 919 994 15 27 918 XOR2_X1
* cell instance $2865 r0 *1 97.28,18.2
X$2865 919 995 917 27 15 967 OAI21_X2
* cell instance $2866 r0 *1 98.61,18.2
X$2866 111 968 919 27 15 996 HA_X1
* cell instance $2867 r0 *1 100.51,18.2
X$2867 996 919 994 15 966 27 AOI21_X1
* cell instance $2868 r0 *1 101.27,18.2
X$2868 919 15 27 1055 BUF_X1
* cell instance $2869 r0 *1 101.84,18.2
X$2869 996 15 27 826 INV_X1
* cell instance $2870 r0 *1 102.22,18.2
X$2870 920 15 27 735 INV_X1
* cell instance $2872 r0 *1 102.98,18.2
X$2872 735 966 997 27 963 15 OAI21_X1
* cell instance $2873 r0 *1 103.74,18.2
X$2873 828 15 27 997 INV_X1
* cell instance $2874 r0 *1 104.12,18.2
X$2874 920 885 833 1055 15 27 1051 NAND4_X1
* cell instance $2876 r0 *1 105.26,18.2
X$2876 830 885 963 15 962 27 AOI21_X1
* cell instance $2877 r0 *1 106.02,18.2
X$2877 830 15 27 884 INV_X1
* cell instance $2879 r0 *1 106.59,18.2
X$2879 195 998 833 27 15 738 HA_X1
* cell instance $2880 r0 *1 108.49,18.2
X$2880 738 15 27 961 INV_X1
* cell instance $2883 m0 *1 111.34,18.2
X$2883 388 958 564 27 15 658 HA_X1
* cell instance $2886 m0 *1 113.81,18.2
X$2886 300 423 1052 27 15 835 HA_X1
* cell instance $2889 r0 *1 113.81,18.2
X$2889 1052 15 27 834 CLKBUF_X3
* cell instance $2895 r0 *1 115.71,18.2
X$2895 1046 15 27 1048 BUF_X1
* cell instance $2896 m0 *1 118.56,18.2
X$2896 836 15 27 957 BUF_X1
* cell instance $2897 m0 *1 116.09,18.2
X$2897 15 662 835 877 834 27 AOI21_X4
* cell instance $2899 m0 *1 119.32,18.2
X$2899 837 838 839 742 15 27 876 OR4_X1
* cell instance $2900 m0 *1 120.46,18.2
X$2900 742 838 437 15 27 875 NOR3_X1
* cell instance $2901 m0 *1 121.22,18.2
X$2901 839 875 15 27 565 XOR2_X1
* cell instance $2904 m0 *1 124.07,18.2
X$2904 841 842 955 27 15 871 OAI21_X2
* cell instance $2907 m0 *1 131.67,18.2
X$2907 869 765 15 27 761 NAND2_X1
* cell instance $2910 m0 *1 134.52,18.2
X$2910 924 15 27 925 BUF_X1
* cell instance $2913 r0 *1 116.28,18.2
X$2913 1047 15 27 1049 BUF_X1
* cell instance $2914 r0 *1 116.85,18.2
X$2914 1049 15 27 1045 BUF_X1
* cell instance $2915 r0 *1 117.42,18.2
X$2915 662 27 836 15 BUF_X4
* cell instance $2916 r0 *1 118.75,18.2
X$2916 1045 15 27 837 BUF_X1
* cell instance $2917 r0 *1 119.32,18.2
X$2917 1001 15 27 1046 BUF_X1
* cell instance $2918 r0 *1 119.89,18.2
X$2918 957 15 27 1044 BUF_X1
* cell instance $2926 r0 *1 124.07,18.2
X$2926 921 1003 924 27 15 742 MUX2_X2
* cell instance $2930 r0 *1 129.39,18.2
X$2930 661 1088 843 15 27 1042 NAND3_X1
* cell instance $2931 r0 *1 130.15,18.2
X$2931 1042 1041 27 433 15 XOR2_X2
* cell instance $2932 r0 *1 131.86,18.2
X$2932 921 1123 15 27 922 OR2_X1
* cell instance $2935 r0 *1 133.57,18.2
X$2935 864 923 924 15 27 NOR2_X4
* cell instance $2936 r0 *1 135.28,18.2
X$2936 1090 1008 15 27 496 NOR2_X2
* cell instance $2937 r0 *1 136.23,18.2
X$2937 923 15 27 1040 BUF_X1
* cell instance $2938 m0 *1 136.8,18.2
X$2938 1035 844 15 27 665 NAND2_X1
* cell instance $2939 m0 *1 136.23,18.2
X$2939 926 843 15 27 1179 NAND2_X1
* cell instance $2941 m0 *1 137.56,18.2
X$2941 15 844 1035 927 58 845 27 OAI211_X4
* cell instance $2942 m0 *1 140.79,18.2
X$2942 951 846 864 15 927 27 AOI21_X2
* cell instance $2945 m0 *1 143.07,18.2
X$2945 847 948 27 251 15 XOR2_X2
* cell instance $2948 r0 *1 136.99,18.2
X$2948 953 1004 15 27 926 NOR2_X2
* cell instance $2950 r0 *1 138.13,18.2
X$2950 954 746 953 27 1031 15 OAI21_X1
* cell instance $2951 r0 *1 138.89,18.2
X$2951 746 929 923 27 845 15 NOR3_X2
* cell instance $2952 r0 *1 140.22,18.2
X$2952 949 923 864 27 15 498 OAI21_X2
* cell instance $2953 r0 *1 141.55,18.2
X$2953 926 928 746 27 15 949 AND3_X1
* cell instance $2956 r0 *1 143.07,18.2
X$2956 15 847 1009 846 929 27 AOI21_X4
* cell instance $2957 m0 *1 145.35,18.2
X$2957 932 848 15 27 573 XNOR2_X2
* cell instance $2961 r0 *1 145.54,18.2
X$2961 1031 944 1011 15 27 848 NAND3_X2
* cell instance $2962 r0 *1 146.87,18.2
X$2962 849 930 928 27 15 944 AND3_X1
* cell instance $2964 r0 *1 148.01,18.2
X$2964 15 442 1012 846 929 27 AOI21_X4
* cell instance $2965 m0 *1 151.81,18.2
X$2965 851 850 860 27 15 747 OAI21_X2
* cell instance $2966 m0 *1 148.39,18.2
X$2966 15 930 1026 849 856 864 27 NAND4_X4
* cell instance $2967 m0 *1 153.14,18.2
X$2967 852 930 853 15 27 860 NAND3_X1
* cell instance $2968 m0 *1 153.9,18.2
X$2968 750 931 15 27 852 NOR2_X2
* cell instance $2969 m0 *1 154.85,18.2
X$2969 854 856 849 852 15 855 27 NAND4_X2
* cell instance $2970 m0 *1 156.56,18.2
X$2970 851 15 27 854 INV_X1
* cell instance $2971 m0 *1 156.94,18.2
X$2971 938 937 15 27 129 XNOR2_X2
* cell instance $2979 r0 *1 150.48,18.2
X$2979 849 856 930 1026 27 15 1029 AND4_X1
* cell instance $2980 r0 *1 151.62,18.2
X$2980 1029 27 929 15 BUF_X4
* cell instance $2981 r0 *1 152.95,18.2
X$2981 750 851 931 27 1026 15 NOR3_X2
* cell instance $2982 r0 *1 154.28,18.2
X$2982 849 932 855 933 27 15 753 AND4_X1
* cell instance $2983 r0 *1 155.42,18.2
X$2983 933 855 15 27 1106 NAND2_X1
* cell instance $2984 r0 *1 155.99,18.2
X$2984 849 856 854 852 27 15 1015 AND4_X1
* cell instance $2986 r0 *1 157.32,18.2
X$2986 935 1015 15 27 934 NOR2_X1
* cell instance $2987 r0 *1 157.89,18.2
X$2987 1022 933 855 15 27 937 NAND3_X1
* cell instance $2989 r0 *1 159.41,18.2
X$2989 1015 935 1016 27 1019 15 OAI21_X1
* cell instance $2990 r0 *1 160.17,18.2
X$2990 1015 935 936 27 1020 15 OAI21_X1
* cell instance $2993 r0 *1 161.5,18.2
X$2993 1020 1017 1019 15 27 1018 MUX2_X1
* cell instance $3004 m0 *1 30.59,147
X$3004 8194 8265 7347 27 7607 15 NOR3_X2
* cell instance $3006 m0 *1 31.92,147
X$3006 8101 7340 15 27 8265 NOR2_X1
* cell instance $3009 r0 *1 30.4,147
X$3009 8367 8108 15 27 8194 NOR2_X1
* cell instance $3012 r0 *1 32.11,147
X$3012 8573 8108 15 27 8268 NOR2_X1
* cell instance $3013 r0 *1 32.68,147
X$3013 8307 7605 15 27 8267 NOR2_X1
* cell instance $3014 r0 *1 33.25,147
X$3014 8268 8267 8023 27 8072 15 NOR3_X2
* cell instance $3015 m0 *1 34.58,147
X$3015 8196 8271 7347 27 7541 15 NOR3_X2
* cell instance $3017 m0 *1 35.91,147
X$3017 8102 7542 8633 15 27 7756 MUX2_X1
* cell instance $3020 m0 *1 39.52,147
X$3020 8198 8104 8023 27 7544 15 NOR3_X2
* cell instance $3021 m0 *1 40.85,147
X$3021 7451 27 7340 15 BUF_X4
* cell instance $3027 r0 *1 35.15,147
X$3027 8197 8108 15 27 8196 NOR2_X1
* cell instance $3029 r0 *1 35.91,147
X$3029 8372 7340 15 27 8271 NOR2_X1
* cell instance $3032 r0 *1 39.9,147
X$3032 8375 7451 15 27 8199 NOR2_X1
* cell instance $3033 r0 *1 40.47,147
X$3033 8376 8199 7435 27 7618 15 NOR3_X2
* cell instance $3036 r0 *1 44.08,147
X$3036 6886 7931 15 27 8311 NAND2_X1
* cell instance $3039 m0 *1 46.36,147
X$3039 8105 7984 6886 15 27 8275 MUX2_X1
* cell instance $3042 m0 *1 50.16,147
X$3042 8275 8012 8172 15 27 8089 MUX2_X1
* cell instance $3044 r0 *1 47.69,147
X$3044 8111 15 27 8108 CLKBUF_X3
* cell instance $3048 r0 *1 51.11,147
X$3048 8200 8108 15 27 8201 NOR2_X1
* cell instance $3049 r0 *1 51.68,147
X$3049 6741 7447 8314 15 27 8202 MUX2_X1
* cell instance $3050 m0 *1 52.06,147
X$3050 8201 8276 8023 27 7930 15 NOR3_X2
* cell instance $3052 m0 *1 53.39,147
X$3052 8202 7451 15 27 8276 NOR2_X1
* cell instance $3056 r0 *1 53.2,147
X$3056 8315 7281 8382 15 27 8013 MUX2_X1
* cell instance $3059 r0 *1 55.1,147
X$3059 7521 7931 15 27 8195 NAND2_X1
* cell instance $3061 m0 *1 56.05,147
X$3061 8107 8106 7347 27 7765 15 NOR3_X2
* cell instance $3063 m0 *1 57.38,147
X$3063 8279 8108 15 27 8107 NOR2_X1
* cell instance $3068 r0 *1 56.24,147
X$3068 8278 7283 8203 15 27 8279 MUX2_X1
* cell instance $3069 r0 *1 57.57,147
X$3069 8278 7452 8203 15 27 8204 MUX2_X1
* cell instance $3074 r0 *1 61.94,147
X$3074 7984 27 8329 15 BUF_X4
* cell instance $3076 m0 *1 62.13,147
X$3076 7984 27 8019 15 BUF_X4
* cell instance $3078 m0 *1 64.41,147
X$3078 8205 8281 6871 27 8181 15 NOR3_X2
* cell instance $3079 m0 *1 65.74,147
X$3079 15 8206 27 6871 BUF_X8
* cell instance $3080 m0 *1 68.21,147
X$3080 8285 8169 7992 27 15 7476 MUX2_X2
* cell instance $3081 m0 *1 69.92,147
X$3081 15 7762 27 8207 BUF_X8
* cell instance $3082 m0 *1 72.39,147
X$3082 15 7435 27 7992 BUF_X8
* cell instance $3083 m0 *1 74.86,147
X$3083 15 7283 27 8075 BUF_X8
* cell instance $3084 m0 *1 77.33,147
X$3084 5675 15 27 7919 BUF_X2
* cell instance $3089 r0 *1 64.98,147
X$3089 8284 8319 15 27 8205 NOR2_X1
* cell instance $3092 r0 *1 66.12,147
X$3092 7938 27 7451 15 BUF_X4
* cell instance $3094 r0 *1 67.83,147
X$3094 15 7992 27 8206 BUF_X8
* cell instance $3097 r0 *1 70.87,147
X$3097 15 8023 27 8206 BUF_X8
* cell instance $3098 r0 *1 73.34,147
X$3098 8012 27 8017 15 BUF_X4
* cell instance $3099 r0 *1 74.67,147
X$3099 5291 27 7271 15 BUF_X4
* cell instance $3101 r0 *1 76.19,147
X$3101 7552 15 27 8319 INV_X2
* cell instance $3103 r0 *1 76.95,147
X$3103 15 8103 27 7762 BUF_X8
* cell instance $3104 m0 *1 80.56,147
X$3104 8112 8019 8114 15 27 8291 MUX2_X1
* cell instance $3105 m0 *1 79.23,147
X$3105 8112 7115 8114 15 27 8113 MUX2_X1
* cell instance $3108 r0 *1 79.42,147
X$3108 6972 27 1298 15 BUF_X4
* cell instance $3110 r0 *1 80.94,147
X$3110 8395 7605 15 27 8292 NOR2_X2
* cell instance $3111 r0 *1 81.89,147
X$3111 8012 27 7938 15 BUF_X4
* cell instance $3112 m0 *1 83.22,147
X$3112 8322 8108 15 27 8294 NOR2_X2
* cell instance $3114 m0 *1 84.17,147
X$3114 8291 8111 15 27 8185 NOR2_X1
* cell instance $3117 m0 *1 85.69,147
X$3117 8208 7115 8209 15 27 8117 MUX2_X1
* cell instance $3122 r0 *1 83.79,147
X$3122 8294 8292 8023 27 8116 15 NOR3_X2
* cell instance $3124 r0 *1 85.88,147
X$3124 8208 8019 8209 15 27 8296 MUX2_X1
* cell instance $3126 m0 *1 88.73,147
X$3126 8211 7624 8120 15 27 8297 MUX2_X1
* cell instance $3127 m0 *1 88.16,147
X$3127 8296 8111 15 27 8118 NOR2_X1
* cell instance $3128 m0 *1 90.06,147
X$3128 8297 8108 15 27 8298 NOR2_X1
* cell instance $3129 m0 *1 90.63,147
X$3129 8299 7451 15 27 8210 NOR2_X1
* cell instance $3131 m0 *1 91.39,147
X$3131 7053 7283 8119 15 27 8299 MUX2_X1
* cell instance $3132 m0 *1 92.72,147
X$3132 8211 7668 8120 15 27 8121 MUX2_X1
* cell instance $3137 r0 *1 89.68,147
X$3137 8298 8210 7435 27 7918 15 NOR3_X2
* cell instance $3139 r0 *1 92.53,147
X$3139 7097 7931 15 27 8396 NAND2_X1
* cell instance $3141 m0 *1 96.14,147
X$3141 8301 7981 8212 15 27 8026 MUX2_X1
* cell instance $3144 r0 *1 96.14,147
X$3144 8301 7762 8212 15 27 8213 MUX2_X1
* cell instance $3146 m0 *1 137.56,23.8
X$3146 1284 1256 1200 27 15 376 OAI21_X2
* cell instance $3147 m0 *1 135.09,23.8
X$3147 15 1008 1094 1202 1287 27 AOI21_X4
* cell instance $3148 m0 *1 138.89,23.8
X$3148 925 15 27 1200 BUF_X1
* cell instance $3150 m0 *1 139.65,23.8
X$3150 15 1091 1348 1347 846 27 NOR3_X4
* cell instance $3151 m0 *1 142.31,23.8
X$3151 1182 1258 15 27 1181 NAND2_X1
* cell instance $3153 m0 *1 143.07,23.8
X$3153 1258 1182 15 27 1197 OR2_X1
* cell instance $3155 m0 *1 144.59,23.8
X$3155 1094 1093 1010 930 27 15 933 AND4_X1
* cell instance $3157 m0 *1 145.92,23.8
X$3157 923 1257 1183 929 15 27 1280 OR4_X1
* cell instance $3159 m0 *1 132.81,23.8
X$3159 1254 1178 1014 15 27 1290 OR3_X1
* cell instance $3160 m0 *1 130.72,23.8
X$3160 1294 1293 1177 1254 1292 434 27 15 AOI221_X2
* cell instance $3161 m0 *1 133.76,23.8
X$3161 1088 1041 1202 1253 15 27 1007 NAND4_X1
* cell instance $3163 r0 *1 130.72,23.8
X$3163 1253 1088 27 15 1293 AND2_X1
* cell instance $3166 r0 *1 132.05,23.8
X$3166 1088 1041 15 27 1292 NOR2_X1
* cell instance $3167 r0 *1 132.62,23.8
X$3167 1254 1346 1345 15 27 1203 OR3_X2
* cell instance $3168 r0 *1 133.76,23.8
X$3168 1203 1089 1290 1355 15 27 1122 NAND4_X1
* cell instance $3170 r0 *1 134.9,23.8
X$3170 1346 1345 15 27 1088 OR2_X1
* cell instance $3171 r0 *1 135.66,23.8
X$3171 1253 1255 1010 15 27 NOR2_X4
* cell instance $3173 r0 *1 138.13,23.8
X$3173 1010 1093 15 27 1256 NAND2_X1
* cell instance $3175 r0 *1 138.89,23.8
X$3175 1347 1348 15 27 1284 NAND2_X1
* cell instance $3178 r0 *1 140.03,23.8
X$3178 15 1091 1257 1092 1178 1096 27 NOR4_X4
* cell instance $3182 r0 *1 147.44,23.8
X$3182 15 1257 1183 1260 930 27 NOR3_X4
* cell instance $3184 m0 *1 147.44,23.8
X$3184 1280 1259 27 250 15 XOR2_X2
* cell instance $3185 m0 *1 149.34,23.8
X$3185 1014 1260 1183 27 1097 15 NOR3_X2
* cell instance $3188 r0 *1 150.48,23.8
X$3188 1276 1097 1096 849 15 27 1261 NAND4_X1
* cell instance $3189 m0 *1 151.81,23.8
X$3189 1274 1184 15 27 754 XNOR2_X2
* cell instance $3190 m0 *1 151.05,23.8
X$3190 1261 846 929 15 1274 27 AOI21_X1
* cell instance $3193 m0 *1 156.94,23.8
X$3193 1185 1262 1186 15 27 1193 NAND3_X1
* cell instance $3199 r0 *1 157.13,23.8
X$3199 1262 1186 15 27 1263 NAND2_X1
* cell instance $3200 r0 *1 157.7,23.8
X$3200 1262 1188 27 15 1420 XNOR2_X1
* cell instance $3201 m0 *1 158.27,23.8
X$3201 1186 1262 1188 15 27 1187 OR3_X1
* cell instance $3203 m0 *1 159.22,23.8
X$3203 1265 1264 1188 27 15 1016 AND3_X1
* cell instance $3204 m0 *1 160.17,23.8
X$3204 1266 1188 1270 15 27 1189 NOR3_X1
* cell instance $3206 m0 *1 161.12,23.8
X$3206 1185 15 27 1266 INV_X1
* cell instance $3214 r0 *1 159.03,23.8
X$3214 1264 15 27 1262 INV_X1
* cell instance $3216 r0 *1 159.6,23.8
X$3216 1350 1270 1269 1265 1352 441 15 27 OAI221_X2
* cell instance $3217 r0 *1 161.69,23.8
X$3217 1264 1266 1017 15 1269 27 AOI21_X1
* cell instance $3229 m0 *1 121.79,155.4
X$3229 8028 8592 15 8721 27 NAND2_X4
* cell instance $3231 m0 *1 123.5,155.4
X$3231 6560 8593 8419 6566 8721 8682 15 27 OAI221_X2
* cell instance $3234 m0 *1 126.54,155.4
X$3234 8592 8035 15 8639 27 NAND2_X4
* cell instance $3235 m0 *1 128.25,155.4
X$3235 5925 8593 8419 6013 8683 8785 15 27 OAI221_X2
* cell instance $3236 m0 *1 130.34,155.4
X$3236 15 10306 8035 8527 8266 27 DFF_X1
* cell instance $3237 m0 *1 133.57,155.4
X$3237 8280 15 27 8266 CLKBUF_X3
* cell instance $3238 m0 *1 134.52,155.4
X$3238 8266 15 27 CLKBUF_X1
* cell instance $3239 m0 *1 135.09,155.4
X$3239 7173 8422 15 27 8783 NAND2_X1
* cell instance $3242 m0 *1 147.82,155.4
X$3242 6233 6904 15 27 8707 OR2_X1
* cell instance $3245 r0 *1 121.79,155.4
X$3245 6296 8593 8419 6553 8756 8788 15 27 OAI221_X2
* cell instance $3246 r0 *1 123.88,155.4
X$3246 15 8682 7561 10805 8028 27 DFF_X2
* cell instance $3250 r0 *1 128.82,155.4
X$3250 15 10566 8526 8785 8266 27 DFF_X1
* cell instance $3252 r0 *1 133.57,155.4
X$3252 8126 8422 15 27 8758 NAND2_X1
* cell instance $3256 r0 *1 138.32,155.4
X$3256 8228 8857 8783 15 8757 27 AOI21_X1
* cell instance $3259 r0 *1 139.65,155.4
X$3259 8060 8781 8525 15 8854 27 AOI21_X1
* cell instance $3264 r0 *1 146.11,155.4
X$3264 6904 6573 15 27 8759 NOR2_X1
* cell instance $3267 m0 *1 148.96,155.4
X$3267 8714 15 27 8594 INV_X1
* cell instance $3270 m0 *1 150.67,155.4
X$3270 7969 6233 15 8533 27 OR2_X4
* cell instance $3272 m0 *1 152.38,155.4
X$3272 7783 7399 15 27 8711 NAND2_X1
* cell instance $3275 m0 *1 156.75,155.4
X$3275 8710 15 27 8709 INV_X1
* cell instance $3276 m0 *1 157.13,155.4
X$3276 15 8684 8453 8685 7900 8058 27 FA_X1
* cell instance $3280 r0 *1 151.43,155.4
X$3280 7783 7418 15 27 8850 NAND2_X1
* cell instance $3281 r0 *1 152,155.4
X$3281 6990 7078 15 27 8596 OR2_X2
* cell instance $3285 r0 *1 154.28,155.4
X$3285 6863 7076 15 27 8760 OR2_X1
* cell instance $3286 r0 *1 155.04,155.4
X$3286 7080 6990 15 27 8430 OR2_X2
* cell instance $3289 r0 *1 157.89,155.4
X$3289 15 8778 8708 8775 8709 8685 27 FA_X1
* cell instance $3291 m0 *1 162.26,155.4
X$3291 8708 15 27 8706 INV_X1
* cell instance $3294 m0 *1 162.83,155.4
X$3294 8686 15 27 8687 INV_X1
* cell instance $3298 r0 *1 162.45,155.4
X$3298 8707 15 27 8539 INV_X2
* cell instance $3299 r0 *1 163.02,155.4
X$3299 15 8707 8686 8774 8533 8829 27 FA_X1
* cell instance $3302 m0 *1 168.15,155.4
X$3302 8688 15 27 8704 INV_X1
* cell instance $3304 m0 *1 172.33,155.4
X$3304 15 8612 8689 8701 8762 8698 27 FA_X1
* cell instance $3305 m0 *1 175.37,155.4
X$3305 15 8602 8601 8836 8702 8535 27 FA_X1
* cell instance $3307 m0 *1 179.17,155.4
X$3307 8701 15 27 8699 INV_X1
* cell instance $3308 m0 *1 179.55,155.4
X$3308 15 8700 8697 8694 7592 8693 27 FA_X1
* cell instance $3317 r0 *1 175.75,155.4
X$3317 8844 8763 15 27 8773 NAND2_X1
* cell instance $3318 r0 *1 176.32,155.4
X$3318 8690 15 27 8763 INV_X1
* cell instance $3321 r0 *1 178.98,155.4
X$3321 8772 15 27 8691 INV_X1
* cell instance $3323 r0 *1 180.12,155.4
X$3323 15 8769 8772 8914 8699 8440 27 FA_X1
* cell instance $3324 r0 *1 183.16,155.4
X$3324 8697 15 27 8764 INV_X1
* cell instance $3327 m0 *1 183.73,155.4
X$3327 15 7956 8698 8767 8768 8605 27 FA_X1
* cell instance $3331 r0 *1 184.11,155.4
X$3331 7955 8764 8992 27 15 8768 HA_X1
* cell instance $3332 r0 *1 186.01,155.4
X$3332 8767 15 27 8765 INV_X1
* cell instance $3385 m0 *1 62.51,63
X$3385 15 300 27 3369 BUF_X8
* cell instance $3387 m0 *1 64.98,63
X$3387 3277 3188 15 27 3424 NAND2_X1
* cell instance $3389 m0 *1 65.74,63
X$3389 3277 244 15 27 3563 NAND2_X1
* cell instance $3391 r0 *1 62.32,63
X$3391 3188 3277 15 27 3497 OR2_X1
* cell instance $3392 r0 *1 63.08,63
X$3392 3278 3277 2535 27 15 3560 MUX2_X2
* cell instance $3394 r0 *1 65.17,63
X$3394 3497 3424 27 15 3500 AND2_X1
* cell instance $3396 r0 *1 66.12,63
X$3396 3563 3566 3500 27 15 3498 OAI21_X2
* cell instance $3397 m0 *1 66.88,63
X$3397 3326 3477 3566 15 27 NOR2_X4
* cell instance $3399 m0 *1 68.59,63
X$3399 388 3502 3398 27 15 3477 HA_X1
* cell instance $3406 r0 *1 68.02,63
X$3406 3362 3566 15 27 3504 XNOR2_X2
* cell instance $3409 r0 *1 71.63,63
X$3409 3426 3362 15 27 3505 NAND2_X1
* cell instance $3410 r0 *1 72.2,63
X$3410 3426 15 27 3427 INV_X4
* cell instance $3411 r0 *1 73.15,63
X$3411 3362 3427 3428 15 3506 27 AOI21_X1
* cell instance $3412 r0 *1 73.91,63
X$3412 3428 3362 15 27 3507 NOR2_X1
* cell instance $3413 r0 *1 74.48,63
X$3413 3509 3478 3507 15 27 3508 MUX2_X1
* cell instance $3414 r0 *1 75.81,63
X$3414 3509 15 27 3570 INV_X1
* cell instance $3415 m0 *1 77.14,63
X$3415 3363 3364 3482 3439 15 27 3723 AOI22_X2
* cell instance $3416 m0 *1 76.19,63
X$3416 3362 15 27 3429 CLKBUF_X3
* cell instance $3418 m0 *1 79.04,63
X$3418 3594 3510 3169 15 27 3483 OR3_X2
* cell instance $3419 m0 *1 80.18,63
X$3419 3483 3194 3333 27 15 3284 OAI21_X4
* cell instance $3424 r0 *1 81.51,63
X$3424 3365 3594 3510 27 15 3484 OAI21_X4
* cell instance $3425 m0 *1 83.22,63
X$3425 3429 3283 15 27 3366 OR2_X1
* cell instance $3427 m0 *1 83.98,63
X$3427 3337 3484 3429 15 27 3397 NAND3_X1
* cell instance $3428 m0 *1 84.74,63
X$3428 3045 3366 15 3655 27 OR2_X4
* cell instance $3430 m0 *1 86.64,63
X$3430 3430 3431 3369 27 3368 15 OAI21_X1
* cell instance $3431 m0 *1 87.4,63
X$3431 3432 3430 3431 15 27 3196 NOR3_X1
* cell instance $3432 m0 *1 88.16,63
X$3432 3369 3283 15 27 3432 OR2_X2
* cell instance $3438 r0 *1 85.5,63
X$3438 15 3045 3430 3431 3432 3485 27 NOR4_X4
* cell instance $3442 r0 *1 91.58,63
X$3442 3369 3284 27 15 3512 XNOR2_X1
* cell instance $3444 r0 *1 93.1,63
X$3444 3199 3511 3373 15 27 3569 NAND3_X1
* cell instance $3445 r0 *1 93.86,63
X$3445 2742 3201 3569 3207 3433 3568 15 27 3481 OAI33_X1
* cell instance $3446 m0 *1 95.76,63
X$3446 3373 3439 15 27 3567 NAND2_X1
* cell instance $3447 m0 *1 94.81,63
X$3447 3373 15 27 3207 CLKBUF_X3
* cell instance $3450 r0 *1 95.95,63
X$3450 3567 3374 15 27 3480 NOR2_X1
* cell instance $3451 r0 *1 96.52,63
X$3451 3567 3284 15 27 3515 NOR2_X1
* cell instance $3453 m0 *1 96.71,63
X$3453 3370 3373 15 27 3434 NOR2_X1
* cell instance $3454 r0 *1 97.09,63
X$3454 3515 3434 2742 27 3559 15 OAI21_X1
* cell instance $3455 m0 *1 99.37,63
X$3455 3158 3202 3435 15 3372 27 AOI21_X2
* cell instance $3456 m0 *1 97.66,63
X$3456 3516 3435 3371 3479 3436 15 27 OAI211_X2
* cell instance $3458 m0 *1 100.89,63
X$3458 3343 3203 3372 15 27 3437 OR3_X2
* cell instance $3459 m0 *1 102.03,63
X$3459 3373 3374 27 15 3476 AND2_X1
* cell instance $3460 m0 *1 102.79,63
X$3460 3395 3476 3070 3253 27 15 3375 OAI22_X2
* cell instance $3461 m0 *1 104.5,63
X$3461 3436 3375 15 27 3556 NAND2_X1
* cell instance $3464 r0 *1 98.04,63
X$3464 3433 3373 15 27 3565 NOR2_X1
* cell instance $3465 r0 *1 98.61,63
X$3465 3480 3565 3069 27 3561 15 OAI21_X1
* cell instance $3466 r0 *1 99.37,63
X$3466 3429 15 27 3373 BUF_X2
* cell instance $3468 r0 *1 100.51,63
X$3468 3071 3250 15 3517 27 OR2_X4
* cell instance $3471 r0 *1 102.79,63
X$3471 3436 3375 3250 15 27 3558 NAND3_X1
* cell instance $3472 r0 *1 103.55,63
X$3472 3253 3070 3374 27 3519 15 OAI21_X1
* cell instance $3474 r0 *1 104.5,63
X$3474 3556 3437 3438 3439 27 15 3520 OAI22_X2
* cell instance $3476 m0 *1 105.45,63
X$3476 3375 3436 27 15 3521 AND2_X2
* cell instance $3479 m0 *1 111.15,63
X$3479 3393 3376 15 27 3524 NOR2_X1
* cell instance $3480 m0 *1 111.72,63
X$3480 3376 3393 15 3527 27 OR2_X4
* cell instance $3483 m0 *1 117.99,63
X$3483 3289 3288 3292 15 27 3475 MUX2_X1
* cell instance $3484 m0 *1 119.32,63
X$3484 3289 3210 3292 15 27 3708 MUX2_X1
* cell instance $3486 r0 *1 106.21,63
X$3486 3437 3521 15 27 3522 XNOR2_X2
* cell instance $3496 r0 *1 116.47,63
X$3496 3439 3440 300 27 15 3528 OAI21_X2
* cell instance $3498 r0 *1 118.56,63
X$3498 3207 3440 15 27 3441 OR2_X1
* cell instance $3501 m0 *1 121.22,63
X$3501 3288 15 27 3209 INV_X1
* cell instance $3503 m0 *1 121.6,63
X$3503 3292 3289 3135 27 15 3325 MUX2_X2
* cell instance $3506 m0 *1 124.26,63
X$3506 3443 2224 15 27 3444 NAND2_X1
* cell instance $3511 r0 *1 122.36,63
X$3511 3441 3210 15 27 3529 NOR2_X1
* cell instance $3512 r0 *1 122.93,63
X$3512 3528 3288 15 27 3442 NAND2_X1
* cell instance $3514 r0 *1 123.88,63
X$3514 3441 3288 15 27 3531 NOR2_X1
* cell instance $3515 r0 *1 124.45,63
X$3515 3210 3441 15 27 3658 OR2_X1
* cell instance $3518 m0 *1 125.21,63
X$3518 3292 3212 27 15 3472 XNOR2_X1
* cell instance $3519 m0 *1 127.11,63
X$3519 3445 3472 3470 15 3215 27 AOI21_X1
* cell instance $3522 r0 *1 125.4,63
X$3522 3288 3441 15 27 3657 OR2_X1
* cell instance $3523 r0 *1 126.16,63
X$3523 3389 3532 3613 15 27 3445 MUX2_X1
* cell instance $3527 r0 *1 131.1,63
X$3527 3446 3079 15 27 3652 NOR2_X1
* cell instance $3528 m0 *1 131.48,63
X$3528 3151 3215 2913 3006 27 15 3466 OAI22_X1
* cell instance $3530 m0 *1 132.43,63
X$3530 3447 3448 3226 3027 27 15 3385 AND4_X1
* cell instance $3531 m0 *1 133.57,63
X$3531 3027 3226 3448 3447 15 27 3386 NAND4_X1
* cell instance $3535 r0 *1 132.24,63
X$3535 3444 3449 27 15 3450 AND2_X1
* cell instance $3536 r0 *1 133,63
X$3536 3220 3450 3217 3297 3651 15 27 OAI211_X2
* cell instance $3539 m0 *1 134.9,63
X$3539 3386 3298 3465 3000 3221 27 15 AOI211_X2
* cell instance $3540 m0 *1 138.13,63
X$3540 3466 3451 3533 15 27 3384 NAND3_X1
* cell instance $3541 m0 *1 138.89,63
X$3541 3384 3452 3319 15 27 3302 NAND3_X2
* cell instance $3543 m0 *1 140.41,63
X$3543 3012 2958 3379 15 27 3464 OR3_X1
* cell instance $3544 m0 *1 141.36,63
X$3544 3452 3319 3464 15 27 3301 MUX2_X1
* cell instance $3547 r0 *1 134.9,63
X$3547 3448 3447 3153 3533 15 27 3545 AOI22_X1
* cell instance $3549 r0 *1 138.89,63
X$3549 3449 2913 15 27 3534 NAND2_X1
* cell instance $3550 r0 *1 139.46,63
X$3550 3535 2913 15 27 3536 NAND2_X1
* cell instance $3551 r0 *1 140.03,63
X$3551 3451 3319 3536 27 15 3305 AND3_X2
* cell instance $3552 r0 *1 141.17,63
X$3552 3153 15 27 3537 CLKBUF_X3
* cell instance $3555 m0 *1 144.02,63
X$3555 3082 3380 27 15 3313 XNOR2_X1
* cell instance $3557 m0 *1 145.16,63
X$3557 3458 3451 2749 15 3141 27 NAND3_X4
* cell instance $3558 m0 *1 147.63,63
X$3558 15 3455 3456 3381 3082 2819 27 NOR4_X4
* cell instance $3559 m0 *1 151.05,63
X$3559 3541 3538 2749 2819 3306 27 15 AOI211_X2
* cell instance $3568 r0 *1 143.83,63
X$3568 3453 3545 15 27 3140 OR2_X2
* cell instance $3569 r0 *1 144.78,63
X$3569 3453 3380 3082 15 27 3460 MUX2_X1
* cell instance $3570 r0 *1 146.11,63
X$3570 15 3460 3454 2758 2749 3083 27 AOI22_X4
* cell instance $3572 r0 *1 149.53,63
X$3572 3082 3456 3381 3455 15 27 3457 OR4_X1
* cell instance $3573 r0 *1 150.67,63
X$3573 3538 3627 2961 3458 2822 27 15 AOI211_X2
* cell instance $3574 r0 *1 152.38,63
X$3574 3539 3540 15 27 2158 XNOR2_X2
* cell instance $3588 m0 *1 146.87,135.8
X$3588 7615 15 27 7616 INV_X1
* cell instance $3589 m0 *1 143.83,135.8
X$3589 15 7566 7565 7496 7721 7503 27 FA_X1
* cell instance $3591 m0 *1 148.77,135.8
X$3591 7203 15 27 7498 INV_X1
* cell instance $3592 m0 *1 149.15,135.8
X$3592 7613 15 27 7611 INV_X1
* cell instance $3595 m0 *1 151.24,135.8
X$3595 15 7571 7475 7572 7569 7496 27 FA_X1
* cell instance $3596 m0 *1 154.28,135.8
X$3596 7601 7604 15 27 7413 XNOR2_X2
* cell instance $3600 m0 *1 158.65,135.8
X$3600 7477 15 27 7495 INV_X1
* cell instance $3601 m0 *1 159.03,135.8
X$3601 7603 7576 27 15 7412 XNOR2_X1
* cell instance $3603 m0 *1 160.36,135.8
X$3603 15 7578 7603 7600 7231 7495 27 FA_X1
* cell instance $3604 m0 *1 163.4,135.8
X$3604 7599 15 27 7494 INV_X1
* cell instance $3606 m0 *1 163.97,135.8
X$3606 15 7411 7599 7598 7597 7493 27 FA_X1
* cell instance $3608 m0 *1 143.07,135.8
X$3608 7473 15 27 7503 INV_X1
* cell instance $3612 r0 *1 143.07,135.8
X$3612 7617 7784 27 15 7604 XNOR2_X1
* cell instance $3613 r0 *1 144.21,135.8
X$3613 7565 7713 27 15 7617 XNOR2_X1
* cell instance $3615 r0 *1 145.73,135.8
X$3615 15 7787 7566 7610 7616 7567 27 FA_X1
* cell instance $3617 r0 *1 149.15,135.8
X$3617 15 7789 7573 7709 7611 7610 27 FA_X1
* cell instance $3620 r0 *1 153.9,135.8
X$3620 15 7711 7713 7477 7572 7494 27 FA_X1
* cell instance $3621 r0 *1 156.94,135.8
X$3621 7476 7005 15 7708 27 NAND2_X4
* cell instance $3622 r0 *1 158.65,135.8
X$3622 7575 7573 7602 27 15 7576 HA_X1
* cell instance $3624 r0 *1 160.74,135.8
X$3624 7577 7706 27 15 7705 XNOR2_X1
* cell instance $3625 r0 *1 161.88,135.8
X$3625 7681 7705 15 27 7601 XNOR2_X2
* cell instance $3626 r0 *1 163.78,135.8
X$3626 7600 15 27 7702 INV_X1
* cell instance $3629 r0 *1 165.3,135.8
X$3629 15 7701 7578 7683 7598 7400 27 FA_X1
* cell instance $3631 m0 *1 167.39,135.8
X$3631 7596 15 27 7493 INV_X1
* cell instance $3633 m0 *1 168.15,135.8
X$3633 15 7139 7597 7580 7886 7137 27 FA_X1
* cell instance $3639 m0 *1 173.47,135.8
X$3639 15 7694 7488 7582 7062 7402 27 FA_X1
* cell instance $3640 m0 *1 171.57,135.8
X$3640 7407 7488 7581 27 15 7596 HA_X1
* cell instance $3641 m0 *1 176.51,135.8
X$3641 7478 15 27 7401 INV_X2
* cell instance $3644 m0 *1 178.03,135.8
X$3644 7479 15 27 7583 INV_X1
* cell instance $3646 m0 *1 179.17,135.8
X$3646 7214 7401 10863 27 15 7592 HA_X1
* cell instance $3649 r0 *1 171.95,135.8
X$3649 7580 15 27 7697 INV_X1
* cell instance $3654 r0 *1 175.18,135.8
X$3654 7595 15 27 7696 INV_X1
* cell instance $3656 r0 *1 176.32,135.8
X$3656 15 7583 7595 7687 7594 7142 27 FA_X1
* cell instance $3657 r0 *1 179.36,135.8
X$3657 7490 15 27 7406 INV_X2
* cell instance $3660 m0 *1 181.45,135.8
X$3660 7480 15 27 7588 INV_X1
* cell instance $3664 r0 *1 181.45,135.8
X$3664 7589 15 27 7403 INV_X1
* cell instance $3665 r0 *1 181.83,135.8
X$3665 15 7478 7589 7689 6911 7065 27 FA_X1
* cell instance $3669 m0 *1 52.44,105
X$3669 5798 15 27 5852 INV_X1
* cell instance $3670 m0 *1 51.87,105
X$3670 5851 5762 15 27 5866 NOR2_X1
* cell instance $3671 m0 *1 52.82,105
X$3671 5188 5852 5868 27 15 5855 HA_X1
* cell instance $3672 m0 *1 54.72,105
X$3672 5188 5798 10861 27 15 5701 HA_X1
* cell instance $3673 m0 *1 56.62,105
X$3673 5853 5854 27 5872 15 XOR2_X2
* cell instance $3675 m0 *1 58.52,105
X$3675 15 5873 5544 5953 5927 5280 27 FA_X1
* cell instance $3676 m0 *1 61.56,105
X$3676 5703 15 27 5873 INV_X1
* cell instance $3679 m0 *1 65.17,105
X$3679 1604 5346 15 27 6118 OR2_X1
* cell instance $3681 r0 *1 51.87,105
X$3681 5872 5867 5799 5953 27 5923 15 NOR4_X2
* cell instance $3682 r0 *1 53.58,105
X$3682 5868 15 27 5867 INV_X2
* cell instance $3685 r0 *1 54.72,105
X$3685 6018 5526 5869 15 27 NOR2_X4
* cell instance $3687 r0 *1 56.62,105
X$3687 5871 5926 15 27 5870 NOR2_X2
* cell instance $3689 r0 *1 57.76,105
X$3689 5926 5871 27 15 5954 AND2_X1
* cell instance $3691 r0 *1 58.71,105
X$3691 15 5873 5871 6448 5855 5188 27 FA_X1
* cell instance $3697 r0 *1 66.31,105
X$3697 15 6020 5448 6629 5874 27 DFF_X2
* cell instance $3698 m0 *1 66.5,105
X$3698 5346 1604 15 27 5928 NOR2_X2
* cell instance $3700 m0 *1 67.45,105
X$3700 5024 15 27 5448 CLKBUF_X3
* cell instance $3701 m0 *1 68.4,105
X$3701 5545 5800 5874 15 27 5875 MUX2_X1
* cell instance $3702 m0 *1 69.73,105
X$3702 5631 5800 6019 15 27 5955 MUX2_X1
* cell instance $3703 m0 *1 71.06,105
X$3703 5632 5800 5930 15 27 5801 MUX2_X1
* cell instance $3704 m0 *1 72.39,105
X$3704 1298 5801 27 15 5876 AND2_X1
* cell instance $3709 r0 *1 70.11,105
X$3709 1298 5875 27 15 6020 AND2_X1
* cell instance $3711 r0 *1 71.63,105
X$3711 15 5878 5930 5876 5448 27 DFF_X1
* cell instance $3712 r0 *1 74.86,105
X$3712 5285 27 2126 15 BUF_X4
* cell instance $3713 m0 *1 76,105
X$3713 5291 15 27 5192 INV_X4
* cell instance $3717 m0 *1 81.51,105
X$3717 5781 15 27 5929 CLKBUF_X2
* cell instance $3723 r0 *1 77.14,105
X$3723 15 6120 6017 5956 5372 27 DFF_X1
* cell instance $3725 r0 *1 80.75,105
X$3725 6017 1248 2095 15 27 5956 MUX2_X1
* cell instance $3726 r0 *1 82.08,105
X$3726 6205 5957 6123 15 27 NOR2_X4
* cell instance $3727 r0 *1 83.79,105
X$3727 5957 5928 27 5958 15 AND2_X4
* cell instance $3729 r0 *1 85.88,105
X$3729 15 5942 5880 6212 6014 5964 27 AOI22_X4
* cell instance $3731 m0 *1 90.44,105
X$3731 5706 5710 5924 27 15 5552 OAI21_X4
* cell instance $3733 m0 *1 92.91,105
X$3733 5706 5710 5882 27 15 5554 OAI21_X2
* cell instance $3735 m0 *1 94.43,105
X$3735 5805 27 5925 15 BUF_X4
* cell instance $3740 r0 *1 91.77,105
X$3740 5710 15 27 5961 INV_X1
* cell instance $3741 r0 *1 92.15,105
X$3741 5882 15 27 5960 BUF_X2
* cell instance $3743 r0 *1 93.1,105
X$3743 5883 5962 6012 15 5882 27 AOI21_X2
* cell instance $3744 r0 *1 94.43,105
X$3744 15 5924 5883 6148 5962 27 AOI21_X4
* cell instance $3745 r0 *1 96.9,105
X$3745 5381 6055 10882 27 15 5883 HA_X1
* cell instance $3746 m0 *1 97.85,105
X$3746 5806 27 6213 15 BUF_X4
* cell instance $3751 m0 *1 99.75,105
X$3751 5719 5807 15 27 5965 XNOR2_X2
* cell instance $3753 m0 *1 101.65,105
X$3753 5922 27 5921 15 BUF_X4
* cell instance $3754 m0 *1 102.98,105
X$3754 5381 5845 10870 27 15 5720 HA_X1
* cell instance $3756 r0 *1 99.75,105
X$3756 15 6007 5966 5964 5965 6010 27 OR4_X4
* cell instance $3757 r0 *1 102.22,105
X$3757 5780 5637 5808 15 27 6126 OR3_X1
* cell instance $3758 r0 *1 103.17,105
X$3758 5966 15 27 6124 BUF_X1
* cell instance $3762 r0 *1 105.07,105
X$3762 5846 5722 15 27 5966 XNOR2_X2
* cell instance $3763 m0 *1 105.45,105
X$3763 5558 5845 5719 27 15 5721 HA_X1
* cell instance $3765 m0 *1 107.35,105
X$3765 5722 5809 5810 27 15 5884 AND3_X1
* cell instance $3766 m0 *1 108.3,105
X$3766 5723 5644 5846 27 15 5919 OAI21_X2
* cell instance $3767 m0 *1 109.63,105
X$3767 15 6005 5841 5919 5725 27 AOI21_X4
* cell instance $3769 m0 *1 112.29,105
X$3769 5558 5843 5886 27 15 5887 HA_X1
* cell instance $3773 r0 *1 107.73,105
X$3773 5637 5884 5885 15 27 5967 OR3_X1
* cell instance $3774 r0 *1 108.68,105
X$3774 5722 5810 5809 15 5885 27 AOI21_X1
* cell instance $3775 r0 *1 109.44,105
X$3775 5886 5811 15 27 6006 XNOR2_X2
* cell instance $3776 r0 *1 111.34,105
X$3776 5885 5645 5886 27 5968 15 OAI21_X1
* cell instance $3777 r0 *1 112.1,105
X$3777 5886 15 27 5725 INV_X1
* cell instance $3778 r0 *1 112.48,105
X$3778 5646 5637 5812 15 27 6220 OR3_X1
* cell instance $3779 r0 *1 113.43,105
X$3779 5887 15 27 5971 INV_X1
* cell instance $3780 r0 *1 113.81,105
X$3780 5646 5887 5969 27 5972 15 OAI21_X1
* cell instance $3786 m0 *1 120.84,105
X$3786 5704 27 5383 15 BUF_X4
* cell instance $3801 r0 *1 138.89,105
X$3801 5888 4419 27 15 5974 XNOR2_X1
* cell instance $3802 m0 *1 140.22,105
X$3802 4448 4332 5726 27 15 5917 HA_X1
* cell instance $3807 r0 *1 140.22,105
X$3807 5767 15 27 5219 INV_X1
* cell instance $3808 r0 *1 140.6,105
X$3808 5813 6003 27 15 6267 XNOR2_X1
* cell instance $3809 r0 *1 141.74,105
X$3809 5917 6001 27 15 6003 XNOR2_X1
* cell instance $3812 r0 *1 143.83,105
X$3812 5889 15 27 5915 INV_X1
* cell instance $3813 m0 *1 144.21,105
X$3813 15 6344 6000 5649 5914 5814 27 FA_X1
* cell instance $3818 m0 *1 149.72,105
X$3818 6068 15 27 5836 INV_X1
* cell instance $3819 m0 *1 150.1,105
X$3819 15 5911 5912 5815 5907 5836 27 FA_X1
* cell instance $3822 r0 *1 144.21,105
X$3822 6000 15 27 6105 INV_X1
* cell instance $3825 r0 *1 147.82,105
X$3825 15 5912 6103 5467 5997 5910 27 FA_X1
* cell instance $3826 r0 *1 150.86,105
X$3826 5890 15 27 5910 INV_X1
* cell instance $3828 r0 *1 151.62,105
X$3828 5992 15 27 5997 INV_X1
* cell instance $3831 m0 *1 156.56,105
X$3831 15 5817 5816 5468 6072 5833 27 FA_X1
* cell instance $3835 m0 *1 161.5,105
X$3835 5906 15 27 5907 INV_X1
* cell instance $3840 m0 *1 178.03,105
X$3840 4594 5654 5893 27 15 5829 HA_X1
* cell instance $3845 r0 *1 165.3,105
X$3845 5990 5570 15 27 5988 NOR2_X1
* cell instance $3847 r0 *1 166.06,105
X$3847 5891 15 27 5652 INV_X1
* cell instance $3848 r0 *1 166.44,105
X$3848 5990 5572 15 27 5905 NOR2_X1
* cell instance $3849 r0 *1 167.01,105
X$3849 5892 5988 5904 27 15 5902 HA_X1
* cell instance $3852 r0 *1 169.86,105
X$3852 15 5904 5574 5986 6078 5987 27 FA_X1
* cell instance $3859 r0 *1 174.23,105
X$3859 5986 6086 5313 27 15 5901 HA_X1
* cell instance $3861 r0 *1 176.51,105
X$3861 5983 5982 5981 27 15 5314 HA_X1
* cell instance $3863 r0 *1 178.6,105
X$3863 5893 15 27 6165 INV_X1
* cell instance $3864 r0 *1 178.98,105
X$3864 5981 5979 5578 27 15 5825 HA_X1
* cell instance $3867 m0 *1 181.07,105
X$3867 5899 6429 5897 27 15 4055 OAI21_X2
* cell instance $3868 m0 *1 182.59,105
X$3868 5898 15 27 5824 INV_X1
* cell instance $3870 m0 *1 183.73,105
X$3870 5733 5824 5894 27 15 5819 HA_X1
* cell instance $3871 m0 *1 183.35,105
X$3871 5823 15 27 5899 INV_X1
* cell instance $3872 m0 *1 185.63,105
X$3872 5481 5819 5895 27 15 5820 HA_X1
* cell instance $3876 r0 *1 184.11,105
X$3876 5894 5895 5818 5980 15 27 5897 NAND4_X1
* cell instance $3881 m0 *1 55.29,65.8
X$3881 3642 3275 3183 3245 15 27 3644 NOR4_X1
* cell instance $3882 m0 *1 54.53,65.8
X$3882 3640 3639 3644 15 27 3586 NOR3_X1
* cell instance $3887 r0 *1 54.72,65.8
X$3887 3420 3776 3643 27 3921 15 OAI21_X1
* cell instance $3889 r0 *1 55.86,65.8
X$3889 3419 3690 15 27 3642 NAND2_X1
* cell instance $3893 r0 *1 58.9,65.8
X$3893 3362 3721 27 15 3779 XNOR2_X1
* cell instance $3894 m0 *1 59.09,65.8
X$3894 2797 3587 3499 15 27 3503 NAND3_X2
* cell instance $3897 m0 *1 60.61,65.8
X$3897 3425 3496 15 27 3645 NAND2_X1
* cell instance $3898 m0 *1 61.18,65.8
X$3898 3496 27 3369 15 BUF_X4
* cell instance $3899 m0 *1 62.51,65.8
X$3899 3105 3589 3588 27 15 3592 OAI21_X2
* cell instance $3901 m0 *1 64.03,65.8
X$3901 3127 3425 3188 15 3646 27 AOI21_X2
* cell instance $3902 m0 *1 65.36,65.8
X$3902 3424 3497 3564 3587 3499 3786 27 15 AOI221_X2
* cell instance $3903 m0 *1 67.45,65.8
X$3903 3501 3425 284 15 27 3591 NOR3_X1
* cell instance $3912 r0 *1 61.37,65.8
X$3912 3499 3587 15 2535 27 NAND2_X4
* cell instance $3914 r0 *1 63.46,65.8
X$3914 3423 3588 3589 27 3691 15 NOR3_X2
* cell instance $3916 r0 *1 65.17,65.8
X$3916 3645 3646 3278 27 15 3807 MUX2_X2
* cell instance $3920 r0 *1 68.97,65.8
X$3920 3741 3592 3503 15 3692 27 AOI21_X2
* cell instance $3922 m0 *1 69.35,65.8
X$3922 3592 3503 15 27 3502 NAND2_X1
* cell instance $3924 m0 *1 72.2,65.8
X$3924 3506 3502 3509 15 27 3571 MUX2_X1
* cell instance $3925 m0 *1 73.53,65.8
X$3925 3648 3502 3570 15 27 3593 MUX2_X1
* cell instance $3926 m0 *1 74.86,65.8
X$3926 3508 15 27 3650 INV_X1
* cell instance $3927 m0 *1 75.24,65.8
X$3927 3428 3369 3643 27 3509 15 OAI21_X1
* cell instance $3928 m0 *1 76,65.8
X$3928 3571 2780 3508 15 27 3572 MUX2_X1
* cell instance $3930 m0 *1 77.52,65.8
X$3930 3643 27 3439 15 BUF_X4
* cell instance $3932 m0 *1 79.04,65.8
X$3932 15 3594 3510 3191 3430 27 NOR3_X4
* cell instance $3934 m0 *1 81.89,65.8
X$3934 3653 3510 3191 15 27 3337 OR3_X2
* cell instance $3939 r0 *1 70.49,65.8
X$3939 3505 3503 3592 15 3693 27 AOI21_X1
* cell instance $3941 r0 *1 72.01,65.8
X$3941 3505 3478 15 27 3695 NOR2_X1
* cell instance $3942 r0 *1 72.58,65.8
X$3942 3507 3649 15 27 3648 NOR2_X1
* cell instance $3943 r0 *1 73.15,65.8
X$3943 3427 3362 15 27 3649 NOR2_X2
* cell instance $3945 r0 *1 74.48,65.8
X$3945 3593 3650 2800 27 15 4032 MUX2_X2
* cell instance $3950 r0 *1 84.74,65.8
X$3950 3697 3365 27 3696 15 AND2_X4
* cell instance $3951 m0 *1 88.16,65.8
X$3951 3337 3484 15 3511 27 NAND2_X4
* cell instance $3952 m0 *1 85.69,65.8
X$3952 15 3595 3655 3484 3337 27 AOI21_X4
* cell instance $3955 m0 *1 91.58,65.8
X$3955 3199 15 27 3513 INV_X1
* cell instance $3956 m0 *1 91.96,65.8
X$3956 3513 3429 15 27 3597 NAND2_X1
* cell instance $3957 m0 *1 92.53,65.8
X$3957 3374 3597 3511 27 3514 15 NOR3_X2
* cell instance $3958 m0 *1 93.86,65.8
X$3958 3513 3511 15 27 3568 NAND2_X1
* cell instance $3959 m0 *1 94.43,65.8
X$3959 3513 3511 3373 15 27 3599 NOR3_X1
* cell instance $3960 m0 *1 95.19,65.8
X$3960 3514 3511 3512 15 3661 27 AOI21_X1
* cell instance $3962 m0 *1 96.14,65.8
X$3962 3660 2742 3661 15 3662 27 AOI21_X2
* cell instance $3963 m0 *1 97.47,65.8
X$3963 3285 3481 3662 27 15 3783 OAI21_X4
* cell instance $3964 m0 *1 99.94,65.8
X$3964 3284 3435 3516 15 27 3518 NAND3_X1
* cell instance $3965 m0 *1 100.7,65.8
X$3965 3517 3512 27 15 3562 AND2_X1
* cell instance $3966 m0 *1 101.46,65.8
X$3966 3559 3561 3600 3521 3285 3782 27 15 AOI221_X2
* cell instance $3967 m0 *1 103.55,65.8
X$3967 3071 3373 3518 3519 27 15 3665 AND4_X1
* cell instance $3969 m0 *1 104.88,65.8
X$3969 3519 3518 15 27 3438 NAND2_X1
* cell instance $3970 m0 *1 105.45,65.8
X$3970 3518 3519 27 15 3601 AND2_X2
* cell instance $3974 r0 *1 86.64,65.8
X$3974 3429 3596 15 3697 27 OR2_X4
* cell instance $3975 r0 *1 88.35,65.8
X$3975 3439 3596 3369 27 15 3787 OAI21_X2
* cell instance $3976 r0 *1 89.68,65.8
X$3976 3597 3439 15 27 3698 NAND2_X1
* cell instance $3979 r0 *1 91.2,65.8
X$3979 3199 3429 15 27 3699 NOR2_X1
* cell instance $3980 r0 *1 91.77,65.8
X$3980 3699 15 27 3659 INV_X1
* cell instance $3981 r0 *1 92.15,65.8
X$3981 244 3513 3429 15 3598 27 AOI21_X1
* cell instance $3983 r0 *1 93.29,65.8
X$3983 3598 3511 3659 15 27 3817 MUX2_X1
* cell instance $3985 r0 *1 95,65.8
X$3985 3599 3374 3514 3516 3342 3660 27 15 AOI221_X2
* cell instance $3990 r0 *1 99.94,65.8
X$3990 3429 3517 15 3700 27 NAND2_X4
* cell instance $3991 r0 *1 101.65,65.8
X$3991 3343 3666 15 27 3600 OR2_X1
* cell instance $3992 r0 *1 102.41,65.8
X$3992 3343 3429 15 27 3819 NOR2_X1
* cell instance $3995 m0 *1 107.73,65.8
X$3995 3438 3602 27 15 3525 XNOR2_X1
* cell instance $3997 m0 *1 108.87,65.8
X$3997 3439 3601 27 15 3523 XNOR2_X1
* cell instance $3998 m0 *1 110.01,65.8
X$3998 3602 3523 27 15 3669 XNOR2_X1
* cell instance $4000 m0 *1 111.34,65.8
X$4000 3526 3439 15 27 3703 NAND2_X1
* cell instance $4002 m0 *1 113.43,65.8
X$4002 3207 3527 15 27 3526 NAND2_X2
* cell instance $4003 m0 *1 114.38,65.8
X$4003 3526 15 27 3608 INV_X1
* cell instance $4005 m0 *1 114.95,65.8
X$4005 3527 3207 15 27 3606 NOR2_X1
* cell instance $4006 m0 *1 115.52,65.8
X$4006 3672 3439 15 27 3605 NOR2_X1
* cell instance $4013 r0 *1 108.87,65.8
X$4013 3601 3602 15 27 3672 XNOR2_X2
* cell instance $4015 r0 *1 111.15,65.8
X$4015 3702 3603 3524 15 27 3670 NOR3_X1
* cell instance $4016 r0 *1 111.91,65.8
X$4016 3525 3670 3669 3704 15 27 3607 AOI22_X1
* cell instance $4017 r0 *1 112.86,65.8
X$4017 3702 3603 3527 27 3773 15 OAI21_X1
* cell instance $4018 r0 *1 113.62,65.8
X$4018 3604 3525 244 15 27 3671 NOR3_X1
* cell instance $4023 r0 *1 115.14,65.8
X$4023 3606 3605 3671 27 15 3706 OAI21_X2
* cell instance $4024 r0 *1 116.47,65.8
X$4024 3606 3608 15 27 3707 NOR2_X1
* cell instance $4027 r0 *1 117.61,65.8
X$4027 3607 300 15 27 3718 NAND2_X1
* cell instance $4028 r0 *1 118.18,65.8
X$4028 3604 3707 27 15 3667 XNOR2_X1
* cell instance $4029 r0 *1 119.32,65.8
X$4029 3604 3707 15 27 3717 OR2_X1
* cell instance $4030 r0 *1 120.08,65.8
X$4030 3668 3210 27 15 3664 AND2_X1
* cell instance $4032 m0 *1 121.6,65.8
X$4032 3210 3528 27 15 3609 AND2_X1
* cell instance $4033 m0 *1 121.03,65.8
X$4033 3528 3210 15 27 3610 NAND2_X1
* cell instance $4034 m0 *1 122.36,65.8
X$4034 3288 3528 27 15 3611 AND2_X1
* cell instance $4035 m0 *1 123.12,65.8
X$4035 3529 3531 3530 27 15 3613 MUX2_X2
* cell instance $4037 m0 *1 125.02,65.8
X$4037 3658 3657 3530 27 15 3213 MUX2_X2
* cell instance $4038 m0 *1 126.73,65.8
X$4038 3532 27 3212 15 BUF_X4
* cell instance $4041 r0 *1 121.22,65.8
X$4041 3667 3209 15 27 3663 NOR2_X1
* cell instance $4042 r0 *1 121.79,65.8
X$4042 3664 3612 3663 15 27 3377 MUX2_X1
* cell instance $4043 r0 *1 123.12,65.8
X$4043 3610 3530 3442 15 27 3656 MUX2_X1
* cell instance $4044 r0 *1 124.45,65.8
X$4044 3612 3443 27 15 3079 AND2_X2
* cell instance $4047 r0 *1 127.3,65.8
X$4047 3213 3656 3532 27 15 3616 AND3_X2
* cell instance $4049 m0 *1 128.44,65.8
X$4049 3622 3446 15 27 3614 OR2_X1
* cell instance $4050 m0 *1 129.39,65.8
X$4050 3446 3826 15 27 3615 NAND2_X1
* cell instance $4052 m0 *1 130.15,65.8
X$4052 3444 3446 27 15 3654 AND2_X1
* cell instance $4053 m0 *1 130.91,65.8
X$4053 3446 15 27 3617 INV_X1
* cell instance $4054 m0 *1 131.29,65.8
X$4054 3652 3616 3654 15 27 3093 MUX2_X1
* cell instance $4055 m0 *1 132.62,65.8
X$4055 3449 3444 15 27 3618 NAND2_X1
* cell instance $4058 m0 *1 134.14,65.8
X$4058 3651 3620 3151 3647 3619 3006 15 27 3623 OAI33_X1
* cell instance $4060 m0 *1 135.66,65.8
X$4060 3618 3620 15 27 3533 NOR2_X2
* cell instance $4061 m0 *1 136.61,65.8
X$4061 3321 3079 3622 15 27 3641 NOR3_X1
* cell instance $4063 m0 *1 137.56,65.8
X$4063 3624 2834 3623 27 15 3303 AND3_X2
* cell instance $4064 m0 *1 138.7,65.8
X$4064 3449 3534 3641 27 15 2886 MUX2_X2
* cell instance $4068 r0 *1 128.82,65.8
X$4068 3614 3615 3616 27 15 3151 MUX2_X2
* cell instance $4069 r0 *1 130.53,65.8
X$4069 15 3620 3617 3321 3616 27 AOI21_X4
* cell instance $4073 r0 *1 134.33,65.8
X$4073 3851 3618 3620 3765 27 3621 15 NOR4_X2
* cell instance $4077 r0 *1 137.37,65.8
X$4077 3623 2834 3624 15 27 3714 NAND3_X2
* cell instance $4078 r0 *1 138.7,65.8
X$4078 3622 3710 3625 15 27 3379 MUX2_X1
* cell instance $4079 r0 *1 140.03,65.8
X$4079 3757 3620 15 27 2959 NOR2_X2
* cell instance $4081 m0 *1 141.74,65.8
X$4081 3537 3621 27 15 3453 AND2_X1
* cell instance $4083 m0 *1 142.5,65.8
X$4083 3621 3537 15 27 3627 NAND2_X1
* cell instance $4084 m0 *1 143.07,65.8
X$4084 3533 3451 3537 15 3082 27 NAND3_X4
* cell instance $4086 m0 *1 145.73,65.8
X$4086 15 3082 3456 3381 3455 3083 27 NOR4_X4
* cell instance $4088 m0 *1 149.34,65.8
X$4088 15 3456 3381 3455 3458 27 NOR3_X4
* cell instance $4090 m0 *1 152.19,65.8
X$4090 3453 3539 15 27 3541 NAND2_X1
* cell instance $4092 m0 *1 152.95,65.8
X$4092 3540 3539 27 2327 15 XOR2_X2
* cell instance $4102 r0 *1 142.69,65.8
X$4102 3537 3533 3451 27 15 3711 AND3_X1
* cell instance $4105 r0 *1 144.59,65.8
X$4105 3709 3380 27 15 3626 AND2_X1
* cell instance $4107 r0 *1 145.54,65.8
X$4107 3226 3303 3626 15 27 3454 MUX2_X1
* cell instance $4111 r0 *1 148.2,65.8
X$4111 2652 3763 3303 27 15 3540 AND3_X1
* cell instance $4112 r0 *1 149.15,65.8
X$4112 3714 3456 15 27 3833 NOR2_X2
* cell instance $4113 r0 *1 150.1,65.8
X$4113 3538 3627 15 27 3628 NOR2_X1
* cell instance $4114 r0 *1 150.67,65.8
X$4114 3456 3628 3538 3629 2652 2657 15 27 OAI221_X2
* cell instance $4115 r0 *1 152.76,65.8
X$4115 3308 3539 3453 27 15 3713 AND3_X1
* cell instance $4129 m0 *1 133.38,121.8
X$4129 5105 5155 15 27 6903 NOR2_X1
* cell instance $4131 m0 *1 133.95,121.8
X$4131 6768 6727 15 27 6835 NOR2_X1
* cell instance $4135 r0 *1 133.19,121.8
X$4135 15 6866 6865 6835 6273 27 DFF_X1
* cell instance $4136 r0 *1 136.42,121.8
X$4136 6866 15 27 6837 INV_X1
* cell instance $4138 r0 *1 136.99,121.8
X$4138 6836 6865 27 6417 15 XOR2_X2
* cell instance $4139 m0 *1 137.37,121.8
X$4139 15 6785 6840 6768 6273 27 DFF_X1
* cell instance $4142 m0 *1 140.79,121.8
X$4142 6570 6770 15 27 6838 OR2_X1
* cell instance $4143 m0 *1 141.55,121.8
X$4143 6785 15 27 6772 CLKBUF_X3
* cell instance $4144 m0 *1 142.5,121.8
X$4144 6771 6784 27 15 6571 XNOR2_X1
* cell instance $4148 r0 *1 138.89,121.8
X$4148 6075 6928 15 27 6927 XOR2_X1
* cell instance $4150 r0 *1 140.41,121.8
X$4150 6862 6858 15 27 6769 XNOR2_X2
* cell instance $4152 r0 *1 142.5,121.8
X$4152 6861 6841 6859 27 15 6860 HA_X1
* cell instance $4153 r0 *1 144.4,121.8
X$4153 6856 6860 27 15 6230 XNOR2_X1
* cell instance $4155 m0 *1 144.78,121.8
X$4155 6770 5570 15 27 6782 NOR2_X1
* cell instance $4157 r0 *1 145.54,121.8
X$4157 6907 6855 15 27 6858 XNOR2_X2
* cell instance $4158 m0 *1 149.53,121.8
X$4158 15 6854 6771 6773 6781 6780 27 FA_X1
* cell instance $4159 m0 *1 146.49,121.8
X$4159 15 6702 6856 6781 6924 6716 27 FA_X1
* cell instance $4161 m0 *1 154.09,121.8
X$4161 6778 15 27 6780 INV_X1
* cell instance $4162 m0 *1 154.47,121.8
X$4162 6774 15 27 6854 INV_X1
* cell instance $4163 m0 *1 154.85,121.8
X$4163 15 5569 6641 6778 6704 6843 27 FA_X1
* cell instance $4164 m0 *1 157.89,121.8
X$4164 6840 6777 27 15 6705 AND2_X1
* cell instance $4166 m0 *1 158.84,121.8
X$4166 6434 5662 15 27 5569 OR2_X2
* cell instance $4174 r0 *1 150.48,121.8
X$4174 6572 6434 15 27 6702 NOR2_X1
* cell instance $4177 r0 *1 152,121.8
X$4177 5730 5300 15 27 6855 XNOR2_X2
* cell instance $4179 r0 *1 154.09,121.8
X$4179 6574 6772 5730 15 27 NOR2_X4
* cell instance $4182 r0 *1 156.75,121.8
X$4182 6842 6840 15 27 6843 NAND2_X1
* cell instance $4187 r0 *1 160.17,121.8
X$4187 6487 6844 15 6846 27 OR2_X4
* cell instance $4189 r0 *1 162.26,121.8
X$4189 6845 6992 6851 27 15 6921 HA_X1
* cell instance $4190 r0 *1 164.16,121.8
X$4190 6846 15 27 6845 INV_X1
* cell instance $4192 r0 *1 164.73,121.8
X$4192 6847 6845 10889 27 15 6920 HA_X1
* cell instance $4195 r0 *1 168.53,121.8
X$4195 5662 6844 15 6913 27 OR2_X4
* cell instance $4196 r0 *1 170.24,121.8
X$4196 6844 5568 15 6848 27 OR2_X4
* cell instance $4201 r0 *1 174.99,121.8
X$4201 6848 15 27 6847 INV_X2
* cell instance $4202 r0 *1 175.56,121.8
X$4202 6915 6847 10877 27 15 6849 HA_X1
* cell instance $4203 r0 *1 177.46,121.8
X$4203 6848 6846 6916 27 15 10922 HA_X1
* cell instance $4210 m0 *1 135.28,40.6
X$4210 1996 2072 15 27 2149 NAND2_X1
* cell instance $4212 m0 *1 135.85,40.6
X$4212 2074 2149 1716 1947 1750 1956 15 27 OAI221_X2
* cell instance $4213 m0 *1 137.94,40.6
X$4213 2183 1793 2182 15 1947 27 AOI21_X2
* cell instance $4217 r0 *1 135.09,40.6
X$4217 2148 2238 15 27 2076 XNOR2_X2
* cell instance $4218 r0 *1 136.99,40.6
X$4218 2151 1579 15 27 2183 NOR2_X1
* cell instance $4220 r0 *1 137.75,40.6
X$4220 2239 2150 2076 27 2151 15 OAI21_X1
* cell instance $4221 r0 *1 138.51,40.6
X$4221 2240 15 27 2182 INV_X1
* cell instance $4224 r0 *1 139.46,40.6
X$4224 2258 1994 2257 15 1642 27 AOI21_X2
* cell instance $4225 r0 *1 140.79,40.6
X$4225 2151 2324 15 27 2153 NOR2_X2
* cell instance $4227 m0 *1 142.12,40.6
X$4227 1997 1949 15 27 2077 NAND2_X1
* cell instance $4229 m0 *1 142.69,40.6
X$4229 2255 1999 1998 27 15 1716 OAI21_X4
* cell instance $4232 r0 *1 142.31,40.6
X$4232 2256 1999 1587 15 27 NOR2_X4
* cell instance $4233 r0 *1 144.02,40.6
X$4233 2075 2181 15 27 1719 NAND2_X1
* cell instance $4234 r0 *1 144.59,40.6
X$4234 15 2155 2181 2156 1720 2154 27 OAI211_X4
* cell instance $4236 m0 *1 145.54,40.6
X$4236 2014 1717 27 15 2013 AND2_X1
* cell instance $4237 m0 *1 147.44,40.6
X$4237 15 2000 2177 2152 1725 2153 27 OAI211_X4
* cell instance $4238 m0 *1 146.68,40.6
X$4238 2152 2153 15 27 2078 OR2_X1
* cell instance $4241 r0 *1 147.82,40.6
X$4241 2155 2156 2154 27 15 1414 OAI21_X4
* cell instance $4245 r0 *1 151.62,40.6
X$4245 1793 2327 2081 15 2157 27 AOI21_X1
* cell instance $4246 m0 *1 152.57,40.6
X$4246 15 1994 2169 2158 1797 2009 27 OAI211_X4
* cell instance $4247 m0 *1 151.81,40.6
X$4247 2157 2169 27 15 1722 AND2_X1
* cell instance $4248 m0 *1 155.8,40.6
X$4248 2079 2009 2004 15 27 2167 NOR3_X1
* cell instance $4249 m0 *1 156.56,40.6
X$4249 2005 1812 15 27 2006 NOR2_X1
* cell instance $4251 m0 *1 157.32,40.6
X$4251 2004 2009 2072 15 2160 27 AOI21_X1
* cell instance $4252 m0 *1 158.08,40.6
X$4252 2160 2082 15 27 1953 NAND2_X1
* cell instance $4264 r0 *1 153.71,40.6
X$4264 15 1994 2408 2009 1730 2247 27 OAI211_X4
* cell instance $4265 r0 *1 156.94,40.6
X$4265 1952 2159 2082 15 27 2247 NAND3_X1
* cell instance $4267 r0 *1 158.08,40.6
X$4267 2082 2009 15 27 2248 OR2_X1
* cell instance $4278 m0 *1 4.94,133
X$4278 7270 7024 15 27 7483 NAND2_X1
* cell instance $4279 m0 *1 1.71,133
X$4279 15 10318 7269 7405 7268 27 DFF_X1
* cell instance $4282 m0 *1 7.22,133
X$4282 7362 15 27 7267 BUF_X1
* cell instance $4285 m0 *1 8.74,133
X$4285 7362 7024 15 27 7363 NAND2_X1
* cell instance $4293 r0 *1 1.52,133
X$4293 7270 15 27 7360 BUF_X1
* cell instance $4296 r0 *1 2.66,133
X$4296 7269 15 27 7359 BUF_X1
* cell instance $4302 r0 *1 3.8,133
X$4302 7269 7024 15 27 7361 NAND2_X1
* cell instance $4303 r0 *1 4.37,133
X$4303 7441 7361 7482 15 7405 27 AOI21_X1
* cell instance $4304 r0 *1 5.13,133
X$4304 7441 7483 7484 15 7404 27 AOI21_X1
* cell instance $4307 r0 *1 7.6,133
X$4307 15 10603 7362 7486 7268 27 DFF_X1
* cell instance $4308 r0 *1 10.83,133
X$4308 7309 15 27 7441 CLKBUF_X3
* cell instance $4310 m0 *1 12.54,133
X$4310 7367 7364 15 27 7218 NAND2_X1
* cell instance $4311 m0 *1 11.97,133
X$4311 7287 7364 15 27 7482 NAND2_X1
* cell instance $4313 m0 *1 13.3,133
X$4313 7365 7364 15 27 7217 NAND2_X1
* cell instance $4314 m0 *1 13.87,133
X$4314 15 10352 7365 7273 7113 27 DFF_X1
* cell instance $4316 m0 *1 17.29,133
X$4316 7176 7146 15 7272 27 NAND2_X4
* cell instance $4317 m0 *1 19,133
X$4317 7112 6133 7274 6134 7323 7366 15 27 OAI221_X2
* cell instance $4318 m0 *1 21.09,133
X$4318 7028 7367 15 7323 27 NAND2_X4
* cell instance $4323 r0 *1 13.11,133
X$4323 7271 15 27 7364 BUF_X2
* cell instance $4326 r0 *1 16.15,133
X$4326 7028 7365 15 7417 27 NAND2_X4
* cell instance $4327 r0 *1 17.86,133
X$4327 15 10615 7367 7366 7113 27 DFF_X1
* cell instance $4329 r0 *1 21.28,133
X$4329 7276 7232 6391 15 27 7419 MUX2_X1
* cell instance $4330 r0 *1 22.61,133
X$4330 7146 7275 5521 15 27 7420 MUX2_X1
* cell instance $4333 m0 *1 23.94,133
X$4333 7277 7340 7419 15 27 7280 MUX2_X1
* cell instance $4334 m0 *1 25.46,133
X$4334 7026 7500 5185 15 27 7337 MUX2_X1
* cell instance $4337 r0 *1 24.89,133
X$4337 7329 7500 5688 15 27 7502 MUX2_X1
* cell instance $4340 m0 *1 27.17,133
X$4340 7420 7278 7334 15 27 7426 MUX2_X1
* cell instance $4342 r0 *1 27.93,133
X$4342 7337 7450 7502 15 27 7510 MUX2_X1
* cell instance $4344 m0 *1 28.88,133
X$4344 7501 7426 7282 27 15 5315 MUX2_X2
* cell instance $4345 r0 *1 29.26,133
X$4345 7365 7442 5119 15 27 7444 MUX2_X1
* cell instance $4346 r0 *1 30.59,133
X$4346 7365 7443 5119 15 27 7445 MUX2_X1
* cell instance $4347 m0 *1 31.16,133
X$4347 15 6487 7607 7280 7347 27 AOI21_X4
* cell instance $4349 m0 *1 33.63,133
X$4349 7822 7368 7282 27 15 5279 MUX2_X2
* cell instance $4353 m0 *1 36.67,133
X$4353 7072 7369 5269 15 27 7370 MUX2_X1
* cell instance $4355 m0 *1 38,133
X$4355 7428 7369 5584 15 27 7371 MUX2_X1
* cell instance $4357 m0 *1 39.52,133
X$4357 7428 7283 5584 15 27 7373 MUX2_X1
* cell instance $4359 r0 *1 38,133
X$4359 7370 7278 7371 15 27 7429 MUX2_X1
* cell instance $4360 r0 *1 39.33,133
X$4360 7372 7451 7373 15 27 7509 MUX2_X1
* cell instance $4362 r0 *1 40.85,133
X$4362 15 5662 7618 7435 7509 27 AOI21_X4
* cell instance $4364 m0 *1 41.23,133
X$4364 7374 7429 7282 27 15 5434 MUX2_X2
* cell instance $4366 r0 *1 43.32,133
X$4366 6885 7448 7449 15 27 7375 MUX2_X1
* cell instance $4368 m0 *1 44.08,133
X$4368 7375 7340 7376 15 27 7284 MUX2_X1
* cell instance $4370 m0 *1 49.97,133
X$4370 15 7431 7378 10672 6955 27 DFF_X2
* cell instance $4371 m0 *1 53.58,133
X$4371 5869 7182 7286 15 27 7431 MUX2_X1
* cell instance $4374 m0 *1 57.19,133
X$4374 15 7377 7378 10696 7177 27 DFF_X2
* cell instance $4375 m0 *1 60.8,133
X$4375 15 7433 7378 10701 7287 27 DFF_X2
* cell instance $4376 m0 *1 64.41,133
X$4376 7287 7454 5424 15 27 7520 MUX2_X1
* cell instance $4378 m0 *1 65.93,133
X$4378 7287 7283 5424 15 27 7379 MUX2_X1
* cell instance $4380 m0 *1 67.45,133
X$4380 7434 7099 15 27 7182 NAND2_X2
* cell instance $4382 m0 *1 68.59,133
X$4382 7288 5510 15 27 7439 NOR2_X2
* cell instance $4384 m0 *1 69.73,133
X$4384 5510 7288 15 27 7436 OR2_X1
* cell instance $4385 m0 *1 70.49,133
X$4385 7436 27 7196 15 BUF_X4
* cell instance $4386 m0 *1 71.82,133
X$4386 5510 7289 15 27 7768 NAND2_X2
* cell instance $4390 r0 *1 45.41,133
X$4390 6883 7443 5222 15 27 7512 MUX2_X1
* cell instance $4391 r0 *1 46.74,133
X$4391 6883 7442 5222 15 27 7625 MUX2_X1
* cell instance $4396 r0 *1 52.44,133
X$4396 6955 7452 6812 15 27 7517 MUX2_X1
* cell instance $4397 r0 *1 53.77,133
X$4397 7515 7452 5226 15 27 7432 MUX2_X1
* cell instance $4398 r0 *1 55.1,133
X$4398 7517 7450 7432 15 27 7453 MUX2_X1
* cell instance $4404 r0 *1 62.7,133
X$4404 7521 7283 7041 15 27 7524 MUX2_X1
* cell instance $4405 r0 *1 64.03,133
X$4405 7521 7454 7041 15 27 7523 MUX2_X1
* cell instance $4406 r0 *1 65.36,133
X$4406 7520 7383 7523 15 27 7455 MUX2_X1
* cell instance $4407 r0 *1 66.69,133
X$4407 7379 7451 7524 15 27 7526 MUX2_X1
* cell instance $4408 r0 *1 68.02,133
X$4408 7664 7435 7526 15 27 7424 MUX2_X1
* cell instance $4411 r0 *1 70.49,133
X$4411 15 7456 7438 6522 7042 27 DFF_X1
* cell instance $4412 r0 *1 73.72,133
X$4412 7289 5510 7438 15 27 7528 OR3_X1
* cell instance $4413 m0 *1 75.24,133
X$4413 6922 15 27 7434 INV_X1
* cell instance $4414 m0 *1 73.91,133
X$4414 7438 27 6549 15 BUF_X4
* cell instance $4417 r0 *1 74.67,133
X$4417 7528 27 6922 15 BUF_X4
* cell instance $4419 r0 *1 76.19,133
X$4419 6405 7434 15 27 7457 NAND2_X2
* cell instance $4421 m0 *1 76.76,133
X$4421 6405 7439 15 27 7190 NAND2_X2
* cell instance $4424 r0 *1 77.9,133
X$4424 7383 27 7281 15 BUF_X4
* cell instance $4425 m0 *1 80.18,133
X$4425 7102 7380 6969 15 27 7290 NAND3_X1
* cell instance $4426 m0 *1 78.85,133
X$4426 6473 7355 7437 15 27 7358 MUX2_X1
* cell instance $4428 m0 *1 81.13,133
X$4428 7382 6518 15 27 7356 NAND2_X2
* cell instance $4429 m0 *1 82.08,133
X$4429 7102 15 27 7382 INV_X4
* cell instance $4430 m0 *1 83.03,133
X$4430 7355 7382 15 7384 27 NAND2_X4
* cell instance $4431 m0 *1 84.74,133
X$4431 7102 7355 2126 15 27 7385 AND3_X4
* cell instance $4434 r0 *1 79.99,133
X$4434 7458 7531 15 27 7638 NAND2_X1
* cell instance $4437 r0 *1 82.27,133
X$4437 7383 27 7278 15 BUF_X4
* cell instance $4440 r0 *1 85.88,133
X$4440 7386 7102 6972 15 27 7291 NAND3_X2
* cell instance $4441 r0 *1 87.21,133
X$4441 7102 15 27 7292 BUF_X2
* cell instance $4443 m0 *1 87.21,133
X$4443 6408 7355 7293 15 27 7461 MUX2_X1
* cell instance $4444 m0 *1 94.62,133
X$4444 7389 7385 15 27 7387 NAND2_X2
* cell instance $4447 r0 *1 88.35,133
X$4447 15 7461 7357 10799 7386 27 DFF_X2
* cell instance $4448 r0 *1 91.96,133
X$4448 6922 27 7274 15 BUF_X4
* cell instance $4451 r0 *1 93.86,133
X$4451 6212 7384 7387 6213 5937 27 15 7527 OAI221_X1
* cell instance $4452 r0 *1 95,133
X$4452 15 7527 7294 10733 7389 27 DFF_X2
* cell instance $4454 m0 *1 95.95,133
X$4454 7295 7388 7389 15 27 7296 MUX2_X1
* cell instance $4456 m0 *1 101.08,133
X$4456 15 7519 6827 10709 7298 27 DFF_X2
* cell instance $4462 r0 *1 100.32,133
X$4462 5959 7384 7518 6214 5937 27 15 7519 OAI221_X1
* cell instance $4464 r0 *1 101.65,133
X$4464 6834 7115 7298 15 27 7464 MUX2_X1
* cell instance $4465 r0 *1 102.98,133
X$4465 7298 7385 15 27 7518 NAND2_X2
* cell instance $4469 r0 *1 106.02,133
X$4469 6744 5937 7384 6181 7516 7636 15 27 OAI221_X2
* cell instance $4470 m0 *1 109.06,133
X$4470 7196 27 7193 15 BUF_X4
* cell instance $4471 m0 *1 107.35,133
X$4471 7430 7385 15 7516 27 NAND2_X4
* cell instance $4472 m0 *1 110.39,133
X$4472 6689 7384 7514 5921 5937 27 15 7351 OAI221_X1
* cell instance $4473 m0 *1 111.53,133
X$4473 7054 15 27 CLKBUF_X1
* cell instance $4475 m0 *1 112.29,133
X$4475 15 7390 27 7384 BUF_X8
* cell instance $4477 r0 *1 108.11,133
X$4477 15 7351 7054 10808 7557 27 DFF_X2
* cell instance $4478 r0 *1 111.72,133
X$4478 15 7385 7559 27 BUF_X16
* cell instance $4482 m0 *1 115.33,133
X$4482 6636 7300 7390 6764 7736 7465 15 27 OAI221_X2
* cell instance $4487 r0 *1 117.42,133
X$4487 15 7466 7056 10776 7513 27 DFF_X2
* cell instance $4488 m0 *1 117.99,133
X$4488 6747 7300 7390 6826 7301 7466 15 27 OAI221_X2
* cell instance $4495 m0 *1 121.22,133
X$4495 7562 7391 15 7392 27 NAND2_X4
* cell instance $4499 r0 *1 121.79,133
X$4499 6560 7300 7390 6566 7392 7635 15 27 OAI221_X2
* cell instance $4502 r0 *1 125.02,133
X$4502 6789 7300 7390 6637 7511 7634 15 27 OAI221_X2
* cell instance $4504 m0 *1 130.72,133
X$4504 7393 6063 15 27 7425 NAND2_X1
* cell instance $4505 m0 *1 127.11,133
X$4505 15 7427 7123 10678 7393 27 DFF_X2
* cell instance $4509 r0 *1 129.2,133
X$4509 15 10521 7468 7508 7123 27 DFF_X1
* cell instance $4510 m0 *1 132.43,133
X$4510 7083 6224 15 27 7470 NAND2_X1
* cell instance $4511 m0 *1 131.67,133
X$4511 5383 7425 7345 15 7427 27 AOI21_X1
* cell instance $4515 r0 *1 132.43,133
X$4515 5383 7469 7470 15 7508 27 AOI21_X1
* cell instance $4518 r0 *1 136.42,133
X$4518 7394 7471 15 27 7507 NAND2_X1
* cell instance $4519 r0 *1 136.99,133
X$4519 7424 7471 15 27 6928 NAND2_X1
* cell instance $4520 r0 *1 137.56,133
X$4520 7471 15 27 7418 CLKBUF_X3
* cell instance $4521 m0 *1 138.7,133
X$4521 7422 7395 27 15 7341 XNOR2_X1
* cell instance $4522 m0 *1 137.94,133
X$4522 7423 6988 15 27 7421 OR2_X1
* cell instance $4525 r0 *1 138.51,133
X$4525 7397 7507 15 27 7506 XOR2_X1
* cell instance $4526 r0 *1 139.65,133
X$4526 7472 7421 27 15 7505 XNOR2_X1
* cell instance $4527 r0 *1 140.79,133
X$4527 7506 7505 27 15 7396 XNOR2_X1
* cell instance $4529 m0 *1 140.98,133
X$4529 7396 7341 27 15 7339 XNOR2_X1
* cell instance $4533 r0 *1 142.5,133
X$4533 7303 7418 15 27 7416 NAND2_X1
* cell instance $4535 m0 *1 143.45,133
X$4535 7398 7339 27 15 7338 XNOR2_X1
* cell instance $4537 m0 *1 144.59,133
X$4537 7130 15 27 7415 INV_X1
* cell instance $4538 m0 *1 144.97,133
X$4538 7415 7399 15 27 7504 NAND2_X1
* cell instance $4543 r0 *1 143.64,133
X$4543 15 7416 7473 7615 7504 7397 27 FA_X1
* cell instance $4545 r0 *1 147.44,133
X$4545 7415 7418 15 27 7414 NAND2_X1
* cell instance $4548 r0 *1 148.58,133
X$4548 15 7414 7613 7497 7499 7203 27 FA_X1
* cell instance $4550 m0 *1 149.72,133
X$4550 7125 7399 15 27 7499 NAND2_X1
* cell instance $4552 m0 *1 157.89,133
X$4552 7305 7412 27 15 7324 XNOR2_X1
* cell instance $4554 m0 *1 165.11,133
X$4554 15 7491 7320 7400 7314 7410 27 FA_X1
* cell instance $4555 m0 *1 168.15,133
X$4555 7409 7406 7410 27 15 7211 HA_X1
* cell instance $4566 r0 *1 152.95,133
X$4566 7570 15 27 7571 INV_X1
* cell instance $4568 r0 *1 153.71,133
X$4568 7476 15 27 6574 INV_X2
* cell instance $4573 r0 *1 167.58,133
X$4573 7203 7489 7409 27 15 7408 HA_X1
* cell instance $4575 r0 *1 169.67,133
X$4575 6249 6844 15 7490 27 OR2_X4
* cell instance $4579 r0 *1 171.38,133
X$4579 6159 6844 15 7478 27 OR2_X4
* cell instance $4583 r0 *1 175.56,133
X$4583 7214 7406 7402 27 15 7310 HA_X1
* cell instance $4585 r0 *1 178.22,133
X$4585 15 7403 7479 7480 7487 7143 27 FA_X1
* cell instance $4589 m0 *1 79.99,110.6
X$4589 6286 5450 15 27 6284 NAND2_X1
* cell instance $4590 m0 *1 78.85,110.6
X$4590 6142 6208 6284 6214 6146 27 15 6141 OAI221_X1
* cell instance $4594 r0 *1 79.04,110.6
X$4594 6209 15 27 6386 INV_X1
* cell instance $4597 m0 *1 83.79,110.6
X$4597 6142 6144 6145 6213 6146 27 15 6285 OAI221_X1
* cell instance $4598 m0 *1 82.46,110.6
X$4598 6212 6183 6143 15 27 6144 MUX2_X1
* cell instance $4599 m0 *1 84.93,110.6
X$4599 6286 6210 15 27 6145 NAND2_X1
* cell instance $4602 r0 *1 82.65,110.6
X$4602 15 6285 6290 10760 6210 27 DFF_X2
* cell instance $4603 r0 *1 86.26,110.6
X$4603 5928 6384 27 6324 15 AND2_X4
* cell instance $4605 m0 *1 87.4,110.6
X$4605 15 5941 5880 6181 6049 5551 27 AOI22_X4
* cell instance $4608 m0 *1 93.1,110.6
X$4608 6147 6295 6053 27 6050 15 OAI21_X1
* cell instance $4609 m0 *1 93.86,110.6
X$4609 6293 15 27 6298 BUF_X1
* cell instance $4610 m0 *1 94.43,110.6
X$4610 6292 15 27 6296 CLKBUF_X3
* cell instance $4611 m0 *1 95.38,110.6
X$4611 15 6128 6295 6297 6298 27 AOI21_X4
* cell instance $4613 m0 *1 98.61,110.6
X$4613 15 6300 6301 6215 6306 27 AOI21_X4
* cell instance $4614 m0 *1 101.08,110.6
X$4614 5558 6150 6303 27 15 6304 HA_X1
* cell instance $4615 m0 *1 102.98,110.6
X$4615 6304 15 27 6308 INV_X1
* cell instance $4619 r0 *1 88.92,110.6
X$4619 6211 15 27 5637 CLKBUF_X3
* cell instance $4622 r0 *1 92.15,110.6
X$4622 6053 6294 15 27 6331 XNOR2_X2
* cell instance $4623 r0 *1 94.05,110.6
X$4623 6332 6293 6300 27 15 6148 OAI21_X4
* cell instance $4625 r0 *1 96.71,110.6
X$4625 5381 6150 10902 27 15 6301 HA_X1
* cell instance $4626 r0 *1 98.61,110.6
X$4626 5381 6379 10897 27 15 6305 HA_X1
* cell instance $4627 r0 *1 100.51,110.6
X$4627 6305 27 6306 15 BUF_X4
* cell instance $4628 r0 *1 101.84,110.6
X$4628 6308 6215 6307 27 15 6297 OAI21_X2
* cell instance $4629 r0 *1 103.17,110.6
X$4629 6305 15 27 6377 INV_X2
* cell instance $4630 m0 *1 103.93,110.6
X$4630 5381 6375 27 15 6302 AND2_X1
* cell instance $4634 m0 *1 107.92,110.6
X$4634 15 6299 6151 6058 6006 6007 27 OR4_X4
* cell instance $4635 m0 *1 110.39,110.6
X$4635 6289 6218 15 27 6151 XNOR2_X2
* cell instance $4636 m0 *1 112.29,110.6
X$4636 6057 5969 6005 27 15 6219 OAI21_X2
* cell instance $4638 r0 *1 103.74,110.6
X$4638 6303 15 27 6215 INV_X2
* cell instance $4640 r0 *1 104.69,110.6
X$4640 15 6335 6302 6336 5957 6299 27 OAI211_X4
* cell instance $4642 r0 *1 108.11,110.6
X$4642 5381 6216 10884 27 15 6217 HA_X1
* cell instance $4643 r0 *1 110.01,110.6
X$4643 6218 15 27 6288 INV_X1
* cell instance $4644 r0 *1 110.39,110.6
X$4644 6217 6288 6289 15 6372 27 AOI21_X1
* cell instance $4645 r0 *1 111.15,110.6
X$4645 6217 6219 6288 15 6291 27 AOI21_X2
* cell instance $4647 r0 *1 112.67,110.6
X$4647 6287 15 27 6218 BUF_X2
* cell instance $4648 r0 *1 113.43,110.6
X$4648 5558 6216 6287 27 15 6371 HA_X1
* cell instance $4649 m0 *1 114.19,110.6
X$4649 6059 6152 6218 27 6180 15 OAI21_X1
* cell instance $4651 m0 *1 114.95,110.6
X$4651 6218 6153 6152 27 15 6221 OAI21_X4
* cell instance $4652 m0 *1 117.42,110.6
X$4652 6218 6152 6153 15 27 6283 OR3_X2
* cell instance $4657 r0 *1 115.33,110.6
X$4657 6340 6221 6283 15 6636 27 NAND3_X4
* cell instance $4659 m0 *1 119.13,110.6
X$4659 15 6563 6062 10654 5461 27 DFF_X2
* cell instance $4664 m0 *1 125.21,110.6
X$4664 6210 6224 15 27 6280 NAND2_X1
* cell instance $4666 m0 *1 125.97,110.6
X$4666 5383 6178 6280 15 6179 27 AOI21_X1
* cell instance $4668 m0 *1 128.25,110.6
X$4668 5383 6278 6445 15 6154 27 AOI21_X1
* cell instance $4671 m0 *1 130.72,110.6
X$4671 15 6226 6273 10647 5162 27 DFF_X2
* cell instance $4672 m0 *1 134.33,110.6
X$4672 5162 6063 15 27 6272 NAND2_X1
* cell instance $4675 m0 *1 136.61,110.6
X$4675 6155 6266 27 15 6156 XNOR2_X1
* cell instance $4676 m0 *1 137.75,110.6
X$4676 6270 6156 27 15 6271 XNOR2_X1
* cell instance $4677 m0 *1 138.89,110.6
X$4677 6417 5463 27 15 6270 XNOR2_X1
* cell instance $4684 r0 *1 124.83,110.6
X$4684 5291 15 27 6224 CLKBUF_X3
* cell instance $4687 r0 *1 126.35,110.6
X$4687 6279 6224 15 27 6225 NAND2_X1
* cell instance $4691 r0 *1 131.1,110.6
X$4691 5383 6272 6225 15 6226 27 AOI21_X1
* cell instance $4695 r0 *1 139.65,110.6
X$4695 6269 6268 27 15 6227 XNOR2_X1
* cell instance $4697 m0 *1 140.41,110.6
X$4697 6176 5464 27 15 6269 XNOR2_X1
* cell instance $4700 m0 *1 145.54,110.6
X$4700 6260 5976 27 15 6229 XNOR2_X1
* cell instance $4705 r0 *1 141.17,110.6
X$4705 6267 6367 27 15 6228 XNOR2_X1
* cell instance $4706 r0 *1 142.31,110.6
X$4706 6228 6343 27 15 6266 XNOR2_X1
* cell instance $4707 r0 *1 143.45,110.6
X$4707 6257 6265 27 15 6368 XNOR2_X1
* cell instance $4708 r0 *1 144.59,110.6
X$4708 6229 6230 27 15 6367 XNOR2_X1
* cell instance $4711 r0 *1 149.15,110.6
X$4711 15 6258 6505 6259 6365 6256 27 FA_X1
* cell instance $4712 m0 *1 149.53,110.6
X$4712 6261 15 27 6258 INV_X1
* cell instance $4714 m0 *1 149.91,110.6
X$4714 15 6231 6260 6256 6363 6175 27 FA_X1
* cell instance $4717 m0 *1 160.55,110.6
X$4717 6159 6233 15 27 6158 NOR2_X2
* cell instance $4721 r0 *1 153.71,110.6
X$4721 6345 6255 15 27 6257 XOR2_X1
* cell instance $4725 r0 *1 156.94,110.6
X$4725 15 5488 6255 6347 5834 5745 27 FA_X1
* cell instance $4726 r0 *1 159.98,110.6
X$4726 6232 6233 15 27 5834 NOR2_X2
* cell instance $4729 r0 *1 162.07,110.6
X$4729 6234 15 27 5591 INV_X2
* cell instance $4732 r0 *1 163.21,110.6
X$4732 6233 6252 15 27 6234 OR2_X1
* cell instance $4733 m0 *1 163.59,110.6
X$4733 6253 15 27 6073 INV_X1
* cell instance $4735 m0 *1 163.97,110.6
X$4735 15 6235 6253 5891 6076 6169 27 FA_X1
* cell instance $4738 r0 *1 164.35,110.6
X$4738 6235 15 27 5488 INV_X2
* cell instance $4740 r0 *1 165.11,110.6
X$4740 6434 6232 15 27 6076 OR2_X2
* cell instance $4741 r0 *1 166.06,110.6
X$4741 6232 27 6249 15 BUF_X4
* cell instance $4742 m0 *1 167.77,110.6
X$4742 5745 15 27 6169 INV_X2
* cell instance $4743 m0 *1 167.39,110.6
X$4743 6251 15 27 5255 INV_X1
* cell instance $4744 m0 *1 168.34,110.6
X$4744 5978 6236 15 27 6091 NOR2_X1
* cell instance $4747 r0 *1 167.39,110.6
X$4747 15 6075 6251 5577 6169 6234 27 FA_X1
* cell instance $4749 m0 *1 170.05,110.6
X$4749 6159 5572 15 27 6160 NOR2_X1
* cell instance $4750 m0 *1 170.81,110.6
X$4750 6159 6236 15 27 6168 NOR2_X1
* cell instance $4754 r0 *1 171,110.6
X$4754 6249 5572 15 27 6247 NOR2_X1
* cell instance $4758 r0 *1 171.57,110.6
X$4758 15 6169 6077 6244 6349 6075 27 FA_X1
* cell instance $4760 m0 *1 171.76,110.6
X$4760 6247 6168 6246 27 15 6167 HA_X1
* cell instance $4761 m0 *1 175.18,110.6
X$4761 6246 15 27 6166 INV_X1
* cell instance $4764 m0 *1 179.36,110.6
X$4764 15 6353 6240 6163 6242 6165 27 FA_X1
* cell instance $4765 m0 *1 182.4,110.6
X$4765 6240 15 27 6162 INV_X1
* cell instance $4772 r0 *1 178.6,110.6
X$4772 6355 15 27 6242 INV_X1
* cell instance $4775 r0 *1 182.21,110.6
X$4775 6430 15 27 6161 INV_X1
* cell instance $4782 m0 *1 94.05,15.4
X$4782 649 778 15 27 892 XOR2_X1
* cell instance $4785 m0 *1 95.38,15.4
X$4785 649 733 821 27 15 689 OAI21_X2
* cell instance $4786 m0 *1 96.71,15.4
X$4786 779 778 650 27 688 15 OAI21_X1
* cell instance $4787 m0 *1 97.47,15.4
X$4787 734 15 27 650 INV_X1
* cell instance $4790 m0 *1 102.41,15.4
X$4790 652 651 736 15 27 298 MUX2_X1
* cell instance $4791 m0 *1 103.74,15.4
X$4791 138 652 885 27 15 830 HA_X1
* cell instance $4793 m0 *1 106.4,15.4
X$4793 737 653 27 15 687 XNOR2_X1
* cell instance $4794 m0 *1 107.54,15.4
X$4794 685 15 27 737 INV_X1
* cell instance $4795 m0 *1 107.92,15.4
X$4795 563 685 653 15 777 27 AOI21_X2
* cell instance $4796 m0 *1 109.25,15.4
X$4796 655 737 656 27 15 657 OAI21_X4
* cell instance $4797 m0 *1 111.72,15.4
X$4797 739 657 27 15 589 XNOR2_X1
* cell instance $4798 m0 *1 112.86,15.4
X$4798 834 775 15 27 485 XNOR2_X2
* cell instance $4801 m0 *1 115.71,15.4
X$4801 256 436 15 651 27 NAND2_X4
* cell instance $4802 m0 *1 117.42,15.4
X$4802 436 15 27 682 BUF_X1
* cell instance $4803 m0 *1 117.99,15.4
X$4803 587 662 15 27 741 NAND2_X1
* cell instance $4806 m0 *1 121.79,15.4
X$4806 15 566 659 325 201 421 27 NAND4_X4
* cell instance $4807 m0 *1 125.21,15.4
X$4807 659 201 325 15 27 743 NAND3_X1
* cell instance $4809 m0 *1 126.16,15.4
X$4809 662 15 27 744 INV_X1
* cell instance $4811 m0 *1 126.73,15.4
X$4811 325 566 53 768 27 15 769 AND4_X1
* cell instance $4812 m0 *1 127.87,15.4
X$4812 769 329 429 15 27 678 NAND3_X1
* cell instance $4814 r0 *1 93.86,15.4
X$4814 824 15 27 891 INV_X2
* cell instance $4816 r0 *1 94.81,15.4
X$4816 111 891 649 27 15 734 HA_X1
* cell instance $4817 r0 *1 96.71,15.4
X$4817 821 15 27 825 INV_X1
* cell instance $4819 r0 *1 100.13,15.4
X$4819 887 651 886 15 27 390 MUX2_X1
* cell instance $4821 r0 *1 101.65,15.4
X$4821 735 827 27 15 886 XNOR2_X1
* cell instance $4822 r0 *1 102.79,15.4
X$4822 829 963 27 15 736 XNOR2_X1
* cell instance $4825 r0 *1 104.5,15.4
X$4825 884 883 829 27 15 832 OAI21_X4
* cell instance $4826 r0 *1 106.97,15.4
X$4826 831 832 27 15 882 XNOR2_X1
* cell instance $4827 r0 *1 108.11,15.4
X$4827 15 656 738 832 833 27 AOI21_X4
* cell instance $4828 r0 *1 110.58,15.4
X$4828 878 739 777 27 15 775 OAI21_X4
* cell instance $4829 r0 *1 113.05,15.4
X$4829 658 15 27 878 INV_X1
* cell instance $4831 r0 *1 113.62,15.4
X$4831 740 15 27 877 INV_X2
* cell instance $4832 r0 *1 114.19,15.4
X$4832 15 663 835 775 834 27 AOI21_X4
* cell instance $4836 r0 *1 116.66,15.4
X$4836 741 742 15 27 50 XNOR2_X2
* cell instance $4838 r0 *1 118.94,15.4
X$4838 838 742 839 27 840 15 OAI21_X1
* cell instance $4839 r0 *1 119.7,15.4
X$4839 840 874 876 27 487 15 OAI21_X1
* cell instance $4840 r0 *1 120.46,15.4
X$4840 663 15 27 838 INV_X1
* cell instance $4844 r0 *1 121.98,15.4
X$4844 744 742 27 15 874 AND2_X1
* cell instance $4846 r0 *1 123.12,15.4
X$4846 53 114 329 15 955 27 AOI21_X1
* cell instance $4848 r0 *1 124.07,15.4
X$4848 421 329 53 27 15 842 AND3_X1
* cell instance $4849 r0 *1 125.02,15.4
X$4849 872 743 15 27 841 NAND2_X1
* cell instance $4851 r0 *1 125.97,15.4
X$4851 660 566 15 27 872 NAND2_X1
* cell instance $4853 r0 *1 126.92,15.4
X$4853 15 871 678 1074 766 870 27 AOI22_X4
* cell instance $4855 m0 *1 129.01,15.4
X$4855 843 745 661 27 15 427 OAI21_X2
* cell instance $4856 m0 *1 131.1,15.4
X$4856 662 765 15 259 27 NAND2_X4
* cell instance $4857 m0 *1 132.81,15.4
X$4857 765 15 27 664 BUF_X2
* cell instance $4858 m0 *1 133.57,15.4
X$4858 663 664 15 252 27 NAND2_X4
* cell instance $4861 r0 *1 130.34,15.4
X$4861 843 661 745 15 27 422 OR3_X2
* cell instance $4864 r0 *1 132.43,15.4
X$4864 744 922 93 668 745 27 15 AOI211_X2
* cell instance $4865 r0 *1 134.14,15.4
X$4865 747 760 15 27 566 XNOR2_X2
* cell instance $4866 m0 *1 135.85,15.4
X$4866 665 252 436 256 676 27 15 AOI211_X2
* cell instance $4868 m0 *1 137.56,15.4
X$4868 667 573 666 15 126 27 NAND3_X4
* cell instance $4869 m0 *1 140.03,15.4
X$4869 572 667 15 27 760 NAND2_X1
* cell instance $4871 m0 *1 140.79,15.4
X$4871 667 747 761 27 15 670 AND3_X1
* cell instance $4873 m0 *1 143.26,15.4
X$4873 748 673 15 27 430 XNOR2_X2
* cell instance $4874 m0 *1 145.16,15.4
X$4874 669 15 27 378 INV_X1
* cell instance $4875 m0 *1 145.54,15.4
X$4875 127 499 444 669 15 27 758 OR4_X1
* cell instance $4876 m0 *1 146.68,15.4
X$4876 758 259 437 15 27 671 NOR3_X1
* cell instance $4877 m0 *1 147.44,15.4
X$4877 754 671 27 15 660 XNOR2_X1
* cell instance $4881 r0 *1 139.46,15.4
X$4881 845 927 15 27 582 NOR2_X1
* cell instance $4883 r0 *1 140.22,15.4
X$4883 746 15 27 951 INV_X1
* cell instance $4887 r0 *1 143.07,15.4
X$4887 948 847 15 27 377 XNOR2_X2
* cell instance $4888 r0 *1 144.97,15.4
X$4888 862 848 15 27 499 XNOR2_X2
* cell instance $4892 m0 *1 148.96,15.4
X$4892 15 750 748 575 754 667 27 NOR4_X4
* cell instance $4893 m0 *1 152.57,15.4
X$4893 753 749 27 575 15 XOR2_X2
* cell instance $4894 m0 *1 154.28,15.4
X$4894 752 750 27 669 15 XOR2_X2
* cell instance $4903 r0 *1 149.34,15.4
X$4903 751 1115 15 27 748 XNOR2_X2
* cell instance $4906 r0 *1 152.19,15.4
X$4906 862 749 856 15 27 NOR2_X4
* cell instance $4909 r0 *1 154.47,15.4
X$4909 849 856 27 15 853 AND2_X1
* cell instance $4911 r0 *1 155.61,15.4
X$4911 853 934 751 27 15 752 AND3_X1
* cell instance $4924 m0 *1 21.66,77
X$4924 3988 4211 4210 15 27 4212 NAND3_X2
* cell instance $4926 m0 *1 22.99,77
X$4926 3988 3931 15 27 3846 NAND2_X1
* cell instance $4928 m0 *1 23.75,77
X$4928 3239 4351 4269 27 15 4353 OAI21_X2
* cell instance $4929 m0 *1 25.08,77
X$4929 3931 4213 3988 4214 27 15 4352 AND4_X1
* cell instance $4932 m0 *1 27.17,77
X$4932 15 4215 4352 3054 4099 27 AOI21_X4
* cell instance $4935 m0 *1 17.67,77
X$4935 3873 4211 15 27 4350 XNOR2_X2
* cell instance $4937 r0 *1 17.86,77
X$4937 15 4102 3396 4350 4268 27 AOI21_X4
* cell instance $4939 m0 *1 19.95,77
X$4939 3633 4211 27 15 4351 XNOR2_X1
* cell instance $4941 r0 *1 20.52,77
X$4941 4210 4211 4012 27 15 4440 AND3_X1
* cell instance $4942 r0 *1 21.47,77
X$4942 4440 4290 4096 15 27 4375 OR3_X2
* cell instance $4943 r0 *1 22.61,77
X$4943 15 4440 4290 4096 4291 27 NOR3_X4
* cell instance $4946 r0 *1 27.55,77
X$4946 15 4353 3882 4292 4215 4295 27 NAND4_X4
* cell instance $4948 m0 *1 30.02,77
X$4948 15 4294 3882 4292 4215 27 AOI21_X4
* cell instance $4950 m0 *1 33.44,77
X$4950 3884 4216 3934 27 4355 15 NOR3_X2
* cell instance $4952 m0 *1 35.53,77
X$4952 15 4015 4217 4358 4355 4218 27 AOI22_X4
* cell instance $4953 m0 *1 38.76,77
X$4953 4219 4296 15 27 4218 NOR2_X2
* cell instance $4954 m0 *1 39.71,77
X$4954 15 4102 3245 4358 4359 27 NOR3_X4
* cell instance $4956 m0 *1 43.13,77
X$4956 3733 3934 15 27 4221 NOR2_X2
* cell instance $4959 r0 *1 30.97,77
X$4959 3882 4215 4292 15 27 4445 NAND3_X1
* cell instance $4961 r0 *1 32.49,77
X$4961 4297 4298 4554 15 3414 27 NAND3_X4
* cell instance $4962 r0 *1 34.96,77
X$4962 4293 4294 4376 4295 4296 4219 15 27 4101 OAI33_X1
* cell instance $4963 r0 *1 36.29,77
X$4963 4219 4296 4295 3182 27 3550 15 NOR4_X2
* cell instance $4964 r0 *1 38,77
X$4964 3683 3684 2838 4218 4298 4537 27 15 AOI221_X2
* cell instance $4965 r0 *1 40.09,77
X$4965 4299 4293 15 27 4538 NAND2_X1
* cell instance $4967 r0 *1 41.04,77
X$4967 4294 4293 15 27 4361 NOR2_X2
* cell instance $4968 r0 *1 41.99,77
X$4968 15 4361 4103 4380 4221 2900 27 AOI22_X4
* cell instance $4970 r0 *1 45.6,77
X$4970 4378 3273 4362 27 4377 15 OAI21_X1
* cell instance $4972 r0 *1 46.74,77
X$4972 4379 4380 4278 4453 4454 27 15 AOI211_X2
* cell instance $4974 m0 *1 47.5,77
X$4974 4108 3734 4107 15 27 4224 OR3_X2
* cell instance $4977 r0 *1 48.64,77
X$4977 4222 4183 4540 15 27 3918 AND3_X4
* cell instance $4978 m0 *1 50.73,77
X$4978 3889 3918 15 2935 27 NAND2_X4
* cell instance $4980 m0 *1 52.44,77
X$4980 4224 4223 4022 3183 4543 4225 15 27 4363 OAI33_X1
* cell instance $4981 m0 *1 53.77,77
X$4981 4363 4226 4303 15 27 NOR2_X4
* cell instance $4983 m0 *1 55.67,77
X$4983 4226 4363 15 27 4382 OR2_X2
* cell instance $4986 r0 *1 50.73,77
X$4986 15 4305 4629 2935 4454 27 AOI21_X4
* cell instance $4988 r0 *1 53.96,77
X$4988 4222 3275 3183 27 15 4301 OAI21_X2
* cell instance $4990 r0 *1 55.48,77
X$4990 4169 4301 27 4302 15 XOR2_X2
* cell instance $4992 r0 *1 57.57,77
X$4992 15 4227 4302 4303 4364 27 NOR3_X4
* cell instance $4994 m0 *1 57.76,77
X$4994 15 4302 4228 4381 4227 3499 27 NOR4_X4
* cell instance $5000 r0 *1 60.99,77
X$5000 15 4023 4455 4304 4305 3589 27 NAND4_X4
* cell instance $5001 m0 *1 62.51,77
X$5001 3588 3589 2293 15 27 NOR2_X4
* cell instance $5003 m0 *1 64.22,77
X$5003 4366 4382 3499 15 27 4284 NAND3_X1
* cell instance $5004 m0 *1 64.98,77
X$5004 4002 4026 4230 27 15 4460 OAI21_X4
* cell instance $5006 m0 *1 70.49,77
X$5006 4371 4029 4085 15 4307 27 AOI21_X2
* cell instance $5009 m0 *1 73.53,77
X$5009 15 4285 4547 2800 4309 27 AOI21_X4
* cell instance $5012 m0 *1 76.95,77
X$5012 15 4373 4117 4115 4032 3653 27 NAND4_X4
* cell instance $5013 m0 *1 80.37,77
X$5013 4373 15 27 4190 BUF_X1
* cell instance $5016 m0 *1 83.22,77
X$5016 4372 4389 4231 27 15 4391 OAI21_X2
* cell instance $5019 r0 *1 64.6,77
X$5019 4455 4303 3740 27 15 4384 AND3_X1
* cell instance $5021 r0 *1 65.74,77
X$5021 4230 4026 4457 4479 4002 3809 15 27 OAI221_X2
* cell instance $5023 r0 *1 68.02,77
X$5023 4459 4384 4306 27 4462 15 OAI21_X1
* cell instance $5024 r0 *1 68.78,77
X$5024 3743 3694 3808 15 27 4662 NAND3_X1
* cell instance $5026 r0 *1 70.3,77
X$5026 4482 4385 15 27 4371 NAND2_X1
* cell instance $5028 r0 *1 71.25,77
X$5028 4482 4385 4306 15 27 4461 NAND3_X1
* cell instance $5030 r0 *1 72.2,77
X$5030 4461 4462 3808 27 15 4309 MUX2_X2
* cell instance $5032 r0 *1 74.29,77
X$5032 4485 2780 4309 15 4549 27 AOI21_X2
* cell instance $5033 r0 *1 75.62,77
X$5033 4308 4115 4032 4386 15 27 4466 NAND4_X1
* cell instance $5035 r0 *1 76.95,77
X$5035 4032 4115 4308 27 15 4387 AND3_X2
* cell instance $5036 r0 *1 78.09,77
X$5036 4308 15 27 4373 BUF_X1
* cell instance $5037 r0 *1 78.66,77
X$5037 15 4117 4308 4032 4115 2990 27 AND4_X4
* cell instance $5040 r0 *1 81.7,77
X$5040 4388 4387 4310 27 15 4389 AND3_X1
* cell instance $5041 r0 *1 82.65,77
X$5041 4310 4388 4387 15 4231 27 AOI21_X2
* cell instance $5043 m0 *1 87.02,77
X$5043 4392 4232 4393 3816 15 27 4119 NOR4_X1
* cell instance $5044 m0 *1 84.93,77
X$5044 4282 4389 4231 15 27 4314 OR3_X4
* cell instance $5045 m0 *1 87.97,77
X$5045 3926 4006 3816 15 4311 27 AOI21_X1
* cell instance $5046 m0 *1 88.73,77
X$5046 4234 4232 15 27 4282 NOR2_X1
* cell instance $5048 m0 *1 90.06,77
X$5048 4233 3871 4312 27 15 4367 OAI21_X2
* cell instance $5049 m0 *1 91.39,77
X$5049 4235 3893 4004 15 4368 27 AOI21_X2
* cell instance $5050 m0 *1 92.72,77
X$5050 4235 15 27 4236 INV_X1
* cell instance $5052 m0 *1 93.29,77
X$5052 4234 4236 15 27 4370 NOR2_X1
* cell instance $5053 m0 *1 93.86,77
X$5053 15 3666 4368 3070 4369 27 AOI21_X4
* cell instance $5055 m0 *1 96.52,77
X$5055 15 4367 4237 3070 4240 3253 27 OAI211_X4
* cell instance $5059 r0 *1 88.16,77
X$5059 4311 3893 4391 27 15 4394 OAI21_X2
* cell instance $5060 r0 *1 89.49,77
X$5060 3339 27 3893 15 BUF_X4
* cell instance $5063 r0 *1 92.72,77
X$5063 4236 4312 3871 27 4369 15 NOR3_X2
* cell instance $5065 r0 *1 94.24,77
X$5065 3253 3070 4370 27 4395 15 OAI21_X1
* cell instance $5067 r0 *1 96.52,77
X$5067 2919 4367 4237 27 15 4397 AND3_X2
* cell instance $5069 r0 *1 97.85,77
X$5069 3435 4391 4234 15 27 4242 OR3_X1
* cell instance $5071 r0 *1 98.99,77
X$5071 4314 4313 4280 15 4396 27 NAND3_X4
* cell instance $5072 m0 *1 101.46,77
X$5072 4001 4238 4240 27 4316 15 OAI21_X1
* cell instance $5073 m0 *1 100.13,77
X$5073 4075 27 3070 15 BUF_X4
* cell instance $5075 m0 *1 102.41,77
X$5075 4238 4001 3666 27 4365 15 OAI21_X1
* cell instance $5077 m0 *1 103.36,77
X$5077 4279 3666 27 4319 15 XOR2_X2
* cell instance $5078 m0 *1 105.07,77
X$5078 3777 3778 4239 27 4279 15 OAI21_X1
* cell instance $5079 m0 *1 105.83,77
X$5079 4315 3285 3521 15 4239 27 AOI21_X1
* cell instance $5082 r0 *1 101.65,77
X$5082 4315 4316 15 27 4317 OR2_X1
* cell instance $5083 r0 *1 102.41,77
X$5083 4396 4397 3750 15 27 NOR2_X4
* cell instance $5084 r0 *1 104.12,77
X$5084 4315 4365 15 27 4320 OR2_X1
* cell instance $5086 r0 *1 105.26,77
X$5086 4280 4314 15 27 4318 NAND2_X1
* cell instance $5088 r0 *1 106.02,77
X$5088 4318 3521 3285 15 4399 27 AOI21_X2
* cell instance $5089 m0 *1 107.54,77
X$5089 4241 4280 4240 15 27 4243 NAND3_X1
* cell instance $5090 m0 *1 106.97,77
X$5090 3917 4039 15 27 4241 NOR2_X1
* cell instance $5094 m0 *1 110.77,77
X$5094 4242 4314 15 27 4244 NAND2_X1
* cell instance $5096 m0 *1 111.53,77
X$5096 4243 4244 2811 15 27 4322 NOR3_X1
* cell instance $5097 m0 *1 112.29,77
X$5097 4322 4244 4243 15 4273 27 AOI21_X1
* cell instance $5098 m0 *1 113.05,77
X$5098 4244 4245 15 27 4323 NOR2_X1
* cell instance $5101 m0 *1 115.33,77
X$5101 4319 4125 27 15 4274 AND2_X2
* cell instance $5103 r0 *1 107.35,77
X$5103 3521 3285 15 27 4767 NAND2_X1
* cell instance $5104 r0 *1 107.92,77
X$5104 15 4314 4280 4240 4313 3777 27 NAND4_X4
* cell instance $5105 r0 *1 111.34,77
X$5105 4314 4245 4242 27 15 4400 AND3_X1
* cell instance $5106 r0 *1 112.29,77
X$5106 4320 4245 15 27 4321 NAND2_X1
* cell instance $5107 r0 *1 112.86,77
X$5107 4321 2811 4317 27 15 4128 OAI21_X2
* cell instance $5110 r0 *1 114.76,77
X$5110 4280 4468 15 27 4467 XOR2_X1
* cell instance $5115 m0 *1 118.37,77
X$5115 4275 4402 15 27 3622 NAND2_X2
* cell instance $5116 m0 *1 116.66,77
X$5116 4127 4129 4125 4319 15 27 4275 AOI22_X2
* cell instance $5120 m0 *1 121.79,77
X$5120 4198 3134 15 27 4249 NAND2_X2
* cell instance $5122 m0 *1 122.93,77
X$5122 15 3826 4274 4043 4129 27 AOI21_X4
* cell instance $5123 m0 *1 125.4,77
X$5123 4248 4130 4068 4247 15 4271 27 NAND4_X2
* cell instance $5124 m0 *1 127.11,77
X$5124 4068 4130 4248 4247 27 15 4357 AND4_X1
* cell instance $5127 r0 *1 117.04,77
X$5127 4497 4401 27 15 4246 AND2_X1
* cell instance $5129 r0 *1 118.18,77
X$5129 4128 4467 15 27 4248 NOR2_X1
* cell instance $5134 r0 *1 121.6,77
X$5134 4497 4129 4360 15 4045 27 AOI21_X2
* cell instance $5135 r0 *1 122.93,77
X$5135 4128 15 27 4360 INV_X1
* cell instance $5137 r0 *1 123.5,77
X$5137 4129 4248 27 15 4044 AND2_X1
* cell instance $5139 r0 *1 124.64,77
X$5139 4273 4043 4044 15 4325 27 AOI21_X1
* cell instance $5141 r0 *1 125.78,77
X$5141 3612 4403 4404 27 15 4407 AND3_X2
* cell instance $5142 r0 *1 126.92,77
X$5142 4325 4326 15 27 4463 NOR2_X1
* cell instance $5143 r0 *1 127.49,77
X$5143 4326 4325 15 27 4327 OR2_X1
* cell instance $5146 m0 *1 128.63,77
X$5146 15 4068 4130 3826 4249 4406 27 NAND4_X4
* cell instance $5148 m0 *1 133.76,77
X$5148 3826 4249 27 15 4250 AND2_X2
* cell instance $5149 m0 *1 134.71,77
X$5149 15 4250 3959 3297 4253 3217 27 OAI211_X4
* cell instance $5152 r0 *1 129.39,77
X$5152 4405 4328 4354 4251 15 4356 27 NAND4_X2
* cell instance $5155 r0 *1 131.67,77
X$5155 4328 4354 4405 15 3217 27 NAND3_X4
* cell instance $5156 r0 *1 134.14,77
X$5156 3216 4458 15 27 3619 OR2_X1
* cell instance $5158 r0 *1 135.09,77
X$5158 15 4407 3959 4250 4328 4048 27 NAND4_X4
* cell instance $5160 m0 *1 138.32,77
X$5160 4251 4250 3959 15 4330 27 AOI21_X2
* cell instance $5161 m0 *1 140.41,77
X$5161 4409 4329 4252 15 3968 27 NAND3_X4
* cell instance $5162 m0 *1 142.88,77
X$5162 4330 3709 4251 4252 3304 27 15 AOI211_X2
* cell instance $5163 m0 *1 144.59,77
X$5163 4330 4251 4252 15 3380 27 AOI21_X2
* cell instance $5167 m0 *1 153.71,77
X$5167 4135 15 27 4616 INV_X1
* cell instance $5170 r0 *1 138.89,77
X$5170 4250 4328 4407 3959 27 15 3964 AND4_X1
* cell instance $5172 r0 *1 140.41,77
X$5172 15 3012 4410 4252 4412 27 AOI21_X4
* cell instance $5174 r0 *1 143.07,77
X$5174 4329 15 27 4450 INV_X1
* cell instance $5175 r0 *1 143.45,77
X$5175 4450 4253 4452 27 15 3967 OAI21_X4
* cell instance $5178 r0 *1 153.52,77
X$5178 15 4416 4449 4331 4332 4417 27 FA_X1
* cell instance $5180 m0 *1 154.47,77
X$5180 15 4331 4136 4347 4447 4448 27 FA_X1
* cell instance $5183 m0 *1 159.98,77
X$5183 4347 4346 4348 27 15 4267 HA_X1
* cell instance $5187 r0 *1 158.46,77
X$5187 15 4417 4447 4345 4332 4420 27 FA_X1
* cell instance $5189 r0 *1 161.88,77
X$5189 15 4345 4346 4441 4442 4416 27 FA_X1
* cell instance $5191 m0 *1 162.26,77
X$5191 4522 4267 4167 27 15 4266 HA_X1
* cell instance $5194 m0 *1 166.63,77
X$5194 4254 15 27 4265 INV_X1
* cell instance $5196 m0 *1 167.77,77
X$5196 4436 4438 4344 27 15 4255 HA_X1
* cell instance $5198 m0 *1 169.86,77
X$5198 4256 15 27 4162 INV_X1
* cell instance $5201 m0 *1 174.04,77
X$5201 4343 4432 4341 27 15 4257 HA_X1
* cell instance $5204 m0 *1 176.89,77
X$5204 4334 15 27 4144 INV_X1
* cell instance $5209 r0 *1 166.06,77
X$5209 4441 4508 4439 27 15 4438 HA_X1
* cell instance $5215 r0 *1 172.52,77
X$5215 4434 15 27 4333 INV_X1
* cell instance $5216 r0 *1 172.9,77
X$5216 15 4509 4434 4264 4435 4843 27 FA_X1
* cell instance $5218 r0 *1 176.32,77
X$5218 15 4340 4334 4339 4430 4422 27 FA_X1
* cell instance $5220 m0 *1 179.17,77
X$5220 4339 15 27 4261 INV_X1
* cell instance $5222 m0 *1 180.5,77
X$5222 15 4707 4262 4335 4426 4261 27 FA_X1
* cell instance $5224 m0 *1 183.73,77
X$5224 4337 4425 4142 15 4260 27 AOI21_X1
* cell instance $5225 m0 *1 184.49,77
X$5225 4259 4258 4142 27 15 4337 HA_X1
* cell instance $5231 r0 *1 183.35,77
X$5231 15 4513 4338 4259 4693 4335 27 FA_X1
* cell instance $5234 m0 *1 56.05,93.8
X$5234 4979 5228 5271 15 5227 27 AOI21_X1
* cell instance $5235 m0 *1 55.29,93.8
X$5235 4979 5100 5273 15 5147 27 AOI21_X1
* cell instance $5236 m0 *1 56.81,93.8
X$5236 15 5227 5101 10720 36 27 DFF_X2
* cell instance $5238 m0 *1 60.61,93.8
X$5238 5192 15 27 4888 CLKBUF_X3
* cell instance $5239 m0 *1 61.56,93.8
X$5239 5149 4888 1298 15 27 5243 NAND3_X1
* cell instance $5243 r0 *1 55.48,93.8
X$5243 5337 5238 15 27 5273 NAND2_X1
* cell instance $5244 r0 *1 56.05,93.8
X$5244 5424 5238 15 27 5271 NAND2_X1
* cell instance $5252 r0 *1 59.66,93.8
X$5252 5024 15 27 5101 CLKBUF_X3
* cell instance $5253 r0 *1 60.61,93.8
X$5253 5101 15 27 10847 INV_X1
* cell instance $5255 r0 *1 61.18,93.8
X$5255 15 10582 5270 5243 5101 27 DFF_X1
* cell instance $5256 m0 *1 63.65,93.8
X$5256 15 5230 5101 10658 38 27 DFF_X2
* cell instance $5258 m0 *1 67.26,93.8
X$5258 5244 5190 5232 15 5230 27 AOI21_X1
* cell instance $5259 m0 *1 68.02,93.8
X$5259 5181 5190 15 27 5149 NAND2_X1
* cell instance $5260 m0 *1 68.59,93.8
X$5260 19 5190 15 27 5191 NAND2_X1
* cell instance $5261 m0 *1 69.16,93.8
X$5261 1394 5341 5191 15 5233 27 AOI21_X1
* cell instance $5262 m0 *1 69.92,93.8
X$5262 5190 5192 5191 27 5150 15 OAI21_X1
* cell instance $5263 m0 *1 70.68,93.8
X$5263 39 5150 5194 15 27 5151 MUX2_X1
* cell instance $5267 r0 *1 66.69,93.8
X$5267 5270 15 27 5190 BUF_X2
* cell instance $5268 r0 *1 67.45,93.8
X$5268 38 5148 1298 27 5244 15 OAI21_X1
* cell instance $5269 r0 *1 68.21,93.8
X$5269 15 5195 5283 5233 5033 27 DFF_X1
* cell instance $5271 r0 *1 71.63,93.8
X$5271 16 15 27 5245 INV_X1
* cell instance $5272 r0 *1 72.01,93.8
X$5272 5345 5245 15 27 5268 NAND2_X1
* cell instance $5273 m0 *1 72.58,93.8
X$5273 5268 5149 15 27 5234 NAND2_X1
* cell instance $5275 m0 *1 73.15,93.8
X$5275 5194 15 27 5193 INV_X1
* cell instance $5277 r0 *1 72.58,93.8
X$5277 5193 5190 5345 27 5246 15 NOR3_X2
* cell instance $5278 r0 *1 73.91,93.8
X$5278 5234 5246 15 27 5247 NOR2_X1
* cell instance $5280 m0 *1 73.91,93.8
X$5280 2055 5195 5247 15 5152 27 AOI21_X1
* cell instance $5282 m0 *1 76.95,93.8
X$5282 15 5194 5196 2184 5033 27 DFF_X1
* cell instance $5283 m0 *1 80.18,93.8
X$5283 2055 5180 5430 15 5104 27 AOI21_X1
* cell instance $5286 r0 *1 74.67,93.8
X$5286 5245 5248 5247 27 5153 15 OAI21_X1
* cell instance $5288 r0 *1 75.62,93.8
X$5288 5195 5248 5245 27 5351 15 NOR3_X2
* cell instance $5290 r0 *1 77.14,93.8
X$5290 15 5349 5351 5267 1299 27 NOR3_X4
* cell instance $5292 r0 *1 80.18,93.8
X$5292 5196 27 5291 15 BUF_X4
* cell instance $5293 m0 *1 81.51,93.8
X$5293 1397 5510 15 27 5231 NAND2_X1
* cell instance $5295 m0 *1 82.08,93.8
X$5295 5136 1397 5231 27 5229 15 OAI21_X1
* cell instance $5297 m0 *1 85.88,93.8
X$5297 5154 969 27 15 5288 XNOR2_X1
* cell instance $5299 m0 *1 90.06,93.8
X$5299 5225 1397 2304 27 15 5155 OAI21_X4
* cell instance $5301 m0 *1 92.72,93.8
X$5301 1397 5249 15 27 5225 NAND2_X1
* cell instance $5307 m0 *1 118.37,93.8
X$5307 2055 5224 5156 15 5250 27 AOI21_X1
* cell instance $5310 m0 *1 120.08,93.8
X$5310 4836 5099 15 27 5224 NAND2_X1
* cell instance $5316 r0 *1 85.88,93.8
X$5316 2095 5288 27 15 5353 XNOR2_X1
* cell instance $5321 r0 *1 89.87,93.8
X$5321 1536 27 1248 15 BUF_X4
* cell instance $5322 r0 *1 91.2,93.8
X$5322 15 10553 5249 5155 5289 27 DFF_X1
* cell instance $5326 r0 *1 102.41,93.8
X$5326 5354 15 27 1564 CLKBUF_X3
* cell instance $5327 r0 *1 103.36,93.8
X$5327 1564 15 27 10833 INV_X4
* cell instance $5338 r0 *1 117.42,93.8
X$5338 15 5250 5292 10761 4836 27 DFF_X2
* cell instance $5341 m0 *1 121.03,93.8
X$5341 5192 15 27 5099 CLKBUF_X3
* cell instance $5346 m0 *1 138.89,93.8
X$5346 15 5348 5220 5179 5037 5219 27 FA_X1
* cell instance $5348 m0 *1 142.12,93.8
X$5348 4992 5197 5218 27 15 5252 HA_X1
* cell instance $5353 r0 *1 123.5,93.8
X$5353 15 5251 5292 10769 5059 27 DFF_X2
* cell instance $5354 r0 *1 127.11,93.8
X$5354 5059 5099 15 27 5352 NAND2_X1
* cell instance $5358 r0 *1 137.18,93.8
X$5358 15 4448 5605 5348 4778 5089 27 FA_X1
* cell instance $5363 r0 *1 143.07,93.8
X$5363 5252 15 27 5294 INV_X1
* cell instance $5365 m0 *1 145.35,93.8
X$5365 5198 15 27 5175 INV_X1
* cell instance $5369 m0 *1 148.96,93.8
X$5369 5343 15 27 5172 INV_X1
* cell instance $5371 m0 *1 150.1,93.8
X$5371 15 5295 5174 5171 5157 5253 27 FA_X1
* cell instance $5376 m0 *1 163.21,93.8
X$5376 15 5215 5168 5214 5404 5301 27 FA_X1
* cell instance $5377 m0 *1 166.25,93.8
X$5377 5214 5392 5166 27 15 5167 HA_X1
* cell instance $5384 r0 *1 152.19,93.8
X$5384 5336 15 27 5253 INV_X1
* cell instance $5385 r0 *1 152.57,93.8
X$5385 5340 15 27 5157 INV_X1
* cell instance $5386 r0 *1 152.95,93.8
X$5386 15 5339 5340 5263 5338 4510 27 FA_X1
* cell instance $5388 r0 *1 156.18,93.8
X$5388 15 5335 5338 5169 5298 5299 27 FA_X1
* cell instance $5390 r0 *1 162.26,93.8
X$5390 15 5753 5327 5042 5254 5391 27 FA_X1
* cell instance $5393 r0 *1 166.44,93.8
X$5393 15 5255 5041 5123 5324 5302 27 FA_X1
* cell instance $5397 r0 *1 170.81,93.8
X$5397 5256 15 27 5112 INV_X1
* cell instance $5407 r0 *1 174.8,93.8
X$5407 15 5261 5257 5316 5258 5303 27 FA_X1
* cell instance $5408 m0 *1 175.75,93.8
X$5408 4417 5158 5211 27 15 5164 HA_X1
* cell instance $5409 m0 *1 175.37,93.8
X$5409 5257 15 27 4597 INV_X1
* cell instance $5410 m0 *1 177.65,93.8
X$5410 15 5201 4700 5210 5200 5211 27 FA_X1
* cell instance $5411 m0 *1 180.69,93.8
X$5411 15 5202 4694 5309 5047 5210 27 FA_X1
* cell instance $5412 m0 *1 183.73,93.8
X$5412 5209 15 27 5311 INV_X1
* cell instance $5413 m0 *1 184.11,93.8
X$5413 15 5203 5209 5204 5207 5159 27 FA_X1
* cell instance $5414 m0 *1 187.15,93.8
X$5414 5199 15 27 5205 BUF_X1
* cell instance $5416 r0 *1 177.84,93.8
X$5416 5316 15 27 5260 INV_X1
* cell instance $5419 r0 *1 182.78,93.8
X$5419 15 5259 4787 5306 5311 5309 27 FA_X1
* cell instance $5421 r0 *1 186.58,93.8
X$5421 5204 15 27 5307 INV_X1
* cell instance $5423 r0 *1 187.15,93.8
X$5423 5482 15 27 5161 BUF_X1
* cell instance $5425 m0 *1 100.89,68.6
X$5425 3071 300 27 15 3784 AND2_X1
* cell instance $5426 m0 *1 99.94,68.6
X$5426 3700 15 27 3866 INV_X4
* cell instance $5429 m0 *1 103.93,68.6
X$5429 3701 3666 27 15 3781 AND2_X1
* cell instance $5430 m0 *1 104.69,68.6
X$5430 3781 3520 3863 3782 3701 4072 27 15 AOI221_X2
* cell instance $5431 m0 *1 106.78,68.6
X$5431 3207 3285 27 15 3749 XNOR2_X1
* cell instance $5433 m0 *1 108.11,68.6
X$5433 3749 3777 3778 27 15 3602 OAI21_X2
* cell instance $5436 m0 *1 98.23,68.6
X$5436 3818 27 3516 15 BUF_X4
* cell instance $5437 r0 *1 98.23,68.6
X$5437 3867 3516 3435 15 3785 27 AOI21_X2
* cell instance $5438 r0 *1 99.56,68.6
X$5438 3784 3374 15 27 3867 NAND2_X1
* cell instance $5439 r0 *1 100.13,68.6
X$5439 3284 3819 27 15 3895 AND2_X1
* cell instance $5440 r0 *1 100.89,68.6
X$5440 3374 3819 27 15 3820 AND2_X2
* cell instance $5445 r0 *1 106.21,68.6
X$5445 3286 15 27 3862 INV_X1
* cell instance $5446 r0 *1 106.59,68.6
X$5446 15 3702 3862 3750 3822 27 AOI21_X4
* cell instance $5447 r0 *1 109.06,68.6
X$5447 3038 3822 3750 15 27 3751 NAND3_X2
* cell instance $5448 m0 *1 110.01,68.6
X$5448 3524 3207 15 27 3823 NOR2_X1
* cell instance $5450 m0 *1 110.58,68.6
X$5450 3775 3751 3524 15 27 3774 NAND3_X1
* cell instance $5451 m0 *1 111.34,68.6
X$5451 3775 3751 15 27 3668 NAND2_X1
* cell instance $5453 r0 *1 110.39,68.6
X$5453 3286 3777 3778 27 15 3775 OAI21_X2
* cell instance $5456 r0 *1 112.29,68.6
X$5456 3702 3603 15 27 3604 NOR2_X2
* cell instance $5457 m0 *1 113.05,68.6
X$5457 3773 3672 3774 15 27 3719 MUX2_X1
* cell instance $5458 m0 *1 112.29,68.6
X$5458 3527 3775 3751 15 3704 27 AOI21_X1
* cell instance $5459 m0 *1 114.38,68.6
X$5459 3704 300 15 27 3772 NOR2_X1
* cell instance $5460 m0 *1 114.95,68.6
X$5460 3668 3672 15 27 3705 NOR2_X2
* cell instance $5461 m0 *1 115.9,68.6
X$5461 3672 3527 15 27 3825 NAND2_X1
* cell instance $5463 m0 *1 117.23,68.6
X$5463 3719 3207 15 27 3857 NAND2_X1
* cell instance $5464 m0 *1 117.8,68.6
X$5464 3719 300 3607 15 27 3752 MUX2_X1
* cell instance $5465 m0 *1 119.13,68.6
X$5465 3707 3604 15 27 3715 NAND2_X1
* cell instance $5467 m0 *1 119.89,68.6
X$5467 4127 3668 15 27 3769 OR2_X1
* cell instance $5469 m0 *1 120.84,68.6
X$5469 4324 3769 3717 3856 3715 3532 15 27 OAI221_X2
* cell instance $5470 m0 *1 122.93,68.6
X$5470 3609 3611 3530 27 15 3767 MUX2_X2
* cell instance $5472 m0 *1 124.83,68.6
X$5472 15 3079 3613 3767 3753 3710 27 NOR4_X4
* cell instance $5475 m0 *1 130.53,68.6
X$5475 3754 3827 3217 3216 3447 15 27 OAI211_X2
* cell instance $5478 m0 *1 133.19,68.6
X$5478 3756 3755 15 27 3005 NAND2_X2
* cell instance $5479 m0 *1 134.14,68.6
X$5479 15 3851 3765 3709 3451 27 NOR3_X4
* cell instance $5481 m0 *1 137.56,68.6
X$5481 3710 3826 15 27 3764 NOR2_X1
* cell instance $5482 m0 *1 138.13,68.6
X$5482 3622 3756 3755 15 3625 27 AOI21_X1
* cell instance $5484 m0 *1 139.08,68.6
X$5484 3764 3710 3625 15 3452 27 AOI21_X2
* cell instance $5485 m0 *1 140.41,68.6
X$5485 3620 3757 15 27 3829 OR2_X1
* cell instance $5487 r0 *1 113.24,68.6
X$5487 3702 3603 3608 244 27 15 3824 OAI22_X2
* cell instance $5492 r0 *1 115.14,68.6
X$5492 3705 3772 3825 15 3994 27 AOI21_X2
* cell instance $5494 r0 *1 117.23,68.6
X$5494 15 3718 3857 3753 3705 3856 27 AOI22_X4
* cell instance $5500 r0 *1 124.45,68.6
X$5500 3613 3767 3753 15 27 3849 OR3_X2
* cell instance $5501 r0 *1 125.59,68.6
X$5501 15 3613 3767 3753 3959 27 NOR3_X4
* cell instance $5502 r0 *1 128.25,68.6
X$5502 3213 3656 3212 3855 27 15 3827 AND4_X1
* cell instance $5505 r0 *1 129.96,68.6
X$5505 3827 3754 15 27 3765 NOR2_X2
* cell instance $5507 r0 *1 131.29,68.6
X$5507 3991 3912 3765 27 3624 15 NOR3_X2
* cell instance $5508 r0 *1 132.62,68.6
X$5508 3828 3898 15 27 3448 NAND2_X1
* cell instance $5512 r0 *1 138.13,68.6
X$5512 3849 3755 3756 15 3757 27 AOI21_X1
* cell instance $5515 r0 *1 140.79,68.6
X$5515 3080 3829 15 27 3843 NAND2_X1
* cell instance $5516 r0 *1 141.36,68.6
X$5516 3012 2958 3829 3080 15 27 3845 OR4_X1
* cell instance $5517 m0 *1 143.26,68.6
X$5517 3830 3712 3378 15 3759 27 AOI21_X2
* cell instance $5518 m0 *1 141.55,68.6
X$5518 3378 3712 15 2559 27 NAND2_X4
* cell instance $5519 m0 *1 144.59,68.6
X$5519 3759 3758 3831 15 27 2827 OR3_X2
* cell instance $5522 r0 *1 142.5,68.6
X$5522 3845 3843 3830 3711 3831 15 27 OAI211_X2
* cell instance $5523 r0 *1 144.21,68.6
X$5523 3831 3758 3759 27 2563 15 NOR3_X2
* cell instance $5525 r0 *1 145.73,68.6
X$5525 3832 2958 3012 27 15 3381 OAI21_X4
* cell instance $5527 m0 *1 147.63,68.6
X$5527 3832 3833 3763 15 3762 27 AOI21_X2
* cell instance $5529 r0 *1 148.96,68.6
X$5529 3832 3763 3833 27 15 3761 AND3_X1
* cell instance $5530 m0 *1 149.53,68.6
X$5530 15 2656 3762 2652 3761 27 AOI21_X4
* cell instance $5532 m0 *1 152,68.6
X$5532 3760 3714 3713 15 3629 27 AOI21_X1
* cell instance $5534 r0 *1 149.91,68.6
X$5534 15 2483 3712 3837 3833 27 AOI21_X4
* cell instance $5536 m0 *1 153.33,68.6
X$5536 3714 3539 3308 15 27 3760 NOR3_X1
* cell instance $5557 m0 *1 27.55,51.8
X$5557 2626 2790 2720 15 27 2721 OR3_X1
* cell instance $5559 m0 *1 28.5,51.8
X$5559 2856 2721 27 15 2832 AND2_X1
* cell instance $5560 m0 *1 29.26,51.8
X$5560 2722 15 27 2791 INV_X1
* cell instance $5564 r0 *1 27.55,51.8
X$5564 2626 2720 2790 27 15 2856 OAI21_X2
* cell instance $5566 r0 *1 29.26,51.8
X$5566 2761 2858 2832 15 27 2860 MUX2_X1
* cell instance $5570 r0 *1 34.2,51.8
X$5570 212 2860 2861 27 15 2862 HA_X1
* cell instance $5572 m0 *1 36.29,51.8
X$5572 2668 2724 15 27 2896 NAND2_X1
* cell instance $5574 m0 *1 36.86,51.8
X$5574 2724 2627 27 15 2762 AND2_X1
* cell instance $5575 m0 *1 37.62,51.8
X$5575 2725 15 27 2724 INV_X1
* cell instance $5576 m0 *1 38,51.8
X$5576 2861 2762 27 15 2836 XNOR2_X1
* cell instance $5581 r0 *1 36.67,51.8
X$5581 2933 2724 2627 15 2863 27 AOI21_X1
* cell instance $5584 r0 *1 38.57,51.8
X$5584 2860 2629 2836 15 27 2864 MUX2_X1
* cell instance $5586 m0 *1 41.99,51.8
X$5586 2451 2281 2726 2764 27 2838 15 OR4_X2
* cell instance $5589 r0 *1 42.94,51.8
X$5589 138 2864 2841 27 15 2898 HA_X1
* cell instance $5590 m0 *1 43.89,51.8
X$5590 2841 2728 2766 27 15 2792 OAI21_X4
* cell instance $5592 m0 *1 46.36,51.8
X$5592 2841 2728 2766 15 27 2842 OR3_X1
* cell instance $5595 r0 *1 44.84,51.8
X$5595 2898 15 27 2865 INV_X1
* cell instance $5598 r0 *1 45.79,51.8
X$5598 2792 2842 27 15 2899 AND2_X1
* cell instance $5599 r0 *1 46.55,51.8
X$5599 2864 2632 2899 15 27 2866 MUX2_X1
* cell instance $5601 m0 *1 49.4,51.8
X$5601 2793 15 27 2729 BUF_X1
* cell instance $5603 m0 *1 49.97,51.8
X$5603 2533 2634 2729 2794 15 27 2764 NAND4_X1
* cell instance $5604 m0 *1 50.92,51.8
X$5604 2795 2729 2769 15 2981 27 AOI21_X2
* cell instance $5605 m0 *1 52.25,51.8
X$5605 2729 15 27 2796 INV_X1
* cell instance $5607 m0 *1 52.82,51.8
X$5607 2729 2730 27 15 2902 XNOR2_X1
* cell instance $5612 r0 *1 49.78,51.8
X$5612 195 2866 2793 27 15 2795 HA_X1
* cell instance $5613 r0 *1 51.68,51.8
X$5613 2795 15 27 2901 INV_X1
* cell instance $5614 r0 *1 52.06,51.8
X$5614 2901 2730 2796 27 15 3103 OAI21_X4
* cell instance $5615 r0 *1 54.53,51.8
X$5615 2866 2902 2456 27 15 2797 MUX2_X2
* cell instance $5616 r0 *1 56.24,51.8
X$5616 15 2456 27 2935 BUF_X8
* cell instance $5617 m0 *1 58.33,51.8
X$5617 195 2731 2772 27 15 2798 HA_X1
* cell instance $5620 m0 *1 61.75,51.8
X$5620 2772 2732 15 27 2903 XOR2_X1
* cell instance $5628 r0 *1 60.23,51.8
X$5628 15 3040 2798 2772 2732 27 AOI21_X4
* cell instance $5630 r0 *1 62.89,51.8
X$5630 2731 2535 2903 15 27 3042 MUX2_X1
* cell instance $5633 r0 *1 66.12,51.8
X$5633 195 2847 2799 27 15 2869 HA_X1
* cell instance $5634 m0 *1 67.26,51.8
X$5634 2799 2734 15 27 2733 XOR2_X1
* cell instance $5636 m0 *1 68.4,51.8
X$5636 2734 2799 27 2870 15 AND2_X4
* cell instance $5637 m0 *1 70.11,51.8
X$5637 2600 2780 2735 15 27 2781 MUX2_X1
* cell instance $5641 m0 *1 76.76,51.8
X$5641 2688 15 27 2803 INV_X1
* cell instance $5642 m0 *1 77.14,51.8
X$5642 2737 2603 15 27 2783 NOR2_X1
* cell instance $5644 r0 *1 68.02,51.8
X$5644 2847 2123 2733 15 27 3169 MUX2_X1
* cell instance $5647 r0 *1 69.92,51.8
X$5647 2603 2906 2211 2726 15 27 2908 NOR4_X1
* cell instance $5648 r0 *1 70.87,51.8
X$5648 15 2123 27 2800 BUF_X8
* cell instance $5649 r0 *1 73.34,51.8
X$5649 2800 27 2780 15 BUF_X4
* cell instance $5653 r0 *1 76.76,51.8
X$5653 2872 15 27 2801 INV_X1
* cell instance $5654 r0 *1 77.14,51.8
X$5654 2848 2803 15 27 2873 NAND2_X2
* cell instance $5655 r0 *1 78.09,51.8
X$5655 2801 2909 2803 15 2874 27 AOI21_X1
* cell instance $5656 m0 *1 78.28,51.8
X$5656 2737 2804 2805 2785 27 2640 15 NOR4_X2
* cell instance $5664 r0 *1 81.51,51.8
X$5664 2804 2805 15 27 2876 NOR2_X1
* cell instance $5665 r0 *1 82.08,51.8
X$5665 2876 2379 15 2741 27 NAND2_X4
* cell instance $5667 m0 *1 85.12,51.8
X$5667 195 2738 2788 27 15 2740 HA_X1
* cell instance $5669 m0 *1 87.02,51.8
X$5669 2846 2517 2739 15 2845 27 AOI21_X1
* cell instance $5671 m0 *1 87.97,51.8
X$5671 2788 15 27 2806 BUF_X1
* cell instance $5673 m0 *1 88.73,51.8
X$5673 2740 2806 2787 15 2807 27 AOI21_X1
* cell instance $5675 m0 *1 89.68,51.8
X$5675 2786 2807 2441 27 2784 15 OAI21_X1
* cell instance $5680 r0 *1 85.69,51.8
X$5680 2738 2306 2914 15 27 2915 MUX2_X1
* cell instance $5682 r0 *1 87.4,51.8
X$5682 2806 15 27 2846 INV_X1
* cell instance $5685 r0 *1 88.92,51.8
X$5685 2740 2845 15 27 2917 OR2_X1
* cell instance $5688 r0 *1 90.25,51.8
X$5688 2944 15 27 2786 INV_X1
* cell instance $5690 r0 *1 91.01,51.8
X$5690 2786 2917 27 15 2916 XNOR2_X1
* cell instance $5692 m0 *1 94.24,51.8
X$5692 1435 2779 2782 2742 15 27 2743 OR4_X1
* cell instance $5693 m0 *1 93.1,51.8
X$5693 2805 2438 27 15 2782 XNOR2_X1
* cell instance $5696 r0 *1 94.43,51.8
X$5696 2742 2438 2805 27 2843 15 OAI21_X1
* cell instance $5699 m0 *1 95.76,51.8
X$5699 2743 2741 15 27 2644 NAND2_X1
* cell instance $5700 m0 *1 98.42,51.8
X$5700 2778 2741 15 27 2921 NAND2_X1
* cell instance $5701 m0 *1 96.71,51.8
X$5701 2743 2920 27 2777 15 XOR2_X2
* cell instance $5707 r0 *1 102.22,51.8
X$5707 2921 1981 2810 2923 2774 27 15 AOI211_X2
* cell instance $5708 m0 *1 104.12,51.8
X$5708 2776 2777 27 2602 15 XOR2_X2
* cell instance $5710 m0 *1 105.83,51.8
X$5710 2773 2814 2744 15 2776 27 NAND3_X4
* cell instance $5715 r0 *1 104.5,51.8
X$5715 2923 2810 15 2744 27 NAND2_X4
* cell instance $5716 r0 *1 106.21,51.8
X$5716 1435 2811 2814 15 27 NOR2_X4
* cell instance $5718 m0 *1 110.39,51.8
X$5718 2744 2770 15 27 1567 XNOR2_X2
* cell instance $5722 m0 *1 113.24,51.8
X$5722 2647 15 27 2813 INV_X4
* cell instance $5723 m0 *1 114.19,51.8
X$5723 2771 2773 27 2547 15 XOR2_X2
* cell instance $5725 m0 *1 116.09,51.8
X$5725 2745 2814 2744 27 2771 15 OAI21_X1
* cell instance $5727 m0 *1 117.04,51.8
X$5727 2648 1981 15 27 2745 NOR2_X2
* cell instance $5729 m0 *1 118.18,51.8
X$5729 2746 1840 2745 15 2770 27 AOI21_X2
* cell instance $5734 m0 *1 125.02,51.8
X$5734 2552 2697 2236 15 27 2767 NAND3_X1
* cell instance $5735 m0 *1 125.78,51.8
X$5735 2767 2237 15 27 2837 NOR2_X1
* cell instance $5741 r0 *1 113.05,51.8
X$5741 2646 2812 15 27 2922 NOR2_X1
* cell instance $5742 r0 *1 113.62,51.8
X$5742 2840 2812 2813 27 15 2882 OAI21_X4
* cell instance $5746 r0 *1 116.09,51.8
X$5746 2840 2922 27 15 2918 XNOR2_X1
* cell instance $5747 r0 *1 117.23,51.8
X$5747 2883 2839 27 15 2556 AND2_X1
* cell instance $5748 r0 *1 117.99,51.8
X$5748 2918 2197 15 27 2839 NAND2_X1
* cell instance $5756 r0 *1 126.16,51.8
X$5756 2815 2555 2697 15 2956 27 AOI21_X2
* cell instance $5758 m0 *1 127.49,51.8
X$5758 2699 2763 15 27 2765 NOR2_X1
* cell instance $5759 m0 *1 128.25,51.8
X$5759 2835 15 27 2697 BUF_X2
* cell instance $5760 m0 *1 129.01,51.8
X$5760 2763 2695 15 27 2580 XNOR2_X2
* cell instance $5764 r0 *1 127.49,51.8
X$5764 2765 2837 2815 27 2834 15 NOR3_X2
* cell instance $5765 r0 *1 128.82,51.8
X$5765 300 2884 2835 27 15 2815 HA_X1
* cell instance $5769 r0 *1 133.19,51.8
X$5769 2558 15 27 2884 INV_X1
* cell instance $5770 r0 *1 133.57,51.8
X$5770 2912 2405 15 27 2833 NAND2_X1
* cell instance $5771 m0 *1 135.28,51.8
X$5771 2747 2885 15 27 2690 XNOR2_X2
* cell instance $5772 m0 *1 133.57,51.8
X$5772 2833 2816 27 1750 15 XOR2_X2
* cell instance $5773 m0 *1 137.18,51.8
X$5773 15 2323 2587 2819 2749 27 AOI21_X4
* cell instance $5776 r0 *1 134.14,51.8
X$5776 2816 2912 15 27 2480 XNOR2_X2
* cell instance $5777 r0 *1 136.04,51.8
X$5777 2817 2818 15 27 2747 NOR2_X1
* cell instance $5778 r0 *1 136.61,51.8
X$5778 2480 2684 15 27 2831 NOR2_X2
* cell instance $5781 r0 *1 138.13,51.8
X$5781 2749 2819 2884 15 27 2748 NAND3_X1
* cell instance $5784 r0 *1 139.84,51.8
X$5784 15 2905 2907 2819 2749 27 AOI21_X4
* cell instance $5785 m0 *1 141.74,51.8
X$5785 2905 2820 27 2565 15 XOR2_X2
* cell instance $5788 m0 *1 143.64,51.8
X$5788 2576 2654 2760 27 2750 15 NOR3_X2
* cell instance $5790 m0 *1 145.16,51.8
X$5790 2760 2654 2576 15 27 2759 OR3_X2
* cell instance $5792 m0 *1 146.49,51.8
X$5792 2759 2751 2154 15 27 NOR2_X4
* cell instance $5794 m0 *1 148.39,51.8
X$5794 2154 2243 2894 27 15 2000 OAI21_X4
* cell instance $5796 m0 *1 151.05,51.8
X$5796 15 2824 2822 2758 2823 27 NOR3_X4
* cell instance $5797 m0 *1 153.71,51.8
X$5797 2407 2825 2570 2752 15 2756 27 NAND4_X2
* cell instance $5800 r0 *1 142.69,51.8
X$5800 2820 2905 15 27 2826 XNOR2_X2
* cell instance $5801 r0 *1 144.59,51.8
X$5801 2827 2576 15 27 2830 NAND2_X1
* cell instance $5803 r0 *1 145.35,51.8
X$5803 2827 2576 2758 27 2821 15 NOR3_X2
* cell instance $5805 r0 *1 146.87,51.8
X$5805 15 2826 2821 2481 2655 2887 27 NAND4_X4
* cell instance $5807 r0 *1 150.48,51.8
X$5807 15 2887 2246 2822 2658 2824 27 OAI22_X4
* cell instance $5809 r0 *1 154.09,51.8
X$5809 2822 2824 15 27 2825 NOR2_X1
* cell instance $5811 r0 *1 154.85,51.8
X$5811 2658 2756 15 27 1416 NAND2_X2
* cell instance $5813 m0 *1 155.99,51.8
X$5813 15 2753 2752 2243 1647 2246 27 OAI211_X4
* cell instance $5822 r0 *1 156.18,51.8
X$5822 2889 2888 2753 15 2246 27 NAND3_X4
* cell instance $5824 r0 *1 159.41,51.8
X$5824 2887 2890 15 27 1588 NAND2_X2
* cell instance $5835 m0 *1 112.29,12.6
X$5835 127 126 518 27 375 15 OAI21_X1
* cell instance $5838 r0 *1 112.1,12.6
X$5838 15 740 658 564 657 27 AOI21_X4
* cell instance $5839 m0 *1 113.62,12.6
X$5839 485 15 27 518 INV_X1
* cell instance $5842 m0 *1 116.09,12.6
X$5842 588 423 587 27 15 517 OAI21_X2
* cell instance $5843 m0 *1 114.38,12.6
X$5843 487 485 126 127 588 15 27 OAI211_X2
* cell instance $5845 m0 *1 118.18,12.6
X$5845 427 422 27 15 486 AND2_X1
* cell instance $5853 r0 *1 115.9,12.6
X$5853 256 682 15 587 27 NAND2_X4
* cell instance $5855 m0 *1 119.51,12.6
X$5855 487 437 15 27 488 NOR2_X1
* cell instance $5857 m0 *1 120.08,12.6
X$5857 426 163 424 15 450 27 AOI21_X1
* cell instance $5858 m0 *1 120.84,12.6
X$5858 15 583 565 105 489 303 27 AND4_X4
* cell instance $5861 m0 *1 125.02,12.6
X$5861 325 201 491 27 15 512 AND3_X1
* cell instance $5862 m0 *1 125.97,12.6
X$5862 384 493 492 27 15 585 OAI21_X2
* cell instance $5870 r0 *1 123.88,12.6
X$5870 266 430 384 660 27 15 659 AND4_X1
* cell instance $5871 r0 *1 125.02,12.6
X$5871 325 201 566 659 27 15 121 AND4_X1
* cell instance $5873 r0 *1 126.54,12.6
X$5873 266 430 384 27 15 768 AND3_X1
* cell instance $5875 r0 *1 129.01,12.6
X$5875 376 567 27 15 870 AND2_X1
* cell instance $5876 m0 *1 129.96,12.6
X$5876 433 494 15 27 568 NAND2_X1
* cell instance $5877 m0 *1 129.2,12.6
X$5877 507 429 494 15 27 567 NAND3_X1
* cell instance $5878 m0 *1 130.53,12.6
X$5878 568 121 434 27 569 15 OAI21_X1
* cell instance $5880 m0 *1 132.05,12.6
X$5880 205 259 437 27 495 15 NOR3_X2
* cell instance $5883 m0 *1 135.66,12.6
X$5883 582 676 15 27 137 XNOR2_X2
* cell instance $5885 m0 *1 137.75,12.6
X$5885 250 497 27 15 583 XNOR2_X1
* cell instance $5888 r0 *1 130.53,12.6
X$5888 569 57 15 27 766 NAND2_X1
* cell instance $5891 r0 *1 133.38,12.6
X$5891 664 663 27 15 249 AND2_X1
* cell instance $5893 r0 *1 134.33,12.6
X$5893 664 747 662 15 27 570 AND3_X4
* cell instance $5897 r0 *1 137.75,12.6
X$5897 570 667 573 15 27 571 AND3_X4
* cell instance $5898 m0 *1 141.17,12.6
X$5898 438 498 15 27 55 XNOR2_X2
* cell instance $5899 m0 *1 139.27,12.6
X$5899 575 572 15 27 384 XNOR2_X2
* cell instance $5901 m0 *1 143.26,12.6
X$5901 15 440 580 266 500 501 27 AOI22_X4
* cell instance $5902 m0 *1 146.49,12.6
X$5902 500 501 15 27 491 NAND2_X1
* cell instance $5904 m0 *1 147.25,12.6
X$5904 315 256 15 27 574 NAND2_X1
* cell instance $5907 r0 *1 139.84,12.6
X$5907 570 15 27 666 BUF_X1
* cell instance $5908 r0 *1 140.41,12.6
X$5908 571 15 27 668 BUF_X1
* cell instance $5910 r0 *1 141.17,12.6
X$5910 15 127 499 247 252 572 27 NOR4_X4
* cell instance $5911 r0 *1 144.59,12.6
X$5911 574 575 499 670 27 673 15 NOR4_X2
* cell instance $5912 r0 *1 146.3,12.6
X$5912 573 670 574 27 15 501 OAI21_X2
* cell instance $5913 r0 *1 147.63,12.6
X$5913 571 15 27 576 BUF_X1
* cell instance $5914 r0 *1 148.2,12.6
X$5914 748 575 15 27 444 OR2_X1
* cell instance $5915 m0 *1 149.15,12.6
X$5915 15 247 27 576 BUF_X8
* cell instance $5926 r0 *1 148.96,12.6
X$5926 15 436 27 571 BUF_X8
* cell instance $5942 m0 *1 50.54,9.8
X$5942 285 323 369 27 368 15 OAI21_X1
* cell instance $5944 m0 *1 51.3,9.8
X$5944 286 15 27 369 INV_X1
* cell instance $5947 r0 *1 50.54,9.8
X$5947 413 368 27 15 468 XNOR2_X1
* cell instance $5949 m0 *1 60.42,46.2
X$5949 212 2371 2513 27 15 2372 HA_X1
* cell instance $5951 m0 *1 62.32,46.2
X$5951 2373 2513 27 2597 15 AND2_X4
* cell instance $5952 m0 *1 64.03,46.2
X$5952 2514 2535 2427 15 27 2428 MUX2_X1
* cell instance $5957 r0 *1 60.42,46.2
X$5957 2534 2372 2597 15 27 2682 OR3_X1
* cell instance $5960 r0 *1 61.94,46.2
X$5960 2371 2535 2289 15 27 2600 MUX2_X1
* cell instance $5963 r0 *1 67.83,46.2
X$5963 2375 2457 2458 27 15 2536 OAI21_X4
* cell instance $5964 m0 *1 69.92,46.2
X$5964 2374 2298 15 27 2459 XOR2_X1
* cell instance $5965 m0 *1 68.02,46.2
X$5965 212 2428 2374 27 15 2457 HA_X1
* cell instance $5970 r0 *1 70.3,46.2
X$5970 2428 2123 2459 15 27 2537 MUX2_X1
* cell instance $5972 m0 *1 78.47,46.2
X$5972 212 2378 2434 27 15 2460 HA_X1
* cell instance $5973 m0 *1 76.76,46.2
X$5973 2219 2434 2217 2538 15 2603 27 NAND4_X2
* cell instance $5976 m0 *1 81.32,46.2
X$5976 2378 2379 2436 15 27 2380 MUX2_X1
* cell instance $5979 m0 *1 83.6,46.2
X$5979 138 2380 2608 27 15 2461 HA_X1
* cell instance $5980 m0 *1 85.5,46.2
X$5980 2461 2462 2439 15 2517 27 AOI21_X2
* cell instance $5981 m0 *1 86.83,46.2
X$5981 2440 2382 15 27 2463 NOR2_X1
* cell instance $5982 m0 *1 87.4,46.2
X$5982 2302 15 27 2303 INV_X1
* cell instance $5983 m0 *1 87.78,46.2
X$5983 2381 2306 2384 15 27 2435 MUX2_X1
* cell instance $5986 r0 *1 77.9,46.2
X$5986 2377 2434 27 2692 15 AND2_X4
* cell instance $5990 r0 *1 83.6,46.2
X$5990 2608 27 2462 15 BUF_X4
* cell instance $5993 r0 *1 85.5,46.2
X$5993 2462 2463 27 15 2696 XNOR2_X1
* cell instance $5994 r0 *1 86.64,46.2
X$5994 15 2464 2388 2302 2462 2739 27 NAND4_X4
* cell instance $5995 m0 *1 90.25,46.2
X$5995 2305 2388 2386 15 2441 27 AOI21_X1
* cell instance $5996 m0 *1 89.49,46.2
X$5996 2519 2518 2385 27 2442 15 OAI21_X1
* cell instance $5998 m0 *1 91.2,46.2
X$5998 2464 2386 2388 27 2387 15 OAI21_X1
* cell instance $5999 m0 *1 91.96,46.2
X$5999 2464 2388 2386 15 27 2390 OR3_X1
* cell instance $6001 m0 *1 93.1,46.2
X$6001 2387 2390 27 15 2389 AND2_X1
* cell instance $6005 r0 *1 90.06,46.2
X$6005 2388 15 27 2519 INV_X1
* cell instance $6006 r0 *1 90.44,46.2
X$6006 2386 2464 2844 15 2518 27 AOI21_X1
* cell instance $6007 r0 *1 91.2,46.2
X$6007 2700 1158 2607 27 15 2386 HA_X1
* cell instance $6008 r0 *1 93.1,46.2
X$6008 2607 27 2464 15 BUF_X4
* cell instance $6009 r0 *1 94.43,46.2
X$6009 2464 2642 27 15 2702 XNOR2_X1
* cell instance $6012 r0 *1 97.47,46.2
X$6012 138 2435 2465 27 15 2466 HA_X1
* cell instance $6013 m0 *1 99.18,46.2
X$6013 2466 2465 2392 15 2516 27 AOI21_X1
* cell instance $6014 m0 *1 98.04,46.2
X$6014 2465 2391 15 27 2704 XOR2_X1
* cell instance $6015 m0 *1 99.94,46.2
X$6015 2393 2307 2808 15 2062 27 AOI21_X1
* cell instance $6018 m0 *1 105.26,46.2
X$6018 1158 2602 2515 27 15 2310 HA_X1
* cell instance $6020 r0 *1 99.37,46.2
X$6020 15 2604 2466 2465 2467 27 AOI21_X4
* cell instance $6021 r0 *1 101.84,46.2
X$6021 2468 2516 2540 27 2809 15 OAI21_X1
* cell instance $6022 r0 *1 102.6,46.2
X$6022 2393 2541 15 27 2540 NOR2_X1
* cell instance $6025 r0 *1 106.97,46.2
X$6025 2602 2224 15 27 2542 NOR2_X2
* cell instance $6026 m0 *1 108.87,46.2
X$6026 111 2394 2469 27 15 2396 HA_X1
* cell instance $6027 m0 *1 107.54,46.2
X$6027 2542 2515 2224 15 2394 27 AOI21_X2
* cell instance $6028 m0 *1 110.77,46.2
X$6028 2396 2469 2546 15 2395 27 AOI21_X1
* cell instance $6029 m0 *1 111.53,46.2
X$6029 2599 2397 2311 2425 15 27 2598 AOI22_X2
* cell instance $6031 m0 *1 113.43,46.2
X$6031 2394 2197 2511 15 27 2230 MUX2_X1
* cell instance $6035 m0 *1 122.55,46.2
X$6035 2400 2316 2399 2402 15 27 2502 NOR4_X1
* cell instance $6036 m0 *1 123.5,46.2
X$6036 2315 2471 2399 2402 15 27 2474 NAND4_X1
* cell instance $6037 m0 *1 124.45,46.2
X$6037 2319 2236 2403 15 2471 27 AOI21_X1
* cell instance $6038 m0 *1 125.21,46.2
X$6038 2319 2417 2236 15 2503 27 AOI21_X2
* cell instance $6042 m0 *1 130.53,46.2
X$6042 2404 15 27 2475 INV_X1
* cell instance $6045 m0 *1 135.47,46.2
X$6045 15 2074 2322 2323 2242 27 NOR3_X4
* cell instance $6046 m0 *1 138.13,46.2
X$6046 2477 2405 15 27 2478 NOR2_X1
* cell instance $6049 r0 *1 107.92,46.2
X$6049 1158 2601 2544 27 15 2543 HA_X1
* cell instance $6050 r0 *1 109.82,46.2
X$6050 2469 2544 2543 27 15 2599 OAI21_X2
* cell instance $6051 r0 *1 111.15,46.2
X$6051 2469 2546 15 27 2511 XOR2_X1
* cell instance $6052 r0 *1 112.29,46.2
X$6052 2599 2470 15 27 2312 NAND2_X1
* cell instance $6054 r0 *1 113.05,46.2
X$6054 2707 2598 15 27 2313 XOR2_X1
* cell instance $6061 r0 *1 115.52,46.2
X$6061 1158 2547 2549 27 15 2548 HA_X1
* cell instance $6064 r0 *1 118.56,46.2
X$6064 2549 2550 15 27 2508 NAND2_X1
* cell instance $6066 r0 *1 119.51,46.2
X$6066 2508 2399 15 27 2233 NAND2_X1
* cell instance $6071 r0 *1 121.6,46.2
X$6071 2400 2316 15 27 2551 NOR2_X2
* cell instance $6072 r0 *1 122.55,46.2
X$6072 2402 2316 2400 2315 15 27 2473 OR4_X1
* cell instance $6073 r0 *1 123.69,46.2
X$6073 2551 2233 2319 2236 2403 2701 27 15 AOI221_X2
* cell instance $6074 r0 *1 125.78,46.2
X$6074 2553 2402 2503 27 15 2555 OAI21_X2
* cell instance $6075 r0 *1 127.11,46.2
X$6075 2591 2502 15 27 2472 NOR2_X1
* cell instance $6078 r0 *1 128.82,46.2
X$6078 2472 2473 2474 15 27 2589 NAND3_X1
* cell instance $6079 r0 *1 129.58,46.2
X$6079 2475 2472 2473 2474 15 27 2500 NAND4_X1
* cell instance $6080 r0 *1 130.53,46.2
X$6080 2475 2557 15 27 2588 NAND2_X1
* cell instance $6084 r0 *1 133.57,46.2
X$6084 2588 2405 2500 15 27 2335 MUX2_X1
* cell instance $6085 r0 *1 134.9,46.2
X$6085 2587 2073 15 27 2585 NOR2_X1
* cell instance $6087 r0 *1 135.85,46.2
X$6087 2476 2558 15 27 2477 NOR2_X1
* cell instance $6088 r0 *1 136.42,46.2
X$6088 2480 2585 2561 2560 2559 2477 15 27 2492 OAI33_X1
* cell instance $6089 r0 *1 137.75,46.2
X$6089 2580 2074 15 27 2579 NAND2_X1
* cell instance $6090 r0 *1 138.32,46.2
X$6090 2478 2579 2479 15 2406 27 AOI21_X2
* cell instance $6091 r0 *1 139.65,46.2
X$6091 2561 2480 15 27 2479 NOR2_X1
* cell instance $6092 m0 *1 140.03,46.2
X$6092 2492 1949 15 27 2489 NAND2_X1
* cell instance $6094 m0 *1 140.6,46.2
X$6094 2830 2562 1639 15 1843 27 AOI21_X1
* cell instance $6099 r0 *1 141.93,46.2
X$6099 2562 2563 2576 15 27 2324 NAND3_X2
* cell instance $6101 m0 *1 142.5,46.2
X$6101 2242 2324 2245 2406 15 27 2487 NOR4_X1
* cell instance $6104 r0 *1 144.02,46.2
X$6104 2577 2567 2566 15 1485 27 AOI21_X2
* cell instance $6105 m0 *1 148.01,46.2
X$6105 2325 2487 2486 27 1951 15 OAI21_X1
* cell instance $6106 m0 *1 144.59,46.2
X$6106 15 2243 2246 2244 2489 2152 27 NOR4_X4
* cell instance $6108 m0 *1 148.96,46.2
X$6108 2482 15 27 2486 INV_X1
* cell instance $6111 r0 *1 146.11,46.2
X$6111 2655 2481 2567 15 2244 27 NAND3_X4
* cell instance $6112 r0 *1 148.58,46.2
X$6112 2244 2245 2482 27 2575 15 OAI21_X1
* cell instance $6113 r0 *1 149.34,46.2
X$6113 2568 2575 27 15 2001 AND2_X1
* cell instance $6114 m0 *1 152.19,46.2
X$6114 2407 2326 2569 15 1994 27 NAND3_X4
* cell instance $6115 m0 *1 149.72,46.2
X$6115 2407 2325 2569 15 2072 27 NAND3_X4
* cell instance $6116 m0 *1 154.66,46.2
X$6116 2326 2327 2250 27 15 2328 AND3_X1
* cell instance $6119 m0 *1 156.56,46.2
X$6119 2483 2485 2004 27 15 1902 OAI21_X2
* cell instance $6120 m0 *1 157.89,46.2
X$6120 1952 2009 2082 15 27 2485 NAND3_X2
* cell instance $6129 r0 *1 151.62,46.2
X$6129 2656 27 2082 15 BUF_X4
* cell instance $6133 r0 *1 155.42,46.2
X$6133 2004 2483 2159 15 27 NOR2_X4
* cell instance $6134 r0 *1 157.13,46.2
X$6134 2485 2659 2571 27 2484 15 OAI21_X1
* cell instance $6135 r0 *1 157.89,46.2
X$6135 2485 2004 15 27 2571 NAND2_X1
* cell instance $6149 m0 *1 3.61,99.4
X$6149 5517 15 27 5514 BUF_X1
* cell instance $6150 m0 *1 4.18,99.4
X$6150 5516 15 27 5513 BUF_X1
* cell instance $6162 r0 *1 6.46,99.4
X$6162 5736 15 27 5515 BUF_X1
* cell instance $6163 r0 *1 7.03,99.4
X$6163 15 10517 5516 5580 5017 27 DFF_X1
* cell instance $6164 m0 *1 9.88,99.4
X$6164 5516 5184 15 27 5581 NAND2_X1
* cell instance $6168 m0 *1 16.72,99.4
X$6168 5658 5519 15 27 5264 NAND2_X1
* cell instance $6170 m0 *1 18.81,99.4
X$6170 5148 15 27 5519 CLKBUF_X3
* cell instance $6172 m0 *1 19.95,99.4
X$6172 15 5940 5139 10659 5521 27 DFF_X2
* cell instance $6174 r0 *1 10.26,99.4
X$6174 5687 5581 5579 15 5580 27 AOI21_X1
* cell instance $6177 r0 *1 13.3,99.4
X$6177 5584 5519 15 27 5579 NAND2_X1
* cell instance $6180 r0 *1 15.01,99.4
X$6180 5517 5184 15 27 5518 NAND2_X1
* cell instance $6184 r0 *1 18.05,99.4
X$6184 5688 5519 15 27 5431 NAND2_X1
* cell instance $6185 r0 *1 18.62,99.4
X$6185 5520 5519 15 27 5583 NAND2_X1
* cell instance $6188 r0 *1 20.33,99.4
X$6188 15 5587 5139 10790 5520 27 DFF_X2
* cell instance $6191 m0 *1 23.94,99.4
X$6191 15 5903 5139 10683 5185 27 DFF_X2
* cell instance $6194 m0 *1 30.02,99.4
X$6194 5357 5522 5526 15 27 5492 OR3_X4
* cell instance $6195 m0 *1 32.11,99.4
X$6195 5432 15 27 5525 INV_X1
* cell instance $6199 r0 *1 25.46,99.4
X$6199 15 5750 5139 10744 5212 27 DFF_X2
* cell instance $6201 r0 *1 30.59,99.4
X$6201 5523 15 27 5524 INV_X1
* cell instance $6202 r0 *1 30.97,99.4
X$6202 5357 5432 5523 27 5622 15 OAI21_X1
* cell instance $6203 r0 *1 31.73,99.4
X$6203 5524 5525 5496 27 15 5667 AND3_X1
* cell instance $6205 r0 *1 32.87,99.4
X$6205 15 5670 5696 5524 5405 27 AOI21_X4
* cell instance $6207 m0 *1 35.15,99.4
X$6207 5500 5526 5497 15 27 5791 OR3_X4
* cell instance $6209 m0 *1 38.95,99.4
X$6209 5223 15 27 5527 INV_X1
* cell instance $6210 m0 *1 39.33,99.4
X$6210 5280 5281 5436 27 15 5435 HA_X1
* cell instance $6211 m0 *1 41.23,99.4
X$6211 5436 5502 15 27 5531 XNOR2_X2
* cell instance $6212 m0 *1 43.13,99.4
X$6212 5436 15 27 5418 INV_X1
* cell instance $6214 m0 *1 43.7,99.4
X$6214 5595 15 27 5532 INV_X1
* cell instance $6215 m0 *1 44.08,99.4
X$6215 5596 15 27 5241 CLKBUF_X2
* cell instance $6221 r0 *1 36.67,99.4
X$6221 5593 5413 5526 15 27 5697 OR3_X4
* cell instance $6222 r0 *1 38.76,99.4
X$6222 5527 5529 5528 15 5413 27 AOI21_X2
* cell instance $6223 r0 *1 40.09,99.4
X$6223 5527 5528 5529 27 15 5593 AND3_X1
* cell instance $6224 r0 *1 41.04,99.4
X$6224 5435 15 27 5528 INV_X1
* cell instance $6225 r0 *1 41.42,99.4
X$6225 5418 5532 5533 15 5530 27 AOI21_X2
* cell instance $6226 r0 *1 42.75,99.4
X$6226 5418 5532 5533 27 15 5671 AND3_X1
* cell instance $6228 r0 *1 43.89,99.4
X$6228 5534 5595 5436 27 5529 15 OAI21_X1
* cell instance $6230 r0 *1 44.84,99.4
X$6230 5241 15 27 5535 INV_X1
* cell instance $6231 r0 *1 45.22,99.4
X$6231 5535 5536 5760 15 5534 27 AOI21_X2
* cell instance $6232 r0 *1 46.55,99.4
X$6232 5280 5537 5539 27 15 5623 HA_X1
* cell instance $6233 m0 *1 47.31,99.4
X$6233 5439 5503 27 15 5538 XNOR2_X1
* cell instance $6234 m0 *1 46.74,99.4
X$6234 5364 15 27 5437 BUF_X1
* cell instance $6237 r0 *1 48.45,99.4
X$6237 5539 15 27 5439 INV_X2
* cell instance $6238 r0 *1 49.02,99.4
X$6238 5762 5540 5539 27 5536 15 OAI21_X1
* cell instance $6240 r0 *1 49.97,99.4
X$6240 5540 15 27 5624 INV_X1
* cell instance $6241 r0 *1 50.35,99.4
X$6241 5280 5542 5541 27 15 5540 HA_X1
* cell instance $6242 m0 *1 51.68,99.4
X$6242 5441 5541 5442 27 15 5505 OAI21_X4
* cell instance $6243 m0 *1 50.35,99.4
X$6243 5441 5506 5541 27 15 5503 OAI21_X2
* cell instance $6244 m0 *1 54.15,99.4
X$6244 5445 5366 15 27 5626 XNOR2_X2
* cell instance $6246 m0 *1 56.24,99.4
X$6246 15 5442 5444 5445 5603 27 AOI21_X4
* cell instance $6247 m0 *1 58.71,99.4
X$6247 5367 15 27 5604 BUF_X1
* cell instance $6248 m0 *1 59.28,99.4
X$6248 5446 5604 5544 27 15 5603 OAI21_X4
* cell instance $6253 r0 *1 52.44,99.4
X$6253 5442 15 27 5600 BUF_X2
* cell instance $6254 r0 *1 53.2,99.4
X$6254 5600 15 27 5768 BUF_X1
* cell instance $6256 r0 *1 53.96,99.4
X$6256 5280 5680 5629 27 15 5628 HA_X1
* cell instance $6257 r0 *1 55.86,99.4
X$6257 5680 15 27 5443 BUF_X1
* cell instance $6258 r0 *1 56.43,99.4
X$6258 5280 5543 5367 27 15 5630 HA_X1
* cell instance $6259 r0 *1 58.33,99.4
X$6259 5188 5684 10905 27 15 5606 HA_X1
* cell instance $6263 r0 *1 60.23,99.4
X$6263 5606 5702 5701 15 5447 27 AOI21_X2
* cell instance $6264 r0 *1 61.56,99.4
X$6264 5367 15 27 5700 BUF_X2
* cell instance $6267 m0 *1 64.6,99.4
X$6267 15 5611 5545 5683 5448 27 DFF_X1
* cell instance $6272 r0 *1 65.17,99.4
X$6272 15 5612 5631 5608 5448 27 DFF_X1
* cell instance $6273 m0 *1 69.16,99.4
X$6273 5614 5345 5368 15 27 5610 NAND3_X1
* cell instance $6274 m0 *1 68.21,99.4
X$6274 5631 5546 5449 15 27 5681 OR3_X1
* cell instance $6277 m0 *1 73.15,99.4
X$6277 16 5192 5284 27 15 5705 AND3_X2
* cell instance $6279 r0 *1 68.4,99.4
X$6279 5610 5546 15 27 5776 NOR2_X1
* cell instance $6280 r0 *1 68.97,99.4
X$6280 5612 5611 5614 27 15 5677 HA_X1
* cell instance $6281 r0 *1 70.87,99.4
X$6281 5345 16 15 27 5800 NAND2_X1
* cell instance $6282 r0 *1 71.44,99.4
X$6282 5679 5345 15 27 5547 NAND2_X1
* cell instance $6283 r0 *1 72.01,99.4
X$6283 5547 5546 5676 15 27 5633 MUX2_X1
* cell instance $6285 r0 *1 73.72,99.4
X$6285 15 5548 5033 10759 5675 27 DFF_X2
* cell instance $6286 m0 *1 74.86,99.4
X$6286 15 5634 5549 5548 5033 27 DFF_X1
* cell instance $6290 m0 *1 79.04,99.4
X$6290 5549 1248 2099 15 27 5548 MUX2_X1
* cell instance $6299 m0 *1 3.04,15.4
X$6299 696 457 15 27 607 NOR2_X1
* cell instance $6301 m0 *1 3.8,15.4
X$6301 607 611 609 15 755 27 AOI21_X2
* cell instance $6302 m0 *1 5.13,15.4
X$6302 15 700 457 611 610 27 AOI21_X4
* cell instance $6303 m0 *1 7.6,15.4
X$6303 612 674 700 578 756 27 15 AOI211_X2
* cell instance $6304 m0 *1 9.31,15.4
X$6304 616 613 15 27 757 NAND2_X1
* cell instance $6312 r0 *1 3.04,15.4
X$6312 696 699 27 15 697 AND2_X1
* cell instance $6313 r0 *1 3.8,15.4
X$6313 698 792 578 27 608 15 OAI21_X1
* cell instance $6314 r0 *1 4.56,15.4
X$6314 699 696 15 27 857 NAND2_X1
* cell instance $6317 r0 *1 6.27,15.4
X$6317 1310 861 696 457 610 858 15 27 OAI221_X2
* cell instance $6321 r0 *1 9.69,15.4
X$6321 504 757 15 27 793 XNOR2_X2
* cell instance $6322 m0 *1 11.02,15.4
X$6322 701 354 15 27 611 NAND2_X2
* cell instance $6323 m0 *1 10.26,15.4
X$6323 696 615 617 27 674 15 OAI21_X1
* cell instance $6325 r0 *1 11.59,15.4
X$6325 354 531 502 701 15 859 27 NAND4_X2
* cell instance $6327 m0 *1 12.35,15.4
X$6327 15 354 701 619 696 794 27 OAI211_X4
* cell instance $6328 m0 *1 16.34,15.4
X$6328 619 794 15 27 759 NOR2_X2
* cell instance $6331 r0 *1 13.68,15.4
X$6331 618 270 15 27 699 NAND2_X1
* cell instance $6333 r0 *1 15.01,15.4
X$6333 15 861 532 759 863 27 AOI21_X4
* cell instance $6334 r0 *1 17.48,15.4
X$6334 270 702 504 27 863 15 NOR3_X2
* cell instance $6335 m0 *1 19.38,15.4
X$6335 15 762 763 458 618 621 27 OAI211_X4
* cell instance $6336 m0 *1 17.67,15.4
X$6336 224 410 702 15 27 NOR2_X4
* cell instance $6337 m0 *1 22.61,15.4
X$6337 764 704 508 15 620 27 AOI21_X1
* cell instance $6339 m0 *1 23.56,15.4
X$6339 15 610 584 362 623 27 AOI21_X4
* cell instance $6344 m0 *1 31.54,15.4
X$6344 707 15 27 679 INV_X1
* cell instance $6346 m0 *1 32.68,15.4
X$6346 538 626 15 27 681 OR2_X1
* cell instance $6349 m0 *1 34.39,15.4
X$6349 626 538 15 27 708 NOR2_X1
* cell instance $6351 m0 *1 35.15,15.4
X$6351 543 509 15 538 27 NAND2_X4
* cell instance $6352 m0 *1 36.86,15.4
X$6352 627 710 538 27 683 15 NOR3_X2
* cell instance $6355 r0 *1 18.81,15.4
X$6355 704 584 534 702 27 15 703 AND4_X2
* cell instance $6356 r0 *1 20.14,15.4
X$6356 534 584 623 702 15 762 27 NAND4_X2
* cell instance $6357 r0 *1 21.85,15.4
X$6357 702 535 15 27 764 NAND2_X1
* cell instance $6358 r0 *1 22.42,15.4
X$6358 865 538 361 27 15 763 OAI21_X2
* cell instance $6360 r0 *1 23.94,15.4
X$6360 767 867 866 27 15 502 OAI21_X2
* cell instance $6361 r0 *1 25.27,15.4
X$6361 535 362 15 27 866 NOR2_X1
* cell instance $6362 r0 *1 25.84,15.4
X$6362 362 704 796 27 15 867 AND3_X1
* cell instance $6363 r0 *1 26.79,15.4
X$6363 224 705 540 27 15 767 AND3_X1
* cell instance $6366 r0 *1 28.69,15.4
X$6366 388 796 706 27 15 624 HA_X1
* cell instance $6367 r0 *1 30.59,15.4
X$6367 224 795 15 27 707 XNOR2_X2
* cell instance $6368 r0 *1 32.49,15.4
X$6368 15 584 873 708 619 770 27 OAI211_X4
* cell instance $6369 r0 *1 35.72,15.4
X$6369 387 707 709 15 770 27 AOI21_X2
* cell instance $6371 r0 *1 37.24,15.4
X$6371 538 710 627 15 27 873 OR3_X1
* cell instance $6374 m0 *1 39.33,15.4
X$6374 629 771 628 15 627 27 AOI21_X1
* cell instance $6375 m0 *1 40.85,15.4
X$6375 773 630 772 15 27 774 MUX2_X1
* cell instance $6376 m0 *1 42.18,15.4
X$6376 631 632 15 27 773 NAND2_X1
* cell instance $6377 m0 *1 42.75,15.4
X$6377 632 633 15 27 772 OR2_X1
* cell instance $6379 m0 *1 43.7,15.4
X$6379 631 630 776 15 27 771 MUX2_X1
* cell instance $6383 r0 *1 39.71,15.4
X$6383 801 711 15 27 628 NOR2_X1
* cell instance $6384 r0 *1 40.28,15.4
X$6384 712 774 802 27 15 534 OAI21_X4
* cell instance $6387 r0 *1 43.89,15.4
X$6387 803 713 15 27 776 OR2_X1
* cell instance $6390 r0 *1 45.79,15.4
X$6390 464 714 15 27 952 NOR2_X2
* cell instance $6391 r0 *1 46.74,15.4
X$6391 714 715 805 27 15 280 MUX2_X2
* cell instance $6392 r0 *1 48.45,15.4
X$6392 905 806 15 27 467 NAND2_X2
* cell instance $6393 m0 *1 49.4,15.4
X$6393 715 15 27 716 INV_X1
* cell instance $6398 m0 *1 56.81,15.4
X$6398 415 15 27 718 INV_X1
* cell instance $6399 m0 *1 57.19,15.4
X$6399 388 780 415 27 15 472 HA_X1
* cell instance $6400 m0 *1 59.09,15.4
X$6400 719 15 27 780 INV_X1
* cell instance $6402 r0 *1 49.4,15.4
X$6402 807 717 464 15 27 NOR2_X4
* cell instance $6404 r0 *1 51.3,15.4
X$6404 1121 907 808 27 15 544 OAI21_X2
* cell instance $6408 r0 *1 56.62,15.4
X$6408 415 636 27 15 810 XNOR2_X1
* cell instance $6409 r0 *1 57.76,15.4
X$6409 636 718 15 27 888 NOR2_X1
* cell instance $6410 r0 *1 58.33,15.4
X$6410 718 636 27 15 889 AND2_X1
* cell instance $6414 r0 *1 59.09,15.4
X$6414 956 639 911 888 637 889 15 27 720 OAI33_X1
* cell instance $6416 m0 *1 59.85,15.4
X$6416 516 27 690 15 BUF_X4
* cell instance $6417 m0 *1 61.94,15.4
X$6417 638 334 784 27 15 809 OAI21_X4
* cell instance $6420 r0 *1 61.18,15.4
X$6420 690 811 782 959 15 27 890 AOI22_X2
* cell instance $6423 r0 *1 64.03,15.4
X$6423 811 516 15 27 812 NAND2_X1
* cell instance $6426 m0 *1 64.79,15.4
X$6426 15 639 721 290 640 27 AOI21_X4
* cell instance $6427 m0 *1 67.45,15.4
X$6427 598 722 787 27 15 695 OAI21_X2
* cell instance $6429 m0 *1 68.97,15.4
X$6429 693 788 15 27 789 OR2_X1
* cell instance $6431 m0 *1 69.92,15.4
X$6431 15 479 789 553 552 27 AOI21_X4
* cell instance $6433 r0 *1 64.98,15.4
X$6433 290 637 960 640 15 813 27 NAND4_X2
* cell instance $6436 r0 *1 67.26,15.4
X$6436 893 784 15 27 551 NOR2_X1
* cell instance $6439 r0 *1 68.4,15.4
X$6439 788 693 15 27 814 NOR2_X1
* cell instance $6441 r0 *1 69.16,15.4
X$6441 814 722 787 27 15 815 OAI21_X2
* cell instance $6443 r0 *1 71.25,15.4
X$6443 723 365 15 27 641 NAND2_X2
* cell instance $6444 r0 *1 72.2,15.4
X$6444 641 692 15 964 27 OR2_X4
* cell instance $6446 m0 *1 72.77,15.4
X$6446 790 478 479 27 15 640 OAI21_X2
* cell instance $6447 m0 *1 74.29,15.4
X$6447 723 724 417 79 15 27 788 NAND4_X1
* cell instance $6449 m0 *1 75.43,15.4
X$6449 184 724 817 643 556 692 27 15 AOI221_X2
* cell instance $6451 r0 *1 73.91,15.4
X$6451 894 15 27 556 BUF_X2
* cell instance $6452 r0 *1 74.67,15.4
X$6452 556 791 15 27 965 XNOR2_X2
* cell instance $6453 r0 *1 76.57,15.4
X$6453 791 556 27 790 15 XOR2_X2
* cell instance $6455 m0 *1 77.9,15.4
X$6455 15 791 643 184 480 27 AOI21_X4
* cell instance $6456 m0 *1 80.56,15.4
X$6456 725 785 15 27 602 XOR2_X1
* cell instance $6459 r0 *1 79.04,15.4
X$6459 555 15 27 896 INV_X2
* cell instance $6462 r0 *1 80.18,15.4
X$6462 212 896 725 27 15 726 HA_X1
* cell instance $6464 m0 *1 82.08,15.4
X$6464 725 644 27 15 895 AND2_X2
* cell instance $6465 r0 *1 82.08,15.4
X$6465 559 895 726 725 786 1053 27 15 AOI221_X2
* cell instance $6466 m0 *1 85.31,15.4
X$6466 560 783 15 27 785 NAND2_X1
* cell instance $6467 m0 *1 83.41,15.4
X$6467 111 558 644 27 15 786 HA_X1
* cell instance $6470 r0 *1 84.17,15.4
X$6470 786 15 27 783 INV_X1
* cell instance $6472 r0 *1 87.59,15.4
X$6472 993 781 727 27 596 15 OAI21_X1
* cell instance $6473 m0 *1 87.97,15.4
X$6473 111 15 27 728 INV_X2
* cell instance $6475 m0 *1 88.54,15.4
X$6475 818 731 730 729 15 489 27 NAND4_X2
* cell instance $6476 m0 *1 90.25,15.4
X$6476 730 728 729 15 27 647 NAND3_X1
* cell instance $6479 m0 *1 91.96,15.4
X$6479 646 647 15 27 648 OR2_X1
* cell instance $6482 r0 *1 88.35,15.4
X$6482 819 15 27 727 INV_X1
* cell instance $6483 r0 *1 88.73,15.4
X$6483 729 731 15 27 781 NAND2_X1
* cell instance $6484 r0 *1 89.3,15.4
X$6484 111 820 731 27 15 10925 HA_X1
* cell instance $6487 r0 *1 92.15,15.4
X$6487 824 114 892 15 27 823 MUX2_X1
* cell instance $6492 m0 *1 3.04,21
X$6492 1057 975 613 27 698 15 NOR3_X2
* cell instance $6494 m0 *1 4.56,21
X$6494 700 578 1105 974 15 27 1056 AOI22_X2
* cell instance $6496 m0 *1 6.46,21
X$6496 1105 974 15 27 1021 NAND2_X1
* cell instance $6504 r0 *1 3.23,21
X$6504 613 940 973 27 15 1216 OAI21_X2
* cell instance $6505 r0 *1 4.56,21
X$6505 897 1057 975 27 15 1267 OAI21_X4
* cell instance $6506 r0 *1 7.03,21
X$6506 15 1134 1058 355 1057 27 NOR3_X4
* cell instance $6508 m0 *1 7.41,21
X$6508 613 975 1057 15 27 974 OR3_X1
* cell instance $6510 m0 *1 8.74,21
X$6510 15 1107 226 975 1112 1023 27 AOI22_X4
* cell instance $6511 r0 *1 9.69,21
X$6511 15 940 1109 226 1107 27 AOI21_X4
* cell instance $6514 m0 *1 12.35,21
X$6514 1059 1060 27 15 1109 XNOR2_X1
* cell instance $6515 r0 *1 12.54,21
X$6515 1060 1059 27 1135 15 XOR2_X2
* cell instance $6516 m0 *1 14.06,21
X$6516 1110 15 27 1059 BUF_X2
* cell instance $6518 m0 *1 14.82,21
X$6518 388 1058 1110 27 15 976 HA_X1
* cell instance $6519 m0 *1 16.72,21
X$6519 1059 1060 27 977 15 AND2_X4
* cell instance $6522 m0 *1 24.7,21
X$6522 1113 1062 15 27 1112 NAND2_X1
* cell instance $6526 m0 *1 29.26,21
X$6526 706 1025 15 27 535 XNOR2_X2
* cell instance $6532 r0 *1 23.94,21
X$6532 1061 1113 1062 27 15 1058 MUX2_X2
* cell instance $6535 r0 *1 26.22,21
X$6535 15 1059 1196 1137 1138 980 27 NAND4_X4
* cell instance $6538 m0 *1 31.73,21
X$6538 941 979 15 27 1025 NAND2_X2
* cell instance $6540 m0 *1 32.68,21
X$6540 535 981 27 15 626 AND2_X1
* cell instance $6545 r0 *1 32.11,21
X$6545 1198 15 27 979 INV_X1
* cell instance $6546 r0 *1 32.49,21
X$6546 941 1199 27 15 1113 AND2_X1
* cell instance $6548 r0 *1 33.63,21
X$6548 1140 1141 1142 15 27 1199 OR3_X1
* cell instance $6549 r0 *1 34.58,21
X$6549 1228 15 27 1143 INV_X1
* cell instance $6551 m0 *1 36.29,21
X$6551 980 943 1027 906 27 15 981 OAI22_X2
* cell instance $6553 m0 *1 38,21
X$6553 540 1116 365 15 27 1027 NAND3_X1
* cell instance $6558 r0 *1 37.81,21
X$6558 15 796 1201 1065 947 27 AOI21_X4
* cell instance $6560 m0 *1 39.14,21
X$6560 1064 899 1065 27 629 15 NOR3_X2
* cell instance $6561 m0 *1 40.66,21
X$6561 906 899 1064 15 27 712 OR3_X1
* cell instance $6562 m0 *1 41.61,21
X$6562 906 1117 1118 27 15 898 OAI21_X4
* cell instance $6563 m0 *1 44.08,21
X$6563 804 901 776 902 805 1118 27 15 AOI221_X2
* cell instance $6565 r0 *1 40.28,21
X$6565 1064 1065 15 27 1201 NOR2_X1
* cell instance $6568 r0 *1 42.75,21
X$6568 713 803 15 27 633 NOR2_X1
* cell instance $6569 r0 *1 43.32,21
X$6569 15 1065 27 906 BUF_X8
* cell instance $6571 m0 *1 46.74,21
X$6571 1120 597 15 27 902 NOR2_X2
* cell instance $6574 m0 *1 47.88,21
X$6574 904 982 27 15 545 AND2_X1
* cell instance $6576 r0 *1 46.55,21
X$6576 1204 945 15 27 1282 NAND2_X1
* cell instance $6577 r0 *1 47.12,21
X$6577 1204 15 27 1120 INV_X1
* cell instance $6578 r0 *1 47.5,21
X$6578 1148 1149 27 15 982 XNOR2_X1
* cell instance $6580 r0 *1 48.83,21
X$6580 1236 1207 1283 27 15 715 OAI21_X4
* cell instance $6581 m0 *1 49.21,21
X$6581 714 15 27 1032 INV_X1
* cell instance $6586 m0 *1 50.73,21
X$6586 1150 714 1039 1033 1121 27 15 AOI211_X2
* cell instance $6587 r0 *1 51.3,21
X$6587 1150 904 1126 1208 634 27 15 AOI211_X2
* cell instance $6588 m0 *1 53.01,21
X$6588 879 1456 27 15 1034 XNOR2_X1
* cell instance $6594 m0 *1 56.62,21
X$6594 15 1124 1125 1127 805 808 27 OAI211_X4
* cell instance $6595 m0 *1 55.29,21
X$6595 984 983 637 15 27 1036 NAND3_X2
* cell instance $6596 m0 *1 59.85,21
X$6596 1067 984 983 637 15 27 1066 NAND4_X1
* cell instance $6597 m0 *1 60.8,21
X$6597 638 879 15 27 984 NAND2_X1
* cell instance $6598 m0 *1 61.37,21
X$6598 983 1067 27 15 1129 AND2_X1
* cell instance $6599 m0 *1 62.13,21
X$6599 809 985 15 27 719 NAND2_X2
* cell instance $6601 m0 *1 63.27,21
X$6601 645 15 27 879 BUF_X2
* cell instance $6604 m0 *1 65.74,21
X$6604 15 1043 987 721 988 911 27 NOR4_X4
* cell instance $6606 m0 *1 70.68,21
X$6606 913 914 912 15 27 959 NAND3_X1
* cell instance $6610 r0 *1 55.67,21
X$6610 1067 720 15 27 1124 NAND2_X1
* cell instance $6611 r0 *1 56.24,21
X$6611 983 984 637 15 27 1286 AND3_X4
* cell instance $6612 r0 *1 58.33,21
X$6612 416 1036 1038 27 15 1127 OAI21_X2
* cell instance $6616 r0 *1 59.66,21
X$6616 1038 1066 890 1291 27 15 1288 OAI22_X1
* cell instance $6617 r0 *1 60.61,21
X$6617 637 983 984 1067 27 15 1211 AND4_X1
* cell instance $6618 r0 *1 61.75,21
X$6618 15 986 1211 1125 1129 1212 27 AOI22_X4
* cell instance $6619 r0 *1 64.98,21
X$6619 1151 722 787 27 15 595 OAI21_X2
* cell instance $6622 r0 *1 72.58,21
X$6622 15 1152 1153 557 1068 914 27 NAND4_X4
* cell instance $6623 m0 *1 73.53,21
X$6623 1069 989 557 15 27 912 NAND3_X2
* cell instance $6625 m0 *1 74.86,21
X$6625 554 989 1069 27 15 1043 AND3_X2
* cell instance $6627 r0 *1 76,21
X$6627 1068 15 27 989 INV_X1
* cell instance $6628 r0 *1 76.38,21
X$6628 1153 1213 1069 15 27 1133 MUX2_X1
* cell instance $6629 m0 *1 76.57,21
X$6629 1050 1070 1072 15 27 915 NAND3_X2
* cell instance $6631 m0 *1 77.9,21
X$6631 138 1133 916 27 15 1072 HA_X1
* cell instance $6632 m0 *1 79.8,21
X$6632 1070 1072 990 27 15 557 OAI21_X4
* cell instance $6637 r0 *1 78.09,21
X$6637 1068 1071 15 27 558 NOR2_X1
* cell instance $6638 r0 *1 78.66,21
X$6638 1070 990 1072 27 15 554 OAI21_X4
* cell instance $6642 r0 *1 83.22,21
X$6642 15 1215 1245 822 992 27 DFF_X2
* cell instance $6643 m0 *1 85.12,21
X$6643 991 1158 10856 27 15 993 HA_X1
* cell instance $6649 r0 *1 88.54,21
X$6649 15 820 1073 1157 1214 111 27 FA_X1
* cell instance $6651 m0 *1 88.92,21
X$6651 1073 729 27 15 1156 XNOR2_X1
* cell instance $6654 r0 *1 91.58,21
X$6654 215 732 1074 15 1246 27 NAND3_X4
* cell instance $6655 m0 *1 93.29,21
X$6655 992 1158 10855 27 15 733 HA_X1
* cell instance $6656 m0 *1 92.72,21
X$6656 1074 823 15 27 1306 NAND2_X1
* cell instance $6657 m0 *1 95.19,21
X$6657 992 822 917 27 1132 15 OAI21_X1
* cell instance $6660 r0 *1 94.05,21
X$6660 215 732 15 27 1305 NAND2_X1
* cell instance $6663 r0 *1 95.57,21
X$6663 1462 1158 917 27 15 995 HA_X1
* cell instance $6664 m0 *1 97.28,21
X$6664 1132 1075 15 27 994 NAND2_X1
* cell instance $6666 m0 *1 97.85,21
X$6666 995 15 27 1075 INV_X1
* cell instance $6671 m0 *1 114.95,21
X$6671 1079 1002 1000 15 27 958 MUX2_X1
* cell instance $6673 m0 *1 117.04,21
X$6673 1169 15 27 1130 INV_X1
* cell instance $6674 m0 *1 117.42,21
X$6674 1048 15 27 1047 BUF_X1
* cell instance $6675 m0 *1 117.99,21
X$6675 1044 15 27 1001 BUF_X1
* cell instance $6678 m0 *1 119.51,21
X$6678 388 1082 1083 27 15 1084 HA_X1
* cell instance $6684 r0 *1 105.83,21
X$6684 138 1341 1077 27 15 1163 HA_X1
* cell instance $6685 r0 *1 107.73,21
X$6685 1077 15 27 1076 INV_X1
* cell instance $6686 r0 *1 108.11,21
X$6686 1163 1077 1162 15 1131 27 AOI21_X1
* cell instance $6689 r0 *1 109.44,21
X$6689 1078 1165 27 15 1164 XNOR2_X1
* cell instance $6690 r0 *1 110.58,21
X$6690 1166 15 27 1078 INV_X1
* cell instance $6692 r0 *1 111.72,21
X$6692 1078 1131 1303 27 1167 15 OAI21_X1
* cell instance $6694 r0 *1 114,21
X$6694 1080 1167 27 15 1079 XNOR2_X1
* cell instance $6699 r0 *1 115.33,21
X$6699 1130 1080 1210 27 15 1170 OAI21_X4
* cell instance $6700 r0 *1 117.8,21
X$6700 1209 1170 27 15 1081 XNOR2_X1
* cell instance $6701 r0 *1 118.94,21
X$6701 1081 1082 1002 27 15 423 MUX2_X2
* cell instance $6702 r0 *1 120.65,21
X$6702 1083 15 27 1209 INV_X1
* cell instance $6705 r0 *1 121.41,21
X$6705 1084 15 27 1171 INV_X1
* cell instance $6706 r0 *1 121.79,21
X$6706 15 1205 1084 1170 1083 27 AOI21_X4
* cell instance $6707 m0 *1 122.74,21
X$6707 924 27 1002 15 BUF_X4
* cell instance $6711 m0 *1 126.35,21
X$6711 954 15 27 1174 INV_X2
* cell instance $6712 m0 *1 124.45,21
X$6712 300 1003 1085 27 15 954 HA_X1
* cell instance $6715 m0 *1 127.87,21
X$6715 1086 1011 1176 27 839 15 OAI21_X1
* cell instance $6717 m0 *1 128.82,21
X$6717 1014 1002 15 27 661 NOR2_X2
* cell instance $6719 m0 *1 129.96,21
X$6719 1086 1004 27 15 1123 XNOR2_X1
* cell instance $6720 m0 *1 131.1,21
X$6720 864 923 1005 921 1123 1006 15 27 765 OAI33_X1
* cell instance $6721 m0 *1 132.43,21
X$6721 1178 1014 27 15 1006 XNOR2_X1
* cell instance $6722 m0 *1 133.57,21
X$6722 15 1122 1041 928 1007 1040 864 844 27 OAI222_X2
* cell instance $6724 m0 *1 136.42,21
X$6724 15 864 1180 1008 1035 1119 27 OAI22_X4
* cell instance $6725 m0 *1 139.65,21
X$6725 1093 1010 15 27 1119 XNOR2_X2
* cell instance $6726 m0 *1 141.55,21
X$6726 1004 846 929 15 1011 27 AOI21_X2
* cell instance $6728 m0 *1 143.07,21
X$6728 1093 1094 1010 15 923 27 NAND3_X4
* cell instance $6729 m0 *1 145.54,21
X$6729 1010 15 27 1095 BUF_X1
* cell instance $6730 m0 *1 146.11,21
X$6730 923 15 27 850 BUF_X1
* cell instance $6733 m0 *1 148.39,21
X$6733 1096 1114 856 849 15 27 1013 NAND4_X1
* cell instance $6735 m0 *1 149.53,21
X$6735 1013 1014 929 846 1115 27 15 AOI211_X2
* cell instance $6737 r0 *1 124.45,21
X$6737 1085 15 27 1173 INV_X1
* cell instance $6739 r0 *1 125.02,21
X$6739 1174 1173 1205 27 15 1086 OAI21_X4
* cell instance $6741 r0 *1 127.68,21
X$6741 1175 1174 15 27 953 NAND2_X1
* cell instance $6743 r0 *1 128.63,21
X$6743 1128 1087 1086 15 27 1176 NAND3_X1
* cell instance $6745 r0 *1 129.77,21
X$6745 1128 1087 15 27 1004 NAND2_X2
* cell instance $6746 r0 *1 130.72,21
X$6746 1202 1041 27 15 1294 XNOR2_X1
* cell instance $6747 r0 *1 131.86,21
X$6747 1203 1002 1089 27 15 205 OAI21_X4
* cell instance $6748 r0 *1 134.33,21
X$6748 1014 1178 15 27 1202 NOR2_X2
* cell instance $6749 r0 *1 135.28,21
X$6749 1092 1002 1091 1179 27 1090 15 NOR4_X2
* cell instance $6750 r0 *1 136.99,21
X$6750 1094 1010 1093 27 15 1180 OAI21_X2
* cell instance $6752 r0 *1 138.51,21
X$6752 1178 1092 1091 27 928 15 NOR3_X2
* cell instance $6755 r0 *1 140.41,21
X$6755 1197 925 1181 27 15 56 OAI21_X4
* cell instance $6756 r0 *1 142.88,21
X$6756 926 1096 1258 15 27 1009 NAND3_X2
* cell instance $6757 r0 *1 144.21,21
X$6757 15 1095 930 1094 1093 935 27 NAND4_X4
* cell instance $6758 r0 *1 147.63,21
X$6758 1259 1014 1183 15 27 1195 NOR3_X1
* cell instance $6759 r0 *1 148.39,21
X$6759 1195 1096 15 27 1012 NAND2_X1
* cell instance $6761 r0 *1 149.15,21
X$6761 1260 1183 15 27 1114 NOR2_X1
* cell instance $6763 r0 *1 149.91,21
X$6763 1096 1097 27 15 1111 AND2_X1
* cell instance $6764 r0 *1 150.67,21
X$6764 1097 1096 15 27 1194 NAND2_X1
* cell instance $6766 r0 *1 151.43,21
X$6766 1194 846 929 15 1017 27 AOI21_X2
* cell instance $6767 m0 *1 151.81,21
X$6767 850 864 1111 27 1024 15 OAI21_X1
* cell instance $6771 m0 *1 154.28,21
X$6771 1106 1098 15 27 207 XNOR2_X2
* cell instance $6772 m0 *1 156.18,21
X$6772 1024 1108 1099 934 15 27 1103 AOI22_X2
* cell instance $6773 m0 *1 157.89,21
X$6773 1100 855 933 15 1108 27 AOI21_X1
* cell instance $6776 m0 *1 159.6,21
X$6776 15 1102 1018 1101 1103 59 27 NAND4_X4
* cell instance $6785 r0 *1 155.42,21
X$6785 1186 1185 27 15 1098 XNOR2_X1
* cell instance $6788 r0 *1 157.13,21
X$6788 1193 15 27 1099 INV_X1
* cell instance $6790 r0 *1 158.27,21
X$6790 1192 1100 15 27 1022 NAND2_X1
* cell instance $6791 r0 *1 158.84,21
X$6791 1106 1185 1187 15 27 1102 OR3_X1
* cell instance $6792 r0 *1 159.79,21
X$6792 1015 935 1189 27 1190 15 OAI21_X1
* cell instance $6793 r0 *1 160.55,21
X$6793 1187 1266 15 27 936 NOR2_X1
* cell instance $6794 r0 *1 161.12,21
X$6794 1015 935 1268 27 1191 15 OAI21_X1
* cell instance $6795 r0 *1 161.88,21
X$6795 1191 1017 1190 15 27 1101 MUX2_X1
* cell instance $6816 r0 *1 3.23,23.8
X$6816 15 578 700 1267 1216 1546 27 NAND4_X4
* cell instance $6817 m0 *1 5.89,23.8
X$6817 1216 1267 578 700 27 15 1217 AND4_X1
* cell instance $6818 m0 *1 3.99,23.8
X$6818 793 1056 15 27 1309 XNOR2_X2
* cell instance $6819 m0 *1 7.03,23.8
X$6819 15 1134 1135 355 973 27 NOR3_X4
* cell instance $6820 m0 *1 9.69,23.8
X$6820 1058 859 1135 15 27 1377 MUX2_X1
* cell instance $6823 r0 *1 6.65,23.8
X$6823 1217 27 1353 15 BUF_X4
* cell instance $6827 r0 *1 13.3,23.8
X$6827 1218 1222 27 15 1312 XNOR2_X1
* cell instance $6829 m0 *1 14.82,23.8
X$6829 295 1220 1219 27 15 1221 HA_X1
* cell instance $6830 m0 *1 14.44,23.8
X$6830 1219 15 27 1218 INV_X1
* cell instance $6833 m0 *1 20.52,23.8
X$6833 1223 1219 1224 1316 15 27 1272 NAND4_X1
* cell instance $6834 m0 *1 21.47,23.8
X$6834 1223 1225 1226 15 27 1317 OR3_X1
* cell instance $6835 m0 *1 22.42,23.8
X$6835 1224 1136 15 27 1381 XOR2_X1
* cell instance $6836 m0 *1 23.56,23.8
X$6836 1272 550 15 27 1196 NOR2_X2
* cell instance $6838 m0 *1 25.27,23.8
X$6838 1273 1319 15 27 1136 NAND2_X1
* cell instance $6841 m0 *1 26.79,23.8
X$6841 1137 1227 1138 27 1273 15 OAI21_X1
* cell instance $6843 m0 *1 27.74,23.8
X$6843 1139 15 27 LOGIC0_X1
* cell instance $6844 m0 *1 28.12,23.8
X$6844 43 1139 1137 27 15 1227 HA_X1
* cell instance $6846 r0 *1 14.82,23.8
X$6846 1313 1222 1218 27 15 1060 OAI21_X4
* cell instance $6848 r0 *1 17.48,23.8
X$6848 195 1426 1316 27 15 1314 HA_X1
* cell instance $6849 r0 *1 19.38,23.8
X$6849 1271 1354 15 1315 27 NAND2_X4
* cell instance $6851 r0 *1 21.28,23.8
X$6851 1223 1225 1226 27 15 1271 OAI21_X4
* cell instance $6852 r0 *1 23.75,23.8
X$6852 1224 1136 27 1226 15 AND2_X4
* cell instance $6854 r0 *1 25.84,23.8
X$6854 1273 1275 27 15 1383 AND2_X1
* cell instance $6856 r0 *1 26.79,23.8
X$6856 1137 1138 1227 15 27 1275 OR3_X1
* cell instance $6857 r0 *1 27.74,23.8
X$6857 897 1137 15 27 1320 NOR2_X1
* cell instance $6859 m0 *1 32.3,23.8
X$6859 1140 1142 1141 27 15 941 OAI21_X4
* cell instance $6860 m0 *1 30.4,23.8
X$6860 295 1061 1140 27 15 1198 HA_X1
* cell instance $6862 m0 *1 34.96,23.8
X$6862 15 1142 1143 1229 1279 27 AOI21_X4
* cell instance $6863 m0 *1 37.43,23.8
X$6863 1229 1279 15 27 1278 NAND2_X1
* cell instance $6868 r0 *1 32.3,23.8
X$6868 195 1322 1228 27 15 1141 HA_X1
* cell instance $6869 r0 *1 34.2,23.8
X$6869 1322 1062 1277 15 27 1220 MUX2_X1
* cell instance $6870 r0 *1 35.53,23.8
X$6870 1143 1278 27 15 1277 XNOR2_X1
* cell instance $6872 m0 *1 41.04,23.8
X$6872 1281 15 27 803 BUF_X2
* cell instance $6873 m0 *1 39.14,23.8
X$6873 295 1064 945 27 15 1281 HA_X1
* cell instance $6874 m0 *1 41.8,23.8
X$6874 1145 1230 15 27 1117 NAND2_X1
* cell instance $6875 m0 *1 42.37,23.8
X$6875 803 945 1231 27 1146 15 OAI21_X1
* cell instance $6876 m0 *1 43.13,23.8
X$6876 1232 1146 15 27 631 OR2_X1
* cell instance $6877 m0 *1 43.89,23.8
X$6877 1147 1232 15 27 713 NAND2_X1
* cell instance $6881 r0 *1 40.85,23.8
X$6881 1356 1145 1230 15 27 801 NAND3_X1
* cell instance $6882 r0 *1 41.61,23.8
X$6882 466 1324 27 15 1322 XNOR2_X1
* cell instance $6883 r0 *1 42.75,23.8
X$6883 803 1231 1233 15 27 1356 NAND3_X1
* cell instance $6884 r0 *1 43.51,23.8
X$6884 1232 15 27 1233 INV_X1
* cell instance $6885 r0 *1 43.89,23.8
X$6885 1146 1147 1232 15 27 1145 NAND3_X1
* cell instance $6886 r0 *1 44.65,23.8
X$6886 1234 1233 15 27 1230 NAND2_X1
* cell instance $6887 m0 *1 45.03,23.8
X$6887 1231 15 27 1148 INV_X1
* cell instance $6889 m0 *1 45.41,23.8
X$6889 945 1231 1232 1204 15 1207 27 NAND4_X2
* cell instance $6890 m0 *1 47.12,23.8
X$6890 1148 1235 1147 27 1206 15 OAI21_X1
* cell instance $6891 m0 *1 47.88,23.8
X$6891 1283 1282 1235 27 1149 15 OAI21_X1
* cell instance $6894 m0 *1 49.59,23.8
X$6894 1236 1325 1207 27 15 714 OAI21_X4
* cell instance $6898 r0 *1 45.22,23.8
X$6898 1234 15 27 1147 INV_X1
* cell instance $6900 r0 *1 45.79,23.8
X$6900 803 1326 945 15 1235 27 AOI21_X2
* cell instance $6902 r0 *1 47.5,23.8
X$6902 1148 1358 27 15 905 XNOR2_X1
* cell instance $6904 r0 *1 49.02,23.8
X$6904 1285 1232 1206 15 1236 27 AOI21_X2
* cell instance $6905 r0 *1 50.35,23.8
X$6905 1359 15 27 1232 BUF_X2
* cell instance $6907 r0 *1 51.3,23.8
X$6907 300 899 1359 27 15 1285 HA_X1
* cell instance $6909 m0 *1 56.24,23.8
X$6909 1286 986 15 1208 27 NAND2_X4
* cell instance $6910 m0 *1 57.95,23.8
X$6910 15 466 720 1067 1288 1237 1126 27 AOI221_X4
* cell instance $6911 m0 *1 60.42,23.8
X$6911 15 1126 720 1212 983 27 AOI21_X4
* cell instance $6915 r0 *1 56.43,23.8
X$6915 986 1286 1326 1367 1329 1365 27 15 AOI221_X2
* cell instance $6916 r0 *1 58.52,23.8
X$6916 1289 1286 986 15 1237 27 AOI21_X1
* cell instance $6921 r0 *1 59.47,23.8
X$6921 416 15 27 1289 INV_X1
* cell instance $6923 r0 *1 60.04,23.8
X$6923 1067 983 15 27 1291 NAND2_X1
* cell instance $6927 r0 *1 64.6,23.8
X$6927 645 27 960 15 BUF_X4
* cell instance $6930 m0 *1 66.31,23.8
X$6930 550 960 15 27 1151 NOR2_X2
* cell instance $6931 m0 *1 68.78,23.8
X$6931 15 1151 1445 787 1152 722 27 OAI211_X4
* cell instance $6933 m0 *1 72.77,23.8
X$6933 554 1068 1152 1153 27 15 987 AND4_X2
* cell instance $6935 m0 *1 74.86,23.8
X$6935 1152 1068 15 27 1213 NAND2_X2
* cell instance $6936 m0 *1 75.81,23.8
X$6936 1154 15 27 1239 INV_X2
* cell instance $6937 m0 *1 76.38,23.8
X$6937 1154 1296 1213 27 15 555 MUX2_X2
* cell instance $6938 m0 *1 78.09,23.8
X$6938 1442 1295 15 27 1296 NAND2_X1
* cell instance $6943 r0 *1 72.58,23.8
X$6943 15 138 1070 1373 1068 1374 27 OAI211_X4
* cell instance $6944 r0 *1 75.81,23.8
X$6944 1238 15 27 1375 INV_X1
* cell instance $6945 r0 *1 76.19,23.8
X$6945 1374 1295 1240 15 1069 27 AOI21_X2
* cell instance $6946 r0 *1 77.52,23.8
X$6946 1071 138 1372 1238 15 27 1376 NAND4_X1
* cell instance $6947 r0 *1 78.47,23.8
X$6947 1372 1241 1071 27 15 1295 OAI21_X2
* cell instance $6950 r0 *1 80.37,23.8
X$6950 1298 1370 27 15 1215 AND2_X1
* cell instance $6952 r0 *1 81.32,23.8
X$6952 1242 1299 1243 27 1370 15 OAI21_X1
* cell instance $6953 m0 *1 82.46,23.8
X$6953 991 992 10857 27 15 1244 HA_X1
* cell instance $6954 m0 *1 82.08,23.8
X$6954 992 15 27 1242 INV_X1
* cell instance $6957 m0 *1 86.07,23.8
X$6957 1155 822 1300 27 15 1302 HA_X1
* cell instance $6958 m0 *1 87.97,23.8
X$6958 1155 970 818 27 15 1304 HA_X1
* cell instance $6959 m0 *1 89.87,23.8
X$6959 1304 15 27 1214 INV_X1
* cell instance $6962 r0 *1 82.27,23.8
X$6962 1299 1330 1300 15 27 1243 NAND3_X1
* cell instance $6964 r0 *1 83.22,23.8
X$6964 15 1369 1245 1155 991 27 DFF_X2
* cell instance $6966 r0 *1 87.02,23.8
X$6966 991 15 27 1331 INV_X1
* cell instance $6968 r0 *1 87.78,23.8
X$6968 1302 27 1458 15 BUF_X4
* cell instance $6969 r0 *1 89.11,23.8
X$6969 1246 818 27 1438 15 AND2_X4
* cell instance $6970 m0 *1 90.82,23.8
X$6970 1246 1156 27 15 1247 AND2_X2
* cell instance $6973 m0 *1 92.53,23.8
X$6973 1158 15 27 970 INV_X2
* cell instance $6978 r0 *1 90.82,23.8
X$6978 1368 1305 1248 27 1366 15 OAI21_X1
* cell instance $6979 r0 *1 91.58,23.8
X$6979 1074 1331 15 27 1368 NAND2_X1
* cell instance $6980 r0 *1 92.15,23.8
X$6980 1157 15 27 1333 INV_X1
* cell instance $6982 r0 *1 92.91,23.8
X$6982 1306 1305 1248 27 1332 15 OAI21_X1
* cell instance $6987 r0 *1 98.8,23.8
X$6987 1335 1400 27 15 1249 XNOR2_X1
* cell instance $6988 m0 *1 98.99,23.8
X$6988 1159 1334 15 27 968 NOR2_X1
* cell instance $6992 m0 *1 101.27,23.8
X$6992 1160 1337 15 27 1251 NAND2_X2
* cell instance $6994 m0 *1 102.41,23.8
X$6994 1308 1159 1161 15 27 652 MUX2_X1
* cell instance $6997 r0 *1 99.94,23.8
X$6997 1249 1159 1250 15 27 887 MUX2_X1
* cell instance $6999 r0 *1 102.03,23.8
X$6999 1339 1251 15 27 1308 XOR2_X1
* cell instance $7000 r0 *1 103.17,23.8
X$7000 212 1161 1339 27 15 1340 HA_X1
* cell instance $7001 r0 *1 105.07,23.8
X$7001 15 1357 1340 1251 1339 27 AOI21_X4
* cell instance $7002 m0 *1 106.97,23.8
X$7002 1076 1162 27 15 1307 XNOR2_X1
* cell instance $7003 m0 *1 105.64,23.8
X$7003 1307 1159 1341 15 27 998 MUX2_X1
* cell instance $7005 m0 *1 108.87,23.8
X$7005 1163 15 27 1252 INV_X1
* cell instance $7006 m0 *1 109.25,23.8
X$7006 1164 1159 1342 15 27 654 MUX2_X1
* cell instance $7007 m0 *1 110.58,23.8
X$7007 1301 15 27 1303 INV_X1
* cell instance $7008 m0 *1 110.96,23.8
X$7008 15 1210 1301 1165 1166 27 AOI21_X4
* cell instance $7009 m0 *1 113.43,23.8
X$7009 924 27 1159 15 BUF_X4
* cell instance $7013 r0 *1 108.11,23.8
X$7013 1252 1076 1357 27 15 1165 OAI21_X4
* cell instance $7014 r0 *1 110.58,23.8
X$7014 195 1342 1166 27 15 1301 HA_X1
* cell instance $7019 m0 *1 115.52,23.8
X$7019 295 1000 1168 27 15 1169 HA_X1
* cell instance $7020 m0 *1 115.14,23.8
X$7020 1168 15 27 1080 INV_X1
* cell instance $7021 m0 *1 117.42,23.8
X$7021 1169 1168 1167 15 1297 27 AOI21_X1
* cell instance $7027 m0 *1 120.08,23.8
X$7027 1209 1297 1171 27 1172 15 OAI21_X1
* cell instance $7030 m0 *1 123.31,23.8
X$7030 1173 1172 27 15 921 XNOR2_X1
* cell instance $7031 m0 *1 124.45,23.8
X$7031 1172 1085 15 27 1175 NAND2_X1
* cell instance $7038 m0 *1 126.92,23.8
X$7038 15 1128 1175 1174 1087 1014 27 NAND4_X4
* cell instance $7042 m0 *1 86.45,99.4
X$7042 5451 5148 15 27 5452 NAND2_X1
* cell instance $7044 m0 *1 88.73,99.4
X$7044 5381 5456 10852 27 15 5454 HA_X1
* cell instance $7045 m0 *1 90.63,99.4
X$7045 15 5618 5454 5455 5554 27 AOI21_X4
* cell instance $7046 m0 *1 93.1,99.4
X$7046 5558 5456 5555 27 15 5559 HA_X1
* cell instance $7048 m0 *1 95.19,99.4
X$7048 5558 5290 5376 27 15 5560 HA_X1
* cell instance $7049 m0 *1 97.09,99.4
X$7049 5559 15 27 5457 INV_X1
* cell instance $7050 m0 *1 97.47,99.4
X$7050 5560 15 27 5616 INV_X1
* cell instance $7052 m0 *1 98.61,99.4
X$7052 5558 5458 5427 27 15 5615 HA_X1
* cell instance $7053 m0 *1 100.51,99.4
X$7053 5460 5613 5609 27 15 5564 OAI21_X4
* cell instance $7054 m0 *1 102.98,99.4
X$7054 5460 5609 5563 27 15 5459 OAI21_X4
* cell instance $7055 m0 *1 105.45,99.4
X$7055 5423 15 27 5460 INV_X1
* cell instance $7060 m0 *1 121.79,99.4
X$7060 5461 5148 15 27 5462 NAND2_X1
* cell instance $7067 m0 *1 82.27,99.4
X$7067 5879 5148 15 27 5550 NAND2_X1
* cell instance $7068 m0 *1 83.03,99.4
X$7068 5383 5371 5550 15 5508 27 AOI21_X1
* cell instance $7073 r0 *1 82.46,99.4
X$7073 15 10465 5674 5617 5372 27 DFF_X1
* cell instance $7074 r0 *1 85.69,99.4
X$7074 5635 1248 2102 15 27 5617 MUX2_X1
* cell instance $7078 r0 *1 89.68,99.4
X$7078 5556 5553 15 27 5551 XNOR2_X2
* cell instance $7079 r0 *1 91.58,99.4
X$7079 5618 15 27 5553 BUF_X1
* cell instance $7081 r0 *1 92.34,99.4
X$7081 5555 15 27 5455 INV_X1
* cell instance $7082 r0 *1 92.72,99.4
X$7082 5376 15 27 5556 INV_X1
* cell instance $7083 r0 *1 93.1,99.4
X$7083 5556 5557 5457 15 5619 27 AOI21_X1
* cell instance $7084 r0 *1 93.86,99.4
X$7084 5556 5457 5557 27 15 5782 AND3_X1
* cell instance $7085 r0 *1 94.81,99.4
X$7085 5376 5711 5559 27 15 5561 OAI21_X2
* cell instance $7087 r0 *1 96.52,99.4
X$7087 5619 5560 5427 27 5639 15 OAI21_X1
* cell instance $7089 r0 *1 97.47,99.4
X$7089 5379 5616 5561 27 15 5638 AND3_X1
* cell instance $7090 r0 *1 98.42,99.4
X$7090 5379 5561 5616 15 5562 27 AOI21_X2
* cell instance $7091 r0 *1 99.75,99.4
X$7091 5615 15 27 5640 INV_X1
* cell instance $7092 r0 *1 100.13,99.4
X$7092 5609 5562 5615 27 15 5641 OAI21_X2
* cell instance $7093 r0 *1 101.46,99.4
X$7093 5558 5565 5609 27 15 5669 HA_X1
* cell instance $7094 r0 *1 103.36,99.4
X$7094 5669 15 27 5642 INV_X1
* cell instance $7109 r0 *1 135.66,99.4
X$7109 15 5668 5647 5566 5605 5602 27 FA_X1
* cell instance $7112 r0 *1 140.41,99.4
X$7112 15 5599 5765 5387 5601 5598 27 FA_X1
* cell instance $7114 m0 *1 141.74,99.4
X$7114 5498 15 27 5601 INV_X1
* cell instance $7116 m0 *1 145.92,99.4
X$7116 15 5666 5465 5597 5388 5837 27 FA_X1
* cell instance $7117 m0 *1 148.96,99.4
X$7117 15 5567 5495 5108 5597 5467 27 FA_X1
* cell instance $7119 m0 *1 152.76,99.4
X$7119 5568 5572 15 27 5493 NOR2_X1
* cell instance $7122 m0 *1 155.61,99.4
X$7122 15 5407 5491 5592 5594 5390 27 FA_X1
* cell instance $7124 m0 *1 158.84,99.4
X$7124 15 5589 5490 5330 5592 5729 27 FA_X1
* cell instance $7125 m0 *1 161.88,99.4
X$7125 15 5473 5589 5391 5588 5488 27 FA_X1
* cell instance $7126 m0 *1 164.92,99.4
X$7126 5471 5572 15 27 5472 NOR2_X1
* cell instance $7134 r0 *1 146.3,99.4
X$7134 5665 15 27 5598 INV_X1
* cell instance $7137 r0 *1 151.24,99.4
X$7137 5650 15 27 5567 INV_X1
* cell instance $7139 r0 *1 152.38,99.4
X$7139 5977 5570 15 27 5389 NOR2_X1
* cell instance $7143 r0 *1 156.56,99.4
X$7143 5569 15 27 5594 INV_X1
* cell instance $7145 r0 *1 157.13,99.4
X$7145 5662 5572 15 27 5297 NOR2_X1
* cell instance $7149 r0 *1 159.79,99.4
X$7149 5591 5745 5571 27 15 5590 HA_X1
* cell instance $7151 r0 *1 164.73,99.4
X$7151 5662 5570 15 27 5470 NOR2_X1
* cell instance $7154 m0 *1 172.71,99.4
X$7154 5475 15 27 5575 INV_X1
* cell instance $7155 m0 *1 169.67,99.4
X$7155 15 5473 5474 5475 5588 5300 27 FA_X1
* cell instance $7165 r0 *1 171.19,99.4
X$7165 15 5576 5256 5586 5575 5577 27 FA_X1
* cell instance $7166 r0 *1 174.23,99.4
X$7166 5586 15 27 5585 INV_X1
* cell instance $7169 m0 *1 175.75,99.4
X$7169 4994 5476 5478 27 15 5477 HA_X1
* cell instance $7171 m0 *1 178.6,99.4
X$7171 15 5657 5202 5485 5578 5486 27 FA_X1
* cell instance $7176 m0 *1 182.97,99.4
X$7176 15 5480 5484 5481 5582 5483 27 FA_X1
* cell instance $7181 r0 *1 182.97,99.4
X$7181 5050 5049 5739 27 15 5483 HA_X1
* cell instance $7188 m0 *1 98.99,147
X$7188 8326 8273 7658 27 15 5456 MUX2_X2
* cell instance $7190 m0 *1 102.98,147
X$7190 7171 8103 8124 15 27 8290 MUX2_X1
* cell instance $7191 m0 *1 104.31,147
X$7191 8290 7605 15 27 8289 NOR2_X1
* cell instance $7192 m0 *1 104.88,147
X$7192 8125 8289 8023 27 8214 15 NOR3_X2
* cell instance $7195 m0 *1 98.04,147
X$7195 8213 8111 15 27 8123 NOR2_X1
* cell instance $7199 r0 *1 98.04,147
X$7199 6824 7762 8324 15 27 8300 MUX2_X1
* cell instance $7201 r0 *1 99.56,147
X$7201 8300 8017 15 27 8394 NOR2_X1
* cell instance $7205 r0 *1 102.22,147
X$7205 8295 7281 8293 15 27 8182 MUX2_X1
* cell instance $7206 r0 *1 103.55,147
X$7206 7171 8022 8124 15 27 8295 MUX2_X1
* cell instance $7211 r0 *1 107.73,147
X$7211 8416 8012 15 27 8215 NOR2_X1
* cell instance $7212 r0 *1 108.3,147
X$7212 8391 8215 8206 27 8074 15 NOR3_X2
* cell instance $7213 r0 *1 109.63,147
X$7213 8389 8287 8206 27 8073 15 NOR3_X2
* cell instance $7215 m0 *1 109.63,147
X$7215 7055 7500 8330 15 27 8216 MUX2_X1
* cell instance $7218 m0 *1 114.95,147
X$7218 8031 8103 6738 15 27 8176 MUX2_X1
* cell instance $7221 m0 *1 119.51,147
X$7221 7739 7762 6742 15 27 8221 MUX2_X1
* cell instance $7222 m0 *1 120.84,147
X$7222 8221 8090 8283 15 27 8222 MUX2_X1
* cell instance $7223 m0 *1 122.17,147
X$7223 7258 8019 7557 15 27 8283 MUX2_X1
* cell instance $7226 r0 *1 110.96,147
X$7226 8216 7450 8331 15 27 8218 MUX2_X1
* cell instance $7228 r0 *1 113.05,147
X$7228 6981 7757 8387 15 27 8219 MUX2_X1
* cell instance $7229 r0 *1 114.38,147
X$7229 8219 7654 8333 15 27 8286 MUX2_X1
* cell instance $7237 r0 *1 121.22,147
X$7237 7057 8019 7560 15 27 8282 MUX2_X1
* cell instance $7238 r0 *1 122.55,147
X$7238 8173 8090 8282 15 27 8334 MUX2_X1
* cell instance $7239 r0 *1 123.88,147
X$7239 8335 8090 8223 15 27 8378 MUX2_X1
* cell instance $7240 m0 *1 124.83,147
X$7240 8126 8075 6698 15 27 8224 MUX2_X1
* cell instance $7242 m0 *1 126.16,147
X$7242 8224 7938 8171 15 27 8225 MUX2_X1
* cell instance $7243 m0 *1 127.49,147
X$7243 8126 7757 6698 15 27 8170 MUX2_X1
* cell instance $7248 r0 *1 126.35,147
X$7248 8277 7992 8225 15 27 7160 MUX2_X1
* cell instance $7251 r0 *1 128.25,147
X$7251 6985 7734 7564 15 27 8336 MUX2_X1
* cell instance $7253 r0 *1 129.96,147
X$7253 6985 7757 7564 15 27 8338 MUX2_X1
* cell instance $7254 r0 *1 131.29,147
X$7254 8030 7762 6559 15 27 8226 MUX2_X1
* cell instance $7256 m0 *1 132.24,147
X$7256 7195 7762 7430 15 27 8272 MUX2_X1
* cell instance $7258 r0 *1 132.62,147
X$7258 8226 8090 8272 15 27 8339 MUX2_X1
* cell instance $7262 r0 *1 136.61,147
X$7262 8228 8270 8071 15 8227 27 AOI21_X1
* cell instance $7263 m0 *1 137.18,147
X$7263 15 10304 8164 8269 8266 27 DFF_X1
* cell instance $7267 r0 *1 137.37,147
X$7267 8371 6063 15 27 8270 NAND2_X1
* cell instance $7273 r0 *1 143.83,147
X$7273 8340 8229 27 15 7398 XNOR2_X1
* cell instance $7274 m0 *1 144.02,147
X$7274 8161 8159 27 15 8229 XNOR2_X1
* cell instance $7277 m0 *1 145.35,147
X$7277 6700 7077 15 27 8127 OR2_X2
* cell instance $7281 m0 *1 147.82,147
X$7281 7969 6700 15 8257 27 OR2_X4
* cell instance $7282 m0 *1 146.68,147
X$7282 7065 8230 27 15 8159 XNOR2_X1
* cell instance $7283 m0 *1 149.53,147
X$7283 15 8233 7788 7569 8263 8130 27 FA_X1
* cell instance $7284 m0 *1 152.57,147
X$7284 8255 15 27 8130 INV_X1
* cell instance $7285 m0 *1 152.95,147
X$7285 8158 15 27 8261 INV_X1
* cell instance $7288 m0 *1 155.04,147
X$7288 8260 15 27 8234 INV_X1
* cell instance $7293 r0 *1 147.06,147
X$7293 8425 8231 27 7245 15 XOR2_X2
* cell instance $7294 r0 *1 148.77,147
X$7294 8341 8257 27 15 7333 XNOR2_X1
* cell instance $7295 r0 *1 149.91,147
X$7295 8232 15 27 8263 INV_X1
* cell instance $7298 r0 *1 151.24,147
X$7298 8129 7418 15 27 8364 NAND2_X1
* cell instance $7301 r0 *1 155.23,147
X$7301 15 8363 8252 8361 8261 8235 27 FA_X1
* cell instance $7303 m0 *1 158.08,147
X$7303 8258 8131 8256 27 15 7884 HA_X1
* cell instance $7304 m0 *1 160.17,147
X$7304 8230 15 27 8040 INV_X1
* cell instance $7306 m0 *1 161.31,147
X$7306 8256 15 27 8156 INV_X1
* cell instance $7307 m0 *1 161.69,147
X$7307 8133 8451 7579 27 15 8255 HA_X1
* cell instance $7309 m0 *1 165.11,147
X$7309 8429 15 27 8152 INV_X1
* cell instance $7310 m0 *1 165.49,147
X$7310 15 8150 8153 8147 8254 8148 27 FA_X1
* cell instance $7313 r0 *1 158.27,147
X$7313 8259 15 27 8131 INV_X1
* cell instance $7317 r0 *1 166.44,147
X$7317 8236 15 27 8254 INV_X1
* cell instance $7321 r0 *1 168.15,147
X$7321 8042 8253 8358 27 15 8345 HA_X1
* cell instance $7327 r0 *1 171.19,147
X$7327 15 8347 8253 8538 8355 8250 27 FA_X1
* cell instance $7328 m0 *1 172.14,147
X$7328 8135 15 27 8148 INV_X1
* cell instance $7335 r0 *1 174.61,147
X$7335 8134 15 27 8348 INV_X1
* cell instance $7339 r0 *1 180.31,147
X$7339 7686 7489 8246 27 15 8046 HA_X1
* cell instance $7342 m0 *1 183.54,147
X$7342 15 8138 8438 8240 8244 8239 27 FA_X1
* cell instance $7345 r0 *1 184.11,147
X$7345 8248 8349 8237 27 15 8241 HA_X1
* cell instance $7347 r0 *1 186.2,147
X$7347 8241 15 27 8239 INV_X1
* cell instance $7352 m0 *1 2.85,149.8
X$7352 8097 15 27 8187 BUF_X1
* cell instance $7354 m0 *1 4.18,149.8
X$7354 8350 15 27 8302 BUF_X1
* cell instance $7356 m0 *1 4.94,149.8
X$7356 8350 7850 15 27 8351 NAND2_X1
* cell instance $7358 m0 *1 5.7,149.8
X$7358 8189 8351 8352 15 8436 27 AOI21_X1
* cell instance $7361 m0 *1 8.74,149.8
X$7361 6931 7854 15 27 8540 NAND2_X1
* cell instance $7362 m0 *1 9.31,149.8
X$7362 7525 15 27 8098 CLKBUF_X3
* cell instance $7363 m0 *1 10.26,149.8
X$7363 15 10390 8303 8353 8098 27 DFF_X1
* cell instance $7364 m0 *1 13.49,149.8
X$7364 8189 8356 8304 15 8353 27 AOI21_X1
* cell instance $7365 m0 *1 14.25,149.8
X$7365 8303 7924 15 27 8356 NAND2_X1
* cell instance $7367 m0 *1 15.01,149.8
X$7367 7699 7652 15 8360 27 NAND2_X4
* cell instance $7368 m0 *1 16.72,149.8
X$7368 7650 6133 7193 6134 8360 8359 15 27 OAI221_X2
* cell instance $7373 r0 *1 2.09,149.8
X$7373 8303 15 27 8399 BUF_X1
* cell instance $7379 r0 *1 3.8,149.8
X$7379 15 10514 8350 8436 8098 27 DFF_X1
* cell instance $7384 r0 *1 9.88,149.8
X$7384 7652 7854 15 27 8541 NAND2_X1
* cell instance $7385 r0 *1 10.45,149.8
X$7385 15 10640 8498 8441 8098 27 DFF_X1
* cell instance $7386 r0 *1 13.68,149.8
X$7386 8189 8542 8195 15 8441 27 AOI21_X1
* cell instance $7389 r0 *1 15.39,149.8
X$7389 15 10530 7652 8359 8501 27 DFF_X1
* cell instance $7390 r0 *1 18.62,149.8
X$7390 7650 6313 7193 6389 8446 8499 15 27 OAI221_X2
* cell instance $7391 m0 *1 20.14,149.8
X$7391 15 10460 7276 8362 7901 27 DFF_X1
* cell instance $7393 m0 *1 23.37,149.8
X$7393 8099 7859 15 27 8450 NAND2_X2
* cell instance $7396 r0 *1 20.71,149.8
X$7396 7754 7699 15 8446 27 NAND2_X4
* cell instance $7397 r0 *1 22.42,149.8
X$7397 6670 7193 8450 7650 6540 27 15 8500 OAI221_X1
* cell instance $7401 r0 *1 27.55,149.8
X$7401 8400 7500 8401 15 27 8454 MUX2_X1
* cell instance $7402 m0 *1 27.93,149.8
X$7402 8625 8108 15 27 8366 NOR2_X1
* cell instance $7406 m0 *1 29.45,149.8
X$7406 6673 7500 8305 15 27 8306 MUX2_X1
* cell instance $7407 m0 *1 30.78,149.8
X$7407 6673 7447 8305 15 27 8368 MUX2_X1
* cell instance $7409 m0 *1 32.3,149.8
X$7409 8455 8108 15 27 8370 NOR2_X1
* cell instance $7410 m0 *1 32.87,149.8
X$7410 8368 7451 15 27 8369 NOR2_X1
* cell instance $7411 m0 *1 33.44,149.8
X$7411 8370 8369 8023 27 7540 15 NOR3_X2
* cell instance $7412 m0 *1 34.77,149.8
X$7412 6677 7448 8373 15 27 8372 MUX2_X1
* cell instance $7413 m0 *1 36.1,149.8
X$7413 6677 8022 8373 15 27 8458 MUX2_X1
* cell instance $7415 r0 *1 28.88,149.8
X$7415 8400 7447 8401 15 27 8455 MUX2_X1
* cell instance $7416 r0 *1 30.21,149.8
X$7416 8306 7450 8454 15 27 7539 MUX2_X1
* cell instance $7419 r0 *1 34.96,149.8
X$7419 8458 7281 8575 15 27 7822 MUX2_X1
* cell instance $7422 m0 *1 39.14,149.8
X$7422 6931 7624 8308 15 27 8375 MUX2_X1
* cell instance $7423 m0 *1 37.81,149.8
X$7423 6931 7115 8308 15 27 8459 MUX2_X1
* cell instance $7424 m0 *1 40.47,149.8
X$7424 8309 8108 15 27 8376 NOR2_X1
* cell instance $7425 m0 *1 41.04,149.8
X$7425 6864 7757 8403 15 27 8310 MUX2_X1
* cell instance $7426 m0 *1 42.37,149.8
X$7426 8310 7654 8405 15 27 7759 MUX2_X1
* cell instance $7430 r0 *1 38.76,149.8
X$7430 8459 7281 8578 15 27 7374 MUX2_X1
* cell instance $7431 r0 *1 40.09,149.8
X$7431 8638 8111 15 27 8198 NOR2_X1
* cell instance $7433 r0 *1 41.42,149.8
X$7433 8402 7757 8404 15 27 8405 MUX2_X1
* cell instance $7434 r0 *1 42.75,149.8
X$7434 6864 7734 8403 15 27 8377 MUX2_X1
* cell instance $7435 r0 *1 44.08,149.8
X$7435 8402 7734 8404 15 27 8464 MUX2_X1
* cell instance $7436 m0 *1 45.41,149.8
X$7436 8463 8312 8016 27 7928 15 NOR3_X2
* cell instance $7437 m0 *1 44.84,149.8
X$7437 8377 7938 15 27 8312 NOR2_X1
* cell instance $7438 m0 *1 46.74,149.8
X$7438 8406 7654 8555 15 27 7656 MUX2_X1
* cell instance $7440 m0 *1 49.59,149.8
X$7440 6741 7442 8314 15 27 8466 MUX2_X1
* cell instance $7442 r0 *1 45.41,149.8
X$7442 8464 8111 15 27 8463 NOR2_X1
* cell instance $7445 r0 *1 46.93,149.8
X$7445 6960 8329 8504 15 27 8473 MUX2_X1
* cell instance $7448 r0 *1 49.21,149.8
X$7448 8407 7447 8506 15 27 8200 MUX2_X1
* cell instance $7449 r0 *1 50.54,149.8
X$7449 8466 7542 8507 15 27 7628 MUX2_X1
* cell instance $7451 m0 *1 51.3,149.8
X$7451 6811 7914 8313 15 27 8315 MUX2_X1
* cell instance $7452 m0 *1 52.82,149.8
X$7452 8316 7914 8385 15 27 8382 MUX2_X1
* cell instance $7454 m0 *1 54.34,149.8
X$7454 8316 8075 8385 15 27 8317 MUX2_X1
* cell instance $7457 m0 *1 57.38,149.8
X$7457 15 8470 8388 10731 8014 27 DFF_X2
* cell instance $7460 m0 *1 62.7,149.8
X$7460 6547 7857 8392 15 27 8318 MUX2_X1
* cell instance $7461 m0 *1 64.03,149.8
X$7461 8318 7858 8510 15 27 7987 MUX2_X1
* cell instance $7464 r0 *1 51.87,149.8
X$7464 6811 8075 8313 15 27 8468 MUX2_X1
* cell instance $7468 r0 *1 55.29,149.8
X$7468 8468 7938 8317 15 27 8285 MUX2_X1
* cell instance $7471 r0 *1 57.19,149.8
X$7471 5869 8579 8471 15 27 8470 MUX2_X1
* cell instance $7472 r0 *1 58.52,149.8
X$7472 7168 6398 8472 27 8471 15 OAI21_X1
* cell instance $7476 r0 *1 59.28,149.8
X$7476 8109 8014 6969 15 27 8472 NAND3_X1
* cell instance $7480 r0 *1 64.03,149.8
X$7480 8411 6191 15 27 8579 NAND2_X2
* cell instance $7481 r0 *1 64.98,149.8
X$7481 8408 8319 15 27 8474 NOR2_X1
* cell instance $7483 r0 *1 65.74,149.8
X$7483 8473 8090 15 27 8409 NOR2_X1
* cell instance $7485 r0 *1 66.5,149.8
X$7485 8474 8409 8206 27 8015 15 NOR3_X2
* cell instance $7486 m0 *1 68.59,149.8
X$7486 8319 15 27 8111 CLKBUF_X3
* cell instance $7487 m0 *1 67.26,149.8
X$7487 6547 7948 8392 15 27 8393 MUX2_X1
* cell instance $7492 r0 *1 69.16,149.8
X$7492 8475 8111 15 27 8410 NOR2_X1
* cell instance $7493 r0 *1 69.73,149.8
X$7493 8410 8320 8206 27 8110 15 NOR3_X2
* cell instance $7494 m0 *1 70.11,149.8
X$7494 8393 8017 15 27 8320 NOR2_X1
* cell instance $7498 m0 *1 71.25,149.8
X$7498 8092 27 7915 15 BUF_X4
* cell instance $7502 r0 *1 71.25,149.8
X$7502 7768 6549 15 27 8411 NOR2_X2
* cell instance $7503 r0 *1 72.2,149.8
X$7503 15 7452 27 8092 BUF_X8
* cell instance $7507 r0 *1 77.33,149.8
X$7507 6972 8321 7188 15 27 8412 NAND3_X2
* cell instance $7508 r0 *1 78.66,149.8
X$7508 6749 7857 8321 15 27 8478 MUX2_X1
* cell instance $7510 m0 *1 79.04,149.8
X$7510 6749 8103 8321 15 27 8395 MUX2_X1
* cell instance $7515 r0 *1 80.94,149.8
X$7515 8478 7858 8479 15 27 7996 MUX2_X1
* cell instance $7517 m0 *1 85.5,149.8
X$7517 15 8206 8481 8398 8374 27 NOR3_X4
* cell instance $7518 m0 *1 84.55,149.8
X$7518 8397 8319 15 27 8398 NOR2_X2
* cell instance $7523 r0 *1 86.45,149.8
X$7523 8483 8090 15 27 8481 NOR2_X2
* cell instance $7527 r0 *1 89.49,149.8
X$7527 8585 8319 15 27 8484 NOR2_X1
* cell instance $7529 m0 *1 90.06,149.8
X$7529 8484 8323 8206 27 8381 15 NOR3_X2
* cell instance $7533 m0 *1 96.9,149.8
X$7533 6824 7653 8324 15 27 8325 MUX2_X1
* cell instance $7534 m0 *1 98.23,149.8
X$7534 8325 7654 8560 15 27 8326 MUX2_X1
* cell instance $7537 m0 *1 100.51,149.8
X$7537 8487 8394 8016 27 8379 15 NOR3_X2
* cell instance $7540 r0 *1 90.06,149.8
X$7540 8564 8090 15 27 8323 NOR2_X1
* cell instance $7542 r0 *1 91.39,149.8
X$7542 7050 7948 8486 15 27 8489 MUX2_X1
* cell instance $7543 r0 *1 92.72,149.8
X$7543 7050 7442 8486 15 27 8488 MUX2_X1
* cell instance $7546 r0 *1 94.62,149.8
X$7546 8488 7542 8516 15 27 7670 MUX2_X1
* cell instance $7549 r0 *1 96.52,149.8
X$7549 8489 8090 15 27 8490 NOR2_X1
* cell instance $7551 r0 *1 97.28,149.8
X$7551 8491 8319 15 27 8492 NOR2_X1
* cell instance $7553 r0 *1 98.23,149.8
X$7553 8492 8490 8206 27 8413 15 NOR3_X2
* cell instance $7555 r0 *1 99.94,149.8
X$7555 8518 8111 15 27 8487 NOR2_X1
* cell instance $7556 r0 *1 100.51,149.8
X$7556 7096 7948 8520 15 27 8485 MUX2_X1
* cell instance $7557 r0 *1 101.84,149.8
X$7557 8485 8017 15 27 8482 NOR2_X1
* cell instance $7559 r0 *1 102.79,149.8
X$7559 8414 8111 15 27 8480 NOR2_X1
* cell instance $7560 m0 *1 104.31,149.8
X$7560 8328 8111 15 27 8125 NOR2_X1
* cell instance $7561 m0 *1 102.98,149.8
X$7561 8415 8022 8327 15 27 8293 MUX2_X1
* cell instance $7564 r0 *1 103.36,149.8
X$7564 8415 8075 8327 15 27 8328 MUX2_X1
* cell instance $7565 r0 *1 104.69,149.8
X$7565 8480 8482 8206 27 8380 15 NOR3_X2
* cell instance $7568 r0 *1 106.97,149.8
X$7568 7014 8329 8522 15 27 8416 MUX2_X1
* cell instance $7569 m0 *1 108.87,149.8
X$7569 8476 8319 15 27 8389 NOR2_X1
* cell instance $7570 m0 *1 108.3,149.8
X$7570 8417 8319 15 27 8391 NOR2_X1
* cell instance $7571 m0 *1 109.44,149.8
X$7571 7055 8329 8330 15 27 8390 MUX2_X1
* cell instance $7572 m0 *1 110.77,149.8
X$7572 8390 8090 15 27 8287 NOR2_X1
* cell instance $7574 m0 *1 111.53,149.8
X$7574 6981 7862 8387 15 27 8384 MUX2_X1
* cell instance $7577 r0 *1 108.3,149.8
X$7577 8477 8329 8418 15 27 8476 MUX2_X1
* cell instance $7578 r0 *1 109.63,149.8
X$7578 8477 7500 8418 15 27 8331 MUX2_X1
* cell instance $7583 r0 *1 113.81,149.8
X$7583 7554 27 8419 15 BUF_X4
* cell instance $7584 m0 *1 114.19,149.8
X$7584 8386 7757 8332 15 27 8333 MUX2_X1
* cell instance $7586 m0 *1 115.52,149.8
X$7586 8386 8075 8332 15 27 8383 MUX2_X1
* cell instance $7587 m0 *1 116.85,149.8
X$7587 8384 7938 8383 15 27 8277 MUX2_X1
* cell instance $7590 m0 *1 119.89,149.8
X$7590 15 7076 8381 8016 8222 27 AOI21_X4
* cell instance $7591 m0 *1 122.36,149.8
X$7591 15 7156 8380 7992 8334 27 AOI21_X4
* cell instance $7592 m0 *1 124.83,149.8
X$7592 15 7078 8413 7992 8378 27 AOI21_X4
* cell instance $7593 m0 *1 127.3,149.8
X$7593 15 7077 8379 7992 8337 27 AOI21_X4
* cell instance $7594 m0 *1 129.77,149.8
X$7594 8467 7654 8338 15 27 8273 MUX2_X1
* cell instance $7600 r0 *1 115.14,149.8
X$7600 8556 7938 8724 15 27 8220 MUX2_X1
* cell instance $7604 r0 *1 117.8,149.8
X$7604 5291 15 27 8420 CLKBUF_X3
* cell instance $7610 r0 *1 122.36,149.8
X$7610 7778 8019 6565 15 27 8335 MUX2_X1
* cell instance $7611 r0 *1 123.69,149.8
X$7611 7122 8019 7676 15 27 8223 MUX2_X1
* cell instance $7612 r0 *1 125.02,149.8
X$7612 5291 15 27 8422 CLKBUF_X3
* cell instance $7614 r0 *1 127.49,149.8
X$7614 8469 8017 8336 15 27 8337 MUX2_X1
* cell instance $7615 r0 *1 128.82,149.8
X$7615 8526 7653 6568 15 27 8467 MUX2_X1
* cell instance $7618 m0 *1 132.43,149.8
X$7618 15 7080 8374 8016 8339 27 AOI21_X4
* cell instance $7621 m0 *1 135.09,149.8
X$7621 15 10291 8371 8227 8266 27 DFF_X1
* cell instance $7624 r0 *1 132.43,149.8
X$7624 7676 8421 15 27 8465 NAND2_X1
* cell instance $7625 r0 *1 133,149.8
X$7625 8420 15 27 8421 BUF_X2
* cell instance $7627 r0 *1 133.95,149.8
X$7627 6985 8422 15 27 8462 NAND2_X1
* cell instance $7628 r0 *1 134.52,149.8
X$7628 7386 8421 15 27 8552 NAND2_X1
* cell instance $7630 r0 *1 135.28,149.8
X$7630 7562 8421 15 27 8423 NAND2_X1
* cell instance $7632 r0 *1 136.23,149.8
X$7632 7564 8421 15 27 8460 NAND2_X1
* cell instance $7634 r0 *1 138.32,149.8
X$7634 8228 8461 8462 15 8424 27 AOI21_X1
* cell instance $7635 r0 *1 139.08,149.8
X$7635 8550 6063 15 27 8461 NAND2_X1
* cell instance $7638 r0 *1 143.45,149.8
X$7638 6772 7080 15 27 8529 OR2_X1
* cell instance $7639 r0 *1 144.21,149.8
X$7639 6772 7078 15 27 8530 OR2_X2
* cell instance $7641 m0 *1 144.78,149.8
X$7641 6772 15 27 6233 CLKBUF_X3
* cell instance $7642 m0 *1 146.49,149.8
X$7642 6906 6772 15 27 8341 OR2_X2
* cell instance $7643 m0 *1 147.44,149.8
X$7643 15 8342 8231 8457 7818 8365 27 FA_X1
* cell instance $7644 m0 *1 150.48,149.8
X$7644 7076 6233 15 27 8342 NOR2_X1
* cell instance $7645 m0 *1 151.05,149.8
X$7645 8426 15 27 8233 INV_X1
* cell instance $7647 m0 *1 151.62,149.8
X$7647 8343 8427 7790 27 15 7570 HA_X1
* cell instance $7649 m0 *1 156.56,149.8
X$7649 15 8453 8363 8344 8234 8132 27 FA_X1
* cell instance $7653 r0 *1 146.68,149.8
X$7653 6772 7156 15 27 8230 OR2_X2
* cell instance $7654 r0 *1 147.63,149.8
X$7654 8548 15 27 8456 INV_X1
* cell instance $7655 r0 *1 148.01,149.8
X$7655 15 8457 8425 8426 8456 8452 27 FA_X1
* cell instance $7656 r0 *1 151.05,149.8
X$7656 8531 15 27 8365 INV_X1
* cell instance $7658 r0 *1 151.62,149.8
X$7658 8627 15 27 8427 INV_X1
* cell instance $7660 r0 *1 152.38,149.8
X$7660 15 8532 8343 8259 8547 7574 27 FA_X1
* cell instance $7663 r0 *1 156.56,149.8
X$7663 8430 15 27 7818 INV_X2
* cell instance $7664 r0 *1 157.13,149.8
X$7664 8545 8544 8448 27 15 8258 HA_X1
* cell instance $7666 r0 *1 159.41,149.8
X$7666 15 8449 8452 8451 8684 8428 27 FA_X1
* cell instance $7668 m0 *1 160.74,149.8
X$7668 8341 15 27 8449 INV_X2
* cell instance $7674 r0 *1 163.78,149.8
X$7674 8598 8448 8447 27 15 8429 HA_X1
* cell instance $7676 m0 *1 169.29,149.8
X$7676 8345 8358 8773 15 7317 27 AOI21_X2
* cell instance $7677 m0 *1 166.25,149.8
X$7677 15 8616 8236 8357 8361 8445 27 FA_X1
* cell instance $7679 m0 *1 170.81,149.8
X$7679 8357 15 27 8444 INV_X1
* cell instance $7680 m0 *1 171.19,149.8
X$7680 8346 8252 8354 27 15 8355 HA_X1
* cell instance $7684 r0 *1 167.01,149.8
X$7684 8447 15 27 8445 INV_X1
* cell instance $7691 r0 *1 172.33,149.8
X$7691 15 8444 8346 8433 8431 8438 27 FA_X1
* cell instance $7692 m0 *1 173.66,149.8
X$7692 15 8432 8347 8535 8354 8348 27 FA_X1
* cell instance $7696 m0 *1 182.97,149.8
X$7696 8240 15 27 8439 INV_X1
* cell instance $7698 m0 *1 184.11,149.8
X$7698 8246 8238 8604 27 15 8349 HA_X1
* cell instance $7702 r0 *1 175.37,149.8
X$7702 8443 15 27 8432 INV_X1
* cell instance $7704 r0 *1 175.94,149.8
X$7704 8433 15 27 8442 INV_X1
* cell instance $7705 r0 *1 176.32,149.8
X$7705 15 8435 8443 8537 8442 8434 27 FA_X1
* cell instance $7706 r0 *1 179.36,149.8
X$7706 15 8437 8435 8440 8439 8140 27 FA_X1
* cell instance $7709 r0 *1 184.11,149.8
X$7709 8430 8237 8695 27 15 8437 HA_X1
* cell instance $7714 m0 *1 3.23,43.4
X$7714 1968 1764 1309 15 27 2200 NAND3_X1
* cell instance $7715 m0 *1 5.51,43.4
X$7715 15 2201 2275 2031 2410 27 NOR3_X4
* cell instance $7718 m0 *1 9.12,43.4
X$7718 2163 1931 15 27 2412 XNOR2_X2
* cell instance $7719 m0 *1 11.02,43.4
X$7719 2111 2253 2252 1818 2331 15 27 OAI211_X2
* cell instance $7727 r0 *1 2.09,43.4
X$7727 2200 2352 2331 15 2351 27 AOI21_X2
* cell instance $7732 r0 *1 3.61,43.4
X$7732 15 1968 1764 1104 858 2275 27 AND4_X4
* cell instance $7734 r0 *1 6.27,43.4
X$7734 1104 858 15 27 2411 NAND2_X1
* cell instance $7736 r0 *1 8.36,43.4
X$7736 2110 2412 1979 15 2613 27 AOI21_X1
* cell instance $7737 r0 *1 9.12,43.4
X$7737 2412 1979 2252 15 27 2490 NAND3_X2
* cell instance $7738 r0 *1 10.45,43.4
X$7738 1818 1931 15 27 2447 XNOR2_X2
* cell instance $7742 r0 *1 13.68,43.4
X$7742 408 2354 27 15 2355 XNOR2_X1
* cell instance $7744 m0 *1 13.87,43.4
X$7744 408 15 27 2163 CLKBUF_X3
* cell instance $7745 m0 *1 17.86,43.4
X$7745 1820 1979 2332 15 27 2493 MUX2_X1
* cell instance $7746 m0 *1 19.19,43.4
X$7746 2037 15 27 2113 INV_X1
* cell instance $7747 m0 *1 19.57,43.4
X$7747 2168 15 27 2202 INV_X1
* cell instance $7753 r0 *1 15.2,43.4
X$7753 2163 1550 27 15 2356 XNOR2_X1
* cell instance $7757 r0 *1 24.13,43.4
X$7757 2276 2277 2333 15 27 2334 OR3_X1
* cell instance $7758 r0 *1 25.08,43.4
X$7758 2276 2277 2333 27 15 2414 OAI21_X4
* cell instance $7759 m0 *1 25.84,43.4
X$7759 2414 2334 27 15 2359 AND2_X1
* cell instance $7761 m0 *1 26.6,43.4
X$7761 2360 2278 27 2333 15 AND2_X4
* cell instance $7764 m0 *1 30.02,43.4
X$7764 2275 27 2162 15 BUF_X4
* cell instance $7765 m0 *1 31.35,43.4
X$7765 2019 2118 2275 27 15 2260 OAI21_X4
* cell instance $7769 r0 *1 27.74,43.4
X$7769 212 2097 2278 27 15 2277 HA_X1
* cell instance $7771 r0 *1 31.16,43.4
X$7771 2162 2049 15 27 2361 NOR2_X1
* cell instance $7774 r0 *1 33.44,43.4
X$7774 15 2362 2260 1880 2103 27 AOI21_X4
* cell instance $7775 m0 *1 35.15,43.4
X$7775 2118 2162 15 27 2280 NOR2_X1
* cell instance $7779 m0 *1 38.95,43.4
X$7779 1978 2204 15 27 2279 NAND2_X1
* cell instance $7780 m0 *1 39.52,43.4
X$7780 2204 1978 15 27 2281 OR2_X1
* cell instance $7783 m0 *1 41.23,43.4
X$7783 1979 1631 15 27 2416 NAND2_X1
* cell instance $7784 m0 *1 41.8,43.4
X$7784 1981 2205 711 1435 27 15 2284 OAI22_X2
* cell instance $7787 m0 *1 45.79,43.4
X$7787 2266 15 27 LOGIC0_X1
* cell instance $7788 m0 *1 46.17,43.4
X$7788 43 2266 2285 27 15 2286 HA_X1
* cell instance $7793 r0 *1 36.67,43.4
X$7793 2363 1353 1880 15 2667 27 AOI21_X1
* cell instance $7796 r0 *1 39.71,43.4
X$7796 2280 2279 2281 15 2338 27 AOI21_X1
* cell instance $7797 r0 *1 40.47,43.4
X$7797 2280 2281 15 27 2282 OR2_X1
* cell instance $7799 r0 *1 41.42,43.4
X$7799 711 2416 2284 15 27 2365 MUX2_X1
* cell instance $7800 r0 *1 42.75,43.4
X$7800 2282 15 27 2419 INV_X1
* cell instance $7803 r0 *1 43.7,43.4
X$7803 2337 2283 15 27 2418 NAND2_X1
* cell instance $7804 r0 *1 44.27,43.4
X$7804 2420 2419 2418 15 27 2054 NAND3_X2
* cell instance $7806 r0 *1 46.36,43.4
X$7806 2422 2285 2286 27 15 2506 OAI21_X2
* cell instance $7807 r0 *1 47.69,43.4
X$7807 2285 2422 2286 15 27 2507 OR3_X1
* cell instance $7808 r0 *1 48.64,43.4
X$7808 2900 2285 15 27 2367 NOR2_X1
* cell instance $7812 r0 *1 51.3,43.4
X$7812 2454 15 27 2369 INV_X2
* cell instance $7813 r0 *1 51.87,43.4
X$7813 111 2367 2287 27 15 2120 HA_X1
* cell instance $7814 m0 *1 53.2,43.4
X$7814 2120 2287 2269 15 2206 27 AOI21_X1
* cell instance $7816 m0 *1 53.96,43.4
X$7816 2207 15 27 2208 INV_X1
* cell instance $7818 m0 *1 54.53,43.4
X$7818 2210 2121 2287 27 2341 15 OAI21_X1
* cell instance $7820 m0 *1 55.48,43.4
X$7820 2209 2288 2342 27 2269 15 OAI21_X1
* cell instance $7822 m0 *1 56.43,43.4
X$7822 2210 15 27 2342 INV_X1
* cell instance $7823 m0 *1 56.81,43.4
X$7823 2272 15 27 2121 BUF_X1
* cell instance $7825 r0 *1 53.77,43.4
X$7825 2340 2207 15 27 2368 NOR2_X1
* cell instance $7826 r0 *1 54.34,43.4
X$7826 2369 2341 2268 15 2340 27 AOI21_X1
* cell instance $7828 r0 *1 55.29,43.4
X$7828 2287 2121 2210 15 27 2370 OR3_X1
* cell instance $7829 r0 *1 56.24,43.4
X$7829 2121 2288 27 15 2426 XNOR2_X1
* cell instance $7832 m0 *1 57.76,43.4
X$7832 1158 2211 2272 27 15 2210 HA_X1
* cell instance $7839 r0 *1 61.37,43.4
X$7839 2513 2373 15 27 2289 XOR2_X1
* cell instance $7840 m0 *1 61.75,43.4
X$7840 2343 15 27 2290 INV_X1
* cell instance $7842 m0 *1 62.13,43.4
X$7842 111 2514 2291 27 15 2343 HA_X1
* cell instance $7843 m0 *1 64.03,43.4
X$7843 2274 2291 2212 15 27 2345 OR3_X1
* cell instance $7847 r0 *1 63.27,43.4
X$7847 2291 2274 2212 27 15 2292 OAI21_X2
* cell instance $7848 r0 *1 64.6,43.4
X$7848 2290 2292 15 27 2373 NAND2_X2
* cell instance $7849 r0 *1 65.55,43.4
X$7849 2292 2345 27 15 2427 AND2_X1
* cell instance $7850 r0 *1 66.31,43.4
X$7850 2293 2274 15 27 2297 NOR2_X1
* cell instance $7852 m0 *1 67.07,43.4
X$7852 2213 2214 2294 27 2295 15 OAI21_X1
* cell instance $7854 m0 *1 67.83,43.4
X$7854 2213 2294 2214 15 27 2296 OR3_X1
* cell instance $7855 m0 *1 68.78,43.4
X$7855 2295 2348 15 27 2298 NAND2_X1
* cell instance $7856 m0 *1 69.35,43.4
X$7856 111 2297 2294 27 15 2349 HA_X1
* cell instance $7857 m0 *1 71.25,43.4
X$7857 2349 15 27 2348 INV_X1
* cell instance $7859 m0 *1 74.67,43.4
X$7859 2215 15 27 LOGIC0_X1
* cell instance $7860 m0 *1 75.05,43.4
X$7860 1158 2215 2217 27 15 2216 HA_X1
* cell instance $7861 m0 *1 76.95,43.4
X$7861 2216 2217 2218 15 2433 27 AOI21_X1
* cell instance $7862 m0 *1 77.71,43.4
X$7862 2220 2219 2216 15 2300 27 AOI21_X1
* cell instance $7863 m0 *1 78.47,43.4
X$7863 2220 15 27 2299 INV_X1
* cell instance $7868 r0 *1 67.64,43.4
X$7868 2294 2374 2213 2375 15 27 2376 NAND4_X1
* cell instance $7869 r0 *1 68.59,43.4
X$7869 2295 2296 27 15 2429 AND2_X1
* cell instance $7871 r0 *1 69.54,43.4
X$7871 2298 2374 27 15 2458 AND2_X2
* cell instance $7872 r0 *1 70.49,43.4
X$7872 2297 2123 2429 15 27 2378 MUX2_X1
* cell instance $7876 r0 *1 74.48,43.4
X$7876 2430 2299 15 27 2377 NAND2_X2
* cell instance $7877 r0 *1 75.43,43.4
X$7877 2219 2217 2216 27 15 2430 OAI21_X2
* cell instance $7879 r0 *1 76.95,43.4
X$7879 2219 2433 27 15 2432 XNOR2_X1
* cell instance $7880 r0 *1 78.09,43.4
X$7880 2377 2434 15 27 2301 NAND2_X1
* cell instance $7881 r0 *1 78.66,43.4
X$7881 2434 2377 15 27 2436 XOR2_X1
* cell instance $7882 r0 *1 79.8,43.4
X$7882 2124 2379 2432 15 27 2381 MUX2_X1
* cell instance $7886 r0 *1 86.07,43.4
X$7886 212 2381 2302 27 15 2382 HA_X1
* cell instance $7887 r0 *1 87.97,43.4
X$7887 2303 2441 2383 27 2439 15 OAI21_X1
* cell instance $7888 r0 *1 88.73,43.4
X$7888 2303 2442 27 15 2384 XNOR2_X1
* cell instance $7889 r0 *1 89.87,43.4
X$7889 2438 2217 15 27 2221 NOR2_X2
* cell instance $7890 m0 *1 90.06,43.4
X$7890 2221 111 2350 27 15 2305 HA_X1
* cell instance $7892 m0 *1 91.96,43.4
X$7892 2305 15 27 2385 INV_X1
* cell instance $7896 r0 *1 90.82,43.4
X$7896 2303 2387 2385 15 2440 27 AOI21_X1
* cell instance $7897 r0 *1 91.58,43.4
X$7897 2350 15 27 2388 BUF_X2
* cell instance $7898 r0 *1 92.34,43.4
X$7898 2221 2306 2389 15 27 2060 MUX2_X1
* cell instance $7901 m0 *1 97.47,43.4
X$7901 2133 2061 15 27 2437 NAND2_X1
* cell instance $7905 m0 *1 98.99,43.4
X$7905 2130 2271 2308 27 15 2467 OAI21_X4
* cell instance $7906 m0 *1 101.46,43.4
X$7906 2060 2132 2222 15 27 1991 MUX2_X1
* cell instance $7909 m0 *1 103.74,43.4
X$7909 111 2225 2347 27 15 2223 HA_X1
* cell instance $7912 r0 *1 97.66,43.4
X$7912 2437 2062 2130 27 2391 15 OAI21_X1
* cell instance $7914 r0 *1 99.18,43.4
X$7914 2130 15 27 2392 INV_X1
* cell instance $7915 r0 *1 99.56,43.4
X$7915 2307 2393 2133 27 2308 15 OAI21_X1
* cell instance $7916 r0 *1 100.32,43.4
X$7916 1158 2431 2307 27 15 2393 HA_X1
* cell instance $7917 r0 *1 102.22,43.4
X$7917 2431 15 27 LOGIC0_X1
* cell instance $7920 r0 *1 104.5,43.4
X$7920 2347 2310 2515 27 15 2136 OAI21_X2
* cell instance $7921 r0 *1 105.83,43.4
X$7921 2515 2347 2310 15 27 2309 OR3_X1
* cell instance $7923 m0 *1 106.02,43.4
X$7923 2136 2309 27 15 2346 AND2_X1
* cell instance $7924 r0 *1 106.78,43.4
X$7924 2811 2307 15 27 2225 NOR2_X1
* cell instance $7925 m0 *1 107.35,43.4
X$7925 2225 2224 2346 15 27 2137 MUX2_X1
* cell instance $7928 m0 *1 110.2,43.4
X$7928 2229 2228 2344 15 2226 27 AOI21_X1
* cell instance $7931 r0 *1 110.39,43.4
X$7931 2395 15 27 2344 INV_X1
* cell instance $7933 r0 *1 110.96,43.4
X$7933 15 2229 2138 2396 2397 27 NOR3_X4
* cell instance $7935 m0 *1 111.34,43.4
X$7935 2227 2228 2229 27 15 2311 OAI21_X2
* cell instance $7936 m0 *1 112.86,43.4
X$7936 2228 2312 15 27 2265 XOR2_X1
* cell instance $7939 m0 *1 115.71,43.4
X$7939 212 2230 2234 27 15 2231 HA_X1
* cell instance $7940 m0 *1 117.61,43.4
X$7940 2141 2139 2231 15 2421 27 AOI21_X1
* cell instance $7941 m0 *1 118.37,43.4
X$7941 2231 2234 2233 15 2232 27 AOI21_X1
* cell instance $7942 m0 *1 119.13,43.4
X$7942 2231 15 27 2314 INV_X1
* cell instance $7943 m0 *1 119.51,43.4
X$7943 2141 2139 2398 15 2235 27 AOI21_X2
* cell instance $7944 m0 *1 120.84,43.4
X$7944 2234 2139 15 27 2316 NAND2_X1
* cell instance $7945 m0 *1 121.41,43.4
X$7945 2315 2316 2235 27 2264 15 OAI21_X1
* cell instance $7947 m0 *1 122.36,43.4
X$7947 2317 2264 27 15 2071 XNOR2_X1
* cell instance $7948 m0 *1 123.5,43.4
X$7948 295 2401 2263 27 15 2319 HA_X1
* cell instance $7950 m0 *1 126.16,43.4
X$7950 2236 2237 15 27 2320 XOR2_X1
* cell instance $7952 m0 *1 130.34,43.4
X$7952 2321 2238 27 15 2262 XNOR2_X1
* cell instance $7954 r0 *1 113.62,43.4
X$7954 2267 2197 2313 15 27 2401 MUX2_X1
* cell instance $7955 r0 *1 114.95,43.4
X$7955 2138 15 27 2425 INV_X1
* cell instance $7960 r0 *1 115.52,43.4
X$7960 2230 2140 2424 15 27 1790 MUX2_X1
* cell instance $7963 r0 *1 118.56,43.4
X$7963 2339 2423 27 15 2424 XNOR2_X1
* cell instance $7964 r0 *1 119.7,43.4
X$7964 2314 2399 2339 27 15 2398 OAI21_X2
* cell instance $7966 r0 *1 121.22,43.4
X$7966 2315 2399 15 27 2423 NAND2_X1
* cell instance $7968 r0 *1 121.98,43.4
X$7968 2318 2317 2235 27 15 2417 OAI21_X2
* cell instance $7969 r0 *1 123.31,43.4
X$7969 2317 2421 2318 27 2403 15 OAI21_X1
* cell instance $7970 r0 *1 124.07,43.4
X$7970 2143 2236 15 27 2400 NAND2_X1
* cell instance $7974 r0 *1 131.29,43.4
X$7974 2262 2073 15 27 2404 NOR2_X1
* cell instance $7975 m0 *1 132.05,43.4
X$7975 15 2073 2147 2321 2336 27 AOI21_X4
* cell instance $7977 m0 *1 134.52,43.4
X$7977 2238 15 27 2336 INV_X4
* cell instance $7981 r0 *1 132.05,43.4
X$7981 15 2476 2147 2321 2336 27 AOI21_X4
* cell instance $7984 r0 *1 135.66,43.4
X$7984 2323 2322 15 27 1996 NOR2_X2
* cell instance $7985 r0 *1 136.61,43.4
X$7985 2323 2322 2073 27 2239 15 NOR3_X2
* cell instance $7986 m0 *1 137.37,43.4
X$7986 2075 2076 2239 2150 2241 15 27 OAI211_X2
* cell instance $7987 m0 *1 136.61,43.4
X$7987 2335 1996 2075 15 27 2240 NAND3_X1
* cell instance $7988 m0 *1 139.08,43.4
X$7988 2241 2240 27 15 2258 AND2_X1
* cell instance $7990 r0 *1 137.94,43.4
X$7990 2323 2322 2074 27 1946 15 OAI21_X1
* cell instance $7992 r0 *1 139.46,43.4
X$7992 2241 1994 2240 27 15 1639 OAI21_X2
* cell instance $7994 m0 *1 140.22,43.4
X$7994 2324 2241 15 27 2257 OR2_X1
* cell instance $7995 m0 *1 141.74,43.4
X$7995 2242 2324 2406 27 2256 15 NOR3_X2
* cell instance $7999 r0 *1 142.5,43.4
X$7999 2242 2324 2406 2243 2246 2244 15 27 1717 OAI33_X1
* cell instance $8001 m0 *1 143.45,43.4
X$8001 2243 2246 2244 2077 27 2255 15 OR4_X2
* cell instance $8002 m0 *1 145.54,43.4
X$8002 2245 2244 15 27 2181 NAND2_X2
* cell instance $8005 m0 *1 147.44,43.4
X$8005 2155 2245 2325 15 27 1425 MUX2_X1
* cell instance $8006 m0 *1 148.77,43.4
X$8006 2326 2243 2246 27 15 2155 OAI21_X4
* cell instance $8008 r0 *1 143.83,43.4
X$8008 15 2246 2244 2243 1999 27 NOR3_X4
* cell instance $8011 r0 *1 148.77,43.4
X$8011 2413 15 27 2325 BUF_X2
* cell instance $8013 r0 *1 149.72,43.4
X$8013 15 2326 27 2413 BUF_X8
* cell instance $8015 m0 *1 151.62,43.4
X$8015 2250 2327 2325 15 27 2081 NAND3_X2
* cell instance $8017 r0 *1 152.38,43.4
X$8017 2082 2159 2079 27 15 2409 AND3_X1
* cell instance $8018 m0 *1 153.52,43.4
X$8018 2250 2158 2326 15 27 2169 NAND3_X2
* cell instance $8022 m0 *1 156.56,43.4
X$8022 1952 2003 2330 2248 27 15 2329 AND4_X1
* cell instance $8023 m0 *1 157.7,43.4
X$8023 2009 2159 2082 27 2330 15 OAI21_X1
* cell instance $8032 r0 *1 153.52,43.4
X$8032 2250 2327 2326 2409 15 2408 27 NAND4_X2
* cell instance $8033 r0 *1 155.23,43.4
X$8033 2328 27 2009 15 BUF_X4
* cell instance $8034 r0 *1 156.56,43.4
X$8034 2484 2329 15 27 1184 XNOR2_X2
* cell instance $8048 m0 *1 3.61,147
X$8048 8188 15 27 8186 BUF_X1
* cell instance $8052 r0 *1 1.52,147
X$8052 15 10547 8188 8242 8098 27 DFF_X1
* cell instance $8056 m0 *1 4.75,147
X$8056 8188 7850 15 27 8243 NAND2_X1
* cell instance $8061 r0 *1 4.94,147
X$8061 8189 8243 8245 15 8242 27 AOI21_X1
* cell instance $8062 r0 *1 5.7,147
X$8062 15 10512 8097 8247 8098 27 DFF_X1
* cell instance $8064 m0 *1 7.22,147
X$8064 8097 7850 15 27 8249 NAND2_X1
* cell instance $8067 r0 *1 8.93,147
X$8067 8189 8249 8190 15 8247 27 AOI21_X1
* cell instance $8071 r0 *1 11.02,147
X$8071 7726 7854 15 27 8352 NAND2_X1
* cell instance $8072 r0 *1 11.59,147
X$8072 7276 7854 15 27 8190 NAND2_X1
* cell instance $8073 m0 *1 12.16,147
X$8073 7279 7854 15 27 8245 NAND2_X1
* cell instance $8079 m0 *1 13.11,147
X$8079 7271 15 27 7854 BUF_X2
* cell instance $8082 r0 *1 13.49,147
X$8082 7538 7854 15 27 8304 NAND2_X1
* cell instance $8084 m0 *1 16.72,147
X$8084 7650 6654 7193 6029 8155 8251 15 27 OAI221_X2
* cell instance $8085 m0 *1 15.01,147
X$8085 7699 7538 15 8155 27 NAND2_X4
* cell instance $8088 m0 *1 20.52,147
X$8088 8099 7276 15 8191 27 NAND2_X4
* cell instance $8090 m0 *1 22.42,147
X$8090 7893 8099 15 8262 27 NAND2_X4
* cell instance $8093 m0 *1 27.93,147
X$8093 8366 8193 7347 27 7813 15 NOR3_X2
* cell instance $8097 r0 *1 15.96,147
X$8097 15 10516 7538 8251 8098 27 DFF_X1
* cell instance $8099 r0 *1 19.38,147
X$8099 7650 6201 7193 5492 8191 8362 15 27 OAI221_X2
* cell instance $8100 r0 *1 21.47,147
X$8100 7650 6583 7193 6542 8262 8264 15 27 OAI221_X2
* cell instance $8101 r0 *1 23.56,147
X$8101 15 8264 7901 10764 7893 27 DFF_X2
* cell instance $8103 r0 *1 27.93,147
X$8103 8192 7340 15 27 8193 NOR2_X1
* cell instance $8109 m0 *1 3.04,74.2
X$8109 4147 15 27 4007 BUF_X1
* cell instance $8110 m0 *1 3.61,74.2
X$8110 4514 15 27 4008 BUF_X1
* cell instance $8113 r0 *1 1.33,74.2
X$8113 4604 15 27 4009 BUF_X1
* cell instance $8120 r0 *1 4.37,74.2
X$8120 4091 4010 15 27 4090 NOR2_X1
* cell instance $8121 m0 *1 5.13,74.2
X$8121 4010 3673 3573 27 15 3981 OAI21_X4
* cell instance $8122 m0 *1 4.56,74.2
X$8122 3086 15 27 4011 INV_X2
* cell instance $8123 m0 *1 7.6,74.2
X$8123 15 3907 4156 4066 3981 4011 27 AOI22_X4
* cell instance $8124 m0 *1 10.83,74.2
X$8124 4064 3461 4092 15 27 NOR2_X4
* cell instance $8128 r0 *1 5.13,74.2
X$8128 3048 4011 15 27 4091 NAND2_X1
* cell instance $8129 r0 *1 5.7,74.2
X$8129 15 3872 4150 3907 4210 4091 27 OAI211_X4
* cell instance $8131 r0 *1 9.12,74.2
X$8131 3049 3461 4064 15 27 4156 OR3_X1
* cell instance $8134 r0 *1 11.02,74.2
X$8134 4092 4158 3574 15 27 4097 OR3_X4
* cell instance $8136 m0 *1 15.39,74.2
X$8136 3929 4067 3873 27 4093 15 NOR3_X2
* cell instance $8137 m0 *1 13.68,74.2
X$8137 4067 3462 3873 3929 27 4470 15 NOR4_X2
* cell instance $8141 m0 *1 19.19,74.2
X$8141 3633 4094 3793 3794 27 15 4095 AND4_X2
* cell instance $8143 m0 *1 22.04,74.2
X$8143 4012 3931 4095 15 3054 27 NAND3_X4
* cell instance $8146 m0 *1 28.31,74.2
X$8146 4163 3990 3396 27 15 4292 MUX2_X2
* cell instance $8148 m0 *1 30.21,74.2
X$8148 3681 3933 15 27 4163 NAND2_X1
* cell instance $8151 r0 *1 15.01,74.2
X$8151 4094 4093 27 15 4269 XNOR2_X1
* cell instance $8152 r0 *1 16.15,74.2
X$8152 15 3793 3794 3633 4094 4270 27 NAND4_X4
* cell instance $8153 r0 *1 19.57,74.2
X$8153 3793 3794 27 15 4211 AND2_X2
* cell instance $8156 r0 *1 21.47,74.2
X$8156 4095 27 4213 15 BUF_X4
* cell instance $8157 r0 *1 22.8,74.2
X$8157 4095 3931 3988 15 3239 27 NAND3_X4
* cell instance $8158 r0 *1 25.27,74.2
X$8158 15 4097 4270 3679 3492 3880 27 NOR4_X4
* cell instance $8161 r0 *1 29.64,74.2
X$8161 4069 3492 15 27 4214 NOR2_X1
* cell instance $8164 m0 *1 32.87,74.2
X$8164 4071 3882 4069 27 4013 15 OAI21_X1
* cell instance $8165 m0 *1 31.16,74.2
X$8165 4069 3681 4099 15 27 NOR2_X4
* cell instance $8168 r0 *1 31.54,74.2
X$8168 4099 4214 3396 27 15 4216 MUX2_X2
* cell instance $8170 r0 *1 33.63,74.2
X$8170 4013 3934 15 27 4272 NOR2_X1
* cell instance $8171 m0 *1 34.2,74.2
X$8171 4014 4164 15 27 4165 NOR2_X1
* cell instance $8173 m0 *1 34.77,74.2
X$8173 3934 3496 3884 15 4164 27 AOI21_X1
* cell instance $8175 r0 *1 34.2,74.2
X$8175 3414 4272 4100 4073 4165 4166 27 15 AOI221_X2
* cell instance $8177 m0 *1 35.91,74.2
X$8177 3852 3887 3886 3914 3416 4217 15 27 OAI221_X2
* cell instance $8181 m0 *1 39.14,74.2
X$8181 3886 4017 15 27 4169 XNOR2_X2
* cell instance $8182 r0 *1 39.33,74.2
X$8182 4166 27 4183 15 BUF_X4
* cell instance $8183 r0 *1 40.66,74.2
X$8183 3686 4102 15 27 4300 NOR2_X1
* cell instance $8184 r0 *1 41.23,74.2
X$8184 2838 3583 4018 4104 4220 27 15 AOI211_X2
* cell instance $8186 m0 *1 41.42,74.2
X$8186 4078 3853 15 27 4103 NOR2_X2
* cell instance $8188 m0 *1 42.75,74.2
X$8188 3935 3496 15 27 4104 NAND2_X1
* cell instance $8189 m0 *1 43.51,74.2
X$8189 3853 4078 15 27 4106 OR2_X1
* cell instance $8192 m0 *1 45.98,74.2
X$8192 4019 3935 15 27 4020 NAND2_X1
* cell instance $8193 m0 *1 46.55,74.2
X$8193 4019 4101 15 27 4179 NAND2_X1
* cell instance $8194 m0 *1 47.12,74.2
X$8194 3496 3690 15 27 4278 XNOR2_X2
* cell instance $8196 m0 *1 50.54,74.2
X$8196 3643 3415 4223 27 4181 15 OAI21_X1
* cell instance $8198 m0 *1 52.06,74.2
X$8198 15 3643 3184 3186 3551 3937 27 NOR4_X4
* cell instance $8200 r0 *1 42.94,74.2
X$8200 3934 3733 15 27 4105 OR2_X1
* cell instance $8201 r0 *1 43.7,74.2
X$8201 4105 3414 4106 15 27 4108 MUX2_X1
* cell instance $8202 r0 *1 45.03,74.2
X$8202 3416 3690 15 27 4378 XNOR2_X2
* cell instance $8203 r0 *1 46.93,74.2
X$8203 4107 3734 4108 15 27 4180 NOR3_X1
* cell instance $8205 r0 *1 47.88,74.2
X$8205 4178 3690 4179 15 27 4556 MUX2_X1
* cell instance $8208 r0 *1 50.16,74.2
X$8208 4181 4180 3918 3889 4226 27 15 AOI211_X2
* cell instance $8210 r0 *1 52.06,74.2
X$8210 4183 4222 3643 3551 4225 15 27 OAI211_X2
* cell instance $8213 m0 *1 55.86,74.2
X$8213 3937 2504 4022 15 3803 27 AOI21_X2
* cell instance $8215 r0 *1 57.19,74.2
X$8215 3938 4021 27 4227 15 AND2_X4
* cell instance $8217 m0 *1 57.57,74.2
X$8217 4021 3938 15 27 4023 NAND2_X2
* cell instance $8219 m0 *1 58.9,74.2
X$8219 3803 4023 15 27 3939 NAND2_X1
* cell instance $8225 r0 *1 59.28,74.2
X$8225 3804 3721 4109 4283 4184 27 15 AOI211_X2
* cell instance $8227 m0 *1 62.7,74.2
X$8227 3738 3721 15 27 4185 NAND2_X1
* cell instance $8228 m0 *1 61.37,74.2
X$8228 4184 3721 4024 15 3942 27 AOI21_X2
* cell instance $8230 m0 *1 63.46,74.2
X$8230 4185 3499 3587 15 4111 27 AOI21_X2
* cell instance $8232 m0 *1 65.55,74.2
X$8232 3498 3499 3587 15 4110 27 AOI21_X1
* cell instance $8235 r0 *1 61.94,74.2
X$8235 4383 3739 3940 27 4287 15 OAI21_X1
* cell instance $8236 r0 *1 62.7,74.2
X$8236 3721 4229 3738 15 4027 27 AOI21_X2
* cell instance $8237 r0 *1 64.03,74.2
X$8237 15 3498 3740 3940 4230 27 NOR3_X4
* cell instance $8238 r0 *1 66.69,74.2
X$8238 4026 4110 4027 4111 4287 4029 15 27 OAI221_X2
* cell instance $8239 m0 *1 66.88,74.2
X$8239 4026 4110 15 27 3943 OR2_X1
* cell instance $8241 m0 *1 67.64,74.2
X$8241 4111 4027 4287 27 3501 15 OAI21_X1
* cell instance $8242 m0 *1 68.4,74.2
X$8242 4028 4112 3591 3560 2800 3501 15 27 4308 OAI33_X1
* cell instance $8243 m0 *1 69.73,74.2
X$8243 3943 3942 15 27 4112 NOR2_X2
* cell instance $8244 m0 *1 70.68,74.2
X$8244 3560 3504 4029 27 4083 15 OAI21_X1
* cell instance $8245 m0 *1 71.44,74.2
X$8245 4029 3864 15 27 4114 NAND2_X1
* cell instance $8246 m0 *1 72.01,74.2
X$8246 4112 2800 4114 15 4030 27 AOI21_X2
* cell instance $8248 m0 *1 73.53,74.2
X$8248 4083 2800 4084 4031 3560 4187 27 15 AOI221_X2
* cell instance $8249 m0 *1 75.62,74.2
X$8249 3560 4031 15 27 3813 XNOR2_X2
* cell instance $8250 m0 *1 77.52,74.2
X$8250 3946 3945 3812 4030 27 15 4116 AND4_X2
* cell instance $8254 r0 *1 69.35,74.2
X$8254 3743 3745 3808 27 4286 15 OAI21_X1
* cell instance $8255 r0 *1 70.11,74.2
X$8255 3942 3943 27 15 4113 AND2_X1
* cell instance $8256 r0 *1 70.87,74.2
X$8256 4286 3864 4113 27 15 4310 OAI21_X2
* cell instance $8257 r0 *1 72.2,74.2
X$8257 4112 2780 4113 15 4034 27 AOI21_X2
* cell instance $8259 r0 *1 73.91,74.2
X$8259 15 4285 4187 4186 4550 4188 27 OAI211_X4
* cell instance $8261 r0 *1 77.33,74.2
X$8261 15 4190 4117 4032 4115 3594 27 NAND4_X4
* cell instance $8263 m0 *1 79.23,74.2
X$8263 3945 4032 4115 15 3948 27 AOI21_X2
* cell instance $8264 r0 *1 80.75,74.2
X$8264 15 4192 4118 4232 4035 3194 27 AOI22_X4
* cell instance $8265 m0 *1 81.13,74.2
X$8265 4033 4034 27 15 4192 AND2_X1
* cell instance $8267 m0 *1 81.89,74.2
X$8267 4034 4033 15 27 4081 NAND2_X1
* cell instance $8268 m0 *1 82.46,74.2
X$8268 4033 2438 15 27 4080 NOR2_X1
* cell instance $8269 m0 *1 83.03,74.2
X$8269 4080 4034 27 4194 15 XOR2_X2
* cell instance $8270 m0 *1 84.74,74.2
X$8270 4118 2438 4035 15 4195 27 AOI21_X1
* cell instance $8272 m0 *1 87.02,74.2
X$8272 4006 3816 15 4004 27 NAND2_X4
* cell instance $8273 m0 *1 88.73,74.2
X$8273 15 4197 4077 27 BUF_X16
* cell instance $8274 m0 *1 93.48,74.2
X$8274 4036 3949 3893 4119 27 15 4204 AND4_X1
* cell instance $8276 m0 *1 94.81,74.2
X$8276 4281 3869 4037 4120 3923 27 15 4038 OAI221_X1
* cell instance $8277 m0 *1 95.95,74.2
X$8277 3433 3202 3951 15 4120 27 AOI21_X1
* cell instance $8279 m0 *1 98.23,74.2
X$8279 3516 3342 3284 3784 27 15 4121 AND4_X1
* cell instance $8282 m0 *1 100.32,74.2
X$8282 3284 4000 15 27 4076 NOR2_X1
* cell instance $8284 m0 *1 106.97,74.2
X$8284 4039 3917 27 15 4123 AND2_X1
* cell instance $8285 m0 *1 107.73,74.2
X$8285 3917 4039 15 27 4206 NAND2_X1
* cell instance $8287 r0 *1 83.98,74.2
X$8287 4079 3194 4035 15 27 4235 MUX2_X1
* cell instance $8290 r0 *1 86.45,74.2
X$8290 4195 3816 4006 15 4196 27 AOI21_X1
* cell instance $8291 r0 *1 87.21,74.2
X$8291 4194 3893 4196 15 4200 27 AOI21_X2
* cell instance $8293 r0 *1 88.92,74.2
X$8293 4195 15 27 4233 INV_X1
* cell instance $8294 r0 *1 89.3,74.2
X$8294 4232 4077 3871 27 4202 15 NOR3_X2
* cell instance $8295 r0 *1 90.63,74.2
X$8295 15 4280 4200 3070 4202 27 AOI21_X4
* cell instance $8296 r0 *1 93.1,74.2
X$8296 3871 4077 4005 4235 27 4237 15 OR4_X2
* cell instance $8298 r0 *1 94.81,74.2
X$8298 4037 2742 3869 27 15 4575 OAI21_X4
* cell instance $8300 r0 *1 98.04,74.2
X$8300 4038 15 27 4315 CLKBUF_X3
* cell instance $8304 r0 *1 101.46,74.2
X$8304 3562 3070 3253 15 27 4238 NOR3_X1
* cell instance $8308 r0 *1 105.83,74.2
X$8308 4277 3917 15 27 4122 OR2_X1
* cell instance $8309 r0 *1 106.59,74.2
X$8309 3601 4122 4276 4241 3522 4123 15 27 4124 OAI33_X1
* cell instance $8312 m0 *1 108.68,74.2
X$8312 4040 2811 4206 27 4042 15 OAI21_X1
* cell instance $8313 m0 *1 110.01,74.2
X$8313 4074 3522 4072 3601 2132 3954 15 27 4205 OAI33_X1
* cell instance $8318 m0 *1 111.91,74.2
X$8318 3954 2132 3601 15 27 3956 NOR3_X1
* cell instance $8321 m0 *1 113.43,74.2
X$8321 4070 3824 4124 15 27 4125 NAND3_X2
* cell instance $8323 m0 *1 116.28,74.2
X$8323 4128 3957 4042 15 27 4203 OR3_X1
* cell instance $8325 r0 *1 112.1,74.2
X$8325 4205 27 4129 15 BUF_X4
* cell instance $8332 r0 *1 117.04,74.2
X$8332 4246 4125 4201 4126 4198 15 27 OAI211_X2
* cell instance $8333 m0 *1 117.99,74.2
X$8333 4274 4203 4201 4043 3855 27 15 AOI211_X2
* cell instance $8334 m0 *1 117.61,74.2
X$8334 4042 15 27 4126 INV_X1
* cell instance $8338 r0 *1 118.75,74.2
X$8338 4125 4201 4126 27 15 3443 OAI21_X2
* cell instance $8342 r0 *1 121.22,74.2
X$8342 4129 4043 4274 3134 3443 4247 27 15 AOI221_X2
* cell instance $8344 m0 *1 122.36,74.2
X$8344 3995 4198 4199 3994 3706 3960 27 15 AOI221_X2
* cell instance $8345 m0 *1 125.21,74.2
X$8345 4043 4044 27 15 3958 AND2_X1
* cell instance $8346 m0 *1 125.97,74.2
X$8346 15 3754 4045 4043 4044 27 AOI21_X4
* cell instance $8349 r0 *1 123.31,74.2
X$8349 4129 4128 15 27 4191 NAND2_X1
* cell instance $8350 r0 *1 123.88,74.2
X$8350 4128 4129 15 27 4193 OR2_X1
* cell instance $8351 r0 *1 124.64,74.2
X$8351 4191 4043 4193 15 3449 27 NAND3_X4
* cell instance $8353 r0 *1 127.3,74.2
X$8353 15 4327 4271 3226 4356 4189 27 AOI22_X4
* cell instance $8354 m0 *1 132.81,74.2
X$8354 4130 4046 15 27 3321 NAND2_X2
* cell instance $8355 m0 *1 130.34,74.2
X$8355 3826 4068 3960 15 3216 27 NAND3_X4
* cell instance $8357 m0 *1 134.52,74.2
X$8357 4047 3000 4048 15 3900 27 NAND3_X4
* cell instance $8358 m0 *1 136.99,74.2
X$8358 3449 3826 15 27 3962 NAND2_X1
* cell instance $8360 m0 *1 137.75,74.2
X$8360 4049 3961 4250 3959 3963 27 15 AOI211_X2
* cell instance $8361 m0 *1 139.46,74.2
X$8361 3826 3449 27 15 4050 AND2_X1
* cell instance $8365 m0 *1 142.69,74.2
X$8365 3900 4132 4133 15 3455 27 NAND3_X4
* cell instance $8366 m0 *1 145.16,74.2
X$8366 15 4133 3832 4134 3015 4177 27 OAI211_X4
* cell instance $8368 m0 *1 148.58,74.2
X$8368 4134 4177 15 27 3084 NOR2_X2
* cell instance $8371 m0 *1 150.48,74.2
X$8371 3969 4051 15 27 2888 XNOR2_X2
* cell instance $8374 m0 *1 154.09,74.2
X$8374 4527 4173 4174 27 15 4175 HA_X1
* cell instance $8375 m0 *1 155.99,74.2
X$8375 15 4172 4053 3982 4175 4052 27 FA_X1
* cell instance $8378 r0 *1 130.53,74.2
X$8378 3826 4249 4046 4130 27 15 4189 AND4_X1
* cell instance $8381 r0 *1 132.81,74.2
X$8381 4046 3826 3960 27 15 3755 AND3_X1
* cell instance $8383 r0 *1 134.52,74.2
X$8383 4249 3826 15 27 4131 NAND2_X1
* cell instance $8384 r0 *1 135.09,74.2
X$8384 15 3297 4408 4131 4047 3849 27 OAI211_X4
* cell instance $8386 r0 *1 138.51,74.2
X$8386 3756 3961 3849 4131 15 27 4252 AOI211_X4
* cell instance $8388 r0 *1 140.98,74.2
X$8388 15 4132 4049 4253 4134 27 NOR3_X4
* cell instance $8391 r0 *1 144.59,74.2
X$8391 4132 15 27 4182 INV_X1
* cell instance $8392 r0 *1 144.97,74.2
X$8392 15 4177 4182 4252 4408 27 AOI21_X4
* cell instance $8394 r0 *1 148.2,74.2
X$8394 4133 4134 4177 27 15 3902 OAI21_X2
* cell instance $8398 r0 *1 153.14,74.2
X$8398 4176 4136 4135 27 15 4173 HA_X1
* cell instance $8401 r0 *1 156.18,74.2
X$8401 15 4171 4172 4168 4174 4418 27 FA_X1
* cell instance $8403 r0 *1 159.6,74.2
X$8403 4688 15 27 4171 INV_X1
* cell instance $8405 m0 *1 161.12,74.2
X$8405 4717 4053 4137 27 15 4054 HA_X1
* cell instance $8407 m0 *1 163.02,74.2
X$8407 4062 4055 4054 4137 4057 4419 27 15 AOI221_X2
* cell instance $8408 m0 *1 165.11,74.2
X$8408 15 4265 4138 4063 4167 4056 27 FA_X1
* cell instance $8412 r0 *1 162.45,74.2
X$8412 15 4138 4170 3905 4266 4168 27 FA_X1
* cell instance $8414 r0 *1 165.87,74.2
X$8414 4521 15 27 4056 INV_X1
* cell instance $8416 m0 *1 168.72,74.2
X$8416 3977 3970 4143 4058 15 27 4139 NAND4_X1
* cell instance $8418 m0 *1 169.67,74.2
X$8418 4139 4161 15 27 4062 NOR2_X1
* cell instance $8423 r0 *1 169.86,74.2
X$8423 15 4333 4140 4160 4344 4162 27 FA_X1
* cell instance $8427 m0 *1 171.57,74.2
X$8427 4142 4145 3972 4137 15 27 4161 NAND4_X1
* cell instance $8431 m0 *1 177.08,74.2
X$8431 4264 15 27 4159 INV_X1
* cell instance $8432 m0 *1 177.46,74.2
X$8432 4157 4155 4058 27 15 4153 HA_X1
* cell instance $8433 m0 *1 179.36,74.2
X$8433 4153 4058 4152 15 4061 27 AOI21_X1
* cell instance $8435 m0 *1 181.64,74.2
X$8435 4145 15 27 4148 INV_X1
* cell instance $8436 m0 *1 182.02,74.2
X$8436 4148 4260 4151 27 4152 15 OAI21_X1
* cell instance $8438 r0 *1 172.9,74.2
X$8438 15 4141 4059 4157 4257 4160 27 FA_X1
* cell instance $8439 r0 *1 175.94,74.2
X$8439 15 4159 4141 4154 4341 4144 27 FA_X1
* cell instance $8440 r0 *1 178.98,74.2
X$8440 15 4262 4155 4149 4263 4154 27 FA_X1
* cell instance $8441 r0 *1 182.02,74.2
X$8441 4149 4338 4145 27 15 4146 HA_X1
* cell instance $8442 m0 *1 183.35,74.2
X$8442 4146 15 27 4151 INV_X1
* cell instance $8454 m0 *1 3.04,163.8
X$8454 9055 15 27 9034 BUF_X1
* cell instance $8456 m0 *1 5.13,163.8
X$8456 15 10362 9055 9056 8567 27 DFF_X1
* cell instance $8457 m0 *1 8.36,163.8
X$8457 6880 9035 9057 15 9056 27 AOI21_X1
* cell instance $8460 m0 *1 13.68,163.8
X$8460 7271 15 27 8732 BUF_X2
* cell instance $8461 m0 *1 14.44,163.8
X$8461 8404 8732 15 27 9057 NAND2_X1
* cell instance $8465 m0 *1 17.48,163.8
X$8465 8880 8570 15 9064 27 NAND2_X4
* cell instance $8478 r0 *1 13.11,163.8
X$8478 9171 8805 15 27 9134 NAND2_X1
* cell instance $8480 r0 *1 14.44,163.8
X$8480 8666 8732 15 27 9097 NAND2_X1
* cell instance $8482 r0 *1 15.2,163.8
X$8482 8570 8732 15 27 9036 NAND2_X1
* cell instance $8485 r0 *1 17.48,163.8
X$8485 8871 6133 9006 6134 9064 9202 15 27 OAI221_X2
* cell instance $8487 m0 *1 22.04,163.8
X$8487 15 10431 8400 9066 8873 27 DFF_X1
* cell instance $8489 m0 *1 25.27,163.8
X$8489 8400 8872 15 27 9067 NAND2_X1
* cell instance $8492 m0 *1 26.79,163.8
X$8492 6029 9070 9069 8968 6654 27 15 9100 OAI221_X1
* cell instance $8496 r0 *1 24.89,163.8
X$8496 8872 8733 15 27 9098 NAND2_X1
* cell instance $8497 r0 *1 25.46,163.8
X$8497 8624 8872 15 27 9099 NAND2_X1
* cell instance $8499 r0 *1 26.41,163.8
X$8499 15 10584 8305 9100 8873 27 DFF_X1
* cell instance $8500 m0 *1 28.5,163.8
X$8500 9101 8305 15 27 9069 NAND2_X1
* cell instance $8506 r0 *1 29.64,163.8
X$8506 6389 9070 9151 8968 6313 27 15 9210 OAI221_X1
* cell instance $8507 r0 *1 30.78,163.8
X$8507 9153 8551 15 27 9151 NAND2_X1
* cell instance $8510 m0 *1 34.96,163.8
X$8510 5689 8877 9037 8810 5690 27 15 9038 OAI221_X1
* cell instance $8514 m0 *1 42.37,163.8
X$8514 9101 7449 15 27 9023 NAND2_X1
* cell instance $8515 m0 *1 42.94,163.8
X$8515 15 9077 8789 10699 7449 27 DFF_X2
* cell instance $8517 m0 *1 47.31,163.8
X$8517 8789 15 27 10841 INV_X1
* cell instance $8521 r0 *1 35.34,163.8
X$8521 15 10569 8632 9038 8809 27 DFF_X1
* cell instance $8524 r0 *1 40.85,163.8
X$8524 8668 27 9101 15 BUF_X4
* cell instance $8528 r0 *1 44.27,163.8
X$8528 9101 8504 15 27 9102 NAND2_X1
* cell instance $8531 r0 *1 48.26,163.8
X$8531 8508 9103 15 9104 27 NAND2_X4
* cell instance $8533 m0 *1 48.83,163.8
X$8533 8506 9103 15 9079 27 NAND2_X4
* cell instance $8536 m0 *1 57.57,163.8
X$8536 15 10412 8278 8881 8388 27 DFF_X1
* cell instance $8539 m0 *1 64.6,163.8
X$8539 15 10396 8557 8883 8972 27 DFF_X1
* cell instance $8542 m0 *1 72.39,163.8
X$8542 15 7981 8008 27 BUF_X16
* cell instance $8546 r0 *1 53.2,163.8
X$8546 8316 8967 15 27 9105 NAND2_X1
* cell instance $8547 r0 *1 53.77,163.8
X$8547 8385 9103 15 9106 27 NAND2_X4
* cell instance $8548 r0 *1 55.48,163.8
X$8548 9109 8008 9107 15 27 8274 MUX2_X1
* cell instance $8549 r0 *1 56.81,163.8
X$8549 8967 9109 15 27 9108 NAND2_X1
* cell instance $8555 r0 *1 63.65,163.8
X$8555 9109 6117 9107 15 27 8284 MUX2_X1
* cell instance $8556 r0 *1 64.98,163.8
X$8556 15 6117 8207 27 BUF_X16
* cell instance $8557 r0 *1 69.73,163.8
X$8557 8969 15 27 8972 CLKBUF_X3
* cell instance $8558 r0 *1 70.68,163.8
X$8558 8972 15 27 10850 INV_X1
* cell instance $8562 r0 *1 72.39,163.8
X$8562 8877 15 27 9006 CLKBUF_X3
* cell instance $8565 m0 *1 78.47,163.8
X$8565 8877 15 27 8823 CLKBUF_X3
* cell instance $8566 m0 *1 77.52,163.8
X$8566 9039 6518 15 27 9086 NAND2_X2
* cell instance $8567 m0 *1 79.42,163.8
X$8567 7189 15 27 9039 INV_X4
* cell instance $8568 m0 *1 80.37,163.8
X$8568 8745 9039 15 27 9092 NAND2_X2
* cell instance $8569 m0 *1 81.32,163.8
X$8569 8885 9086 15 27 8951 NAND2_X1
* cell instance $8572 r0 *1 78.09,163.8
X$8572 8653 8817 15 9111 27 NAND2_X4
* cell instance $8573 r0 *1 79.8,163.8
X$8573 8020 8817 15 27 9219 NAND2_X2
* cell instance $8577 m0 *1 82.27,163.8
X$8577 15 10415 8729 9091 8674 27 DFF_X1
* cell instance $8578 m0 *1 87.02,163.8
X$8578 15 8819 27 9092 BUF_X8
* cell instance $8579 m0 *1 89.49,163.8
X$8579 8888 8211 15 9040 27 NAND2_X4
* cell instance $8581 m0 *1 91.39,163.8
X$8581 6607 8823 8819 6746 9114 9285 15 27 OAI221_X2
* cell instance $8582 m0 *1 93.48,163.8
X$8582 8821 8517 15 8959 27 NAND2_X4
* cell instance $8583 m0 *1 95.19,163.8
X$8583 6747 8890 8889 6826 9041 9176 15 27 OAI221_X2
* cell instance $8584 m0 *1 97.28,163.8
X$8584 15 10357 8519 9096 8892 27 DFF_X1
* cell instance $8585 m0 *1 100.51,163.8
X$8585 6515 8823 8819 6604 8891 9165 15 27 OAI221_X2
* cell instance $8590 r0 *1 83.6,163.8
X$8590 7868 8866 15 9167 27 NAND2_X4
* cell instance $8591 r0 *1 85.31,163.8
X$8591 8515 8866 15 9113 27 NAND2_X4
* cell instance $8594 r0 *1 89.3,163.8
X$8594 6607 8890 8889 6746 9040 9166 15 27 OAI221_X2
* cell instance $8595 r0 *1 91.39,163.8
X$8595 15 8887 8824 27 BUF_X16
* cell instance $8597 r0 *1 96.33,163.8
X$8597 15 10508 8561 9042 9177 27 DFF_X1
* cell instance $8598 r0 *1 99.56,163.8
X$8598 15 10504 8648 9165 8892 27 DFF_X1
* cell instance $8599 r0 *1 102.79,163.8
X$8599 15 10507 8649 9164 8892 27 DFF_X1
* cell instance $8600 m0 *1 106.97,163.8
X$8600 8892 15 27 CLKBUF_X1
* cell instance $8601 m0 *1 103.74,163.8
X$8601 15 10321 8415 9095 8892 27 DFF_X1
* cell instance $8603 m0 *1 107.73,163.8
X$8603 6222 8890 8889 6658 9093 9043 15 27 OAI221_X2
* cell instance $8604 m0 *1 109.82,163.8
X$8604 6636 8890 8889 6764 9030 9162 15 27 OAI221_X2
* cell instance $8605 m0 *1 111.91,163.8
X$8605 8677 8330 15 27 8867 NAND2_X2
* cell instance $8607 m0 *1 113.05,163.8
X$8607 6636 8823 8819 6764 9089 9090 15 27 OAI221_X2
* cell instance $8609 m0 *1 116.66,163.8
X$8609 15 9087 8978 10718 8418 27 DFF_X2
* cell instance $8610 m0 *1 120.27,163.8
X$8610 8280 15 27 8978 CLKBUF_X3
* cell instance $8611 m0 *1 121.22,163.8
X$8611 8978 15 27 CLKBUF_X1
* cell instance $8612 m0 *1 121.79,163.8
X$8612 5704 15 27 8228 CLKBUF_X3
* cell instance $8613 m0 *1 122.74,163.8
X$8613 5192 15 27 8896 CLKBUF_X3
* cell instance $8616 m0 *1 124.64,163.8
X$8616 8228 9085 9045 15 9044 27 AOI21_X1
* cell instance $8618 m0 *1 126.92,163.8
X$8618 9116 8896 15 27 9085 NAND2_X1
* cell instance $8619 m0 *1 127.49,163.8
X$8619 8228 9084 8979 15 9117 27 AOI21_X1
* cell instance $8621 r0 *1 106.02,163.8
X$8621 8752 15 27 8892 CLKBUF_X3
* cell instance $8623 r0 *1 107.16,163.8
X$8623 8477 8888 15 9093 27 NAND2_X4
* cell instance $8624 r0 *1 108.87,163.8
X$8624 15 9162 8754 10815 8680 27 DFF_X2
* cell instance $8627 r0 *1 113.43,163.8
X$8627 8418 8824 15 8977 27 NAND2_X4
* cell instance $8631 r0 *1 115.14,163.8
X$8631 15 10502 8681 9090 8978 27 DFF_X1
* cell instance $8632 r0 *1 118.37,163.8
X$8632 5354 15 27 8280 CLKBUF_X3
* cell instance $8638 r0 *1 122.17,163.8
X$8638 8228 9161 9115 15 9217 27 AOI21_X1
* cell instance $8639 r0 *1 122.93,163.8
X$8639 9178 8896 15 27 9161 NAND2_X1
* cell instance $8642 r0 *1 124.07,163.8
X$8642 15 10555 9116 9044 8978 27 DFF_X1
* cell instance $8643 r0 *1 127.3,163.8
X$8643 15 10563 9083 9117 9234 27 DFF_X1
* cell instance $8644 m0 *1 128.82,163.8
X$8644 9083 8896 15 27 9084 NAND2_X1
* cell instance $8647 m0 *1 130.91,163.8
X$8647 8228 9082 9024 15 9159 27 AOI21_X1
* cell instance $8650 r0 *1 130.53,163.8
X$8650 15 10568 9118 9159 9179 27 DFF_X1
* cell instance $8652 m0 *1 132.81,163.8
X$8652 9118 8896 15 27 9082 NAND2_X1
* cell instance $8653 m0 *1 134.14,163.8
X$8653 9120 9157 9081 15 9158 27 AOI21_X1
* cell instance $8658 r0 *1 133.76,163.8
X$8658 15 10562 9119 9158 9179 27 DFF_X1
* cell instance $8659 r0 *1 136.99,163.8
X$8659 9120 9211 8860 15 9182 27 AOI21_X1
* cell instance $8662 r0 *1 140.03,163.8
X$8662 9120 9155 8940 15 9154 27 AOI21_X1
* cell instance $8664 m0 *1 140.6,163.8
X$8664 9022 8899 15 27 9080 NAND2_X1
* cell instance $8667 r0 *1 140.79,163.8
X$8667 9121 8899 15 27 9155 NAND2_X1
* cell instance $8669 r0 *1 141.55,163.8
X$8669 15 10586 9121 9154 8827 27 DFF_X1
* cell instance $8672 m0 *1 145.35,163.8
X$8672 15 9046 9187 9047 8900 8830 27 FA_X1
* cell instance $8673 m0 *1 148.58,163.8
X$8673 15 8932 9075 9243 9078 8133 27 FA_X1
* cell instance $8677 m0 *1 155.61,163.8
X$8677 15 9018 9207 9189 9076 8832 27 FA_X1
* cell instance $8678 m0 *1 158.65,163.8
X$8678 15 8903 9125 9073 8986 8596 27 FA_X1
* cell instance $8679 m0 *1 161.69,163.8
X$8679 15 8597 9074 9050 8133 8761 27 FA_X1
* cell instance $8680 m0 *1 164.73,163.8
X$8680 8761 8133 9049 27 15 9145 HA_X1
* cell instance $8683 m0 *1 167.58,163.8
X$8683 15 7708 9072 9144 7490 8128 27 FA_X1
* cell instance $8684 m0 *1 170.62,163.8
X$8684 9072 15 27 8700 INV_X1
* cell instance $8686 m0 *1 171.76,163.8
X$8686 15 9065 9063 9051 7897 8919 27 FA_X1
* cell instance $8690 r0 *1 148.01,163.8
X$8690 9047 15 27 9122 INV_X1
* cell instance $8693 r0 *1 149.53,163.8
X$8693 15 8901 9123 9124 9152 8829 27 FA_X1
* cell instance $8696 r0 *1 156.37,163.8
X$8696 8257 15 27 8597 INV_X2
* cell instance $8700 r0 *1 161.69,163.8
X$8700 9126 15 27 9150 INV_X1
* cell instance $8702 r0 *1 162.26,163.8
X$8702 15 9127 9206 9146 9073 9147 27 FA_X1
* cell instance $8703 r0 *1 165.3,163.8
X$8703 9050 15 27 9127 INV_X1
* cell instance $8704 r0 *1 165.68,163.8
X$8704 9145 15 27 9147 INV_X1
* cell instance $8706 r0 *1 169.1,163.8
X$8706 8128 15 27 7686 INV_X2
* cell instance $8708 r0 *1 170.43,163.8
X$8708 9144 15 27 9200 INV_X2
* cell instance $8709 r0 *1 171,163.8
X$8709 9142 15 27 9065 INV_X1
* cell instance $8714 r0 *1 171.57,163.8
X$8714 8989 8700 9191 27 15 9141 HA_X1
* cell instance $8715 r0 *1 173.47,163.8
X$8715 9141 15 27 9140 INV_X1
* cell instance $8718 r0 *1 174.8,163.8
X$8718 9051 15 27 9139 INV_X1
* cell instance $8720 m0 *1 176.89,163.8
X$8720 9063 15 27 9062 INV_X1
* cell instance $8725 m0 *1 178.6,163.8
X$8725 9061 9062 9137 27 15 9059 HA_X1
* cell instance $8729 r0 *1 178.6,163.8
X$8729 9137 15 27 9198 INV_X1
* cell instance $8730 r0 *1 178.98,163.8
X$8730 8596 9136 9129 27 15 9131 HA_X1
* cell instance $8731 r0 *1 180.88,163.8
X$8731 8991 9135 9136 27 15 9133 HA_X1
* cell instance $8733 m0 *1 182.4,163.8
X$8733 15 8992 9000 9058 9059 9053 27 FA_X1
* cell instance $8734 m0 *1 185.63,163.8
X$8734 9058 15 27 9130 INV_X1
* cell instance $8739 r0 *1 183.16,163.8
X$8739 9133 15 27 9053 INV_X1
* cell instance $8741 r0 *1 184.3,163.8
X$8741 15 9131 8994 9193 9130 9132 27 FA_X1
* cell instance $8750 r0 *1 1.52,161
X$8750 15 10478 8870 8993 8567 27 DFF_X1
* cell instance $8754 m0 *1 4.18,161
X$8754 8870 15 27 8912 BUF_X1
* cell instance $8757 m0 *1 6.27,161
X$8757 8837 8805 15 27 8913 NAND2_X1
* cell instance $8762 r0 *1 5.13,161
X$8762 8870 8805 15 27 8965 NAND2_X1
* cell instance $8763 r0 *1 5.7,161
X$8763 6880 8965 8966 15 8993 27 AOI21_X1
* cell instance $8765 r0 *1 6.65,161
X$8765 8995 15 27 8964 BUF_X1
* cell instance $8767 r0 *1 7.98,161
X$8767 9055 8805 15 27 9035 NAND2_X1
* cell instance $8769 r0 *1 9.31,161
X$8769 15 10479 8995 8997 8916 27 DFF_X1
* cell instance $8770 m0 *1 11.21,161
X$8770 7309 15 27 6880 CLKBUF_X3
* cell instance $8772 m0 *1 12.16,161
X$8772 8995 8805 15 27 8998 NAND2_X1
* cell instance $8774 m0 *1 13.49,161
X$8774 8572 8732 15 27 8966 NAND2_X1
* cell instance $8776 m0 *1 15.58,161
X$8776 8572 8880 15 9004 27 NAND2_X4
* cell instance $8777 m0 *1 17.29,161
X$8777 8871 6654 9006 6029 9009 8920 15 27 OAI221_X2
* cell instance $8778 m0 *1 19.38,161
X$8778 15 10416 8401 8920 8501 27 DFF_X1
* cell instance $8781 m0 *1 28.88,161
X$8781 8705 8872 15 27 9011 NAND2_X1
* cell instance $8782 m0 *1 29.45,161
X$8782 15 10365 8577 9015 8873 27 DFF_X1
* cell instance $8783 m0 *1 32.68,161
X$8783 8665 8967 15 27 8875 NAND2_X1
* cell instance $8786 m0 *1 34.96,161
X$8786 5791 8877 8876 8810 5793 27 15 9019 OAI221_X1
* cell instance $8787 m0 *1 36.1,161
X$8787 5697 8877 8929 8810 5694 27 15 8878 OAI221_X1
* cell instance $8788 m0 *1 37.24,161
X$8788 7525 15 27 8809 CLKBUF_X3
* cell instance $8789 m0 *1 38.19,161
X$8789 8635 8879 15 27 8929 NAND2_X1
* cell instance $8791 r0 *1 12.54,161
X$8791 6880 8998 8999 15 8997 27 AOI21_X1
* cell instance $8794 r0 *1 13.87,161
X$8794 7551 8732 15 27 8999 NAND2_X1
* cell instance $8797 r0 *1 16.15,161
X$8797 8871 6313 9006 6389 9004 9060 15 27 OAI221_X2
* cell instance $8798 r0 *1 18.24,161
X$8798 8401 8880 15 9009 27 NAND2_X4
* cell instance $8803 r0 *1 24.32,161
X$8803 6029 8975 9067 8874 6654 27 15 9066 OAI221_X1
* cell instance $8804 r0 *1 25.46,161
X$8804 6389 8975 9011 8874 6313 27 15 9068 OAI221_X1
* cell instance $8805 r0 *1 26.6,161
X$8805 15 10588 8705 9068 8873 27 DFF_X1
* cell instance $8807 r0 *1 30.21,161
X$8807 5697 8814 9017 8874 5694 27 15 9015 OAI221_X1
* cell instance $8808 r0 *1 31.35,161
X$8808 8577 8967 15 27 9017 NAND2_X1
* cell instance $8810 r0 *1 32.11,161
X$8810 15 10581 8666 9019 8809 27 DFF_X1
* cell instance $8811 r0 *1 35.34,161
X$8811 8632 8879 15 27 9037 NAND2_X1
* cell instance $8814 r0 *1 36.48,161
X$8814 8809 15 27 10826 INV_X2
* cell instance $8817 r0 *1 38.76,161
X$8817 15 8879 8880 27 BUF_X16
* cell instance $8818 m0 *1 39.33,161
X$8818 7546 8880 15 8930 27 NAND2_X4
* cell instance $8820 m0 *1 41.04,161
X$8820 15 8931 8789 10700 7546 27 DFF_X2
* cell instance $8822 m0 *1 45.41,161
X$8822 8667 27 8968 15 BUF_X4
* cell instance $8824 r0 *1 43.51,161
X$8824 5860 8736 9023 8968 5859 27 15 9077 OAI221_X1
* cell instance $8826 r0 *1 46.17,161
X$8826 8969 15 27 8789 CLKBUF_X3
* cell instance $8827 m0 *1 49.21,161
X$8827 8669 8935 6961 15 27 8872 AND3_X4
* cell instance $8828 m0 *1 47.12,161
X$8828 8871 6193 8877 6623 9079 8970 15 27 OAI221_X2
* cell instance $8830 m0 *1 51.49,161
X$8830 8669 8935 6961 15 27 8967 AND3_X4
* cell instance $8832 m0 *1 53.77,161
X$8832 8810 27 8871 15 BUF_X4
* cell instance $8834 r0 *1 47.12,161
X$8834 15 10624 8506 8970 8789 27 DFF_X1
* cell instance $8837 r0 *1 51.3,161
X$8837 15 8879 9103 27 BUF_X16
* cell instance $8838 m0 *1 55.67,161
X$8838 6398 8871 8936 27 9026 15 OAI21_X1
* cell instance $8842 r0 *1 56.05,161
X$8842 15 10477 8203 9026 8388 27 DFF_X1
* cell instance $8844 m0 *1 57.57,161
X$8844 8669 8938 15 8874 27 NAND2_X4
* cell instance $8845 m0 *1 60.04,161
X$8845 8741 8942 15 27 8810 NAND2_X2
* cell instance $8846 m0 *1 60.99,161
X$8846 6961 8741 7169 15 27 8879 AND3_X4
* cell instance $8847 m0 *1 63.08,161
X$8847 6380 8669 8882 15 27 8971 MUX2_X1
* cell instance $8848 m0 *1 64.41,161
X$8848 7169 7551 6889 15 27 8946 NAND3_X1
* cell instance $8849 m0 *1 65.17,161
X$8849 8946 8945 15 27 9027 NAND2_X1
* cell instance $8859 r0 *1 62.51,161
X$8859 6380 8741 9027 15 27 9028 MUX2_X1
* cell instance $8860 r0 *1 63.84,161
X$8860 15 9028 8972 10784 7551 27 DFF_X2
* cell instance $8864 r0 *1 70.11,161
X$8864 15 8092 7981 27 BUF_X16
* cell instance $8865 m0 *1 73.91,161
X$8865 15 10364 8095 8884 8972 27 DFF_X1
* cell instance $8866 m0 *1 71.44,161
X$8866 15 7275 27 8092 BUF_X8
* cell instance $8867 m0 *1 77.14,161
X$8867 6473 8745 8951 15 27 9029 MUX2_X1
* cell instance $8869 m0 *1 78.66,161
X$8869 8815 6961 7530 15 27 8886 AND3_X4
* cell instance $8870 m0 *1 80.75,161
X$8870 7189 6961 8745 15 27 8887 AND3_X4
* cell instance $8874 r0 *1 75.24,161
X$8874 15 9029 8674 10798 7936 27 DFF_X2
* cell instance $8875 r0 *1 78.85,161
X$8875 8815 8863 15 8974 27 NAND2_X4
* cell instance $8877 r0 *1 81.32,161
X$8877 8800 8801 15 27 8973 NAND2_X2
* cell instance $8879 r0 *1 83.03,161
X$8879 15 9112 27 8886 BUF_X8
* cell instance $8880 m0 *1 85.69,161
X$8880 15 8888 27 8886 BUF_X8
* cell instance $8881 m0 *1 84.74,161
X$8881 8729 8886 15 27 9032 NAND2_X2
* cell instance $8884 m0 *1 89.11,161
X$8884 15 8887 8821 27 BUF_X16
* cell instance $8886 m0 *1 95.38,161
X$8886 6296 8890 8889 6553 8960 9286 15 27 OAI221_X2
* cell instance $8887 m0 *1 97.47,161
X$8887 5925 8890 8889 6013 8961 9042 15 27 OAI221_X2
* cell instance $8888 m0 *1 99.56,161
X$8888 8561 8888 15 8961 27 NAND2_X4
* cell instance $8890 r0 *1 85.5,161
X$8890 6689 8974 9032 5921 8975 27 15 9091 OAI221_X1
* cell instance $8892 r0 *1 87.4,161
X$8892 15 8889 27 8974 BUF_X8
* cell instance $8894 r0 *1 90.25,161
X$8894 15 10579 8517 9033 8288 27 DFF_X1
* cell instance $8896 r0 *1 94.24,161
X$8896 6747 8823 8819 6826 8976 9094 15 27 OAI221_X2
* cell instance $8897 r0 *1 96.33,161
X$8897 8893 8301 15 9041 27 NAND2_X4
* cell instance $8898 r0 *1 98.04,161
X$8898 8821 8519 15 8820 27 NAND2_X4
* cell instance $8902 r0 *1 101.08,161
X$8902 15 8886 8893 27 BUF_X16
* cell instance $8903 m0 *1 101.84,161
X$8903 15 10355 8327 8963 8892 27 DFF_X1
* cell instance $8905 m0 *1 105.07,161
X$8905 6560 8823 8819 6566 8962 8963 15 27 OAI221_X2
* cell instance $8906 m0 *1 107.16,161
X$8906 8415 8893 15 8868 27 NAND2_X4
* cell instance $8909 r0 *1 106.02,161
X$8909 15 10488 8589 8957 8892 27 DFF_X1
* cell instance $8911 m0 *1 110.96,161
X$8911 6789 8890 8889 6637 8894 9031 15 27 OAI221_X2
* cell instance $8912 m0 *1 109.25,161
X$8912 8680 8893 15 9030 27 NAND2_X4
* cell instance $8913 m0 *1 113.05,161
X$8913 6638 8889 8958 6605 8890 27 15 8957 OAI221_X1
* cell instance $8914 m0 *1 114.19,161
X$8914 15 8955 8978 10646 8332 27 DFF_X2
* cell instance $8916 m0 *1 118.56,161
X$8916 15 8953 8978 10689 7945 27 DFF_X2
* cell instance $8917 m0 *1 122.17,161
X$8917 7773 8755 15 8952 27 NAND2_X4
* cell instance $8918 m0 *1 123.88,161
X$8918 7778 8755 15 8756 27 NAND2_X4
* cell instance $8919 m0 *1 125.59,161
X$8919 7553 8422 15 27 9215 NAND2_X1
* cell instance $8920 m0 *1 126.16,161
X$8920 7122 8422 15 27 8979 NAND2_X1
* cell instance $8925 r0 *1 109.82,161
X$8925 15 10480 8386 9031 8754 27 DFF_X1
* cell instance $8926 r0 *1 113.05,161
X$8926 6222 8823 8819 6658 8977 9087 15 27 OAI221_X2
* cell instance $8930 r0 *1 115.14,161
X$8930 6605 8823 8819 6638 8895 9088 15 27 OAI221_X2
* cell instance $8932 r0 *1 117.42,161
X$8932 15 9088 8978 10772 8590 27 DFF_X2
* cell instance $8936 r0 *1 122.17,161
X$8936 7057 8422 15 27 9115 NAND2_X1
* cell instance $8937 r0 *1 122.74,161
X$8937 6894 8422 15 27 9024 NAND2_X1
* cell instance $8939 r0 *1 123.5,161
X$8939 8031 8422 15 27 9025 NAND2_X1
* cell instance $8941 r0 *1 124.26,161
X$8941 7254 8422 15 27 9045 NAND2_X1
* cell instance $8944 m0 *1 131.86,161
X$8944 15 10305 8980 8862 8266 27 DFF_X1
* cell instance $8949 m0 *1 137.56,161
X$8949 8060 8943 8858 15 8981 27 AOI21_X1
* cell instance $8951 m0 *1 138.51,161
X$8951 8982 8899 15 27 8943 NAND2_X1
* cell instance $8953 r0 *1 136.99,161
X$8953 15 10560 8982 8981 9179 27 DFF_X1
* cell instance $8954 m0 *1 139.65,161
X$8954 8984 8899 15 27 8937 NAND2_X1
* cell instance $8956 m0 *1 140.22,161
X$8956 8060 9080 8898 15 8983 27 AOI21_X1
* cell instance $8957 m0 *1 140.98,161
X$8957 8280 15 27 8827 CLKBUF_X3
* cell instance $8958 m0 *1 141.93,161
X$8958 15 10374 8984 8934 8827 27 DFF_X1
* cell instance $8961 m0 *1 146.11,161
X$8961 8933 8759 9020 27 15 8985 HA_X1
* cell instance $8965 m0 *1 155.04,161
X$8965 8830 15 27 8133 INV_X4
* cell instance $8966 m0 *1 155.99,161
X$8966 15 8928 8923 8927 8902 7900 27 FA_X1
* cell instance $8968 r0 *1 140.22,161
X$8968 15 10523 9022 8983 8827 27 DFF_X1
* cell instance $8972 r0 *1 147.63,161
X$8972 9021 7418 15 27 9046 NAND2_X1
* cell instance $8975 r0 *1 149.91,161
X$8975 9021 7399 15 27 9152 NAND2_X1
* cell instance $8978 r0 *1 151.62,161
X$8978 8831 7399 15 27 8986 NAND2_X1
* cell instance $8980 r0 *1 152.38,161
X$8980 8831 7418 15 27 9018 NAND2_X1
* cell instance $8983 m0 *1 159.79,161
X$8983 15 8597 8833 8988 8684 8761 27 FA_X1
* cell instance $8984 m0 *1 159.41,161
X$8984 8927 15 27 8987 INV_X1
* cell instance $8985 m0 *1 162.83,161
X$8985 8904 15 27 9013 INV_X1
* cell instance $8987 m0 *1 163.97,161
X$8987 8923 15 27 9012 INV_X1
* cell instance $8990 r0 *1 159.79,161
X$8990 15 9074 9016 9126 8987 8988 27 FA_X1
* cell instance $8991 r0 *1 162.83,161
X$8991 9016 15 27 9014 INV_X1
* cell instance $8994 r0 *1 164.92,161
X$8994 15 9014 9048 9071 9012 9013 27 FA_X1
* cell instance $8997 m0 *1 170.81,161
X$8997 8921 15 27 8918 INV_X1
* cell instance $8999 m0 *1 172.14,161
X$8999 7478 7490 8989 27 15 10913 HA_X1
* cell instance $9001 m0 *1 175.56,161
X$9001 9007 8918 9002 27 15 9005 HA_X1
* cell instance $9002 m0 *1 177.46,161
X$9002 15 9003 8907 9052 9005 8692 27 FA_X1
* cell instance $9004 m0 *1 180.69,161
X$9004 15 8910 9003 8909 9002 8908 27 FA_X1
* cell instance $9005 m0 *1 183.73,161
X$9005 8911 15 27 8910 INV_X1
* cell instance $9008 r0 *1 171,161
X$9008 9071 15 27 9010 INV_X1
* cell instance $9013 r0 *1 172.9,161
X$9013 9010 8905 9001 27 15 9008 HA_X1
* cell instance $9017 r0 *1 177.27,161
X$9017 15 8915 9007 8990 9008 9000 27 FA_X1
* cell instance $9019 r0 *1 180.5,161
X$9019 8990 15 27 8996 INV_X1
* cell instance $9022 r0 *1 181.45,161
X$9022 8694 15 27 9061 INV_X1
* cell instance $9026 r0 *1 183.92,161
X$9026 15 8994 8911 9054 8996 8766 27 FA_X1
* cell instance $9033 m0 *1 2.85,60.2
X$9033 3307 2109 3109 15 27 3345 MUX2_X1
* cell instance $9036 m0 *1 6.46,60.2
X$9036 3148 15 27 3262 BUF_X2
* cell instance $9037 m0 *1 7.22,60.2
X$9037 3229 3310 2852 27 15 3263 MUX2_X2
* cell instance $9039 m0 *1 9.12,60.2
X$9039 15 3461 3172 3173 2851 27 AOI21_X4
* cell instance $9040 m0 *1 11.59,60.2
X$9040 3114 2163 15 27 3310 NOR2_X1
* cell instance $9041 m0 *1 12.16,60.2
X$9041 3090 3152 1499 3114 27 15 3311 OAI22_X1
* cell instance $9043 m0 *1 13.3,60.2
X$9043 3312 3311 2852 27 15 3172 MUX2_X2
* cell instance $9045 m0 *1 15.2,60.2
X$9045 3116 3175 3090 15 27 NOR2_X4
* cell instance $9047 m0 *1 17.1,60.2
X$9047 2929 3176 27 3175 15 AND2_X4
* cell instance $9048 m0 *1 18.81,60.2
X$9048 3176 2929 27 3265 15 XOR2_X2
* cell instance $9057 r0 *1 3.04,60.2
X$9057 3109 2109 2755 27 3344 15 OAI21_X1
* cell instance $9058 r0 *1 3.8,60.2
X$9058 3345 3261 2109 3109 2755 3382 15 27 OAI221_X2
* cell instance $9060 r0 *1 6.65,60.2
X$9060 3262 3346 3050 2849 15 3261 27 NAND4_X2
* cell instance $9061 r0 *1 8.36,60.2
X$9061 3051 3111 3050 27 3264 15 NOR3_X2
* cell instance $9062 r0 *1 9.69,60.2
X$9062 15 3462 2854 3013 3174 27 AOI21_X4
* cell instance $9065 r0 *1 14.44,60.2
X$9065 2163 15 27 3347 CLKBUF_X3
* cell instance $9068 r0 *1 16.53,60.2
X$9068 388 3348 3233 27 15 3116 HA_X1
* cell instance $9069 r0 *1 18.43,60.2
X$9069 2929 3176 15 27 3387 XNOR2_X2
* cell instance $9073 m0 *1 22.8,60.2
X$9073 3314 3316 3177 27 15 3176 OAI21_X4
* cell instance $9074 m0 *1 22.42,60.2
X$9074 3235 15 27 3314 INV_X1
* cell instance $9075 m0 *1 25.27,60.2
X$9075 3315 15 27 2976 BUF_X1
* cell instance $9076 m0 *1 25.84,60.2
X$9076 2966 3177 27 15 3266 XNOR2_X1
* cell instance $9077 m0 *1 26.98,60.2
X$9077 15 3177 3237 3178 2976 27 AOI21_X4
* cell instance $9078 m0 *1 29.45,60.2
X$9078 2976 3178 15 27 3267 XOR2_X1
* cell instance $9082 r0 *1 22.42,60.2
X$9082 3388 15 27 3348 INV_X2
* cell instance $9085 r0 *1 24.13,60.2
X$9085 2966 15 27 3316 INV_X1
* cell instance $9090 r0 *1 28.88,60.2
X$9090 2497 2858 3267 15 27 3351 MUX2_X1
* cell instance $9095 r0 *1 33.06,60.2
X$9095 3268 3180 3181 15 3352 27 AOI21_X1
* cell instance $9096 m0 *1 35.15,60.2
X$9096 3317 3181 27 15 3270 XNOR2_X1
* cell instance $9097 m0 *1 33.25,60.2
X$9097 195 3179 3180 27 15 3268 HA_X1
* cell instance $9098 m0 *1 36.29,60.2
X$9098 3179 3270 2629 27 15 3182 MUX2_X2
* cell instance $9103 m0 *1 51.87,60.2
X$9103 3186 3184 3274 15 27 NOR2_X4
* cell instance $9105 m0 *1 54.34,60.2
X$9105 15 3245 3183 3275 3171 3185 27 NOR4_X4
* cell instance $9106 m0 *1 57.76,60.2
X$9106 2937 3245 3183 27 15 3126 OAI21_X2
* cell instance $9107 m0 *1 59.09,60.2
X$9107 3030 3275 2937 15 3187 27 AOI21_X2
* cell instance $9111 r0 *1 33.82,60.2
X$9111 3268 3180 3238 15 3412 27 AOI21_X2
* cell instance $9112 r0 *1 35.15,60.2
X$9112 3180 15 27 3317 INV_X1
* cell instance $9114 r0 *1 36.29,60.2
X$9114 15 3356 3317 2933 550 3413 27 OR4_X4
* cell instance $9115 r0 *1 38.76,60.2
X$9115 295 3182 3271 27 15 3357 HA_X1
* cell instance $9117 r0 *1 41.04,60.2
X$9117 3271 15 27 3394 INV_X1
* cell instance $9118 r0 *1 41.42,60.2
X$9118 3394 3272 27 15 3358 XNOR2_X1
* cell instance $9122 r0 *1 46.17,60.2
X$9122 3359 3035 27 15 3273 AND2_X2
* cell instance $9124 r0 *1 47.5,60.2
X$9124 3324 15 27 3359 INV_X2
* cell instance $9126 r0 *1 48.83,60.2
X$9126 2594 15 27 3471 INV_X1
* cell instance $9127 r0 *1 49.21,60.2
X$9127 388 3360 2594 27 15 3324 HA_X1
* cell instance $9135 r0 *1 59.66,60.2
X$9135 3276 3474 27 3277 15 XOR2_X2
* cell instance $9137 r0 *1 61.56,60.2
X$9137 3188 15 27 3362 CLKBUF_X3
* cell instance $9139 m0 *1 64.22,60.2
X$9139 2512 3041 3278 3188 15 27 3423 NAND4_X1
* cell instance $9140 m0 *1 63.08,60.2
X$9140 3188 3278 2805 3189 15 27 3590 OR4_X1
* cell instance $9141 m0 *1 65.17,60.2
X$9141 2512 3041 15 27 3564 NAND2_X1
* cell instance $9147 r0 *1 66.88,60.2
X$9147 3477 3326 15 3425 27 OR2_X4
* cell instance $9148 m0 *1 67.83,60.2
X$9148 3190 2938 27 3326 15 AND2_X4
* cell instance $9151 m0 *1 70.3,60.2
X$9151 3190 2938 27 3279 15 XOR2_X2
* cell instance $9153 m0 *1 72.2,60.2
X$9153 3327 15 27 2988 BUF_X2
* cell instance $9154 m0 *1 72.96,60.2
X$9154 388 3191 3327 27 15 3193 HA_X1
* cell instance $9156 m0 *1 75.05,60.2
X$9156 3255 2988 15 27 3428 NAND2_X1
* cell instance $9158 m0 *1 75.81,60.2
X$9158 3329 3328 15 27 3331 NAND2_X1
* cell instance $9159 m0 *1 76.38,60.2
X$9159 3193 15 27 3328 INV_X1
* cell instance $9160 m0 *1 76.76,60.2
X$9160 3193 3192 3061 15 27 3332 OR3_X1
* cell instance $9161 m0 *1 77.71,60.2
X$9161 3061 2736 3062 27 3364 15 OAI21_X1
* cell instance $9162 m0 *1 78.47,60.2
X$9162 3061 2736 15 27 3280 NOR2_X1
* cell instance $9163 m0 *1 79.04,60.2
X$9163 2736 3332 3331 27 3259 15 OAI21_X1
* cell instance $9164 m0 *1 79.8,60.2
X$9164 3258 2988 27 3335 15 XOR2_X2
* cell instance $9166 r0 *1 68.59,60.2
X$9166 3398 15 27 2938 CLKBUF_X2
* cell instance $9167 r0 *1 69.35,60.2
X$9167 2938 3190 15 27 3478 XNOR2_X2
* cell instance $9172 r0 *1 74.1,60.2
X$9172 3128 3328 15 3426 27 NAND2_X4
* cell instance $9174 r0 *1 76,60.2
X$9174 2988 3193 3362 27 3482 15 OAI21_X1
* cell instance $9175 r0 *1 76.76,60.2
X$9175 3192 3193 244 15 27 3363 NOR3_X1
* cell instance $9177 r0 *1 77.71,60.2
X$9177 3062 3280 15 27 3333 XNOR2_X2
* cell instance $9178 r0 *1 79.61,60.2
X$9178 2988 3258 15 27 3365 XNOR2_X2
* cell instance $9179 r0 *1 81.51,60.2
X$9179 15 3431 3335 2990 2942 27 AOI21_X4
* cell instance $9181 m0 *1 81.89,60.2
X$9181 2942 2990 15 27 3281 NAND2_X2
* cell instance $9185 r0 *1 85.12,60.2
X$9185 3366 3484 3337 15 3338 27 AOI21_X1
* cell instance $9187 r0 *1 86.07,60.2
X$9187 2517 3282 3283 3397 3368 3367 27 15 AOI221_X2
* cell instance $9189 m0 *1 86.26,60.2
X$9189 3065 3195 3196 3338 27 15 3339 OAI22_X2
* cell instance $9191 m0 *1 89.68,60.2
X$9191 15 3596 3198 3260 2991 27 AOI21_X4
* cell instance $9192 m0 *1 92.15,60.2
X$9192 3257 2992 27 15 3199 AND2_X1
* cell instance $9193 m0 *1 92.91,60.2
X$9193 3198 15 27 3257 INV_X1
* cell instance $9195 m0 *1 93.48,60.2
X$9195 3200 3341 15 27 3433 NAND2_X2
* cell instance $9198 m0 *1 96.14,60.2
X$9198 3342 3202 15 2919 27 NAND2_X4
* cell instance $9199 m0 *1 97.85,60.2
X$9199 3254 3342 3202 15 27 2923 NAND3_X2
* cell instance $9201 m0 *1 100.7,60.2
X$9201 3250 3071 3343 15 27 NOR2_X4
* cell instance $9202 m0 *1 102.41,60.2
X$9202 3251 3205 3250 15 27 NOR2_X4
* cell instance $9204 m0 *1 104.31,60.2
X$9204 3204 3205 15 27 3286 XNOR2_X2
* cell instance $9213 r0 *1 91.01,60.2
X$9213 388 3370 3131 27 15 3198 HA_X1
* cell instance $9214 r0 *1 92.91,60.2
X$9214 3197 15 27 3374 CLKBUF_X3
* cell instance $9217 r0 *1 94.43,60.2
X$9217 3284 15 27 3370 INV_X1
* cell instance $9220 r0 *1 98.04,60.2
X$9220 3370 300 15 27 3371 NOR2_X1
* cell instance $9221 r0 *1 98.61,60.2
X$9221 3284 3373 15 27 3479 NOR2_X1
* cell instance $9224 r0 *1 99.75,60.2
X$9224 15 3343 3203 3372 3285 27 NOR3_X4
* cell instance $9226 r0 *1 102.79,60.2
X$9226 3374 3373 15 27 3395 NOR2_X1
* cell instance $9231 r0 *1 108.49,60.2
X$9231 3392 3287 27 3393 15 AND2_X4
* cell instance $9232 r0 *1 110.2,60.2
X$9232 388 3210 3287 27 15 3376 HA_X1
* cell instance $9233 r0 *1 112.1,60.2
X$9233 3392 3287 27 3288 15 XOR2_X2
* cell instance $9239 r0 *1 116.09,60.2
X$9239 3439 300 3206 27 15 3292 OAI21_X4
* cell instance $9240 m0 *1 117.42,60.2
X$9240 3206 3207 15 27 3289 NOR2_X1
* cell instance $9243 m0 *1 118.18,60.2
X$9243 3207 3206 15 27 3208 OR2_X1
* cell instance $9245 m0 *1 119.13,60.2
X$9245 3214 3208 15 27 3290 NAND2_X1
* cell instance $9247 r0 *1 118.56,60.2
X$9247 3207 3440 15 27 3214 XNOR2_X2
* cell instance $9248 m0 *1 120.84,60.2
X$9248 3340 2224 3211 15 27 3244 MUX2_X1
* cell instance $9249 m0 *1 120.08,60.2
X$9249 3214 3209 3208 15 27 3211 NAND3_X1
* cell instance $9250 m0 *1 122.17,60.2
X$9250 3290 3210 15 27 3291 NOR2_X1
* cell instance $9253 r0 *1 120.46,60.2
X$9253 3290 3288 15 27 3391 NOR2_X1
* cell instance $9255 r0 *1 121.22,60.2
X$9255 3210 3290 15 27 3340 OR2_X1
* cell instance $9256 r0 *1 121.98,60.2
X$9256 3291 3134 3391 15 27 3389 MUX2_X1
* cell instance $9258 r0 *1 123.69,60.2
X$9258 3214 3292 15 27 3390 NOR2_X1
* cell instance $9259 m0 *1 125.02,60.2
X$9259 3214 3293 15 27 3294 NOR2_X1
* cell instance $9260 m0 *1 123.88,60.2
X$9260 3293 3212 27 15 3334 XNOR2_X1
* cell instance $9261 m0 *1 125.59,60.2
X$9261 3244 3212 3213 15 27 3336 MUX2_X1
* cell instance $9263 m0 *1 127.11,60.2
X$9263 3336 3334 3330 27 15 3218 OAI21_X2
* cell instance $9264 m0 *1 128.44,60.2
X$9264 3135 3214 15 27 3330 OR2_X1
* cell instance $9267 r0 *1 124.45,60.2
X$9267 3292 15 27 3293 INV_X1
* cell instance $9269 r0 *1 125.02,60.2
X$9269 3212 3294 3390 3377 15 27 3296 AOI22_X2
* cell instance $9271 r0 *1 127.11,60.2
X$9271 3214 3135 15 27 3470 NOR2_X1
* cell instance $9273 r0 *1 128.06,60.2
X$9273 3389 3135 3212 15 3295 27 AOI21_X2
* cell instance $9276 m0 *1 129.58,60.2
X$9276 3212 3325 15 27 2817 XNOR2_X2
* cell instance $9277 m0 *1 131.67,60.2
X$9277 3217 3216 2648 15 27 NOR2_X4
* cell instance $9278 m0 *1 133.38,60.2
X$9278 3297 3217 3220 27 3219 15 OAI21_X1
* cell instance $9280 m0 *1 134.33,60.2
X$9280 3093 3002 3218 15 27 3320 NAND3_X1
* cell instance $9282 m0 *1 135.28,60.2
X$9282 3218 3093 27 15 3322 AND2_X1
* cell instance $9286 r0 *1 129.77,60.2
X$9286 3296 3295 27 15 3006 AND2_X1
* cell instance $9287 r0 *1 130.53,60.2
X$9287 3217 3216 3295 3296 3137 27 15 AOI211_X2
* cell instance $9291 r0 *1 134.33,60.2
X$9291 3137 3093 3218 15 3298 27 AOI21_X1
* cell instance $9294 r0 *1 135.66,60.2
X$9294 3323 2818 3322 3137 3385 3378 15 27 OAI221_X2
* cell instance $9296 r0 *1 138.13,60.2
X$9296 3320 3136 15 27 3319 NAND2_X1
* cell instance $9297 r0 *1 138.7,60.2
X$9297 3379 3136 3320 15 3318 27 AOI21_X2
* cell instance $9299 m0 *1 140.41,60.2
X$9299 3318 3299 3221 27 15 3300 OAI21_X2
* cell instance $9302 m0 *1 141.93,60.2
X$9302 3318 3015 3018 27 15 3225 OAI21_X2
* cell instance $9304 m0 *1 143.45,60.2
X$9304 3302 3225 27 15 3224 AND2_X1
* cell instance $9306 m0 *1 144.4,60.2
X$9306 3303 2405 3226 15 27 3230 NAND3_X1
* cell instance $9308 r0 *1 140.22,60.2
X$9308 3221 3299 2961 15 27 NOR2_X4
* cell instance $9310 r0 *1 142.12,60.2
X$9310 3300 3301 27 15 3223 AND2_X1
* cell instance $9311 r0 *1 142.88,60.2
X$9311 15 3300 3301 3302 3225 2760 27 NAND4_X4
* cell instance $9312 m0 *1 145.73,60.2
X$9312 15 2655 2760 3140 3141 27 AOI21_X4
* cell instance $9314 m0 *1 148.2,60.2
X$9314 2749 3083 15 2652 27 NAND2_X4
* cell instance $9315 m0 *1 149.91,60.2
X$9315 3305 2560 2559 27 15 3227 OAI21_X2
* cell instance $9317 m0 *1 151.43,60.2
X$9317 3143 3084 15 27 3309 NOR2_X1
* cell instance $9318 m0 *1 152,60.2
X$9318 3306 3308 27 2079 15 XOR2_X2
* cell instance $9322 m0 *1 156.18,60.2
X$9322 3145 3227 15 27 1798 XNOR2_X2
* cell instance $9331 r0 *1 146.3,60.2
X$9331 3313 3458 2749 15 2482 27 AOI21_X2
* cell instance $9332 r0 *1 147.63,60.2
X$9332 3303 3304 15 27 3142 NAND2_X1
* cell instance $9334 r0 *1 148.58,60.2
X$9334 15 2824 4532 3309 3305 27 AOI21_X4
* cell instance $9335 r0 *1 151.05,60.2
X$9335 3457 27 2560 15 BUF_X4
* cell instance $9336 r0 *1 152.38,60.2
X$9336 3308 3306 15 27 1952 XNOR2_X2
* cell instance $9351 r0 *1 1.33,63
X$9351 3046 3399 3401 15 3486 27 NAND3_X4
* cell instance $9358 m0 *1 3.61,63
X$9358 3261 3383 3344 15 3400 27 AOI21_X1
* cell instance $9359 m0 *1 3.23,63
X$9359 2755 15 27 3630 INV_X1
* cell instance $9360 m0 *1 4.37,63
X$9360 3400 3261 3345 27 15 3463 MUX2_X2
* cell instance $9361 m0 *1 6.08,63
X$9361 3262 15 27 3399 BUF_X2
* cell instance $9363 r0 *1 3.8,63
X$9363 3399 2849 3344 27 15 3631 AND3_X1
* cell instance $9364 r0 *1 4.75,63
X$9364 3399 3046 3401 27 15 3487 AND3_X2
* cell instance $9365 r0 *1 5.89,63
X$9365 3049 3048 2572 27 3459 15 NOR3_X2
* cell instance $9366 r0 *1 7.22,63
X$9366 3155 3486 3402 2974 3050 3573 15 27 OAI221_X2
* cell instance $9368 m0 *1 7.22,63
X$9368 3263 3149 2975 3459 3632 27 15 3383 OAI221_X1
* cell instance $9370 m0 *1 9.31,63
X$9370 2974 3402 15 3346 27 OR2_X4
* cell instance $9373 r0 *1 9.5,63
X$9373 2974 3402 3488 15 27 NOR2_X4
* cell instance $9375 r0 *1 11.4,63
X$9375 3488 3172 15 27 3489 NOR2_X2
* cell instance $9376 m0 *1 11.59,63
X$9376 3347 3090 27 15 3542 XNOR2_X1
* cell instance $9378 m0 *1 12.73,63
X$9378 2927 3090 15 27 3404 XNOR2_X2
* cell instance $9379 m0 *1 14.63,63
X$9379 3231 3346 15 27 3543 NAND2_X1
* cell instance $9384 r0 *1 12.54,63
X$9384 3542 3016 15 27 3403 NAND2_X1
* cell instance $9386 r0 *1 13.3,63
X$9386 2854 3403 3543 3544 3634 3633 15 27 OAI221_X2
* cell instance $9388 r0 *1 15.58,63
X$9388 3487 3050 15 27 3544 NAND2_X1
* cell instance $9390 r0 *1 16.34,63
X$9390 3050 3487 3346 15 3405 27 NAND3_X4
* cell instance $9391 r0 *1 18.81,63
X$9391 3265 2927 15 27 3467 NAND2_X1
* cell instance $9392 m0 *1 19.57,63
X$9392 3387 3347 15 27 3546 NAND2_X1
* cell instance $9395 m0 *1 21.66,63
X$9395 3350 3348 2927 15 27 3349 NAND3_X2
* cell instance $9396 m0 *1 22.99,63
X$9396 3350 3388 3347 15 27 3406 NAND3_X2
* cell instance $9399 r0 *1 19.38,63
X$9399 3467 3546 3409 3487 3489 3490 27 15 AOI221_X2
* cell instance $9401 r0 *1 21.66,63
X$9401 15 3491 3405 3406 3349 27 AOI21_X4
* cell instance $9402 r0 *1 24.13,63
X$9402 15 2858 27 3405 BUF_X8
* cell instance $9403 m0 *1 25.65,63
X$9403 2928 3266 2858 27 15 3492 MUX2_X2
* cell instance $9407 m0 *1 29.07,63
X$9407 3468 15 27 3354 BUF_X1
* cell instance $9408 m0 *1 29.64,63
X$9408 295 3351 3468 27 15 3353 HA_X1
* cell instance $9409 m0 *1 31.54,63
X$9409 3353 15 27 3407 INV_X1
* cell instance $9412 m0 *1 32.87,63
X$9412 3353 3354 3408 27 3411 15 OAI21_X1
* cell instance $9413 m0 *1 33.63,63
X$9413 3268 3353 15 27 3355 NOR2_X1
* cell instance $9419 r0 *1 29.07,63
X$9419 3354 15 27 3549 INV_X1
* cell instance $9420 r0 *1 29.45,63
X$9420 3549 3412 3407 27 3636 15 OAI21_X1
* cell instance $9421 r0 *1 30.21,63
X$9421 3549 3352 3407 27 3548 15 OAI21_X1
* cell instance $9422 r0 *1 30.97,63
X$9422 3351 3239 3493 15 27 3410 MUX2_X1
* cell instance $9423 r0 *1 32.3,63
X$9423 3354 3412 27 15 3493 XNOR2_X1
* cell instance $9424 r0 *1 33.44,63
X$9424 3411 3269 3355 15 3766 27 AOI21_X2
* cell instance $9426 m0 *1 36.29,63
X$9426 2934 3356 2366 27 3350 15 NOR3_X2
* cell instance $9427 m0 *1 35.34,63
X$9427 3354 3408 2364 2532 15 27 3413 NAND4_X1
* cell instance $9428 m0 *1 37.62,63
X$9428 2934 2366 3356 15 27 3409 OR3_X4
* cell instance $9431 m0 *1 40.66,63
X$9431 3357 15 27 3469 INV_X1
* cell instance $9433 m0 *1 41.23,63
X$9433 3469 3394 3272 27 15 3637 OAI21_X4
* cell instance $9434 m0 *1 43.7,63
X$9434 3271 3272 15 27 3494 XNOR2_X2
* cell instance $9436 m0 *1 46.36,63
X$9436 3035 3359 15 27 3417 NAND2_X2
* cell instance $9437 m0 *1 47.31,63
X$9437 3361 3471 15 3581 27 OR2_X4
* cell instance $9438 m0 *1 49.02,63
X$9438 3471 3361 15 27 3415 XNOR2_X2
* cell instance $9441 r0 *1 43.89,63
X$9441 15 2632 27 3414 BUF_X8
* cell instance $9444 r0 *1 50.92,63
X$9444 3416 3273 3418 15 27 3554 NOR3_X1
* cell instance $9446 m0 *1 51.3,63
X$9446 3415 3419 27 15 3418 AND2_X1
* cell instance $9447 m0 *1 52.82,63
X$9447 3419 3273 15 27 3473 NAND2_X1
* cell instance $9449 m0 *1 53.58,63
X$9449 3416 15 27 3188 CLKBUF_X3
* cell instance $9452 m0 *1 58.33,63
X$9452 388 3278 3474 27 15 3557 HA_X1
* cell instance $9453 m0 *1 60.23,63
X$9453 3276 3474 27 3422 15 AND2_X4
* cell instance $9455 r0 *1 51.68,63
X$9455 3416 3417 3418 15 27 3555 NOR3_X1
* cell instance $9456 r0 *1 52.44,63
X$9456 3554 3495 3555 15 27 3420 MUX2_X1
* cell instance $9457 r0 *1 53.77,63
X$9457 3421 3243 3188 3495 3473 27 15 3640 OAI221_X1
* cell instance $9461 r0 *1 57,63
X$9461 3557 3422 15 3419 27 OR2_X4
* cell instance $9462 r0 *1 58.71,63
X$9462 3557 3422 3638 15 27 NOR2_X4
* cell instance $9478 r0 *1 2.28,40.6
X$9478 755 2161 15 27 2109 XNOR2_X2
* cell instance $9482 m0 *1 4.18,40.6
X$9482 1970 1969 1764 15 27 2031 NAND3_X2
* cell instance $9484 m0 *1 5.51,40.6
X$9484 15 2249 1309 2083 2032 27 AOI21_X4
* cell instance $9485 m0 *1 7.98,40.6
X$9485 1905 1767 1353 27 15 2110 MUX2_X2
* cell instance $9486 m0 *1 9.69,40.6
X$9486 1905 2163 15 27 2086 NOR2_X1
* cell instance $9488 r0 *1 4.18,40.6
X$9488 2162 2201 857 2031 27 2161 15 NOR4_X2
* cell instance $9489 r0 *1 5.89,40.6
X$9489 1309 15 27 2201 INV_X1
* cell instance $9493 r0 *1 10.45,40.6
X$9493 2251 2164 2110 2163 2491 27 15 AOI211_X2
* cell instance $9494 m0 *1 11.21,40.6
X$9494 2165 1353 2085 15 2111 27 AOI21_X1
* cell instance $9495 m0 *1 10.64,40.6
X$9495 1767 2163 15 27 2085 NOR2_X1
* cell instance $9497 m0 *1 12.16,40.6
X$9497 1766 1818 15 27 2112 NAND2_X1
* cell instance $9499 m0 *1 12.92,40.6
X$9499 2103 2033 2036 27 2164 15 OAI21_X1
* cell instance $9502 m0 *1 14.63,40.6
X$9502 1972 1973 15 27 2354 XNOR2_X2
* cell instance $9505 r0 *1 12.16,40.6
X$9505 1353 2166 2112 15 2251 27 AOI21_X1
* cell instance $9506 r0 *1 12.92,40.6
X$9506 2254 2086 2103 27 2253 15 OAI21_X1
* cell instance $9508 r0 *1 16.72,40.6
X$9508 15 1973 2168 2171 2037 27 AOI21_X4
* cell instance $9509 m0 *1 18.62,40.6
X$9509 2021 2048 2034 2044 27 15 2036 AND4_X1
* cell instance $9510 m0 *1 17.67,40.6
X$9510 2044 2034 2048 2021 15 27 2165 NAND4_X1
* cell instance $9511 m0 *1 19.76,40.6
X$9511 2113 2088 27 15 2332 XNOR2_X1
* cell instance $9513 m0 *1 21.09,40.6
X$9513 2041 2035 2040 15 2170 27 AOI21_X1
* cell instance $9515 m0 *1 22.04,40.6
X$9515 2090 15 27 2114 INV_X1
* cell instance $9517 m0 *1 22.61,40.6
X$9517 2039 2115 27 15 2116 XNOR2_X1
* cell instance $9519 m0 *1 23.94,40.6
X$9519 2041 2172 2035 15 2115 27 AOI21_X2
* cell instance $9521 r0 *1 19.19,40.6
X$9521 295 1820 2037 27 15 2168 HA_X1
* cell instance $9522 r0 *1 21.09,40.6
X$9522 2038 2170 2114 27 2088 15 OAI21_X1
* cell instance $9523 r0 *1 21.85,40.6
X$9523 2114 2115 2038 27 15 2171 OAI21_X2
* cell instance $9524 r0 *1 23.18,40.6
X$9524 2042 1979 2116 15 27 2203 MUX2_X1
* cell instance $9526 r0 *1 24.89,40.6
X$9526 2043 1979 2117 15 27 2259 MUX2_X1
* cell instance $9528 m0 *1 25.65,40.6
X$9528 2035 2040 15 27 2117 XOR2_X1
* cell instance $9530 m0 *1 29.07,40.6
X$9530 212 2045 2046 27 15 1932 HA_X1
* cell instance $9532 m0 *1 31.16,40.6
X$9532 2094 2046 2049 27 15 2044 AND3_X1
* cell instance $9534 m0 *1 32.3,40.6
X$9534 2047 1979 2174 15 27 2097 MUX2_X1
* cell instance $9536 m0 *1 33.82,40.6
X$9536 2094 2176 27 15 2174 XNOR2_X1
* cell instance $9541 r0 *1 28.69,40.6
X$9541 2045 1979 2173 15 27 2358 MUX2_X1
* cell instance $9542 r0 *1 30.02,40.6
X$9542 2046 2261 27 15 2173 XNOR2_X1
* cell instance $9543 r0 *1 31.16,40.6
X$9543 2175 2046 2094 15 27 1976 NAND3_X1
* cell instance $9545 r0 *1 32.11,40.6
X$9545 1933 2094 2175 15 2261 27 AOI21_X1
* cell instance $9547 m0 *1 36.1,40.6
X$9547 2049 1977 15 27 2175 OR2_X1
* cell instance $9548 m0 *1 35.34,40.6
X$9548 1977 2049 2118 15 2176 27 AOI21_X1
* cell instance $9554 r0 *1 38.57,40.6
X$9554 2166 1353 15 27 2204 NOR2_X1
* cell instance $9555 m0 *1 38.95,40.6
X$9555 2119 2052 15 27 2166 NAND2_X1
* cell instance $9558 r0 *1 39.14,40.6
X$9558 2052 2119 27 15 2254 AND2_X1
* cell instance $9559 m0 *1 40.09,40.6
X$9559 1772 1980 15 27 2119 XNOR2_X2
* cell instance $9562 m0 *1 42.75,40.6
X$9562 2051 15 27 2180 INV_X1
* cell instance $9563 m0 *1 43.13,40.6
X$9563 2180 1116 1980 15 2179 27 AOI21_X2
* cell instance $9565 r0 *1 39.9,40.6
X$9565 1353 2119 27 15 2205 XNOR2_X1
* cell instance $9568 r0 *1 41.61,40.6
X$9568 2103 1773 15 27 2283 NOR2_X2
* cell instance $9569 r0 *1 42.56,40.6
X$9569 15 1435 2178 2179 2366 1981 27 OAI22_X4
* cell instance $9571 m0 *1 44.84,40.6
X$9571 1980 1772 1604 27 2048 15 OAI21_X1
* cell instance $9581 r0 *1 54.34,40.6
X$9581 2120 15 27 2268 INV_X1
* cell instance $9583 r0 *1 55.1,40.6
X$9583 2121 15 27 2209 INV_X1
* cell instance $9589 r0 *1 61.94,40.6
X$9589 2273 15 27 LOGIC0_X1
* cell instance $9590 r0 *1 62.32,40.6
X$9590 1158 2273 2274 27 15 2212 HA_X1
* cell instance $9593 r0 *1 65.93,40.6
X$9593 1158 2054 2213 27 15 2214 HA_X1
* cell instance $9596 m0 *1 68.02,40.6
X$9596 2123 2054 2122 15 27 NOR2_X4
* cell instance $9599 r0 *1 68.59,40.6
X$9599 15 2124 2122 2213 2123 27 AOI21_X4
* cell instance $9604 r0 *1 76.57,40.6
X$9604 2124 111 2219 27 15 2220 HA_X1
* cell instance $9605 m0 *1 77.9,40.6
X$9605 2056 1986 1394 27 2184 15 NOR3_X2
* cell instance $9610 m0 *1 79.61,40.6
X$9610 2030 15 27 1986 INV_X2
* cell instance $9612 m0 *1 81.13,40.6
X$9612 1330 2056 15 27 2125 NAND2_X1
* cell instance $9613 m0 *1 80.56,40.6
X$9613 2125 1299 15 27 1941 NAND2_X1
* cell instance $9616 r0 *1 80.94,40.6
X$9616 2056 2126 1330 15 1397 27 NAND3_X4
* cell instance $9617 m0 *1 83.03,40.6
X$9617 1941 1987 15 27 2028 NAND2_X1
* cell instance $9618 m0 *1 82.08,40.6
X$9618 2125 1299 2030 1989 15 27 2104 NAND4_X1
* cell instance $9620 m0 *1 83.79,40.6
X$9620 1941 1942 15 27 2127 NAND2_X1
* cell instance $9621 m0 *1 84.36,40.6
X$9621 2055 2127 2104 15 1988 27 AOI21_X1
* cell instance $9625 m0 *1 87.59,40.6
X$9625 15 2304 2188 1943 2026 27 AOI21_X4
* cell instance $9627 m0 *1 90.25,40.6
X$9627 2057 1942 15 27 2128 NAND2_X1
* cell instance $9628 m0 *1 90.82,40.6
X$9628 2101 2128 15 27 2059 NAND2_X1
* cell instance $9631 m0 *1 95.95,40.6
X$9631 212 2060 2061 27 15 2190 HA_X1
* cell instance $9632 m0 *1 97.85,40.6
X$9632 2190 2061 2131 15 2130 27 AOI21_X2
* cell instance $9633 m0 *1 99.18,40.6
X$9633 2133 2062 27 15 2134 XNOR2_X1
* cell instance $9634 m0 *1 100.32,40.6
X$9634 2131 15 27 2192 INV_X1
* cell instance $9635 m0 *1 100.7,40.6
X$9635 2308 2192 15 27 2270 NAND2_X1
* cell instance $9638 r0 *1 83.41,40.6
X$9638 2126 2056 1330 27 15 2187 AND3_X1
* cell instance $9639 r0 *1 84.36,40.6
X$9639 2187 27 1536 15 BUF_X4
* cell instance $9644 r0 *1 96.71,40.6
X$9644 111 2129 2133 27 15 2131 HA_X1
* cell instance $9645 r0 *1 98.61,40.6
X$9645 2061 15 27 2271 INV_X1
* cell instance $9646 r0 *1 98.99,40.6
X$9646 2129 2132 2134 15 27 2193 MUX2_X1
* cell instance $9647 r0 *1 100.32,40.6
X$9647 2271 2270 27 15 2222 XNOR2_X1
* cell instance $9649 m0 *1 104.31,40.6
X$9649 2135 2063 27 2066 15 AND2_X4
* cell instance $9650 m0 *1 103.17,40.6
X$9650 2063 2135 15 27 2092 XOR2_X1
* cell instance $9651 m0 *1 106.02,40.6
X$9651 2065 1990 15 2064 27 NAND2_X4
* cell instance $9652 m0 *1 107.73,40.6
X$9652 2193 2224 2092 15 27 2067 MUX2_X1
* cell instance $9654 m0 *1 109.25,40.6
X$9654 2227 2226 27 15 2199 XNOR2_X1
* cell instance $9655 m0 *1 110.39,40.6
X$9655 138 2067 2227 27 15 2138 HA_X1
* cell instance $9656 m0 *1 112.29,40.6
X$9656 2067 2197 2199 15 27 2070 MUX2_X1
* cell instance $9658 m0 *1 115.14,40.6
X$9658 2195 15 27 2139 BUF_X1
* cell instance $9659 m0 *1 115.71,40.6
X$9659 138 2068 2195 27 15 2141 HA_X1
* cell instance $9660 m0 *1 117.61,40.6
X$9660 2068 2140 2069 15 27 1792 MUX2_X1
* cell instance $9661 m0 *1 118.94,40.6
X$9661 2141 15 27 2142 INV_X1
* cell instance $9664 r0 *1 104.5,40.6
X$9664 2196 2136 15 27 2135 NAND2_X2
* cell instance $9666 r0 *1 105.64,40.6
X$9666 2065 2194 27 15 2198 AND2_X1
* cell instance $9667 r0 *1 106.4,40.6
X$9667 2223 15 27 2196 INV_X1
* cell instance $9669 r0 *1 106.97,40.6
X$9669 1991 2224 2198 15 27 2267 MUX2_X1
* cell instance $9673 r0 *1 110.39,40.6
X$9673 212 2137 2228 27 15 2229 HA_X1
* cell instance $9677 r0 *1 114.95,40.6
X$9677 2137 2197 2265 15 27 2068 MUX2_X1
* cell instance $9683 r0 *1 117.23,40.6
X$9683 2139 2232 27 15 2069 XNOR2_X1
* cell instance $9684 r0 *1 118.37,40.6
X$9684 2139 15 27 2191 INV_X1
* cell instance $9685 r0 *1 118.75,40.6
X$9685 2191 2232 2142 27 2189 15 OAI21_X1
* cell instance $9687 r0 *1 120.27,40.6
X$9687 2234 15 27 2339 INV_X1
* cell instance $9688 m0 *1 120.65,40.6
X$9688 195 2070 2143 27 15 2144 HA_X1
* cell instance $9690 m0 *1 122.55,40.6
X$9690 2070 2140 2071 15 27 1864 MUX2_X1
* cell instance $9692 m0 *1 129.96,40.6
X$9692 1949 15 27 2146 INV_X1
* cell instance $9693 m0 *1 130.34,40.6
X$9693 2146 2262 2072 27 15 1519 MUX2_X2
* cell instance $9694 m0 *1 132.05,40.6
X$9694 2147 15 27 2185 INV_X1
* cell instance $9702 r0 *1 122.17,40.6
X$9702 2143 15 27 2317 INV_X1
* cell instance $9704 r0 *1 122.74,40.6
X$9704 2144 15 27 2318 INV_X1
* cell instance $9705 r0 *1 123.12,40.6
X$9705 2144 2143 2189 15 2237 27 AOI21_X2
* cell instance $9706 r0 *1 124.45,40.6
X$9706 2263 15 27 2236 BUF_X2
* cell instance $9708 r0 *1 125.4,40.6
X$9708 1840 2401 2145 27 2186 15 OAI21_X1
* cell instance $9709 r0 *1 126.16,40.6
X$9709 2320 1840 15 27 2145 NAND2_X1
* cell instance $9711 r0 *1 129.77,40.6
X$9711 300 2146 2321 27 15 2147 HA_X1
* cell instance $9713 r0 *1 131.86,40.6
X$9713 2185 2238 2148 27 15 2074 OAI21_X4
* cell instance $9714 r0 *1 134.33,40.6
X$9714 2321 15 27 2148 INV_X1
* cell instance $9722 r0 *1 1.52,37.8
X$9722 15 1764 1968 858 1104 2032 27 NAND4_X4
* cell instance $9726 m0 *1 5.32,37.8
X$9726 1906 1767 15 27 2011 NAND2_X1
* cell instance $9727 m0 *1 3.99,37.8
X$9727 2011 1546 1904 15 27 1970 MUX2_X1
* cell instance $9729 r0 *1 4.94,37.8
X$9729 1764 1969 1970 27 15 2083 AND3_X1
* cell instance $9732 m0 *1 6.27,37.8
X$9732 1906 15 27 1930 INV_X1
* cell instance $9733 m0 *1 6.84,37.8
X$9733 1875 1908 1546 27 15 1968 MUX2_X2
* cell instance $9735 m0 *1 8.74,37.8
X$9735 1499 1931 408 27 15 1906 OAI21_X2
* cell instance $9736 m0 *1 10.07,37.8
X$9736 1931 1818 15 27 1971 NOR2_X1
* cell instance $9737 m0 *1 10.64,37.8
X$9737 1971 1819 15 27 2012 NAND2_X1
* cell instance $9740 r0 *1 6.65,37.8
X$9740 2032 27 1979 15 BUF_X4
* cell instance $9742 r0 *1 8.36,37.8
X$9742 1766 15 27 1905 INV_X1
* cell instance $9744 r0 *1 8.93,37.8
X$9744 2084 1353 2012 15 27 1969 MUX2_X1
* cell instance $9745 r0 *1 10.26,37.8
X$9745 1971 1766 15 27 2084 NAND2_X1
* cell instance $9746 r0 *1 10.83,37.8
X$9746 1766 1819 1353 27 15 2252 MUX2_X2
* cell instance $9748 r0 *1 12.73,37.8
X$9748 1819 1818 15 27 2033 NAND2_X1
* cell instance $9751 r0 *1 14.44,37.8
X$9751 1974 2087 1972 15 1877 27 AOI21_X2
* cell instance $9752 m0 *1 16.53,37.8
X$9752 1546 15 27 2103 BUF_X2
* cell instance $9753 m0 *1 14.63,37.8
X$9753 388 1550 1972 27 15 1974 HA_X1
* cell instance $9757 r0 *1 15.77,37.8
X$9757 1973 15 27 2087 INV_X4
* cell instance $9758 r0 *1 16.72,37.8
X$9758 2034 2040 1974 1972 2016 1931 27 15 AOI221_X2
* cell instance $9759 r0 *1 18.81,37.8
X$9759 1972 2039 2035 2037 27 15 2034 AND4_X1
* cell instance $9760 r0 *1 19.95,37.8
X$9760 2113 2089 2202 27 2016 15 OAI21_X1
* cell instance $9762 r0 *1 20.9,37.8
X$9762 2039 15 27 2038 INV_X1
* cell instance $9764 r0 *1 21.47,37.8
X$9764 2090 2039 2041 15 2089 27 AOI21_X1
* cell instance $9765 r0 *1 22.23,37.8
X$9765 195 2042 2039 27 15 2090 HA_X1
* cell instance $9767 r0 *1 24.32,37.8
X$9767 138 2043 2035 27 15 2041 HA_X1
* cell instance $9771 r0 *1 28.31,37.8
X$9771 1975 1976 15 27 2172 NAND2_X1
* cell instance $9772 r0 *1 28.88,37.8
X$9772 1975 2020 1976 27 15 2040 OAI21_X4
* cell instance $9773 m0 *1 30.02,37.8
X$9773 2019 15 27 1447 INV_X4
* cell instance $9775 m0 *1 30.97,37.8
X$9775 1932 2046 1933 15 1975 27 AOI21_X2
* cell instance $9777 m0 *1 32.49,37.8
X$9777 1978 1821 1881 15 27 2047 MUX2_X1
* cell instance $9783 r0 *1 32.3,37.8
X$9783 111 2047 2094 27 15 1933 HA_X1
* cell instance $9787 r0 *1 35.53,37.8
X$9787 2100 15 27 LOGIC0_X1
* cell instance $9788 r0 *1 35.91,37.8
X$9788 43 2100 2049 27 15 1977 HA_X1
* cell instance $9789 r0 *1 37.81,37.8
X$9789 999 1028 15 27 2021 NOR2_X1
* cell instance $9791 m0 *1 38.95,37.8
X$9791 1934 711 1957 27 15 1978 OAI21_X2
* cell instance $9793 m0 *1 40.28,37.8
X$9793 1030 15 27 1028 INV_X2
* cell instance $9794 m0 *1 40.85,37.8
X$9794 1116 1631 15 27 1957 NAND2_X1
* cell instance $9796 r0 *1 39.14,37.8
X$9796 1065 1957 15 27 2118 OR2_X2
* cell instance $9797 r0 *1 40.09,37.8
X$9797 1979 1065 1772 27 2050 15 OAI21_X1
* cell instance $9798 r0 *1 40.85,37.8
X$9798 2050 1144 1979 27 15 2178 OAI21_X2
* cell instance $9799 m0 *1 41.99,37.8
X$9799 1977 1830 1065 15 27 1961 OR3_X1
* cell instance $9803 r0 *1 42.18,37.8
X$9803 1116 1980 2103 27 2051 15 OAI21_X1
* cell instance $9804 r0 *1 42.94,37.8
X$9804 1980 2027 15 27 1880 NOR2_X2
* cell instance $9806 m0 *1 44.27,37.8
X$9806 1328 1686 1961 1144 1631 2020 27 15 AOI221_X2
* cell instance $9808 m0 *1 46.36,37.8
X$9808 15 1631 1144 2019 1935 1686 27 AOI22_X4
* cell instance $9810 r0 *1 44.08,37.8
X$9810 1328 27 1980 15 BUF_X4
* cell instance $9813 r0 *1 47.69,37.8
X$9813 2052 722 15 27 2027 NAND2_X1
* cell instance $9817 r0 *1 49.59,37.8
X$9817 2055 27 1394 15 BUF_X4
* cell instance $9818 m0 *1 50.16,37.8
X$9818 15 1935 27 1328 BUF_X8
* cell instance $9824 r0 *1 52.25,37.8
X$9824 1982 1936 2106 1981 27 15 1776 OAI22_X2
* cell instance $9826 m0 *1 53.01,37.8
X$9826 456 1981 1935 15 1936 27 AOI21_X1
* cell instance $9827 m0 *1 53.96,37.8
X$9827 1982 1116 1935 27 15 1983 AND3_X2
* cell instance $9828 m0 *1 55.1,37.8
X$9828 591 1935 15 27 1938 NOR2_X1
* cell instance $9829 m0 *1 55.67,37.8
X$9829 1937 1938 15 27 1778 NOR2_X1
* cell instance $9833 r0 *1 54.91,37.8
X$9833 1983 1772 2053 15 2106 27 AOI21_X2
* cell instance $9834 r0 *1 56.24,37.8
X$9834 2053 1885 2107 15 1937 27 AOI21_X1
* cell instance $9835 m0 *1 58.52,37.8
X$9835 1939 1984 1940 15 1884 27 AOI21_X1
* cell instance $9836 m0 *1 56.62,37.8
X$9836 111 591 1984 27 15 1939 HA_X1
* cell instance $9838 m0 *1 59.47,37.8
X$9838 43 1967 1982 27 15 1940 HA_X1
* cell instance $9840 r0 *1 57,37.8
X$9840 1328 15 27 2053 INV_X1
* cell instance $9841 r0 *1 57.38,37.8
X$9841 1982 1984 1940 15 27 2107 OR3_X1
* cell instance $9842 r0 *1 58.33,37.8
X$9842 1984 1982 1940 27 15 1885 OAI21_X2
* cell instance $9848 m0 *1 61.75,37.8
X$9848 1939 1940 1661 15 27 1923 OR3_X1
* cell instance $9849 m0 *1 62.89,37.8
X$9849 1604 1030 15 27 1661 NAND2_X2
* cell instance $9852 r0 *1 62.7,37.8
X$9852 1661 27 1981 15 BUF_X4
* cell instance $9853 r0 *1 64.03,37.8
X$9853 1883 27 2052 15 BUF_X4
* cell instance $9855 m0 *1 64.98,37.8
X$9855 1830 1780 999 15 1887 27 AOI21_X2
* cell instance $9856 m0 *1 66.5,37.8
X$9856 1782 1780 1888 1889 15 27 1967 AOI211_X4
* cell instance $9861 m0 *1 71.44,37.8
X$9861 1890 1832 15 43 27 NAND2_X4
* cell instance $9863 m0 *1 73.15,37.8
X$9863 1890 1832 15 1158 27 NAND2_X4
* cell instance $9868 r0 *1 73.72,37.8
X$9868 1832 1526 15 195 27 NAND2_X4
* cell instance $9869 r0 *1 75.43,37.8
X$9869 2105 27 1832 15 BUF_X4
* cell instance $9872 r0 *1 77.71,37.8
X$9872 2055 2108 1985 15 1817 27 AOI21_X1
* cell instance $9874 m0 *1 78.28,37.8
X$9874 1941 1526 15 27 1985 NAND2_X1
* cell instance $9876 r0 *1 78.47,37.8
X$9876 1986 1891 1941 15 27 2108 OR3_X1
* cell instance $9877 r0 *1 79.42,37.8
X$9877 1604 1986 1330 15 27 NOR2_X4
* cell instance $9878 m0 *1 80.18,37.8
X$9878 1298 1966 27 15 1892 AND2_X1
* cell instance $9880 m0 *1 80.94,37.8
X$9880 1941 1965 2028 27 1966 15 OAI21_X1
* cell instance $9881 m0 *1 81.7,37.8
X$9881 2029 2030 15 27 1965 NAND2_X1
* cell instance $9884 r0 *1 81.51,37.8
X$9884 1697 1784 2029 27 15 2105 HA_X1
* cell instance $9885 m0 *1 85.12,37.8
X$9885 1942 15 27 1989 INV_X1
* cell instance $9886 m0 *1 82.65,37.8
X$9886 15 2056 1526 1987 1942 27 AOI21_X4
* cell instance $9888 m0 *1 86.26,37.8
X$9888 1698 15 27 1942 BUF_X2
* cell instance $9890 m0 *1 87.21,37.8
X$9890 1987 1942 1526 15 27 1964 NAND3_X1
* cell instance $9892 r0 *1 83.41,37.8
X$9892 15 1988 1245 1697 1698 27 DFF_X2
* cell instance $9893 r0 *1 87.02,37.8
X$9893 1526 1989 1399 1784 27 15 2188 AND4_X1
* cell instance $9894 r0 *1 88.16,37.8
X$9894 1700 1987 1989 15 27 2101 NAND3_X1
* cell instance $9895 m0 *1 88.54,37.8
X$9895 1784 1526 15 27 1943 NOR2_X2
* cell instance $9898 r0 *1 88.92,37.8
X$9898 1396 1987 1399 15 27 2057 MUX2_X1
* cell instance $9900 m0 *1 89.87,37.8
X$9900 1396 1942 1700 15 27 2026 MUX2_X1
* cell instance $9902 r0 *1 90.25,37.8
X$9902 1396 2058 2102 27 15 2096 HA_X1
* cell instance $9904 m0 *1 92.53,37.8
X$9904 1927 1894 2098 27 15 1963 HA_X1
* cell instance $9906 m0 *1 94.43,37.8
X$9906 1963 2025 15 27 2023 XOR2_X1
* cell instance $9908 m0 *1 96.33,37.8
X$9908 2023 1895 27 15 2024 XNOR2_X1
* cell instance $9911 m0 *1 105.07,37.8
X$9911 1962 15 27 1990 INV_X1
* cell instance $9912 m0 *1 105.45,37.8
X$9912 138 1991 2093 27 15 1962 HA_X1
* cell instance $9917 r0 *1 92.34,37.8
X$9917 2098 2096 2099 27 15 2025 HA_X1
* cell instance $9918 r0 *1 94.24,37.8
X$9918 2024 1928 15 27 2095 XNOR2_X2
* cell instance $9921 r0 *1 102.98,37.8
X$9921 212 2193 2063 27 15 1992 HA_X1
* cell instance $9922 r0 *1 104.88,37.8
X$9922 2093 1992 2066 27 15 2065 OAI21_X4
* cell instance $9923 r0 *1 107.35,37.8
X$9923 2093 1992 2066 15 27 2194 OR3_X1
* cell instance $9931 m0 *1 120.65,37.8
X$9931 1920 1897 27 15 1921 AND2_X1
* cell instance $9934 m0 *1 123.88,37.8
X$9934 1960 15 27 1993 INV_X1
* cell instance $9935 m0 *1 124.26,37.8
X$9935 1920 1993 15 1959 27 NAND2_X4
* cell instance $9942 m0 *1 126.54,37.8
X$9942 388 1713 2022 27 15 2091 HA_X1
* cell instance $9944 m0 *1 128.44,37.8
X$9944 2022 1959 27 15 1958 XNOR2_X1
* cell instance $9946 r0 *1 126.54,37.8
X$9946 2186 15 27 1713 INV_X1
* cell instance $9947 r0 *1 126.92,37.8
X$9947 15 2238 2091 2022 1959 27 AOI21_X4
* cell instance $9949 m0 *1 130.15,37.8
X$9949 15 1706 27 1994 BUF_X8
* cell instance $9951 m0 *1 132.62,37.8
X$9951 1994 27 1842 15 BUF_X4
* cell instance $9953 m0 *1 134.14,37.8
X$9953 1946 1812 1944 27 15 1715 OAI21_X2
* cell instance $9954 m0 *1 135.47,37.8
X$9954 1945 2018 1956 15 27 1255 NAND3_X2
* cell instance $9955 m0 *1 136.8,37.8
X$9955 1956 2018 1945 27 15 1582 AND3_X1
* cell instance $9956 m0 *1 137.75,37.8
X$9956 1946 1750 15 27 1948 NOR2_X1
* cell instance $9958 m0 *1 138.51,37.8
X$9958 1948 1839 1484 27 1945 15 OAI21_X1
* cell instance $9963 r0 *1 134.52,37.8
X$9963 1750 1842 2242 15 1995 27 AOI21_X1
* cell instance $9964 r0 *1 135.28,37.8
X$9964 1996 2073 15 27 1944 NAND2_X1
* cell instance $9966 r0 *1 136.23,37.8
X$9966 1899 1996 2072 2073 15 27 2018 NAND4_X1
* cell instance $9967 r0 *1 137.18,37.8
X$9967 1579 15 27 2075 INV_X4
* cell instance $9969 m0 *1 140.22,37.8
X$9969 1999 27 1793 15 BUF_X4
* cell instance $9970 m0 *1 139.65,37.8
X$9970 1841 2076 15 27 1955 NAND2_X1
* cell instance $9971 m0 *1 141.55,37.8
X$9971 2015 2017 1999 27 15 1645 MUX2_X2
* cell instance $9972 m0 *1 143.26,37.8
X$9972 1955 1999 1910 15 27 1954 MUX2_X1
* cell instance $9975 m0 *1 145.54,37.8
X$9975 2014 1950 1856 27 15 2177 AND3_X1
* cell instance $9976 m0 *1 146.49,37.8
X$9976 2014 2000 1950 15 1586 27 NAND3_X4
* cell instance $9977 m0 *1 148.96,37.8
X$9977 1414 1586 1484 1951 27 1417 15 OR4_X2
* cell instance $9983 r0 *1 140.22,37.8
X$9983 1997 2076 15 27 1998 NAND2_X1
* cell instance $9984 r0 *1 140.79,37.8
X$9984 2075 1949 15 27 2017 NAND2_X1
* cell instance $9985 r0 *1 141.36,37.8
X$9985 2076 2075 15 27 2015 NAND2_X1
* cell instance $9987 r0 *1 142.31,37.8
X$9987 1998 2077 1999 27 15 1484 MUX2_X2
* cell instance $9988 r0 *1 144.02,37.8
X$9988 15 1812 27 1999 BUF_X8
* cell instance $9989 r0 *1 146.49,37.8
X$9989 15 2013 1716 1508 1950 2000 27 AOI22_X4
* cell instance $9990 r0 *1 149.72,37.8
X$9990 2001 27 1491 15 BUF_X4
* cell instance $9994 r0 *1 152.38,37.8
X$9994 2079 1812 15 27 2080 NOR2_X1
* cell instance $9995 r0 *1 152.95,37.8
X$9995 2080 2081 2004 15 27 2002 NOR3_X1
* cell instance $9996 r0 *1 153.71,37.8
X$9996 1500 2167 2002 2003 2010 931 27 15 AOI221_X2
* cell instance $9997 m0 *1 154.66,37.8
X$9997 1952 1845 1797 15 27 1901 NAND3_X2
* cell instance $9999 m0 *1 155.99,37.8
X$9999 1952 2009 2004 15 27 2010 NOR3_X1
* cell instance $10000 m0 *1 156.75,37.8
X$10000 1952 2009 15 27 2005 NAND2_X1
* cell instance $10002 r0 *1 155.8,37.8
X$10002 2006 2081 2079 15 1490 27 AOI21_X2
* cell instance $10003 r0 *1 157.13,37.8
X$10003 2005 2082 2006 15 27 1648 MUX2_X1
* cell instance $10004 m0 *1 157.89,37.8
X$10004 1417 2008 1953 15 2007 27 AOI21_X2
* cell instance $10013 r0 *1 158.46,37.8
X$10013 2082 2004 2081 15 27 2008 OR3_X1
* cell instance $10026 m0 *1 8.36,107.8
X$10026 5932 15 27 5942 BUF_X2
* cell instance $10031 m0 *1 13.87,107.8
X$10031 5743 6027 15 27 5989 NAND2_X2
* cell instance $10032 m0 *1 14.82,107.8
X$10032 5743 5936 15 27 6083 NAND2_X2
* cell instance $10033 m0 *1 15.77,107.8
X$10033 6025 6028 5937 6029 5989 6024 15 27 OAI221_X2
* cell instance $10034 m0 *1 17.86,107.8
X$10034 6027 5519 15 27 6081 NAND2_X1
* cell instance $10035 m0 *1 18.43,107.8
X$10035 6132 6028 5939 6029 5996 6089 15 27 OAI221_X2
* cell instance $10036 m0 *1 20.52,107.8
X$10036 5119 6170 15 5996 27 NAND2_X4
* cell instance $10039 m0 *1 28.5,107.8
X$10039 15 6030 5935 6028 5918 6093 27 AOI22_X4
* cell instance $10040 m0 *1 31.73,107.8
X$10040 5943 6094 5526 15 27 6029 OR3_X4
* cell instance $10042 m0 *1 34.58,107.8
X$10042 15 5944 5946 5755 6102 27 NOR3_X4
* cell instance $10043 m0 *1 37.24,107.8
X$10043 15 6034 5945 5797 6100 27 AOI21_X4
* cell instance $10044 m0 *1 39.71,107.8
X$10044 5947 5949 6035 27 15 6037 OAI21_X4
* cell instance $10045 m0 *1 42.18,107.8
X$10045 6037 5950 15 27 6182 NAND2_X1
* cell instance $10047 m0 *1 42.94,107.8
X$10047 6109 6039 5948 27 15 6015 OAI21_X2
* cell instance $10048 m0 *1 44.27,107.8
X$10048 5951 15 27 6109 INV_X1
* cell instance $10051 m0 *1 46.36,107.8
X$10051 6015 6016 15 27 6042 XNOR2_X2
* cell instance $10053 m0 *1 49.02,107.8
X$10053 5280 5952 27 15 6016 XNOR2_X1
* cell instance $10057 m0 *1 55.48,107.8
X$10057 15 5526 5870 5954 6116 27 NOR3_X4
* cell instance $10061 m0 *1 62.13,107.8
X$10061 15 5229 5448 10663 6117 27 DFF_X2
* cell instance $10062 m0 *1 65.74,107.8
X$10062 6118 27 6044 15 BUF_X4
* cell instance $10065 m0 *1 69.35,107.8
X$10065 1298 5955 27 15 6045 AND2_X1
* cell instance $10071 m0 *1 2.85,107.8
X$10071 5857 15 27 5934 BUF_X2
* cell instance $10082 r0 *1 3.42,107.8
X$10082 6022 15 27 5938 BUF_X2
* cell instance $10084 r0 *1 4.94,107.8
X$10084 6021 15 27 6036 BUF_X2
* cell instance $10086 r0 *1 6.08,107.8
X$10086 6023 15 27 5941 BUF_X2
* cell instance $10088 m0 *1 6.27,107.8
X$10088 5931 15 27 6031 BUF_X2
* cell instance $10094 r0 *1 14.25,107.8
X$10094 5995 15 27 CLKBUF_X1
* cell instance $10095 r0 *1 14.82,107.8
X$10095 5024 15 27 5995 CLKBUF_X3
* cell instance $10097 r0 *1 15.96,107.8
X$10097 6025 6133 5937 6134 6083 5858 15 27 OAI221_X2
* cell instance $10098 r0 *1 18.05,107.8
X$10098 15 6089 5995 10795 5119 27 DFF_X2
* cell instance $10101 r0 *1 22.23,107.8
X$10101 15 6172 6436 10773 5186 27 DFF_X2
* cell instance $10105 r0 *1 28.5,107.8
X$10105 15 6030 5741 6177 5918 5755 27 AOI22_X4
* cell instance $10106 r0 *1 31.73,107.8
X$10106 5792 5913 5622 27 15 6094 AND3_X1
* cell instance $10107 r0 *1 32.68,107.8
X$10107 5280 6135 5795 27 15 6035 HA_X1
* cell instance $10108 r0 *1 34.58,107.8
X$10108 5944 15 27 6093 BUF_X1
* cell instance $10109 r0 *1 35.15,107.8
X$10109 5797 6032 15 27 6033 XNOR2_X2
* cell instance $10110 r0 *1 37.05,107.8
X$10110 6098 15 27 5861 INV_X1
* cell instance $10112 r0 *1 37.81,107.8
X$10112 6034 6039 15 27 6104 XNOR2_X2
* cell instance $10113 r0 *1 39.71,107.8
X$10113 6104 6033 6102 15 27 6110 NAND3_X2
* cell instance $10114 r0 *1 41.04,107.8
X$10114 5947 6035 5949 15 27 6038 OR3_X2
* cell instance $10115 r0 *1 42.18,107.8
X$10115 6040 5280 6039 27 15 6137 HA_X1
* cell instance $10117 r0 *1 44.27,107.8
X$10117 5280 6040 6041 27 15 10916 HA_X1
* cell instance $10119 r0 *1 46.55,107.8
X$10119 15 6190 6042 6110 5188 6043 27 AND4_X4
* cell instance $10121 r0 *1 49.4,107.8
X$10121 15 6030 5938 6446 5918 5953 27 AOI22_X4
* cell instance $10124 r0 *1 53.2,107.8
X$10124 5188 5952 27 15 6138 XNOR2_X1
* cell instance $10125 r0 *1 54.34,107.8
X$10125 5703 5543 5680 5542 15 27 6192 NOR4_X1
* cell instance $10127 r0 *1 55.67,107.8
X$10127 15 5918 27 6115 BUF_X8
* cell instance $10128 r0 *1 58.14,107.8
X$10128 6140 27 5526 15 BUF_X4
* cell instance $10133 r0 *1 59.66,107.8
X$10133 6043 6044 6115 15 27 NOR2_X4
* cell instance $10134 r0 *1 61.37,107.8
X$10134 15 6276 6030 27 BUF_X16
* cell instance $10138 r0 *1 68.78,107.8
X$10138 15 6046 6019 6045 5448 27 DFF_X1
* cell instance $10139 r0 *1 72.01,107.8
X$10139 6046 15 27 6188 INV_X1
* cell instance $10140 r0 *1 72.39,107.8
X$10140 15 6282 5704 5705 5877 27 AOI21_X4
* cell instance $10141 m0 *1 72.96,107.8
X$10141 5705 5285 15 27 6281 NAND2_X2
* cell instance $10143 m0 *1 73.91,107.8
X$10143 5878 15 27 6402 BUF_X2
* cell instance $10145 m0 *1 75.43,107.8
X$10145 6119 15 27 5354 CLKBUF_X3
* cell instance $10146 m0 *1 76.38,107.8
X$10146 5285 5877 5705 27 15 6047 AND3_X1
* cell instance $10151 r0 *1 76.19,107.8
X$10151 6047 15 27 6125 BUF_X1
* cell instance $10153 r0 *1 77.14,107.8
X$10153 6125 6031 15 27 6186 NAND2_X1
* cell instance $10154 m0 *1 77.9,107.8
X$10154 6120 15 27 6207 BUF_X2
* cell instance $10156 m0 *1 78.66,107.8
X$10156 15 10393 6122 5956 5372 27 DFF_X1
* cell instance $10157 m0 *1 81.89,107.8
X$10157 5958 6123 6048 15 27 NOR2_X4
* cell instance $10158 m0 *1 83.6,107.8
X$10158 15 6031 5880 5959 5958 5965 27 AOI22_X4
* cell instance $10160 r0 *1 77.71,107.8
X$10160 15 6141 6185 10767 5450 27 DFF_X2
* cell instance $10163 r0 *1 82.27,107.8
X$10163 6125 5942 15 27 6143 NAND2_X1
* cell instance $10164 r0 *1 82.84,107.8
X$10164 6048 27 5880 15 BUF_X4
* cell instance $10167 r0 *1 85.12,107.8
X$10167 5958 15 27 6049 BUF_X2
* cell instance $10170 r0 *1 87.02,107.8
X$10170 15 6036 5880 6689 6049 6129 27 AOI22_X4
* cell instance $10171 m0 *1 87.4,107.8
X$10171 15 5896 5880 6013 6049 5707 27 AOI22_X4
* cell instance $10173 m0 *1 90.63,107.8
X$10173 6049 15 27 6014 BUF_X1
* cell instance $10176 r0 *1 90.44,107.8
X$10176 5963 15 27 6129 BUF_X1
* cell instance $10177 r0 *1 91.01,107.8
X$10177 5961 5960 15 27 6326 XNOR2_X2
* cell instance $10178 m0 *1 92.91,107.8
X$10178 5961 6051 6050 27 15 6052 AND3_X1
* cell instance $10179 m0 *1 91.58,107.8
X$10179 5707 5551 5963 6410 27 6010 15 OR4_X2
* cell instance $10181 m0 *1 94.05,107.8
X$10181 5962 6128 6051 27 5713 15 OAI21_X1
* cell instance $10182 m0 *1 94.81,107.8
X$10182 6054 15 27 6053 BUF_X1
* cell instance $10183 m0 *1 95.38,107.8
X$10183 6127 15 27 6051 INV_X1
* cell instance $10186 m0 *1 102.03,107.8
X$10186 6126 27 6214 15 BUF_X4
* cell instance $10190 r0 *1 92.91,107.8
X$10190 5961 6050 6051 15 5881 27 AOI21_X1
* cell instance $10191 r0 *1 93.67,107.8
X$10191 5637 5881 6052 15 27 6292 OR3_X1
* cell instance $10192 r0 *1 94.62,107.8
X$10192 6054 15 27 5962 INV_X2
* cell instance $10193 r0 *1 95.19,107.8
X$10193 5558 6055 6054 27 15 6127 HA_X1
* cell instance $10194 r0 *1 97.09,107.8
X$10194 6054 15 27 6149 BUF_X1
* cell instance $10199 r0 *1 107.92,107.8
X$10199 5381 6056 10883 27 15 6121 HA_X1
* cell instance $10201 r0 *1 110.01,107.8
X$10201 6121 15 27 6057 INV_X1
* cell instance $10203 m0 *1 110.77,107.8
X$10203 5970 6005 15 27 6058 XNOR2_X2
* cell instance $10205 m0 *1 112.67,107.8
X$10205 5969 15 27 5970 INV_X1
* cell instance $10206 m0 *1 113.05,107.8
X$10206 5970 5968 5971 15 6059 27 AOI21_X1
* cell instance $10207 m0 *1 113.81,107.8
X$10207 5970 5971 5968 27 15 6060 AND3_X1
* cell instance $10208 m0 *1 114.76,107.8
X$10208 5637 6060 6059 15 27 6061 OR3_X1
* cell instance $10213 r0 *1 110.58,107.8
X$10213 6057 5969 5840 27 15 6289 OAI21_X4
* cell instance $10215 r0 *1 113.43,107.8
X$10215 5558 6056 5969 27 15 6152 HA_X1
* cell instance $10220 r0 *1 115.71,107.8
X$10220 6061 15 27 6222 CLKBUF_X3
* cell instance $10221 r0 *1 116.66,107.8
X$10221 5972 15 27 6153 INV_X2
* cell instance $10228 r0 *1 125.21,107.8
X$10228 15 6179 6062 10802 5106 27 DFF_X2
* cell instance $10229 m0 *1 127.68,107.8
X$10229 15 6154 6062 10713 5199 27 DFF_X2
* cell instance $10230 m0 *1 126.73,107.8
X$10230 5192 15 27 6063 CLKBUF_X3
* cell instance $10231 m0 *1 131.29,107.8
X$10231 5383 6113 5973 15 6114 27 AOI21_X1
* cell instance $10232 m0 *1 132.05,107.8
X$10232 15 6114 6273 10723 5482 27 DFF_X2
* cell instance $10233 m0 *1 135.66,107.8
X$10233 5482 6063 15 27 6113 NAND2_X1
* cell instance $10235 m0 *1 139.27,107.8
X$10235 5974 6111 15 27 5453 XNOR2_X2
* cell instance $10236 m0 *1 141.17,107.8
X$10236 4510 4420 6066 27 15 6001 HA_X1
* cell instance $10237 m0 *1 143.07,107.8
X$10237 15 5915 6067 5998 6105 5999 27 FA_X1
* cell instance $10238 m0 *1 146.11,107.8
X$10238 15 6103 5976 5727 6259 5998 27 FA_X1
* cell instance $10239 m0 *1 149.15,107.8
X$10239 6101 5219 6068 27 15 6099 HA_X1
* cell instance $10241 r0 *1 128.82,107.8
X$10241 5106 6063 15 27 6178 NAND2_X1
* cell instance $10244 r0 *1 130.53,107.8
X$10244 5199 6063 15 27 6278 NAND2_X1
* cell instance $10250 r0 *1 136.99,107.8
X$10250 6064 6065 27 15 6155 XNOR2_X1
* cell instance $10254 r0 *1 140.22,107.8
X$10254 15 6107 6176 5889 6066 6108 27 FA_X1
* cell instance $10255 r0 *1 143.26,107.8
X$10255 6067 5975 27 15 6265 XNOR2_X1
* cell instance $10258 r0 *1 146.11,107.8
X$10258 6097 15 27 5999 INV_X1
* cell instance $10260 r0 *1 148.01,107.8
X$10260 15 6099 6261 5890 5994 6069 27 FA_X1
* cell instance $10262 m0 *1 151.62,107.8
X$10262 5591 5730 6101 27 15 5993 HA_X1
* cell instance $10264 m0 *1 153.52,107.8
X$10264 15 6092 6096 5994 5991 5993 27 FA_X1
* cell instance $10266 m0 *1 157.32,107.8
X$10266 15 5300 6071 5833 5390 6158 27 FA_X1
* cell instance $10269 r0 *1 152.76,107.8
X$10269 6096 15 27 6175 INV_X1
* cell instance $10270 r0 *1 153.14,107.8
X$10270 15 6070 6097 5992 6095 6171 27 FA_X1
* cell instance $10271 r0 *1 156.18,107.8
X$10271 15 6071 6095 5756 6174 6346 27 FA_X1
* cell instance $10273 r0 *1 159.98,107.8
X$10273 15 5300 6157 6092 5588 6158 27 FA_X1
* cell instance $10274 m0 *1 160.93,107.8
X$10274 15 5834 5991 6074 5473 5653 27 FA_X1
* cell instance $10276 m0 *1 163.97,107.8
X$10276 6075 15 27 5653 INV_X2
* cell instance $10279 r0 *1 163.02,107.8
X$10279 6074 6073 5906 27 15 6171 HA_X1
* cell instance $10281 m0 *1 165.87,107.8
X$10281 6076 15 27 5588 INV_X2
* cell instance $10285 m0 *1 167.39,107.8
X$10285 5978 5572 15 27 5892 NOR2_X1
* cell instance $10290 r0 *1 169.67,107.8
X$10290 6160 6091 6088 27 15 6078 HA_X1
* cell instance $10291 m0 *1 170.05,107.8
X$10291 6090 15 27 5987 INV_X1
* cell instance $10294 m0 *1 170.62,107.8
X$10294 15 6169 6090 5656 6076 6075 27 FA_X1
* cell instance $10296 m0 *1 173.85,107.8
X$10296 15 6166 6085 6079 6359 5576 27 FA_X1
* cell instance $10297 m0 *1 176.89,107.8
X$10297 6085 15 27 5982 INV_X1
* cell instance $10300 m0 *1 178.98,107.8
X$10300 6082 6351 5732 27 15 4995 HA_X1
* cell instance $10302 m0 *1 181.07,107.8
X$10302 15 6161 5898 6080 5479 6163 27 FA_X1
* cell instance $10308 r0 *1 171.95,107.8
X$10308 6077 15 27 6087 INV_X1
* cell instance $10309 r0 *1 172.33,107.8
X$10309 15 6088 6086 5983 6167 6087 27 FA_X1
* cell instance $10311 r0 *1 176.89,107.8
X$10311 6079 15 27 6084 INV_X1
* cell instance $10313 r0 *1 177.65,107.8
X$10313 6084 6350 6082 27 15 5979 HA_X1
* cell instance $10316 m0 *1 184.49,107.8
X$10316 6080 15 27 5980 INV_X1
* cell instance $10326 m0 *1 2.66,54.6
X$10326 15 2963 2755 2410 2249 1727 27 OR4_X4
* cell instance $10335 r0 *1 3.8,54.6
X$10335 1418 2249 2410 15 27 3047 OR3_X2
* cell instance $10338 r0 *1 5.51,54.6
X$10338 2963 2614 2711 27 2850 15 NOR3_X2
* cell instance $10339 m0 *1 6.46,54.6
X$10339 2963 2614 2711 15 27 2852 OR3_X4
* cell instance $10341 m0 *1 8.55,54.6
X$10341 2892 2712 2850 27 3051 15 NOR3_X2
* cell instance $10342 m0 *1 9.88,54.6
X$10342 2712 2850 2892 27 15 2851 OAI21_X2
* cell instance $10345 r0 *1 6.84,54.6
X$10345 15 2711 2614 2963 2925 2974 27 NOR4_X4
* cell instance $10346 r0 *1 10.26,54.6
X$10346 2926 15 27 2892 INV_X1
* cell instance $10348 r0 *1 10.83,54.6
X$10348 2926 2522 2853 15 27 3173 NAND3_X2
* cell instance $10349 r0 *1 12.16,54.6
X$10349 2621 2853 2789 15 27 3016 MUX2_X1
* cell instance $10350 m0 *1 13.68,54.6
X$10350 2852 27 2853 15 BUF_X4
* cell instance $10351 m0 *1 12.35,54.6
X$10351 1818 27 2927 15 BUF_X4
* cell instance $10356 r0 *1 15.2,54.6
X$10356 2927 2621 27 15 3092 XNOR2_X1
* cell instance $10361 r0 *1 20.71,54.6
X$10361 2260 550 15 27 3094 NOR2_X1
* cell instance $10364 m0 *1 21.47,54.6
X$10364 2259 2853 2893 15 27 2928 MUX2_X1
* cell instance $10366 m0 *1 24.51,54.6
X$10366 2854 2790 15 27 2723 NOR2_X1
* cell instance $10368 m0 *1 25.27,54.6
X$10368 2857 2929 2790 2626 15 27 2967 NAND4_X1
* cell instance $10370 m0 *1 27.74,54.6
X$10370 2791 2856 15 27 2855 NAND2_X2
* cell instance $10371 m0 *1 28.69,54.6
X$10371 2857 2855 15 27 2895 XOR2_X1
* cell instance $10372 m0 *1 29.83,54.6
X$10372 212 2528 2857 27 15 3026 HA_X1
* cell instance $10373 m0 *1 31.73,54.6
X$10373 2528 2858 2895 15 27 2977 MUX2_X1
* cell instance $10376 m0 *1 34.77,54.6
X$10376 2932 15 27 2897 BUF_X2
* cell instance $10377 m0 *1 35.53,54.6
X$10377 2862 2861 2896 15 2968 27 AOI21_X1
* cell instance $10379 m0 *1 36.48,54.6
X$10379 2861 2897 15 27 2933 NAND2_X1
* cell instance $10384 r0 *1 22.04,54.6
X$10384 3024 2260 550 3021 27 2975 15 NOR4_X2
* cell instance $10385 r0 *1 23.75,54.6
X$10385 3022 2967 15 27 3020 NOR2_X1
* cell instance $10386 r0 *1 24.32,54.6
X$10386 2966 2929 2790 15 27 3021 NAND3_X1
* cell instance $10388 r0 *1 25.27,54.6
X$10388 2930 2976 2966 15 27 3022 NAND3_X1
* cell instance $10390 r0 *1 26.22,54.6
X$10390 2857 2930 2976 2626 15 27 3024 NAND4_X1
* cell instance $10393 r0 *1 27.74,54.6
X$10393 2855 2857 27 2931 15 AND2_X4
* cell instance $10394 r0 *1 29.45,54.6
X$10394 2930 3026 2931 27 15 3052 OAI21_X4
* cell instance $10395 r0 *1 31.92,54.6
X$10395 2930 3026 2931 15 27 3096 OR3_X1
* cell instance $10398 r0 *1 33.44,54.6
X$10398 138 2977 2932 27 15 3028 HA_X1
* cell instance $10399 r0 *1 35.34,54.6
X$10399 3028 2897 2862 15 2978 27 AOI21_X1
* cell instance $10400 r0 *1 36.1,54.6
X$10400 2897 15 27 3097 INV_X1
* cell instance $10402 r0 *1 36.86,54.6
X$10402 2897 2968 27 15 3029 XNOR2_X1
* cell instance $10403 r0 *1 38,54.6
X$10403 2977 2629 3029 15 27 3164 MUX2_X1
* cell instance $10405 r0 *1 40.85,54.6
X$10405 2366 1616 15 27 2979 NOR2_X1
* cell instance $10406 r0 *1 41.42,54.6
X$10406 2979 3055 3162 27 15 2726 OAI21_X2
* cell instance $10407 r0 *1 42.75,54.6
X$10407 15 1631 3055 2727 3030 27 NOR3_X4
* cell instance $10408 m0 *1 42.94,54.6
X$10408 2365 27 2934 15 BUF_X4
* cell instance $10410 m0 *1 44.27,54.6
X$10410 2792 2865 15 3031 27 NAND2_X4
* cell instance $10414 r0 *1 45.41,54.6
X$10414 3056 3031 15 27 2980 XOR2_X1
* cell instance $10415 r0 *1 46.55,54.6
X$10415 2337 2052 15 27 3034 NAND2_X1
* cell instance $10418 r0 *1 47.69,54.6
X$10418 2794 15 27 3057 INV_X1
* cell instance $10420 r0 *1 49.59,54.6
X$10420 2366 2934 3034 15 27 3036 OR3_X1
* cell instance $10422 m0 *1 50.16,54.6
X$10422 3036 2338 27 15 2867 XNOR2_X1
* cell instance $10425 r0 *1 50.73,54.6
X$10425 2794 2981 27 15 3241 XNOR2_X1
* cell instance $10426 r0 *1 51.87,54.6
X$10426 3036 3168 27 15 2936 AND2_X2
* cell instance $10428 r0 *1 54.34,54.6
X$10428 2867 1631 15 27 3059 NAND2_X1
* cell instance $10429 m0 *1 54.91,54.6
X$10429 2935 27 2504 15 BUF_X4
* cell instance $10432 m0 *1 57.76,54.6
X$10432 2971 2936 27 2779 15 XOR2_X2
* cell instance $10435 m0 *1 63.27,54.6
X$10435 2867 2775 27 15 2871 AND2_X1
* cell instance $10437 m0 *1 67.07,54.6
X$10437 2799 2868 2938 15 27 2973 NAND3_X1
* cell instance $10439 m0 *1 68.02,54.6
X$10439 2868 2869 2870 15 27 2939 OR3_X1
* cell instance $10440 m0 *1 68.97,54.6
X$10440 2868 2870 2869 27 15 2986 OAI21_X4
* cell instance $10441 m0 *1 71.44,54.6
X$10441 2871 2908 27 15 2940 AND2_X1
* cell instance $10444 m0 *1 75.43,54.6
X$10444 195 2781 2872 27 15 2875 HA_X1
* cell instance $10445 m0 *1 77.33,54.6
X$10445 2873 2872 15 27 2910 NOR2_X1
* cell instance $10446 m0 *1 77.9,54.6
X$10446 2783 2874 2875 15 27 2941 NOR3_X1
* cell instance $10447 m0 *1 78.66,54.6
X$10447 2910 2783 2874 15 27 2911 NOR3_X1
* cell instance $10449 m0 *1 79.61,54.6
X$10449 2781 2379 2911 15 27 2877 MUX2_X1
* cell instance $10453 m0 *1 85.69,54.6
X$10453 2871 15 27 2943 INV_X1
* cell instance $10456 m0 *1 87.02,54.6
X$10456 2806 3130 27 15 2914 XNOR2_X1
* cell instance $10459 m0 *1 89.11,54.6
X$10459 295 2877 2944 27 15 2945 HA_X1
* cell instance $10460 m0 *1 91.01,54.6
X$10460 2944 2917 27 15 2948 AND2_X1
* cell instance $10461 m0 *1 91.77,54.6
X$10461 2917 2944 15 27 2947 NAND2_X1
* cell instance $10463 r0 *1 54.91,54.6
X$10463 2936 2934 15 27 3122 NAND2_X1
* cell instance $10466 r0 *1 56.43,54.6
X$10466 2934 1435 2937 15 27 NOR2_X4
* cell instance $10467 r0 *1 58.14,54.6
X$10467 2937 2504 15 27 2971 NAND2_X1
* cell instance $10468 r0 *1 58.71,54.6
X$10468 295 2797 2983 27 15 3039 HA_X1
* cell instance $10472 r0 *1 60.61,54.6
X$10472 3039 15 27 2982 INV_X1
* cell instance $10473 r0 *1 60.99,54.6
X$10473 2983 15 27 2984 INV_X1
* cell instance $10476 r0 *1 61.94,54.6
X$10476 3125 3126 3187 2972 27 15 3041 AND4_X1
* cell instance $10477 r0 *1 63.08,54.6
X$10477 2983 3040 27 15 3105 XNOR2_X1
* cell instance $10479 r0 *1 67.26,54.6
X$10479 2973 2376 550 15 27 2972 NOR3_X1
* cell instance $10482 r0 *1 68.59,54.6
X$10482 2985 2986 15 3190 27 NAND2_X4
* cell instance $10483 r0 *1 70.3,54.6
X$10483 2986 2939 27 15 2987 AND2_X1
* cell instance $10486 r0 *1 72.96,54.6
X$10486 3062 2988 15 27 2906 NAND2_X1
* cell instance $10490 r0 *1 75.62,54.6
X$10490 15 3062 2873 2872 2988 3128 27 NAND4_X4
* cell instance $10491 r0 *1 79.04,54.6
X$10491 2875 15 27 2989 INV_X1
* cell instance $10495 r0 *1 80.75,54.6
X$10495 2805 15 27 3063 INV_X1
* cell instance $10497 r0 *1 81.32,54.6
X$10497 2990 2942 15 2379 27 NAND2_X4
* cell instance $10498 r0 *1 83.03,54.6
X$10498 2990 2942 2876 27 15 2970 AND3_X2
* cell instance $10502 r0 *1 85.5,54.6
X$10502 15 3045 2779 2943 1616 2739 27 OR4_X4
* cell instance $10504 r0 *1 88.16,54.6
X$10504 2991 2806 2944 15 27 3283 NAND3_X2
* cell instance $10505 r0 *1 89.49,54.6
X$10505 2945 2740 2944 15 3104 27 AOI21_X2
* cell instance $10506 r0 *1 90.82,54.6
X$10506 2970 2946 15 27 2844 NOR2_X2
* cell instance $10508 r0 *1 91.96,54.6
X$10508 2948 2945 2991 27 2992 15 OAI21_X1
* cell instance $10510 m0 *1 92.72,54.6
X$10510 2784 15 27 2993 INV_X1
* cell instance $10511 m0 *1 93.86,54.6
X$10511 15 2306 27 2919 BUF_X8
* cell instance $10513 m0 *1 96.52,54.6
X$10513 2741 2871 15 27 2920 NAND2_X1
* cell instance $10515 r0 *1 92.72,54.6
X$10515 2844 2784 2948 27 3043 15 OAI21_X1
* cell instance $10516 r0 *1 93.48,54.6
X$10516 2945 2991 15 27 3068 NOR2_X1
* cell instance $10517 r0 *1 94.05,54.6
X$10517 2991 15 27 3044 INV_X1
* cell instance $10519 r0 *1 94.62,54.6
X$10519 2438 1435 15 27 3256 NOR2_X1
* cell instance $10522 r0 *1 96.14,54.6
X$10522 2877 2916 3069 27 15 3038 MUX2_X2
* cell instance $10523 m0 *1 97.66,54.6
X$10523 2878 2642 2742 15 2808 27 AOI21_X1
* cell instance $10526 m0 *1 99.94,54.6
X$10526 2808 2809 2879 27 2949 15 OAI21_X1
* cell instance $10527 m0 *1 100.7,54.6
X$10527 295 2915 2950 27 15 2969 HA_X1
* cell instance $10531 r0 *1 97.85,54.6
X$10531 2920 2994 2742 15 27 2878 NOR3_X1
* cell instance $10535 r0 *1 99.94,54.6
X$10535 2950 2949 27 15 2951 XNOR2_X1
* cell instance $10536 r0 *1 101.08,54.6
X$10536 2915 2132 2951 15 27 2995 MUX2_X1
* cell instance $10537 r0 *1 102.41,54.6
X$10537 15 3205 2969 2950 2879 27 AOI21_X4
* cell instance $10538 r0 *1 104.88,54.6
X$10538 1981 2923 2810 15 3032 27 AOI21_X1
* cell instance $10539 m0 *1 106.4,54.6
X$10539 195 2880 2952 27 15 3037 HA_X1
* cell instance $10540 m0 *1 105.26,54.6
X$10540 2952 2064 15 27 2924 XOR2_X1
* cell instance $10541 m0 *1 108.3,54.6
X$10541 2880 2224 2924 15 27 2881 MUX2_X1
* cell instance $10544 m0 *1 113.43,54.6
X$10544 2812 2840 15 27 2953 NAND2_X1
* cell instance $10545 m0 *1 114,54.6
X$10545 295 2881 2840 27 15 2954 HA_X1
* cell instance $10546 m0 *1 115.9,54.6
X$10546 2881 2648 15 27 2883 NAND2_X1
* cell instance $10550 r0 *1 106.78,54.6
X$10550 15 2996 3037 2952 2064 27 AOI21_X4
* cell instance $10554 r0 *1 113.24,54.6
X$10554 3076 2840 27 15 2997 AND2_X1
* cell instance $10555 r0 *1 114,54.6
X$10555 2953 2999 15 27 2998 NAND2_X1
* cell instance $10556 r0 *1 114.57,54.6
X$10556 2882 2999 15 3078 27 NAND2_X4
* cell instance $10560 r0 *1 116.28,54.6
X$10560 2954 15 27 2999 INV_X1
* cell instance $10562 m0 *1 117.04,54.6
X$10562 15 2197 27 3000 BUF_X8
* cell instance $10569 m0 *1 120.65,54.6
X$10569 2814 2052 3136 15 2746 27 AOI21_X1
* cell instance $10570 m0 *1 122.93,54.6
X$10570 2744 2814 27 15 3033 XNOR2_X1
* cell instance $10579 r0 *1 123.69,54.6
X$10579 3033 2955 550 15 27 3027 NOR3_X1
* cell instance $10582 r0 *1 125.02,54.6
X$10582 3030 2955 15 27 3001 OR2_X1
* cell instance $10584 r0 *1 125.97,54.6
X$10584 3032 2955 2956 27 3095 15 OAI21_X1
* cell instance $10588 m0 *1 128.25,54.6
X$10588 2913 2744 15 27 2650 XNOR2_X2
* cell instance $10589 r0 *1 128.44,54.6
X$10589 3001 2956 15 27 3242 NAND2_X1
* cell instance $10591 r0 *1 129.39,54.6
X$10591 2956 3001 27 15 3002 AND2_X2
* cell instance $10593 m0 *1 131.86,54.6
X$10593 2580 2957 15 27 3004 NOR2_X1
* cell instance $10594 m0 *1 130.53,54.6
X$10594 3000 27 2913 15 BUF_X4
* cell instance $10598 m0 *1 134.9,54.6
X$10598 2834 2816 27 15 2885 AND2_X1
* cell instance $10600 m0 *1 135.85,54.6
X$10600 2074 3006 3005 27 2965 15 NOR3_X2
* cell instance $10601 m0 *1 137.18,54.6
X$10601 2648 2817 15 27 2904 OR2_X2
* cell instance $10605 r0 *1 130.91,54.6
X$10605 2580 3002 15 27 3003 NOR2_X1
* cell instance $10606 r0 *1 131.48,54.6
X$10606 3003 2648 3004 15 27 3025 MUX2_X1
* cell instance $10608 r0 *1 133,54.6
X$10608 2957 3005 3002 15 27 2912 MUX2_X1
* cell instance $10609 r0 *1 134.33,54.6
X$10609 15 3005 2817 3220 2476 3023 27 AND4_X4
* cell instance $10610 r0 *1 136.8,54.6
X$10610 15 3025 2558 3023 2965 3012 2958 3017 27 OAI222_X2
* cell instance $10612 m0 *1 139.27,54.6
X$10612 2885 2904 2959 15 27 2907 NAND3_X2
* cell instance $10613 m0 *1 141.36,54.6
X$10613 15 2961 2964 2576 2831 2904 27 AOI22_X4
* cell instance $10614 m0 *1 144.59,54.6
X$10614 2960 2886 15 27 2751 XNOR2_X2
* cell instance $10615 m0 *1 146.49,54.6
X$10615 2886 2960 27 2481 15 XOR2_X2
* cell instance $10617 m0 *1 148.39,54.6
X$10617 2481 2655 2826 2821 27 15 2752 AND4_X2
* cell instance $10618 m0 *1 149.72,54.6
X$10618 2749 2560 3007 3011 2483 2659 15 27 OAI221_X2
* cell instance $10621 r0 *1 139.46,54.6
X$10621 2885 2904 3019 15 27 3014 NAND3_X1
* cell instance $10625 r0 *1 141.55,54.6
X$10625 15 3018 3015 3017 3082 2964 27 NOR4_X4
* cell instance $10627 r0 *1 145.16,54.6
X$10627 3014 3083 2961 15 2960 27 AOI21_X2
* cell instance $10631 r0 *1 148.58,54.6
X$10631 3012 2958 15 27 3011 OR2_X2
* cell instance $10633 r0 *1 149.72,54.6
X$10633 15 3011 3007 2961 2004 2560 27 OAI22_X4
* cell instance $10634 m0 *1 154.66,54.6
X$10634 2888 2823 2889 2753 27 15 2250 AND4_X2
* cell instance $10635 m0 *1 152.95,54.6
X$10635 2753 2889 2888 2156 15 2894 27 NAND4_X2
* cell instance $10636 m0 *1 155.99,54.6
X$10636 1650 2890 2887 15 2660 27 AOI21_X1
* cell instance $10640 r0 *1 153.52,54.6
X$10640 15 3143 3008 2890 2407 27 NOR3_X4
* cell instance $10641 r0 *1 156.18,54.6
X$10641 3010 3009 27 2753 15 XOR2_X2
* cell instance $10642 m0 *1 157.32,54.6
X$10642 2888 3085 15 27 1846 XNOR2_X2
* cell instance $10651 r0 *1 157.89,54.6
X$10651 3010 3009 15 27 2962 NAND2_X1
* cell instance $10664 m0 *1 2.09,49
X$10664 15 2032 2444 2110 2609 27 NOR3_X4
* cell instance $10666 m0 *1 4.94,49
X$10666 2252 2447 27 15 2520 XNOR2_X1
* cell instance $10667 m0 *1 6.08,49
X$10667 2032 2488 2520 27 15 2610 AND3_X1
* cell instance $10669 m0 *1 7.22,49
X$10669 2447 2162 2252 15 27 2612 NOR3_X1
* cell instance $10673 r0 *1 1.71,49
X$10673 1764 1968 2610 2609 2446 2711 15 27 OAI221_X2
* cell instance $10677 r0 *1 3.8,49
X$10677 2609 2610 15 27 2891 NOR2_X2
* cell instance $10678 r0 *1 4.75,49
X$10678 2611 2252 2610 1799 2446 3049 27 15 AOI221_X2
* cell instance $10679 r0 *1 6.84,49
X$10679 2611 2613 2612 2521 15 27 2757 OR4_X1
* cell instance $10680 r0 *1 7.98,49
X$10680 2613 2612 2522 2615 15 27 2662 OR4_X1
* cell instance $10682 m0 *1 8.36,49
X$10682 2110 2447 2162 27 15 2578 OAI21_X2
* cell instance $10683 m0 *1 9.88,49
X$10683 2523 2619 2617 2522 15 2616 27 NAND4_X2
* cell instance $10684 m0 *1 11.59,49
X$10684 2713 1550 2661 15 27 2444 MUX2_X1
* cell instance $10685 m0 *1 12.92,49
X$10685 408 2524 1499 27 2661 15 OAI21_X1
* cell instance $10686 m0 *1 13.68,49
X$10686 2525 2526 2162 27 15 2712 MUX2_X2
* cell instance $10689 r0 *1 9.12,49
X$10689 2524 1818 15 27 2615 NAND2_X1
* cell instance $10691 r0 *1 9.88,49
X$10691 15 2662 2663 2616 2618 3402 27 NAND4_X4
* cell instance $10693 r0 *1 13.49,49
X$10693 2490 2578 2620 2522 15 2663 27 NAND4_X2
* cell instance $10696 r0 *1 16.15,49
X$10696 388 2621 2527 27 15 2714 HA_X1
* cell instance $10698 m0 *1 20.71,49
X$10698 195 2259 2623 27 15 2664 HA_X1
* cell instance $10699 m0 *1 18.81,49
X$10699 295 2203 2495 27 15 2622 HA_X1
* cell instance $10703 m0 *1 31.92,49
X$10703 43 2451 2499 27 15 2529 HA_X1
* cell instance $10706 m0 *1 36.1,49
X$10706 2531 2364 2532 27 2668 15 OAI21_X1
* cell instance $10707 m0 *1 36.86,49
X$10707 2667 2531 2532 27 2627 15 OAI21_X1
* cell instance $10708 m0 *1 37.62,49
X$10708 2532 2364 2531 15 27 2628 OR3_X1
* cell instance $10709 m0 *1 38.57,49
X$10709 2669 15 27 2364 CLKBUF_X2
* cell instance $10712 m0 *1 45.6,49
X$10712 2631 2672 15 27 2673 XOR2_X1
* cell instance $10716 r0 *1 19.19,49
X$10716 2495 15 27 2718 INV_X1
* cell instance $10719 r0 *1 20.14,49
X$10719 2622 15 27 2717 INV_X1
* cell instance $10720 r0 *1 20.52,49
X$10720 15 2719 2664 2624 2623 27 AOI21_X4
* cell instance $10721 r0 *1 22.99,49
X$10721 2623 2624 15 27 2893 XOR2_X1
* cell instance $10723 r0 *1 25.65,49
X$10723 2665 15 27 LOGIC0_X1
* cell instance $10724 r0 *1 26.03,49
X$10724 43 2665 2625 27 15 2720 HA_X1
* cell instance $10725 r0 *1 27.93,49
X$10725 111 2761 2626 27 15 2722 HA_X1
* cell instance $10726 r0 *1 29.83,49
X$10726 2666 2499 2357 15 2761 27 AOI21_X2
* cell instance $10727 r0 *1 31.16,49
X$10727 2357 2451 2666 15 27 NOR2_X4
* cell instance $10730 r0 *1 36.1,49
X$10730 111 2723 2532 27 15 2725 HA_X1
* cell instance $10733 r0 *1 38.57,49
X$10733 2668 2628 27 15 2670 AND2_X1
* cell instance $10734 r0 *1 39.33,49
X$10734 2723 2629 2670 15 27 2630 MUX2_X1
* cell instance $10738 r0 *1 42.75,49
X$10738 212 2630 2631 27 15 2728 HA_X1
* cell instance $10740 r0 *1 45.41,49
X$10740 2672 2631 27 2766 15 AND2_X4
* cell instance $10741 r0 *1 47.12,49
X$10741 2630 2632 2673 15 27 2633 MUX2_X1
* cell instance $10745 m0 *1 50.16,49
X$10745 138 2633 2674 27 15 2675 HA_X1
* cell instance $10746 r0 *1 50.35,49
X$10746 2674 15 27 2634 BUF_X1
* cell instance $10749 r0 *1 51.87,49
X$10749 15 2730 2675 2634 2678 27 AOI21_X4
* cell instance $10750 m0 *1 52.82,49
X$10750 2634 2368 27 15 2676 XNOR2_X1
* cell instance $10751 m0 *1 52.44,49
X$10751 2634 15 27 2677 INV_X1
* cell instance $10752 m0 *1 53.96,49
X$10752 2675 15 27 2679 INV_X1
* cell instance $10756 r0 *1 54.34,49
X$10756 2677 2368 2679 27 2769 15 OAI21_X1
* cell instance $10757 r0 *1 55.1,49
X$10757 2633 2456 2676 15 27 2731 MUX2_X1
* cell instance $10763 m0 *1 59.28,49
X$10763 138 2595 2534 27 15 2680 HA_X1
* cell instance $10764 m0 *1 61.37,49
X$10764 2534 2372 2597 27 15 2635 OAI21_X4
* cell instance $10765 m0 *1 63.84,49
X$10765 2635 2682 27 15 2636 AND2_X1
* cell instance $10770 r0 *1 60.42,49
X$10770 2680 15 27 2681 INV_X1
* cell instance $10771 r0 *1 60.8,49
X$10771 2512 15 27 2211 INV_X2
* cell instance $10772 r0 *1 61.37,49
X$10772 2635 2681 15 2732 27 NAND2_X4
* cell instance $10773 r0 *1 63.08,49
X$10773 2595 2535 2636 15 27 2847 MUX2_X1
* cell instance $10775 m0 *1 65.93,49
X$10775 2512 2775 27 15 2683 XNOR2_X1
* cell instance $10777 m0 *1 67.07,49
X$10777 138 2600 2375 27 15 2686 HA_X1
* cell instance $10778 m0 *1 68.97,49
X$10778 2375 2457 2458 15 27 2637 OR3_X1
* cell instance $10779 m0 *1 69.92,49
X$10779 2536 2637 27 15 2735 AND2_X1
* cell instance $10780 m0 *1 70.68,49
X$10780 2686 15 27 2685 INV_X1
* cell instance $10785 r0 *1 66.69,49
X$10785 2211 2775 15 27 2737 XNOR2_X2
* cell instance $10786 r0 *1 68.59,49
X$10786 2685 2536 15 2734 27 NAND2_X4
* cell instance $10789 m0 *1 73.91,49
X$10789 138 2537 2689 27 15 2688 HA_X1
* cell instance $10791 m0 *1 75.81,49
X$10791 2689 15 27 2638 BUF_X1
* cell instance $10792 m0 *1 76.38,49
X$10792 2683 2691 15 27 2218 NAND2_X1
* cell instance $10793 m0 *1 76.95,49
X$10793 2301 2300 2683 15 2639 27 AOI21_X1
* cell instance $10794 m0 *1 77.71,49
X$10794 2638 2460 2692 27 15 2848 OAI21_X2
* cell instance $10795 m0 *1 79.04,49
X$10795 2640 2301 2693 27 2606 15 OAI21_X1
* cell instance $10796 m0 *1 79.8,49
X$10796 2538 2692 15 27 2605 NAND2_X1
* cell instance $10797 m0 *1 80.37,49
X$10797 2460 15 27 2693 INV_X1
* cell instance $10800 m0 *1 85.31,49
X$10800 2380 2306 2696 15 27 2539 MUX2_X1
* cell instance $10801 m0 *1 86.64,49
X$10801 2461 2462 2382 15 2641 27 AOI21_X1
* cell instance $10804 m0 *1 88.35,49
X$10804 2382 15 27 2383 INV_X1
* cell instance $10809 m0 *1 94.24,49
X$10809 2700 2306 2702 15 27 2129 MUX2_X1
* cell instance $10816 r0 *1 76.19,49
X$10816 2872 2638 27 15 2538 AND2_X1
* cell instance $10817 r0 *1 76.95,49
X$10817 2688 2638 2460 15 2802 27 AOI21_X1
* cell instance $10818 r0 *1 77.71,49
X$10818 2639 2460 2638 27 2909 15 OAI21_X1
* cell instance $10819 r0 *1 78.47,49
X$10819 2300 15 27 2785 INV_X1
* cell instance $10820 r0 *1 78.85,49
X$10820 2605 2640 15 27 2736 NOR2_X1
* cell instance $10821 r0 *1 79.42,49
X$10821 2638 2606 15 27 2694 XOR2_X1
* cell instance $10822 r0 *1 80.56,49
X$10822 2537 2379 2694 15 27 2738 MUX2_X1
* cell instance $10826 r0 *1 87.21,49
X$10826 2641 15 27 2787 INV_X1
* cell instance $10829 r0 *1 91.01,49
X$10829 2741 2737 15 27 2700 XNOR2_X2
* cell instance $10832 r0 *1 94.62,49
X$10832 1435 2742 2438 15 2643 27 AOI21_X1
* cell instance $10833 r0 *1 95.38,49
X$10833 2843 2643 15 27 2703 NAND2_X1
* cell instance $10834 r0 *1 95.95,49
X$10834 2644 2779 2703 15 2773 27 AOI21_X2
* cell instance $10836 r0 *1 98.04,49
X$10836 2779 2543 15 27 2778 NOR2_X1
* cell instance $10837 m0 *1 99.56,49
X$10837 2645 2604 27 15 2706 XNOR2_X1
* cell instance $10838 m0 *1 98.23,49
X$10838 2435 2132 2704 15 27 2880 MUX2_X1
* cell instance $10839 m0 *1 100.7,49
X$10839 2645 15 27 2468 INV_X1
* cell instance $10840 m0 *1 101.08,49
X$10840 195 2539 2645 27 15 2541 HA_X1
* cell instance $10847 r0 *1 99.94,49
X$10847 2541 15 27 2705 INV_X1
* cell instance $10848 r0 *1 100.32,49
X$10848 2705 2468 2604 27 15 2879 OAI21_X4
* cell instance $10849 r0 *1 102.79,49
X$10849 2539 2132 2706 15 27 3073 MUX2_X1
* cell instance $10852 m0 *1 107.16,49
X$10852 2601 15 27 LOGIC0_X1
* cell instance $10855 m0 *1 110.77,49
X$10855 2774 2545 15 27 2546 NOR2_X1
* cell instance $10856 m0 *1 110.2,49
X$10856 2543 2544 15 27 2545 NOR2_X1
* cell instance $10860 r0 *1 111.15,49
X$10860 2647 2397 2774 15 2646 27 AOI21_X2
* cell instance $10862 m0 *1 111.72,49
X$10862 2396 15 27 2470 INV_X1
* cell instance $10863 m0 *1 112.67,49
X$10863 2707 2598 15 27 2647 NAND2_X2
* cell instance $10868 r0 *1 112.86,49
X$10868 195 2267 2707 27 15 2812 HA_X1
* cell instance $10873 m0 *1 116.09,49
X$10873 2596 2140 2709 15 27 1809 MUX2_X1
* cell instance $10874 m0 *1 115.52,49
X$10874 2648 2544 15 27 2596 NOR2_X1
* cell instance $10875 m0 *1 117.42,49
X$10875 2548 2549 15 27 2649 NOR2_X1
* cell instance $10876 m0 *1 117.99,49
X$10876 111 2596 2550 27 15 2708 HA_X1
* cell instance $10877 m0 *1 119.89,49
X$10877 2708 2550 2548 15 2399 27 AOI21_X2
* cell instance $10881 r0 *1 115.71,49
X$10881 2547 2140 2710 15 27 1869 MUX2_X1
* cell instance $10882 r0 *1 117.04,49
X$10882 2550 2649 27 15 2709 XNOR2_X1
* cell instance $10884 r0 *1 118.37,49
X$10884 2549 2768 27 15 2710 XNOR2_X1
* cell instance $10885 r0 *1 119.51,49
X$10885 2650 1981 15 27 2768 NOR2_X1
* cell instance $10887 r0 *1 120.27,49
X$10887 2550 2549 27 15 2651 AND2_X1
* cell instance $10889 r0 *1 121.22,49
X$10889 2651 1981 2650 27 15 2315 OAI21_X2
* cell instance $10891 m0 *1 123.31,49
X$10891 2551 2552 15 27 2593 NOR2_X1
* cell instance $10893 m0 *1 123.88,49
X$10893 2552 15 27 2402 INV_X1
* cell instance $10894 m0 *1 124.26,49
X$10894 2552 2471 2593 15 27 2591 MUX2_X1
* cell instance $10895 m0 *1 125.59,49
X$10895 2554 2552 2319 15 2699 27 AOI21_X1
* cell instance $10896 m0 *1 126.35,49
X$10896 2554 15 27 2553 INV_X1
* cell instance $10897 m0 *1 126.73,49
X$10897 388 2557 2698 27 15 2554 HA_X1
* cell instance $10900 m0 *1 129.58,49
X$10900 2556 15 27 2557 INV_X1
* cell instance $10901 m0 *1 129.96,49
X$10901 2556 2589 2652 27 15 1949 MUX2_X2
* cell instance $10905 m0 *1 134.14,49
X$10905 2587 2476 15 27 2684 NAND2_X1
* cell instance $10906 m0 *1 134.71,49
X$10906 2476 2558 15 27 2687 NAND2_X1
* cell instance $10907 m0 *1 135.28,49
X$10907 2690 2476 2587 15 2561 27 AOI21_X2
* cell instance $10908 m0 *1 136.61,49
X$10908 2560 2559 2580 27 2582 15 OAI21_X1
* cell instance $10909 m0 *1 137.37,49
X$10909 15 2558 2560 2559 2322 27 NOR3_X4
* cell instance $10910 m0 *1 140.03,49
X$10910 2561 2480 2405 27 2562 15 OAI21_X1
* cell instance $10913 m0 *1 141.74,49
X$10913 15 2014 2564 2565 1914 27 AOI21_X4
* cell instance $10914 m0 *1 144.21,49
X$10914 2565 1914 27 15 2577 AND2_X1
* cell instance $10915 m0 *1 144.97,49
X$10915 2576 2654 2567 15 27 NOR2_X4
* cell instance $10917 m0 *1 146.87,49
X$10917 2567 2655 2481 15 27 2413 AND3_X4
* cell instance $10918 m0 *1 148.96,49
X$10918 15 2481 2655 2569 2407 2566 27 NAND4_X4
* cell instance $10919 m0 *1 152.38,49
X$10919 15 2823 2159 2082 2657 2569 27 AND4_X4
* cell instance $10920 m0 *1 154.85,49
X$10920 2159 2082 2657 15 27 2570 NAND3_X1
* cell instance $10930 r0 *1 123.69,49
X$10930 2551 2552 2697 2651 15 2955 27 NAND4_X2
* cell instance $10932 r0 *1 125.59,49
X$10932 2553 2402 2701 27 15 2695 OAI21_X2
* cell instance $10933 r0 *1 126.92,49
X$10933 2698 15 27 2552 CLKBUF_X2
* cell instance $10936 r0 *1 128.82,49
X$10936 2697 15 27 2763 INV_X1
* cell instance $10937 r0 *1 129.2,49
X$10937 2697 2695 15 27 2587 XNOR2_X2
* cell instance $10938 r0 *1 131.1,49
X$10938 15 2140 27 2652 BUF_X8
* cell instance $10939 r0 *1 133.57,49
X$10939 2652 27 1840 15 BUF_X4
* cell instance $10941 r0 *1 135.28,49
X$10941 2690 2831 15 27 1860 NOR2_X2
* cell instance $10942 r0 *1 136.23,49
X$10942 2559 2560 2687 2747 2684 2480 15 27 2653 OAI33_X1
* cell instance $10943 r0 *1 137.56,49
X$10943 2074 2582 2748 15 2150 27 AOI21_X2
* cell instance $10944 r0 *1 138.89,49
X$10944 2653 15 27 1900 BUF_X2
* cell instance $10945 r0 *1 139.65,49
X$10945 2653 15 27 2671 BUF_X2
* cell instance $10949 r0 *1 141.74,49
X$10949 2563 2671 15 27 1914 NAND2_X2
* cell instance $10950 r0 *1 142.69,49
X$10950 15 1641 2564 2750 2566 27 AOI21_X4
* cell instance $10953 r0 *1 146.87,49
X$10953 2759 2751 15 27 1950 NAND2_X2
* cell instance $10956 r0 *1 148.96,49
X$10956 2243 2246 2752 27 2568 15 OAI21_X1
* cell instance $10958 r0 *1 150.48,49
X$10958 15 2159 2823 2657 2656 2243 27 NAND4_X4
* cell instance $10959 r0 *1 153.9,49
X$10959 15 2660 2754 2658 2756 1845 27 AND4_X4
* cell instance $10960 r0 *1 156.37,49
X$10960 2753 2752 2243 2246 2754 15 27 OAI211_X2
* cell instance $10975 m0 *1 2.28,105
X$10975 5784 15 27 5821 BUF_X2
* cell instance $10978 m0 *1 4.75,105
X$10978 5785 15 27 5787 BUF_X2
* cell instance $10979 m0 *1 5.51,105
X$10979 5789 15 27 5686 BUF_X1
* cell instance $10985 r0 *1 1.71,105
X$10985 5856 15 27 5935 CLKBUF_X2
* cell instance $10992 r0 *1 6.08,105
X$10992 5933 15 27 5896 BUF_X2
* cell instance $10994 r0 *1 7.6,105
X$10994 15 10636 5789 5985 5995 27 DFF_X1
* cell instance $10996 m0 *1 8.74,105
X$10996 5786 15 27 5822 BUF_X2
* cell instance $10998 m0 *1 10.45,105
X$10998 5789 5184 15 27 5984 NAND2_X1
* cell instance $11002 r0 *1 10.83,105
X$11002 5687 5984 6081 15 5985 27 AOI21_X1
* cell instance $11007 r0 *1 14.44,105
X$11007 5936 5519 15 27 5788 NAND2_X1
* cell instance $11010 r0 *1 16.15,105
X$11010 15 5858 5995 10778 5936 27 DFF_X2
* cell instance $11011 m0 *1 19.19,105
X$11011 15 5790 5995 10732 5688 27 DFF_X2
* cell instance $11012 m0 *1 18.24,105
X$11012 5743 5688 15 27 5900 NAND2_X2
* cell instance $11016 m0 *1 27.55,105
X$11016 5791 5692 5908 5693 5793 27 15 5278 OAI221_X1
* cell instance $11017 m0 *1 28.69,105
X$11017 5356 5691 15 27 5908 NAND2_X1
* cell instance $11018 m0 *1 29.26,105
X$11018 5794 15 27 5913 INV_X1
* cell instance $11019 m0 *1 29.64,105
X$11019 5792 5622 5913 15 5943 27 AOI21_X2
* cell instance $11021 m0 *1 31.16,105
X$11021 5795 15 27 5792 INV_X1
* cell instance $11022 m0 *1 31.54,105
X$11022 5795 5695 5794 27 15 5916 OAI21_X2
* cell instance $11023 m0 *1 32.87,105
X$11023 5861 5795 5796 27 15 5842 OAI21_X2
* cell instance $11024 m0 *1 34.2,105
X$11024 15 5735 5863 5690 5918 5531 27 AOI22_X4
* cell instance $11025 m0 *1 37.43,105
X$11025 15 5787 5863 5694 5918 5920 27 AOI22_X4
* cell instance $11026 m0 *1 40.66,105
X$11026 5531 5920 5848 27 6009 15 NOR3_X2
* cell instance $11030 m0 *1 46.74,105
X$11030 5438 15 27 5865 INV_X1
* cell instance $11032 r0 *1 19.76,105
X$11032 5747 5859 5830 5860 5900 5790 15 27 OAI221_X2
* cell instance $11036 r0 *1 23.18,105
X$11036 5185 5909 15 6002 27 NAND2_X4
* cell instance $11037 r0 *1 24.89,105
X$11037 5693 5859 5692 5860 6002 5903 15 27 OAI221_X2
* cell instance $11039 r0 *1 27.17,105
X$11039 15 5691 5909 27 BUF_X16
* cell instance $11041 r0 *1 32.3,105
X$11041 5792 6008 15 27 5944 XNOR2_X2
* cell instance $11043 r0 *1 34.39,105
X$11043 5861 5795 5670 27 15 6100 OAI21_X4
* cell instance $11044 r0 *1 36.86,105
X$11044 5670 27 6008 15 BUF_X4
* cell instance $11045 r0 *1 38.19,105
X$11045 6009 5862 5142 15 27 5946 NAND3_X2
* cell instance $11046 r0 *1 39.52,105
X$11046 5945 5797 5842 15 5948 27 AOI21_X2
* cell instance $11047 r0 *1 40.85,105
X$11047 5864 5950 15 27 6011 NAND2_X1
* cell instance $11048 r0 *1 41.42,105
X$11048 5916 15 27 5949 INV_X2
* cell instance $11049 r0 *1 41.99,105
X$11049 6106 15 27 5950 INV_X1
* cell instance $11050 r0 *1 42.37,105
X$11050 5188 6040 10893 27 15 5951 HA_X1
* cell instance $11053 r0 *1 44.84,105
X$11053 15 5822 5863 5859 5918 5865 27 AOI22_X4
* cell instance $11055 m0 *1 47.5,105
X$11055 5538 5626 5438 5923 15 27 5848 NAND4_X1
* cell instance $11057 r0 *1 48.07,105
X$11057 5538 15 27 6112 INV_X1
* cell instance $11063 m0 *1 2.28,46.2
X$11063 858 1104 27 15 2352 AND2_X1
* cell instance $11064 m0 *1 3.04,46.2
X$11064 2331 2352 15 27 2353 NAND2_X1
* cell instance $11065 m0 *1 3.61,46.2
X$11065 15 2755 858 1903 1104 27 AOI21_X4
* cell instance $11066 m0 *1 6.08,46.2
X$11066 1903 2411 2491 27 15 2446 OAI21_X2
* cell instance $11072 r0 *1 2.09,46.2
X$11072 2110 2032 2444 15 27 2443 OR3_X1
* cell instance $11076 r0 *1 3.04,46.2
X$11076 2573 2443 2574 2353 1903 2572 27 15 AOI221_X2
* cell instance $11077 r0 *1 5.13,46.2
X$11077 1799 15 27 2574 INV_X1
* cell instance $11078 r0 *1 5.51,46.2
X$11078 2520 2488 2032 15 27 2573 NAND3_X1
* cell instance $11079 r0 *1 6.27,46.2
X$11079 2444 2032 15 27 2611 NOR2_X1
* cell instance $11080 r0 *1 6.84,46.2
X$11080 2445 15 27 2488 INV_X1
* cell instance $11081 r0 *1 7.22,46.2
X$11081 2445 2162 15 27 2521 NOR2_X1
* cell instance $11085 m0 *1 10.07,46.2
X$11085 357 2110 27 15 2448 XNOR2_X1
* cell instance $11087 r0 *1 10.07,46.2
X$11087 2162 2447 2448 15 27 2523 OR3_X1
* cell instance $11088 r0 *1 11.02,46.2
X$11088 2162 2447 2448 27 2619 15 OAI21_X1
* cell instance $11090 r0 *1 12.16,46.2
X$11090 2524 2355 2525 1499 27 15 2445 OAI22_X2
* cell instance $11091 m0 *1 13.3,46.2
X$11091 2354 15 27 2525 INV_X1
* cell instance $11093 m0 *1 13.68,46.2
X$11093 2354 1550 2162 27 15 2522 MUX2_X2
* cell instance $11094 m0 *1 15.39,46.2
X$11094 2355 2275 2356 15 27 2494 MUX2_X1
* cell instance $11096 m0 *1 18.24,46.2
X$11096 2493 15 27 2621 BUF_X2
* cell instance $11100 r0 *1 13.87,46.2
X$11100 1550 15 27 2526 INV_X1
* cell instance $11104 r0 *1 19.19,46.2
X$11104 15 550 2581 2260 2494 2614 27 NOR4_X4
* cell instance $11105 r0 *1 22.61,46.2
X$11105 2276 2623 2495 2584 15 2581 27 NAND4_X2
* cell instance $11106 m0 *1 24.13,46.2
X$11106 138 2358 2276 27 15 2496 HA_X1
* cell instance $11108 m0 *1 26.03,46.2
X$11108 2358 2357 2359 15 27 2497 MUX2_X1
* cell instance $11110 m0 *1 27.55,46.2
X$11110 2278 2360 15 27 2498 XOR2_X1
* cell instance $11111 m0 *1 28.69,46.2
X$11111 2097 2357 2498 15 27 2859 MUX2_X1
* cell instance $11115 r0 *1 24.51,46.2
X$11115 2496 15 27 2583 INV_X1
* cell instance $11116 r0 *1 24.89,46.2
X$11116 2414 2583 15 2624 27 NAND2_X4
* cell instance $11118 r0 *1 26.79,46.2
X$11118 2449 2499 2527 2278 27 15 2584 AND4_X1
* cell instance $11121 r0 *1 31.16,46.2
X$11121 2361 2357 2586 15 27 2528 MUX2_X1
* cell instance $11122 m0 *1 31.35,46.2
X$11122 111 2361 2449 27 15 2501 HA_X1
* cell instance $11124 m0 *1 33.25,46.2
X$11124 2501 15 27 2415 INV_X1
* cell instance $11126 m0 *1 33.82,46.2
X$11126 2415 2450 15 27 2360 NAND2_X2
* cell instance $11128 m0 *1 34.96,46.2
X$11128 2362 15 27 2451 INV_X4
* cell instance $11131 r0 *1 32.49,46.2
X$11131 2449 2529 2499 27 15 2450 OAI21_X2
* cell instance $11132 r0 *1 33.82,46.2
X$11132 2449 2499 2529 15 27 2530 OR3_X1
* cell instance $11133 r0 *1 34.77,46.2
X$11133 2450 2530 27 15 2586 AND2_X1
* cell instance $11135 m0 *1 37.24,46.2
X$11135 2364 15 27 2363 INV_X1
* cell instance $11138 m0 *1 40.66,46.2
X$11138 2364 2283 27 15 2590 XNOR2_X1
* cell instance $11140 m0 *1 41.99,46.2
X$11140 2281 2451 1435 27 2288 15 NOR3_X2
* cell instance $11142 m0 *1 43.51,46.2
X$11142 2284 2052 2337 15 2727 27 AOI21_X2
* cell instance $11143 m0 *1 44.84,46.2
X$11143 2504 2288 15 27 2420 NAND2_X1
* cell instance $11144 m0 *1 45.41,46.2
X$11144 111 2452 2422 27 15 2505 HA_X1
* cell instance $11145 m0 *1 47.31,46.2
X$11145 2505 15 27 2453 INV_X1
* cell instance $11147 r0 *1 38.57,46.2
X$11147 43 2282 2669 27 15 2531 HA_X1
* cell instance $11149 r0 *1 40.85,46.2
X$11149 2282 2629 2590 15 27 2452 MUX2_X1
* cell instance $11151 r0 *1 42.56,46.2
X$11151 15 2512 2451 2283 2337 27 AOI21_X4
* cell instance $11154 r0 *1 46.17,46.2
X$11154 2453 2506 15 27 2672 NAND2_X2
* cell instance $11156 r0 *1 47.31,46.2
X$11156 2452 2632 2592 15 27 2455 MUX2_X1
* cell instance $11157 m0 *1 48.26,46.2
X$11157 2506 2507 27 15 2592 AND2_X1
* cell instance $11163 r0 *1 50.92,46.2
X$11163 2287 2121 2594 2454 27 15 2533 AND4_X1
* cell instance $11164 m0 *1 51.11,46.2
X$11164 212 2455 2454 27 15 2207 HA_X1
* cell instance $11166 m0 *1 53.01,46.2
X$11166 2208 2206 2369 27 15 2678 OAI21_X4
* cell instance $11168 m0 *1 55.67,46.2
X$11168 2341 2370 27 15 2510 AND2_X1
* cell instance $11169 m0 *1 56.43,46.2
X$11169 2367 2456 2510 15 27 2371 MUX2_X1
* cell instance $11170 m0 *1 57.76,46.2
X$11170 2211 2456 2426 15 27 2514 MUX2_X1
* cell instance $11173 r0 *1 52.06,46.2
X$11173 2454 2206 27 15 2509 XNOR2_X1
* cell instance $11174 r0 *1 53.2,46.2
X$11174 2455 2456 2509 15 27 2595 MUX2_X1
* cell instance $11184 m0 *1 2.09,91
X$11184 5018 15 27 4968 BUF_X1
* cell instance $11197 r0 *1 4.18,91
X$11197 5097 15 27 5016 BUF_X1
* cell instance $11200 m0 *1 13.11,91
X$11200 15 10384 5018 5054 5017 27 DFF_X1
* cell instance $11205 r0 *1 14.82,91
X$11205 15 10575 5097 5163 4885 27 DFF_X1
* cell instance $11206 m0 *1 16.91,91
X$11206 5018 4980 15 27 5019 NAND2_X1
* cell instance $11208 m0 *1 17.48,91
X$11208 4979 5019 5020 15 5054 27 AOI21_X1
* cell instance $11210 m0 *1 18.43,91
X$11210 5021 5056 5057 15 5055 27 AOI21_X1
* cell instance $11213 r0 *1 18.05,91
X$11213 5097 4980 15 27 5118 NAND2_X1
* cell instance $11214 r0 *1 18.62,91
X$11214 4885 15 27 CLKBUF_X1
* cell instance $11217 r0 *1 21.47,91
X$11217 5119 5144 15 27 5057 NAND2_X1
* cell instance $11218 r0 *1 22.04,91
X$11218 4336 4888 15 27 5138 NAND2_X1
* cell instance $11220 r0 *1 22.8,91
X$11220 15 10601 5053 5120 5139 27 DFF_X1
* cell instance $11221 m0 *1 25.84,91
X$11221 5021 5060 5187 15 5023 27 AOI21_X1
* cell instance $11225 r0 *1 26.03,91
X$11225 5053 4888 15 27 5098 NAND2_X1
* cell instance $11226 r0 *1 26.6,91
X$11226 5021 5098 5165 15 5120 27 AOI21_X1
* cell instance $11229 m0 *1 28.5,91
X$11229 5021 4975 5140 15 5061 27 AOI21_X1
* cell instance $11231 m0 *1 32.87,91
X$11231 2055 15 27 4979 CLKBUF_X3
* cell instance $11239 r0 *1 34.01,91
X$11239 5188 5279 10907 27 15 5125 HA_X1
* cell instance $11241 r0 *1 36.1,91
X$11241 5217 27 5170 15 BUF_X4
* cell instance $11242 r0 *1 37.43,91
X$11242 5125 5189 5143 15 5325 27 AOI21_X2
* cell instance $11244 m0 *1 39.71,91
X$11244 5024 15 27 4887 CLKBUF_X3
* cell instance $11246 m0 *1 40.66,91
X$11246 4887 15 27 CLKBUF_X1
* cell instance $11250 m0 *1 43.7,91
X$11250 1394 5026 5027 15 5062 27 AOI21_X1
* cell instance $11252 m0 *1 44.65,91
X$11252 15 5028 4887 10684 29 27 DFF_X2
* cell instance $11255 r0 *1 40.47,91
X$11255 5272 15 27 5221 INV_X1
* cell instance $11258 r0 *1 41.99,91
X$11258 5126 5144 15 27 5025 NAND2_X1
* cell instance $11262 r0 *1 45.03,91
X$11262 5127 5144 15 27 5029 NAND2_X1
* cell instance $11264 r0 *1 48.64,91
X$11264 15 5178 4887 10779 33 27 DFF_X2
* cell instance $11266 m0 *1 48.64,91
X$11266 15 5030 4887 10680 30 27 DFF_X2
* cell instance $11268 m0 *1 56.24,91
X$11268 34 4980 15 27 5100 NAND2_X1
* cell instance $11269 m0 *1 52.63,91
X$11269 15 5067 5101 10724 18 27 DFF_X2
* cell instance $11270 m0 *1 56.81,91
X$11270 36 4980 15 27 5228 NAND2_X1
* cell instance $11275 r0 *1 53.2,91
X$11275 5099 15 27 4980 CLKBUF_X3
* cell instance $11277 r0 *1 54.34,91
X$11277 4979 5129 5146 15 5067 27 AOI21_X1
* cell instance $11278 r0 *1 55.1,91
X$11278 15 5147 5101 10792 34 27 DFF_X2
* cell instance $11284 m0 *1 64.6,91
X$11284 4893 4982 4892 27 15 4942 AND3_X1
* cell instance $11286 m0 *1 69.54,91
X$11286 15 5133 5033 10716 39 27 DFF_X2
* cell instance $11291 r0 *1 67.26,91
X$11291 19 38 5102 27 5232 15 OAI21_X1
* cell instance $11292 r0 *1 68.02,91
X$11292 5099 19 15 27 5102 NAND2_X1
* cell instance $11293 r0 *1 68.59,91
X$11293 19 15 27 5181 INV_X1
* cell instance $11297 r0 *1 71.44,91
X$11297 1298 5151 27 15 5133 AND2_X1
* cell instance $11299 m0 *1 73.72,91
X$11299 15 5103 5033 10664 17 27 DFF_X2
* cell instance $11303 m0 *1 79.61,91
X$11303 3594 5015 15 27 5079 OR2_X1
* cell instance $11308 r0 *1 73.91,91
X$11308 5152 5134 15 27 5103 NAND2_X1
* cell instance $11309 r0 *1 74.48,91
X$11309 5153 17 15 27 5134 NAND2_X1
* cell instance $11312 r0 *1 78.85,91
X$11312 15 5104 5033 10812 37 27 DFF_X2
* cell instance $11313 r0 *1 82.46,91
X$11313 37 5099 15 27 5180 NAND2_X1
* cell instance $11316 m0 *1 85.31,91
X$11316 970 2102 5034 27 15 5035 HA_X1
* cell instance $11321 r0 *1 86.26,91
X$11321 15 2099 5154 5136 5035 728 27 FA_X1
* cell instance $11325 m0 *1 97.66,91
X$11325 4960 4985 15 27 5036 XNOR2_X2
* cell instance $11330 r0 *1 97.66,91
X$11330 15 10559 5135 5105 5289 27 DFF_X1
* cell instance $11331 r0 *1 100.89,91
X$11331 5135 2059 1536 27 15 5105 MUX2_X2
* cell instance $11332 m0 *1 102.41,91
X$11332 5092 5036 27 4590 15 XOR2_X2
* cell instance $11341 m0 *1 140.79,91
X$11341 5179 5095 5096 27 15 5094 HA_X1
* cell instance $11342 m0 *1 142.69,91
X$11342 5096 15 27 5132 INV_X1
* cell instance $11359 r0 *1 142.31,91
X$11359 5218 15 27 5131 INV_X1
* cell instance $11361 r0 *1 143.07,91
X$11361 15 4993 5177 5130 5132 5131 27 FA_X1
* cell instance $11363 m0 *1 143.45,91
X$11363 5175 5094 5088 27 15 5176 HA_X1
* cell instance $11364 m0 *1 146.87,91
X$11364 15 5172 5087 5038 5088 5083 27 FA_X1
* cell instance $11365 m0 *1 149.91,91
X$11365 5107 15 27 5083 INV_X1
* cell instance $11368 r0 *1 146.11,91
X$11368 15 5130 5198 5128 4830 5174 27 FA_X1
* cell instance $11370 r0 *1 149.34,91
X$11370 15 5109 5107 4909 5128 5108 27 FA_X1
* cell instance $11371 m0 *1 152.38,91
X$11371 15 5081 5109 4847 5171 5111 27 FA_X1
* cell instance $11373 m0 *1 155.42,91
X$11373 5082 15 27 5081 INV_X1
* cell instance $11374 m0 *1 155.8,91
X$11374 15 5040 5082 4912 5406 5077 27 FA_X1
* cell instance $11379 r0 *1 154.09,91
X$11379 5110 15 27 5111 INV_X1
* cell instance $11381 m0 *1 160.17,91
X$11381 15 5169 5078 5075 5168 4782 27 FA_X1
* cell instance $11385 m0 *1 164.16,91
X$11385 5075 15 27 5076 INV_X1
* cell instance $11386 m0 *1 164.54,91
X$11386 5042 5041 4915 27 15 5070 HA_X1
* cell instance $11388 m0 *1 167.2,91
X$11388 5167 15 27 5072 INV_X1
* cell instance $11391 m0 *1 168.53,91
X$11391 5166 15 27 5069 INV_X1
* cell instance $11392 m0 *1 168.91,91
X$11392 15 5069 4917 4921 5124 5066 27 FA_X1
* cell instance $11393 m0 *1 171.95,91
X$11393 5122 15 27 5066 INV_X1
* cell instance $11395 m0 *1 173.85,91
X$11395 4332 5044 5046 27 15 5045 HA_X1
* cell instance $11400 r0 *1 169.86,91
X$11400 5320 15 27 5124 INV_X1
* cell instance $11401 r0 *1 170.24,91
X$11401 5123 5112 5043 27 15 5122 HA_X1
* cell instance $11406 r0 *1 175.18,91
X$11406 5113 15 27 5114 INV_X1
* cell instance $11408 m0 *1 176.32,91
X$11408 15 5164 4926 4697 5260 5046 27 FA_X1
* cell instance $11414 r0 *1 180.88,91
X$11414 5121 15 27 4839 INV_X1
* cell instance $11415 r0 *1 181.26,91
X$11415 4594 5115 10910 27 15 5117 HA_X1
* cell instance $11416 m0 *1 181.45,91
X$11416 15 5050 5048 5058 5049 4506 27 FA_X1
* cell instance $11419 m0 *1 184.68,91
X$11419 5117 5058 5051 27 15 5052 HA_X1
* cell instance $11423 r0 *1 183.73,91
X$11423 5106 15 27 5160 BUF_X1
* cell instance $11426 r0 *1 184.87,91
X$11426 4995 15 27 5203 INV_X1
* cell instance $11427 r0 *1 185.25,91
X$11427 5058 15 27 5207 INV_X1
* cell instance $11428 r0 *1 185.63,91
X$11428 5117 15 27 5159 INV_X1
* cell instance $11431 r0 *1 186.58,91
X$11431 5162 15 27 5116 BUF_X1
* cell instance $11432 m0 *1 187.15,91
X$11432 5039 15 27 4997 BUF_X1
* cell instance $11442 r0 *1 1.52,155.4
X$11442 8837 15 27 8730 BUF_X1
* cell instance $11444 m0 *1 1.71,155.4
X$11444 8660 15 27 8495 BUF_X1
* cell instance $11446 m0 *1 2.85,155.4
X$11446 8657 15 27 8565 BUF_X1
* cell instance $11448 m0 *1 3.42,155.4
X$11448 8662 15 27 8656 BUF_X1
* cell instance $11449 m0 *1 3.99,155.4
X$11449 8808 15 27 8655 BUF_X1
* cell instance $11450 m0 *1 4.56,155.4
X$11450 8657 7850 15 27 8659 NAND2_X1
* cell instance $11451 m0 *1 5.13,155.4
X$11451 8189 8659 8609 15 8658 27 AOI21_X1
* cell instance $11457 r0 *1 4.37,155.4
X$11457 15 10486 8657 8658 8567 27 DFF_X1
* cell instance $11459 m0 *1 6.27,155.4
X$11459 8660 7850 15 27 8661 NAND2_X1
* cell instance $11460 m0 *1 7.6,155.4
X$11460 15 10379 8662 8696 8567 27 DFF_X1
* cell instance $11461 m0 *1 10.83,155.4
X$11461 8662 7924 15 27 8663 NAND2_X1
* cell instance $11462 m0 *1 11.4,155.4
X$11462 8189 8663 8621 15 8696 27 AOI21_X1
* cell instance $11466 r0 *1 10.83,155.4
X$11466 15 10483 8568 8770 8916 27 DFF_X1
* cell instance $11467 m0 *1 13.11,155.4
X$11467 8189 8664 8618 15 8770 27 AOI21_X1
* cell instance $11468 m0 *1 12.54,155.4
X$11468 8568 7924 15 27 8664 NAND2_X1
* cell instance $11471 r0 *1 14.06,155.4
X$11471 6960 8732 15 27 8771 NAND2_X1
* cell instance $11472 r0 *1 14.63,155.4
X$11472 8007 8732 15 27 7593 NAND2_X1
* cell instance $11474 m0 *1 19.38,155.4
X$11474 7112 6649 6922 6682 8703 8777 15 27 OAI221_X2
* cell instance $11475 m0 *1 15.77,155.4
X$11475 15 8569 8501 10704 7801 27 DFF_X2
* cell instance $11476 m0 *1 21.47,155.4
X$11476 15 8571 8501 10710 8105 27 DFF_X2
* cell instance $11481 r0 *1 18.81,155.4
X$11481 15 10605 7754 8499 8501 27 DFF_X1
* cell instance $11482 r0 *1 22.04,155.4
X$11482 15 8777 8501 10765 8007 27 DFF_X2
* cell instance $11484 r0 *1 25.84,155.4
X$11484 8733 7275 8734 15 27 8100 MUX2_X1
* cell instance $11485 m0 *1 31.73,155.4
X$11485 8705 8103 8572 15 27 8573 MUX2_X1
* cell instance $11486 m0 *1 26.98,155.4
X$11486 15 7448 7232 27 BUF_X16
* cell instance $11488 m0 *1 33.82,155.4
X$11488 8665 7448 8666 15 27 8197 MUX2_X1
* cell instance $11492 r0 *1 27.17,155.4
X$11492 8733 7448 8734 15 27 8367 MUX2_X1
* cell instance $11496 r0 *1 35.72,155.4
X$11496 5791 8736 8779 8667 5793 27 15 8780 OAI221_X1
* cell instance $11497 r0 *1 36.86,155.4
X$11497 8373 8668 15 27 8779 NAND2_X1
* cell instance $11500 r0 *1 38,155.4
X$11500 5697 8736 8782 8667 5694 27 15 8735 OAI221_X1
* cell instance $11501 r0 *1 39.14,155.4
X$11501 8308 8668 15 27 8782 NAND2_X1
* cell instance $11502 m0 *1 39.52,155.4
X$11502 15 7624 7448 27 BUF_X16
* cell instance $11512 m0 *1 5.32,96.6
X$11512 5287 15 27 5276 BUF_X1
* cell instance $11516 m0 *1 11.21,96.6
X$11516 15 10298 5237 5305 5017 27 DFF_X1
* cell instance $11517 m0 *1 14.44,96.6
X$11517 4979 5304 5583 15 5305 27 AOI21_X1
* cell instance $11519 m0 *1 15.96,96.6
X$11519 5277 5184 15 27 5399 NAND2_X1
* cell instance $11521 m0 *1 16.72,96.6
X$11521 4979 5399 5431 15 5398 27 AOI21_X1
* cell instance $11524 m0 *1 26.6,96.6
X$11524 15 5278 5139 10673 5356 27 DFF_X2
* cell instance $11525 m0 *1 30.21,96.6
X$11525 5280 5315 5239 27 15 5432 HA_X1
* cell instance $11526 m0 *1 32.11,96.6
X$11526 5240 15 27 5358 INV_X1
* cell instance $11536 r0 *1 14.63,96.6
X$11536 15 10542 5277 5398 4885 27 DFF_X1
* cell instance $11540 r0 *1 25.08,96.6
X$11540 5024 15 27 5139 CLKBUF_X3
* cell instance $11542 r0 *1 26.79,96.6
X$11542 15 5355 5139 10742 5269 27 DFF_X2
* cell instance $11544 r0 *1 30.78,96.6
X$11544 5358 5322 5359 15 5357 27 AOI21_X2
* cell instance $11545 r0 *1 32.11,96.6
X$11545 5358 5359 5322 27 15 5522 AND3_X1
* cell instance $11546 m0 *1 33.06,96.6
X$11546 5280 5279 5323 27 15 5410 HA_X1
* cell instance $11549 m0 *1 35.15,96.6
X$11549 5413 5414 5323 27 5322 15 OAI21_X1
* cell instance $11550 m0 *1 35.91,96.6
X$11550 5323 15 27 5189 INV_X2
* cell instance $11555 r0 *1 33.44,96.6
X$11555 5410 15 27 5359 INV_X1
* cell instance $11558 r0 *1 34.39,96.6
X$11558 5240 5497 5410 27 15 5496 OAI21_X2
* cell instance $11560 r0 *1 35.91,96.6
X$11560 5189 5361 5433 15 5497 27 AOI21_X2
* cell instance $11561 r0 *1 37.24,96.6
X$11561 5189 5361 5433 27 15 5500 AND3_X1
* cell instance $11562 r0 *1 38.19,96.6
X$11562 5414 15 27 5361 INV_X1
* cell instance $11564 r0 *1 38.76,96.6
X$11564 5280 5434 5223 27 15 5414 HA_X1
* cell instance $11566 m0 *1 41.99,96.6
X$11566 15 5362 5329 5418 5332 27 AOI21_X4
* cell instance $11567 m0 *1 40.66,96.6
X$11567 5329 5418 5331 15 5328 27 AOI21_X2
* cell instance $11568 m0 *1 44.46,96.6
X$11568 5282 5241 5364 27 15 5332 OAI21_X4
* cell instance $11571 m0 *1 47.88,96.6
X$11571 5188 5537 10864 27 15 5421 HA_X1
* cell instance $11575 r0 *1 40.85,96.6
X$11575 5223 5530 5435 27 15 5433 OAI21_X2
* cell instance $11577 r0 *1 42.37,96.6
X$11577 5331 15 27 5502 BUF_X1
* cell instance $11578 r0 *1 42.94,96.6
X$11578 5362 15 27 5501 BUF_X1
* cell instance $11581 r0 *1 44.08,96.6
X$11581 5280 5363 5596 27 15 5595 HA_X1
* cell instance $11582 r0 *1 45.98,96.6
X$11582 5241 5437 27 15 5438 XNOR2_X1
* cell instance $11583 r0 *1 47.12,96.6
X$11583 5421 5439 5503 15 5365 27 AOI21_X2
* cell instance $11584 r0 *1 48.45,96.6
X$11584 15 5364 5421 5439 5505 27 AOI21_X4
* cell instance $11585 r0 *1 50.92,96.6
X$11585 5188 5542 10909 27 15 5504 HA_X1
* cell instance $11586 r0 *1 52.82,96.6
X$11586 5504 15 27 5441 INV_X1
* cell instance $11589 r0 *1 54.15,96.6
X$11589 5188 5443 10906 27 15 5444 HA_X1
* cell instance $11590 r0 *1 56.05,96.6
X$11590 5444 5445 5507 15 5506 27 AOI21_X2
* cell instance $11592 r0 *1 57.57,96.6
X$11592 5188 5543 10908 27 15 5509 HA_X1
* cell instance $11594 m0 *1 57.76,96.6
X$11594 5507 15 27 5366 BUF_X1
* cell instance $11595 m0 *1 58.52,96.6
X$11595 15 5425 5101 5280 5188 27 DFF_X2
* cell instance $11602 r0 *1 59.47,96.6
X$11602 5446 5447 5367 27 15 5507 OAI21_X2
* cell instance $11603 r0 *1 60.8,96.6
X$11603 5509 15 27 5446 INV_X1
* cell instance $11606 r0 *1 64.6,96.6
X$11606 5346 1028 15 6205 27 OR2_X4
* cell instance $11611 r0 *1 69.16,96.6
X$11611 5345 5368 15 27 5449 NAND2_X1
* cell instance $11612 m0 *1 69.54,96.6
X$11612 5245 5368 5345 27 5341 15 OAI21_X1
* cell instance $11615 m0 *1 71.06,96.6
X$11615 5283 15 27 5345 CLKBUF_X3
* cell instance $11620 r0 *1 71.82,96.6
X$11620 5248 15 27 5368 INV_X1
* cell instance $11622 m0 *1 72.96,96.6
X$11622 5234 5195 5284 15 5369 27 AOI21_X1
* cell instance $11623 m0 *1 72.39,96.6
X$11623 2030 5190 15 27 5284 NOR2_X1
* cell instance $11624 m0 *1 73.72,96.6
X$11624 5246 2056 5285 15 27 5346 NAND3_X2
* cell instance $11625 m0 *1 75.05,96.6
X$11625 2056 2030 15 27 5370 NAND2_X1
* cell instance $11626 m0 *1 75.62,96.6
X$11626 5268 5345 5350 27 15 5267 OAI21_X2
* cell instance $11627 m0 *1 76.95,96.6
X$11627 1564 15 27 5033 CLKBUF_X3
* cell instance $11628 m0 *1 77.9,96.6
X$11628 2056 5286 15 27 5349 NOR2_X1
* cell instance $11629 m0 *1 78.47,96.6
X$11629 5286 15 27 5350 INV_X1
* cell instance $11632 m0 *1 82.08,96.6
X$11632 5188 1536 5453 15 27 5425 MUX2_X1
* cell instance $11633 m0 *1 83.41,96.6
X$11633 35 5099 15 27 5371 NAND2_X1
* cell instance $11636 r0 *1 72.58,96.6
X$11636 5369 5370 15 27 5546 NAND2_X2
* cell instance $11637 r0 *1 73.53,96.6
X$11637 5345 5248 16 15 27 5512 NAND3_X1
* cell instance $11638 r0 *1 74.29,96.6
X$11638 1394 5512 5370 15 5429 27 AOI21_X1
* cell instance $11641 r0 *1 76.19,96.6
X$11641 15 5286 5511 5429 5033 27 DFF_X1
* cell instance $11642 r0 *1 79.42,96.6
X$11642 5511 15 27 2030 BUF_X2
* cell instance $11643 r0 *1 80.18,96.6
X$11643 5450 5148 15 27 5430 NAND2_X1
* cell instance $11646 r0 *1 81.7,96.6
X$11646 15 5508 5372 10762 35 27 DFF_X2
* cell instance $11648 m0 *1 86.45,96.6
X$11648 15 5374 5289 10714 5287 27 DFF_X2
* cell instance $11649 m0 *1 85.88,96.6
X$11649 5287 5099 15 27 5373 NAND2_X1
* cell instance $11651 m0 *1 93.1,96.6
X$11651 5426 15 27 5375 INV_X1
* cell instance $11652 m0 *1 93.48,96.6
X$11652 5375 5376 5618 27 15 5378 OAI21_X4
* cell instance $11653 m0 *1 95.95,96.6
X$11653 5381 5290 10862 27 15 5426 HA_X1
* cell instance $11654 m0 *1 97.85,96.6
X$11654 1564 15 27 5289 CLKBUF_X3
* cell instance $11655 m0 *1 98.8,96.6
X$11655 5289 15 27 10821 INV_X2
* cell instance $11658 m0 *1 103.17,96.6
X$11658 5381 5565 10873 27 15 5423 HA_X1
* cell instance $11659 m0 *1 105.07,96.6
X$11659 5381 1536 5607 15 27 5382 MUX2_X1
* cell instance $11666 r0 *1 86.64,96.6
X$11666 2055 5373 5452 15 5374 27 AOI21_X1
* cell instance $11670 r0 *1 89.49,96.6
X$11670 15 5428 5454 5455 5552 27 AOI21_X4
* cell instance $11671 r0 *1 91.96,96.6
X$11671 5375 5428 5376 27 15 5377 OAI21_X4
* cell instance $11673 r0 *1 94.62,96.6
X$11673 5427 5377 15 27 5963 XNOR2_X2
* cell instance $11676 r0 *1 97.09,96.6
X$11676 5427 15 27 5379 INV_X1
* cell instance $11677 r0 *1 97.47,96.6
X$11677 15 5563 5380 5379 5378 27 AOI21_X4
* cell instance $11678 r0 *1 99.94,96.6
X$11678 15 5613 5380 5379 5377 27 AOI21_X4
* cell instance $11679 r0 *1 102.41,96.6
X$11679 5381 5458 10904 27 15 5380 HA_X1
* cell instance $11682 r0 *1 105.45,96.6
X$11682 15 5382 5289 5558 5381 27 DFF_X2
* cell instance $11689 m0 *1 117.42,96.6
X$11689 5291 27 5148 15 BUF_X4
* cell instance $11693 r0 *1 118.56,96.6
X$11693 6480 5148 15 27 5156 NAND2_X1
* cell instance $11698 m0 *1 125.02,96.6
X$11698 1564 15 27 5292 CLKBUF_X3
* cell instance $11699 m0 *1 121.41,96.6
X$11699 15 5422 5292 10651 4831 27 DFF_X2
* cell instance $11700 m0 *1 125.97,96.6
X$11700 5292 15 27 10822 INV_X2
* cell instance $11701 m0 *1 126.54,96.6
X$11701 4831 5099 15 27 5420 NAND2_X1
* cell instance $11703 r0 *1 121.98,96.6
X$11703 5383 5420 5462 15 5422 27 AOI21_X1
* cell instance $11706 r0 *1 123.88,96.6
X$11706 6223 5148 15 27 5384 NAND2_X1
* cell instance $11707 r0 *1 124.45,96.6
X$11707 5383 5352 5384 15 5251 27 AOI21_X1
* cell instance $11710 r0 *1 126.92,96.6
X$11710 5039 5099 15 27 5385 NAND2_X1
* cell instance $11713 m0 *1 127.49,96.6
X$11713 15 5293 5292 10706 5039 27 DFF_X2
* cell instance $11716 r0 *1 127.68,96.6
X$11716 5383 5385 6004 15 5293 27 AOI21_X1
* cell instance $11722 r0 *1 137.37,96.6
X$11722 5566 5220 5499 27 15 5419 HA_X1
* cell instance $11724 m0 *1 138.32,96.6
X$11724 5415 5419 27 15 5386 XNOR2_X1
* cell instance $11725 m0 *1 140.22,96.6
X$11725 5347 5176 27 15 5417 XNOR2_X1
* cell instance $11726 m0 *1 141.36,96.6
X$11726 15 5294 5347 5412 5416 5387 27 FA_X1
* cell instance $11730 r0 *1 139.27,96.6
X$11730 5417 5386 27 15 5463 XNOR2_X1
* cell instance $11731 r0 *1 140.41,96.6
X$11731 5499 15 27 5416 INV_X1
* cell instance $11734 r0 *1 141.36,96.6
X$11734 5464 4991 5197 27 15 5498 HA_X1
* cell instance $11736 r0 *1 143.64,96.6
X$11736 15 5412 5975 5494 5177 5465 27 FA_X1
* cell instance $11737 r0 *1 146.68,96.6
X$11737 15 5495 5415 5343 5727 5494 27 FA_X1
* cell instance $11738 m0 *1 147.25,96.6
X$11738 5344 15 27 5388 INV_X1
* cell instance $11740 m0 *1 147.63,96.6
X$11740 15 5466 5344 5342 5411 4594 27 FA_X1
* cell instance $11744 m0 *1 151.05,96.6
X$11744 5342 15 27 5295 INV_X1
* cell instance $11747 m0 *1 151.81,96.6
X$11747 15 5408 5411 5339 5409 5491 27 FA_X1
* cell instance $11749 m0 *1 157.13,96.6
X$11749 5297 5296 5215 27 15 5298 HA_X1
* cell instance $11750 m0 *1 159.03,96.6
X$11750 15 5390 5299 5254 5407 5300 27 FA_X1
* cell instance $11755 r0 *1 152.38,96.6
X$11755 5493 5389 5335 27 15 5409 HA_X1
* cell instance $11759 r0 *1 156.94,96.6
X$11759 5568 5570 15 27 5296 NOR2_X1
* cell instance $11761 r0 *1 157.7,96.6
X$11761 15 5468 5336 5406 5490 5489 27 FA_X1
* cell instance $11762 r0 *1 160.74,96.6
X$11762 5469 5590 5333 27 15 5489 HA_X1
* cell instance $11766 r0 *1 164.73,96.6
X$11766 5472 5470 5403 27 15 5404 HA_X1
* cell instance $11767 m0 *1 164.92,96.6
X$11767 15 5473 5301 5324 5390 5300 27 FA_X1
* cell instance $11770 m0 *1 168.15,96.6
X$11770 5393 5749 5321 27 15 5320 HA_X1
* cell instance $11772 r0 *1 166.63,96.6
X$11772 15 5403 5392 5393 5660 5474 27 FA_X1
* cell instance $11775 m0 *1 170.62,96.6
X$11775 5321 15 27 5400 INV_X1
* cell instance $11778 m0 *1 171.19,96.6
X$11778 5394 15 27 5261 INV_X1
* cell instance $11779 m0 *1 171.57,96.6
X$11779 15 5400 4920 5113 5402 5318 27 FA_X1
* cell instance $11780 m0 *1 174.61,96.6
X$11780 5317 15 27 5318 INV_X1
* cell instance $11783 r0 *1 170.81,96.6
X$11783 5573 5574 5394 27 15 5487 HA_X1
* cell instance $11787 r0 *1 172.71,96.6
X$11787 5487 15 27 5402 INV_X1
* cell instance $11790 r0 *1 174.04,96.6
X$11790 5585 5655 5044 27 15 5317 HA_X1
* cell instance $11791 r0 *1 175.94,96.6
X$11791 5395 5477 5158 27 15 5396 HA_X1
* cell instance $11793 m0 *1 176.89,96.6
X$11793 5396 15 27 5303 INV_X1
* cell instance $11795 m0 *1 178.22,96.6
X$11795 5313 5314 5200 27 15 5121 HA_X1
* cell instance $11798 r0 *1 177.84,96.6
X$11798 4420 5478 5486 27 15 5201 HA_X1
* cell instance $11801 m0 *1 181.45,96.6
X$11801 4510 4782 5115 27 15 5050 HA_X1
* cell instance $11803 m0 *1 183.35,96.6
X$11803 5306 5484 5397 27 15 4424 HA_X1
* cell instance $11809 r0 *1 181.83,96.6
X$11809 5115 15 27 5479 INV_X1
* cell instance $11812 r0 *1 182.78,96.6
X$11812 15 5734 5259 5480 5307 5485 27 FA_X1
* cell instance $11817 m0 *1 4.18,32.2
X$11817 1649 1545 1446 15 27 1673 OR3_X2
* cell instance $11821 m0 *1 10.83,32.2
X$11821 1728 1608 27 1766 15 XOR2_X2
* cell instance $11822 m0 *1 12.54,32.2
X$11822 1549 15 27 1729 INV_X1
* cell instance $11823 m0 *1 12.92,32.2
X$11823 1729 1675 1674 27 1652 15 OAI21_X1
* cell instance $11824 m0 *1 13.68,32.2
X$11824 1609 15 27 1674 INV_X1
* cell instance $11835 m0 *1 3.23,32.2
X$11835 755 1544 15 27 1727 NAND2_X1
* cell instance $11838 r0 *1 4.94,32.2
X$11838 1763 1673 15 27 1799 NAND2_X2
* cell instance $11841 r0 *1 6.84,32.2
X$11841 408 1766 27 15 1765 XNOR2_X1
* cell instance $11842 r0 *1 7.98,32.2
X$11842 355 1766 27 15 1853 XNOR2_X1
* cell instance $11845 r0 *1 9.69,32.2
X$11845 355 15 27 1818 CLKBUF_X3
* cell instance $11846 r0 *1 10.64,32.2
X$11846 1548 1608 1652 15 1607 27 AOI21_X2
* cell instance $11847 r0 *1 11.97,32.2
X$11847 388 1767 1608 27 15 1548 HA_X1
* cell instance $11849 m0 *1 15.77,32.2
X$11849 1676 1610 1732 27 15 1379 OAI21_X4
* cell instance $11850 m0 *1 14.44,32.2
X$11850 1609 1549 1731 15 1728 27 AOI21_X2
* cell instance $11851 m0 *1 18.24,32.2
X$11851 1611 1613 1734 15 1675 27 AOI21_X2
* cell instance $11852 m0 *1 19.57,32.2
X$11852 1613 1614 1733 27 15 1610 OAI21_X2
* cell instance $11853 m0 *1 20.9,32.2
X$11853 1678 1679 1735 27 1734 15 OAI21_X1
* cell instance $11854 m0 *1 21.66,32.2
X$11854 1614 15 27 1678 INV_X1
* cell instance $11855 m0 *1 22.04,32.2
X$11855 1733 15 27 1735 INV_X1
* cell instance $11858 r0 *1 15.58,32.2
X$11858 1611 1609 1548 27 1676 15 NOR3_X2
* cell instance $11861 r0 *1 18.81,32.2
X$11861 1613 1677 15 27 1768 XOR2_X1
* cell instance $11863 r0 *1 20.33,32.2
X$11863 1678 1800 1735 27 1677 15 OAI21_X1
* cell instance $11864 r0 *1 21.09,32.2
X$11864 1614 1679 27 15 1769 XNOR2_X1
* cell instance $11865 r0 *1 22.23,32.2
X$11865 15 1732 1736 1680 1681 27 AOI21_X4
* cell instance $11866 m0 *1 22.99,32.2
X$11866 1733 1682 15 27 1736 OR2_X1
* cell instance $11869 m0 *1 23.94,32.2
X$11869 212 1504 1680 27 15 1682 HA_X1
* cell instance $11875 r0 *1 24.7,32.2
X$11875 1682 1680 1737 15 1679 27 AOI21_X1
* cell instance $11879 r0 *1 28.12,32.2
X$11879 111 1320 1770 27 15 1771 HA_X1
* cell instance $11883 r0 *1 39.52,32.2
X$11883 1776 1065 1774 15 27 1615 MUX2_X1
* cell instance $11885 r0 *1 41.04,32.2
X$11885 1683 15 27 1775 INV_X1
* cell instance $11887 r0 *1 41.61,32.2
X$11887 111 1776 1683 27 15 1777 HA_X1
* cell instance $11888 m0 *1 43.13,32.2
X$11888 1778 1065 1739 15 27 1506 MUX2_X1
* cell instance $11891 m0 *1 44.65,32.2
X$11891 1617 1684 15 27 1739 XOR2_X1
* cell instance $11892 m0 *1 45.79,32.2
X$11892 1618 15 27 1685 INV_X1
* cell instance $11893 m0 *1 46.17,32.2
X$11893 15 1453 1618 1617 1684 27 AOI21_X4
* cell instance $11898 r0 *1 43.89,32.2
X$11898 1617 15 27 1738 INV_X1
* cell instance $11899 r0 *1 44.27,32.2
X$11899 1738 1804 1685 27 1390 15 OAI21_X1
* cell instance $11900 r0 *1 45.03,32.2
X$11900 212 1778 1617 27 15 1618 HA_X1
* cell instance $11902 r0 *1 49.97,32.2
X$11902 548 15 27 1805 INV_X1
* cell instance $11903 r0 *1 50.35,32.2
X$11903 295 1805 1779 27 15 1690 HA_X1
* cell instance $11905 m0 *1 51.3,32.2
X$11905 1741 15 27 1689 BUF_X1
* cell instance $11907 m0 *1 53.39,32.2
X$11907 1689 15 27 1743 INV_X1
* cell instance $11908 m0 *1 52.25,32.2
X$11908 1689 1619 27 15 1517 XNOR2_X1
* cell instance $11909 m0 *1 53.77,32.2
X$11909 1742 1743 1619 27 15 983 OAI21_X4
* cell instance $11911 m0 *1 57.76,32.2
X$11911 1620 15 27 1746 INV_X1
* cell instance $11912 m0 *1 58.14,32.2
X$11912 1621 1745 1746 27 15 1691 OAI21_X4
* cell instance $11913 m0 *1 60.61,32.2
X$11913 1620 1558 27 15 1748 AND2_X1
* cell instance $11914 m0 *1 61.37,32.2
X$11914 1747 1560 15 27 1622 NOR2_X1
* cell instance $11915 m0 *1 61.94,32.2
X$11915 1521 15 27 1623 INV_X1
* cell instance $11918 m0 *1 65.55,32.2
X$11918 1692 1458 1625 27 1562 15 OAI21_X1
* cell instance $11919 m0 *1 66.31,32.2
X$11919 1625 27 1631 15 BUF_X4
* cell instance $11921 m0 *1 67.83,32.2
X$11921 15 1627 1458 1030 1604 1692 27 OR4_X4
* cell instance $11923 m0 *1 71.06,32.2
X$11923 111 1460 1693 27 15 1692 HA_X1
* cell instance $11925 m0 *1 73.15,32.2
X$11925 1526 1833 1694 27 15 723 OAI21_X2
* cell instance $11927 m0 *1 74.67,32.2
X$11927 1833 1694 1783 1696 27 15 1695 OAI22_X1
* cell instance $11930 r0 *1 52.44,32.2
X$11930 1687 1688 1744 27 1456 15 OAI21_X1
* cell instance $11931 r0 *1 53.2,32.2
X$11931 1687 1829 1807 15 27 NOR2_X4
* cell instance $11932 r0 *1 54.91,32.2
X$11932 1557 1689 1690 15 1744 27 AOI21_X1
* cell instance $11934 r0 *1 58.71,32.2
X$11934 15 1687 1691 1747 1748 27 AOI21_X4
* cell instance $11938 r0 *1 61.18,32.2
X$11938 1623 1885 1922 15 1747 27 AOI21_X2
* cell instance $11940 r0 *1 65.55,32.2
X$11940 1692 15 27 1780 INV_X2
* cell instance $11941 r0 *1 66.12,32.2
X$11941 1627 553 15 1116 27 NAND2_X4
* cell instance $11942 r0 *1 67.83,32.2
X$11942 1626 15 27 1781 INV_X1
* cell instance $11943 r0 *1 68.21,32.2
X$11943 15 1749 1695 1666 1814 1460 27 AND4_X4
* cell instance $11944 r0 *1 70.68,32.2
X$11944 15 1070 1626 1692 722 1816 27 OAI211_X4
* cell instance $11945 r0 *1 73.91,32.2
X$11945 15 1626 1455 1696 1694 27 AOI21_X4
* cell instance $11946 r0 *1 76.38,32.2
X$11946 15 1817 1245 1696 1670 27 DFF_X2
* cell instance $11947 m0 *1 76.95,32.2
X$11947 1752 15 27 1455 BUF_X2
* cell instance $11949 m0 *1 77.71,32.2
X$11949 1696 1629 1891 27 15 1752 HA_X1
* cell instance $11950 m0 *1 79.61,32.2
X$11950 1696 1629 10867 27 15 597 HA_X1
* cell instance $11953 r0 *1 80.37,32.2
X$11953 1694 1696 15 212 27 NAND2_X4
* cell instance $11954 m0 *1 83.79,32.2
X$11954 1564 15 27 1245 CLKBUF_X3
* cell instance $11955 m0 *1 81.89,32.2
X$11955 1698 1630 10854 27 15 1629 HA_X1
* cell instance $11957 m0 *1 84.93,32.2
X$11957 1458 1030 15 1616 27 NAND2_X4
* cell instance $11962 r0 *1 82.27,32.2
X$11962 1697 1630 10895 27 15 1785 HA_X1
* cell instance $11965 r0 *1 85.31,32.2
X$11965 1698 1630 10887 27 15 1701 HA_X1
* cell instance $11967 m0 *1 89.49,32.2
X$11967 15 10328 1699 1672 1563 27 DFF_X1
* cell instance $11971 m0 *1 93.1,32.2
X$11971 1700 15 27 1671 INV_X1
* cell instance $11975 r0 *1 94.24,32.2
X$11975 1757 1701 15 27 1835 NAND2_X1
* cell instance $11978 r0 *1 95.38,32.2
X$11978 15 10556 1787 1702 1563 27 DFF_X1
* cell instance $11979 m0 *1 96.71,32.2
X$11979 15 10330 1757 1758 1563 27 DFF_X1
* cell instance $11980 m0 *1 95.38,32.2
X$11980 1787 1536 429 15 27 1702 MUX2_X1
* cell instance $11981 m0 *1 99.94,32.2
X$11981 1759 15 27 1566 BUF_X1
* cell instance $11982 m0 *1 100.51,32.2
X$11982 1158 1567 1759 27 15 1633 HA_X1
* cell instance $11986 m0 *1 103.74,32.2
X$11986 1541 1634 27 15 1568 AND2_X1
* cell instance $11988 m0 *1 104.5,32.2
X$11988 1633 1566 1435 15 1704 27 AOI21_X1
* cell instance $11993 r0 *1 104.88,32.2
X$11993 1812 1703 15 27 1632 NOR2_X1
* cell instance $11995 r0 *1 106.97,32.2
X$11995 1788 1703 1705 27 15 1635 OAI21_X2
* cell instance $11997 m0 *1 107.92,32.2
X$11997 1635 1761 27 15 1760 AND2_X1
* cell instance $11999 m0 *1 116.28,32.2
X$11999 1708 15 27 1791 INV_X1
* cell instance $12002 m0 *1 118.94,32.2
X$12002 1756 15 27 1856 INV_X1
* cell instance $12006 r0 *1 108.3,32.2
X$12006 1703 1788 1705 15 27 1761 OR3_X1
* cell instance $12007 r0 *1 109.25,32.2
X$12007 1789 15 27 1762 INV_X1
* cell instance $12008 r0 *1 109.63,32.2
X$12008 1762 1635 15 27 1810 NAND2_X2
* cell instance $12009 r0 *1 110.58,32.2
X$12009 1809 1706 1811 15 27 1470 MUX2_X1
* cell instance $12012 r0 *1 113.05,32.2
X$12012 1790 1706 1707 15 27 1406 MUX2_X1
* cell instance $12013 r0 *1 114.38,32.2
X$12013 138 1790 1868 27 15 1708 HA_X1
* cell instance $12018 r0 *1 116.47,32.2
X$12018 1709 1808 15 27 1755 XOR2_X1
* cell instance $12019 r0 *1 117.61,32.2
X$12019 1808 1709 27 1806 15 AND2_X4
* cell instance $12020 r0 *1 119.32,32.2
X$12020 1792 1706 1755 15 27 1473 MUX2_X1
* cell instance $12025 m0 *1 124.26,32.2
X$12025 1636 15 27 1753 INV_X1
* cell instance $12027 r0 *1 125.02,32.2
X$12027 300 1710 1754 27 15 1711 HA_X1
* cell instance $12028 m0 *1 125.21,32.2
X$12028 1754 15 27 1410 CLKBUF_X2
* cell instance $12030 m0 *1 125.97,32.2
X$12030 1711 15 27 1637 INV_X1
* cell instance $12032 m0 *1 126.92,32.2
X$12032 1711 1753 1410 15 1841 27 AOI21_X2
* cell instance $12035 m0 *1 129.77,32.2
X$12035 1638 1712 1578 15 27 NOR2_X4
* cell instance $12039 r0 *1 128.44,32.2
X$12039 15 1086 1862 1793 1712 27 NOR3_X4
* cell instance $12040 r0 *1 131.1,32.2
X$12040 15 1086 2072 1713 1638 27 NOR3_X4
* cell instance $12041 m0 *1 133.57,32.2
X$12041 1858 1482 1488 27 15 1516 OAI21_X2
* cell instance $12043 m0 *1 134.9,32.2
X$12043 1715 1714 1716 15 1346 27 AOI21_X2
* cell instance $12044 m0 *1 136.23,32.2
X$12044 1714 1715 1716 27 15 1345 AND3_X1
* cell instance $12045 m0 *1 137.18,32.2
X$12045 1577 1639 15 27 1751 NAND2_X1
* cell instance $12046 m0 *1 137.75,32.2
X$12046 1482 1488 15 1577 27 OR2_X4
* cell instance $12047 m0 *1 139.46,32.2
X$12047 1584 1411 1497 1640 1795 1091 15 27 OAI221_X2
* cell instance $12048 m0 *1 141.55,32.2
X$12048 1641 1642 15 27 1643 NAND2_X1
* cell instance $12049 m0 *1 142.12,32.2
X$12049 1641 1642 15 27 1644 NOR2_X1
* cell instance $12050 m0 *1 142.69,32.2
X$12050 1644 1585 1718 15 1486 27 AOI21_X2
* cell instance $12051 m0 *1 144.02,32.2
X$12051 1484 1587 15 27 1509 NOR2_X1
* cell instance $12053 m0 *1 145.35,32.2
X$12053 1740 1482 1719 27 15 1487 OAI21_X2
* cell instance $12054 m0 *1 146.68,32.2
X$12054 1587 1586 1414 1645 27 1740 15 NOR4_X2
* cell instance $12055 m0 *1 148.39,32.2
X$12055 15 1723 1646 1710 1489 1087 27 NAND4_X4
* cell instance $12056 m0 *1 151.81,32.2
X$12056 1646 1723 1489 15 27 1714 NAND3_X2
* cell instance $12057 m0 *1 153.14,32.2
X$12057 1489 1723 1646 27 15 1497 AND3_X2
* cell instance $12060 r0 *1 133.76,32.2
X$12060 1751 1917 15 27 1041 XNOR2_X2
* cell instance $12061 r0 *1 135.66,32.2
X$12061 1488 15 27 1515 BUF_X1
* cell instance $12063 r0 *1 136.42,32.2
X$12063 1715 1750 15 27 1859 NOR2_X1
* cell instance $12065 r0 *1 137.37,32.2
X$12065 1750 1715 15 27 1483 OR2_X1
* cell instance $12066 r0 *1 138.13,32.2
X$12066 1714 1794 1803 1642 1577 1094 27 15 AOI221_X2
* cell instance $12067 r0 *1 140.22,32.2
X$12067 1858 1717 15 27 1584 NAND2_X1
* cell instance $12068 r0 *1 140.79,32.2
X$12068 1639 1793 15 27 1640 NAND2_X1
* cell instance $12071 r0 *1 142.5,32.2
X$12071 1641 1716 1717 15 27 1718 NAND3_X1
* cell instance $12074 r0 *1 145.54,32.2
X$12074 15 1720 1586 1587 1645 1724 27 NOR4_X4
* cell instance $12078 r0 *1 150.29,32.2
X$12078 1722 1489 1646 15 1721 27 AOI21_X1
* cell instance $12079 r0 *1 151.05,32.2
X$12079 1721 1722 1796 27 15 749 MUX2_X2
* cell instance $12080 r0 *1 152.76,32.2
X$12080 15 1730 1725 1797 1845 1589 27 NAND4_X4
* cell instance $12081 m0 *1 156.75,32.2
X$12081 1648 1726 27 750 15 XOR2_X2
* cell instance $12082 m0 *1 155.42,32.2
X$12082 1724 27 1489 15 BUF_X4
* cell instance $12083 m0 *1 158.46,32.2
X$12083 1798 1647 27 1264 15 XOR2_X2
* cell instance $12091 r0 *1 156.18,32.2
X$12091 1730 1491 27 15 1646 AND2_X2
* cell instance $12093 r0 *1 157.32,32.2
X$12093 1901 1417 1646 1724 1726 27 15 AOI211_X2
* cell instance $12095 r0 *1 159.22,32.2
X$12095 1798 1647 1588 15 27 1270 NAND3_X2
* cell instance $12109 m0 *1 4.75,51.8
X$12109 1799 2446 15 27 3086 NAND2_X2
* cell instance $12111 m0 *1 8.93,51.8
X$12111 2524 1818 15 27 2713 NOR2_X2
* cell instance $12112 m0 *1 9.88,51.8
X$12112 2490 2578 2713 2712 15 2618 27 NAND4_X2
* cell instance $12113 m0 *1 11.59,51.8
X$12113 2620 2617 15 27 2926 OR2_X1
* cell instance $12115 m0 *1 12.54,51.8
X$12115 2715 1818 2714 15 27 2617 NOR3_X1
* cell instance $12116 m0 *1 13.3,51.8
X$12116 2715 2714 2524 15 27 NOR2_X4
* cell instance $12117 m0 *1 15.01,51.8
X$12117 2716 2527 27 2789 15 XOR2_X2
* cell instance $12118 m0 *1 16.72,51.8
X$12118 2716 2527 27 2715 15 AND2_X4
* cell instance $12119 m0 *1 18.43,51.8
X$12119 2717 2718 2719 27 15 2716 OAI21_X4
* cell instance $12120 m0 *1 20.9,51.8
X$12120 2718 2719 27 15 2828 XNOR2_X1
* cell instance $12121 m0 *1 22.04,51.8
X$12121 2203 15 27 2829 INV_X1
* cell instance $12125 m0 *1 26.41,51.8
X$12125 2625 15 27 2790 BUF_X1
* cell instance $12132 r0 *1 1.52,51.8
X$12132 1418 2351 15 27 2849 XNOR2_X2
* cell instance $12140 r0 *1 8.93,51.8
X$12140 2713 2522 15 27 2925 OR2_X1
* cell instance $12144 r0 *1 12.35,51.8
X$12144 2524 2163 15 27 2620 NOR2_X1
* cell instance $12147 r0 *1 19.19,51.8
X$12147 2829 2828 2852 27 15 3388 MUX2_X2
* cell instance $12151 r0 *1 24.51,51.8
X$12151 15 2357 27 2852 BUF_X8
* cell instance $12162 m0 *1 4.94,102.2
X$12162 5620 15 27 5673 BUF_X2
* cell instance $12164 m0 *1 5.7,102.2
X$12164 5621 15 27 5741 CLKBUF_X2
* cell instance $12168 r0 *1 6.27,102.2
X$12168 5685 15 27 5735 BUF_X2
* cell instance $12169 r0 *1 7.03,102.2
X$12169 15 10510 5736 5738 5017 27 DFF_X1
* cell instance $12170 m0 *1 10.07,102.2
X$12170 5736 5184 15 27 5737 NAND2_X1
* cell instance $12174 r0 *1 10.26,102.2
X$12174 5687 5737 5788 15 5738 27 AOI21_X1
* cell instance $12176 m0 *1 15.77,102.2
X$12176 5687 5518 5742 15 5659 27 AOI21_X1
* cell instance $12177 m0 *1 12.54,102.2
X$12177 15 10315 5517 5659 4885 27 DFF_X1
* cell instance $12182 r0 *1 17.29,102.2
X$12182 6026 5519 15 27 5742 NAND2_X1
* cell instance $12183 r0 *1 17.86,102.2
X$12183 5584 5743 15 27 5831 NAND2_X2
* cell instance $12184 r0 *1 18.81,102.2
X$12184 5743 5520 15 27 5827 NAND2_X2
* cell instance $12185 r0 *1 19.76,102.2
X$12185 5747 5690 5830 5689 5827 5587 15 27 OAI221_X2
* cell instance $12187 m0 *1 21.47,102.2
X$12187 15 5832 5139 10702 5584 27 DFF_X2
* cell instance $12190 m0 *1 27.55,102.2
X$12190 5269 5691 15 27 5752 NAND2_X1
* cell instance $12191 m0 *1 28.12,102.2
X$12191 5667 5526 5695 15 27 6134 OR3_X4
* cell instance $12193 r0 *1 21.85,102.2
X$12193 5747 5694 5830 5697 5831 5832 15 27 OAI221_X2
* cell instance $12196 r0 *1 25.65,102.2
X$12196 5689 5692 5751 5693 5690 27 15 5750 OAI221_X1
* cell instance $12197 r0 *1 26.79,102.2
X$12197 5212 5691 15 27 5751 NAND2_X1
* cell instance $12198 r0 *1 27.36,102.2
X$12198 5697 5692 5752 5693 5694 27 15 5355 OAI221_X1
* cell instance $12202 r0 *1 29.83,102.2
X$12202 5280 5838 5523 27 15 5794 HA_X1
* cell instance $12203 m0 *1 30.78,102.2
X$12203 5524 5496 5525 15 5695 27 AOI21_X2
* cell instance $12205 m0 *1 32.11,102.2
X$12205 5523 5839 15 27 5755 XNOR2_X2
* cell instance $12206 m0 *1 34.01,102.2
X$12206 5354 15 27 5024 CLKBUF_X3
* cell instance $12207 m0 *1 34.96,102.2
X$12207 5024 15 27 10832 INV_X4
* cell instance $12211 m0 *1 39.9,102.2
X$12211 5527 5501 15 27 5920 XNOR2_X2
* cell instance $12213 m0 *1 41.99,102.2
X$12213 5671 5526 5530 15 27 5689 OR3_X4
* cell instance $12216 r0 *1 31.73,102.2
X$12216 5188 5838 10901 27 15 5696 HA_X1
* cell instance $12218 r0 *1 34.01,102.2
X$12218 5696 5524 5360 15 5796 27 AOI21_X1
* cell instance $12219 r0 *1 34.77,102.2
X$12219 5360 15 27 5839 BUF_X1
* cell instance $12223 r0 *1 38.95,102.2
X$12223 5947 15 27 5797 INV_X1
* cell instance $12227 r0 *1 43.32,102.2
X$12227 5847 5534 5526 15 27 5860 OR3_X4
* cell instance $12228 m0 *1 46.17,102.2
X$12228 5241 5672 5623 27 15 5533 OAI21_X2
* cell instance $12229 m0 *1 45.22,102.2
X$12229 5535 5760 5536 27 15 5847 AND3_X1
* cell instance $12230 m0 *1 47.5,102.2
X$12230 5623 15 27 5760 INV_X1
* cell instance $12235 r0 *1 48.83,102.2
X$12235 5850 5526 5672 15 27 5849 OR3_X4
* cell instance $12236 m0 *1 50.35,102.2
X$12236 5439 5624 5625 27 15 5850 AND3_X1
* cell instance $12237 m0 *1 49.02,102.2
X$12237 5439 5624 5625 15 5672 27 AOI21_X2
* cell instance $12239 m0 *1 51.49,102.2
X$12239 5764 5541 15 27 5625 NAND2_X1
* cell instance $12241 m0 *1 52.25,102.2
X$12241 5541 15 27 5698 INV_X1
* cell instance $12243 m0 *1 54.15,102.2
X$12243 5445 5699 5627 27 5764 15 OAI21_X1
* cell instance $12245 m0 *1 55.1,102.2
X$12245 5628 15 27 5627 INV_X1
* cell instance $12247 m0 *1 55.67,102.2
X$12247 5629 15 27 5445 INV_X2
* cell instance $12249 m0 *1 57,102.2
X$12249 5870 5630 5629 27 5682 15 OAI21_X1
* cell instance $12250 m0 *1 57.76,102.2
X$12250 15 5699 5630 5700 5770 27 AOI21_X4
* cell instance $12251 m0 *1 60.23,102.2
X$12251 5772 15 27 5702 INV_X1
* cell instance $12252 m0 *1 60.61,102.2
X$12252 5280 5703 5772 27 15 5774 HA_X1
* cell instance $12253 m0 *1 62.51,102.2
X$12253 5774 15 27 5773 INV_X1
* cell instance $12256 m0 *1 66.12,102.2
X$12256 5777 1394 15 27 5683 NOR2_X1
* cell instance $12257 m0 *1 66.69,102.2
X$12257 2055 5775 5681 15 5608 27 AOI21_X1
* cell instance $12258 m0 *1 67.45,102.2
X$12258 5546 5631 15 27 5775 NAND2_X1
* cell instance $12259 m0 *1 68.02,102.2
X$12259 5776 5545 5546 15 5777 27 AOI21_X1
* cell instance $12260 m0 *1 68.78,102.2
X$12260 5631 5545 10872 27 15 5678 HA_X1
* cell instance $12261 m0 *1 70.68,102.2
X$12261 5632 5678 5679 27 15 5248 HA_X1
* cell instance $12262 m0 *1 72.58,102.2
X$12262 5632 15 27 5676 INV_X1
* cell instance $12264 r0 *1 50.92,102.2
X$12264 5698 5768 15 27 5799 XNOR2_X2
* cell instance $12265 r0 *1 52.82,102.2
X$12265 5698 5682 5627 15 5762 27 AOI21_X1
* cell instance $12266 r0 *1 53.58,102.2
X$12266 5698 5627 5682 27 15 5851 AND3_X1
* cell instance $12267 r0 *1 54.53,102.2
X$12267 5445 5699 15 27 6018 XNOR2_X2
* cell instance $12270 r0 *1 57.57,102.2
X$12270 5854 15 27 5926 INV_X1
* cell instance $12273 r0 *1 58.52,102.2
X$12273 5700 15 27 5854 BUF_X1
* cell instance $12278 r0 *1 59.47,102.2
X$12278 5702 5855 5773 27 5770 15 OAI21_X1
* cell instance $12279 r0 *1 60.23,102.2
X$12279 5701 15 27 5927 INV_X2
* cell instance $12280 r0 *1 60.8,102.2
X$12280 5544 15 27 5853 BUF_X1
* cell instance $12283 r0 *1 61.94,102.2
X$12283 5703 15 27 5684 BUF_X1
* cell instance $12286 r0 *1 69.35,102.2
X$12286 2126 15 27 5704 INV_X4
* cell instance $12287 r0 *1 70.3,102.2
X$12287 5448 15 27 CLKBUF_X1
* cell instance $12291 r0 *1 72.2,102.2
X$12291 5676 5677 27 15 5877 AND2_X2
* cell instance $12294 m0 *1 73.34,102.2
X$12294 5633 1394 15 27 5778 NOR2_X1
* cell instance $12295 m0 *1 76.95,102.2
X$12295 5634 15 27 5802 BUF_X2
* cell instance $12299 r0 *1 73.53,102.2
X$12299 15 10526 5632 5778 5448 27 DFF_X1
* cell instance $12303 r0 *1 82.08,102.2
X$12303 1564 15 27 5372 CLKBUF_X3
* cell instance $12305 m0 *1 82.65,102.2
X$12305 15 5781 5635 5617 5372 27 DFF_X1
* cell instance $12308 m0 *1 89.87,102.2
X$12308 5803 15 27 5706 INV_X1
* cell instance $12310 m0 *1 90.44,102.2
X$12310 5555 5552 15 27 5707 XNOR2_X2
* cell instance $12311 m0 *1 92.34,102.2
X$12311 5455 5636 5709 15 5711 27 AOI21_X2
* cell instance $12312 m0 *1 93.67,102.2
X$12312 5713 5710 15 27 5636 NAND2_X1
* cell instance $12313 m0 *1 94.24,102.2
X$12313 5637 5619 5782 15 27 5714 OR3_X1
* cell instance $12317 m0 *1 97.66,102.2
X$12317 5719 15 27 5718 INV_X1
* cell instance $12318 m0 *1 98.04,102.2
X$12318 5562 5637 5638 15 27 5922 OR3_X1
* cell instance $12319 m0 *1 98.99,102.2
X$12319 5715 5640 5639 27 15 5783 AND3_X1
* cell instance $12320 m0 *1 99.94,102.2
X$12320 5715 5639 5640 15 5716 27 AOI21_X1
* cell instance $12321 m0 *1 100.7,102.2
X$12321 5563 15 27 5717 BUF_X1
* cell instance $12323 m0 *1 101.46,102.2
X$12323 5718 5642 5641 27 15 5808 AND3_X1
* cell instance $12324 m0 *1 102.41,102.2
X$12324 5718 5641 5642 15 5780 27 AOI21_X2
* cell instance $12326 m0 *1 103.93,102.2
X$12326 5716 5669 5719 27 5810 15 OAI21_X1
* cell instance $12327 m0 *1 104.69,102.2
X$12327 5381 5643 10865 27 15 5779 HA_X1
* cell instance $12328 m0 *1 106.59,102.2
X$12328 5644 5780 5721 27 15 5724 OAI21_X2
* cell instance $12329 m0 *1 107.92,102.2
X$12329 5644 15 27 5722 INV_X1
* cell instance $12330 m0 *1 108.3,102.2
X$12330 5779 15 27 5723 INV_X1
* cell instance $12332 m0 *1 108.87,102.2
X$12332 5558 5643 5644 27 15 5645 HA_X1
* cell instance $12335 r0 *1 83.03,102.2
X$12335 5372 15 27 10823 INV_X2
* cell instance $12339 r0 *1 88.54,102.2
X$12339 5381 5804 10885 27 15 5803 HA_X1
* cell instance $12340 r0 *1 90.44,102.2
X$12340 5558 5804 5710 27 15 5708 HA_X1
* cell instance $12341 r0 *1 92.34,102.2
X$12341 5881 5708 5555 27 5557 15 OAI21_X1
* cell instance $12342 r0 *1 93.1,102.2
X$12342 5455 5709 5636 27 15 5712 AND3_X1
* cell instance $12343 r0 *1 94.05,102.2
X$12343 5711 5637 5712 15 27 5805 OR3_X1
* cell instance $12345 r0 *1 95.19,102.2
X$12345 5714 27 6744 15 BUF_X4
* cell instance $12346 r0 *1 96.52,102.2
X$12346 5708 15 27 5709 INV_X1
* cell instance $12349 r0 *1 97.85,102.2
X$12349 5637 5716 5783 15 27 5806 OR3_X1
* cell instance $12350 r0 *1 98.8,102.2
X$12350 5715 5717 15 27 5964 XNOR2_X2
* cell instance $12351 r0 *1 100.7,102.2
X$12351 5609 15 27 5715 INV_X1
* cell instance $12352 r0 *1 101.08,102.2
X$12352 5564 15 27 5807 BUF_X1
* cell instance $12353 r0 *1 101.65,102.2
X$12353 15 5846 5720 5718 5459 27 AOI21_X4
* cell instance $12354 r0 *1 104.12,102.2
X$12354 15 5844 5720 5718 5564 27 AOI21_X4
* cell instance $12356 r0 *1 107.35,102.2
X$12356 5721 15 27 5809 INV_X1
* cell instance $12357 r0 *1 107.73,102.2
X$12357 5723 5644 5844 27 15 5811 OAI21_X4
* cell instance $12358 r0 *1 110.2,102.2
X$12358 5381 5843 10896 27 15 5841 HA_X1
* cell instance $12359 m0 *1 112.29,102.2
X$12359 5725 5724 5771 15 5646 27 AOI21_X1
* cell instance $12360 m0 *1 111.91,102.2
X$12360 5645 15 27 5771 INV_X1
* cell instance $12366 r0 *1 112.1,102.2
X$12366 15 5840 5841 5725 5811 27 AOI21_X4
* cell instance $12367 r0 *1 114.57,102.2
X$12367 5725 5771 5724 27 15 5812 AND3_X1
* cell instance $12373 r0 *1 116.66,102.2
X$12373 5704 27 2055 15 BUF_X4
* cell instance $12379 m0 *1 134.9,102.2
X$12379 5648 5647 27 15 5769 XNOR2_X1
* cell instance $12381 m0 *1 136.04,102.2
X$12381 15 5089 5648 5668 4778 5767 27 FA_X1
* cell instance $12387 r0 *1 136.23,102.2
X$12387 5769 5093 27 15 6064 XNOR2_X1
* cell instance $12392 m0 *1 142.12,102.2
X$12392 5766 15 27 5599 INV_X1
* cell instance $12393 m0 *1 140.22,102.2
X$12393 5761 5726 5766 27 15 5763 HA_X1
* cell instance $12394 m0 *1 142.5,102.2
X$12394 4417 4416 5464 27 15 5761 HA_X1
* cell instance $12397 m0 *1 145.35,102.2
X$12397 4782 4506 5914 27 15 5665 HA_X1
* cell instance $12398 m0 *1 147.25,102.2
X$12398 5649 15 27 5666 INV_X1
* cell instance $12401 m0 *1 149.91,102.2
X$12401 5591 5089 5664 27 15 5759 HA_X1
* cell instance $12403 r0 *1 140.22,102.2
X$12403 5763 5765 15 27 5813 XOR2_X1
* cell instance $12408 r0 *1 151.62,102.2
X$12408 5759 15 27 5911 INV_X1
* cell instance $12411 m0 *1 152.19,102.2
X$12411 15 5758 5650 5110 5728 5651 27 FA_X1
* cell instance $12412 m0 *1 155.99,102.2
X$12412 5757 5664 5077 27 15 5758 HA_X1
* cell instance $12416 r0 *1 152.57,102.2
X$12416 5835 15 27 5837 INV_X1
* cell instance $12418 r0 *1 153.14,102.2
X$12418 5815 15 27 5651 INV_X1
* cell instance $12420 r0 *1 154.28,102.2
X$12420 15 5756 5835 5728 5816 5754 27 FA_X1
* cell instance $12422 r0 *1 157.7,102.2
X$12422 15 5300 5817 5729 5473 5834 27 FA_X1
* cell instance $12423 m0 *1 160.93,102.2
X$12423 15 5653 5663 5469 4994 5730 27 FA_X1
* cell instance $12424 m0 *1 159.03,102.2
X$12424 5652 5663 5757 27 15 5754 HA_X1
* cell instance $12427 m0 *1 164.92,102.2
X$12427 5471 5570 15 27 5661 NOR2_X1
* cell instance $12429 m0 *1 166.25,102.2
X$12429 5905 5661 5748 27 15 5660 HA_X1
* cell instance $12431 m0 *1 169.67,102.2
X$12431 15 5473 5731 5746 5588 5653 27 FA_X1
* cell instance $12434 m0 *1 173.66,102.2
X$12434 5746 5654 5395 27 15 5655 HA_X1
* cell instance $12435 m0 *1 175.56,102.2
X$12435 5656 15 27 5476 INV_X1
* cell instance $12436 m0 *1 175.94,102.2
X$12436 5901 15 27 5258 INV_X1
* cell instance $12441 r0 *1 164.54,102.2
X$12441 15 5653 5753 5302 5588 5730 27 FA_X1
* cell instance $12444 r0 *1 168.15,102.2
X$12444 15 5748 5749 5573 5902 5731 27 FA_X1
* cell instance $12450 r0 *1 173.47,102.2
X$12450 5745 4994 5654 27 15 5744 HA_X1
* cell instance $12451 r0 *1 175.37,102.2
X$12451 5744 15 27 5576 INV_X1
* cell instance $12453 r0 *1 176.13,102.2
X$12453 6244 15 27 5828 INV_X1
* cell instance $12456 r0 *1 178.22,102.2
X$12456 15 5829 5734 5826 5732 5740 27 FA_X1
* cell instance $12458 m0 *1 178.22,102.2
X$12458 4506 5828 5740 27 15 5657 HA_X1
* cell instance $12462 r0 *1 181.45,102.2
X$12462 15 6162 5582 5733 5739 5826 27 FA_X1
* cell instance $12463 r0 *1 184.49,102.2
X$12463 5397 5820 5818 27 15 5823 HA_X1
* cell instance $12479 m0 *1 7.03,88.2
X$12479 4884 15 27 4881 BUF_X1
* cell instance $12480 m0 *1 7.79,88.2
X$12480 4969 15 27 4883 BUF_X1
* cell instance $12487 r0 *1 12.73,88.2
X$12487 15 10574 4969 5055 5017 27 DFF_X1
* cell instance $12490 m0 *1 16.34,88.2
X$12490 15 10372 4884 4924 4885 27 DFF_X1
* cell instance $12491 m0 *1 21.09,88.2
X$12491 15 10351 4606 4928 4885 27 DFF_X1
* cell instance $12492 m0 *1 24.32,88.2
X$12492 4696 4888 15 27 4973 NAND2_X1
* cell instance $12496 r0 *1 17.29,88.2
X$12496 4969 4980 15 27 5056 NAND2_X1
* cell instance $12498 r0 *1 18.24,88.2
X$12498 4884 4980 15 27 4970 NAND2_X1
* cell instance $12499 r0 *1 18.81,88.2
X$12499 5021 4970 5265 15 4924 27 AOI21_X1
* cell instance $12501 r0 *1 19.76,88.2
X$12501 4803 4980 15 27 4971 NAND2_X1
* cell instance $12503 r0 *1 20.71,88.2
X$12503 5021 4971 5137 15 4998 27 AOI21_X1
* cell instance $12505 r0 *1 21.85,88.2
X$12505 4606 4888 15 27 4972 NAND2_X1
* cell instance $12506 r0 *1 22.42,88.2
X$12506 5021 4972 5022 15 4928 27 AOI21_X1
* cell instance $12508 r0 *1 23.94,88.2
X$12508 5021 4973 4974 15 5001 27 AOI21_X1
* cell instance $12510 m0 *1 25.46,88.2
X$12510 15 10410 4147 5023 4887 27 DFF_X1
* cell instance $12512 m0 *1 28.69,88.2
X$12512 4604 4888 15 27 4975 NAND2_X1
* cell instance $12515 m0 *1 30.21,88.2
X$12515 15 10395 4886 4977 4887 27 DFF_X1
* cell instance $12521 r0 *1 25.65,88.2
X$12521 4147 4888 15 27 5060 NAND2_X1
* cell instance $12522 r0 *1 26.22,88.2
X$12522 15 10509 4604 5061 4887 27 DFF_X1
* cell instance $12523 r0 *1 29.45,88.2
X$12523 4886 4980 15 27 4976 NAND2_X1
* cell instance $12524 r0 *1 30.02,88.2
X$12524 5021 4976 5141 15 4977 27 AOI21_X1
* cell instance $12528 r0 *1 32.11,88.2
X$12528 2055 15 27 5021 CLKBUF_X3
* cell instance $12531 r0 *1 37.62,88.2
X$12531 15 10482 4514 5006 5024 27 DFF_X1
* cell instance $12532 r0 *1 40.85,88.2
X$12532 4514 4888 15 27 4978 NAND2_X1
* cell instance $12534 r0 *1 41.61,88.2
X$12534 1394 4978 5025 15 5006 27 AOI21_X1
* cell instance $12535 r0 *1 42.37,88.2
X$12535 15 10487 4698 5062 4887 27 DFF_X1
* cell instance $12537 m0 *1 43.7,88.2
X$12537 4698 4888 15 27 5026 NAND2_X1
* cell instance $12541 m0 *1 55.1,88.2
X$12541 15 4657 4797 4752 4303 3587 27 NOR4_X4
* cell instance $12542 m0 *1 58.52,88.2
X$12542 4657 4797 15 27 5009 OR2_X1
* cell instance $12543 m0 *1 59.28,88.2
X$12543 4364 4864 4798 5009 15 27 4982 NAND4_X1
* cell instance $12544 m0 *1 60.23,88.2
X$12544 4889 4890 4797 27 4866 15 OAI21_X1
* cell instance $12545 m0 *1 60.99,88.2
X$12545 15 4657 4797 4752 4479 27 NOR3_X4
* cell instance $12546 m0 *1 63.65,88.2
X$12546 4563 4478 4752 27 4892 15 OAI21_X1
* cell instance $12547 m0 *1 64.41,88.2
X$12547 4657 15 27 4893 INV_X1
* cell instance $12548 m0 *1 64.79,88.2
X$12548 4895 4894 4898 4896 4731 27 15 AOI211_X2
* cell instance $12549 m0 *1 66.5,88.2
X$12549 4366 4897 4806 4945 4983 3925 27 15 AOI221_X2
* cell instance $12550 m0 *1 68.59,88.2
X$12550 4896 4898 27 4983 15 XOR2_X2
* cell instance $12553 r0 *1 45.79,88.2
X$12553 1394 5063 5029 15 5028 27 AOI21_X1
* cell instance $12556 r0 *1 47.5,88.2
X$12556 29 4888 15 27 5063 NAND2_X1
* cell instance $12559 r0 *1 49.21,88.2
X$12559 4979 5065 5031 15 5030 27 AOI21_X1
* cell instance $12562 r0 *1 50.54,88.2
X$12562 30 4980 15 27 5065 NAND2_X1
* cell instance $12564 r0 *1 54.15,88.2
X$12564 18 4980 15 27 5129 NAND2_X1
* cell instance $12571 r0 *1 61.75,88.2
X$12571 4981 4891 15 27 4896 XNOR2_X2
* cell instance $12572 r0 *1 63.65,88.2
X$12572 4981 4657 15 27 4366 NOR2_X2
* cell instance $12573 r0 *1 64.6,88.2
X$12573 4892 4982 15 27 5014 NAND2_X1
* cell instance $12574 r0 *1 65.17,88.2
X$12574 4798 4893 15 27 5032 NOR2_X1
* cell instance $12575 r0 *1 65.74,88.2
X$12575 5032 4891 15 27 5073 OR2_X1
* cell instance $12576 r0 *1 66.5,88.2
X$12576 4808 4893 15 27 5011 NOR2_X1
* cell instance $12579 r0 *1 68.02,88.2
X$12579 4898 5073 5011 4662 4810 27 15 AOI211_X2
* cell instance $12581 m0 *1 70.87,88.2
X$12581 4753 5014 15 27 4811 XNOR2_X2
* cell instance $12584 m0 *1 74.29,88.2
X$12584 4899 4640 4636 27 15 4949 OAI21_X2
* cell instance $12585 m0 *1 75.62,88.2
X$12585 15 4949 4951 4870 4901 27 NOR3_X4
* cell instance $12589 r0 *1 76.76,88.2
X$12589 15 4811 4731 4810 4757 3510 27 NAND4_X4
* cell instance $12590 m0 *1 78.85,88.2
X$12590 4811 4757 15 27 5015 NAND2_X1
* cell instance $12592 m0 *1 79.42,88.2
X$12592 5015 3653 4550 4731 5080 27 15 AOI211_X2
* cell instance $12593 m0 *1 81.13,88.2
X$12593 4954 4082 2942 2990 4903 27 15 AOI211_X2
* cell instance $12594 m0 *1 82.84,88.2
X$12594 4757 4285 27 15 4900 AND2_X1
* cell instance $12595 m0 *1 83.6,88.2
X$12595 4811 15 27 4812 INV_X1
* cell instance $12597 m0 *1 84.74,88.2
X$12597 4813 2438 15 27 4902 NOR2_X2
* cell instance $12598 m0 *1 85.69,88.2
X$12598 4983 4903 15 27 3926 XNOR2_X2
* cell instance $12599 m0 *1 87.59,88.2
X$12599 4903 4983 27 4957 15 XOR2_X2
* cell instance $12600 m0 *1 89.3,88.2
X$12600 15 5013 4394 5012 4959 4957 27 OAI22_X4
* cell instance $12601 m0 *1 92.53,88.2
X$12601 15 4904 4984 3871 4312 5010 27 NOR4_X4
* cell instance $12602 m0 *1 95.95,88.2
X$12602 4801 4761 4762 15 4986 27 AOI21_X2
* cell instance $12603 m0 *1 97.28,88.2
X$12603 4901 15 27 4764 INV_X1
* cell instance $12604 m0 *1 97.66,88.2
X$12604 15 4901 4877 5010 4905 27 NOR3_X4
* cell instance $12606 m0 *1 101.08,88.2
X$12606 4816 15 27 4817 INV_X1
* cell instance $12607 m0 *1 101.46,88.2
X$12607 15 4986 4987 4819 4906 4277 27 NAND4_X4
* cell instance $12608 m0 *1 104.88,88.2
X$12608 3917 4277 4819 27 4965 15 OAI21_X1
* cell instance $12609 m0 *1 105.64,88.2
X$12609 15 5008 4820 4818 4795 4967 27 OAI22_X4
* cell instance $12610 m0 *1 108.87,88.2
X$12610 4821 4959 27 4769 15 XOR2_X2
* cell instance $12611 m0 *1 110.58,88.2
X$12611 4905 4902 27 4633 15 XOR2_X2
* cell instance $12612 m0 *1 112.29,88.2
X$12612 4874 4962 15 27 4823 XNOR2_X2
* cell instance $12614 m0 *1 114.38,88.2
X$12614 4962 4874 27 4682 15 XOR2_X2
* cell instance $12619 r0 *1 80.18,88.2
X$12619 5079 5080 4810 27 15 4960 MUX2_X2
* cell instance $12620 r0 *1 81.89,88.2
X$12620 3653 4757 15 27 4813 XNOR2_X2
* cell instance $12623 r0 *1 85.69,88.2
X$12623 15 4901 4801 5085 4960 4036 27 NOR4_X4
* cell instance $12624 r0 *1 89.11,88.2
X$12624 4960 3925 15 27 5086 OR2_X1
* cell instance $12625 r0 *1 89.87,88.2
X$12625 5086 3926 4815 15 4987 27 AOI21_X2
* cell instance $12626 r0 *1 91.2,88.2
X$12626 3925 3926 15 27 4984 OR2_X1
* cell instance $12628 r0 *1 92.15,88.2
X$12628 4960 4801 4901 15 27 4904 OR3_X4
* cell instance $12629 r0 *1 94.24,88.2
X$12629 4904 4984 3871 4077 27 4761 15 OR4_X2
* cell instance $12631 r0 *1 95.95,88.2
X$12631 4762 4761 4816 4901 4759 4990 27 15 AOI221_X2
* cell instance $12632 r0 *1 98.04,88.2
X$12632 4877 4801 4901 5010 27 4985 15 NOR4_X2
* cell instance $12634 r0 *1 100.13,88.2
X$12634 4986 4906 4819 15 27 5090 NAND3_X1
* cell instance $12636 r0 *1 101.08,88.2
X$12636 4276 5090 4987 15 27 5092 NOR3_X1
* cell instance $12637 r0 *1 101.84,88.2
X$12637 4819 4906 4986 27 15 4988 AND3_X1
* cell instance $12638 r0 *1 102.79,88.2
X$12638 4988 5036 27 15 5007 AND2_X1
* cell instance $12641 r0 *1 104.12,88.2
X$12641 4817 4760 4820 27 15 4989 AND3_X1
* cell instance $12642 r0 *1 105.07,88.2
X$12642 4990 4276 4965 27 15 5008 OAI21_X2
* cell instance $12643 r0 *1 106.4,88.2
X$12643 4276 4965 15 27 4967 OR2_X2
* cell instance $12654 m0 *1 134.9,88.2
X$12654 4769 4590 4823 15 27 4952 NAND3_X2
* cell instance $12660 r0 *1 139.65,88.2
X$12660 15 4448 5037 5005 4778 4416 27 FA_X1
* cell instance $12661 m0 *1 141.36,88.2
X$12661 4420 4332 4948 27 15 4991 HA_X1
* cell instance $12667 r0 *1 143.07,88.2
X$12667 15 5005 5095 5004 5091 5089 27 FA_X1
* cell instance $12669 m0 *1 145.92,88.2
X$12669 4829 15 27 4993 INV_X1
* cell instance $12670 m0 *1 149.34,88.2
X$12670 15 4908 5084 4717 5038 4907 27 FA_X1
* cell instance $12671 m0 *1 152.38,88.2
X$12671 4909 15 27 4943 INV_X1
* cell instance $12673 r0 *1 146.11,88.2
X$12673 5084 5087 15 27 5093 XNOR2_X2
* cell instance $12676 m0 *1 153.14,88.2
X$12676 5003 15 27 4910 INV_X1
* cell instance $12678 m0 *1 157.32,88.2
X$12678 4911 15 27 4832 INV_X1
* cell instance $12682 r0 *1 154.28,88.2
X$12682 15 5263 5003 4911 5078 5074 27 FA_X1
* cell instance $12683 r0 *1 157.32,88.2
X$12683 4778 5333 4913 27 15 5040 HA_X1
* cell instance $12685 m0 *1 158.84,88.2
X$12685 4912 15 27 4781 INV_X1
* cell instance $12688 m0 *1 159.6,88.2
X$12688 4448 5571 4937 27 15 4914 HA_X1
* cell instance $12690 r0 *1 160.74,88.2
X$12690 5330 5327 5002 27 15 5074 HA_X1
* cell instance $12691 r0 *1 162.64,88.2
X$12691 15 5076 4611 4916 5072 5071 27 FA_X1
* cell instance $12693 m0 *1 164.92,88.2
X$12693 4915 15 27 4936 INV_X1
* cell instance $12694 r0 *1 165.68,88.2
X$12694 5070 15 27 5071 INV_X1
* cell instance $12695 m0 *1 165.87,88.2
X$12695 4937 15 27 4931 INV_X1
* cell instance $12699 r0 *1 166.06,88.2
X$12699 4994 4416 5068 27 15 4918 HA_X1
* cell instance $12700 m0 *1 167.58,88.2
X$12700 4918 15 27 4919 INV_X1
* cell instance $12707 r0 *1 170.43,88.2
X$12707 5043 5068 5064 27 15 4833 HA_X1
* cell instance $12711 m0 *1 171.57,88.2
X$12711 4921 15 27 4930 INV_X1
* cell instance $12718 r0 *1 173.66,88.2
X$12718 15 5045 4922 5000 5114 5064 27 FA_X1
* cell instance $12720 m0 *1 173.85,88.2
X$12720 4922 15 27 4509 INV_X1
* cell instance $12725 m0 *1 176.89,88.2
X$12725 4926 15 27 4340 INV_X1
* cell instance $12730 m0 *1 179.93,88.2
X$12730 15 4510 4925 5049 4782 4594 27 FA_X1
* cell instance $12732 m0 *1 185.25,88.2
X$12732 4996 5052 10860 27 15 4786 HA_X1
* cell instance $12735 r0 *1 181.64,88.2
X$12735 5825 4999 5047 27 15 4837 HA_X1
* cell instance $12736 r0 *1 183.54,88.2
X$12736 4995 5051 10911 27 15 4996 HA_X1
* cell instance $12737 r0 *1 185.44,88.2
X$12737 5059 15 27 4923 BUF_X1
* cell instance $12747 m0 *1 5.32,113.4
X$12747 6311 15 27 6312 CLKBUF_X2
* cell instance $12748 m0 *1 6.08,113.4
X$12748 6309 15 27 6354 CLKBUF_X2
* cell instance $12749 m0 *1 6.84,113.4
X$12749 6310 15 27 6321 BUF_X1
* cell instance $12757 r0 *1 3.42,113.4
X$12757 6459 15 27 6395 BUF_X2
* cell instance $12760 r0 *1 5.89,113.4
X$12760 6460 15 27 6468 CLKBUF_X2
* cell instance $12761 r0 *1 6.65,113.4
X$12761 6196 15 27 6431 BUF_X2
* cell instance $12763 r0 *1 8.17,113.4
X$12763 6387 15 27 6393 CLKBUF_X2
* cell instance $12767 r0 *1 11.59,113.4
X$12767 15 6356 5995 10813 6245 27 DFF_X2
* cell instance $12768 m0 *1 15.2,113.4
X$12768 6025 6313 5937 6389 6358 6356 15 27 OAI221_X2
* cell instance $12769 m0 *1 14.63,113.4
X$12769 6391 5519 15 27 6241 NAND2_X1
* cell instance $12773 r0 *1 15.2,113.4
X$12773 6390 6245 15 27 6358 NAND2_X2
* cell instance $12775 r0 *1 16.34,113.4
X$12775 6390 6391 15 27 6462 NAND2_X2
* cell instance $12778 r0 *1 18.24,113.4
X$12778 6132 6313 5939 6389 6500 6581 15 27 OAI221_X2
* cell instance $12779 r0 *1 20.33,113.4
X$12779 5310 6170 15 6500 27 NAND2_X4
* cell instance $12780 r0 *1 22.04,113.4
X$12780 6390 5312 15 27 6463 NAND2_X1
* cell instance $12784 r0 *1 23.94,113.4
X$12784 15 6507 6436 10777 5658 27 DFF_X2
* cell instance $12785 m0 *1 26.98,113.4
X$12785 6314 5935 15 27 6464 NAND2_X1
* cell instance $12787 m0 *1 27.55,113.4
X$12787 6314 5741 15 27 6315 NAND2_X1
* cell instance $12788 m0 *1 28.12,113.4
X$12788 15 6201 6369 6393 6030 27 AOI21_X4
* cell instance $12789 m0 *1 30.59,113.4
X$12789 15 6313 6202 6312 6030 27 AOI21_X4
* cell instance $12792 r0 *1 27.74,113.4
X$12792 6177 6392 6315 15 27 6465 MUX2_X1
* cell instance $12793 r0 *1 29.07,113.4
X$12793 6201 6392 6466 15 27 6467 MUX2_X1
* cell instance $12796 r0 *1 32.11,113.4
X$12796 6314 6312 15 27 6513 NAND2_X1
* cell instance $12798 r0 *1 33.06,113.4
X$12798 15 5793 6441 6468 6030 27 AOI21_X4
* cell instance $12799 m0 *1 33.63,113.4
X$12799 6316 5142 6044 27 6369 15 NOR3_X2
* cell instance $12802 m0 *1 35.53,113.4
X$12802 15 5934 6030 6540 5918 6317 27 AOI22_X4
* cell instance $12807 m0 *1 42.75,113.4
X$12807 15 6541 5863 6397 5918 6112 27 AOI22_X4
* cell instance $12811 m0 *1 48.45,113.4
X$12811 6043 15 27 6316 BUF_X1
* cell instance $12815 r0 *1 35.53,113.4
X$12815 6316 5862 6044 27 6441 15 NOR3_X2
* cell instance $12819 r0 *1 38.95,113.4
X$12819 6394 6392 6444 15 27 6594 MUX2_X1
* cell instance $12820 r0 *1 40.28,113.4
X$12820 6314 6395 15 27 6444 NAND2_X1
* cell instance $12821 r0 *1 40.85,113.4
X$12821 6262 6396 15 6670 27 NAND2_X4
* cell instance $12822 r0 *1 42.56,113.4
X$12822 5127 5909 15 6521 27 NAND2_X4
* cell instance $12823 r0 *1 44.27,113.4
X$12823 6132 6397 5692 5849 6521 6469 15 27 OAI221_X2
* cell instance $12826 r0 *1 46.93,113.4
X$12826 15 6030 6395 6394 5918 5867 27 AOI22_X4
* cell instance $12828 r0 *1 50.54,113.4
X$12828 6396 5867 15 6542 27 NAND2_X4
* cell instance $12830 m0 *1 53.39,113.4
X$12830 15 6398 6318 6030 6197 27 AOI21_X4
* cell instance $12833 m0 *1 56.62,113.4
X$12833 6044 6274 15 27 6380 OR2_X2
* cell instance $12834 m0 *1 57.57,113.4
X$12834 6314 6319 6197 15 27 6320 NAND3_X1
* cell instance $12838 r0 *1 55.48,113.4
X$12838 6396 6448 15 6682 27 NAND2_X4
* cell instance $12839 r0 *1 57.19,113.4
X$12839 6319 6398 6320 27 6599 15 OAI21_X1
* cell instance $12842 m0 *1 59.85,113.4
X$12842 6383 6319 15 27 6322 NOR2_X1
* cell instance $12843 m0 *1 59.47,113.4
X$12843 6321 15 27 6382 INV_X1
* cell instance $12847 r0 *1 59.66,113.4
X$12847 6322 6319 6451 15 6600 27 AOI21_X1
* cell instance $12848 r0 *1 60.42,113.4
X$12848 6472 6282 6321 6314 15 27 6451 AOI22_X1
* cell instance $12849 r0 *1 61.37,113.4
X$12849 15 6524 6471 10741 6472 27 DFF_X2
* cell instance $12850 m0 *1 64.41,113.4
X$12850 15 6276 27 6399 BUF_X8
* cell instance $12851 m0 *1 63.08,113.4
X$12851 6399 27 5863 15 BUF_X4
* cell instance $12853 m0 *1 67.64,113.4
X$12853 6044 6205 6043 27 15 6323 MUX2_X2
* cell instance $12858 r0 *1 65.93,113.4
X$12858 6044 6205 6043 27 15 6399 MUX2_X2
* cell instance $12861 r0 *1 68.21,113.4
X$12861 15 10587 6453 6400 6185 27 DFF_X1
* cell instance $12862 r0 *1 71.44,113.4
X$12862 6453 27 6401 15 BUF_X4
* cell instance $12863 m0 *1 73.72,113.4
X$12863 6206 27 5510 15 BUF_X4
* cell instance $12864 m0 *1 72.77,113.4
X$12864 6523 15 27 6185 CLKBUF_X3
* cell instance $12866 m0 *1 76.57,113.4
X$12866 6125 15 27 6314 CLKBUF_X3
* cell instance $12867 m0 *1 77.52,113.4
X$12867 6385 27 6183 15 BUF_X4
* cell instance $12868 m0 *1 78.85,113.4
X$12868 6385 6386 6282 15 27 6286 AND3_X4
* cell instance $12871 m0 *1 84.17,113.4
X$12871 6211 6205 6384 27 15 6405 OAI21_X4
* cell instance $12873 m0 *1 86.83,113.4
X$12873 6406 6378 5381 15 27 6384 NAND3_X2
* cell instance $12876 r0 *1 72.96,113.4
X$12876 6206 6401 6684 15 27 NOR2_X4
* cell instance $12877 r0 *1 74.67,113.4
X$12877 6401 1248 5353 15 27 6400 MUX2_X1
* cell instance $12880 r0 *1 77.14,113.4
X$12880 6044 6406 15 27 6473 OR2_X2
* cell instance $12881 r0 *1 78.09,113.4
X$12881 6458 6474 6520 15 6404 27 AOI21_X2
* cell instance $12882 r0 *1 79.42,113.4
X$12882 6354 15 27 6457 INV_X1
* cell instance $12884 r0 *1 79.99,113.4
X$12884 6125 15 27 6539 CLKBUF_X3
* cell instance $12885 r0 *1 80.94,113.4
X$12885 15 6457 6606 6518 5958 6374 27 AOI22_X4
* cell instance $12886 r0 *1 84.17,113.4
X$12886 6125 15 27 6475 CLKBUF_X3
* cell instance $12889 r0 *1 87.02,113.4
X$12889 6324 15 27 6340 BUF_X1
* cell instance $12890 r0 *1 87.59,113.4
X$12890 5381 6330 10899 27 15 6407 HA_X1
* cell instance $12892 m0 *1 88.54,113.4
X$12892 6324 15 27 6211 INV_X2
* cell instance $12893 r0 *1 89.49,113.4
X$12893 15 5637 6147 6328 6408 27 NOR3_X4
* cell instance $12894 m0 *1 89.87,113.4
X$12894 6327 6325 15 27 6147 NOR2_X2
* cell instance $12895 m0 *1 89.49,113.4
X$12895 6407 15 27 6332 INV_X1
* cell instance $12896 m0 *1 90.82,113.4
X$12896 6329 15 27 6325 INV_X1
* cell instance $12897 m0 *1 91.2,113.4
X$12897 6325 6327 27 15 6328 AND2_X1
* cell instance $12898 m0 *1 91.96,113.4
X$12898 5558 6330 6409 27 15 6295 HA_X1
* cell instance $12899 m0 *1 93.86,113.4
X$12899 6332 6381 6293 27 15 6012 OAI21_X2
* cell instance $12901 m0 *1 95.38,113.4
X$12901 6149 6128 15 27 6516 XNOR2_X2
* cell instance $12902 m0 *1 97.28,113.4
X$12902 6379 15 27 6333 INV_X1
* cell instance $12903 m0 *1 97.66,113.4
X$12903 15 6454 6381 6660 6377 5558 27 FA_X1
* cell instance $12904 m0 *1 100.7,113.4
X$12904 6150 15 27 6454 INV_X1
* cell instance $12905 m0 *1 101.08,113.4
X$12905 6334 6558 6378 27 15 6375 HA_X1
* cell instance $12907 m0 *1 103.17,113.4
X$12907 5558 6334 27 15 6376 XNOR2_X1
* cell instance $12908 m0 *1 104.31,113.4
X$12908 6376 6450 15 27 6335 XNOR2_X2
* cell instance $12909 m0 *1 106.21,113.4
X$12909 6335 15 27 6374 BUF_X1
* cell instance $12912 r0 *1 92.15,113.4
X$12912 6409 15 27 6329 BUF_X1
* cell instance $12913 r0 *1 92.72,113.4
X$12913 6409 15 27 6456 BUF_X1
* cell instance $12914 r0 *1 93.29,113.4
X$12914 6456 6517 27 15 6554 XNOR2_X1
* cell instance $12915 r0 *1 94.43,113.4
X$12915 6409 15 27 6293 BUF_X2
* cell instance $12916 r0 *1 95.19,113.4
X$12916 6148 15 27 6294 BUF_X1
* cell instance $12917 r0 *1 95.76,113.4
X$12917 6381 15 27 6517 BUF_X1
* cell instance $12919 r0 *1 96.52,113.4
X$12919 5381 6333 6455 27 15 6307 HA_X1
* cell instance $12921 r0 *1 98.61,113.4
X$12921 15 6454 6327 6514 6307 5381 27 FA_X1
* cell instance $12925 r0 *1 102.98,113.4
X$12925 5381 6334 27 15 6452 XNOR2_X1
* cell instance $12926 r0 *1 104.12,113.4
X$12926 6452 6449 15 27 6406 XNOR2_X2
* cell instance $12929 r0 *1 107.73,113.4
X$12929 6336 15 27 6694 BUF_X1
* cell instance $12930 m0 *1 108.11,113.4
X$12930 6151 15 27 6337 BUF_X1
* cell instance $12933 r0 *1 108.3,113.4
X$12933 5381 6338 10890 27 15 6478 HA_X1
* cell instance $12935 m0 *1 109.06,113.4
X$12935 6291 6373 27 6336 15 XOR2_X2
* cell instance $12936 m0 *1 111.53,113.4
X$12936 6338 5558 6373 27 15 6411 HA_X1
* cell instance $12938 r0 *1 110.2,113.4
X$12938 6413 15 27 10828 INV_X2
* cell instance $12939 r0 *1 110.77,113.4
X$12939 6479 6373 6372 27 15 6450 OAI21_X2
* cell instance $12941 r0 *1 112.48,113.4
X$12941 6411 6447 6342 15 6449 27 AOI21_X2
* cell instance $12942 m0 *1 115.71,113.4
X$12942 6180 6341 15 27 6339 NAND2_X1
* cell instance $12943 m0 *1 113.81,113.4
X$12943 5558 6338 6447 27 15 10914 HA_X1
* cell instance $12944 m0 *1 116.28,113.4
X$12944 6371 15 27 6341 INV_X1
* cell instance $12945 m0 *1 116.66,113.4
X$12945 6221 6341 15 27 6342 NAND2_X1
* cell instance $12950 m0 *1 125.78,113.4
X$12950 6413 15 27 6062 CLKBUF_X3
* cell instance $12951 m0 *1 126.73,113.4
X$12951 6062 15 27 CLKBUF_X1
* cell instance $12953 m0 *1 133.38,113.4
X$12953 5155 5105 27 15 6414 XNOR2_X1
* cell instance $12958 r0 *1 114.57,113.4
X$12958 6339 6447 27 6561 15 XOR2_X2
* cell instance $12961 r0 *1 117.23,113.4
X$12961 15 6412 6062 10780 6480 27 DFF_X2
* cell instance $12967 r0 *1 122.55,113.4
X$12967 15 6602 6062 10807 6223 27 DFF_X2
* cell instance $12969 r0 *1 126.35,113.4
X$12969 6832 6224 15 27 6445 NAND2_X1
* cell instance $12972 r0 *1 127.49,113.4
X$12972 15 6511 6062 10753 6568 27 DFF_X2
* cell instance $12976 r0 *1 133.76,113.4
X$12976 15 6484 6485 6414 6273 27 DFF_X1
* cell instance $12978 m0 *1 138.32,113.4
X$12978 6370 6416 27 15 5888 XNOR2_X1
* cell instance $12979 m0 *1 137.18,113.4
X$12979 6271 6415 27 15 6370 XNOR2_X1
* cell instance $12980 m0 *1 139.46,113.4
X$12980 6364 6227 27 15 6065 XNOR2_X1
* cell instance $12986 r0 *1 141.36,113.4
X$12986 5591 6839 6508 27 15 6419 HA_X1
* cell instance $12988 m0 *1 142.5,113.4
X$12988 6368 6418 27 15 6343 XNOR2_X1
* cell instance $12991 r0 *1 143.83,113.4
X$12991 6419 6486 27 15 6268 XNOR2_X1
* cell instance $12992 m0 *1 144.21,113.4
X$12992 6443 6509 5408 27 15 6366 HA_X1
* cell instance $12994 m0 *1 146.11,113.4
X$12994 15 6439 6344 5466 6366 6442 27 FA_X1
* cell instance $12997 r0 *1 144.97,113.4
X$12997 6487 5572 15 27 6443 NOR2_X1
* cell instance $12999 r0 *1 145.92,113.4
X$12999 6437 6508 6504 27 15 6486 HA_X1
* cell instance $13000 r0 *1 147.82,113.4
X$13000 15 6440 6489 6420 6422 6504 27 FA_X1
* cell instance $13001 m0 *1 150.48,113.4
X$13001 6420 15 27 6365 INV_X1
* cell instance $13005 r0 *1 150.86,113.4
X$13005 6435 5602 6069 27 15 6440 HA_X1
* cell instance $13006 m0 *1 152.95,113.4
X$13006 6362 15 27 6363 INV_X1
* cell instance $13008 m0 *1 153.33,113.4
X$13008 15 6361 6362 6070 6345 6502 27 FA_X1
* cell instance $13009 m0 *1 156.37,113.4
X$13009 15 5390 6361 6346 5407 6360 27 FA_X1
* cell instance $13010 m0 *1 159.41,113.4
X$13010 6347 15 27 6437 INV_X1
* cell instance $13013 m0 *1 160.74,113.4
X$13013 15 5488 6348 6435 4994 5730 27 FA_X1
* cell instance $13018 r0 *1 154.47,113.4
X$13018 6438 15 27 6439 INV_X1
* cell instance $13019 r0 *1 154.85,113.4
X$13019 15 5569 6438 6072 6704 6421 27 FA_X1
* cell instance $13021 r0 *1 158.08,113.4
X$13021 5978 6233 15 27 6360 NOR2_X1
* cell instance $13025 r0 *1 159.98,113.4
X$13025 6157 15 27 6586 INV_X1
* cell instance $13028 r0 *1 160.93,113.4
X$13028 6348 15 27 6585 INV_X1
* cell instance $13032 r0 *1 162.64,113.4
X$13032 6423 15 27 6422 INV_X1
* cell instance $13035 r0 *1 163.59,113.4
X$13035 6233 6424 15 27 6235 OR2_X1
* cell instance $13036 r0 *1 164.35,113.4
X$13036 6434 5990 5390 15 27 NOR2_X4
* cell instance $13038 m0 *1 167.39,113.4
X$13038 6434 6252 15 27 6349 OR2_X2
* cell instance $13044 m0 *1 169.48,113.4
X$13044 6349 15 27 4994 INV_X4
* cell instance $13049 r0 *1 171.19,113.4
X$13049 6424 6236 15 27 6498 NOR2_X1
* cell instance $13052 r0 *1 172.71,113.4
X$13052 6490 6498 6495 27 15 6426 HA_X1
* cell instance $13053 m0 *1 174.8,113.4
X$13053 6425 15 27 6359 INV_X1
* cell instance $13055 m0 *1 175.18,113.4
X$13055 6426 6433 6357 27 15 6350 HA_X1
* cell instance $13056 m0 *1 177.08,113.4
X$13056 6357 6427 6355 27 15 6351 HA_X1
* cell instance $13057 m0 *1 178.98,113.4
X$13057 4994 4510 6428 27 15 6352 HA_X1
* cell instance $13058 m0 *1 180.88,113.4
X$13058 6352 15 27 6353 INV_X1
* cell instance $13063 r0 *1 175.18,113.4
X$13063 6492 6495 6432 27 15 6427 HA_X1
* cell instance $13067 r0 *1 179.17,113.4
X$13067 6432 6428 6493 27 15 6430 HA_X1
* cell instance $13087 m0 *1 4.37,116.2
X$13087 6615 6531 15 27 6528 NAND2_X1
* cell instance $13088 m0 *1 4.94,116.2
X$13088 15 10294 6530 6578 6388 27 DFF_X1
* cell instance $13093 r0 *1 1.71,116.2
X$13093 15 10528 6615 6577 6388 27 DFF_X1
* cell instance $13097 r0 *1 4.94,116.2
X$13097 6529 6528 6642 15 6577 27 AOI21_X1
* cell instance $13099 r0 *1 6.08,116.2
X$13099 6530 6531 15 27 6532 NAND2_X1
* cell instance $13100 r0 *1 6.65,116.2
X$13100 6529 6532 6644 15 6578 27 AOI21_X1
* cell instance $13101 r0 *1 7.41,116.2
X$13101 15 10570 6617 6643 6388 27 DFF_X1
* cell instance $13102 m0 *1 9.5,116.2
X$13102 6461 15 27 6541 BUF_X2
* cell instance $13107 m0 *1 15.01,116.2
X$13107 6025 6201 5937 5492 6462 6496 15 27 OAI221_X2
* cell instance $13108 m0 *1 17.1,116.2
X$13108 15 6581 6436 10693 5310 27 DFF_X2
* cell instance $13113 r0 *1 15.58,116.2
X$13113 15 10558 6391 6496 6436 27 DFF_X1
* cell instance $13115 r0 *1 19.19,116.2
X$13115 15 6390 27 6248 BUF_X8
* cell instance $13116 m0 *1 23.18,116.2
X$13116 15 6582 6436 10669 5312 27 DFF_X2
* cell instance $13117 m0 *1 21.09,116.2
X$13117 5747 6583 5937 6542 6463 6582 15 27 OAI221_X2
* cell instance $13119 m0 *1 26.98,116.2
X$13119 6028 6392 6464 15 27 6510 MUX2_X1
* cell instance $13120 m0 *1 28.31,116.2
X$13120 6534 6465 6533 6134 6536 27 15 6507 OAI221_X1
* cell instance $13121 m0 *1 29.45,116.2
X$13121 6314 6393 15 27 6466 NAND2_X1
* cell instance $13123 m0 *1 30.21,116.2
X$13123 6534 6467 6588 5492 6536 27 15 6535 OAI221_X1
* cell instance $13124 m0 *1 31.35,116.2
X$13124 6538 5213 15 27 6588 NAND2_X1
* cell instance $13125 m0 *1 31.92,116.2
X$13125 6313 6392 6513 15 27 6589 MUX2_X1
* cell instance $13129 r0 *1 22.04,116.2
X$13129 6523 15 27 6436 CLKBUF_X3
* cell instance $13130 r0 *1 22.99,116.2
X$13130 6436 15 27 CLKBUF_X1
* cell instance $13134 r0 *1 26.22,116.2
X$13134 6028 15 27 6654 BUF_X2
* cell instance $13137 r0 *1 28.12,116.2
X$13137 6538 5658 15 27 6533 NAND2_X1
* cell instance $13139 r0 *1 29.07,116.2
X$13139 15 6535 6537 10754 5213 27 DFF_X2
* cell instance $13142 r0 *1 34.58,116.2
X$13142 6539 5735 15 27 6618 NAND2_X1
* cell instance $13145 m0 *1 35.15,116.2
X$13145 6539 6468 15 27 6728 NAND2_X1
* cell instance $13149 r0 *1 36.48,116.2
X$13149 6539 5787 15 27 6730 NAND2_X1
* cell instance $13150 m0 *1 37.05,116.2
X$13150 6539 5934 15 27 6592 NAND2_X1
* cell instance $13153 m0 *1 38.38,116.2
X$13153 6544 27 6392 15 BUF_X4
* cell instance $13155 m0 *1 39.9,116.2
X$13155 6534 6594 6593 6542 6536 27 15 6595 OAI221_X1
* cell instance $13156 m0 *1 41.04,116.2
X$13156 15 6595 6471 10655 5126 27 DFF_X2
* cell instance $13157 m0 *1 44.65,116.2
X$13157 15 6469 6471 10665 5127 27 DFF_X2
* cell instance $13158 m0 *1 48.26,116.2
X$13158 6539 5821 15 27 6622 NAND2_X1
* cell instance $13159 m0 *1 48.83,116.2
X$13159 6539 5938 15 27 6543 NAND2_X1
* cell instance $13161 m0 *1 50.16,116.2
X$13161 5866 6396 15 27 6623 NAND2_X2
* cell instance $13164 r0 *1 37.43,116.2
X$13164 6540 6544 6592 15 27 6678 MUX2_X1
* cell instance $13165 r0 *1 38.76,116.2
X$13165 6394 27 6583 15 BUF_X4
* cell instance $13166 r0 *1 40.09,116.2
X$13166 6538 5126 15 27 6593 NAND2_X1
* cell instance $13167 r0 *1 40.66,116.2
X$13167 6539 5822 15 27 6620 NAND2_X1
* cell instance $13169 r0 *1 42.75,116.2
X$13169 6539 6541 15 27 6734 NAND2_X1
* cell instance $13171 r0 *1 43.51,116.2
X$13171 15 6621 6471 10793 5222 27 DFF_X2
* cell instance $13174 r0 *1 48.07,116.2
X$13174 6446 6544 6543 15 27 6624 MUX2_X1
* cell instance $13175 r0 *1 49.4,116.2
X$13175 15 6649 27 6446 BUF_X8
* cell instance $13176 m0 *1 51.68,116.2
X$13176 6396 5866 27 15 6525 AND2_X1
* cell instance $13179 m0 *1 53.2,116.2
X$13179 6146 15 27 6536 CLKBUF_X3
* cell instance $13182 r0 *1 51.87,116.2
X$13182 6523 15 27 6471 CLKBUF_X3
* cell instance $13183 r0 *1 52.82,116.2
X$13183 6471 15 27 10829 INV_X2
* cell instance $13187 r0 *1 56.05,116.2
X$13187 6597 6663 15 27 6627 NAND2_X1
* cell instance $13188 r0 *1 56.62,116.2
X$13188 6609 5869 6538 6628 15 27 6663 AOI22_X1
* cell instance $13190 m0 *1 57.57,116.2
X$13190 6599 6545 15 27 6597 NAND2_X1
* cell instance $13193 r0 *1 58.14,116.2
X$13193 6282 6545 6544 15 27 6626 AND3_X4
* cell instance $13194 m0 *1 58.71,116.2
X$13194 6544 27 6319 15 BUF_X4
* cell instance $13197 m0 *1 60.23,116.2
X$13197 6380 6545 6600 15 27 6524 MUX2_X1
* cell instance $13198 m0 *1 61.56,116.2
X$13198 6277 6319 6601 15 27 6470 MUX2_X1
* cell instance $13199 m0 *1 62.89,116.2
X$13199 6547 6282 6237 6314 15 27 6601 AOI22_X1
* cell instance $13205 r0 *1 60.23,116.2
X$13205 6191 6609 15 27 6545 NAND2_X1
* cell instance $13208 r0 *1 61.37,116.2
X$13208 6116 6534 15 27 6546 NAND2_X1
* cell instance $13209 r0 *1 61.94,116.2
X$13209 6139 15 27 6396 BUF_X1
* cell instance $13211 r0 *1 62.7,116.2
X$13211 6534 6470 6546 27 6665 15 OAI21_X1
* cell instance $13213 r0 *1 63.84,116.2
X$13213 15 6665 6185 10743 6547 27 DFF_X2
* cell instance $13215 m0 *1 67.26,116.2
X$13215 6399 27 6942 15 BUF_X4
* cell instance $13218 r0 *1 67.45,116.2
X$13218 15 10606 6664 6400 6185 27 DFF_X1
* cell instance $13219 r0 *1 70.68,116.2
X$13219 5510 6401 6549 15 5830 27 NAND3_X4
* cell instance $13221 m0 *1 72.77,116.2
X$13221 6185 15 27 10837 INV_X1
* cell instance $13223 m0 *1 75.43,116.2
X$13223 6549 1248 5034 15 27 6522 MUX2_X1
* cell instance $13224 m0 *1 76.76,116.2
X$13224 6550 6282 6354 6314 15 27 6520 AOI22_X1
* cell instance $13226 m0 *1 77.9,116.2
X$13226 6404 6209 6473 15 27 6519 MUX2_X1
* cell instance $13227 m0 *1 79.23,116.2
X$13227 15 6519 6185 10711 6550 27 DFF_X2
* cell instance $13228 m0 *1 82.84,116.2
X$13228 6518 6474 6458 15 27 NOR2_X4
* cell instance $13229 m0 *1 84.55,116.2
X$13229 6475 5941 15 27 6551 NAND2_X1
* cell instance $13231 m0 *1 85.31,116.2
X$13231 6405 6609 27 15 6142 AND2_X2
* cell instance $13233 m0 *1 86.45,116.2
X$13233 6475 6036 15 27 6552 NAND2_X1
* cell instance $13235 m0 *1 87.78,116.2
X$13235 6475 5896 15 27 6750 NAND2_X1
* cell instance $13236 m0 *1 88.35,116.2
X$13236 6554 15 27 6610 INV_X1
* cell instance $13237 m0 *1 88.73,116.2
X$13237 15 6555 27 6049 BUF_X8
* cell instance $13238 m0 *1 91.2,116.2
X$13238 6331 6326 15 27 6476 NOR2_X2
* cell instance $13239 m0 *1 92.15,116.2
X$13239 6476 6477 6554 15 27 6410 NAND3_X1
* cell instance $13242 m0 *1 96.14,116.2
X$13242 6516 6340 15 6515 27 NAND2_X4
* cell instance $13243 m0 *1 97.85,116.2
X$13243 6455 15 27 6556 INV_X2
* cell instance $13244 m0 *1 98.42,116.2
X$13244 6556 6660 15 27 6477 NOR2_X1
* cell instance $13245 m0 *1 98.99,116.2
X$13245 6379 5456 5290 5458 15 27 6557 NOR4_X1
* cell instance $13250 r0 *1 76.95,116.2
X$13250 15 6048 6606 27 BUF_X16
* cell instance $13251 r0 *1 81.7,116.2
X$13251 15 6662 27 6048 BUF_X8
* cell instance $13253 r0 *1 84.55,116.2
X$13253 15 6431 6633 6631 6555 6610 27 AOI22_X4
* cell instance $13257 r0 *1 89.11,116.2
X$13257 15 5673 6633 6553 6555 6326 27 AOI22_X4
* cell instance $13260 r0 *1 94.05,116.2
X$13260 15 6612 6632 6604 6555 6331 27 AOI22_X4
* cell instance $13261 r0 *1 97.28,116.2
X$13261 6150 6330 6055 5804 15 27 6661 NOR4_X1
* cell instance $13262 r0 *1 98.23,116.2
X$13262 6340 6556 15 6747 27 NAND2_X4
* cell instance $13264 r0 *1 100.13,116.2
X$13264 6290 15 27 10827 INV_X2
* cell instance $13265 r0 *1 100.7,116.2
X$13265 6608 6611 6661 6557 15 27 6558 NAND4_X1
* cell instance $13266 r0 *1 101.65,116.2
X$13266 1564 15 27 6290 CLKBUF_X3
* cell instance $13267 m0 *1 102.03,116.2
X$13267 6340 6514 15 6560 27 NAND2_X4
* cell instance $13270 r0 *1 102.6,116.2
X$13270 5565 6216 6338 6334 15 27 6611 NOR4_X1
* cell instance $13272 r0 *1 103.93,116.2
X$13272 5830 27 5937 15 BUF_X4
* cell instance $13274 m0 *1 104.12,116.2
X$13274 5692 27 5939 15 BUF_X4
* cell instance $13277 r0 *1 106.78,116.2
X$13277 15 6659 6633 6658 6555 6058 27 AOI22_X4
* cell instance $13278 m0 *1 107.54,116.2
X$13278 5845 5643 5843 6056 15 27 6608 NOR4_X1
* cell instance $13280 m0 *1 108.49,116.2
X$13280 5967 15 27 6607 CLKBUF_X3
* cell instance $13282 m0 *1 110.2,116.2
X$13282 6478 15 27 6479 INV_X1
* cell instance $13285 m0 *1 111.53,116.2
X$13285 5354 15 27 6413 CLKBUF_X3
* cell instance $13287 r0 *1 110.01,116.2
X$13287 6559 6635 15 6657 27 NAND2_X4
* cell instance $13289 r0 *1 112.1,116.2
X$13289 5692 15 27 6562 CLKBUF_X3
* cell instance $13290 m0 *1 113.05,116.2
X$13290 6220 27 6605 15 BUF_X4
* cell instance $13294 m0 *1 118.94,116.2
X$13294 6480 6482 15 6603 27 NAND2_X4
* cell instance $13295 m0 *1 120.65,116.2
X$13295 15 6481 6737 10721 6565 27 DFF_X2
* cell instance $13296 m0 *1 124.26,116.2
X$13296 6565 6482 15 6512 27 NAND2_X4
* cell instance $13305 r0 *1 115.14,116.2
X$13305 6561 6340 15 6789 27 NAND2_X4
* cell instance $13307 r0 *1 118.37,116.2
X$13307 6515 6562 6564 6604 6603 6412 15 27 OAI221_X2
* cell instance $13311 r0 *1 121.22,116.2
X$13311 6296 6562 6564 6553 6512 6481 15 27 OAI221_X2
* cell instance $13313 r0 *1 123.5,116.2
X$13313 6560 6562 6564 6566 6655 6602 15 27 OAI221_X2
* cell instance $13314 r0 *1 125.59,116.2
X$13314 5461 6482 15 6735 27 NAND2_X4
* cell instance $13315 r0 *1 127.3,116.2
X$13315 6223 6567 15 6655 27 NAND2_X4
* cell instance $13316 m0 *1 129.01,116.2
X$13316 6568 6567 15 6598 27 NAND2_X4
* cell instance $13317 m0 *1 127.87,116.2
X$13317 6013 6564 6598 5925 6562 27 15 6511 OAI221_X1
* cell instance $13320 m0 *1 133.95,116.2
X$13320 15 6569 6596 6483 6273 27 DFF_X1
* cell instance $13322 r0 *1 129.01,116.2
X$13322 6605 6562 6564 6638 6651 6652 15 27 OAI221_X2
* cell instance $13323 r0 *1 131.1,116.2
X$13323 6698 6567 15 6653 27 NAND2_X4
* cell instance $13324 r0 *1 132.81,116.2
X$13324 6699 6567 15 6651 27 NAND2_X4
* cell instance $13326 r0 *1 134.71,116.2
X$13326 6413 15 27 6273 CLKBUF_X3
* cell instance $13327 r0 *1 135.66,116.2
X$13327 6273 15 27 CLKBUF_X1
* cell instance $13329 r0 *1 136.99,116.2
X$13329 6569 15 27 6863 CLKBUF_X3
* cell instance $13331 m0 *1 137.56,116.2
X$13331 6484 15 27 6700 CLKBUF_X3
* cell instance $13333 m0 *1 139.46,116.2
X$13333 6485 15 27 6570 INV_X1
* cell instance $13337 r0 *1 137.94,116.2
X$13337 6232 6650 27 15 6726 XNOR2_X1
* cell instance $13338 r0 *1 139.08,116.2
X$13338 6159 5662 27 15 6650 XNOR2_X1
* cell instance $13342 m0 *1 142.69,116.2
X$13342 6571 6506 27 15 6418 XNOR2_X1
* cell instance $13345 r0 *1 142.69,116.2
X$13345 6596 15 27 6573 INV_X2
* cell instance $13346 r0 *1 143.26,116.2
X$13346 15 6723 6107 5814 6590 6647 27 FA_X1
* cell instance $13347 m0 *1 144.4,116.2
X$13347 6572 5570 15 27 6509 NOR2_X1
* cell instance $13350 m0 *1 146.49,116.2
X$13350 6572 5572 15 27 6488 NOR2_X1
* cell instance $13351 m0 *1 147.06,116.2
X$13351 6503 6489 27 15 6506 XNOR2_X1
* cell instance $13355 r0 *1 146.3,116.2
X$13355 6488 6640 6442 27 15 6590 HA_X1
* cell instance $13357 m0 *1 151.05,116.2
X$13357 6505 6501 15 27 6591 XOR2_X1
* cell instance $13359 m0 *1 152.19,116.2
X$13359 6487 15 27 5977 BUF_X1
* cell instance $13362 m0 *1 154.47,116.2
X$13362 6574 6570 5745 15 27 NOR2_X4
* cell instance $13366 r0 *1 151.43,116.2
X$13366 6591 6646 27 15 6364 XNOR2_X1
* cell instance $13369 r0 *1 154.47,116.2
X$13369 6641 6645 27 15 6646 XNOR2_X1
* cell instance $13371 r0 *1 155.99,116.2
X$13371 6434 5471 15 27 6421 OR2_X2
* cell instance $13373 r0 *1 157.13,116.2
X$13373 6421 15 27 5407 INV_X2
* cell instance $13374 m0 *1 157.51,116.2
X$13374 15 5390 6503 6587 6360 5473 27 FA_X1
* cell instance $13378 r0 *1 158.08,116.2
X$13378 6705 5407 6501 27 15 10924 HA_X1
* cell instance $13379 r0 *1 159.98,116.2
X$13379 15 6586 6645 6423 6584 6585 27 FA_X1
* cell instance $13381 m0 *1 160.93,116.2
X$13381 6587 15 27 6584 INV_X1
* cell instance $13384 m0 *1 165.3,116.2
X$13384 6159 6434 5473 15 27 NOR2_X4
* cell instance $13389 r0 *1 163.78,116.2
X$13389 6573 15 27 5572 CLKBUF_X3
* cell instance $13393 m0 *1 169.86,116.2
X$13393 6252 6573 15 27 6497 NOR2_X1
* cell instance $13395 m0 *1 170.43,116.2
X$13395 6249 6236 15 27 6499 NOR2_X1
* cell instance $13397 m0 *1 171.19,116.2
X$13397 6424 6573 15 27 6580 NOR2_X1
* cell instance $13398 m0 *1 171.76,116.2
X$13398 6580 6499 6433 27 15 6425 HA_X1
* cell instance $13399 m0 *1 173.66,116.2
X$13399 6497 6491 6579 27 15 6492 HA_X1
* cell instance $13405 r0 *1 170.62,116.2
X$13405 6574 6236 15 27 6491 NOR2_X1
* cell instance $13409 r0 *1 171.19,116.2
X$13409 6574 6573 15 27 6490 NOR2_X1
* cell instance $13412 m0 *1 178.41,116.2
X$13412 6579 4782 27 15 6494 AND2_X1
* cell instance $13414 m0 *1 179.17,116.2
X$13414 6493 6494 6576 27 15 6575 HA_X1
* cell instance $13415 m0 *1 181.07,116.2
X$13415 6575 6576 4782 15 6429 27 AOI21_X1
* cell instance $13429 r0 *1 1.33,135.8
X$13429 7585 15 27 7532 BUF_X1
* cell instance $13432 r0 *1 2.47,135.8
X$13432 15 10591 7585 7584 7268 27 DFF_X1
* cell instance $13436 m0 *1 5.32,135.8
X$13436 7585 7024 15 27 7586 NAND2_X1
* cell instance $13437 m0 *1 4.75,135.8
X$13437 7591 15 27 7440 BUF_X1
* cell instance $13441 m0 *1 8.36,135.8
X$13441 7533 15 27 6531 CLKBUF_X3
* cell instance $13442 m0 *1 9.31,135.8
X$13442 7441 7363 7691 15 7486 27 AOI21_X1
* cell instance $13444 r0 *1 5.7,135.8
X$13444 6523 15 27 7268 CLKBUF_X3
* cell instance $13445 r0 *1 6.65,135.8
X$13445 7441 7586 7587 15 7584 27 AOI21_X1
* cell instance $13446 r0 *1 7.41,135.8
X$13446 7533 15 27 7024 CLKBUF_X3
* cell instance $13447 r0 *1 8.36,135.8
X$13447 15 10602 7591 7590 7268 27 DFF_X1
* cell instance $13448 m0 *1 10.64,135.8
X$13448 7591 6531 15 27 7534 NAND2_X1
* cell instance $13451 m0 *1 11.97,135.8
X$13451 7536 7364 15 27 7485 NAND2_X1
* cell instance $13454 m0 *1 16.34,135.8
X$13454 7028 7536 15 27 7492 NAND2_X2
* cell instance $13458 m0 *1 29.64,135.8
X$13458 7538 7442 6027 15 27 7606 MUX2_X1
* cell instance $13459 m0 *1 30.97,135.8
X$13459 7444 7542 7606 15 27 7609 MUX2_X1
* cell instance $13460 m0 *1 32.3,135.8
X$13460 7539 7609 7446 27 15 6135 MUX2_X2
* cell instance $13462 r0 *1 11.59,135.8
X$13462 6880 7534 7593 15 7590 27 AOI21_X1
* cell instance $13463 r0 *1 12.35,135.8
X$13463 7006 7364 15 27 7587 NAND2_X1
* cell instance $13467 r0 *1 15.58,135.8
X$13467 6389 7274 7492 7112 6313 27 15 7698 OAI221_X1
* cell instance $13468 r0 *1 16.72,135.8
X$13468 15 10623 7536 7698 7537 27 DFF_X1
* cell instance $13469 r0 *1 19.95,135.8
X$13469 7699 7535 15 7704 27 NAND2_X4
* cell instance $13473 r0 *1 23.75,135.8
X$13473 7367 7232 5186 15 27 7712 MUX2_X1
* cell instance $13474 r0 *1 25.08,135.8
X$13474 7367 7653 5186 15 27 7715 MUX2_X1
* cell instance $13477 r0 *1 29.64,135.8
X$13477 7538 7443 6027 15 27 7608 MUX2_X1
* cell instance $13480 r0 *1 31.54,135.8
X$13480 7445 7605 7608 15 27 7612 MUX2_X1
* cell instance $13483 r0 *1 34.01,135.8
X$13483 15 6721 7540 7435 7612 27 AOI21_X4
* cell instance $13484 m0 *1 34.58,135.8
X$13484 6957 7447 5212 15 27 7614 MUX2_X1
* cell instance $13486 m0 *1 35.91,135.8
X$13486 6957 7548 5212 15 27 7543 MUX2_X1
* cell instance $13493 r0 *1 37.05,135.8
X$13493 7614 7605 7728 15 27 7619 MUX2_X1
* cell instance $13496 r0 *1 39.52,135.8
X$13496 15 5471 7544 7435 7619 27 AOI21_X4
* cell instance $13498 m0 *1 44.65,135.8
X$13498 6885 7452 7449 15 27 7547 MUX2_X1
* cell instance $13499 m0 *1 42.94,135.8
X$13499 7623 7510 7446 27 15 5363 MUX2_X2
* cell instance $13500 m0 *1 45.98,135.8
X$13500 7547 7450 7621 15 27 7623 MUX2_X1
* cell instance $13501 m0 *1 47.31,135.8
X$13501 7625 7542 7626 15 27 7627 MUX2_X1
* cell instance $13503 m0 *1 48.83,135.8
X$13503 7512 7451 7549 15 27 7629 MUX2_X1
* cell instance $13504 m0 *1 50.16,135.8
X$13504 7628 7627 7446 27 15 5542 MUX2_X2
* cell instance $13508 r0 *1 43.7,135.8
X$13508 7545 7448 7546 15 27 7376 MUX2_X1
* cell instance $13509 r0 *1 45.03,135.8
X$13509 7545 7500 7546 15 27 7621 MUX2_X1
* cell instance $13512 r0 *1 47.5,135.8
X$13512 7535 7548 5440 15 27 7626 MUX2_X1
* cell instance $13514 r0 *1 49.02,135.8
X$13514 7535 7624 5440 15 27 7549 MUX2_X1
* cell instance $13517 r0 *1 52.06,135.8
X$13517 15 6159 7930 7435 7629 27 AOI21_X4
* cell instance $13518 m0 *1 53.2,135.8
X$13518 6955 7448 6812 15 27 7630 MUX2_X1
* cell instance $13520 m0 *1 54.53,135.8
X$13520 7515 7448 5226 15 27 7633 MUX2_X1
* cell instance $13521 m0 *1 55.86,135.8
X$13521 7632 7453 7446 27 15 5680 MUX2_X2
* cell instance $13524 r0 *1 54.91,135.8
X$13524 7630 7340 7633 15 27 7631 MUX2_X1
* cell instance $13525 r0 *1 56.24,135.8
X$13525 15 6232 7765 7347 7631 27 AOI21_X4
* cell instance $13527 m0 *1 57.95,135.8
X$13527 7525 15 27 7378 CLKBUF_X3
* cell instance $13529 r0 *1 58.71,135.8
X$13529 7378 15 27 10844 INV_X1
* cell instance $13534 r0 *1 59.28,135.8
X$13534 15 10561 7521 7740 7378 27 DFF_X1
* cell instance $13537 r0 *1 64.22,135.8
X$13537 7550 7454 7551 15 27 7662 MUX2_X1
* cell instance $13538 m0 *1 65.55,135.8
X$13538 7663 7455 7381 27 15 5952 MUX2_X2
* cell instance $13542 r0 *1 65.93,135.8
X$13542 7550 7283 7551 15 27 7744 MUX2_X1
* cell instance $13545 m0 *1 67.64,135.8
X$13545 7439 7099 15 27 7659 NAND2_X2
* cell instance $13547 m0 *1 69.54,135.8
X$13547 7381 27 7282 15 BUF_X4
* cell instance $13550 m0 *1 72.58,135.8
X$13550 7456 15 27 6685 CLKBUF_X3
* cell instance $13551 m0 *1 73.53,135.8
X$13551 7383 27 7542 15 BUF_X4
* cell instance $13557 r0 *1 73.15,135.8
X$13557 15 10540 7552 6522 7042 27 DFF_X1
* cell instance $13559 m0 *1 75.24,135.8
X$13559 7381 27 7446 15 BUF_X4
* cell instance $13561 m0 *1 77.52,135.8
X$13561 6473 7457 7638 15 27 7637 MUX2_X1
* cell instance $13566 r0 *1 77.71,135.8
X$13566 15 7637 7357 10763 7553 27 DFF_X2
* cell instance $13568 m0 *1 79.23,135.8
X$13568 7047 7553 6889 15 27 7458 NAND3_X1
* cell instance $13569 m0 *1 81.32,135.8
X$13569 7047 15 27 7459 INV_X4
* cell instance $13570 m0 *1 80.37,135.8
X$13570 7459 6518 15 27 7531 NAND2_X2
* cell instance $13572 m0 *1 82.46,135.8
X$13572 7383 27 7450 15 BUF_X4
* cell instance $13573 m0 *1 83.79,135.8
X$13573 7457 7459 15 7554 27 NAND2_X4
* cell instance $13578 r0 *1 82.65,135.8
X$13578 6961 7457 7047 15 27 7671 AND3_X4
* cell instance $13579 r0 *1 84.74,135.8
X$13579 6408 7457 7529 15 27 7746 MUX2_X1
* cell instance $13580 m0 *1 86.07,135.8
X$13580 6413 15 27 7357 CLKBUF_X3
* cell instance $13582 m0 *1 87.02,135.8
X$13582 7460 7643 6631 27 15 7529 OAI21_X2
* cell instance $13583 m0 *1 88.35,135.8
X$13583 7357 15 27 10835 INV_X1
* cell instance $13586 m0 *1 90.44,135.8
X$13586 15 7555 7357 10662 7462 27 DFF_X2
* cell instance $13589 m0 *1 95.76,135.8
X$13589 7462 7388 6828 15 27 7556 MUX2_X1
* cell instance $13590 m0 *1 97.09,135.8
X$13590 7556 7278 7296 15 27 7522 MUX2_X1
* cell instance $13591 m0 *1 98.42,135.8
X$13591 7294 15 27 10820 INV_X2
* cell instance $13592 m0 *1 98.99,135.8
X$13592 7743 7522 7282 27 15 5565 MUX2_X2
* cell instance $13593 m0 *1 100.7,135.8
X$13593 7641 7639 7282 27 15 5845 MUX2_X2
* cell instance $13594 m0 *1 102.41,135.8
X$13594 7463 7281 7464 15 27 7639 MUX2_X1
* cell instance $13598 m0 *1 106.21,135.8
X$13598 15 7636 7054 10660 7430 27 DFF_X2
* cell instance $13599 m0 *1 109.82,135.8
X$13599 6413 15 27 7054 CLKBUF_X3
* cell instance $13600 m0 *1 110.77,135.8
X$13600 7557 7385 15 27 7514 NAND2_X2
* cell instance $13602 m0 *1 114.76,135.8
X$13602 15 7465 7054 10676 7558 27 DFF_X2
* cell instance $13603 m0 *1 118.37,135.8
X$13603 7513 7559 15 7301 27 NAND2_X4
* cell instance $13605 m0 *1 120.84,135.8
X$13605 15 7635 7561 10707 7562 27 DFF_X2
* cell instance $13606 m0 *1 124.45,135.8
X$13606 7563 7391 15 7511 27 NAND2_X4
* cell instance $13607 m0 *1 126.16,135.8
X$13607 15 7634 7561 10705 7563 27 DFF_X2
* cell instance $13608 m0 *1 129.77,135.8
X$13608 6605 7300 7390 6638 7677 7467 15 27 OAI221_X2
* cell instance $13609 m0 *1 131.86,135.8
X$13609 7468 6063 15 27 7469 NAND2_X1
* cell instance $13613 m0 *1 134.9,135.8
X$13613 6413 15 27 7162 CLKBUF_X3
* cell instance $13614 m0 *1 135.85,135.8
X$13614 7162 15 27 10838 INV_X1
* cell instance $13618 r0 *1 86.07,135.8
X$13618 6972 7642 7047 15 27 7460 NAND3_X2
* cell instance $13619 r0 *1 87.4,135.8
X$13619 7047 15 27 7643 BUF_X2
* cell instance $13621 r0 *1 91.2,135.8
X$13621 6212 7554 7644 6213 7274 27 15 7555 OAI221_X1
* cell instance $13623 r0 *1 93.1,135.8
X$13623 7462 7671 15 27 7644 NAND2_X2
* cell instance $13628 r0 *1 98.42,135.8
X$13628 6413 15 27 7294 CLKBUF_X3
* cell instance $13631 r0 *1 101.65,135.8
X$13631 7640 7115 6829 15 27 7463 MUX2_X1
* cell instance $13636 r0 *1 111.53,135.8
X$13636 7258 7548 7557 15 27 7674 MUX2_X1
* cell instance $13639 r0 *1 114.57,135.8
X$13639 6607 7300 7390 6746 7735 7675 15 27 OAI221_X2
* cell instance $13643 r0 *1 116.66,135.8
X$13643 7558 7559 15 7736 27 NAND2_X4
* cell instance $13646 r0 *1 119.32,135.8
X$13646 7391 7560 15 7838 27 NAND2_X4
* cell instance $13650 r0 *1 122.17,135.8
X$13650 15 7385 7391 27 BUF_X16
* cell instance $13651 r0 *1 126.92,135.8
X$13651 6296 7300 7390 6553 7729 7730 15 27 OAI221_X2
* cell instance $13655 r0 *1 130.34,135.8
X$13655 15 7467 7162 10786 7620 27 DFF_X2
* cell instance $13656 r0 *1 133.95,135.8
X$13656 15 10515 7564 7622 7162 27 DFF_X1
* cell instance $13658 m0 *1 139.08,135.8
X$13658 6700 7302 15 27 7397 OR2_X2
* cell instance $13660 m0 *1 140.03,135.8
X$13660 7160 7399 15 27 7472 NAND2_X1
* cell instance $13662 m0 *1 140.79,135.8
X$13662 7126 15 27 7005 INV_X4
* cell instance $13671 m0 *1 5.13,68.6
X$13671 2891 15 27 3791 INV_X1
* cell instance $13673 m0 *1 6.27,68.6
X$13673 3110 3147 2572 15 27 3836 NAND3_X1
* cell instance $13682 r0 *1 4.56,68.6
X$13682 3086 3110 3791 27 3838 15 OAI21_X1
* cell instance $13683 r0 *1 5.32,68.6
X$13683 3048 3791 3110 15 3904 27 AOI21_X1
* cell instance $13686 r0 *1 6.65,68.6
X$13686 3835 3836 15 27 3906 XNOR2_X2
* cell instance $13687 r0 *1 8.55,68.6
X$13687 3838 2757 27 15 4064 AND2_X1
* cell instance $13689 m0 *1 10.64,68.6
X$13689 3724 3674 3575 3792 3725 3873 27 15 AOI221_X2
* cell instance $13691 m0 *1 12.73,68.6
X$13691 3231 3404 2854 27 15 3726 OAI21_X2
* cell instance $13692 m0 *1 14.06,68.6
X$13692 15 3676 3576 3792 3387 27 AOI21_X4
* cell instance $13694 m0 *1 17.29,68.6
X$13694 3127 3908 3265 2854 3677 3793 15 27 OAI221_X2
* cell instance $13696 m0 *1 19.57,68.6
X$13696 2854 3265 3677 27 3678 15 OAI21_X1
* cell instance $13702 r0 *1 11.97,68.6
X$13702 3725 3792 15 27 3839 NAND2_X1
* cell instance $13703 r0 *1 12.54,68.6
X$13703 3405 27 3792 15 BUF_X4
* cell instance $13704 r0 *1 13.87,68.6
X$13704 3387 3405 3576 1499 3841 3929 27 15 AOI221_X2
* cell instance $13705 r0 *1 15.96,68.6
X$13705 2927 3680 15 27 3840 OR2_X1
* cell instance $13706 r0 *1 16.72,68.6
X$13706 3347 3680 15 27 3841 OR2_X1
* cell instance $13707 r0 *1 17.48,68.6
X$13707 15 3727 3842 3387 3794 2854 27 OAI211_X4
* cell instance $13708 r0 *1 20.71,68.6
X$13708 3766 3577 15 27 3844 NOR2_X1
* cell instance $13709 r0 *1 21.28,68.6
X$13709 3730 3676 27 15 3911 XNOR2_X1
* cell instance $13710 r0 *1 22.42,68.6
X$13710 3676 3730 15 27 3795 NAND2_X1
* cell instance $13711 r0 *1 22.99,68.6
X$13711 3796 3396 3797 3846 3848 3847 15 27 OAI221_X2
* cell instance $13712 m0 *1 23.18,68.6
X$13712 2927 15 27 3730 CLKBUF_X3
* cell instance $13714 m0 *1 24.13,68.6
X$13714 2927 3680 15 27 3728 XNOR2_X2
* cell instance $13719 r0 *1 25.08,68.6
X$13719 3728 3676 15 27 3848 NAND2_X1
* cell instance $13724 r0 *1 30.78,68.6
X$13724 3492 15 27 3850 INV_X1
* cell instance $13726 m0 *1 36.48,68.6
X$13726 3682 3729 15 27 3888 NOR2_X1
* cell instance $13728 m0 *1 37.05,68.6
X$13728 3682 3729 15 3852 27 OR2_X4
* cell instance $13729 m0 *1 38.76,68.6
X$13729 3584 3347 15 27 3684 NAND2_X1
* cell instance $13731 m0 *1 39.52,68.6
X$13731 3730 15 27 3416 CLKBUF_X3
* cell instance $13732 m0 *1 40.47,68.6
X$13732 3730 3579 27 15 3768 XNOR2_X1
* cell instance $13733 m0 *1 41.61,68.6
X$13733 3853 3731 15 27 3732 OR2_X1
* cell instance $13734 m0 *1 42.37,68.6
X$13734 3127 3579 27 15 3733 AND2_X1
* cell instance $13735 m0 *1 43.13,68.6
X$13735 3733 3716 3768 15 3770 27 AOI21_X1
* cell instance $13738 m0 *1 47.12,68.6
X$13738 2900 3771 3687 15 3734 27 AOI21_X1
* cell instance $13741 m0 *1 51.68,68.6
X$13741 3416 3273 3720 27 15 3688 AND3_X1
* cell instance $13742 m0 *1 52.63,68.6
X$13742 3736 3690 3688 15 27 3776 MUX2_X1
* cell instance $13744 m0 *1 54.15,68.6
X$13744 15 3776 3420 3186 3938 3184 27 OAI22_X4
* cell instance $13749 r0 *1 40.85,68.6
X$13749 3584 3643 15 27 3853 NOR2_X2
* cell instance $13750 r0 *1 41.8,68.6
X$13750 3798 3732 3414 27 15 3245 MUX2_X2
* cell instance $13751 r0 *1 43.51,68.6
X$13751 3853 3731 15 27 3854 NOR2_X1
* cell instance $13753 r0 *1 44.27,68.6
X$13753 3770 3414 3854 15 27 3801 MUX2_X1
* cell instance $13755 r0 *1 45.79,68.6
X$13755 3935 3583 3584 15 27 3800 MUX2_X1
* cell instance $13756 r0 *1 47.12,68.6
X$13756 3800 15 27 3690 CLKBUF_X3
* cell instance $13759 r0 *1 49.97,68.6
X$13759 3495 3127 15 27 3919 NOR2_X1
* cell instance $13760 r0 *1 50.54,68.6
X$13760 3801 15 27 3121 BUF_X2
* cell instance $13762 r0 *1 52.06,68.6
X$13762 3735 3720 27 15 3736 AND2_X1
* cell instance $13763 r0 *1 52.82,68.6
X$13763 15 3689 3735 3186 3802 3184 27 OAI22_X4
* cell instance $13764 r0 *1 56.05,68.6
X$13764 3495 3802 15 27 3739 XNOR2_X2
* cell instance $13766 m0 *1 57.76,68.6
X$13766 3780 3419 3779 15 3737 27 AOI21_X1
* cell instance $13768 r0 *1 58.14,68.6
X$13768 3803 15 27 3780 INV_X1
* cell instance $13769 r0 *1 58.52,68.6
X$13769 3188 3638 15 27 3804 XNOR2_X2
* cell instance $13771 m0 *1 58.9,68.6
X$13771 3369 3638 15 27 3738 XNOR2_X2
* cell instance $13775 r0 *1 60.42,68.6
X$13775 3369 3721 27 15 3859 XNOR2_X1
* cell instance $13776 m0 *1 61.37,68.6
X$13776 3721 3739 3805 15 3860 27 AOI21_X2
* cell instance $13779 r0 *1 61.56,68.6
X$13779 15 3924 3739 3864 3740 2535 27 AOI22_X4
* cell instance $13780 m0 *1 63.27,68.6
X$13780 3590 3588 3589 27 3742 15 NOR3_X2
* cell instance $13782 m0 *1 64.6,68.6
X$13782 15 3741 3786 3691 3742 3861 27 NOR4_X4
* cell instance $13783 m0 *1 68.02,68.6
X$13783 3741 3786 3691 3742 15 27 3743 OR4_X1
* cell instance $13786 m0 *1 70.87,68.6
X$13786 3478 3694 3744 15 3789 27 AOI21_X2
* cell instance $13789 r0 *1 64.98,68.6
X$13789 3587 3499 3807 15 3891 27 NAND3_X4
* cell instance $13790 r0 *1 67.45,68.6
X$13790 3499 3587 3807 27 15 4026 AND3_X2
* cell instance $13793 r0 *1 69.54,68.6
X$13793 3692 3694 3808 15 27 3865 NAND3_X2
* cell instance $13794 r0 *1 70.87,68.6
X$13794 3693 3744 3694 15 27 3810 NAND3_X1
* cell instance $13797 r0 *1 72.2,68.6
X$13797 3808 3694 3692 27 15 3747 AND3_X1
* cell instance $13798 m0 *1 74.29,68.6
X$13798 3649 3478 27 15 3790 AND2_X1
* cell instance $13799 m0 *1 72.58,68.6
X$13799 3695 3790 3809 3745 27 15 3746 OAI22_X2
* cell instance $13802 m0 *1 78.28,68.6
X$13802 3362 3259 27 15 3927 XNOR2_X1
* cell instance $13806 m0 *1 81.89,68.6
X$13806 3594 3510 3194 15 27 NOR2_X4
* cell instance $13808 m0 *1 84.36,68.6
X$13808 15 3281 3696 4006 3697 3430 27 AOI22_X4
* cell instance $13809 m0 *1 87.59,68.6
X$13809 3787 3430 3431 15 27 3816 OR3_X4
* cell instance $13810 m0 *1 89.68,68.6
X$13810 3698 3699 3511 27 15 4234 MUX2_X2
* cell instance $13811 m0 *1 91.39,68.6
X$13811 3369 3199 15 27 3748 XNOR2_X2
* cell instance $13813 r0 *1 73.15,68.6
X$13813 3279 3745 3809 27 15 3928 OAI21_X2
* cell instance $13815 r0 *1 74.86,68.6
X$13815 3810 3746 15 27 3788 NAND2_X1
* cell instance $13817 r0 *1 75.81,68.6
X$13817 3789 3747 3429 27 4188 15 NOR3_X2
* cell instance $13818 r0 *1 77.14,68.6
X$13818 3723 3747 3789 27 15 3946 OAI21_X2
* cell instance $13819 r0 *1 78.47,68.6
X$13819 3362 3747 3789 3259 27 3812 15 OR4_X2
* cell instance $13821 r0 *1 79.99,68.6
X$13821 3572 3788 3813 27 3868 15 OAI21_X1
* cell instance $13823 r0 *1 80.94,68.6
X$13823 3948 3814 15 27 3870 OR2_X1
* cell instance $13824 r0 *1 81.7,68.6
X$13824 3814 3281 15 27 3815 NAND2_X1
* cell instance $13829 r0 *1 87.97,68.6
X$13829 3367 27 3871 15 BUF_X4
* cell instance $13832 r0 *1 92.53,68.6
X$13832 3748 3511 15 27 3950 NOR2_X1
* cell instance $13834 m0 *1 94.43,68.6
X$13834 3511 3722 27 15 3701 XNOR2_X1
* cell instance $13835 m0 *1 93.67,68.6
X$13835 3253 3070 3748 27 3722 15 OAI21_X1
* cell instance $13839 r0 *1 93.86,68.6
X$13839 3748 3511 15 27 3869 NAND2_X2
* cell instance $13854 r0 *1 5.32,166.6
X$13854 9250 15 27 9221 BUF_X1
* cell instance $13857 m0 *1 7.03,166.6
X$13857 9171 15 27 9170 BUF_X1
* cell instance $13861 r0 *1 9.31,166.6
X$13861 15 10557 9250 9194 8916 27 DFF_X1
* cell instance $13862 m0 *1 13.49,166.6
X$13862 8969 15 27 8916 CLKBUF_X3
* cell instance $13863 m0 *1 10.26,166.6
X$13863 15 10454 9171 9197 9289 27 DFF_X1
* cell instance $13864 m0 *1 14.44,166.6
X$13864 9222 9134 9097 15 9197 27 AOI21_X1
* cell instance $13866 r0 *1 12.54,166.6
X$13866 9222 9252 9036 15 9194 27 AOI21_X1
* cell instance $13868 r0 *1 13.49,166.6
X$13868 8734 8732 15 27 9333 NAND2_X1
* cell instance $13871 m0 *1 17.29,166.6
X$13871 15 10451 8570 9202 8916 27 DFF_X1
* cell instance $13872 m0 *1 15.58,166.6
X$13872 8404 8880 15 9201 27 NAND2_X4
* cell instance $13873 m0 *1 20.52,166.6
X$13873 15 10425 8734 9203 8873 27 DFF_X1
* cell instance $13874 m0 *1 23.75,166.6
X$13874 8871 6201 9006 5492 9148 9203 15 27 OAI221_X2
* cell instance $13876 r0 *1 15.96,166.6
X$13876 8871 6540 9006 6670 9201 9223 15 27 OAI221_X2
* cell instance $13878 r0 *1 24.13,166.6
X$13878 5492 8975 9098 8874 6201 27 15 9341 OAI221_X1
* cell instance $13879 r0 *1 25.27,166.6
X$13879 6134 8975 9099 8874 6133 27 15 9340 OAI221_X1
* cell instance $13880 m0 *1 26.79,166.6
X$13880 7525 15 27 8873 CLKBUF_X3
* cell instance $13881 m0 *1 26.22,166.6
X$13881 9101 8502 15 27 9172 NAND2_X1
* cell instance $13882 m0 *1 27.74,166.6
X$13882 9103 8734 15 9148 27 NAND2_X4
* cell instance $13883 m0 *1 29.45,166.6
X$13883 15 10376 8551 9210 9224 27 DFF_X1
* cell instance $13884 m0 *1 32.68,166.6
X$13884 8874 5690 8814 5689 9156 9346 15 27 OAI221_X2
* cell instance $13885 m0 *1 34.77,166.6
X$13885 8576 8967 15 9156 27 NAND2_X4
* cell instance $13886 m0 *1 36.48,166.6
X$13886 5689 8736 9213 8968 5690 27 15 9212 OAI221_X1
* cell instance $13887 m0 *1 37.62,166.6
X$13887 8166 9101 15 27 9213 NAND2_X1
* cell instance $13889 m0 *1 41.23,166.6
X$13889 8668 27 9153 15 BUF_X4
* cell instance $13893 r0 *1 26.6,166.6
X$13893 6134 9070 9172 8968 6133 27 15 9260 OAI221_X1
* cell instance $13895 r0 *1 27.93,166.6
X$13895 5492 9070 9263 8968 6201 27 15 9342 OAI221_X1
* cell instance $13898 r0 *1 30.02,166.6
X$13898 9153 8005 15 27 9263 NAND2_X1
* cell instance $13902 r0 *1 31.92,166.6
X$13902 6670 9070 9265 8968 6540 27 15 9225 OAI221_X1
* cell instance $13904 r0 *1 33.44,166.6
X$13904 9153 8403 15 27 9265 NAND2_X1
* cell instance $13908 r0 *1 38,166.6
X$13908 6670 8975 9268 8874 6540 27 15 9350 OAI221_X1
* cell instance $13911 r0 *1 40.85,166.6
X$13911 8402 8872 15 27 9268 NAND2_X1
* cell instance $13914 r0 *1 43.13,166.6
X$13914 15 10554 8504 9160 9226 27 DFF_X1
* cell instance $13915 m0 *1 43.89,166.6
X$13915 5849 8736 9102 8968 6397 27 15 9160 OAI221_X1
* cell instance $13919 m0 *1 46.36,166.6
X$13919 6682 8736 9218 8968 6649 27 15 9437 OAI221_X1
* cell instance $13921 m0 *1 47.5,166.6
X$13921 9153 8313 15 27 9218 NAND2_X1
* cell instance $13922 m0 *1 48.07,166.6
X$13922 8871 6397 8877 5849 9104 9271 15 27 OAI221_X2
* cell instance $13926 m0 *1 52.63,166.6
X$13926 6682 8814 9105 8874 6649 27 15 9173 OAI221_X1
* cell instance $13927 m0 *1 53.77,166.6
X$13927 8871 6649 8877 6682 9106 9227 15 27 OAI221_X2
* cell instance $13928 m0 *1 55.86,166.6
X$13928 9103 9107 15 9174 27 NAND2_X4
* cell instance $13929 m0 *1 57.57,166.6
X$13929 6542 8975 9108 8874 6583 27 15 9228 OAI221_X1
* cell instance $13933 m0 *1 62.7,166.6
X$13933 15 8971 8972 10715 7550 27 DFF_X2
* cell instance $13936 r0 *1 46.36,166.6
X$13936 6542 9070 9270 8968 6583 27 15 9355 OAI221_X1
* cell instance $13938 r0 *1 47.88,166.6
X$13938 9153 8009 15 27 9270 NAND2_X1
* cell instance $13939 r0 *1 48.45,166.6
X$13939 15 10485 8508 9271 9226 27 DFF_X1
* cell instance $13942 r0 *1 52.25,166.6
X$13942 15 10495 8316 9173 8789 27 DFF_X1
* cell instance $13943 r0 *1 55.48,166.6
X$13943 8871 6583 9006 6542 9174 9273 15 27 OAI221_X2
* cell instance $13945 r0 *1 57.95,166.6
X$13945 15 10594 9109 9228 9358 27 DFF_X1
* cell instance $13953 r0 *1 66.31,166.6
X$13953 5704 27 7309 15 BUF_X4
* cell instance $13955 m0 *1 67.45,166.6
X$13955 8814 15 27 8975 CLKBUF_X3
* cell instance $13958 m0 *1 68.78,166.6
X$13958 8736 15 27 9070 CLKBUF_X3
* cell instance $13959 m0 *1 71.25,166.6
X$13959 15 8207 8075 27 BUF_X16
* cell instance $13960 m0 *1 76,166.6
X$13960 5959 8746 9219 6214 9070 27 15 9168 OAI221_X1
* cell instance $13965 r0 *1 75.05,166.6
X$13965 15 10598 8020 9168 9277 27 DFF_X1
* cell instance $13966 m0 *1 77.71,166.6
X$13966 6214 8975 8974 5959 9278 9276 15 27 OAI221_X2
* cell instance $13968 m0 *1 79.8,166.6
X$13968 6214 9006 9092 5959 9392 9175 15 27 OAI221_X2
* cell instance $13969 m0 *1 81.89,166.6
X$13969 8583 9112 15 9281 27 NAND2_X4
* cell instance $13972 r0 *1 78.47,166.6
X$13972 6744 8975 8974 6181 9281 9279 15 27 OAI221_X2
* cell instance $13973 r0 *1 80.56,166.6
X$13973 6744 9006 9092 6181 9282 9364 15 27 OAI221_X2
* cell instance $13974 r0 *1 82.65,166.6
X$13974 6213 8975 8974 6212 9283 9562 15 27 OAI221_X2
* cell instance $13975 m0 *1 84.17,166.6
X$13975 6213 9006 9092 6212 9169 9229 15 27 OAI221_X2
* cell instance $13977 m0 *1 86.26,166.6
X$13977 8209 8887 15 9169 27 NAND2_X4
* cell instance $13980 r0 *1 84.93,166.6
X$13980 5921 9070 8746 6689 9113 9230 15 27 OAI221_X2
* cell instance $13982 r0 *1 87.21,166.6
X$13982 6213 9070 8746 6212 9167 9284 15 27 OAI221_X2
* cell instance $13984 m0 *1 88.35,166.6
X$13984 8652 8887 15 27 9231 NAND2_X2
* cell instance $13985 r0 *1 89.3,166.6
X$13985 6689 9092 9231 5921 9006 27 15 9366 OAI221_X1
* cell instance $13986 m0 *1 89.87,166.6
X$13986 15 10359 8211 9166 9220 27 DFF_X1
* cell instance $13991 r0 *1 91.01,166.6
X$13991 15 9285 9220 10739 8120 27 DFF_X2
* cell instance $13992 m0 *1 95.19,166.6
X$13992 15 10382 8301 9176 9177 27 DFF_X1
* cell instance $13993 m0 *1 93.48,166.6
X$13993 8120 8824 15 9114 27 NAND2_X4
* cell instance $13996 r0 *1 94.62,166.6
X$13996 15 10537 8562 9286 9232 27 DFF_X1
* cell instance $13998 m0 *1 99.75,166.6
X$13998 5354 15 27 8752 CLKBUF_X3
* cell instance $14000 m0 *1 100.7,166.6
X$14000 8649 8893 15 9163 27 NAND2_X4
* cell instance $14001 m0 *1 102.41,166.6
X$14001 6515 8890 8889 6604 9163 9164 15 27 OAI221_X2
* cell instance $14004 m0 *1 106.21,166.6
X$14004 15 10380 8477 9043 9177 27 DFF_X1
* cell instance $14008 m0 *1 114.19,166.6
X$14008 8824 8681 15 9089 27 NAND2_X4
* cell instance $14014 r0 *1 102.6,166.6
X$14014 8752 15 27 10834 CLKBUF_X3
* cell instance $14023 m0 *1 120.08,166.6
X$14023 15 10371 9178 9217 9234 27 DFF_X1
* cell instance $14029 r0 *1 121.79,166.6
X$14029 5704 15 27 9241 CLKBUF_X3
* cell instance $14033 r0 *1 125.21,166.6
X$14033 9241 9216 9025 15 9384 27 AOI21_X1
* cell instance $14035 r0 *1 126.35,166.6
X$14035 7773 9236 15 27 9280 NAND2_X1
* cell instance $14038 r0 *1 127.49,166.6
X$14038 9237 8896 15 27 9216 NAND2_X1
* cell instance $14040 m0 *1 129.96,166.6
X$14040 9241 9181 9215 15 9214 27 AOI21_X1
* cell instance $14042 m0 *1 130.72,166.6
X$14042 15 10373 9180 9214 9179 27 DFF_X1
* cell instance $14043 m0 *1 133.95,166.6
X$14043 9180 8896 15 27 9181 NAND2_X1
* cell instance $14044 m0 *1 134.52,166.6
X$14044 9119 8899 15 27 9157 NAND2_X1
* cell instance $14047 m0 *1 136.04,166.6
X$14047 15 10377 9183 9182 9179 27 DFF_X1
* cell instance $14048 m0 *1 139.27,166.6
X$14048 9183 8899 15 27 9211 NAND2_X1
* cell instance $14051 m0 *1 147.44,166.6
X$14051 9122 8985 9185 27 15 9186 HA_X1
* cell instance $14054 m0 *1 152.57,166.6
X$14054 9124 15 27 9208 INV_X1
* cell instance $14057 r0 *1 131.86,166.6
X$14057 7947 9236 15 27 9238 NAND2_X1
* cell instance $14060 r0 *1 133.57,166.6
X$14060 7462 9236 15 27 9239 NAND2_X1
* cell instance $14063 r0 *1 136.04,166.6
X$14063 8280 15 27 9179 CLKBUF_X3
* cell instance $14064 r0 *1 136.99,166.6
X$14064 9120 9275 8944 15 9240 27 AOI21_X1
* cell instance $14065 r0 *1 137.75,166.6
X$14065 9179 15 27 CLKBUF_X1
* cell instance $14066 r0 *1 138.32,166.6
X$14066 9274 8899 15 27 9275 NAND2_X1
* cell instance $14069 r0 *1 139.84,166.6
X$14069 9242 8896 15 27 9184 NAND2_X1
* cell instance $14070 r0 *1 140.41,166.6
X$14070 9241 9184 8758 15 9209 27 AOI21_X1
* cell instance $14071 r0 *1 141.17,166.6
X$14071 15 10529 9242 9209 9316 27 DFF_X1
* cell instance $14074 r0 *1 146.3,166.6
X$14074 8712 9185 10892 27 15 9272 HA_X1
* cell instance $14075 r0 *1 148.2,166.6
X$14075 9272 9186 10886 27 15 9508 HA_X1
* cell instance $14078 r0 *1 150.67,166.6
X$14078 15 9124 10819 9245 9187 9244 27 FA_X1
* cell instance $14080 m0 *1 153.33,166.6
X$14080 9187 15 27 9188 INV_X1
* cell instance $14083 m0 *1 159.03,166.6
X$14083 9189 15 27 9149 INV_X1
* cell instance $14086 r0 *1 153.71,166.6
X$14086 9208 9188 9267 27 15 9359 HA_X1
* cell instance $14087 r0 *1 155.61,166.6
X$14087 9319 9267 10879 27 15 9246 HA_X1
* cell instance $14089 m0 *1 160.93,166.6
X$14089 15 9206 9205 9143 9125 9150 27 FA_X1
* cell instance $14090 m0 *1 160.55,166.6
X$14090 9207 15 27 9266 INV_X1
* cell instance $14091 m0 *1 163.97,166.6
X$14091 9049 9149 9742 27 15 9204 HA_X1
* cell instance $14096 r0 *1 161.88,166.6
X$14096 7708 15 27 7319 INV_X4
* cell instance $14099 r0 *1 165.11,166.6
X$14099 15 9204 9261 9264 9266 9247 27 FA_X1
* cell instance $14101 m0 *1 166.25,166.6
X$14101 9146 15 27 9247 INV_X1
* cell instance $14102 m0 *1 168.15,166.6
X$14102 7686 7319 10866 27 15 9190 HA_X1
* cell instance $14105 m0 *1 172.33,166.6
X$14105 7489 9200 9262 27 15 9135 HA_X1
* cell instance $14107 m0 *1 174.42,166.6
X$14107 9139 9140 9348 27 15 9199 HA_X1
* cell instance $14109 m0 *1 177.08,166.6
X$14109 9199 15 27 9128 INV_X1
* cell instance $14111 r0 *1 168.15,166.6
X$14111 9048 15 27 9195 INV_X1
* cell instance $14114 r0 *1 169.1,166.6
X$14114 9190 9200 9356 27 15 9248 HA_X1
* cell instance $14119 r0 *1 171.38,166.6
X$14119 9143 15 27 9259 INV_X1
* cell instance $14121 r0 *1 171.95,166.6
X$14121 8832 9262 9325 27 15 9257 HA_X1
* cell instance $14122 r0 *1 173.85,166.6
X$14122 8539 9259 9327 27 15 9196 HA_X1
* cell instance $14124 r0 *1 176.13,166.6
X$14124 15 9257 9254 9256 9258 9129 27 FA_X1
* cell instance $14126 m0 *1 177.84,166.6
X$14126 9198 9128 9258 27 15 9192 HA_X1
* cell instance $14129 r0 *1 179.17,166.6
X$14129 8906 15 27 9347 INV_X1
* cell instance $14131 r0 *1 179.74,166.6
X$14131 9192 15 27 9253 INV_X1
* cell instance $14132 r0 *1 180.12,166.6
X$14132 15 9001 9255 9251 9196 9253 27 FA_X1
* cell instance $14134 r0 *1 183.35,166.6
X$14134 9251 15 27 9335 INV_X1
* cell instance $14143 m0 *1 4.56,71.4
X$14143 3110 3791 15 27 4010 NAND2_X2
* cell instance $14144 m0 *1 5.51,71.4
X$14144 3904 3673 3573 27 15 3872 OAI21_X2
* cell instance $14145 m0 *1 6.84,71.4
X$14145 3573 3673 15 3907 27 OR2_X4
* cell instance $14148 m0 *1 10.26,71.4
X$14148 3792 3461 3264 27 15 4094 OAI21_X4
* cell instance $14156 r0 *1 4.75,71.4
X$14156 4090 3086 3147 15 4150 27 AOI21_X2
* cell instance $14157 r0 *1 6.08,71.4
X$14157 3573 3673 4158 15 27 NOR2_X4
* cell instance $14158 r0 *1 7.79,71.4
X$14158 15 4011 3981 4065 3907 3049 27 AOI22_X4
* cell instance $14161 m0 *1 13.3,71.4
X$14161 3726 3839 3835 3127 3676 3874 27 15 AOI221_X2
* cell instance $14163 m0 *1 15.39,71.4
X$14163 3840 3675 3265 3792 4067 27 15 AOI211_X2
* cell instance $14166 r0 *1 13.68,71.4
X$14166 3839 3726 3462 3676 3127 3877 27 15 AOI221_X2
* cell instance $14168 m0 *1 18.05,71.4
X$14168 3844 2927 15 27 3842 NOR2_X1
* cell instance $14169 m0 *1 17.48,71.4
X$14169 3844 3347 15 27 3908 NOR2_X1
* cell instance $14171 r0 *1 18.81,71.4
X$14171 4094 3633 3766 15 27 3984 NAND3_X1
* cell instance $14172 m0 *1 19.19,71.4
X$14172 3577 3766 15 27 3875 OR2_X1
* cell instance $14174 m0 *1 19.95,71.4
X$14174 3678 3730 3875 15 3876 27 AOI21_X1
* cell instance $14175 m0 *1 20.71,71.4
X$14175 3678 3347 15 27 3909 NAND2_X1
* cell instance $14176 m0 *1 21.28,71.4
X$14176 3577 15 27 3985 INV_X1
* cell instance $14178 m0 *1 21.85,71.4
X$14178 3911 3577 3987 27 15 3930 OAI21_X2
* cell instance $14180 m0 *1 23.37,71.4
X$14180 3676 3728 15 27 3796 OR2_X1
* cell instance $14182 m0 *1 24.32,71.4
X$14182 3876 3877 15 27 3797 NAND2_X1
* cell instance $14183 m0 *1 24.89,71.4
X$14183 3676 3728 27 15 3878 AND2_X1
* cell instance $14185 m0 *1 26.41,71.4
X$14185 3728 3676 15 27 3879 NOR2_X1
* cell instance $14187 m0 *1 27.17,71.4
X$14187 3847 27 3884 15 BUF_X4
* cell instance $14188 m0 *1 28.5,71.4
X$14188 3881 3239 3880 1499 3883 4098 27 15 AOI221_X2
* cell instance $14189 m0 *1 30.59,71.4
X$14189 3681 15 27 3881 INV_X2
* cell instance $14190 m0 *1 31.16,71.4
X$14190 3850 3881 3054 27 15 3886 MUX2_X2
* cell instance $14191 m0 *1 32.87,71.4
X$14191 3882 3852 15 27 3914 NAND2_X1
* cell instance $14192 m0 *1 33.44,71.4
X$14192 3852 3730 15 27 3883 NAND2_X1
* cell instance $14193 m0 *1 34.01,71.4
X$14193 3127 3884 27 15 3885 XNOR2_X1
* cell instance $14195 r0 *1 19.57,71.4
X$14195 3766 3633 4094 27 15 3987 AND3_X1
* cell instance $14197 r0 *1 20.9,71.4
X$14197 3984 3985 3463 3909 3795 4096 27 15 AOI221_X2
* cell instance $14201 r0 *1 24.32,71.4
X$14201 3931 3877 3988 3876 27 15 3932 AND4_X1
* cell instance $14202 r0 *1 25.46,71.4
X$14202 3932 3878 3879 3239 3882 27 15 AOI211_X2
* cell instance $14203 r0 *1 27.17,71.4
X$14203 15 3934 3880 3054 3881 27 AOI21_X4
* cell instance $14204 r0 *1 29.64,71.4
X$14204 3492 3933 15 27 3990 NAND2_X1
* cell instance $14206 r0 *1 30.4,71.4
X$14206 3883 3643 15 27 3933 NAND2_X1
* cell instance $14207 r0 *1 30.97,71.4
X$14207 3888 3730 15 27 4071 NAND2_X1
* cell instance $14208 r0 *1 31.54,71.4
X$14208 3852 3347 15 4069 27 NAND2_X4
* cell instance $14209 r0 *1 33.25,71.4
X$14209 3883 3884 3852 3934 27 15 4014 OAI22_X1
* cell instance $14210 r0 *1 34.2,71.4
X$14210 3730 3852 3885 15 27 4073 OR3_X1
* cell instance $14211 r0 *1 35.15,71.4
X$14211 3885 3992 3934 3914 3496 4015 15 27 OAI221_X2
* cell instance $14212 m0 *1 35.72,71.4
X$14212 3884 3886 15 27 3887 NAND2_X1
* cell instance $14215 m0 *1 37.81,71.4
X$14215 3347 3888 27 15 4016 XNOR2_X1
* cell instance $14217 r0 *1 37.24,71.4
X$14217 3934 3888 15 27 3992 NAND2_X1
* cell instance $14220 r0 *1 38.76,71.4
X$14220 3886 4016 27 15 4078 XNOR2_X1
* cell instance $14221 m0 *1 39.52,71.4
X$14221 3496 3579 27 15 3915 XNOR2_X1
* cell instance $14224 m0 *1 41.42,71.4
X$14224 3915 3686 15 27 3799 NOR2_X1
* cell instance $14225 m0 *1 41.99,71.4
X$14225 3799 3731 3685 27 15 3916 MUX2_X2
* cell instance $14229 r0 *1 39.9,71.4
X$14229 4016 3685 15 27 4017 NAND2_X1
* cell instance $14232 r0 *1 41.04,71.4
X$14232 3915 3686 3643 3935 27 15 3798 OAI22_X1
* cell instance $14233 r0 *1 41.99,71.4
X$14233 3579 3730 15 27 4018 NAND2_X1
* cell instance $14237 r0 *1 45.22,71.4
X$14237 3579 15 27 3935 INV_X1
* cell instance $14239 r0 *1 45.98,71.4
X$14239 3273 3416 15 27 4019 NOR2_X1
* cell instance $14240 m0 *1 46.55,71.4
X$14240 3735 3579 15 27 3936 NAND2_X1
* cell instance $14243 m0 *1 48.64,71.4
X$14243 3273 3496 15 27 3735 NOR2_X2
* cell instance $14244 m0 *1 49.59,71.4
X$14244 3360 3918 3889 15 27 3920 NAND3_X1
* cell instance $14245 m0 *1 50.35,71.4
X$14245 3919 3585 3918 3889 15 27 3922 NAND4_X1
* cell instance $14246 m0 *1 51.3,71.4
X$14246 3920 3274 3415 27 15 3721 OAI21_X4
* cell instance $14247 m0 *1 53.77,71.4
X$14247 3638 3188 3921 3274 3922 3858 15 27 OAI221_X2
* cell instance $14248 m0 *1 55.86,71.4
X$14248 3858 3586 3127 3739 3890 27 15 AOI211_X2
* cell instance $14249 m0 *1 57.57,71.4
X$14249 3690 3802 27 15 3998 XNOR2_X1
* cell instance $14252 r0 *1 46.55,71.4
X$14252 3583 4020 3936 15 4107 27 AOI21_X1
* cell instance $14253 r0 *1 47.31,71.4
X$14253 3735 4101 15 27 4178 NAND2_X1
* cell instance $14255 r0 *1 49.4,71.4
X$14255 3801 27 4222 15 BUF_X4
* cell instance $14256 r0 *1 50.73,71.4
X$14256 3918 3690 3889 3585 15 4021 27 NAND4_X2
* cell instance $14257 r0 *1 52.44,71.4
X$14257 3415 3643 15 27 4022 NOR2_X2
* cell instance $14260 r0 *1 55.1,71.4
X$14260 4021 3938 3937 4022 2935 3740 27 15 AOI221_X2
* cell instance $14263 r0 *1 58.14,71.4
X$14263 3737 3998 3939 2293 27 15 4085 OAI22_X2
* cell instance $14268 m0 *1 61.18,71.4
X$14268 3638 3188 15 27 3805 NOR2_X1
* cell instance $14269 m0 *1 59.85,71.4
X$14269 3803 3638 3859 27 15 3924 OAI21_X2
* cell instance $14272 r0 *1 60.8,71.4
X$14272 3804 3721 15 27 3940 NOR2_X2
* cell instance $14274 m0 *1 63.08,71.4
X$14274 3890 3860 15 27 4002 OR2_X2
* cell instance $14275 m0 *1 62.13,71.4
X$14275 3860 3890 15 27 3806 NOR2_X2
* cell instance $14276 m0 *1 64.03,71.4
X$14276 3741 3806 3941 3891 3744 27 15 AOI211_X2
* cell instance $14277 m0 *1 65.74,71.4
X$14277 15 3808 3806 3891 3941 27 AOI21_X4
* cell instance $14280 r0 *1 62.51,71.4
X$14280 3589 3588 3738 27 4024 15 OAI21_X1
* cell instance $14283 r0 *1 63.84,71.4
X$14283 3498 3740 3940 15 27 3941 OR3_X2
* cell instance $14284 r0 *1 64.98,71.4
X$14284 4284 4025 3806 3891 3941 4086 27 15 AOI221_X2
* cell instance $14287 r0 *1 68.02,71.4
X$14287 3560 3504 27 15 4028 XNOR2_X1
* cell instance $14289 r0 *1 69.54,71.4
X$14289 3864 2940 3943 3942 4084 15 27 OAI211_X2
* cell instance $14290 m0 *1 70.3,71.4
X$14290 3744 3694 15 2800 27 NAND2_X4
* cell instance $14292 m0 *1 72.01,71.4
X$14292 3504 15 27 3944 INV_X1
* cell instance $14293 m0 *1 72.39,71.4
X$14293 3369 3928 3865 15 4186 27 AOI21_X2
* cell instance $14294 m0 *1 73.72,71.4
X$14294 3928 3865 15 27 3811 NAND2_X2
* cell instance $14296 m0 *1 74.86,71.4
X$14296 3746 3810 27 4115 15 AND2_X4
* cell instance $14298 m0 *1 78.09,71.4
X$14298 3811 3927 15 27 3947 XNOR2_X2
* cell instance $14300 m0 *1 80.18,71.4
X$14300 3813 3788 3572 27 3814 15 NOR3_X2
* cell instance $14301 m0 *1 81.51,71.4
X$14301 3815 3868 15 27 4005 NAND2_X1
* cell instance $14302 m0 *1 82.08,71.4
X$14302 4081 3870 3947 3811 3281 3813 15 27 4372 OAI33_X1
* cell instance $14304 m0 *1 83.6,71.4
X$14304 15 2438 27 3194 BUF_X8
* cell instance $14305 m0 *1 86.07,71.4
X$14305 15 3595 3926 3925 3485 3949 27 NOR4_X4
* cell instance $14308 m0 *1 91.77,71.4
X$14308 3284 3892 4004 3893 15 27 3894 NAND4_X1
* cell instance $14309 m0 *1 92.72,71.4
X$14309 3894 4003 244 27 3923 15 OAI21_X1
* cell instance $14312 m0 *1 94.43,71.4
X$14312 15 3342 27 3951 BUF_X8
* cell instance $14315 m0 *1 97.85,71.4
X$14315 3433 3866 3820 3951 3818 4001 27 15 AOI221_X2
* cell instance $14316 m0 *1 99.94,71.4
X$14316 3202 3342 4076 3895 3821 15 27 OAI211_X2
* cell instance $14317 m0 *1 101.65,71.4
X$14317 4000 3374 15 27 3896 NOR2_X2
* cell instance $14321 r0 *1 71.44,71.4
X$14321 3944 3745 3809 27 15 4031 OAI21_X4
* cell instance $14323 r0 *1 74.1,71.4
X$14323 4031 3560 27 3945 15 XOR2_X2
* cell instance $14325 r0 *1 76,71.4
X$14325 15 3812 4030 3946 3945 4082 27 NAND4_X4
* cell instance $14327 r0 *1 79.61,71.4
X$14327 3812 3945 3946 15 27 4033 NAND3_X1
* cell instance $14329 r0 *1 80.56,71.4
X$14329 3814 3947 3948 27 4118 15 NOR3_X2
* cell instance $14331 r0 *1 82.65,71.4
X$14331 3813 3811 15 27 4035 NOR2_X2
* cell instance $14332 r0 *1 83.6,71.4
X$14332 3947 15 27 4079 INV_X1
* cell instance $14336 r0 *1 88.16,71.4
X$14336 3816 4006 27 4197 15 AND2_X4
* cell instance $14338 r0 *1 90.06,71.4
X$14338 3949 4036 15 27 4003 NAND2_X1
* cell instance $14339 r0 *1 90.63,71.4
X$14339 3949 3892 4036 15 27 3951 AND3_X4
* cell instance $14340 r0 *1 92.72,71.4
X$14340 4204 3950 15 27 4037 NOR2_X2
* cell instance $14342 r0 *1 93.86,71.4
X$14342 3871 4077 3818 15 27 NOR2_X4
* cell instance $14343 r0 *1 95.57,71.4
X$14343 15 3202 27 3818 BUF_X8
* cell instance $14344 r0 *1 98.04,71.4
X$14344 3951 27 3435 15 BUF_X4
* cell instance $14345 r0 *1 99.37,71.4
X$14345 244 3866 4000 15 27 NOR2_X4
* cell instance $14346 r0 *1 101.08,71.4
X$14346 15 3820 3896 4075 3999 3253 27 OAI22_X4
* cell instance $14348 m0 *1 103.74,71.4
X$14348 3999 3821 3917 3666 27 15 3863 AND4_X1
* cell instance $14350 r0 *1 104.31,71.4
X$14350 3999 3821 15 4039 27 NAND2_X4
* cell instance $14352 m0 *1 108.49,71.4
X$14352 3750 3822 3038 27 15 3603 AND3_X1
* cell instance $14353 m0 *1 106.78,71.4
X$14353 3822 3750 15 2132 27 NAND2_X4
* cell instance $14354 m0 *1 109.44,71.4
X$14354 3823 3038 3703 15 27 3954 MUX2_X1
* cell instance $14355 m0 *1 110.77,71.4
X$14355 3823 3286 3703 15 27 3953 MUX2_X1
* cell instance $14356 m0 *1 112.1,71.4
X$14356 3775 3751 3823 15 27 4070 NAND3_X1
* cell instance $14362 r0 *1 107.92,71.4
X$14362 4039 3917 15 27 4040 OR2_X1
* cell instance $14366 r0 *1 110.01,71.4
X$14366 4074 3522 15 27 3955 NOR2_X1
* cell instance $14367 r0 *1 110.58,71.4
X$14367 3777 3778 3952 27 4074 15 OAI21_X1
* cell instance $14368 r0 *1 111.34,71.4
X$14368 3953 15 27 3952 INV_X1
* cell instance $14369 r0 *1 111.72,71.4
X$14369 3953 3954 2811 27 15 4041 MUX2_X2
* cell instance $14371 r0 *1 113.62,71.4
X$14371 3955 3956 15 27 3997 NOR2_X1
* cell instance $14372 r0 *1 114.19,71.4
X$14372 3956 3955 15 27 4201 OR2_X2
* cell instance $14376 r0 *1 115.14,71.4
X$14376 4041 3672 27 15 3957 AND2_X1
* cell instance $14380 r0 *1 117.23,71.4
X$14380 3957 15 27 3996 INV_X1
* cell instance $14381 r0 *1 117.61,71.4
X$14381 3996 3997 3856 27 15 3446 OAI21_X2
* cell instance $14383 m0 *1 118.56,71.4
X$14383 15 3752 3475 3708 4068 3995 27 OAI22_X4
* cell instance $14386 m0 *1 127.11,71.4
X$14386 3212 3656 3213 3855 15 3828 27 NAND4_X2
* cell instance $14387 m0 *1 128.82,71.4
X$14387 3855 3656 3213 15 27 3913 NAND3_X1
* cell instance $14389 m0 *1 129.77,71.4
X$14389 3754 3212 15 27 3897 NAND2_X1
* cell instance $14390 m0 *1 130.34,71.4
X$14390 3913 3325 3897 3756 3961 3912 27 15 AOI221_X2
* cell instance $14391 m0 *1 132.43,71.4
X$14391 3828 3898 3756 3961 3851 27 15 AOI211_X2
* cell instance $14392 m0 *1 134.14,71.4
X$14392 3960 3826 4046 15 27 3297 NAND3_X2
* cell instance $14393 m0 *1 135.47,71.4
X$14393 4048 4047 3910 2744 2052 3323 27 15 AOI221_X2
* cell instance $14394 m0 *1 137.56,71.4
X$14394 3449 3622 15 27 3899 NAND2_X1
* cell instance $14395 m0 *1 138.13,71.4
X$14395 2744 2052 15 27 3989 NAND2_X1
* cell instance $14397 m0 *1 138.89,71.4
X$14397 3963 3964 3965 27 3535 15 OAI21_X1
* cell instance $14398 m0 *1 139.65,71.4
X$14398 3622 3449 27 15 3986 AND2_X1
* cell instance $14400 m0 *1 141.93,71.4
X$14400 3829 3080 15 27 3830 OR2_X2
* cell instance $14402 m0 *1 144.4,71.4
X$14402 15 3968 3539 3900 3967 3018 27 NAND4_X4
* cell instance $14403 m0 *1 147.82,71.4
X$14403 3009 3304 15 27 3901 NAND2_X1
* cell instance $14404 m0 *1 148.39,71.4
X$14404 3901 3902 15 27 3763 NOR2_X1
* cell instance $14406 m0 *1 149.15,71.4
X$14406 3968 3967 15 27 3308 NAND2_X2
* cell instance $14408 m0 *1 150.29,71.4
X$14408 3901 3902 3381 27 3837 15 NOR3_X2
* cell instance $14415 r0 *1 121.98,71.4
X$14415 15 3134 27 3995 BUF_X8
* cell instance $14416 r0 *1 124.45,71.4
X$14416 3994 3706 15 27 4130 NAND2_X2
* cell instance $14419 r0 *1 125.97,71.4
X$14419 3958 4045 3212 15 27 3993 NOR3_X1
* cell instance $14421 r0 *1 128.25,71.4
X$14421 3898 3325 3993 15 27 3991 MUX2_X1
* cell instance $14423 r0 *1 130.34,71.4
X$14423 3752 3475 3708 3995 27 15 4046 OAI22_X2
* cell instance $14424 r0 *1 132.05,71.4
X$14424 3754 15 27 3898 INV_X1
* cell instance $14426 r0 *1 132.62,71.4
X$14426 3960 3826 4068 15 27 3961 AND3_X4
* cell instance $14427 r0 *1 134.71,71.4
X$14427 3756 3961 15 3000 27 NAND2_X4
* cell instance $14429 r0 *1 136.8,71.4
X$14429 3962 3710 3899 15 27 3910 MUX2_X1
* cell instance $14430 r0 *1 138.13,71.4
X$14430 3989 3965 3963 3964 3465 15 27 OAI211_X2
* cell instance $14432 r0 *1 140.03,71.4
X$14432 4050 3710 3986 15 27 3965 MUX2_X1
* cell instance $14435 r0 *1 143.07,71.4
X$14435 3830 3966 3983 15 3758 27 AOI21_X2
* cell instance $14437 r0 *1 144.59,71.4
X$14437 3900 3967 3968 3539 27 15 3983 AND4_X1
* cell instance $14440 r0 *1 148.01,71.4
X$14440 3968 3967 3539 15 3456 27 NAND3_X4
* cell instance $14441 r0 *1 150.48,71.4
X$14441 4051 3969 27 3143 15 XOR2_X2
* cell instance $14443 m0 *1 152,71.4
X$14443 3902 3901 15 27 3538 OR2_X2
* cell instance $14447 m0 *1 166.82,71.4
X$14447 3905 3971 3977 27 15 3834 HA_X1
* cell instance $14448 m0 *1 168.72,71.4
X$14448 3834 3977 3903 15 3976 27 AOI21_X1
* cell instance $14457 r0 *1 161.88,71.4
X$14457 3982 4170 3970 27 15 3980 HA_X1
* cell instance $14459 r0 *1 165.3,71.4
X$14459 3980 15 27 3979 INV_X1
* cell instance $14462 r0 *1 166.82,71.4
X$14462 3970 15 27 3978 INV_X1
* cell instance $14463 r0 *1 167.2,71.4
X$14463 3978 3976 3979 27 4057 15 OAI21_X1
* cell instance $14464 r0 *1 167.96,71.4
X$14464 15 4140 3971 3975 4255 4063 27 FA_X1
* cell instance $14469 r0 *1 171.38,71.4
X$14469 3972 15 27 3973 INV_X1
* cell instance $14470 r0 *1 171.76,71.4
X$14470 3975 4059 3972 27 15 3974 HA_X1
* cell instance $14471 r0 *1 173.66,71.4
X$14471 4061 3973 4060 27 3903 15 OAI21_X1
* cell instance $14472 r0 *1 174.42,71.4
X$14472 3974 15 27 4060 INV_X1
* cell instance $14483 r0 *1 2.85,26.6
X$14483 697 1419 15 27 1418 XNOR2_X2
* cell instance $14489 m0 *1 6.27,26.6
X$14489 1353 793 1310 27 1419 15 NOR3_X2
* cell instance $14490 m0 *1 7.79,26.6
X$14490 1311 1379 15 27 1134 NAND2_X2
* cell instance $14491 m0 *1 8.74,26.6
X$14491 355 1379 1311 15 1107 27 NAND3_X4
* cell instance $14495 r0 *1 6.46,26.6
X$14495 1377 578 700 1378 27 15 1446 AND4_X1
* cell instance $14496 r0 *1 7.6,26.6
X$14496 357 1311 1379 15 1378 27 AOI21_X1
* cell instance $14499 m0 *1 12.54,26.6
X$14499 859 27 1380 15 BUF_X4
* cell instance $14503 r0 *1 13.11,26.6
X$14503 1423 1312 1380 27 15 1819 MUX2_X2
* cell instance $14504 m0 *1 14.63,26.6
X$14504 226 27 1499 15 BUF_X4
* cell instance $14505 m0 *1 14.25,26.6
X$14505 1220 15 27 1423 INV_X1
* cell instance $14507 m0 *1 16.15,26.6
X$14507 1221 15 27 1313 INV_X1
* cell instance $14509 m0 *1 17.29,26.6
X$14509 1316 1315 15 27 1502 XOR2_X1
* cell instance $14511 m0 *1 18.62,26.6
X$14511 15 1222 1314 1316 1315 27 AOI21_X4
* cell instance $14512 m0 *1 21.09,26.6
X$14512 1271 1317 27 15 1427 AND2_X1
* cell instance $14513 m0 *1 21.85,26.6
X$14513 1318 15 27 1354 INV_X1
* cell instance $14518 r0 *1 17.29,26.6
X$14518 1426 1380 1502 15 27 1501 MUX2_X1
* cell instance $14520 r0 *1 19,26.6
X$14520 1552 1380 1427 15 27 1612 MUX2_X1
* cell instance $14521 r0 *1 20.33,26.6
X$14521 138 1552 1223 27 15 1318 HA_X1
* cell instance $14522 r0 *1 22.23,26.6
X$14522 1382 1380 1381 15 27 1503 MUX2_X1
* cell instance $14524 m0 *1 22.61,26.6
X$14524 212 1382 1224 27 15 1225 HA_X1
* cell instance $14528 r0 *1 24.51,26.6
X$14528 1384 1380 1383 15 27 1504 MUX2_X1
* cell instance $14529 m0 *1 25.84,26.6
X$14529 1428 15 27 1319 INV_X1
* cell instance $14531 m0 *1 26.22,26.6
X$14531 111 1384 1138 27 15 1428 HA_X1
* cell instance $14534 m0 *1 31.35,26.6
X$14534 1386 1388 1387 15 27 1321 OR3_X1
* cell instance $14535 m0 *1 32.3,26.6
X$14535 1431 1321 27 15 1430 AND2_X1
* cell instance $14538 m0 *1 36.86,26.6
X$14538 1323 15 27 1279 INV_X1
* cell instance $14545 r0 *1 28.5,26.6
X$14545 1385 1388 1062 15 1384 27 AOI21_X2
* cell instance $14546 r0 *1 29.83,26.6
X$14546 1448 1062 1430 15 27 1382 MUX2_X1
* cell instance $14547 r0 *1 31.16,26.6
X$14547 1386 1387 1388 27 15 1431 OAI21_X2
* cell instance $14550 r0 *1 33.06,26.6
X$14550 706 1389 1386 1140 15 27 1507 NAND4_X1
* cell instance $14551 r0 *1 34.01,26.6
X$14551 1451 1228 1388 15 27 1598 NAND3_X1
* cell instance $14552 r0 *1 34.77,26.6
X$14552 1506 1062 1599 15 27 1426 MUX2_X1
* cell instance $14553 r0 *1 36.1,26.6
X$14553 138 1506 1389 27 15 1323 HA_X1
* cell instance $14556 r0 *1 41.42,26.6
X$14556 1116 946 15 1144 27 NAND2_X4
* cell instance $14558 m0 *1 42.18,26.6
X$14558 1434 946 15 27 1324 NOR2_X1
* cell instance $14559 m0 *1 42.94,26.6
X$14559 1391 1390 27 15 1434 XNOR2_X1
* cell instance $14560 m0 *1 44.08,26.6
X$14560 388 1602 1231 27 15 1234 HA_X1
* cell instance $14561 m0 *1 45.98,26.6
X$14561 1390 1204 15 27 1437 NAND2_X1
* cell instance $14564 r0 *1 43.13,26.6
X$14564 1454 1511 1065 27 15 1061 MUX2_X2
* cell instance $14565 r0 *1 44.84,26.6
X$14565 1204 1514 27 15 1511 XNOR2_X1
* cell instance $14567 r0 *1 46.36,26.6
X$14567 1513 15 27 1204 CLKBUF_X2
* cell instance $14568 r0 *1 47.12,26.6
X$14568 1325 805 1283 15 27 1514 MUX2_X1
* cell instance $14569 m0 *1 48.45,26.6
X$14569 15 1126 1365 804 1437 1361 27 AOI22_X4
* cell instance $14570 m0 *1 47.69,26.6
X$14570 1325 1282 1235 27 1358 15 OAI21_X1
* cell instance $14571 m0 *1 51.68,26.6
X$14571 1326 15 27 1361 INV_X1
* cell instance $14573 m0 *1 52.82,26.6
X$14573 1126 1208 15 1328 27 NAND2_X4
* cell instance $14575 m0 *1 54.72,26.6
X$14575 1327 1326 15 27 1362 NOR2_X2
* cell instance $14577 r0 *1 48.45,26.6
X$14577 195 1454 1513 27 15 1326 HA_X1
* cell instance $14578 r0 *1 50.35,26.6
X$14578 1126 1208 1686 15 27 1773 NAND3_X2
* cell instance $14579 r0 *1 51.68,26.6
X$14579 881 1517 1328 27 15 899 MUX2_X2
* cell instance $14583 r0 *1 55.48,26.6
X$14583 1455 1067 27 15 1327 XNOR2_X1
* cell instance $14584 m0 *1 56.24,26.6
X$14584 327 1457 1328 27 15 1064 MUX2_X2
* cell instance $14586 m0 *1 57.95,26.6
X$14586 1391 416 15 27 1329 OR2_X1
* cell instance $14587 m0 *1 58.71,26.6
X$14587 416 1391 15 27 1367 NAND2_X1
* cell instance $14593 r0 *1 57.19,26.6
X$14593 328 1328 1523 15 27 1454 MUX2_X1
* cell instance $14598 m0 *1 63.65,26.6
X$14598 1562 722 15 27 70 NOR2_X1
* cell instance $14600 m0 *1 64.22,26.6
X$14600 1392 27 357 15 BUF_X4
* cell instance $14601 m0 *1 65.55,26.6
X$14601 960 15 27 1392 INV_X1
* cell instance $14604 m0 *1 66.88,26.6
X$14604 1458 1392 1461 15 27 693 NAND3_X2
* cell instance $14611 r0 *1 66.69,26.6
X$14611 960 597 15 1459 27 OR2_X4
* cell instance $14612 r0 *1 68.4,26.6
X$14612 1444 553 15 1154 27 NAND2_X4
* cell instance $14615 m0 *1 75.05,26.6
X$14615 15 1374 1375 1443 1295 27 AOI21_X4
* cell instance $14616 m0 *1 73.15,26.6
X$14616 212 1153 1238 27 15 1373 HA_X1
* cell instance $14617 m0 *1 77.52,26.6
X$14617 1393 15 27 1443 INV_X1
* cell instance $14618 m0 *1 77.9,26.6
X$14618 43 1371 1071 27 15 1241 HA_X1
* cell instance $14619 m0 *1 79.8,26.6
X$14619 1371 15 27 LOGIC0_X1
* cell instance $14623 r0 *1 74.1,26.6
X$14623 1376 1526 1605 15 1445 27 AOI21_X2
* cell instance $14625 r0 *1 75.62,26.6
X$14625 111 1239 1372 27 15 1393 HA_X1
* cell instance $14627 r0 *1 77.71,26.6
X$14627 1238 1393 15 27 1240 NOR2_X1
* cell instance $14629 r0 *1 78.47,26.6
X$14629 1372 1071 1241 15 27 1442 OR3_X1
* cell instance $14634 m0 *1 1.52,158.2
X$14634 15 10367 8804 8838 8567 27 DFF_X1
* cell instance $14636 m0 *1 4.94,158.2
X$14636 8804 8805 15 27 8840 NAND2_X1
* cell instance $14637 m0 *1 5.51,158.2
X$14637 7525 15 27 8567 CLKBUF_X3
* cell instance $14638 m0 *1 6.46,158.2
X$14638 6880 8913 8771 15 8841 27 AOI21_X1
* cell instance $14639 m0 *1 7.22,158.2
X$14639 6880 8840 8806 15 8838 27 AOI21_X1
* cell instance $14641 m0 *1 8.17,158.2
X$14641 6880 8842 8807 15 8843 27 AOI21_X1
* cell instance $14642 m0 *1 8.93,158.2
X$14642 8808 8805 15 27 8842 NAND2_X1
* cell instance $14646 m0 *1 13.49,158.2
X$14646 8401 8732 15 27 8806 NAND2_X1
* cell instance $14650 r0 *1 1.71,158.2
X$14650 8804 15 27 8731 BUF_X1
* cell instance $14656 r0 *1 3.99,158.2
X$14656 15 10496 8837 8841 8567 27 DFF_X1
* cell instance $14657 r0 *1 7.22,158.2
X$14657 15 10592 8808 8843 8916 27 DFF_X1
* cell instance $14660 m0 *1 14.63,158.2
X$14660 8105 8732 15 27 8807 NAND2_X1
* cell instance $14665 m0 *1 20.52,158.2
X$14665 7525 15 27 8501 CLKBUF_X3
* cell instance $14666 m0 *1 21.47,158.2
X$14666 8501 15 27 CLKBUF_X1
* cell instance $14671 m0 *1 32.87,158.2
X$14671 15 10383 8373 8780 8809 27 DFF_X1
* cell instance $14676 r0 *1 15.96,158.2
X$14676 15 10631 8572 9060 8501 27 DFF_X1
* cell instance $14681 r0 *1 28.88,158.2
X$14681 15 10580 8665 8926 8873 27 DFF_X1
* cell instance $14682 r0 *1 32.11,158.2
X$14682 5791 8814 8875 8874 5793 27 15 8926 OAI221_X1
* cell instance $14685 r0 *1 34.96,158.2
X$14685 8666 8879 15 27 8876 NAND2_X1
* cell instance $14688 r0 *1 36.48,158.2
X$14688 15 10572 8635 8878 8809 27 DFF_X1
* cell instance $14690 m0 *1 37.24,158.2
X$14690 15 10370 8308 8735 8809 27 DFF_X1
* cell instance $14694 r0 *1 39.9,158.2
X$14694 8810 5859 8877 5860 8930 8931 15 27 OAI221_X2
* cell instance $14696 m0 *1 45.98,158.2
X$14696 7285 8669 8737 15 27 8715 MUX2_X1
* cell instance $14697 m0 *1 44.65,158.2
X$14697 8716 5859 8738 27 15 8786 OAI21_X2
* cell instance $14698 m0 *1 47.31,158.2
X$14698 8852 6397 8738 27 15 8737 OAI21_X2
* cell instance $14699 m0 *1 48.64,158.2
X$14699 8505 6969 8739 15 8852 27 NAND3_X4
* cell instance $14703 m0 *1 51.49,158.2
X$14703 8641 27 8935 15 BUF_X4
* cell instance $14707 m0 *1 56.43,158.2
X$14707 7259 27 8641 15 BUF_X4
* cell instance $14709 m0 *1 57.76,158.2
X$14709 8856 6398 8738 27 15 8811 OAI21_X2
* cell instance $14711 m0 *1 59.85,158.2
X$14711 7259 27 8939 15 BUF_X4
* cell instance $14714 m0 *1 62.89,158.2
X$14714 8739 7550 1298 15 27 8812 NAND3_X1
* cell instance $14716 r0 *1 56.43,158.2
X$14716 8203 8879 5869 8742 15 27 8936 AOI22_X1
* cell instance $14717 r0 *1 57.38,158.2
X$14717 5869 8669 8811 15 27 8881 MUX2_X1
* cell instance $14723 r0 *1 59.66,158.2
X$14723 8939 15 27 8938 INV_X4
* cell instance $14725 r0 *1 60.8,158.2
X$14725 8938 6383 15 27 8941 NAND2_X2
* cell instance $14726 r0 *1 61.75,158.2
X$14726 7169 15 27 8942 INV_X2
* cell instance $14727 r0 *1 62.32,158.2
X$14727 8942 6383 15 27 8945 NAND2_X1
* cell instance $14728 r0 *1 62.89,158.2
X$14728 8812 8941 15 27 8882 NAND2_X1
* cell instance $14730 m0 *1 65.36,158.2
X$14730 6116 8741 8795 15 27 8813 MUX2_X1
* cell instance $14731 m0 *1 64.03,158.2
X$14731 6116 8669 8740 15 27 8883 MUX2_X1
* cell instance $14735 r0 *1 65.36,158.2
X$14735 15 8813 8972 10785 8581 27 DFF_X2
* cell instance $14736 m0 *1 72.58,158.2
X$14736 8744 15 27 8877 CLKBUF_X3
* cell instance $14737 m0 *1 67.83,158.2
X$14737 15 8092 7857 27 BUF_X16
* cell instance $14742 r0 *1 71.63,158.2
X$14742 8814 15 27 8890 CLKBUF_X3
* cell instance $14743 r0 *1 72.58,158.2
X$14743 6473 8815 8973 15 27 8884 MUX2_X1
* cell instance $14744 m0 *1 74.1,158.2
X$14744 6889 7935 7188 15 27 8797 NAND3_X2
* cell instance $14746 m0 *1 75.43,158.2
X$14746 6889 8095 7530 15 27 8800 NAND3_X2
* cell instance $14747 m0 *1 76.76,158.2
X$14747 8863 6518 15 8801 27 NAND2_X4
* cell instance $14748 m0 *1 78.47,158.2
X$14748 6408 8745 8864 15 27 8747 MUX2_X1
* cell instance $14750 m0 *1 79.99,158.2
X$14750 6408 8815 8816 15 27 8803 MUX2_X1
* cell instance $14753 m0 *1 85.12,158.2
X$14753 15 8866 27 8817 BUF_X8
* cell instance $14754 m0 *1 87.59,158.2
X$14754 8736 15 27 8750 BUF_X2
* cell instance $14755 m0 *1 88.35,158.2
X$14755 15 10411 8119 8818 8288 27 DFF_X1
* cell instance $14759 r0 *1 74.1,158.2
X$14759 6473 8511 8948 15 27 9110 MUX2_X1
* cell instance $14760 r0 *1 75.43,158.2
X$14760 6889 7936 7189 15 27 8885 NAND3_X2
* cell instance $14761 r0 *1 76.76,158.2
X$14761 8511 6961 7188 15 27 8817 AND3_X4
* cell instance $14762 r0 *1 78.85,158.2
X$14762 7530 15 27 8863 INV_X4
* cell instance $14764 r0 *1 80.18,158.2
X$14764 8752 15 27 8674 CLKBUF_X3
* cell instance $14765 r0 *1 81.13,158.2
X$14765 8674 15 27 10825 INV_X2
* cell instance $14766 r0 *1 81.7,158.2
X$14766 8797 8728 15 27 8948 NAND2_X1
* cell instance $14771 r0 *1 85.12,158.2
X$14771 15 8677 27 8817 BUF_X8
* cell instance $14773 r0 *1 87.78,158.2
X$14773 8588 8119 15 8956 27 NAND2_X4
* cell instance $14774 r0 *1 89.49,158.2
X$14774 6607 8750 8749 6746 8956 8818 15 27 OAI221_X2
* cell instance $14775 r0 *1 91.58,158.2
X$14775 6296 8823 8819 6553 8959 9033 15 27 OAI221_X2
* cell instance $14776 m0 *1 92.91,158.2
X$14776 15 8588 27 8817 BUF_X8
* cell instance $14778 m0 *1 95.38,158.2
X$14778 15 10354 8324 8751 8288 27 DFF_X1
* cell instance $14779 m0 *1 98.61,158.2
X$14779 15 10356 8520 8869 8288 27 DFF_X1
* cell instance $14782 r0 *1 93.67,158.2
X$14782 8562 8888 15 8960 27 NAND2_X4
* cell instance $14783 r0 *1 95.38,158.2
X$14783 8824 8212 15 8976 27 NAND2_X4
* cell instance $14786 r0 *1 97.66,158.2
X$14786 5925 8823 8819 6013 8820 9096 15 27 OAI221_X2
* cell instance $14788 r0 *1 100.13,158.2
X$14788 8648 8821 15 8891 27 NAND2_X4
* cell instance $14792 r0 *1 103.93,158.2
X$14792 6560 8890 8889 6566 8868 9095 15 27 OAI221_X2
* cell instance $14793 m0 *1 105.45,158.2
X$14793 6658 8749 8867 6222 8750 27 15 8753 OAI221_X1
* cell instance $14795 m0 *1 106.59,158.2
X$14795 15 10313 8330 8753 8754 27 DFF_X1
* cell instance $14796 m0 *1 109.82,158.2
X$14796 8677 8387 15 8822 27 NAND2_X4
* cell instance $14797 m0 *1 111.53,158.2
X$14797 15 10319 8387 8792 8754 27 DFF_X1
* cell instance $14798 m0 *1 114.76,158.2
X$14798 8280 15 27 8754 CLKBUF_X3
* cell instance $14799 m0 *1 115.71,158.2
X$14799 8754 15 27 CLKBUF_X1
* cell instance $14802 m0 *1 117.23,158.2
X$14802 15 10369 8031 8865 8754 27 DFF_X1
* cell instance $14804 m0 *1 121.22,158.2
X$14804 6607 8593 8419 6746 8952 8790 15 27 OAI221_X2
* cell instance $14806 r0 *1 106.02,158.2
X$14806 8327 8821 15 8962 27 NAND2_X4
* cell instance $14807 r0 *1 107.73,158.2
X$14807 8893 8386 15 8894 27 NAND2_X4
* cell instance $14808 r0 *1 109.44,158.2
X$14808 8888 8589 15 27 8958 NAND2_X2
* cell instance $14809 r0 *1 110.39,158.2
X$14809 6789 8750 8749 6637 8822 8792 15 27 OAI221_X2
* cell instance $14810 r0 *1 112.48,158.2
X$14810 6789 8823 8819 6637 8954 8955 15 27 OAI221_X2
* cell instance $14811 r0 *1 114.57,158.2
X$14811 8332 8821 15 8954 27 NAND2_X4
* cell instance $14815 r0 *1 116.28,158.2
X$14815 8590 8824 15 8895 27 NAND2_X4
* cell instance $14817 r0 *1 118.37,158.2
X$14817 6747 8593 8419 6826 8825 8953 15 27 OAI221_X2
* cell instance $14823 r0 *1 122.36,158.2
X$14823 15 8790 8978 10806 7773 27 DFF_X2
* cell instance $14824 m0 *1 123.88,158.2
X$14824 15 8788 7561 10692 7778 27 DFF_X2
* cell instance $14827 m0 *1 128.25,158.2
X$14827 6222 8593 8419 6658 8784 8950 15 27 OAI221_X2
* cell instance $14828 m0 *1 130.34,158.2
X$14828 8592 7947 15 8784 27 NAND2_X4
* cell instance $14829 m0 *1 132.05,158.2
X$14829 7199 8422 15 27 8949 NAND2_X1
* cell instance $14831 m0 *1 132.81,158.2
X$14831 8420 15 27 8826 BUF_X2
* cell instance $14832 m0 *1 133.57,158.2
X$14832 6828 8826 15 27 8859 NAND2_X1
* cell instance $14833 m0 *1 134.14,158.2
X$14833 6696 8826 15 27 9081 NAND2_X1
* cell instance $14834 m0 *1 134.71,158.2
X$14834 7053 8826 15 27 8861 NAND2_X1
* cell instance $14835 m0 *1 135.28,158.2
X$14835 6568 8826 15 27 8855 NAND2_X1
* cell instance $14836 m0 *1 135.85,158.2
X$14836 6738 8826 15 27 8860 NAND2_X1
* cell instance $14838 m0 *1 137.18,158.2
X$14838 6829 8826 15 27 8940 NAND2_X1
* cell instance $14841 r0 *1 129.01,158.2
X$14841 15 10567 7947 8950 8266 27 DFF_X1
* cell instance $14844 r0 *1 132.81,158.2
X$14844 8228 8947 8949 15 8862 27 AOI21_X1
* cell instance $14845 r0 *1 133.57,158.2
X$14845 6742 8826 15 27 8858 NAND2_X1
* cell instance $14848 r0 *1 134.71,158.2
X$14848 8980 8896 15 27 8947 NAND2_X1
* cell instance $14849 r0 *1 135.28,158.2
X$14849 6699 8826 15 27 8897 NAND2_X1
* cell instance $14850 r0 *1 135.85,158.2
X$14850 6767 8826 15 27 8944 NAND2_X1
* cell instance $14851 r0 *1 136.42,158.2
X$14851 6559 8826 15 27 8898 NAND2_X1
* cell instance $14853 m0 *1 141.36,158.2
X$14853 15 10297 8853 8854 8827 27 DFF_X1
* cell instance $14854 m0 *1 138.13,158.2
X$14854 15 10296 8828 8757 8827 27 DFF_X1
* cell instance $14857 m0 *1 146.3,158.2
X$14857 6990 6906 15 27 8829 OR2_X2
* cell instance $14858 m0 *1 147.25,158.2
X$14858 6990 6904 15 27 8830 OR2_X2
* cell instance $14863 r0 *1 139.08,158.2
X$14863 8828 8896 15 27 8857 NAND2_X1
* cell instance $14865 r0 *1 140.03,158.2
X$14865 8853 8899 15 27 8781 NAND2_X1
* cell instance $14868 r0 *1 141.17,158.2
X$14868 8060 8937 8855 15 8934 27 AOI21_X1
* cell instance $14869 r0 *1 141.93,158.2
X$14869 8827 15 27 10849 INV_X1
* cell instance $14872 r0 *1 144.21,158.2
X$14872 7078 7127 15 27 8932 NOR2_X1
* cell instance $14874 r0 *1 145.54,158.2
X$14874 6863 6906 15 27 8900 OR2_X1
* cell instance $14875 r0 *1 146.3,158.2
X$14875 6906 5570 15 27 8933 NOR2_X1
* cell instance $14877 r0 *1 148.39,158.2
X$14877 7969 15 27 9021 INV_X1
* cell instance $14881 m0 *1 149.34,158.2
X$14881 6863 15 27 7399 INV_X2
* cell instance $14882 m0 *1 151.43,158.2
X$14882 7077 15 27 8831 INV_X1
* cell instance $14883 m0 *1 151.81,158.2
X$14883 6990 7156 15 27 8832 OR2_X2
* cell instance $14884 m0 *1 152.76,158.2
X$14884 6236 27 5570 15 BUF_X4
* cell instance $14885 m0 *1 154.09,158.2
X$14885 15 8850 8776 8851 8760 8430 27 FA_X1
* cell instance $14887 r0 *1 149.34,158.2
X$14887 7156 6863 15 27 9078 NOR2_X1
* cell instance $14890 r0 *1 151.05,158.2
X$14890 6236 7156 15 27 8901 OR2_X1
* cell instance $14891 r0 *1 151.81,158.2
X$14891 7418 15 27 6236 INV_X2
* cell instance $14894 r0 *1 153.33,158.2
X$14894 6863 7078 15 27 9076 OR2_X1
* cell instance $14895 r0 *1 154.09,158.2
X$14895 7080 6863 15 27 8902 NOR2_X1
* cell instance $14896 r0 *1 154.66,158.2
X$14896 7076 5570 15 27 8928 NOR2_X1
* cell instance $14898 r0 *1 155.99,158.2
X$14898 6236 7080 15 27 8903 OR2_X1
* cell instance $14901 m0 *1 157.51,158.2
X$14901 8851 15 27 8849 INV_X1
* cell instance $14904 m0 *1 158.27,158.2
X$14904 15 8058 8778 8924 8684 8597 27 FA_X1
* cell instance $14907 r0 *1 158.84,158.2
X$14907 8832 15 27 8684 INV_X2
* cell instance $14908 r0 *1 159.41,158.2
X$14908 15 8833 8925 8904 8849 8924 27 FA_X1
* cell instance $14911 r0 *1 163.02,158.2
X$14911 8925 15 27 8848 INV_X1
* cell instance $14913 m0 *1 163.21,158.2
X$14913 8775 15 27 8847 INV_X1
* cell instance $14915 m0 *1 166.82,158.2
X$14915 8449 8133 8905 27 15 8846 HA_X1
* cell instance $14916 m0 *1 168.72,158.2
X$14916 8846 8774 8834 27 15 8599 HA_X1
* cell instance $14921 r0 *1 163.4,158.2
X$14921 8829 15 27 8761 INV_X2
* cell instance $14922 r0 *1 163.97,158.2
X$14922 15 8848 8921 8922 8776 8847 27 FA_X1
* cell instance $14926 r0 *1 170.62,158.2
X$14926 8922 15 27 8835 INV_X1
* cell instance $14927 r0 *1 171,158.2
X$14927 8835 8834 8915 27 15 8762 HA_X1
* cell instance $14932 r0 *1 173.09,158.2
X$14932 7065 7478 8919 27 15 10923 HA_X1
* cell instance $14935 r0 *1 176.7,158.2
X$14935 9138 8917 8845 27 8844 15 OAI21_X1
* cell instance $14936 r0 *1 177.46,158.2
X$14936 8836 8907 8906 27 15 8917 HA_X1
* cell instance $14938 m0 *1 181.83,158.2
X$14938 8127 8603 9132 27 15 8839 HA_X1
* cell instance $14940 m0 *1 183.73,158.2
X$14940 15 8839 8769 8766 8765 8695 27 FA_X1
* cell instance $14944 r0 *1 182.4,158.2
X$14944 8914 15 27 8908 INV_X1
* cell instance $14950 m0 *1 8.36,130.2
X$14950 6529 7110 7217 15 7216 27 AOI21_X1
* cell instance $14951 m0 *1 9.31,130.2
X$14951 6529 7220 7218 15 7219 27 AOI21_X1
* cell instance $14953 m0 *1 10.26,130.2
X$14953 7111 7024 15 27 7220 NAND2_X1
* cell instance $14957 m0 *1 14.82,130.2
X$14957 15 10293 7146 7311 7113 27 DFF_X1
* cell instance $14958 m0 *1 18.05,130.2
X$14958 6523 15 27 7113 CLKBUF_X3
* cell instance $14959 m0 *1 19,130.2
X$14959 6883 7028 15 6956 27 NAND2_X4
* cell instance $14960 m0 *1 20.71,130.2
X$14960 7073 7176 15 7155 27 NAND2_X4
* cell instance $14961 m0 *1 22.42,130.2
X$14961 7113 15 27 10840 INV_X1
* cell instance $14969 r0 *1 2.09,130.2
X$14969 15 10596 7270 7404 7268 27 DFF_X1
* cell instance $14974 m0 *1 4.75,130.2
X$14974 15 10299 7109 7216 6852 27 DFF_X1
* cell instance $14978 r0 *1 10.07,130.2
X$14978 7309 15 27 6529 CLKBUF_X3
* cell instance $14981 r0 *1 12.92,130.2
X$14981 7271 15 27 6882 BUF_X2
* cell instance $14985 r0 *1 16.15,130.2
X$14985 7112 6201 7274 5492 7272 7311 15 27 OAI221_X2
* cell instance $14986 r0 *1 18.24,130.2
X$14986 7112 6654 7274 6029 7417 7273 15 27 OAI221_X2
* cell instance $14988 r0 *1 20.71,130.2
X$14988 7276 7275 6391 15 27 7334 MUX2_X1
* cell instance $14989 r0 *1 22.04,130.2
X$14989 7146 7232 5521 15 27 7277 MUX2_X1
* cell instance $14992 r0 *1 24.32,130.2
X$14992 7329 7232 5688 15 27 7332 MUX2_X1
* cell instance $14994 m0 *1 24.7,130.2
X$14994 7026 7232 5185 15 27 7330 MUX2_X1
* cell instance $14996 r0 *1 25.65,130.2
X$14996 7330 7340 7332 15 27 7235 MUX2_X1
* cell instance $14998 m0 *1 28.12,130.2
X$14998 7029 7232 5356 15 27 7239 MUX2_X1
* cell instance $15000 m0 *1 29.45,130.2
X$15000 7032 27 7112 15 BUF_X4
* cell instance $15001 m0 *1 30.78,130.2
X$15001 7029 7115 5356 15 27 7178 MUX2_X1
* cell instance $15004 m0 *1 35.91,130.2
X$15004 15 10409 7072 7179 6959 27 DFF_X1
* cell instance $15009 m0 *1 47.69,130.2
X$15009 7285 7035 7252 15 27 7180 MUX2_X1
* cell instance $15012 r0 *1 28.5,130.2
X$15012 7279 7232 6026 15 27 7342 MUX2_X1
* cell instance $15013 r0 *1 29.83,130.2
X$15013 7239 7340 7342 15 27 7346 MUX2_X1
* cell instance $15014 r0 *1 31.16,130.2
X$15014 7279 7115 6026 15 27 7344 MUX2_X1
* cell instance $15016 r0 *1 32.68,130.2
X$15016 7178 7281 7344 15 27 7368 MUX2_X1
* cell instance $15018 r0 *1 34.77,130.2
X$15018 15 5568 7541 7347 7346 27 AOI21_X4
* cell instance $15021 r0 *1 38.19,130.2
X$15021 7072 7283 5269 15 27 7372 MUX2_X1
* cell instance $15025 r0 *1 44.84,130.2
X$15025 7284 7235 7347 27 15 6777 MUX2_X2
* cell instance $15027 r0 *1 46.93,130.2
X$15027 5849 15 27 7285 INV_X1
* cell instance $15028 r0 *1 47.31,130.2
X$15028 15 7180 6810 10736 5242 27 DFF_X2
* cell instance $15031 m0 *1 50.92,130.2
X$15031 7253 6397 6962 27 15 7252 OAI21_X2
* cell instance $15036 m0 *1 53.39,130.2
X$15036 7181 7182 6961 15 27 7027 AND3_X4
* cell instance $15037 m0 *1 56.24,130.2
X$15037 7182 7185 15 27 7032 NAND2_X2
* cell instance $15039 m0 *1 57.38,130.2
X$15039 7181 6277 7184 27 7183 15 OAI21_X1
* cell instance $15040 m0 *1 58.14,130.2
X$15040 7181 7177 7037 15 27 7184 NAND3_X1
* cell instance $15041 m0 *1 58.9,130.2
X$15041 7181 15 27 7185 INV_X2
* cell instance $15043 r0 *1 53.39,130.2
X$15043 6398 7181 7352 27 7286 15 OAI21_X1
* cell instance $15044 r0 *1 54.15,130.2
X$15044 7181 6955 7037 15 27 7352 NAND3_X1
* cell instance $15047 r0 *1 56.62,130.2
X$15047 6116 7182 7183 15 27 7377 MUX2_X1
* cell instance $15053 m0 *1 60.42,130.2
X$15053 7181 7287 6889 15 27 7256 NAND3_X1
* cell instance $15054 m0 *1 59.85,130.2
X$15054 7185 6383 15 27 7257 NAND2_X1
* cell instance $15055 m0 *1 61.18,130.2
X$15055 7256 7257 15 27 7353 NAND2_X1
* cell instance $15060 r0 *1 60.61,130.2
X$15060 6380 7182 7353 15 27 7433 MUX2_X1
* cell instance $15062 m0 *1 66.31,130.2
X$15062 7525 15 27 7042 CLKBUF_X3
* cell instance $15063 m0 *1 65.93,130.2
X$15063 7042 15 27 10836 INV_X1
* cell instance $15064 m0 *1 67.26,130.2
X$15064 7187 7186 6323 27 15 8109 MUX2_X2
* cell instance $15067 m0 *1 71.25,130.2
X$15067 7048 7118 6276 27 15 7259 MUX2_X2
* cell instance $15068 m0 *1 72.96,130.2
X$15068 7187 7186 6606 27 15 7188 MUX2_X2
* cell instance $15073 r0 *1 70.11,130.2
X$15073 6549 6401 15 27 7288 NAND2_X1
* cell instance $15077 r0 *1 73.34,130.2
X$15077 6401 15 27 7289 INV_X1
* cell instance $15078 r0 *1 73.72,130.2
X$15078 15 6549 6405 6401 5510 7355 27 NAND4_X4
* cell instance $15079 m0 *1 76.76,130.2
X$15079 5675 27 7115 15 BUF_X4
* cell instance $15080 m0 *1 75.05,130.2
X$15080 7048 7118 6606 27 15 7530 MUX2_X2
* cell instance $15083 r0 *1 77.33,130.2
X$15083 15 7358 7357 10791 7380 27 DFF_X2
* cell instance $15084 m0 *1 79.04,130.2
X$15084 6473 7190 7263 15 27 7172 MUX2_X1
* cell instance $15085 m0 *1 78.47,130.2
X$15085 7261 7262 15 27 7263 NAND2_X1
* cell instance $15086 m0 *1 80.37,130.2
X$15086 7170 5879 6889 15 27 7261 NAND3_X1
* cell instance $15087 m0 *1 81.13,130.2
X$15087 7170 15 27 7191 INV_X4
* cell instance $15088 m0 *1 82.08,130.2
X$15088 7191 6518 15 27 7262 NAND2_X2
* cell instance $15089 m0 *1 83.03,130.2
X$15089 7190 7191 15 7192 27 NAND2_X4
* cell instance $15090 m0 *1 84.74,130.2
X$15090 7170 7190 2126 15 27 7121 AND3_X4
* cell instance $15091 m0 *1 86.83,130.2
X$15091 6408 7190 7265 15 27 7266 MUX2_X1
* cell instance $15093 m0 *1 88.35,130.2
X$15093 15 7266 7357 10645 7173 27 DFF_X2
* cell instance $15097 m0 *1 94.43,130.2
X$15097 6212 7192 7264 6213 7193 27 15 7354 OAI221_X1
* cell instance $15101 r0 *1 80.94,130.2
X$15101 7290 7356 15 27 7437 NAND2_X1
* cell instance $15103 r0 *1 81.7,130.2
X$15103 6122 15 27 7381 BUF_X2
* cell instance $15106 r0 *1 83.6,130.2
X$15106 5674 27 7383 15 BUF_X4
* cell instance $15108 r0 *1 85.12,130.2
X$15108 7170 27 7120 15 BUF_X4
* cell instance $15109 r0 *1 86.45,130.2
X$15109 7291 7292 6631 27 15 7293 OAI21_X2
* cell instance $15115 r0 *1 93.67,130.2
X$15115 15 7354 7294 10758 7295 27 DFF_X2
* cell instance $15116 r0 *1 97.28,130.2
X$15116 7295 7121 15 27 7264 NAND2_X2
* cell instance $15120 r0 *1 100.32,130.2
X$15120 15 7297 6827 10804 6834 27 DFF_X2
* cell instance $15121 m0 *1 100.7,130.2
X$15121 5959 7192 7260 6214 7193 27 15 7297 OAI221_X1
* cell instance $15123 m0 *1 101.84,130.2
X$15123 6834 7121 15 27 7260 NAND2_X2
* cell instance $15127 m0 *1 106.78,130.2
X$15127 15 7194 7054 10661 7195 27 DFF_X2
* cell instance $15129 m0 *1 111.15,130.2
X$15129 7258 7121 15 27 7350 NAND2_X2
* cell instance $15135 r0 *1 106.78,130.2
X$15135 6181 7192 7299 6744 7193 27 15 7194 OAI221_X1
* cell instance $15136 r0 *1 107.92,130.2
X$15136 7195 7121 15 27 7299 NAND2_X2
* cell instance $15137 r0 *1 108.87,130.2
X$15137 5830 15 27 7300 CLKBUF_X3
* cell instance $15138 r0 *1 109.82,130.2
X$15138 6689 7192 7350 5921 7193 27 15 7349 OAI221_X1
* cell instance $15140 r0 *1 111.72,130.2
X$15140 15 7349 7056 10797 7258 27 DFF_X2
* cell instance $15141 m0 *1 112.67,130.2
X$15141 15 6982 27 7192 BUF_X8
* cell instance $15144 m0 *1 115.33,130.2
X$15144 7196 15 27 6899 CLKBUF_X3
* cell instance $15146 m0 *1 116.47,130.2
X$15146 7254 6833 15 7255 27 NAND2_X4
* cell instance $15147 m0 *1 118.18,130.2
X$15147 6747 6899 6982 6826 7255 7348 15 27 OAI221_X2
* cell instance $15156 r0 *1 117.42,130.2
X$15156 15 7348 7056 10774 7254 27 DFF_X2
* cell instance $15159 m0 *1 125.02,130.2
X$15159 6560 6899 6982 6566 7249 7197 15 27 OAI221_X2
* cell instance $15160 m0 *1 121.41,130.2
X$15160 15 7088 7056 10681 7122 27 DFF_X2
* cell instance $15161 m0 *1 127.11,130.2
X$15161 6222 6899 6982 6658 7248 7250 15 27 OAI221_X2
* cell instance $15162 m0 *1 129.2,130.2
X$15162 15 10338 7083 7198 7123 27 DFF_X1
* cell instance $15166 r0 *1 125.02,130.2
X$15166 15 7197 7123 10816 7199 27 DFF_X2
* cell instance $15167 r0 *1 128.63,130.2
X$15167 6605 6899 6982 6638 7251 7198 15 27 OAI221_X2
* cell instance $15168 r0 *1 130.72,130.2
X$15168 7199 6983 15 7249 27 NAND2_X4
* cell instance $15169 r0 *1 132.43,130.2
X$15169 6413 15 27 7123 CLKBUF_X3
* cell instance $15170 r0 *1 133.38,130.2
X$15170 7123 15 27 CLKBUF_X1
* cell instance $15171 r0 *1 133.95,130.2
X$15171 7124 6224 15 27 7345 NAND2_X1
* cell instance $15173 m0 *1 134.33,130.2
X$15173 15 7127 7471 6903 7123 27 DFF_X1
* cell instance $15175 m0 *1 139.27,130.2
X$15175 7302 7246 27 15 7247 XNOR2_X1
* cell instance $15179 r0 *1 137.75,130.2
X$15179 7343 15 27 7423 INV_X1
* cell instance $15182 r0 *1 139.84,130.2
X$15182 7302 15 27 7125 INV_X1
* cell instance $15185 m0 *1 140.79,130.2
X$15185 7129 7130 27 15 7246 XNOR2_X1
* cell instance $15187 m0 *1 145.73,130.2
X$15187 7200 7241 27 15 7201 XNOR2_X1
* cell instance $15191 r0 *1 141.36,130.2
X$15191 7303 15 27 7129 INV_X1
* cell instance $15192 r0 *1 141.74,130.2
X$15192 7336 7317 15 27 5607 XNOR2_X2
* cell instance $15193 r0 *1 143.64,130.2
X$15193 7335 7338 27 15 7336 XNOR2_X1
* cell instance $15196 r0 *1 145.73,130.2
X$15196 7201 7331 27 15 7335 XNOR2_X1
* cell instance $15198 m0 *1 149.34,130.2
X$15198 7245 7233 27 15 7202 XNOR2_X1
* cell instance $15199 m0 *1 148.01,130.2
X$15199 7126 27 6844 15 BUF_X4
* cell instance $15200 m0 *1 150.48,130.2
X$15200 7202 7229 27 15 7304 XNOR2_X1
* cell instance $15201 m0 *1 151.62,130.2
X$15201 6417 7244 27 15 7327 XNOR2_X1
* cell instance $15202 m0 *1 152.76,130.2
X$15202 7204 7240 27 15 7326 XNOR2_X1
* cell instance $15203 m0 *1 153.9,130.2
X$15203 7230 7242 27 15 7243 XNOR2_X1
* cell instance $15206 r0 *1 149.15,130.2
X$15206 7328 7333 27 15 7331 XNOR2_X1
* cell instance $15208 r0 *1 150.67,130.2
X$15208 7326 7304 27 15 7328 XNOR2_X1
* cell instance $15209 r0 *1 151.81,130.2
X$15209 7474 7243 27 15 7204 XNOR2_X1
* cell instance $15211 r0 *1 153.14,130.2
X$15211 7324 7327 27 15 7325 XNOR2_X1
* cell instance $15212 r0 *1 154.28,130.2
X$15212 7413 7325 15 27 7206 XNOR2_X2
* cell instance $15213 m0 *1 156.56,130.2
X$15213 7238 7205 27 15 7240 XNOR2_X1
* cell instance $15214 m0 *1 155.42,130.2
X$15214 7134 7574 27 15 7205 XNOR2_X1
* cell instance $15216 r0 *1 156.18,130.2
X$15216 7206 6912 15 27 7241 XNOR2_X2
* cell instance $15217 m0 *1 158.27,130.2
X$15217 15 7060 7207 7237 7236 7234 27 FA_X1
* cell instance $15219 m0 *1 161.31,130.2
X$15219 7237 15 27 7306 INV_X1
* cell instance $15221 r0 *1 158.08,130.2
X$15221 7322 7207 15 27 7305 XOR2_X1
* cell instance $15222 r0 *1 159.22,130.2
X$15222 7397 7319 7318 27 15 7208 HA_X1
* cell instance $15223 r0 *1 161.12,130.2
X$15223 15 7136 7577 7321 7306 7315 27 FA_X1
* cell instance $15224 m0 *1 162.26,130.2
X$15224 15 7321 7209 7231 7320 7225 27 FA_X1
* cell instance $15228 m0 *1 166.25,130.2
X$15228 7227 7228 27 15 7229 XNOR2_X1
* cell instance $15229 m0 *1 167.39,130.2
X$15229 15 7211 7230 7225 7226 7316 27 FA_X1
* cell instance $15234 r0 *1 167.39,130.2
X$15234 15 7408 7210 7316 7401 7318 27 FA_X1
* cell instance $15236 r0 *1 170.62,130.2
X$15236 7222 7313 7314 27 15 7315 HA_X1
* cell instance $15240 m0 *1 174.23,130.2
X$15240 15 7213 7224 7222 7064 7223 27 FA_X1
* cell instance $15241 m0 *1 172.33,130.2
X$15241 7212 7224 7226 27 15 7135 HA_X1
* cell instance $15242 m0 *1 177.27,130.2
X$15242 7214 7215 7223 27 15 7221 HA_X1
* cell instance $15244 m0 *1 179.93,130.2
X$15244 6911 15 27 7140 INV_X2
* cell instance $15247 r0 *1 172.71,130.2
X$15247 15 7310 7313 7407 7307 7312 27 FA_X1
* cell instance $15249 r0 *1 175.94,130.2
X$15249 7401 7140 7312 27 15 7213 HA_X1
* cell instance $15250 r0 *1 177.84,130.2
X$15250 7065 15 27 7214 INV_X2
* cell instance $15252 r0 *1 179.17,130.2
X$15252 7214 7140 10888 27 15 7308 HA_X1
* cell instance $15253 m0 *1 181.07,130.2
X$15253 7215 7140 10869 27 15 7688 HA_X1
* cell instance $15259 r0 *1 181.07,130.2
X$15259 6912 6911 7481 27 15 10921 HA_X1
* cell instance $15266 m0 *1 1.52,141.4
X$15266 7888 15 27 7750 BUF_X1
* cell instance $15268 m0 *1 2.28,141.4
X$15268 15 10316 7751 7889 7268 27 DFF_X1
* cell instance $15270 m0 *1 5.7,141.4
X$15270 7751 7850 15 27 7851 NAND2_X1
* cell instance $15272 m0 *1 6.46,141.4
X$15272 7441 7851 7803 15 7889 27 AOI21_X1
* cell instance $15279 r0 *1 2.28,141.4
X$15279 7922 15 27 7920 BUF_X1
* cell instance $15284 r0 *1 3.23,141.4
X$15284 15 10607 7921 8045 7268 27 DFF_X1
* cell instance $15285 r0 *1 6.46,141.4
X$15285 7922 7850 15 27 7923 NAND2_X1
* cell instance $15286 r0 *1 7.03,141.4
X$15286 7441 7923 7894 15 7957 27 AOI21_X1
* cell instance $15287 r0 *1 7.79,141.4
X$15287 15 10593 7922 7957 7537 27 DFF_X1
* cell instance $15291 m0 *1 2.47,29.4
X$15291 857 1419 27 15 1544 XNOR2_X1
* cell instance $15292 m0 *1 3.8,29.4
X$15292 1495 1377 578 700 1545 27 15 AOI211_X2
* cell instance $15294 m0 *1 5.7,29.4
X$15294 1496 1377 1591 15 27 1310 MUX2_X1
* cell instance $15296 m0 *1 7.22,29.4
X$15296 1607 355 15 27 1496 NOR2_X1
* cell instance $15298 m0 *1 7.98,29.4
X$15298 1607 408 1499 27 1591 15 OAI21_X1
* cell instance $15302 m0 *1 11.21,29.4
X$15302 1548 1608 15 27 1547 NOR2_X2
* cell instance $15315 r0 *1 3.42,29.4
X$15315 15 1649 1545 1446 1764 27 NOR3_X4
* cell instance $15316 r0 *1 6.08,29.4
X$15316 1377 1495 27 15 1649 AND2_X1
* cell instance $15318 r0 *1 7.22,29.4
X$15318 355 1607 27 15 1495 XNOR2_X1
* cell instance $15321 r0 *1 10.26,29.4
X$15321 1651 1547 1311 15 27 NOR2_X4
* cell instance $15322 r0 *1 11.97,29.4
X$15322 1609 1548 1549 27 1651 15 NOR3_X2
* cell instance $15324 r0 *1 13.68,29.4
X$15324 1549 1675 27 15 1654 XNOR2_X1
* cell instance $15326 m0 *1 14.06,29.4
X$15326 295 1501 1549 27 15 1609 HA_X1
* cell instance $15331 r0 *1 14.82,29.4
X$15331 1501 1654 1546 27 15 1550 MUX2_X2
* cell instance $15332 r0 *1 16.53,29.4
X$15332 1610 1732 1551 27 1731 15 OAI21_X1
* cell instance $15333 r0 *1 17.29,29.4
X$15333 1611 15 27 1551 INV_X1
* cell instance $15336 r0 *1 18.62,29.4
X$15336 195 1612 1613 27 15 1611 HA_X1
* cell instance $15338 r0 *1 20.9,29.4
X$15338 138 1503 1614 27 15 1733 HA_X1
* cell instance $15342 r0 *1 25.27,29.4
X$15342 365 27 408 15 BUF_X4
* cell instance $15344 m0 *1 29.45,29.4
X$15344 43 1447 1388 27 15 1387 HA_X1
* cell instance $15345 m0 *1 27.74,29.4
X$15345 1447 1062 1385 15 27 NOR2_X4
* cell instance $15348 r0 *1 30.4,29.4
X$15348 111 1448 1386 27 15 1655 HA_X1
* cell instance $15349 m0 *1 31.92,29.4
X$15349 1431 1449 15 27 1450 NAND2_X2
* cell instance $15351 m0 *1 32.87,29.4
X$15351 1451 1450 15 27 1553 XOR2_X1
* cell instance $15352 m0 *1 34.01,29.4
X$15352 1450 1451 27 1554 15 AND2_X4
* cell instance $15354 r0 *1 32.3,29.4
X$15354 1655 15 27 1449 INV_X1
* cell instance $15355 r0 *1 32.68,29.4
X$15355 1615 1062 1553 15 27 1552 MUX2_X1
* cell instance $15356 r0 *1 34.01,29.4
X$15356 212 1615 1451 27 15 1555 HA_X1
* cell instance $15357 r0 *1 35.91,29.4
X$15357 1389 1555 1554 15 27 1556 OR3_X1
* cell instance $15358 m0 *1 38.57,29.4
X$15358 1028 1065 1772 27 15 705 OAI21_X2
* cell instance $15359 m0 *1 36.1,29.4
X$15359 1389 1554 1555 27 15 1229 OAI21_X4
* cell instance $15360 m0 *1 39.9,29.4
X$15360 946 1452 15 27 1448 NOR2_X1
* cell instance $15363 m0 *1 47.31,29.4
X$15363 597 1453 1391 27 15 1658 OAI21_X4
* cell instance $15364 m0 *1 49.78,29.4
X$15364 1455 1453 15 1325 27 OR2_X4
* cell instance $15368 r0 *1 36.86,29.4
X$15368 1229 1556 27 15 1599 AND2_X1
* cell instance $15369 r0 *1 37.62,29.4
X$15369 1598 1507 1616 15 27 1656 NOR3_X1
* cell instance $15370 r0 *1 38.38,29.4
X$15370 1656 1934 15 27 1063 NAND2_X1
* cell instance $15374 r0 *1 48.26,29.4
X$15374 1658 15 27 1283 INV_X4
* cell instance $15376 r0 *1 49.59,29.4
X$15376 1455 15 27 1391 INV_X1
* cell instance $15380 r0 *1 51.3,29.4
X$15380 388 881 1741 27 15 1557 HA_X1
* cell instance $15382 r0 *1 53.96,29.4
X$15382 1557 15 27 1742 INV_X1
* cell instance $15385 r0 *1 56.05,29.4
X$15385 195 327 1620 27 15 1659 HA_X1
* cell instance $15386 m0 *1 56.62,29.4
X$15386 1620 1520 27 15 1457 XNOR2_X1
* cell instance $15388 m0 *1 57.76,29.4
X$15388 138 328 1558 27 15 1559 HA_X1
* cell instance $15389 m0 *1 59.66,29.4
X$15389 212 416 1521 27 15 1560 HA_X1
* cell instance $15390 m0 *1 61.56,29.4
X$15390 1521 1561 15 27 1067 XNOR2_X2
* cell instance $15394 r0 *1 57.95,29.4
X$15394 1659 15 27 1621 INV_X1
* cell instance $15396 r0 *1 58.52,29.4
X$15396 1559 1558 1660 15 1520 27 AOI21_X1
* cell instance $15401 r0 *1 59.47,29.4
X$15401 1559 1558 1560 15 1745 27 AOI21_X2
* cell instance $15402 r0 *1 60.8,29.4
X$15402 1558 1622 27 15 1523 XNOR2_X1
* cell instance $15403 r0 *1 61.94,29.4
X$15403 1623 1561 1624 27 1660 15 OAI21_X1
* cell instance $15404 r0 *1 62.7,29.4
X$15404 1560 15 27 1624 INV_X1
* cell instance $15406 r0 *1 64.6,29.4
X$15406 1661 1562 15 27 552 NAND2_X2
* cell instance $15408 r0 *1 65.93,29.4
X$15408 1604 1030 15 27 1625 NOR2_X1
* cell instance $15411 m0 *1 67.64,29.4
X$15411 15 1616 1459 260 1749 1455 27 OAI22_X4
* cell instance $15412 m0 *1 71.63,29.4
X$15412 1460 1603 1772 27 15 1153 MUX2_X2
* cell instance $15414 m0 *1 74.1,29.4
X$15414 15 1070 260 1526 1605 27 AOI21_X4
* cell instance $15416 m0 *1 78.09,29.4
X$15416 1458 1461 15 550 27 NAND2_X4
* cell instance $15417 m0 *1 79.8,29.4
X$15417 1606 27 260 15 BUF_X4
* cell instance $15418 m0 *1 81.13,29.4
X$15418 1604 15 27 1461 INV_X2
* cell instance $15421 r0 *1 68.02,29.4
X$15421 1667 15 27 LOGIC1_X1
* cell instance $15422 r0 *1 68.4,29.4
X$15422 1626 1627 15 27 1628 NAND2_X2
* cell instance $15424 r0 *1 69.54,29.4
X$15424 43 1667 1666 27 15 1668 HA_X1
* cell instance $15425 r0 *1 71.44,29.4
X$15425 1668 1693 15 27 1603 XOR2_X1
* cell instance $15430 r0 *1 78.09,29.4
X$15430 1670 1629 10880 27 15 1606 HA_X1
* cell instance $15431 r0 *1 79.99,29.4
X$15431 1629 1670 10881 27 15 645 HA_X1
* cell instance $15434 m0 *1 84.17,29.4
X$15434 15 1532 1462 1530 1563 27 DFF_X1
* cell instance $15435 m0 *1 82.84,29.4
X$15435 1462 27 1604 15 BUF_X4
* cell instance $15436 m0 *1 87.4,29.4
X$15436 1532 27 1030 15 BUF_X4
* cell instance $15438 r0 *1 82.84,29.4
X$15438 1245 15 27 10830 INV_X2
* cell instance $15441 r0 *1 84.36,29.4
X$15441 1458 15 27 999 INV_X2
* cell instance $15444 m0 *1 89.3,29.4
X$15444 1397 1396 15 27 1534 NAND2_X1
* cell instance $15448 m0 *1 92.15,29.4
X$15448 646 1536 15 27 1565 NAND2_X1
* cell instance $15449 m0 *1 92.72,29.4
X$15449 1246 1565 1463 1671 1248 27 15 1464 OAI221_X1
* cell instance $15453 m0 *1 102.22,29.4
X$15453 111 1632 1569 27 15 1539 HA_X1
* cell instance $15454 m0 *1 104.12,29.4
X$15454 1539 15 27 1540 INV_X1
* cell instance $15455 m0 *1 104.5,29.4
X$15455 1539 1569 1465 15 1571 27 AOI21_X2
* cell instance $15456 m0 *1 105.83,29.4
X$15456 1570 1571 27 15 1466 XNOR2_X1
* cell instance $15457 m0 *1 106.97,29.4
X$15457 1467 1541 1540 15 1543 27 AOI21_X1
* cell instance $15458 m0 *1 107.73,29.4
X$15458 1542 1467 1571 27 15 1537 OAI21_X2
* cell instance $15459 m0 *1 109.06,29.4
X$15459 1468 15 27 1542 INV_X1
* cell instance $15460 m0 *1 109.44,29.4
X$15460 138 1470 1573 27 15 1538 HA_X1
* cell instance $15461 m0 *1 111.34,29.4
X$15461 1538 1572 1537 15 1471 27 AOI21_X2
* cell instance $15462 m0 *1 112.67,29.4
X$15462 1538 15 27 1665 INV_X1
* cell instance $15463 m0 *1 113.05,29.4
X$15463 1535 1472 1471 27 15 1601 OAI21_X2
* cell instance $15465 m0 *1 114.57,29.4
X$15465 195 1406 1405 27 15 1533 HA_X1
* cell instance $15466 m0 *1 116.47,29.4
X$15466 15 1401 27 1577 BUF_X8
* cell instance $15468 m0 *1 119.13,29.4
X$15468 295 1473 1574 27 15 1474 HA_X1
* cell instance $15469 m0 *1 121.03,29.4
X$15469 1474 1601 1408 15 1478 27 AOI21_X2
* cell instance $15470 m0 *1 122.36,29.4
X$15470 1474 15 27 1576 INV_X1
* cell instance $15471 m0 *1 122.74,29.4
X$15471 1477 1432 1476 15 1600 27 AOI21_X2
* cell instance $15472 m0 *1 124.07,29.4
X$15472 15 1524 1477 1432 1525 27 AOI21_X4
* cell instance $15473 m0 *1 126.54,29.4
X$15473 1410 1600 15 27 1481 XNOR2_X2
* cell instance $15474 m0 *1 128.44,29.4
X$15474 1481 1086 1518 27 1522 15 NOR3_X2
* cell instance $15475 m0 *1 129.77,29.4
X$15475 1577 1519 1578 1518 1086 1481 15 27 1254 OAI33_X1
* cell instance $15476 m0 *1 131.1,29.4
X$15476 1519 1578 1580 15 27 NOR2_X4
* cell instance $15477 m0 *1 132.81,29.4
X$15477 1581 1516 15 1178 27 NAND2_X4
* cell instance $15478 m0 *1 134.52,29.4
X$15478 1516 1581 27 15 843 AND2_X2
* cell instance $15481 r0 *1 89.87,29.4
X$15481 1699 1248 1246 15 27 1672 MUX2_X1
* cell instance $15483 r0 *1 91.96,29.4
X$15483 1563 15 27 CLKBUF_X1
* cell instance $15484 r0 *1 92.53,29.4
X$15484 1564 15 27 1563 CLKBUF_X3
* cell instance $15485 r0 *1 93.48,29.4
X$15485 15 1464 1563 10809 1700 27 DFF_X2
* cell instance $15487 r0 *1 97.85,29.4
X$15487 1757 1536 587 15 27 1758 MUX2_X1
* cell instance $15489 r0 *1 99.56,29.4
X$15489 1566 1631 27 15 1669 XNOR2_X1
* cell instance $15490 r0 *1 100.7,29.4
X$15490 1567 1401 1669 15 27 1250 MUX2_X1
* cell instance $15491 r0 *1 102.03,29.4
X$15491 1632 1401 1568 15 27 1161 MUX2_X1
* cell instance $15492 r0 *1 103.36,29.4
X$15492 1566 1569 1633 15 27 1634 OR3_X1
* cell instance $15494 r0 *1 104.5,29.4
X$15494 1566 1633 1569 27 1541 15 OAI21_X1
* cell instance $15495 r0 *1 105.26,29.4
X$15495 1704 15 27 1465 INV_X1
* cell instance $15498 r0 *1 106.78,29.4
X$15498 1569 1570 1566 1572 15 27 1663 NAND4_X1
* cell instance $15499 r0 *1 107.73,29.4
X$15499 1570 15 27 1467 INV_X1
* cell instance $15502 r0 *1 109.25,29.4
X$15502 1572 1469 27 15 1404 XNOR2_X1
* cell instance $15503 r0 *1 110.39,29.4
X$15503 1573 15 27 1572 BUF_X1
* cell instance $15506 r0 *1 111.91,29.4
X$15506 1572 15 27 1664 INV_X1
* cell instance $15507 r0 *1 112.29,29.4
X$15507 1664 1469 1665 27 1662 15 OAI21_X1
* cell instance $15509 r0 *1 113.81,29.4
X$15509 1472 1616 1575 1663 15 27 1756 OR4_X1
* cell instance $15510 r0 *1 114.95,29.4
X$15510 1533 1405 1662 15 1527 27 AOI21_X2
* cell instance $15516 r0 *1 119.7,29.4
X$15516 1574 15 27 1408 BUF_X1
* cell instance $15520 r0 *1 121.41,29.4
X$15520 1575 1527 15 27 1597 NOR2_X2
* cell instance $15521 r0 *1 122.36,29.4
X$15521 1475 1527 1576 27 1476 15 OAI21_X1
* cell instance $15522 r0 *1 123.12,29.4
X$15522 1408 1432 1410 15 27 1575 NAND3_X1
* cell instance $15523 r0 *1 123.88,29.4
X$15523 1477 1432 1474 15 1636 27 AOI21_X1
* cell instance $15524 r0 *1 124.64,29.4
X$15524 1478 15 27 1525 INV_X2
* cell instance $15526 r0 *1 125.59,29.4
X$15526 1637 1524 1480 27 15 1579 OAI21_X4
* cell instance $15528 r0 *1 129.58,29.4
X$15528 1579 1519 15 27 1518 XNOR2_X2
* cell instance $15531 r0 *1 132.62,29.4
X$15531 1519 1579 15 27 1581 NAND2_X1
* cell instance $15534 r0 *1 135.47,29.4
X$15534 1582 1411 1583 27 15 1092 OAI21_X4
* cell instance $15535 m0 *1 136.04,29.4
X$15535 1255 1407 1512 15 1287 27 AOI21_X2
* cell instance $15537 m0 *1 137.37,29.4
X$15537 15 1497 1483 1484 1510 27 NOR3_X4
* cell instance $15538 m0 *1 140.03,29.4
X$15538 1485 15 27 1585 INV_X1
* cell instance $15540 m0 *1 141.17,29.4
X$15540 1485 1596 1509 27 15 746 MUX2_X2
* cell instance $15541 m0 *1 142.88,29.4
X$15541 1486 1411 1595 27 15 1257 OAI21_X4
* cell instance $15543 r0 *1 137.94,29.4
X$15543 1645 1483 1412 27 1512 15 OAI21_X1
* cell instance $15544 r0 *1 138.7,29.4
X$15544 1485 1577 15 27 1596 NAND2_X2
* cell instance $15545 r0 *1 139.65,29.4
X$15545 1585 1584 15 27 1657 NOR2_X1
* cell instance $15546 r0 *1 140.22,29.4
X$15546 15 1641 1657 1596 438 1643 27 OAI22_X4
* cell instance $15548 r0 *1 143.64,29.4
X$15548 1643 1509 1585 15 27 1595 MUX2_X1
* cell instance $15549 r0 *1 144.97,29.4
X$15549 1484 1587 1586 27 1413 15 NOR3_X2
* cell instance $15550 m0 *1 145.92,29.4
X$15550 1487 1594 1593 15 1183 27 NAND3_X4
* cell instance $15552 m0 *1 148.39,29.4
X$15552 1482 1488 1411 15 27 NOR2_X4
* cell instance $15555 r0 *1 146.49,29.4
X$15555 1586 1587 1645 15 27 1653 OR3_X1
* cell instance $15556 r0 *1 147.44,29.4
X$15556 1653 1414 15 27 1592 NAND2_X1
* cell instance $15558 r0 *1 148.2,29.4
X$15558 1508 1414 1653 15 1593 27 AOI21_X2
* cell instance $15561 m0 *1 150.48,29.4
X$15561 1489 1491 15 27 1424 OR2_X1
* cell instance $15565 r0 *1 153.33,29.4
X$15565 1491 1489 1589 15 1188 27 NAND3_X4
* cell instance $15566 m0 *1 154.09,29.4
X$15566 15 1491 1589 1489 1590 1421 27 NAND4_X4
* cell instance $15569 m0 *1 158.27,29.4
X$15569 1492 1498 1494 938 15 27 849 AOI211_X4
* cell instance $15570 m0 *1 160.36,29.4
X$15570 1493 1188 1264 15 27 1494 MUX2_X1
* cell instance $15578 r0 *1 155.8,29.4
X$15578 1186 1650 15 27 1590 NOR2_X1
* cell instance $15582 r0 *1 157.7,29.4
X$15582 1647 1588 15 27 1186 NAND2_X2
* cell instance $15583 r0 *1 158.65,29.4
X$15583 1588 1647 27 15 1265 AND2_X1
* cell instance $15596 r0 *1 126.35,1.4
X$15596 64 32 31 15 27 28 NOR3_X1
* cell instance $15613 m0 *1 2.66,144.2
X$15613 8047 15 27 7998 BUF_X1
* cell instance $15615 m0 *1 3.23,144.2
X$15615 8002 15 27 7849 BUF_X1
* cell instance $15616 m0 *1 3.8,144.2
X$15616 7921 15 27 7999 BUF_X1
* cell instance $15618 m0 *1 4.56,144.2
X$15618 7921 7850 15 27 8000 NAND2_X1
* cell instance $15619 m0 *1 5.13,144.2
X$15619 7441 8000 8049 15 8045 27 AOI21_X1
* cell instance $15622 m0 *1 7.6,144.2
X$15622 8047 7850 15 27 8001 NAND2_X1
* cell instance $15624 m0 *1 8.36,144.2
X$15624 7441 8001 7853 15 8142 27 AOI21_X1
* cell instance $15626 m0 *1 9.88,144.2
X$15626 7863 7854 15 27 8049 NAND2_X1
* cell instance $15636 r0 *1 4.37,144.2
X$15636 15 10546 8047 8142 8098 27 DFF_X1
* cell instance $15639 r0 *1 9.5,144.2
X$15639 7428 7854 15 27 8609 NAND2_X1
* cell instance $15641 r0 *1 10.45,144.2
X$15641 15 10608 7852 8052 8098 27 DFF_X1
* cell instance $15642 m0 *1 11.02,144.2
X$15642 15 10375 8002 8054 7537 27 DFF_X1
* cell instance $15644 m0 *1 14.25,144.2
X$15644 8002 7924 15 27 8003 NAND2_X1
* cell instance $15646 m0 *1 15.01,144.2
X$15646 8060 8003 8055 15 8054 27 AOI21_X1
* cell instance $15649 m0 *1 19,144.2
X$15649 15 10385 7805 8065 7537 27 DFF_X1
* cell instance $15651 m0 *1 22.42,144.2
X$15651 7650 6397 7196 5849 8004 8067 15 27 OAI221_X2
* cell instance $15652 m0 *1 24.51,144.2
X$15652 15 8067 7901 10690 7863 27 DFF_X2
* cell instance $15653 m0 *1 28.12,144.2
X$15653 15 8068 7901 10687 7279 27 DFF_X2
* cell instance $15657 r0 *1 14.44,144.2
X$15657 8060 7925 8085 15 8052 27 AOI21_X1
* cell instance $15661 r0 *1 19.95,144.2
X$15661 8099 7805 15 27 8157 NAND2_X2
* cell instance $15665 r0 *1 22.23,144.2
X$15665 6718 7931 15 27 8055 NAND2_X1
* cell instance $15666 r0 *1 22.8,144.2
X$15666 7863 8099 15 8004 27 NAND2_X4
* cell instance $15669 r0 *1 26.79,144.2
X$15669 7525 15 27 7901 CLKBUF_X3
* cell instance $15670 r0 *1 27.74,144.2
X$15670 7901 15 27 CLKBUF_X1
* cell instance $15671 r0 *1 28.31,144.2
X$15671 8160 7278 8100 15 27 7501 MUX2_X1
* cell instance $15672 r0 *1 29.64,144.2
X$15672 5213 7668 8005 15 27 8160 MUX2_X1
* cell instance $15673 r0 *1 30.97,144.2
X$15673 5213 7448 8005 15 27 8101 MUX2_X1
* cell instance $15675 m0 *1 33.82,144.2
X$15675 8006 7971 7658 27 15 6136 MUX2_X2
* cell instance $15679 m0 *1 38.76,144.2
X$15679 7805 8075 5308 15 27 8077 MUX2_X1
* cell instance $15680 m0 *1 40.09,144.2
X$15680 8007 7914 6718 15 27 8076 MUX2_X1
* cell instance $15681 m0 *1 41.42,144.2
X$15681 8076 7281 7977 15 27 8083 MUX2_X1
* cell instance $15684 m0 *1 45.03,144.2
X$15684 7893 7275 5312 15 27 8081 MUX2_X1
* cell instance $15685 m0 *1 46.36,144.2
X$15685 8105 8008 6886 15 27 8079 MUX2_X1
* cell instance $15686 m0 *1 47.69,144.2
X$15686 8079 7278 8081 15 27 8082 MUX2_X1
* cell instance $15688 m0 *1 49.78,144.2
X$15688 8011 8082 7282 27 15 5798 MUX2_X2
* cell instance $15692 r0 *1 36.1,144.2
X$15692 7006 7548 8166 15 27 8102 MUX2_X1
* cell instance $15693 r0 *1 37.43,144.2
X$15693 7006 8103 8166 15 27 8167 MUX2_X1
* cell instance $15696 r0 *1 39.33,144.2
X$15696 8167 7605 15 27 8104 NOR2_X1
* cell instance $15699 r0 *1 40.47,144.2
X$15699 8007 8075 6718 15 27 8168 MUX2_X1
* cell instance $15702 r0 *1 42.37,144.2
X$15702 8168 7938 8077 15 27 8169 MUX2_X1
* cell instance $15706 r0 *1 46.17,144.2
X$15706 7893 7984 5312 15 27 8172 MUX2_X1
* cell instance $15707 r0 *1 47.5,144.2
X$15707 5126 8008 8009 15 27 8010 MUX2_X1
* cell instance $15708 r0 *1 48.83,144.2
X$15708 8010 7278 8274 15 27 8011 MUX2_X1
* cell instance $15711 r0 *1 51.3,144.2
X$15711 5126 7984 8009 15 27 8175 MUX2_X1
* cell instance $15714 m0 *1 53.58,144.2
X$15714 8013 8083 7282 27 15 5703 MUX2_X2
* cell instance $15718 r0 *1 53.58,144.2
X$15718 7271 27 7931 15 BUF_X4
* cell instance $15719 r0 *1 54.91,144.2
X$15719 6628 7448 8014 15 27 8174 MUX2_X1
* cell instance $15720 r0 *1 56.24,144.2
X$15720 8174 7340 15 27 8106 NOR2_X2
* cell instance $15722 m0 *1 56.43,144.2
X$15722 6628 7452 8014 15 27 8177 MUX2_X1
* cell instance $15724 m0 *1 59.47,144.2
X$15724 7040 7931 15 27 8085 NAND2_X1
* cell instance $15727 m0 *1 61.75,144.2
X$15727 7177 8019 7040 15 27 8088 MUX2_X1
* cell instance $15728 m0 *1 63.08,144.2
X$15728 7657 8019 5337 15 27 8180 MUX2_X1
* cell instance $15729 m0 *1 64.41,144.2
X$15729 8012 27 7605 15 BUF_X4
* cell instance $15730 m0 *1 65.74,144.2
X$15730 15 5978 8015 8016 7988 27 AOI21_X4
* cell instance $15731 m0 *1 68.21,144.2
X$15731 15 8016 27 6871 BUF_X8
* cell instance $15734 r0 *1 57.38,144.2
X$15734 8177 7450 8204 15 27 7632 MUX2_X1
* cell instance $15735 r0 *1 58.71,144.2
X$15735 8175 8012 15 27 8281 NOR2_X1
* cell instance $15742 r0 *1 61.94,144.2
X$15742 6117 27 7984 15 BUF_X4
* cell instance $15744 r0 *1 63.46,144.2
X$15744 8088 8090 8180 15 27 8179 MUX2_X1
* cell instance $15746 r0 *1 64.98,144.2
X$15746 15 6252 8181 6871 8089 27 AOI21_X4
* cell instance $15748 r0 *1 67.64,144.2
X$15748 8207 27 7908 15 BUF_X4
* cell instance $15749 r0 *1 68.97,144.2
X$15749 15 6424 8110 7992 8179 27 AOI21_X4
* cell instance $15750 m0 *1 71.63,144.2
X$15750 15 5675 8092 27 BUF_X16
* cell instance $15751 m0 *1 71.06,144.2
X$15751 7989 15 27 7933 BUF_X1
* cell instance $15753 r0 *1 71.44,144.2
X$15753 15 8092 7989 27 BUF_X16
* cell instance $15754 r0 *1 76.19,144.2
X$15754 7552 27 8012 15 BUF_X4
* cell instance $15755 m0 *1 78.09,144.2
X$15755 7993 8017 8096 15 27 8018 MUX2_X1
* cell instance $15756 m0 *1 76.76,144.2
X$15756 8095 7908 7936 15 27 8096 MUX2_X1
* cell instance $15757 m0 *1 79.42,144.2
X$15757 5450 8019 8020 15 27 8094 MUX2_X1
* cell instance $15759 m0 *1 81.51,144.2
X$15759 8018 7992 8093 15 27 7394 MUX2_X1
* cell instance $15760 m0 *1 82.84,144.2
X$15760 8094 8017 15 27 8115 NOR2_X1
* cell instance $15763 m0 *1 84.36,144.2
X$15763 7173 7915 7386 15 27 8091 MUX2_X1
* cell instance $15764 m0 *1 85.69,144.2
X$15764 7995 7858 8091 15 27 7939 MUX2_X1
* cell instance $15766 m0 *1 88.54,144.2
X$15766 8118 7940 8016 27 8087 15 NOR3_X2
* cell instance $15770 m0 *1 95.19,144.2
X$15770 7097 7934 8122 15 27 8025 MUX2_X1
* cell instance $15771 m0 *1 96.52,144.2
X$15771 8025 7278 8026 15 27 7916 MUX2_X1
* cell instance $15772 m0 *1 97.85,144.2
X$15772 15 7158 8087 8023 8086 27 AOI21_X4
* cell instance $15776 m0 *1 102.79,144.2
X$15776 8028 8022 6223 15 27 7990 MUX2_X1
* cell instance $15777 m0 *1 104.12,144.2
X$15777 8028 7447 6223 15 27 8029 MUX2_X1
* cell instance $15778 m0 *1 105.45,144.2
X$15778 8029 7605 7942 15 27 8084 MUX2_X1
* cell instance $15779 m0 *1 106.78,144.2
X$15779 8030 7671 15 27 7943 NAND2_X2
* cell instance $15780 m0 *1 107.73,144.2
X$15780 15 7944 8288 10671 8030 27 DFF_X2
* cell instance $15783 m0 *1 114.57,144.2
X$15783 8031 7857 6738 15 27 7982 MUX2_X1
* cell instance $15784 m0 *1 115.9,144.2
X$15784 8176 7605 8032 15 27 8080 MUX2_X1
* cell instance $15788 m0 *1 121.22,144.2
X$15788 7254 7734 7513 15 27 8078 MUX2_X1
* cell instance $15789 m0 *1 122.55,144.2
X$15789 7946 8017 8078 15 27 8034 MUX2_X1
* cell instance $15791 m0 *1 124.07,144.2
X$15791 8280 15 27 7561 CLKBUF_X3
* cell instance $15792 m0 *1 125.02,144.2
X$15792 15 7568 7911 7992 7979 27 AOI21_X4
* cell instance $15794 m0 *1 128.25,144.2
X$15794 6901 7757 7563 15 27 8036 MUX2_X1
* cell instance $15797 m0 *1 132.81,144.2
X$15797 15 7130 8073 8016 7972 27 AOI21_X4
* cell instance $15799 m0 *1 136.04,144.2
X$15799 8069 6063 15 27 8038 NAND2_X1
* cell instance $15800 m0 *1 136.61,144.2
X$15800 8228 8038 7903 15 8070 27 AOI21_X1
* cell instance $15801 m0 *1 137.37,144.2
X$15801 15 10308 8069 8070 7162 27 DFF_X1
* cell instance $15806 m0 *1 146.11,144.2
X$15806 6700 27 6990 15 BUF_X4
* cell instance $15807 m0 *1 147.44,144.2
X$15807 6700 7568 15 27 7880 OR2_X2
* cell instance $15808 m0 *1 148.39,144.2
X$15808 6700 7076 15 27 7950 OR2_X2
* cell instance $15810 r0 *1 77.52,144.2
X$15810 8012 27 8090 15 BUF_X4
* cell instance $15812 r0 *1 79.04,144.2
X$15812 5450 8022 8020 15 27 8021 MUX2_X1
* cell instance $15813 r0 *1 80.37,144.2
X$15813 8021 7281 8113 15 27 7641 MUX2_X1
* cell instance $15816 r0 *1 82.27,144.2
X$15816 15 8016 8115 8185 7911 27 NOR3_X4
* cell instance $15819 r0 *1 86.07,144.2
X$15819 15 7969 8116 7435 8184 27 AOI21_X4
* cell instance $15821 r0 *1 88.92,144.2
X$15821 15 7347 27 8023 BUF_X8
* cell instance $15822 r0 *1 91.39,144.2
X$15822 7053 7668 8119 15 27 8024 MUX2_X1
* cell instance $15823 r0 *1 92.72,144.2
X$15823 8024 7278 8121 15 27 7871 MUX2_X1
* cell instance $15827 r0 *1 95.38,144.2
X$15827 7097 7762 8122 15 27 8183 MUX2_X1
* cell instance $15830 r0 *1 97.28,144.2
X$15830 8183 8017 15 27 8027 NOR2_X1
* cell instance $15831 r0 *1 97.85,144.2
X$15831 8123 8027 8016 27 8033 15 NOR3_X2
* cell instance $15834 r0 *1 106.02,144.2
X$15834 15 6906 8214 8084 7435 27 AOI21_X4
* cell instance $15839 r0 *1 114,144.2
X$15839 8286 8178 7658 27 15 6338 MUX2_X2
* cell instance $15843 r0 *1 115.71,144.2
X$15843 6832 8103 7558 15 27 8032 MUX2_X1
* cell instance $15844 r0 *1 117.04,144.2
X$15844 8220 8080 8023 27 15 7303 MUX2_X2
* cell instance $15847 r0 *1 119.7,144.2
X$15847 7980 8019 6480 15 27 8173 MUX2_X1
* cell instance $15851 r0 *1 122.17,144.2
X$15851 15 6904 8033 7992 8034 27 AOI21_X4
* cell instance $15852 r0 *1 124.64,144.2
X$15852 7561 15 27 10848 INV_X1
* cell instance $15853 r0 *1 125.02,144.2
X$15853 6901 8075 7563 15 27 8171 MUX2_X1
* cell instance $15857 r0 *1 128.44,144.2
X$15857 8170 7654 8036 15 27 8178 MUX2_X1
* cell instance $15858 r0 *1 129.77,144.2
X$15858 7258 6224 15 27 8071 NAND2_X1
* cell instance $15860 r0 *1 130.72,144.2
X$15860 8035 7948 6699 15 27 8037 MUX2_X1
* cell instance $15861 r0 *1 132.05,144.2
X$15861 8037 8012 7780 15 27 8165 MUX2_X1
* cell instance $15863 r0 *1 133.57,144.2
X$15863 8074 8016 8165 15 7302 27 AOI21_X2
* cell instance $15864 r0 *1 134.9,144.2
X$15864 7195 6224 15 27 8162 NAND2_X1
* cell instance $15867 r0 *1 137.75,144.2
X$15867 8228 8163 8162 15 8269 27 AOI21_X1
* cell instance $15870 r0 *1 139.08,144.2
X$15870 8164 6063 15 27 8163 NAND2_X1
* cell instance $15874 r0 *1 144.97,144.2
X$15874 7880 8127 27 15 8161 XNOR2_X1
* cell instance $15875 r0 *1 146.11,144.2
X$15875 6424 7126 15 8128 27 OR2_X4
* cell instance $15877 r0 *1 148.2,144.2
X$15877 6252 7126 15 8712 27 OR2_X4
* cell instance $15878 m0 *1 149.91,144.2
X$15878 7882 7399 15 27 7966 NAND2_X1
* cell instance $15883 m0 *1 151.05,144.2
X$15883 7568 15 27 8129 INV_X1
* cell instance $15885 m0 *1 151.43,144.2
X$15885 7965 15 27 8063 INV_X1
* cell instance $15886 m0 *1 151.81,144.2
X$15886 7882 7418 15 27 8062 NAND2_X1
* cell instance $15889 r0 *1 151.24,144.2
X$15889 8129 7399 15 27 8066 NAND2_X1
* cell instance $15891 r0 *1 152.19,144.2
X$15891 15 8062 8158 8260 8066 7881 27 FA_X1
* cell instance $15892 m0 *1 152.95,144.2
X$15892 15 8061 8056 8057 8064 8063 27 FA_X1
* cell instance $15898 r0 *1 156.18,144.2
X$15898 15 7900 8039 8132 7818 8058 27 FA_X1
* cell instance $15900 m0 *1 159.6,144.2
X$15900 15 8428 7322 7962 8058 8040 27 FA_X1
* cell instance $15904 m0 *1 164.92,144.2
X$15904 15 8053 7885 8042 7682 8041 27 FA_X1
* cell instance $15907 m0 *1 175.56,144.2
X$15907 7959 8051 8140 27 15 8144 HA_X1
* cell instance $15910 r0 *1 161.12,144.2
X$15910 15 8152 8059 8154 8057 8156 27 FA_X1
* cell instance $15911 r0 *1 164.16,144.2
X$15911 8154 15 27 8150 INV_X1
* cell instance $15913 r0 *1 164.92,144.2
X$15913 8153 8056 8151 27 15 8041 HA_X1
* cell instance $15915 r0 *1 167.2,144.2
X$15915 15 8149 8053 8250 8151 7951 27 FA_X1
* cell instance $15917 r0 *1 170.43,144.2
X$15917 8043 15 27 8149 INV_X1
* cell instance $15923 r0 *1 171.38,144.2
X$15923 15 8145 8043 8134 8147 8146 27 FA_X1
* cell instance $15926 r0 *1 174.99,144.2
X$15926 15 8144 8145 8434 8050 7952 27 FA_X1
* cell instance $15927 m0 *1 180.88,144.2
X$15927 15 8046 8143 8248 7890 8048 27 FA_X1
* cell instance $15928 m0 *1 177.84,144.2
X$15928 15 7953 8135 8050 8137 8044 27 FA_X1
* cell instance $15933 r0 *1 178.22,144.2
X$15933 8136 8143 8051 27 15 8044 HA_X1
* cell instance $15934 r0 *1 180.12,144.2
X$15934 8141 15 27 8137 INV_X1
* cell instance $15938 r0 *1 181.83,144.2
X$15938 15 7588 8141 8138 8139 8133 27 FA_X1
* cell instance $15939 r0 *1 184.87,144.2
X$15939 7887 15 27 8238 INV_X1
* cell instance $15944 m0 *1 1.33,110.6
X$15944 6198 15 27 6130 BUF_X1
* cell instance $15948 m0 *1 5.13,110.6
X$15948 6239 15 27 6131 BUF_X1
* cell instance $15954 r0 *1 2.47,110.6
X$15954 6195 15 27 6197 BUF_X2
* cell instance $15960 r0 *1 6.46,110.6
X$15960 6194 15 27 6237 BUF_X2
* cell instance $15961 m0 *1 10.07,110.6
X$15961 6239 5184 15 27 6199 NAND2_X1
* cell instance $15962 m0 *1 6.84,110.6
X$15962 15 10344 6239 6164 5995 27 DFF_X1
* cell instance $15963 m0 *1 10.64,110.6
X$15963 5687 6199 6241 15 6164 27 AOI21_X1
* cell instance $15964 m0 *1 11.4,110.6
X$15964 6198 5184 15 27 6243 NAND2_X1
* cell instance $15967 r0 *1 7.22,110.6
X$15967 15 10520 6198 6238 6388 27 DFF_X1
* cell instance $15970 r0 *1 11.59,110.6
X$15970 5687 6243 6200 15 6238 27 AOI21_X1
* cell instance $15973 r0 *1 13.49,110.6
X$15973 6245 5519 15 27 6200 NAND2_X1
* cell instance $15975 m0 *1 13.87,110.6
X$15975 15 6024 5995 10694 6027 27 DFF_X2
* cell instance $15981 r0 *1 19.38,110.6
X$15981 15 5743 27 6248 BUF_X8
* cell instance $15983 m0 *1 20.14,110.6
X$15983 6132 6201 5939 5492 6250 5940 15 27 OAI221_X2
* cell instance $15984 r0 *1 21.85,110.6
X$15984 5521 6170 15 6250 27 NAND2_X4
* cell instance $15985 m0 *1 24.7,110.6
X$15985 5186 6170 15 6173 27 NAND2_X4
* cell instance $15986 m0 *1 22.61,110.6
X$15986 6132 6133 5939 6134 6173 6172 15 27 OAI221_X2
* cell instance $15990 m0 *1 31.73,110.6
X$15990 5279 5315 5838 6135 15 27 6187 NOR4_X1
* cell instance $15992 m0 *1 32.87,110.6
X$15992 5188 6135 10874 27 15 6098 HA_X1
* cell instance $15994 m0 *1 34.96,110.6
X$15994 5188 6136 10868 27 15 5945 HA_X1
* cell instance $15996 m0 *1 37.05,110.6
X$15996 6254 6039 27 6317 15 XOR2_X2
* cell instance $15997 m0 *1 38.76,110.6
X$15997 5943 6035 5947 27 5864 15 OAI21_X1
* cell instance $15998 m0 *1 39.52,110.6
X$15998 5280 6136 5947 27 15 6106 HA_X1
* cell instance $15999 m0 *1 41.42,110.6
X$15999 6011 6041 27 6262 15 XOR2_X2
* cell instance $16003 r0 *1 28.12,110.6
X$16003 6177 27 6133 15 BUF_X4
* cell instance $16004 r0 *1 29.45,110.6
X$16004 5693 27 6132 15 BUF_X4
* cell instance $16005 r0 *1 30.78,110.6
X$16005 15 5691 6170 27 BUF_X16
* cell instance $16007 r0 *1 36.29,110.6
X$16007 5842 27 6032 15 BUF_X4
* cell instance $16008 r0 *1 37.62,110.6
X$16008 6316 6033 6044 27 6202 15 NOR3_X2
* cell instance $16009 r0 *1 38.95,110.6
X$16009 6034 15 27 6254 BUF_X1
* cell instance $16011 r0 *1 39.9,110.6
X$16011 6396 6037 6038 15 6389 27 NAND3_X4
* cell instance $16014 m0 *1 43.51,110.6
X$16014 6137 6041 6182 15 6184 27 AOI21_X2
* cell instance $16016 r0 *1 44.08,110.6
X$16016 5434 6136 6040 5952 15 27 6203 NOR4_X1
* cell instance $16017 r0 *1 45.03,110.6
X$16017 5798 5537 5363 5281 15 27 6264 NOR4_X1
* cell instance $16019 m0 *1 45.22,110.6
X$16019 6187 6203 6192 6264 15 27 6189 NAND4_X1
* cell instance $16021 m0 *1 46.74,110.6
X$16021 5952 6189 6263 27 15 6190 HA_X1
* cell instance $16023 m0 *1 48.64,110.6
X$16023 6042 15 27 6275 BUF_X1
* cell instance $16025 m0 *1 49.78,110.6
X$16025 15 5821 5863 6193 6115 5799 27 AOI22_X4
* cell instance $16031 m0 *1 53.58,110.6
X$16031 6184 6138 15 27 6274 XNOR2_X2
* cell instance $16034 r0 *1 53.39,110.6
X$16034 6043 5626 6044 27 6318 15 NOR3_X2
* cell instance $16037 r0 *1 55.29,110.6
X$16037 15 6030 6237 6277 5918 5872 27 AOI22_X4
* cell instance $16039 m0 *1 55.86,110.6
X$16039 6263 5188 6274 15 6204 27 NAND3_X4
* cell instance $16041 m0 *1 62.13,110.6
X$16041 6139 15 27 6140 INV_X4
* cell instance $16044 m0 *1 64.03,110.6
X$16044 6140 6205 6204 27 15 6191 OAI21_X4
* cell instance $16048 m0 *1 71.25,110.6
X$16048 6281 5877 6046 27 6548 15 NOR3_X2
* cell instance $16049 m0 *1 72.58,110.6
X$16049 15 6188 5877 6281 6403 27 NOR3_X4
* cell instance $16053 r0 *1 58.9,110.6
X$16053 15 6382 6276 6383 6115 6275 27 AOI22_X4
* cell instance $16059 r0 *1 62.7,110.6
X$16059 5928 6204 27 6139 15 AND2_X4
* cell instance $16060 r0 *1 64.41,110.6
X$16060 6140 6204 6205 27 15 6964 OAI21_X4
* cell instance $16064 r0 *1 71.06,110.6
X$16064 15 5229 6185 10750 6206 27 DFF_X2
* cell instance $16067 m0 *1 77.14,110.6
X$16067 5959 6183 6186 15 27 6208 MUX2_X1
* cell instance $16070 m0 *1 153.33,186.2
X$16070 9242 15 27 10100 BUF_X1
* cell instance $16072 m0 *1 153.9,186.2
X$16072 8853 15 27 10284 BUF_X1
* cell instance $16082 m0 *1 152.19,186.2
X$16082 9431 15 27 10102 BUF_X1
* cell instance $16083 r0 *1 152.19,186.2
X$16083 8371 15 27 10130 BUF_X1
* cell instance $16086 r0 *1 153.71,186.2
X$16086 9409 15 27 10127 BUF_X1
* cell instance $16099 m0 *1 1.33,119
X$16099 6615 15 27 6526 BUF_X1
* cell instance $16102 m0 *1 2.66,119
X$16102 6530 15 27 6527 BUF_X1
* cell instance $16103 m0 *1 3.23,119
X$16103 6617 15 27 6613 BUF_X1
* cell instance $16105 m0 *1 4.56,119
X$16105 6616 15 27 6614 BUF_X1
* cell instance $16106 m0 *1 5.13,119
X$16106 6616 6531 15 27 6707 NAND2_X1
* cell instance $16110 r0 *1 2.09,119
X$16110 15 10489 6616 6706 6388 27 DFF_X1
* cell instance $16114 r0 *1 5.32,119
X$16114 6529 6707 6709 15 6706 27 AOI21_X1
* cell instance $16116 m0 *1 6.08,119
X$16116 6523 15 27 6388 CLKBUF_X3
* cell instance $16117 m0 *1 8.55,119
X$16117 6617 6531 15 27 6667 NAND2_X1
* cell instance $16118 m0 *1 9.12,119
X$16118 6529 6667 6998 15 6643 27 AOI21_X1
* cell instance $16120 m0 *1 15.96,119
X$16120 6390 6713 15 27 6668 NAND2_X2
* cell instance $16123 r0 *1 6.08,119
X$16123 6708 15 27 6666 BUF_X1
* cell instance $16126 r0 *1 14.25,119
X$16126 6540 6025 5937 6670 6668 6779 15 27 OAI221_X2
* cell instance $16127 r0 *1 16.34,119
X$16127 15 6025 27 6712 BUF_X8
* cell instance $16128 m0 *1 20.14,119
X$16128 15 5747 27 6712 BUF_X8
* cell instance $16129 m0 *1 18.05,119
X$16129 6649 5747 5830 6682 6783 6648 15 27 OAI221_X2
* cell instance $16130 m0 *1 22.61,119
X$16130 6718 5909 15 6671 27 NAND2_X4
* cell instance $16131 m0 *1 24.32,119
X$16131 5401 5909 15 6719 27 NAND2_X4
* cell instance $16134 m0 *1 29.26,119
X$16134 6534 6510 6724 6029 6536 27 15 6672 OAI221_X1
* cell instance $16135 m0 *1 30.4,119
X$16135 6538 6673 15 27 6724 NAND2_X1
* cell instance $16138 r0 *1 18.81,119
X$16138 15 6648 6436 10787 5308 27 DFF_X2
* cell instance $16140 r0 *1 22.61,119
X$16140 6132 6540 5939 6670 6719 6669 15 27 OAI221_X2
* cell instance $16142 r0 *1 25.46,119
X$16142 6132 6649 5692 6682 6671 6786 15 27 OAI221_X2
* cell instance $16145 r0 *1 28.5,119
X$16145 15 6672 6537 10796 6673 27 DFF_X2
* cell instance $16149 m0 *1 34.58,119
X$16149 5793 6619 6728 15 27 6675 MUX2_X1
* cell instance $16151 m0 *1 35.91,119
X$16151 5694 6619 6730 15 27 6676 MUX2_X1
* cell instance $16153 m0 *1 40.28,119
X$16153 5859 6619 6620 15 27 6679 MUX2_X1
* cell instance $16155 r0 *1 34.58,119
X$16155 5690 6619 6618 15 27 6733 MUX2_X1
* cell instance $16156 r0 *1 35.91,119
X$16156 6674 6675 6731 5791 6729 27 15 6732 OAI221_X1
* cell instance $16157 r0 *1 37.05,119
X$16157 6626 6677 15 27 6731 NAND2_X1
* cell instance $16160 m0 *1 42.18,119
X$16160 6397 6619 6734 15 27 6736 MUX2_X1
* cell instance $16162 m0 *1 43.51,119
X$16162 6132 6193 5692 6623 6680 6621 15 27 OAI221_X2
* cell instance $16165 m0 *1 47.31,119
X$16165 6193 6544 6622 15 27 6681 MUX2_X1
* cell instance $16166 m0 *1 48.64,119
X$16166 6534 6681 6739 6623 6536 27 15 6625 OAI221_X1
* cell instance $16173 r0 *1 43.51,119
X$16173 5222 5909 15 6680 27 NAND2_X4
* cell instance $16177 r0 *1 48.83,119
X$16177 15 6625 6810 10757 6741 27 DFF_X2
* cell instance $16179 m0 *1 54.15,119
X$16179 6626 27 6538 15 BUF_X4
* cell instance $16181 m0 *1 55.48,119
X$16181 15 6627 6471 10685 6628 27 DFF_X2
* cell instance $16186 m0 *1 67.64,119
X$16186 6630 6683 6323 27 15 6544 MUX2_X2
* cell instance $16188 m0 *1 70.11,119
X$16188 6684 6685 15 6146 27 NAND2_X4
* cell instance $16189 m0 *1 71.82,119
X$16189 6685 6684 27 15 6609 AND2_X1
* cell instance $16192 r0 *1 55.67,119
X$16192 6674 15 27 6534 CLKBUF_X3
* cell instance $16195 r0 *1 57.76,119
X$16195 6609 6191 27 15 6674 AND2_X2
* cell instance $16202 r0 *1 68.21,119
X$16202 6630 6683 6323 27 15 6619 MUX2_X2
* cell instance $16203 r0 *1 69.92,119
X$16203 5510 6401 6685 15 5692 27 NAND3_X4
* cell instance $16204 r0 *1 72.39,119
X$16204 6401 5510 6685 27 15 6686 AND3_X1
* cell instance $16206 m0 *1 72.96,119
X$16206 6403 6629 6402 15 27 6683 NAND3_X2
* cell instance $16208 m0 *1 74.86,119
X$16208 6207 5802 5929 15 27 6630 NAND3_X2
* cell instance $16210 m0 *1 76.19,119
X$16210 6630 6683 6687 27 15 6688 MUX2_X2
* cell instance $16211 m0 *1 77.9,119
X$16211 15 6662 6687 27 BUF_X16
* cell instance $16212 m0 *1 82.65,119
X$16212 15 6606 6633 27 BUF_X32
* cell instance $16213 m0 *1 91.96,119
X$16213 6475 5673 15 27 6752 NAND2_X1
* cell instance $16217 m0 *1 95,119
X$16217 15 6691 6632 6826 6555 6556 27 AOI22_X4
* cell instance $16222 r0 *1 76.19,119
X$16222 6630 6683 6687 27 15 6385 MUX2_X2
* cell instance $16223 r0 *1 77.9,119
X$16223 6609 6405 27 6209 15 AND2_X4
* cell instance $16224 r0 *1 79.61,119
X$16224 6631 6474 6748 15 27 6760 MUX2_X1
* cell instance $16226 r0 *1 81.7,119
X$16226 6749 6282 6431 6314 15 27 6748 AOI22_X1
* cell instance $16228 r0 *1 83.41,119
X$16228 15 6474 27 6385 BUF_X8
* cell instance $16230 r0 *1 86.07,119
X$16230 6689 6688 6552 15 27 6799 MUX2_X1
* cell instance $16233 r0 *1 89.11,119
X$16233 6013 6688 6750 15 27 6751 MUX2_X1
* cell instance $16236 r0 *1 91.58,119
X$16236 5925 6146 6751 6142 6874 6690 15 27 OAI221_X2
* cell instance $16240 r0 *1 96.33,119
X$16240 6212 6634 6797 6213 5939 27 15 6692 OAI221_X1
* cell instance $16243 m0 *1 1.9,77
X$16243 4696 15 27 4088 BUF_X1
* cell instance $16246 m0 *1 2.66,77
X$16246 4336 15 27 4208 BUF_X1
* cell instance $16256 m0 *1 5.7,77
X$16256 4010 3086 15 27 4342 NOR2_X1
* cell instance $16257 m0 *1 5.13,77
X$16257 5053 15 27 4207 BUF_X1
* cell instance $16260 m0 *1 7.98,77
X$16260 15 3049 4158 4092 4342 4209 27 NOR4_X4
* cell instance $16261 m0 *1 7.41,77
X$16261 4606 15 27 4087 BUF_X1
* cell instance $16262 m0 *1 11.4,77
X$16262 4092 4158 3574 3462 27 4288 15 NOR4_X2
* cell instance $16265 r0 *1 8.17,77
X$16265 4158 3262 15 27 4427 NAND2_X2
* cell instance $16266 r0 *1 9.12,77
X$16266 4698 15 27 4089 BUF_X1
* cell instance $16268 r0 *1 10.07,77
X$16268 15 3574 4158 4092 3931 27 NOR3_X4
* cell instance $16269 r0 *1 12.73,77
X$16269 4092 4158 15 27 4551 NOR2_X2
* cell instance $16270 m0 *1 15.39,77
X$16270 4209 4210 4094 4012 27 15 4289 AND4_X1
* cell instance $16271 m0 *1 13.49,77
X$16271 3462 4093 15 27 4268 XNOR2_X2
* cell instance $16272 m0 *1 16.53,77
X$16272 3633 4211 15 27 4349 OR2_X1
* cell instance $16274 r0 *1 13.68,77
X$16274 3463 4288 3874 15 4290 27 AOI21_X2
* cell instance $16276 r0 *1 15.39,77
X$16276 4349 4431 4289 27 15 4376 OAI21_X2
* cell instance $16277 r0 *1 16.72,77
X$16277 4211 3633 15 27 4431 NAND2_X1
* cell instance $16279 m0 *1 1.33,121.8
X$16279 6776 15 27 6753 BUF_X1
* cell instance $16285 r0 *1 1.9,121.8
X$16285 6850 15 27 6803 BUF_X1
* cell instance $16286 m0 *1 5.51,121.8
X$16286 6776 6531 15 27 6754 NAND2_X1
* cell instance $16287 m0 *1 2.28,121.8
X$16287 15 10322 6776 6775 6388 27 DFF_X1
* cell instance $16288 m0 *1 6.08,121.8
X$16288 6529 6754 7069 15 6775 27 AOI21_X1
* cell instance $16291 r0 *1 2.85,121.8
X$16291 6805 15 27 6804 BUF_X1
* cell instance $16297 r0 *1 5.13,121.8
X$16297 6850 6531 15 27 6918 NAND2_X1
* cell instance $16300 m0 *1 7.79,121.8
X$16300 15 10358 6708 6879 6388 27 DFF_X1
* cell instance $16301 m0 *1 7.22,121.8
X$16301 6708 6531 15 27 6877 NAND2_X1
* cell instance $16305 r0 *1 7.6,121.8
X$16305 15 10500 6805 6878 6852 27 DFF_X1
* cell instance $16306 r0 *1 10.83,121.8
X$16306 6805 6531 15 27 6806 NAND2_X1
* cell instance $16308 m0 *1 13.87,121.8
X$16308 15 6779 6852 10728 6713 27 DFF_X2
* cell instance $16310 m0 *1 17.48,121.8
X$16310 6713 5519 15 27 6853 NAND2_X1
* cell instance $16312 m0 *1 18.24,121.8
X$16312 5308 6390 15 27 6783 NAND2_X1
* cell instance $16317 m0 *1 25.08,121.8
X$16317 15 6786 6537 10650 6718 27 DFF_X2
* cell instance $16318 m0 *1 21.47,121.8
X$16318 15 6669 6436 10697 5401 27 DFF_X2
* cell instance $16321 m0 *1 30.4,121.8
X$16321 6537 15 27 10842 INV_X1
* cell instance $16322 m0 *1 30.78,121.8
X$16322 6523 15 27 6537 CLKBUF_X3
* cell instance $16323 m0 *1 31.73,121.8
X$16323 6534 6589 6791 6389 6536 27 15 6790 OAI221_X1
* cell instance $16324 m0 *1 32.87,121.8
X$16324 6755 6925 15 27 6791 NAND2_X1
* cell instance $16329 r0 *1 26.79,121.8
X$16329 6248 6026 15 27 6857 NAND2_X1
* cell instance $16330 r0 *1 27.36,121.8
X$16330 5791 5830 6857 5793 6712 27 15 6923 OAI221_X1
* cell instance $16331 r0 *1 28.5,121.8
X$16331 5354 15 27 6523 CLKBUF_X3
* cell instance $16332 r0 *1 29.45,121.8
X$16332 6523 15 27 10824 INV_X2
* cell instance $16335 r0 *1 30.97,121.8
X$16335 15 6790 6537 10738 6925 27 DFF_X2
* cell instance $16337 m0 *1 34.77,121.8
X$16337 15 10408 6677 6732 6537 27 DFF_X1
* cell instance $16343 r0 *1 38.76,121.8
X$16343 15 6807 6810 10751 6864 27 DFF_X2
* cell instance $16344 m0 *1 40.28,121.8
X$16344 6755 6864 15 27 6793 NAND2_X1
* cell instance $16345 m0 *1 39.14,121.8
X$16345 6534 6678 6793 6670 6536 27 15 6807 OAI221_X1
* cell instance $16347 m0 *1 41.42,121.8
X$16347 6674 6679 6932 5860 6536 27 15 7034 OAI221_X1
* cell instance $16351 m0 *1 43.13,121.8
X$16351 6132 6394 5939 6542 6808 7008 15 27 OAI221_X2
* cell instance $16353 m0 *1 45.22,121.8
X$16353 6674 6736 6935 5849 6536 27 15 6809 OAI221_X1
* cell instance $16356 r0 *1 43.51,121.8
X$16356 6170 6886 15 6808 27 NAND2_X4
* cell instance $16358 r0 *1 45.98,121.8
X$16358 15 6755 27 6626 BUF_X8
* cell instance $16359 m0 *1 46.93,121.8
X$16359 6755 6741 15 27 6739 NAND2_X1
* cell instance $16361 m0 *1 47.5,121.8
X$16361 6811 6755 15 6795 27 NAND2_X4
* cell instance $16362 m0 *1 49.21,121.8
X$16362 6682 6536 6624 6534 6795 6867 15 27 OAI221_X2
* cell instance $16365 m0 *1 53.58,121.8
X$16365 6398 6132 6796 27 6868 15 OAI21_X1
* cell instance $16367 m0 *1 55.86,121.8
X$16367 6812 5691 5869 6686 15 27 6796 AOI22_X1
* cell instance $16371 r0 *1 48.45,121.8
X$16371 15 6867 6810 10755 6811 27 DFF_X2
* cell instance $16374 r0 *1 53.01,121.8
X$16374 15 10470 6812 6868 6810 27 DFF_X1
* cell instance $16377 r0 *1 57.95,121.8
X$16377 6146 15 27 6729 CLKBUF_X3
* cell instance $16382 m0 *1 59.66,121.8
X$16382 6756 6813 15 27 5693 NAND2_X2
* cell instance $16384 m0 *1 60.61,121.8
X$16384 6191 6686 15 27 6756 NAND2_X2
* cell instance $16385 m0 *1 61.56,121.8
X$16385 6800 15 27 6813 INV_X2
* cell instance $16387 m0 *1 62.32,121.8
X$16387 6380 6756 6870 15 27 6798 MUX2_X1
* cell instance $16388 m0 *1 63.65,121.8
X$16388 15 6798 7042 10717 5424 27 DFF_X2
* cell instance $16392 r0 *1 59.85,121.8
X$16392 6756 6961 6800 15 27 5691 AND3_X4
* cell instance $16394 r0 *1 62.13,121.8
X$16394 6813 6383 15 27 6869 NAND2_X1
* cell instance $16396 r0 *1 62.89,121.8
X$16396 6814 6869 15 27 6870 NAND2_X1
* cell instance $16398 m0 *1 68.59,121.8
X$16398 6664 27 6871 15 BUF_X4
* cell instance $16403 m0 *1 70.49,121.8
X$16403 6629 15 27 6815 INV_X1
* cell instance $16406 r0 *1 70.68,121.8
X$16406 6403 6815 6402 15 27 7186 NAND3_X2
* cell instance $16407 m0 *1 72.01,121.8
X$16407 6758 6757 6276 27 15 6800 MUX2_X2
* cell instance $16408 m0 *1 71.25,121.8
X$16408 6548 6815 6402 15 27 6757 NAND3_X1
* cell instance $16410 m0 *1 73.91,121.8
X$16410 6758 6757 6687 27 15 6759 MUX2_X2
* cell instance $16412 r0 *1 72.01,121.8
X$16412 6548 6629 6402 15 27 6816 NAND3_X1
* cell instance $16413 r0 *1 72.77,121.8
X$16413 6629 6402 15 27 6817 NOR2_X1
* cell instance $16416 r0 *1 73.91,121.8
X$16416 6892 5929 15 27 6758 NAND2_X1
* cell instance $16418 r0 *1 74.67,121.8
X$16418 6207 5802 15 27 6892 NOR2_X1
* cell instance $16420 r0 *1 75.62,121.8
X$16420 15 6873 6821 10782 6749 27 DFF_X2
* cell instance $16421 m0 *1 76.19,121.8
X$16421 6405 6686 15 27 6818 NAND2_X2
* cell instance $16426 r0 *1 79.23,121.8
X$16426 6819 6948 6760 27 15 6873 OAI21_X2
* cell instance $16427 m0 *1 79.99,121.8
X$16427 6759 15 27 6820 INV_X4
* cell instance $16429 m0 *1 80.94,121.8
X$16429 6744 6146 6801 6209 6802 6761 15 27 OAI221_X2
* cell instance $16430 m0 *1 83.03,121.8
X$16430 6759 6818 2126 15 27 6635 AND3_X4
* cell instance $16431 m0 *1 85.12,121.8
X$16431 6181 6688 6551 15 27 6801 MUX2_X1
* cell instance $16434 m0 *1 87.4,121.8
X$16434 5921 6146 6799 6209 6893 6762 15 27 OAI221_X2
* cell instance $16435 m0 *1 89.49,121.8
X$16435 6553 6688 6752 15 27 6823 MUX2_X1
* cell instance $16438 r0 *1 80.94,121.8
X$16438 6820 6518 15 27 6950 NAND2_X2
* cell instance $16439 r0 *1 81.89,121.8
X$16439 6818 6820 15 6634 27 NAND2_X4
* cell instance $16440 r0 *1 83.6,121.8
X$16440 15 6761 6821 10817 6822 27 DFF_X2
* cell instance $16441 r0 *1 87.21,121.8
X$16441 15 6762 6821 10800 6894 27 DFF_X2
* cell instance $16443 m0 *1 91.39,121.8
X$16443 15 6690 6290 10712 6824 27 DFF_X2
* cell instance $16445 m0 *1 95,121.8
X$16445 6539 6691 15 27 6875 NAND2_X1
* cell instance $16446 m0 *1 95.57,121.8
X$16446 6828 6635 15 27 6797 NAND2_X2
* cell instance $16447 m0 *1 96.52,121.8
X$16447 15 6692 6827 10677 6828 27 DFF_X2
* cell instance $16449 m0 *1 101.65,121.8
X$16449 5959 6634 6794 6214 5939 27 15 6763 OAI221_X1
* cell instance $16451 r0 *1 92.34,121.8
X$16451 6824 6895 15 6874 27 NAND2_X4
* cell instance $16454 r0 *1 94.62,121.8
X$16454 6826 6474 6875 15 27 6896 MUX2_X1
* cell instance $16455 r0 *1 95.95,121.8
X$16455 6475 6612 15 27 6825 NAND2_X1
* cell instance $16459 r0 *1 98.99,121.8
X$16459 6539 6945 15 27 6897 NAND2_X1
* cell instance $16462 r0 *1 100.51,121.8
X$16462 15 6763 6827 10745 6829 27 DFF_X2
* cell instance $16464 m0 *1 103.17,121.8
X$16464 6829 6635 15 27 6794 NAND2_X2
* cell instance $16466 m0 *1 106.4,121.8
X$16466 15 6831 6632 6764 6555 6337 27 AOI22_X4
* cell instance $16467 m0 *1 109.63,121.8
X$16467 5921 5939 6634 6689 6765 6743 15 27 OAI221_X2
* cell instance $16471 m0 *1 118.75,121.8
X$16471 6747 6562 6564 6826 6735 6563 15 27 OAI221_X2
* cell instance $16474 r0 *1 104.88,121.8
X$16474 6475 6830 15 27 6943 NAND2_X1
* cell instance $16477 r0 *1 106.4,121.8
X$16477 6475 6693 15 27 6898 NAND2_X1
* cell instance $16478 r0 *1 106.97,121.8
X$16478 6475 6831 15 27 6872 NAND2_X1
* cell instance $16479 r0 *1 107.54,121.8
X$16479 6764 6474 6872 15 27 6941 MUX2_X1
* cell instance $16481 r0 *1 109.63,121.8
X$16481 6742 6635 15 6765 27 NAND2_X4
* cell instance $16486 r0 *1 117.42,121.8
X$16486 15 6900 6737 10775 6832 27 DFF_X2
* cell instance $16488 m0 *1 121.41,121.8
X$16488 6607 6562 6564 6746 6792 6766 15 27 OAI221_X2
* cell instance $16490 m0 *1 123.5,121.8
X$16490 6696 6482 15 6792 27 NAND2_X4
* cell instance $16491 m0 *1 125.21,121.8
X$16491 6413 15 27 6737 CLKBUF_X3
* cell instance $16493 m0 *1 126.92,121.8
X$16493 6901 6224 15 27 6004 NAND2_X1
* cell instance $16494 m0 *1 127.49,121.8
X$16494 6767 6567 15 6788 27 NAND2_X4
* cell instance $16495 m0 *1 129.2,121.8
X$16495 15 6787 6062 10679 6767 27 DFF_X2
* cell instance $16497 r0 *1 121.22,121.8
X$16497 6738 6482 15 6695 27 NAND2_X4
* cell instance $16498 r0 *1 122.93,121.8
X$16498 6279 6833 15 6933 27 NAND2_X4
* cell instance $16501 r0 *1 125.78,121.8
X$16501 15 10536 6901 6902 6737 27 DFF_X1
* cell instance $16504 r0 *1 130.72,121.8
X$16504 6834 6224 15 27 5973 NAND2_X1
* cell instance $16507 m0 *1 1.33,152.6
X$16507 8498 15 27 8494 BUF_X1
* cell instance $16509 m0 *1 1.9,152.6
X$16509 8568 15 27 8493 BUF_X1
* cell instance $16512 m0 *1 4.18,152.6
X$16512 8496 15 27 8566 BUF_X1
* cell instance $16513 m0 *1 4.75,152.6
X$16513 8496 7850 15 27 8497 NAND2_X1
* cell instance $16515 m0 *1 5.51,152.6
X$16515 8189 8497 8540 15 8607 27 AOI21_X1
* cell instance $16519 r0 *1 1.52,152.6
X$16519 15 10501 8496 8607 8567 27 DFF_X1
* cell instance $16524 r0 *1 4.94,152.6
X$16524 15 10490 8660 8610 8567 27 DFF_X1
* cell instance $16525 m0 *1 7.41,152.6
X$16525 7533 15 27 7850 BUF_X2
* cell instance $16526 m0 *1 6.65,152.6
X$16526 8189 8661 8541 15 8610 27 AOI21_X1
* cell instance $16530 m0 *1 13.49,152.6
X$16530 8498 7924 15 27 8542 NAND2_X1
* cell instance $16537 r0 *1 10.83,152.6
X$16537 7309 15 27 8189 BUF_X2
* cell instance $16542 r0 *1 15.96,152.6
X$16542 7112 6540 7274 6670 8617 8569 15 27 OAI221_X2
* cell instance $16543 r0 *1 18.05,152.6
X$16543 7801 7176 15 8617 27 NAND2_X4
* cell instance $16544 m0 *1 19.19,152.6
X$16544 7754 7931 15 27 8618 NAND2_X1
* cell instance $16546 m0 *1 19.76,152.6
X$16546 8007 7176 15 8703 27 NAND2_X4
* cell instance $16547 m0 *1 21.47,152.6
X$16547 7859 7931 15 27 8621 NAND2_X1
* cell instance $16548 m0 *1 22.04,152.6
X$16548 15 10428 7859 8500 8501 27 DFF_X1
* cell instance $16551 m0 *1 26.98,152.6
X$16551 5658 7232 8502 15 27 8192 MUX2_X1
* cell instance $16552 m0 *1 28.31,152.6
X$16552 5658 7997 8502 15 27 8503 MUX2_X1
* cell instance $16553 m0 *1 29.64,152.6
X$16553 8503 7858 8626 15 27 7720 MUX2_X1
* cell instance $16556 r0 *1 19.95,152.6
X$16556 8105 7176 15 8622 27 NAND2_X4
* cell instance $16557 r0 *1 21.66,152.6
X$16557 7112 6583 7274 6542 8622 8571 15 27 OAI221_X2
* cell instance $16559 r0 *1 25.27,152.6
X$16559 8624 7232 8570 15 27 8625 MUX2_X1
* cell instance $16560 r0 *1 26.6,152.6
X$16560 8624 7997 8570 15 27 8626 MUX2_X1
* cell instance $16564 r0 *1 30.02,152.6
X$16564 8705 7857 8572 15 27 8629 MUX2_X1
* cell instance $16565 r0 *1 31.35,152.6
X$16565 6925 7857 8551 15 27 8574 MUX2_X1
* cell instance $16566 m0 *1 31.54,152.6
X$16566 6925 8103 8551 15 27 8307 MUX2_X1
* cell instance $16570 m0 *1 35.15,152.6
X$16570 5354 15 27 7525 CLKBUF_X3
* cell instance $16571 m0 *1 36.1,152.6
X$16571 7525 15 27 10831 INV_X4
* cell instance $16574 r0 *1 32.68,152.6
X$16574 8574 7858 8629 15 27 8006 MUX2_X1
* cell instance $16575 r0 *1 34.01,152.6
X$16575 8665 7115 8666 15 27 8575 MUX2_X1
* cell instance $16577 r0 *1 35.53,152.6
X$16577 8576 7548 8632 15 27 8633 MUX2_X1
* cell instance $16578 r0 *1 36.86,152.6
X$16578 8576 8075 8632 15 27 8638 MUX2_X1
* cell instance $16579 r0 *1 38.19,152.6
X$16579 8577 7115 8635 15 27 8578 MUX2_X1
* cell instance $16581 m0 *1 38.95,152.6
X$16581 6677 7931 15 27 8634 NAND2_X1
* cell instance $16583 m0 *1 45.79,152.6
X$16583 6960 7653 8504 15 27 8406 MUX2_X1
* cell instance $16585 m0 *1 47.88,152.6
X$16585 8505 7653 8508 15 27 8555 MUX2_X1
* cell instance $16587 m0 *1 49.4,152.6
X$16587 8407 7442 8506 15 27 8507 MUX2_X1
* cell instance $16588 m0 *1 50.73,152.6
X$16588 8505 8329 8508 15 27 8408 MUX2_X1
* cell instance $16593 r0 *1 39.52,152.6
X$16593 8577 7624 8635 15 27 8309 MUX2_X1
* cell instance $16596 r0 *1 44.65,152.6
X$16596 5860 15 27 8713 INV_X1
* cell instance $16600 r0 *1 49.21,152.6
X$16600 7545 8641 6969 15 27 8716 NAND3_X1
* cell instance $16604 r0 *1 53.58,152.6
X$16604 6525 8579 8643 15 27 8671 MUX2_X1
* cell instance $16605 r0 *1 54.91,152.6
X$16605 6193 7168 8644 27 8643 15 OAI21_X1
* cell instance $16608 r0 *1 56.24,152.6
X$16608 8109 8314 6969 15 27 8644 NAND3_X1
* cell instance $16612 m0 *1 57.76,152.6
X$16612 15 8509 8388 10727 7742 27 DFF_X2
* cell instance $16615 m0 *1 63.84,152.6
X$16615 8557 7915 8581 15 27 8510 MUX2_X1
* cell instance $16618 r0 *1 57.95,152.6
X$16618 6380 8579 8645 15 27 8509 MUX2_X1
* cell instance $16623 r0 *1 59.66,152.6
X$16623 8647 8580 15 27 8645 NAND2_X1
* cell instance $16627 r0 *1 61.56,152.6
X$16627 7168 7742 1298 15 27 8647 NAND3_X1
* cell instance $16631 r0 *1 64.41,152.6
X$16631 7168 6277 8582 27 8719 15 OAI21_X1
* cell instance $16632 r0 *1 65.17,152.6
X$16632 8109 8392 6969 15 27 8582 NAND3_X1
* cell instance $16634 m0 *1 67.26,152.6
X$16634 8557 7948 8581 15 27 8475 MUX2_X1
* cell instance $16636 m0 *1 68.59,152.6
X$16636 15 7948 27 8207 BUF_X8
* cell instance $16639 m0 *1 71.44,152.6
X$16639 15 7997 27 8092 BUF_X8
* cell instance $16642 m0 *1 74.29,152.6
X$16642 6405 8411 15 27 8511 NAND2_X2
* cell instance $16645 r0 *1 75.43,152.6
X$16645 15 10552 8321 8512 8674 27 DFF_X1
* cell instance $16646 m0 *1 77.71,152.6
X$16646 8412 7188 6631 27 15 8559 OAI21_X2
* cell instance $16647 m0 *1 76.38,152.6
X$16647 6408 8511 8559 15 27 8512 MUX2_X1
* cell instance $16650 m0 *1 79.99,152.6
X$16650 8513 7915 8514 15 27 8479 MUX2_X1
* cell instance $16651 m0 *1 81.32,152.6
X$16651 8513 8103 8514 15 27 8322 MUX2_X1
* cell instance $16652 m0 *1 82.65,152.6
X$16652 8583 7500 8584 15 27 8563 MUX2_X1
* cell instance $16655 r0 *1 79.42,152.6
X$16655 8650 7530 6631 27 15 8816 OAI21_X2
* cell instance $16656 r0 *1 80.75,152.6
X$16656 8513 6972 7530 15 27 8650 NAND3_X2
* cell instance $16657 r0 *1 82.08,152.6
X$16657 8583 8329 8584 15 27 8397 MUX2_X1
* cell instance $16660 m0 *1 85.69,152.6
X$16660 8654 7450 8563 15 27 7917 MUX2_X1
* cell instance $16661 m0 *1 84.36,152.6
X$16661 6822 7948 8653 15 27 8483 MUX2_X1
* cell instance $16665 r0 *1 84.74,152.6
X$16665 6822 7452 8653 15 27 8654 MUX2_X1
* cell instance $16667 r0 *1 86.45,152.6
X$16667 8729 7548 8652 15 27 8651 MUX2_X1
* cell instance $16668 r0 *1 87.78,152.6
X$16668 8729 8329 8652 15 27 8585 MUX2_X1
* cell instance $16669 m0 *1 90.25,152.6
X$16669 8586 7542 8651 15 27 7846 MUX2_X1
* cell instance $16670 m0 *1 88.92,152.6
X$16670 6894 7948 8515 15 27 8564 MUX2_X1
* cell instance $16674 r0 *1 89.11,152.6
X$16674 6894 7548 8515 15 27 8586 MUX2_X1
* cell instance $16678 r0 *1 91.77,152.6
X$16678 8486 8588 15 8587 27 NAND2_X4
* cell instance $16680 m0 *1 94.43,152.6
X$16680 8562 7442 8517 15 27 8516 MUX2_X1
* cell instance $16682 m0 *1 95.76,152.6
X$16682 8562 8329 8517 15 27 8491 MUX2_X1
* cell instance $16684 m0 *1 97.85,152.6
X$16684 8561 7653 8519 15 27 8560 MUX2_X1
* cell instance $16685 m0 *1 99.18,152.6
X$16685 8561 7948 8519 15 27 8518 MUX2_X1
* cell instance $16687 m0 *1 100.7,152.6
X$16687 7096 7452 8520 15 27 8521 MUX2_X1
* cell instance $16688 m0 *1 102.03,152.6
X$16688 8521 7450 8558 15 27 7776 MUX2_X1
* cell instance $16694 r0 *1 96.71,152.6
X$16694 8288 15 27 CLKBUF_X1
* cell instance $16696 r0 *1 100.32,152.6
X$16696 8649 7452 8648 15 27 8558 MUX2_X1
* cell instance $16697 r0 *1 101.65,152.6
X$16697 8649 8329 8648 15 27 8414 MUX2_X1
* cell instance $16702 r0 *1 108.49,152.6
X$16702 8589 8329 8590 15 27 8417 MUX2_X1
* cell instance $16703 m0 *1 109.25,152.6
X$16703 7014 7997 8522 15 27 8523 MUX2_X1
* cell instance $16705 m0 *1 110.58,152.6
X$16705 8523 7858 8591 15 27 8217 MUX2_X1
* cell instance $16709 r0 *1 110.39,152.6
X$16709 8589 7997 8590 15 27 8591 MUX2_X1
* cell instance $16711 m0 *1 113.62,152.6
X$16711 6939 8103 8524 15 27 8556 MUX2_X1
* cell instance $16712 m0 *1 112.29,152.6
X$16712 6939 7857 8524 15 27 8646 MUX2_X1
* cell instance $16715 m0 *1 121.79,152.6
X$16715 15 7671 8592 27 BUF_X16
* cell instance $16716 m0 *1 126.54,152.6
X$16716 6565 7931 15 27 8525 NAND2_X1
* cell instance $16719 r0 *1 113.24,152.6
X$16719 8646 7858 8723 15 27 7983 MUX2_X1
* cell instance $16724 r0 *1 115.33,152.6
X$16724 6922 15 27 8593 BUF_X2
* cell instance $16726 r0 *1 116.85,152.6
X$16726 7980 8755 15 8642 27 NAND2_X4
* cell instance $16727 r0 *1 118.56,152.6
X$16727 6515 8593 8419 6604 8642 8722 15 27 OAI221_X2
* cell instance $16730 r0 *1 121.22,152.6
X$16730 15 8755 27 7671 BUF_X8
* cell instance $16733 r0 *1 124.64,152.6
X$16733 8126 8592 15 8640 27 NAND2_X4
* cell instance $16734 r0 *1 126.35,152.6
X$16734 6789 8593 8419 6637 8640 8637 15 27 OAI221_X2
* cell instance $16735 m0 *1 128.44,152.6
X$16735 8526 7734 6568 15 27 8469 MUX2_X1
* cell instance $16737 m0 *1 129.77,152.6
X$16737 6605 8593 8419 6638 8639 8527 15 27 OAI221_X2
* cell instance $16739 m0 *1 132.05,152.6
X$16739 6698 8421 15 27 8636 NAND2_X1
* cell instance $16740 m0 *1 132.62,152.6
X$16740 7557 8421 15 27 10121 NAND2_X1
* cell instance $16741 m0 *1 133.19,152.6
X$16741 7560 8421 15 27 8630 NAND2_X1
* cell instance $16743 m0 *1 133.95,152.6
X$16743 6970 8421 15 27 8554 NAND2_X1
* cell instance $16745 r0 *1 128.44,152.6
X$16745 8526 8592 15 8683 27 NAND2_X4
* cell instance $16747 r0 *1 130.34,152.6
X$16747 15 10565 8126 8637 8266 27 DFF_X1
* cell instance $16749 m0 *1 135.09,152.6
X$16749 7430 8421 15 27 8553 NAND2_X1
* cell instance $16751 m0 *1 135.66,152.6
X$16751 7513 8421 15 27 8631 NAND2_X1
* cell instance $16754 m0 *1 137.94,152.6
X$16754 15 10290 8550 8424 8827 27 DFF_X1
* cell instance $16757 m0 *1 142.88,152.6
X$16757 8530 8529 27 15 8528 XNOR2_X1
* cell instance $16758 m0 *1 144.02,152.6
X$16758 8528 8549 27 15 8340 XNOR2_X1
* cell instance $16759 m0 *1 145.16,152.6
X$16759 8128 7950 27 15 8549 XNOR2_X1
* cell instance $16760 m0 *1 146.3,152.6
X$16760 15 8127 8548 8628 8529 8530 27 FA_X1
* cell instance $16762 m0 *1 150.86,152.6
X$16762 7077 6233 15 27 8531 OR2_X1
* cell instance $16768 r0 *1 147.44,152.6
X$16768 15 8628 8232 8627 8594 8623 27 FA_X1
* cell instance $16769 r0 *1 150.48,152.6
X$16769 15 8596 8714 8532 8531 8230 27 FA_X1
* cell instance $16770 m0 *1 153.14,152.6
X$16770 15 8533 8546 8544 8832 8530 27 FA_X1
* cell instance $16771 m0 *1 152.76,152.6
X$16771 8546 15 27 8547 INV_X1
* cell instance $16774 m0 *1 157.89,152.6
X$16774 8543 15 27 8545 INV_X1
* cell instance $16776 m0 *1 158.46,152.6
X$16776 15 8257 8543 8620 8230 8341 27 FA_X1
* cell instance $16777 m0 *1 161.5,152.6
X$16777 8533 15 27 8428 INV_X1
* cell instance $16779 m0 *1 163.4,152.6
X$16779 8761 8539 7594 27 15 7574 HA_X1
* cell instance $16780 m0 *1 165.3,152.6
X$16780 8344 15 27 8534 INV_X1
* cell instance $16785 r0 *1 153.9,152.6
X$16785 15 8364 8595 8710 8711 7950 27 FA_X1
* cell instance $16786 r0 *1 156.94,152.6
X$16786 8127 15 27 7900 INV_X2
* cell instance $16789 r0 *1 159.22,152.6
X$16789 8596 15 27 8058 INV_X2
* cell instance $16790 r0 *1 159.79,152.6
X$16790 15 8539 8623 7886 8597 8449 27 FA_X1
* cell instance $16791 r0 *1 162.83,152.6
X$16791 8687 8620 8614 27 15 8598 HA_X1
* cell instance $16793 r0 *1 164.92,152.6
X$16793 15 8706 8619 8688 8595 8534 27 FA_X1
* cell instance $16794 r0 *1 167.96,152.6
X$16794 8619 15 27 8600 INV_X1
* cell instance $16795 r0 *1 168.34,152.6
X$16795 8615 15 27 8616 INV_X1
* cell instance $16796 r0 *1 168.72,152.6
X$16796 8599 8614 8613 27 15 8615 HA_X1
* cell instance $16797 r0 *1 170.62,152.6
X$16797 8704 8613 8612 27 15 8431 HA_X1
* cell instance $16801 r0 *1 172.52,152.6
X$16801 8689 8600 8611 27 15 8702 HA_X1
* cell instance $16802 r0 *1 174.42,152.6
X$16802 8538 8601 8845 27 15 8690 HA_X1
* cell instance $16804 r0 *1 176.51,152.6
X$16804 15 8691 8602 8692 8611 8536 27 FA_X1
* cell instance $16806 m0 *1 178.22,152.6
X$16806 8537 15 27 8536 INV_X1
* cell instance $16811 m0 *1 181.45,152.6
X$16811 7065 6911 8693 27 15 10915 HA_X1
* cell instance $16816 r0 *1 181.26,152.6
X$16816 7319 7792 8991 27 15 8608 HA_X1
* cell instance $16818 r0 *1 183.92,152.6
X$16818 8604 8608 8603 27 15 8606 HA_X1
* cell instance $16819 r0 *1 185.82,152.6
X$16819 8606 15 27 8605 INV_X1
* cell instance $16824 m0 *1 1.33,127.4
X$16824 7023 15 27 7022 BUF_X1
* cell instance $16826 m0 *1 1.9,127.4
X$16826 7105 15 27 6952 BUF_X1
* cell instance $16827 m0 *1 2.47,127.4
X$16827 15 10325 7023 7068 6852 27 DFF_X1
* cell instance $16829 m0 *1 5.89,127.4
X$16829 7023 7024 15 27 7025 NAND2_X1
* cell instance $16830 m0 *1 6.46,127.4
X$16830 6529 7025 7485 15 7068 27 AOI21_X1
* cell instance $16833 m0 *1 8.17,127.4
X$16833 6523 15 27 6852 CLKBUF_X3
* cell instance $16834 m0 *1 9.12,127.4
X$16834 6852 15 27 CLKBUF_X1
* cell instance $16839 r0 *1 1.33,127.4
X$16839 15 10497 7105 7144 6852 27 DFF_X1
* cell instance $16843 r0 *1 4.56,127.4
X$16843 7105 7024 15 27 7106 NAND2_X1
* cell instance $16844 r0 *1 5.13,127.4
X$16844 6529 7106 7107 15 7144 27 AOI21_X1
* cell instance $16845 r0 *1 5.89,127.4
X$16845 7109 15 27 7108 BUF_X1
* cell instance $16847 r0 *1 6.65,127.4
X$16847 7111 15 27 7104 BUF_X1
* cell instance $16849 r0 *1 7.98,127.4
X$16849 7109 7024 15 27 7110 NAND2_X1
* cell instance $16851 r0 *1 8.74,127.4
X$16851 15 10505 7111 7219 6852 27 DFF_X1
* cell instance $16852 r0 *1 11.97,127.4
X$16852 7146 6882 15 27 7107 NAND2_X1
* cell instance $16853 m0 *1 12.92,127.4
X$16853 7029 6882 15 27 6642 NAND2_X1
* cell instance $16854 m0 *1 12.35,127.4
X$16854 7072 6882 15 27 7069 NAND2_X1
* cell instance $16858 m0 *1 15.96,127.4
X$16858 7026 7028 15 7149 27 NAND2_X4
* cell instance $16859 m0 *1 17.67,127.4
X$16859 15 7027 7176 27 BUF_X16
* cell instance $16862 r0 *1 12.54,127.4
X$16862 7177 6882 15 27 7145 NAND2_X1
* cell instance $16866 r0 *1 17.1,127.4
X$16866 7112 5859 6922 5860 7149 7150 15 27 OAI221_X2
* cell instance $16867 r0 *1 19.19,127.4
X$16867 15 10476 7026 7150 7113 27 DFF_X1
* cell instance $16870 r0 *1 22.99,127.4
X$16870 15 7114 7113 10818 7073 27 DFF_X2
* cell instance $16872 m0 *1 23.56,127.4
X$16872 7112 6397 6922 5849 7155 7114 15 27 OAI221_X2
* cell instance $16874 m0 *1 28.88,127.4
X$16874 7029 7027 15 27 7079 NAND2_X1
* cell instance $16875 m0 *1 29.45,127.4
X$16875 5791 6922 7079 7032 5793 27 15 7157 OAI221_X1
* cell instance $16878 m0 *1 32.3,127.4
X$16878 5689 6922 7031 7032 5690 27 15 7030 OAI221_X1
* cell instance $16881 m0 *1 41.04,127.4
X$16881 15 7034 6959 10667 6885 27 DFF_X2
* cell instance $16884 m0 *1 47.88,127.4
X$16884 6525 7035 7090 15 27 7159 MUX2_X1
* cell instance $16885 m0 *1 49.21,127.4
X$16885 7091 6193 6962 27 15 7090 OAI21_X2
* cell instance $16887 m0 *1 50.73,127.4
X$16887 5242 7036 7037 15 7253 27 NAND3_X4
* cell instance $16888 m0 *1 53.2,127.4
X$16888 7094 6398 6962 27 15 7164 OAI21_X2
* cell instance $16889 m0 *1 54.53,127.4
X$16889 5226 7037 7036 15 7094 27 NAND3_X4
* cell instance $16890 m0 *1 57,127.4
X$16890 5337 7037 7036 15 7116 27 NAND3_X4
* cell instance $16891 m0 *1 59.47,127.4
X$16891 15 7117 7042 10656 5337 27 DFF_X2
* cell instance $16892 m0 *1 63.08,127.4
X$16892 7040 6800 7037 15 27 7039 NAND3_X1
* cell instance $16896 m0 *1 67.83,127.4
X$16896 7045 6816 6942 27 15 7181 MUX2_X2
* cell instance $16897 m0 *1 69.54,127.4
X$16897 7044 7100 6942 27 15 7043 MUX2_X2
* cell instance $16900 m0 *1 72.2,127.4
X$16900 7044 7100 6687 27 15 7170 MUX2_X2
* cell instance $16901 m0 *1 73.91,127.4
X$16901 7045 6816 6687 27 15 7047 MUX2_X2
* cell instance $16902 m0 *1 75.62,127.4
X$16902 6207 7049 6967 15 27 7103 NAND3_X1
* cell instance $16903 m0 *1 76.38,127.4
X$16903 6207 7049 5929 15 27 7187 NAND3_X1
* cell instance $16905 m0 *1 77.33,127.4
X$16905 6207 15 27 7046 INV_X1
* cell instance $16907 m0 *1 79.23,127.4
X$16907 6972 15 27 6889 CLKBUF_X3
* cell instance $16908 m0 *1 80.18,127.4
X$16908 6972 15 27 6969 CLKBUF_X3
* cell instance $16915 r0 *1 28.69,127.4
X$16915 15 10498 7029 7157 6959 27 DFF_X1
* cell instance $16916 r0 *1 31.92,127.4
X$16916 15 10466 6957 7030 6959 27 DFF_X1
* cell instance $16919 r0 *1 36.1,127.4
X$16919 7072 7027 15 27 7033 NAND2_X1
* cell instance $16920 r0 *1 36.67,127.4
X$16920 5697 6922 7033 7032 5694 27 15 7179 OAI221_X1
* cell instance $16921 r0 *1 37.81,127.4
X$16921 6523 15 27 6959 CLKBUF_X3
* cell instance $16922 r0 *1 38.76,127.4
X$16922 6959 15 27 CLKBUF_X1
* cell instance $16926 r0 *1 46.36,127.4
X$16926 15 7159 6810 10735 5440 27 DFF_X2
* cell instance $16929 r0 *1 51.11,127.4
X$16929 5869 7035 7164 15 27 7163 MUX2_X1
* cell instance $16930 r0 *1 52.44,127.4
X$16930 15 7163 6810 10783 5226 27 DFF_X2
* cell instance $16933 r0 *1 57.76,127.4
X$16933 7116 6277 6962 27 15 7165 OAI21_X2
* cell instance $16937 r0 *1 59.09,127.4
X$16937 6116 7035 7165 15 27 7117 MUX2_X1
* cell instance $16938 r0 *1 60.42,127.4
X$16938 6888 7038 15 27 7166 NAND2_X1
* cell instance $16939 r0 *1 60.99,127.4
X$16939 6380 7035 7166 15 27 7167 MUX2_X1
* cell instance $16941 r0 *1 62.7,127.4
X$16941 15 7167 7042 10768 7041 27 DFF_X2
* cell instance $16944 r0 *1 67.26,127.4
X$16944 7187 7186 6323 27 15 7168 MUX2_X2
* cell instance $16948 r0 *1 71.06,127.4
X$16948 7103 7119 6276 27 15 7169 MUX2_X2
* cell instance $16950 r0 *1 74.29,127.4
X$16950 7103 7119 6606 27 15 7189 MUX2_X2
* cell instance $16955 r0 *1 78.85,127.4
X$16955 15 7172 6821 10770 5879 27 DFF_X2
* cell instance $16958 m0 *1 83.79,127.4
X$16958 15 6971 6821 10691 5451 27 DFF_X2
* cell instance $16961 m0 *1 91.39,127.4
X$16961 15 10292 7097 7098 7294 27 DFF_X1
* cell instance $16962 m0 *1 94.62,127.4
X$16962 6948 6896 7051 6747 6729 27 15 7098 OAI221_X1
* cell instance $16963 m0 *1 95.76,127.4
X$16963 6895 7097 15 27 7051 NAND2_X1
* cell instance $16965 m0 *1 96.52,127.4
X$16965 15 7052 6827 10722 7096 27 DFF_X2
* cell instance $16966 m0 *1 100.13,127.4
X$16966 15 7095 6827 10708 7053 27 DFF_X2
* cell instance $16967 m0 *1 103.74,127.4
X$16967 6974 7171 15 27 6978 NAND2_X1
* cell instance $16970 r0 *1 84.36,127.4
X$16970 7175 7174 6631 27 15 7265 OAI21_X2
* cell instance $16971 r0 *1 85.69,127.4
X$16971 7173 6972 7120 15 7175 27 NAND3_X4
* cell instance $16972 r0 *1 88.16,127.4
X$16972 7120 15 27 7174 BUF_X2
* cell instance $16978 r0 *1 100.7,127.4
X$16978 1564 15 27 6827 CLKBUF_X3
* cell instance $16979 r0 *1 101.65,127.4
X$16979 6827 15 27 10846 INV_X1
* cell instance $16981 r0 *1 102.41,127.4
X$16981 15 6976 7054 10749 7171 27 DFF_X2
* cell instance $16982 m0 *1 104.88,127.4
X$16982 15 7093 7054 10668 7014 27 DFF_X2
* cell instance $16987 m0 *1 109.82,127.4
X$16987 6974 7055 15 27 7092 NAND2_X1
* cell instance $16991 m0 *1 111.72,127.4
X$16991 15 7089 7056 10674 7055 27 DFF_X2
* cell instance $17001 r0 *1 116.66,127.4
X$17001 7056 15 27 CLKBUF_X1
* cell instance $17002 r0 *1 117.23,127.4
X$17002 6413 15 27 7056 CLKBUF_X3
* cell instance $17003 m0 *1 118.18,127.4
X$17003 15 7121 6833 27 BUF_X16
* cell instance $17005 m0 *1 122.93,127.4
X$17005 6296 6899 6982 6553 7086 7088 15 27 OAI221_X2
* cell instance $17008 m0 *1 125.97,127.4
X$17008 6983 7083 15 7251 27 NAND2_X4
* cell instance $17009 m0 *1 127.68,127.4
X$17009 5925 6899 6982 6013 7085 7084 15 27 OAI221_X2
* cell instance $17010 m0 *1 129.77,127.4
X$17010 15 10341 6985 7084 7123 27 DFF_X1
* cell instance $17018 r0 *1 121.22,127.4
X$17018 7122 6833 15 7086 27 NAND2_X4
* cell instance $17019 r0 *1 122.93,127.4
X$17019 15 7121 6983 27 BUF_X16
* cell instance $17023 r0 *1 129.01,127.4
X$17023 15 10522 7124 7250 7123 27 DFF_X1
* cell instance $17024 r0 *1 132.24,127.4
X$17024 6983 7124 15 7248 27 NAND2_X4
* cell instance $17026 r0 *1 134.71,127.4
X$17026 15 7161 7343 5155 7162 27 DFF_X1
* cell instance $17027 m0 *1 136.61,127.4
X$17027 7081 7082 15 27 7422 XOR2_X1
* cell instance $17032 m0 *1 140.22,127.4
X$17032 7125 7005 15 27 5767 NAND2_X1
* cell instance $17034 m0 *1 141.55,127.4
X$17034 7129 6989 15 27 6839 NOR2_X1
* cell instance $17035 m0 *1 142.12,127.4
X$17035 7130 6989 15 27 5602 NOR2_X2
* cell instance $17037 m0 *1 143.83,127.4
X$17037 7076 6989 4416 15 27 NOR2_X4
* cell instance $17040 r0 *1 138.32,127.4
X$17040 7161 27 7126 15 BUF_X4
* cell instance $17042 r0 *1 139.84,127.4
X$17042 7247 7126 15 27 6701 NOR2_X1
* cell instance $17043 r0 *1 140.41,127.4
X$17043 7160 7005 15 27 7128 NAND2_X1
* cell instance $17046 r0 *1 142.12,127.4
X$17046 7158 6989 4448 15 27 NOR2_X4
* cell instance $17047 r0 *1 143.83,127.4
X$17047 7129 7131 27 15 7132 XNOR2_X1
* cell instance $17048 r0 *1 144.97,127.4
X$17048 7132 6990 15 27 7200 NOR2_X1
* cell instance $17049 r0 *1 145.54,127.4
X$17049 6904 7126 4782 15 27 NOR2_X4
* cell instance $17050 m0 *1 147.63,127.4
X$17050 15 6989 27 6844 BUF_X8
* cell instance $17051 m0 *1 145.92,127.4
X$17051 7078 6989 4420 15 27 NOR2_X4
* cell instance $17055 m0 *1 152.57,127.4
X$17055 6721 6844 15 27 6991 NOR2_X2
* cell instance $17059 m0 *1 160.55,127.4
X$17059 7059 15 27 7060 INV_X1
* cell instance $17062 m0 *1 161.88,127.4
X$17062 7075 15 27 7152 INV_X1
* cell instance $17065 r0 *1 147.44,127.4
X$17065 7156 6989 4506 15 27 NOR2_X4
* cell instance $17067 r0 *1 149.34,127.4
X$17067 6770 6844 15 27 7154 NOR2_X1
* cell instance $17070 r0 *1 150.48,127.4
X$17070 7131 6434 15 27 7203 OR2_X2
* cell instance $17071 r0 *1 151.43,127.4
X$17071 7475 7133 27 15 7244 XNOR2_X1
* cell instance $17072 r0 *1 152.57,127.4
X$17072 6991 7154 7133 27 15 7242 HA_X1
* cell instance $17076 r0 *1 155.8,127.4
X$17076 15 7152 7134 7153 7058 7133 27 FA_X1
* cell instance $17078 r0 *1 159.03,127.4
X$17078 7153 15 27 7234 INV_X1
* cell instance $17080 r0 *1 160.17,127.4
X$17080 7208 6908 27 15 7233 XNOR2_X1
* cell instance $17081 r0 *1 161.31,127.4
X$17081 7135 7209 27 15 7238 XNOR2_X1
* cell instance $17084 m0 *1 162.64,127.4
X$17084 15 7061 7151 7411 7579 6994 27 FA_X1
* cell instance $17087 m0 *1 168.15,127.4
X$17087 6910 15 27 7137 INV_X1
* cell instance $17090 r0 *1 162.64,127.4
X$17090 7151 15 27 7136 INV_X1
* cell instance $17094 r0 *1 166.63,127.4
X$17094 7210 7138 27 15 7228 XNOR2_X1
* cell instance $17097 r0 *1 168.72,127.4
X$17097 6909 7148 27 15 7227 XNOR2_X1
* cell instance $17100 r0 *1 171,127.4
X$17100 15 7147 7148 7212 7221 6909 27 FA_X1
* cell instance $17105 m0 *1 171.95,127.4
X$17105 7074 15 27 7062 INV_X1
* cell instance $17106 m0 *1 172.52,127.4
X$17106 7063 15 27 7307 INV_X1
* cell instance $17111 m0 *1 174.8,127.4
X$17111 6914 15 27 7139 INV_X1
* cell instance $17113 m0 *1 178.6,127.4
X$17113 6917 15 27 7142 INV_X1
* cell instance $17114 m0 *1 175.56,127.4
X$17114 15 6911 7071 7066 6912 7065 27 FA_X1
* cell instance $17119 r0 *1 175.75,127.4
X$17119 7140 6915 7147 27 15 7138 HA_X1
* cell instance $17121 r0 *1 178.03,127.4
X$17121 7066 15 27 7141 INV_X1
* cell instance $17123 r0 *1 178.6,127.4
X$17123 7215 6915 10891 27 15 7487 HA_X1
* cell instance $17125 r0 *1 180.88,127.4
X$17125 6912 15 27 7215 INV_X1
* cell instance $17128 m0 *1 1.33,138.6
X$17128 7690 15 27 7645 BUF_X1
* cell instance $17130 m0 *1 1.9,138.6
X$17130 7648 15 27 7646 BUF_X1
* cell instance $17131 m0 *1 2.47,138.6
X$17131 15 10317 7690 7647 7268 27 DFF_X1
* cell instance $17132 m0 *1 5.7,138.6
X$17132 7690 7024 15 27 7752 NAND2_X1
* cell instance $17139 r0 *1 2.47,138.6
X$17139 7852 15 27 7749 BUF_X1
* cell instance $17145 r0 *1 4.94,138.6
X$17145 7751 15 27 7848 BUF_X1
* cell instance $17147 r0 *1 5.7,138.6
X$17147 7441 7752 7796 15 7647 27 AOI21_X1
* cell instance $17149 r0 *1 6.65,138.6
X$17149 15 10611 7648 7798 7537 27 DFF_X1
* cell instance $17150 m0 *1 9.12,138.6
X$17150 7648 7024 15 27 7753 NAND2_X1
* cell instance $17154 m0 *1 11.97,138.6
X$17154 7801 7364 15 27 7691 NAND2_X1
* cell instance $17156 r0 *1 9.88,138.6
X$17156 7441 7753 7800 15 7798 27 AOI21_X1
* cell instance $17158 r0 *1 12.16,138.6
X$17158 7893 7364 15 27 7800 NAND2_X1
* cell instance $17159 r0 *1 12.73,138.6
X$17159 7515 7364 15 27 7803 NAND2_X1
* cell instance $17160 m0 *1 13.11,138.6
X$17160 7657 7364 15 27 7484 NAND2_X1
* cell instance $17165 r0 *1 13.3,138.6
X$17165 7805 7364 15 27 7796 NAND2_X1
* cell instance $17167 m0 *1 16.53,138.6
X$17167 7329 7699 15 7703 27 NAND2_X4
* cell instance $17169 m0 *1 18.24,138.6
X$17169 7650 5859 7196 5860 7703 7649 15 27 OAI221_X2
* cell instance $17170 m0 *1 20.33,138.6
X$17170 7650 6193 7196 6623 7704 7651 15 27 OAI221_X2
* cell instance $17171 m0 *1 22.42,138.6
X$17171 7652 7232 5936 15 27 7714 MUX2_X1
* cell instance $17173 m0 *1 24.51,138.6
X$17173 7652 7653 5936 15 27 7716 MUX2_X1
* cell instance $17174 m0 *1 25.84,138.6
X$17174 7712 7340 7714 15 27 7719 MUX2_X1
* cell instance $17175 m0 *1 27.17,138.6
X$17175 7715 7654 7716 15 27 7723 MUX2_X1
* cell instance $17176 m0 *1 28.5,138.6
X$17176 15 6572 7813 7347 7719 27 AOI21_X4
* cell instance $17177 m0 *1 30.97,138.6
X$17177 7720 7723 7658 27 15 5838 MUX2_X2
* cell instance $17181 r0 *1 17.29,138.6
X$17181 15 10590 7329 7649 7537 27 DFF_X1
* cell instance $17183 r0 *1 20.71,138.6
X$17183 15 7651 7901 10771 7535 27 DFF_X2
* cell instance $17188 r0 *1 29.45,138.6
X$17188 7754 7443 6245 15 27 7820 MUX2_X1
* cell instance $17189 r0 *1 30.78,138.6
X$17189 7536 7443 5310 15 27 7755 MUX2_X1
* cell instance $17190 r0 *1 32.11,138.6
X$17190 7755 7605 7820 15 27 7823 MUX2_X1
* cell instance $17192 m0 *1 35.15,138.6
X$17192 7726 7548 5520 15 27 7655 MUX2_X1
* cell instance $17193 m0 *1 33.82,138.6
X$17193 7726 7447 5520 15 27 7728 MUX2_X1
* cell instance $17194 m0 *1 36.48,138.6
X$17194 7543 7542 7655 15 27 7825 MUX2_X1
* cell instance $17201 r0 *1 34.77,138.6
X$17201 15 6770 8072 7435 7823 27 AOI21_X4
* cell instance $17203 r0 *1 37.43,138.6
X$17203 7756 7825 7446 27 15 5281 MUX2_X2
* cell instance $17205 r0 *1 39.9,138.6
X$17205 7801 7757 5401 15 27 7758 MUX2_X1
* cell instance $17206 r0 *1 41.23,138.6
X$17206 7758 7654 7827 15 27 7760 MUX2_X1
* cell instance $17207 r0 *1 42.56,138.6
X$17207 7759 7760 7658 27 15 6040 MUX2_X2
* cell instance $17208 r0 *1 44.27,138.6
X$17208 7862 27 7443 15 BUF_X4
* cell instance $17210 m0 *1 47.88,138.6
X$17210 7656 7761 7658 27 15 5537 MUX2_X2
* cell instance $17211 m0 *1 46.55,138.6
X$17211 7073 7653 5127 15 27 7828 MUX2_X1
* cell instance $17215 r0 *1 47.5,138.6
X$17215 7828 7654 7830 15 27 7761 MUX2_X1
* cell instance $17217 r0 *1 49.02,138.6
X$17217 7073 7762 5127 15 27 7831 MUX2_X1
* cell instance $17220 r0 *1 52.25,138.6
X$17220 15 7763 7378 10781 7515 27 DFF_X2
* cell instance $17222 m0 *1 53.01,138.6
X$17222 5869 7659 7738 15 27 7763 MUX2_X1
* cell instance $17223 m0 *1 55.1,138.6
X$17223 6398 7043 7764 27 7738 15 OAI21_X1
* cell instance $17225 m0 *1 58.9,138.6
X$17225 6380 7659 7660 15 27 7740 MUX2_X1
* cell instance $17228 r0 *1 55.86,138.6
X$17228 7515 7043 7037 15 27 7764 NAND3_X1
* cell instance $17229 r0 *1 56.62,138.6
X$17229 7043 7657 7037 15 27 7864 NAND3_X1
* cell instance $17230 r0 *1 57.38,138.6
X$17230 6116 7659 7836 15 27 7835 MUX2_X1
* cell instance $17231 r0 *1 58.71,138.6
X$17231 7043 15 27 7766 INV_X2
* cell instance $17235 r0 *1 59.28,138.6
X$17235 7766 6383 15 27 7837 NAND2_X1
* cell instance $17236 r0 *1 59.85,138.6
X$17236 7767 7837 15 27 7660 NAND2_X1
* cell instance $17237 r0 *1 60.42,138.6
X$17237 7043 7521 6889 15 27 7767 NAND3_X1
* cell instance $17239 m0 *1 61.56,138.6
X$17239 6472 7283 7742 15 27 7745 MUX2_X1
* cell instance $17241 m0 *1 62.89,138.6
X$17241 6472 7454 7742 15 27 7661 MUX2_X1
* cell instance $17242 m0 *1 64.22,138.6
X$17242 7661 7383 7662 15 27 7663 MUX2_X1
* cell instance $17245 m0 *1 66.88,138.6
X$17245 7745 7451 7744 15 27 7664 MUX2_X1
* cell instance $17250 m0 *1 68.59,138.6
X$17250 7381 27 7658 15 BUF_X4
* cell instance $17252 r0 *1 70.3,138.6
X$17252 7665 27 7442 15 BUF_X4
* cell instance $17253 m0 *1 71.25,138.6
X$17253 7665 27 7548 15 BUF_X4
* cell instance $17255 m0 *1 72.58,138.6
X$17255 5675 15 27 7665 BUF_X2
* cell instance $17257 m0 *1 73.53,138.6
X$17257 7665 27 7500 15 BUF_X4
* cell instance $17260 r0 *1 71.63,138.6
X$17260 7665 27 7653 15 BUF_X4
* cell instance $17262 r0 *1 73.34,138.6
X$17262 7665 27 7757 15 BUF_X4
* cell instance $17264 m0 *1 76.19,138.6
X$17264 5675 15 27 7666 BUF_X1
* cell instance $17266 m0 *1 76.76,138.6
X$17266 7666 15 27 7454 CLKBUF_X2
* cell instance $17269 m0 *1 79.8,138.6
X$17269 5879 7666 7380 15 27 7845 MUX2_X1
* cell instance $17270 m0 *1 81.13,138.6
X$17270 7747 7748 7381 27 15 6334 MUX2_X2
* cell instance $17272 m0 *1 84.36,138.6
X$17272 15 7746 7357 10657 7642 27 DFF_X2
* cell instance $17276 r0 *1 76.19,138.6
X$17276 6550 7454 7935 15 27 7769 MUX2_X1
* cell instance $17277 r0 *1 77.52,138.6
X$17277 7769 7383 7844 15 27 7747 MUX2_X1
* cell instance $17280 r0 *1 79.99,138.6
X$17280 7553 7666 6970 15 27 7770 MUX2_X1
* cell instance $17281 r0 *1 81.32,138.6
X$17281 7770 7383 7845 15 27 7748 MUX2_X1
* cell instance $17284 r0 *1 83.79,138.6
X$17284 2126 15 27 6972 CLKBUF_X3
* cell instance $17287 r0 *1 86.64,138.6
X$17287 7173 7447 7386 15 27 7771 MUX2_X1
* cell instance $17288 r0 *1 87.97,138.6
X$17288 6210 7115 7868 15 27 7772 MUX2_X1
* cell instance $17289 r0 *1 89.3,138.6
X$17289 7772 7281 8117 15 27 7743 MUX2_X1
* cell instance $17293 r0 *1 91.96,138.6
X$17293 7773 7668 6696 15 27 7774 MUX2_X1
* cell instance $17294 m0 *1 92.34,138.6
X$17294 6279 7283 7669 15 27 7667 MUX2_X1
* cell instance $17296 m0 *1 93.67,138.6
X$17296 6279 7668 7669 15 27 7847 MUX2_X1
* cell instance $17299 m0 *1 96.71,138.6
X$17299 7670 7731 7446 27 15 5804 MUX2_X2
* cell instance $17300 m0 *1 98.42,138.6
X$17300 7846 7737 7446 27 15 5458 MUX2_X2
* cell instance $17301 m0 *1 100.13,138.6
X$17301 6214 7274 7554 5959 7741 7775 15 27 OAI221_X2
* cell instance $17302 m0 *1 102.22,138.6
X$17302 7640 7671 15 7741 27 NAND2_X4
* cell instance $17305 r0 *1 93.29,138.6
X$17305 7774 7278 7847 15 27 7872 MUX2_X1
* cell instance $17306 r0 *1 94.62,138.6
X$17306 7917 7842 7446 27 15 5290 MUX2_X2
* cell instance $17310 r0 *1 98.99,138.6
X$17310 15 7775 7294 10801 7640 27 DFF_X2
* cell instance $17313 r0 *1 103.17,138.6
X$17313 7776 7841 7446 27 15 6055 MUX2_X2
* cell instance $17316 r0 *1 105.45,138.6
X$17316 15 7672 7294 10794 7739 27 DFF_X2
* cell instance $17317 m0 *1 108.49,138.6
X$17317 7739 7671 15 27 7843 NAND2_X2
* cell instance $17318 m0 *1 107.35,138.6
X$17318 6689 7554 7843 5921 7274 27 15 7672 OAI221_X1
* cell instance $17320 r0 *1 109.06,138.6
X$17320 7195 7500 7430 15 27 7777 MUX2_X1
* cell instance $17321 m0 *1 111.15,138.6
X$17321 7673 7542 7674 15 27 7737 MUX2_X1
* cell instance $17322 m0 *1 109.82,138.6
X$17322 7739 7548 6742 15 27 7673 MUX2_X1
* cell instance $17324 m0 *1 112.67,138.6
X$17324 7669 7559 15 7735 27 NAND2_X4
* cell instance $17325 m0 *1 114.38,138.6
X$17325 15 7675 7054 10652 7669 27 DFF_X2
* cell instance $17326 m0 *1 117.99,138.6
X$17326 15 10300 7560 7733 7561 27 DFF_X1
* cell instance $17327 m0 *1 121.22,138.6
X$17327 7732 7542 7834 15 27 7731 MUX2_X1
* cell instance $17328 m0 *1 122.55,138.6
X$17328 15 10311 7676 7730 7561 27 DFF_X1
* cell instance $17331 r0 *1 111.91,138.6
X$17331 8218 7833 7446 27 15 6056 MUX2_X2
* cell instance $17338 r0 *1 116.28,138.6
X$17338 7839 7450 7840 15 27 7841 MUX2_X1
* cell instance $17341 r0 *1 118.18,138.6
X$17341 7057 7452 7560 15 27 7840 MUX2_X1
* cell instance $17342 r0 *1 119.51,138.6
X$17342 6604 7390 7838 6515 7300 27 15 7733 OAI221_X1
* cell instance $17346 r0 *1 121.98,138.6
X$17346 7778 7442 6565 15 27 7732 MUX2_X1
* cell instance $17350 r0 *1 124.64,138.6
X$17350 7122 7548 7676 15 27 7834 MUX2_X1
* cell instance $17352 m0 *1 126.35,138.6
X$17352 7676 7391 15 7729 27 NAND2_X4
* cell instance $17354 m0 *1 128.06,138.6
X$17354 5925 7300 7390 6013 7727 7622 15 27 OAI221_X2
* cell instance $17357 r0 *1 126.92,138.6
X$17357 7559 7564 15 7727 27 NAND2_X4
* cell instance $17358 r0 *1 128.63,138.6
X$17358 6222 7300 7390 6658 7832 7829 15 27 OAI221_X2
* cell instance $17359 m0 *1 130.72,138.6
X$17359 15 7829 7162 10726 7779 27 DFF_X2
* cell instance $17363 m0 *1 138.89,138.6
X$17363 7781 7724 27 15 7395 XNOR2_X1
* cell instance $17364 m0 *1 140.03,138.6
X$17364 7160 7418 15 27 7782 NAND2_X1
* cell instance $17366 r0 *1 130.72,138.6
X$17366 7779 7391 15 7832 27 NAND2_X4
* cell instance $17370 r0 *1 137.75,138.6
X$17370 15 7782 7821 7725 7826 7781 27 FA_X1
* cell instance $17371 r0 *1 140.79,138.6
X$17371 7303 7399 15 27 7826 NAND2_X1
* cell instance $17372 m0 *1 141.17,138.6
X$17372 7725 15 27 7722 INV_X1
* cell instance $17374 m0 *1 141.55,138.6
X$17374 7783 6840 15 27 7724 NAND2_X1
* cell instance $17376 m0 *1 142.31,138.6
X$17376 15 7678 7824 7721 7717 7722 27 FA_X1
* cell instance $17377 m0 *1 145.35,138.6
X$17377 15 7679 7718 7717 7786 7498 27 FA_X1
* cell instance $17380 r0 *1 142.88,138.6
X$17380 7718 7824 27 15 7784 XNOR2_X1
* cell instance $17382 r0 *1 144.78,138.6
X$17382 15 7785 7678 7567 7786 7679 27 FA_X1
* cell instance $17383 r0 *1 147.82,138.6
X$17383 15 7818 7787 7819 7786 7785 27 FA_X1
* cell instance $17385 m0 *1 148.77,138.6
X$17385 7788 7821 27 15 7474 XNOR2_X1
* cell instance $17388 m0 *1 152.38,138.6
X$17388 7497 15 27 7680 INV_X1
* cell instance $17394 r0 *1 151.81,138.6
X$17394 15 7817 7789 8061 7680 7819 27 FA_X1
* cell instance $17398 m0 *1 155.42,138.6
X$17398 15 7816 7711 7707 7709 7710 27 FA_X1
* cell instance $17400 r0 *1 155.42,138.6
X$17400 7790 15 27 7710 INV_X1
* cell instance $17404 r0 *1 159.98,138.6
X$17404 15 7814 7575 7812 7815 7808 27 FA_X1
* cell instance $17406 m0 *1 160.36,138.6
X$17406 7707 15 27 7814 INV_X1
* cell instance $17408 m0 *1 161.69,138.6
X$17408 15 7702 7706 7682 7602 7811 27 FA_X1
* cell instance $17411 m0 *1 166.44,138.6
X$17411 7686 7880 7700 27 15 7491 HA_X1
* cell instance $17412 m0 *1 168.34,138.6
X$17412 15 7898 7701 7685 7581 7700 27 FA_X1
* cell instance $17413 m0 *1 171.38,138.6
X$17413 15 7697 7684 7806 7696 7695 27 FA_X1
* cell instance $17416 m0 *1 177.65,138.6
X$17416 7686 7401 7892 27 15 7694 HA_X1
* cell instance $17417 m0 *1 179.55,138.6
X$17417 15 7802 7797 7693 7308 7481 27 FA_X1
* cell instance $17418 m0 *1 182.59,138.6
X$17418 15 7692 7799 7795 7688 7067 27 FA_X1
* cell instance $17424 r0 *1 165.11,138.6
X$17424 7810 15 27 7811 INV_X1
* cell instance $17425 r0 *1 165.49,138.6
X$17425 15 7807 7810 7809 7812 7683 27 FA_X1
* cell instance $17428 r0 *1 169.48,138.6
X$17428 7684 15 27 7808 INV_X1
* cell instance $17431 r0 *1 171,138.6
X$17431 15 7791 7807 8146 7806 7685 27 FA_X1
* cell instance $17438 r0 *1 175.37,138.6
X$17438 7582 7804 7895 27 15 7695 HA_X1
* cell instance $17441 r0 *1 179.17,138.6
X$17441 15 7401 7802 7792 7406 7686 27 FA_X1
* cell instance $17442 r0 *1 182.21,138.6
X$17442 7793 15 27 7692 INV_X1
* cell instance $17443 r0 *1 182.59,138.6
X$17443 7799 15 27 8139 INV_X1
* cell instance $17444 r0 *1 182.97,138.6
X$17444 7689 15 27 7890 INV_X1
* cell instance $17446 r0 *1 184.11,138.6
X$17446 7797 15 27 7794 INV_X1
* cell instance $17447 r0 *1 184.49,138.6
X$17447 7795 15 27 7954 INV_X1
* cell instance $17538 r0 *1 4.18,12.6
X$17538 672 608 457 15 27 609 MUX2_X1
* cell instance $17541 r0 *1 7.22,12.6
X$17541 614 610 27 15 672 AND2_X1
* cell instance $17542 r0 *1 7.98,12.6
X$17542 611 675 613 530 27 15 612 OAI22_X2
* cell instance $17543 r0 *1 9.69,12.6
X$17543 530 614 616 15 27 675 OR3_X1
* cell instance $17545 r0 *1 10.83,12.6
X$17545 616 457 530 15 27 615 NAND3_X1
* cell instance $17546 m0 *1 12.16,12.6
X$17546 312 349 457 353 352 577 27 15 AOI221_X2
* cell instance $17547 m0 *1 11.59,12.6
X$17547 312 349 15 27 616 NAND2_X1
* cell instance $17548 m0 *1 14.25,12.6
X$17548 352 353 15 27 530 NAND2_X1
* cell instance $17549 m0 *1 14.82,12.6
X$17549 404 270 353 352 15 27 407 AOI22_X1
* cell instance $17550 m0 *1 15.77,12.6
X$17550 445 459 458 15 27 351 NOR3_X1
* cell instance $17551 m0 *1 16.53,12.6
X$17551 460 533 457 27 532 15 NOR3_X2
* cell instance $17552 m0 *1 17.86,12.6
X$17552 410 459 458 15 27 505 NOR3_X1
* cell instance $17555 r0 *1 11.97,12.6
X$17555 579 577 270 618 27 15 617 OAI22_X1
* cell instance $17557 r0 *1 13.3,12.6
X$17557 616 457 459 458 15 27 579 NOR4_X1
* cell instance $17560 r0 *1 14.82,12.6
X$17560 531 502 350 445 408 405 27 15 AOI221_X2
* cell instance $17562 r0 *1 17.29,12.6
X$17562 459 458 15 27 504 NOR2_X2
* cell instance $17565 m0 *1 19.95,12.6
X$17565 226 349 534 461 15 27 677 AOI22_X2
* cell instance $17566 m0 *1 19,12.6
X$17566 534 461 15 27 352 NAND2_X2
* cell instance $17567 m0 *1 21.66,12.6
X$17567 581 536 537 27 15 621 OAI21_X2
* cell instance $17568 m0 *1 22.99,12.6
X$17568 537 536 15 27 459 NOR2_X2
* cell instance $17569 m0 *1 23.94,12.6
X$17569 538 539 362 27 15 457 MUX2_X2
* cell instance $17570 m0 *1 25.65,12.6
X$17570 584 463 462 15 27 539 NOR3_X1
* cell instance $17571 m0 *1 26.41,12.6
X$17571 462 463 623 15 27 NOR2_X4
* cell instance $17572 m0 *1 28.12,12.6
X$17572 542 463 462 27 461 15 NOR3_X2
* cell instance $17575 r0 *1 19.57,12.6
X$17575 620 703 353 677 701 27 15 AOI211_X2
* cell instance $17576 r0 *1 21.28,12.6
X$17576 349 226 15 27 581 NAND2_X1
* cell instance $17577 r0 *1 21.85,12.6
X$17577 535 538 361 27 15 353 OAI21_X4
* cell instance $17578 r0 *1 24.32,12.6
X$17578 622 362 539 15 614 27 AOI21_X1
* cell instance $17579 r0 *1 25.08,12.6
X$17579 623 362 15 27 622 NOR2_X1
* cell instance $17580 r0 *1 25.65,12.6
X$17580 462 463 704 15 27 NOR2_X4
* cell instance $17584 r0 *1 28.69,12.6
X$17584 705 540 463 462 680 15 27 OAI211_X2
* cell instance $17585 m0 *1 30.02,12.6
X$17585 541 624 275 15 27 NOR2_X4
* cell instance $17589 m0 *1 34.01,12.6
X$17589 464 280 27 15 542 AND2_X1
* cell instance $17590 m0 *1 34.77,12.6
X$17590 280 464 15 584 27 NAND2_X4
* cell instance $17594 r0 *1 30.59,12.6
X$17594 624 541 15 208 27 OR2_X4
* cell instance $17595 r0 *1 32.3,12.6
X$17595 679 680 362 27 625 15 OAI21_X1
* cell instance $17596 r0 *1 33.06,12.6
X$17596 625 681 683 542 15 27 531 AOI211_X4
* cell instance $17598 r0 *1 35.34,12.6
X$17598 584 543 509 15 27 536 NAND3_X2
* cell instance $17600 m0 *1 37.81,12.6
X$17600 465 366 283 27 15 509 OAI21_X4
* cell instance $17605 r0 *1 39.71,12.6
X$17605 629 684 628 15 537 27 AOI21_X2
* cell instance $17606 r0 *1 41.04,12.6
X$17606 686 630 586 15 27 684 MUX2_X1
* cell instance $17607 r0 *1 42.37,12.6
X$17607 632 631 27 15 686 AND2_X1
* cell instance $17608 m0 *1 43.13,12.6
X$17608 15 513 467 466 544 364 27 NAND4_X4
* cell instance $17610 m0 *1 46.55,12.6
X$17610 15 467 513 544 466 283 27 AND4_X4
* cell instance $17614 m0 *1 51.49,12.6
X$17614 547 15 27 469 INV_X1
* cell instance $17615 m0 *1 51.87,12.6
X$17615 295 469 230 27 15 549 HA_X1
* cell instance $17616 m0 *1 53.77,12.6
X$17616 15 515 472 590 549 414 27 NOR4_X4
* cell instance $17617 m0 *1 57.19,12.6
X$17617 471 65 15 27 591 NOR2_X2
* cell instance $17619 r0 *1 43.13,12.6
X$17619 633 632 15 27 586 NOR2_X1
* cell instance $17620 r0 *1 43.7,12.6
X$17620 15 466 634 635 545 366 27 NOR4_X4
* cell instance $17621 r0 *1 47.12,12.6
X$17621 466 634 635 545 15 27 514 OR4_X1
* cell instance $17623 r0 *1 48.45,12.6
X$17623 879 27 226 15 BUF_X4
* cell instance $17625 r0 *1 50.54,12.6
X$17625 468 690 15 27 546 NAND2_X1
* cell instance $17626 r0 *1 51.11,12.6
X$17626 546 690 547 27 15 881 OAI21_X2
* cell instance $17630 r0 *1 54.53,12.6
X$17630 590 515 549 27 636 15 NOR3_X2
* cell instance $17631 r0 *1 55.86,12.6
X$17631 470 414 260 27 691 15 NOR3_X2
* cell instance $17632 r0 *1 57.19,12.6
X$17632 15 637 691 455 594 27 AOI21_X4
* cell instance $17634 m0 *1 58.52,12.6
X$17634 471 593 595 27 15 516 OAI21_X4
* cell instance $17637 m0 *1 66.31,12.6
X$17637 473 112 550 15 27 598 NOR3_X1
* cell instance $17638 m0 *1 67.07,12.6
X$17638 473 550 112 15 27 599 OR3_X4
* cell instance $17639 m0 *1 69.16,12.6
X$17639 475 694 474 27 15 638 OAI21_X4
* cell instance $17647 r0 *1 63.27,12.6
X$17647 334 516 357 784 27 782 15 NOR4_X2
* cell instance $17649 r0 *1 65.36,12.6
X$17649 693 553 552 15 594 27 AOI21_X2
* cell instance $17650 r0 *1 66.69,12.6
X$17650 15 721 337 601 695 27 AOI21_X4
* cell instance $17651 r0 *1 69.16,12.6
X$17651 474 15 27 601 INV_X1
* cell instance $17653 r0 *1 69.73,12.6
X$17653 15 694 599 553 552 27 AOI21_X4
* cell instance $17654 m0 *1 75.24,12.6
X$17654 478 479 606 27 477 15 OAI21_X1
* cell instance $17655 m0 *1 72.01,12.6
X$17655 15 290 194 476 547 605 27 OAI22_X4
* cell instance $17656 m0 *1 76,12.6
X$17656 480 184 15 27 606 XOR2_X1
* cell instance $17658 r0 *1 72.2,12.6
X$17658 641 692 79 27 180 15 NOR3_X2
* cell instance $17660 r0 *1 73.72,12.6
X$17660 641 692 478 15 27 NOR2_X4
* cell instance $17662 r0 *1 75.81,12.6
X$17662 138 642 480 27 15 643 HA_X1
* cell instance $17664 m0 *1 77.52,12.6
X$17664 522 520 554 555 605 27 15 AOI211_X2
* cell instance $17665 m0 *1 79.42,12.6
X$17665 602 557 15 27 522 NOR2_X1
* cell instance $17666 m0 *1 79.99,12.6
X$17666 603 554 604 27 157 15 OAI21_X1
* cell instance $17668 m0 *1 81.51,12.6
X$17668 603 481 15 27 559 OR2_X1
* cell instance $17671 m0 *1 83.22,12.6
X$17671 15 597 138 27 INV_X16
* cell instance $17672 m0 *1 86.45,12.6
X$17672 597 525 527 27 15 482 HA_X1
* cell instance $17673 m0 *1 88.35,12.6
X$17673 482 527 596 15 420 27 AOI21_X1
* cell instance $17674 m0 *1 89.11,12.6
X$17674 419 529 15 27 730 NOR2_X2
* cell instance $17677 m0 *1 92.34,12.6
X$17677 528 648 510 585 15 27 732 AOI22_X2
* cell instance $17680 m0 *1 95,12.6
X$17680 592 296 484 27 15 525 OAI21_X2
* cell instance $17681 m0 *1 96.33,12.6
X$17681 212 484 562 27 15 521 HA_X1
* cell instance $17682 m0 *1 98.23,12.6
X$17682 521 562 688 15 346 27 AOI21_X2
* cell instance $17687 r0 *1 77.9,12.6
X$17687 522 554 555 15 642 27 AOI21_X2
* cell instance $17688 r0 *1 79.23,12.6
X$17688 556 480 27 15 724 AND2_X2
* cell instance $17690 r0 *1 80.37,12.6
X$17690 557 456 15 27 604 NAND2_X1
* cell instance $17692 r0 *1 81.32,12.6
X$17692 600 557 558 15 27 291 MUX2_X1
* cell instance $17693 r0 *1 82.65,12.6
X$17693 559 644 15 27 560 NAND2_X1
* cell instance $17694 r0 *1 83.22,12.6
X$17694 644 559 15 27 600 XOR2_X1
* cell instance $17699 r0 *1 95.38,12.6
X$17699 649 15 27 779 INV_X1
* cell instance $17700 r0 *1 95.76,12.6
X$17700 561 650 689 27 15 483 AND3_X1
* cell instance $17701 r0 *1 96.71,12.6
X$17701 15 523 561 650 689 27 AOI21_X4
* cell instance $17702 r0 *1 99.18,12.6
X$17702 562 15 27 561 INV_X1
* cell instance $17707 r0 *1 105.26,12.6
X$17707 654 587 687 15 27 345 MUX2_X1
* cell instance $17710 r0 *1 107.73,12.6
X$17710 295 654 685 27 15 563 HA_X1
* cell instance $17711 r0 *1 109.63,12.6
X$17711 563 15 27 655 INV_X1
* cell instance $17714 r0 *1 111.15,12.6
X$17714 564 15 27 739 INV_X2
* cell instance $17731 m0 *1 19.19,177.8
X$17731 15 10421 9567 9569 9289 27 DFF_X1
* cell instance $17734 m0 *1 24.51,177.8
X$17734 15 10438 9652 9619 9615 27 DFF_X1
* cell instance $17738 m0 *1 28.69,177.8
X$17738 9624 9653 15 27 9654 NAND2_X1
* cell instance $17739 m0 *1 29.26,177.8
X$17739 9573 9654 9574 15 9655 27 AOI21_X1
* cell instance $17741 m0 *1 30.21,177.8
X$17741 15 10437 9795 9657 9856 27 DFF_X1
* cell instance $17743 m0 *1 33.63,177.8
X$17743 15 10442 9754 9627 9224 27 DFF_X1
* cell instance $17745 m0 *1 37.05,177.8
X$17745 15 10441 9658 9696 9224 27 DFF_X1
* cell instance $17747 m0 *1 40.47,177.8
X$17747 15 10445 9659 9698 9390 27 DFF_X1
* cell instance $17748 m0 *1 43.7,177.8
X$17748 9584 9700 9701 15 9762 27 AOI21_X1
* cell instance $17749 m0 *1 44.46,177.8
X$17749 9717 9653 15 27 9700 NAND2_X1
* cell instance $17754 r0 *1 29.26,177.8
X$17754 7533 15 27 9653 CLKBUF_X3
* cell instance $17755 r0 *1 30.21,177.8
X$17755 8005 9792 15 27 9794 NAND2_X1
* cell instance $17758 r0 *1 31.92,177.8
X$17758 9795 9653 15 27 9656 NAND2_X1
* cell instance $17762 r0 *1 41.99,177.8
X$17762 15 10534 9717 9762 9390 27 DFF_X1
* cell instance $17764 m0 *1 45.6,177.8
X$17764 15 10333 9718 9767 9660 27 DFF_X1
* cell instance $17767 m0 *1 50.35,177.8
X$17767 9770 9653 15 27 9661 NAND2_X1
* cell instance $17768 m0 *1 50.92,177.8
X$17768 9584 9661 9455 15 9719 27 AOI21_X1
* cell instance $17772 r0 *1 46.36,177.8
X$17772 9584 9768 9766 15 9767 27 AOI21_X1
* cell instance $17773 r0 *1 47.12,177.8
X$17773 9718 9653 15 27 9768 NAND2_X1
* cell instance $17775 r0 *1 48.07,177.8
X$17775 9584 9839 9577 15 9769 27 AOI21_X1
* cell instance $17779 r0 *1 50.16,177.8
X$17779 15 10642 9770 9719 9524 27 DFF_X1
* cell instance $17782 r0 *1 54.53,177.8
X$17782 9798 9772 9720 15 9799 27 AOI21_X1
* cell instance $17783 m0 *1 55.29,177.8
X$17783 7533 15 27 9522 CLKBUF_X3
* cell instance $17785 m0 *1 56.24,177.8
X$17785 15 10402 9662 9579 9524 27 DFF_X1
* cell instance $17786 m0 *1 59.47,177.8
X$17786 9662 9517 15 27 9639 NAND2_X1
* cell instance $17787 m0 *1 60.04,177.8
X$17787 15 10400 9663 9641 9358 27 DFF_X1
* cell instance $17788 m0 *1 63.27,177.8
X$17788 9663 9517 15 27 9583 NAND2_X1
* cell instance $17792 r0 *1 55.67,177.8
X$17792 8969 15 27 9524 CLKBUF_X3
* cell instance $17793 r0 *1 56.62,177.8
X$17793 9898 9522 15 27 9772 NAND2_X1
* cell instance $17794 r0 *1 57.19,177.8
X$17794 9524 15 27 10845 INV_X1
* cell instance $17798 r0 *1 58.9,177.8
X$17798 9843 9522 15 27 9844 NAND2_X1
* cell instance $17802 r0 *1 59.47,177.8
X$17802 7271 15 27 9792 CLKBUF_X3
* cell instance $17804 r0 *1 61.18,177.8
X$17804 7271 15 27 9796 CLKBUF_X3
* cell instance $17808 r0 *1 64.22,177.8
X$17808 9664 9517 15 27 9585 NAND2_X1
* cell instance $17809 r0 *1 64.79,177.8
X$17809 9721 9517 15 27 9722 NAND2_X1
* cell instance $17810 m0 *1 65.17,177.8
X$17810 15 10397 9664 9586 9707 27 DFF_X1
* cell instance $17816 m0 *1 73.91,177.8
X$17816 9723 9648 15 27 9665 NAND2_X1
* cell instance $17817 m0 *1 74.48,177.8
X$17817 9528 9665 9643 15 9779 27 AOI21_X1
* cell instance $17820 m0 *1 77.52,177.8
X$17820 9528 9709 9708 15 9781 27 AOI21_X1
* cell instance $17824 r0 *1 65.36,177.8
X$17824 9584 9722 9463 15 9777 27 AOI21_X1
* cell instance $17826 r0 *1 66.31,177.8
X$17826 15 10632 9721 9777 9707 27 DFF_X1
* cell instance $17828 r0 *1 70.3,177.8
X$17828 15 10634 9723 9779 9559 27 DFF_X1
* cell instance $17831 r0 *1 74.1,177.8
X$17831 9528 9801 9465 15 9780 27 AOI21_X1
* cell instance $17832 r0 *1 74.86,177.8
X$17832 15 10604 9724 9781 9277 27 DFF_X1
* cell instance $17833 r0 *1 78.09,177.8
X$17833 9724 9589 15 27 9709 NAND2_X1
* cell instance $17836 r0 *1 80.37,177.8
X$17836 15 10597 9725 9784 9277 27 DFF_X1
* cell instance $17838 m0 *1 83.22,177.8
X$17838 8583 9666 15 27 9727 NAND2_X1
* cell instance $17840 r0 *1 83.6,177.8
X$17840 9297 9726 9727 15 9784 27 AOI21_X1
* cell instance $17842 m0 *1 85.12,177.8
X$17842 8208 9666 15 27 9854 NAND2_X1
* cell instance $17845 m0 *1 87.21,177.8
X$17845 9528 9786 9466 15 9728 27 AOI21_X1
* cell instance $17846 m0 *1 87.97,177.8
X$17846 8729 9666 15 27 9729 NAND2_X1
* cell instance $17851 m0 *1 94.05,177.8
X$17851 9667 9711 9397 15 9710 27 AOI21_X1
* cell instance $17854 m0 *1 95.76,177.8
X$17854 9593 9713 9712 15 9731 27 AOI21_X1
* cell instance $17858 r0 *1 86.26,177.8
X$17858 15 10620 9730 9728 9868 27 DFF_X1
* cell instance $17859 r0 *1 89.49,177.8
X$17859 9730 9589 15 27 9786 NAND2_X1
* cell instance $17862 r0 *1 91.2,177.8
X$17862 15 10627 9803 9710 9530 27 DFF_X1
* cell instance $17864 r0 *1 94.81,177.8
X$17864 15 10614 9732 9731 9232 27 DFF_X1
* cell instance $17866 m0 *1 97.66,177.8
X$17866 9732 9589 15 27 9713 NAND2_X1
* cell instance $17868 m0 *1 99.18,177.8
X$17868 9528 9715 9588 15 9733 27 AOI21_X1
* cell instance $17870 m0 *1 100.7,177.8
X$17870 9668 9648 15 27 9715 NAND2_X1
* cell instance $17875 r0 *1 98.61,177.8
X$17875 15 10595 9668 9733 9232 27 DFF_X1
* cell instance $17878 r0 *1 102.41,177.8
X$17878 8420 15 27 9804 BUF_X2
* cell instance $17879 m0 *1 102.6,177.8
X$17879 8420 15 27 9666 CLKBUF_X3
* cell instance $17882 m0 *1 103.74,177.8
X$17882 9307 15 27 9593 CLKBUF_X3
* cell instance $17883 m0 *1 104.69,177.8
X$17883 15 10342 9787 9651 9400 27 DFF_X1
* cell instance $17887 r0 *1 103.74,177.8
X$17887 9667 9789 9734 15 9805 27 AOI21_X1
* cell instance $17889 r0 *1 104.69,177.8
X$17889 9788 9648 15 27 9789 NAND2_X1
* cell instance $17892 m0 *1 108.49,177.8
X$17892 15 10288 9735 9650 9400 27 DFF_X1
* cell instance $17894 m0 *1 111.72,177.8
X$17894 15 10289 9785 9594 9595 27 DFF_X1
* cell instance $17896 m0 *1 115.71,177.8
X$17896 7558 9535 15 27 9809 NAND2_X1
* cell instance $17897 m0 *1 116.28,177.8
X$17897 7380 9535 15 27 9736 NAND2_X1
* cell instance $17898 m0 *1 116.85,177.8
X$17898 7014 9535 15 27 9782 NAND2_X1
* cell instance $17900 m0 *1 117.61,177.8
X$17900 7669 9535 15 27 9876 NAND2_X1
* cell instance $17902 m0 *1 119.7,177.8
X$17902 9307 15 27 9304 CLKBUF_X3
* cell instance $17903 m0 *1 120.65,177.8
X$17903 7563 9535 15 27 9737 NAND2_X1
* cell instance $17905 m0 *1 121.41,177.8
X$17905 7389 9535 15 27 9946 NAND2_X1
* cell instance $17907 m0 *1 125.02,177.8
X$17907 8590 9536 15 27 9850 NAND2_X1
* cell instance $17908 m0 *1 125.59,177.8
X$17908 8028 9536 15 27 9670 NAND2_X1
* cell instance $17909 m0 *1 126.16,177.8
X$17909 7945 9536 15 27 9671 NAND2_X1
* cell instance $17910 m0 *1 126.73,177.8
X$17910 8332 9536 15 27 9848 NAND2_X1
* cell instance $17911 m0 *1 127.3,177.8
X$17911 8418 9536 15 27 9841 NAND2_X1
* cell instance $17912 m0 *1 127.87,177.8
X$17912 9539 9705 9706 15 9776 27 AOI21_X1
* cell instance $17916 m0 *1 136.42,177.8
X$17916 9120 9704 8861 15 9738 27 AOI21_X1
* cell instance $17917 m0 *1 137.18,177.8
X$17917 9703 9672 15 27 9704 NAND2_X1
* cell instance $17919 m0 *1 139.27,177.8
X$17919 9120 9702 8631 15 9771 27 AOI21_X1
* cell instance $17923 m0 *1 144.02,177.8
X$17923 9539 9699 9635 15 9764 27 AOI21_X1
* cell instance $17924 m0 *1 144.78,177.8
X$17924 15 10368 9673 9764 9316 27 DFF_X1
* cell instance $17927 r0 *1 108.49,177.8
X$17927 8386 9666 15 27 9806 NAND2_X1
* cell instance $17929 r0 *1 109.25,177.8
X$17929 9400 15 27 CLKBUF_X1
* cell instance $17930 r0 *1 109.82,177.8
X$17930 8752 15 27 9400 CLKBUF_X3
* cell instance $17931 r0 *1 110.77,177.8
X$17931 9593 9807 9472 15 9808 27 AOI21_X1
* cell instance $17932 r0 *1 111.53,177.8
X$17932 9735 9589 15 27 9714 NAND2_X1
* cell instance $17933 r0 *1 112.1,177.8
X$17933 9785 9589 15 27 9669 NAND2_X1
* cell instance $17940 r0 *1 116.66,177.8
X$17940 9304 9783 9736 15 9810 27 AOI21_X1
* cell instance $17948 r0 *1 125.4,177.8
X$17948 9539 9778 9670 15 9849 27 AOI21_X1
* cell instance $17950 r0 *1 126.92,177.8
X$17950 15 10494 9775 9776 9404 27 DFF_X1
* cell instance $17951 r0 *1 130.15,177.8
X$17951 9775 9816 15 27 9705 NAND2_X1
* cell instance $17953 r0 *1 132.24,177.8
X$17953 9120 9774 8636 15 9847 27 AOI21_X1
* cell instance $17955 r0 *1 133.76,177.8
X$17955 9813 9672 15 27 9774 NAND2_X1
* cell instance $17957 r0 *1 134.71,177.8
X$17957 9120 9773 8554 15 9845 27 AOI21_X1
* cell instance $17959 r0 *1 135.66,177.8
X$17959 15 10475 9703 9738 9404 27 DFF_X1
* cell instance $17960 r0 *1 138.89,177.8
X$17960 15 10578 9740 9771 9739 27 DFF_X1
* cell instance $17961 r0 *1 142.12,177.8
X$17961 9740 9672 15 27 9702 NAND2_X1
* cell instance $17964 r0 *1 143.64,177.8
X$17964 9539 9763 9604 15 9765 27 AOI21_X1
* cell instance $17965 r0 *1 144.4,177.8
X$17965 15 10525 9741 9765 9316 27 DFF_X1
* cell instance $17966 r0 *1 147.63,177.8
X$17966 9741 9816 15 27 9763 NAND2_X1
* cell instance $17967 r0 *1 148.2,177.8
X$17967 9673 9816 15 27 9699 NAND2_X1
* cell instance $17988 r0 *1 14.63,7
X$17988 226 270 27 15 271 XNOR2_X1
* cell instance $17993 r0 *1 21.28,7
X$17993 314 272 312 313 27 311 15 NOR4_X2
* cell instance $17996 r0 *1 24.7,7
X$17996 223 273 274 27 314 15 OAI21_X1
* cell instance $17997 r0 *1 25.46,7
X$17997 208 223 226 15 27 274 NAND3_X1
* cell instance $18001 r0 *1 28.88,7
X$18001 275 224 15 27 276 NAND2_X1
* cell instance $18004 r0 *1 30.59,7
X$18004 316 277 318 225 278 27 15 AOI211_X2
* cell instance $18005 r0 *1 32.3,7
X$18005 208 224 15 27 225 NOR2_X1
* cell instance $18006 r0 *1 32.87,7
X$18006 225 15 27 279 INV_X1
* cell instance $18009 r0 *1 35.53,7
X$18009 321 322 320 279 317 15 27 OAI211_X2
* cell instance $18010 r0 *1 37.24,7
X$18010 226 227 15 281 27 NAND2_X4
* cell instance $18012 m0 *1 37.43,7
X$18012 260 208 15 227 27 NAND2_X4
* cell instance $18017 r0 *1 38.95,7
X$18017 283 366 263 227 316 27 15 AOI211_X2
* cell instance $18018 r0 *1 40.66,7
X$18018 227 15 27 367 INV_X1
* cell instance $18020 r0 *1 41.8,7
X$18020 275 284 15 27 263 NAND2_X1
* cell instance $18022 r0 *1 42.75,7
X$18022 224 226 15 27 284 NOR2_X2
* cell instance $18027 r0 *1 49.4,7
X$18027 285 323 27 15 393 XNOR2_X1
* cell instance $18028 r0 *1 50.54,7
X$18028 228 15 27 285 INV_X1
* cell instance $18029 m0 *1 51.68,7
X$18029 138 289 191 27 15 229 HA_X1
* cell instance $18030 m0 *1 50.92,7
X$18030 229 191 192 15 323 27 AOI21_X1
* cell instance $18032 r0 *1 50.92,7
X$18032 195 288 228 27 15 286 HA_X1
* cell instance $18033 r0 *1 52.82,7
X$18033 286 229 228 15 287 27 AOI21_X1
* cell instance $18034 r0 *1 53.58,7
X$18034 228 191 230 15 27 193 NAND3_X2
* cell instance $18036 m0 *1 53.96,7
X$18036 191 192 15 27 326 XOR2_X1
* cell instance $18038 m0 *1 57.95,7
X$18038 212 231 95 27 15 67 HA_X1
* cell instance $18039 m0 *1 55.48,7
X$18039 15 515 193 66 148 27 AOI21_X4
* cell instance $18040 m0 *1 59.85,7
X$18040 95 149 27 15 233 XNOR2_X1
* cell instance $18041 m0 *1 60.99,7
X$18041 179 15 27 20 BUF_X1
* cell instance $18045 r0 *1 55.86,7
X$18045 289 370 326 15 27 327 MUX2_X1
* cell instance $18046 r0 *1 57.19,7
X$18046 95 415 65 20 15 399 27 NAND4_X2
* cell instance $18047 r0 *1 58.9,7
X$18047 232 370 233 15 328 27 AOI21_X2
* cell instance $18054 m0 *1 62.89,7
X$18054 69 15 27 401 INV_X1
* cell instance $18057 m0 *1 64.03,7
X$18057 21 151 27 15 331 XNOR2_X1
* cell instance $18058 m0 *1 65.17,7
X$18058 21 71 69 15 27 473 NAND3_X1
* cell instance $18059 m0 *1 65.93,7
X$18059 212 234 21 27 15 102 HA_X1
* cell instance $18060 m0 *1 67.83,7
X$18060 104 15 27 44 INV_X1
* cell instance $18062 r0 *1 62.7,7
X$18062 332 290 180 15 27 231 MUX2_X1
* cell instance $18063 r0 *1 64.03,7
X$18063 234 334 331 15 27 289 MUX2_X1
* cell instance $18066 r0 *1 67.07,7
X$18066 235 152 334 27 15 288 MUX2_X2
* cell instance $18067 m0 *1 71.82,7
X$18067 45 136 22 27 237 15 NOR3_X2
* cell instance $18068 m0 *1 68.59,7
X$18068 15 112 153 214 154 155 27 OAI22_X4
* cell instance $18069 m0 *1 73.15,7
X$18069 136 213 15 27 194 XNOR2_X2
* cell instance $18070 m0 *1 75.05,7
X$18070 195 156 113 27 15 45 HA_X1
* cell instance $18073 m0 *1 77.9,7
X$18073 77 78 27 15 338 XNOR2_X1
* cell instance $18074 m0 *1 79.04,7
X$18074 268 78 218 27 15 184 OAI21_X4
* cell instance $18075 m0 *1 81.51,7
X$18075 269 159 158 15 268 27 AOI21_X2
* cell instance $18080 m0 *1 95.95,7
X$18080 114 27 296 15 BUF_X4
* cell instance $18084 r0 *1 70.68,7
X$18084 236 15 27 335 INV_X1
* cell instance $18085 r0 *1 71.06,7
X$18085 335 154 75 237 27 337 15 OR4_X2
* cell instance $18089 r0 *1 76.57,7
X$18089 185 371 291 15 27 235 MUX2_X1
* cell instance $18090 r0 *1 77.9,7
X$18090 157 520 338 15 27 234 MUX2_X1
* cell instance $18091 r0 *1 79.23,7
X$18091 159 77 27 15 417 AND2_X1
* cell instance $18094 r0 *1 80.56,7
X$18094 212 291 159 27 15 269 HA_X1
* cell instance $18099 r0 *1 90.63,7
X$18099 195 15 27 294 INV_X1
* cell instance $18101 r0 *1 92.53,7
X$18101 295 15 27 340 INV_X1
* cell instance $18102 r0 *1 92.91,7
X$18102 342 340 238 27 15 396 HA_X1
* cell instance $18105 r0 *1 95.76,7
X$18105 219 296 298 27 15 342 OAI21_X2
* cell instance $18106 r0 *1 97.09,7
X$18106 343 160 15 27 297 NAND2_X1
* cell instance $18107 m0 *1 97.66,7
X$18107 221 220 160 27 219 15 OAI21_X1
* cell instance $18108 m0 *1 98.42,7
X$18108 161 196 240 27 15 220 AND3_X1
* cell instance $18110 m0 *1 99.56,7
X$18110 15 221 161 240 196 27 AOI21_X4
* cell instance $18111 m0 *1 102.03,7
X$18111 195 298 115 27 15 197 HA_X1
* cell instance $18113 m0 *1 104.12,7
X$18113 198 15 27 222 INV_X1
* cell instance $18114 m0 *1 104.5,7
X$18114 198 197 221 27 15 188 OAI21_X4
* cell instance $18116 m0 *1 107.16,7
X$18116 189 147 199 15 24 27 AOI21_X2
* cell instance $18117 m0 *1 108.49,7
X$18117 222 241 116 27 199 15 OAI21_X1
* cell instance $18119 m0 *1 109.44,7
X$18119 339 242 147 27 190 15 OAI21_X1
* cell instance $18120 m0 *1 110.2,7
X$18120 200 162 117 27 204 15 NOR3_X2
* cell instance $18122 m0 *1 111.72,7
X$18122 117 200 15 27 48 OR2_X2
* cell instance $18126 r0 *1 98.23,7
X$18126 239 346 27 15 343 XNOR2_X1
* cell instance $18128 r0 *1 99.75,7
X$18128 239 346 196 27 187 15 OAI21_X1
* cell instance $18129 r0 *1 100.51,7
X$18129 348 15 27 196 INV_X1
* cell instance $18133 r0 *1 103.36,7
X$18133 222 241 27 15 347 XNOR2_X1
* cell instance $18134 r0 *1 104.5,7
X$18134 295 299 198 27 15 242 HA_X1
* cell instance $18135 r0 *1 106.4,7
X$18135 452 15 27 147 BUF_X2
* cell instance $18136 r0 *1 107.16,7
X$18136 241 222 15 27 389 NOR2_X1
* cell instance $18137 r0 *1 107.73,7
X$18137 242 15 27 116 INV_X1
* cell instance $18140 r0 *1 110.01,7
X$18140 15 117 300 243 301 27 AOI21_X4
* cell instance $18141 r0 *1 112.48,7
X$18141 300 301 243 27 15 200 AND3_X2
* cell instance $18143 m0 *1 113.24,7
X$18143 117 200 24 15 27 163 OR3_X2
* cell instance $18144 m0 *1 114.38,7
X$18144 51 244 82 15 267 27 AOI21_X1
* cell instance $18146 m0 *1 115.33,7
X$18146 164 267 15 27 165 XOR2_X1
* cell instance $18148 m0 *1 116.66,7
X$18148 201 165 15 27 166 OR2_X1
* cell instance $18151 m0 *1 119.7,7
X$18151 204 52 110 118 48 27 15 141 OAI221_X1
* cell instance $18153 m0 *1 121.6,7
X$18153 48 118 167 27 202 15 OAI21_X1
* cell instance $18154 m0 *1 122.36,7
X$18154 15 63 139 216 217 215 27 AND4_X4
* cell instance $18155 m0 *1 124.83,7
X$18155 64 32 15 27 329 NOR2_X1
* cell instance $18156 m0 *1 125.4,7
X$18156 64 32 121 87 15 27 265 NOR4_X1
* cell instance $18158 m0 *1 126.54,7
X$18158 32 204 324 15 27 431 NOR3_X1
* cell instance $18160 m0 *1 127.49,7
X$18160 203 84 51 15 27 206 NOR3_X1
* cell instance $18161 m0 *1 128.25,7
X$18161 204 84 15 27 122 OR2_X1
* cell instance $18164 r0 *1 113.62,7
X$18164 301 243 27 15 82 AND2_X1
* cell instance $18165 r0 *1 114.38,7
X$18165 164 244 82 15 49 27 AOI21_X1
* cell instance $18175 r0 *1 121.22,7
X$18175 52 84 15 27 333 NOR2_X1
* cell instance $18176 r0 *1 121.79,7
X$18176 202 266 303 15 120 27 NAND3_X4
* cell instance $18177 r0 *1 124.26,7
X$18177 490 330 265 15 27 216 NOR3_X1
* cell instance $18180 r0 *1 125.59,7
X$18180 15 169 245 137 246 52 27 NAND4_X4
* cell instance $18181 r0 *1 129.01,7
X$18181 245 169 246 15 27 203 NAND3_X1
* cell instance $18183 m0 *1 130.34,7
X$18183 57 205 15 27 169 XNOR2_X2
* cell instance $18186 m0 *1 133,7
X$18186 170 211 27 15 183 AND2_X1
* cell instance $18187 m0 *1 133.76,7
X$18187 15 182 123 124 87 172 27 OAI211_X4
* cell instance $18189 m0 *1 137.75,7
X$18189 58 247 256 15 181 27 AOI21_X1
* cell instance $18193 r0 *1 136.99,7
X$18193 55 319 15 27 53 XNOR2_X2
* cell instance $18194 m0 *1 139.46,7
X$18194 259 56 173 15 27 178 NOR3_X1
* cell instance $18195 m0 *1 138.89,7
X$18195 259 173 15 27 125 NAND2_X1
* cell instance $18196 m0 *1 140.22,7
X$18196 249 56 15 27 210 NOR2_X1
* cell instance $18197 m0 *1 140.79,7
X$18197 210 100 264 15 132 27 AOI21_X1
* cell instance $18199 m0 *1 141.74,7
X$18199 56 249 27 15 264 AND2_X1
* cell instance $18201 m0 *1 143.26,7
X$18201 261 128 176 27 15 172 MUX2_X2
* cell instance $18202 m0 *1 144.97,7
X$18202 259 252 128 15 27 209 NAND3_X1
* cell instance $18203 m0 *1 145.73,7
X$18203 209 176 253 27 15 124 OAI21_X2
* cell instance $18205 r0 *1 138.89,7
X$18205 306 100 15 27 319 NAND2_X1
* cell instance $18209 r0 *1 140.79,7
X$18209 306 92 15 27 248 NAND2_X1
* cell instance $18210 r0 *1 141.36,7
X$18210 251 248 27 15 262 XNOR2_X1
* cell instance $18211 r0 *1 142.5,7
X$18211 250 377 315 27 15 261 AND3_X1
* cell instance $18212 r0 *1 143.45,7
X$18212 250 251 27 15 128 AND2_X2
* cell instance $18214 r0 *1 144.59,7
X$18214 250 377 252 315 15 27 253 OR4_X1
* cell instance $18218 m0 *1 147.63,7
X$18218 255 252 247 256 130 27 15 AOI211_X2
* cell instance $18219 m0 *1 149.34,7
X$18219 258 307 15 27 182 XNOR2_X2
* cell instance $18220 m0 *1 151.24,7
X$18220 258 129 15 27 96 NOR2_X2
* cell instance $18229 r0 *1 148.01,7
X$18229 254 380 250 15 27 255 NAND3_X1
* cell instance $18230 r0 *1 148.77,7
X$18230 254 250 15 27 257 NAND2_X1
* cell instance $18232 r0 *1 149.72,7
X$18232 308 442 15 27 258 XNOR2_X2
* cell instance $18253 m0 *1 9.88,169.4
X$18253 7533 15 27 8805 CLKBUF_X3
* cell instance $18255 m0 *1 12.35,169.4
X$18255 9250 8805 15 27 9252 NAND2_X1
* cell instance $18267 r0 *1 12.16,169.4
X$18267 9416 8805 15 27 9287 NAND2_X1
* cell instance $18268 r0 *1 12.73,169.4
X$18268 9222 9287 9333 15 9334 27 AOI21_X1
* cell instance $18271 m0 *1 15.77,169.4
X$18271 15 9223 8916 10725 8404 27 DFF_X2
* cell instance $18275 r0 *1 15.77,169.4
X$18275 9389 8805 15 27 9288 NAND2_X1
* cell instance $18276 r0 *1 16.34,169.4
X$18276 9222 9288 9337 15 9419 27 AOI21_X1
* cell instance $18278 m0 *1 26.03,169.4
X$18278 15 10453 8502 9260 8873 27 DFF_X1
* cell instance $18279 m0 *1 22.8,169.4
X$18279 15 10429 8624 9340 9289 27 DFF_X1
* cell instance $18282 m0 *1 30.97,169.4
X$18282 15 9225 9224 10649 8403 27 DFF_X2
* cell instance $18283 m0 *1 34.58,169.4
X$18283 15 9212 9224 10729 8166 27 DFF_X2
* cell instance $18284 m0 *1 38.19,169.4
X$18284 15 10414 8402 9350 9226 27 DFF_X1
* cell instance $18287 m0 *1 47.69,169.4
X$18287 8969 15 27 9226 CLKBUF_X3
* cell instance $18288 m0 *1 48.64,169.4
X$18288 9226 15 27 CLKBUF_X1
* cell instance $18292 r0 *1 23.94,169.4
X$18292 15 10549 8733 9341 9289 27 DFF_X1
* cell instance $18294 r0 *1 27.55,169.4
X$18294 15 10511 8005 9342 8873 27 DFF_X1
* cell instance $18297 r0 *1 32.49,169.4
X$18297 15 10545 8576 9346 9224 27 DFF_X1
* cell instance $18301 r0 *1 38.19,169.4
X$18301 8635 9291 15 27 9337 NAND2_X1
* cell instance $18304 r0 *1 39.71,169.4
X$18304 8060 9352 8634 15 9290 27 AOI21_X1
* cell instance $18305 r0 *1 40.47,169.4
X$18305 9435 7924 15 27 9352 NAND2_X1
* cell instance $18309 r0 *1 45.98,169.4
X$18309 15 9355 9226 10734 8009 27 DFF_X2
* cell instance $18310 r0 *1 49.59,169.4
X$18310 8506 9291 15 27 9292 NAND2_X1
* cell instance $18313 r0 *1 52.06,169.4
X$18313 6741 9291 15 27 9293 NAND2_X1
* cell instance $18316 m0 *1 52.63,169.4
X$18316 15 10423 8385 9227 9226 27 DFF_X1
* cell instance $18318 m0 *1 56.81,169.4
X$18318 15 10418 9107 9273 9358 27 DFF_X1
* cell instance $18320 m0 *1 60.23,169.4
X$18320 5192 15 27 7533 CLKBUF_X3
* cell instance $18321 m0 *1 61.18,169.4
X$18321 15 7862 7624 27 BUF_X16
* cell instance $18325 r0 *1 54.53,169.4
X$18325 8385 9291 15 27 9720 NAND2_X1
* cell instance $18329 r0 *1 57.57,169.4
X$18329 8203 9291 15 27 9459 NAND2_X1
* cell instance $18335 r0 *1 59.85,169.4
X$18335 8581 9291 15 27 9461 NAND2_X1
* cell instance $18338 m0 *1 68.02,169.4
X$18338 15 8207 7862 27 BUF_X16
* cell instance $18342 r0 *1 69.54,169.4
X$18342 15 8207 7734 27 BUF_X16
* cell instance $18345 m0 *1 74.67,169.4
X$18345 15 10462 8653 9361 8972 27 DFF_X1
* cell instance $18347 r0 *1 75.43,169.4
X$18347 8112 9112 15 9278 27 NAND2_X4
* cell instance $18348 r0 *1 77.14,169.4
X$18348 15 10622 8114 9175 9277 27 DFF_X1
* cell instance $18350 m0 *1 78.28,169.4
X$18350 6744 9070 8746 6181 9111 9361 15 27 OAI221_X2
* cell instance $18352 r0 *1 80.37,169.4
X$18352 15 10633 8584 9364 9220 27 DFF_X1
* cell instance $18353 m0 *1 83.22,169.4
X$18353 8208 9112 15 9283 27 NAND2_X4
* cell instance $18354 m0 *1 81.51,169.4
X$18354 8584 8887 15 9282 27 NAND2_X4
* cell instance $18355 m0 *1 84.93,169.4
X$18355 15 10406 8515 9230 9220 27 DFF_X1
* cell instance $18359 m0 *1 93.48,169.4
X$18359 15 10340 8212 9094 9232 27 DFF_X1
* cell instance $18362 m0 *1 98.99,169.4
X$18362 8561 9233 15 27 9294 NAND2_X1
* cell instance $18364 m0 *1 99.75,169.4
X$18364 8301 9233 15 27 9370 NAND2_X1
* cell instance $18369 r0 *1 85.69,169.4
X$18369 15 10600 8652 9366 9220 27 DFF_X1
* cell instance $18370 r0 *1 88.92,169.4
X$18370 8752 15 27 9220 CLKBUF_X3
* cell instance $18374 r0 *1 99.18,169.4
X$18374 15 10464 9300 9369 9177 27 DFF_X1
* cell instance $18375 m0 *1 100.89,169.4
X$18375 9297 9368 9370 15 9369 27 AOI21_X1
* cell instance $18379 m0 *1 102.6,169.4
X$18379 8513 9233 15 27 9295 NAND2_X1
* cell instance $18381 m0 *1 103.93,169.4
X$18381 8752 15 27 9177 CLKBUF_X3
* cell instance $18382 m0 *1 104.88,169.4
X$18382 9177 15 27 CLKBUF_X1
* cell instance $18383 m0 *1 105.45,169.4
X$18383 8562 9233 15 27 9298 NAND2_X1
* cell instance $18384 m0 *1 106.02,169.4
X$18384 8649 9233 15 27 9371 NAND2_X1
* cell instance $18386 m0 *1 106.78,169.4
X$18386 9297 9444 9371 15 9372 27 AOI21_X1
* cell instance $18388 m0 *1 108.3,169.4
X$18388 7171 9233 15 27 9375 NAND2_X1
* cell instance $18390 m0 *1 109.06,169.4
X$18390 8420 15 27 9233 BUF_X2
* cell instance $18391 m0 *1 109.82,169.4
X$18391 8415 9233 15 27 9302 NAND2_X1
* cell instance $18395 m0 *1 112.86,169.4
X$18395 6550 9233 15 27 9379 NAND2_X1
* cell instance $18398 m0 *1 115.14,169.4
X$18398 6981 9233 15 27 9378 NAND2_X1
* cell instance $18399 m0 *1 115.71,169.4
X$18399 6939 9233 15 27 9381 NAND2_X1
* cell instance $18401 m0 *1 116.47,169.4
X$18401 15 10361 9235 9383 9234 27 DFF_X1
* cell instance $18406 r0 *1 102.6,169.4
X$18406 15 10473 9299 9296 9177 27 DFF_X1
* cell instance $18407 r0 *1 105.83,169.4
X$18407 9300 9301 15 27 9368 NAND2_X1
* cell instance $18408 r0 *1 106.4,169.4
X$18408 15 10628 9399 9372 9177 27 DFF_X1
* cell instance $18410 r0 *1 109.82,169.4
X$18410 9297 9376 9302 15 9377 27 AOI21_X1
* cell instance $18411 r0 *1 110.58,169.4
X$18411 15 10469 9306 9377 9177 27 DFF_X1
* cell instance $18412 r0 *1 113.81,169.4
X$18412 9306 9301 15 27 9376 NAND2_X1
* cell instance $18418 r0 *1 115.33,169.4
X$18418 9304 9305 9379 15 9303 27 AOI21_X1
* cell instance $18419 r0 *1 116.09,169.4
X$18419 9441 9301 15 27 9305 NAND2_X1
* cell instance $18421 r0 *1 116.85,169.4
X$18421 9304 9382 9378 15 9383 27 AOI21_X1
* cell instance $18422 r0 *1 117.61,169.4
X$18422 9235 9301 15 27 9382 NAND2_X1
* cell instance $18426 r0 *1 119.51,169.4
X$18426 5704 15 27 9307 CLKBUF_X3
* cell instance $18432 r0 *1 122.17,169.4
X$18432 9234 15 27 CLKBUF_X1
* cell instance $18433 m0 *1 122.93,169.4
X$18433 7640 9236 15 27 9387 NAND2_X1
* cell instance $18434 m0 *1 122.36,169.4
X$18434 7739 9236 15 27 9386 NAND2_X1
* cell instance $18436 m0 *1 123.69,169.4
X$18436 5192 15 27 9309 CLKBUF_X3
* cell instance $18437 m0 *1 124.64,169.4
X$18437 15 10285 9237 9384 9234 27 DFF_X1
* cell instance $18440 r0 *1 122.74,169.4
X$18440 8280 15 27 9234 CLKBUF_X3
* cell instance $18441 r0 *1 123.69,169.4
X$18441 9241 9385 9386 15 9308 27 AOI21_X1
* cell instance $18442 r0 *1 124.45,169.4
X$18442 9241 9380 9387 15 9388 27 AOI21_X1
* cell instance $18443 r0 *1 125.21,169.4
X$18443 9402 9310 15 27 9385 NAND2_X1
* cell instance $18444 r0 *1 125.78,169.4
X$18444 9403 9310 15 27 9380 NAND2_X1
* cell instance $18447 r0 *1 126.92,169.4
X$18447 9241 9374 9280 15 9311 27 AOI21_X1
* cell instance $18448 r0 *1 127.68,169.4
X$18448 9373 9310 15 27 9374 NAND2_X1
* cell instance $18450 m0 *1 129.2,169.4
X$18450 8420 15 27 9236 BUF_X2
* cell instance $18456 r0 *1 130.91,169.4
X$18456 15 10617 9314 9313 9404 27 DFF_X1
* cell instance $18457 m0 *1 131.29,169.4
X$18457 8030 9236 15 27 9312 NAND2_X1
* cell instance $18459 m0 *1 131.86,169.4
X$18459 9241 9367 9238 15 9313 27 AOI21_X1
* cell instance $18460 m0 *1 132.62,169.4
X$18460 8526 9236 15 27 9439 NAND2_X1
* cell instance $18461 m0 *1 133.19,169.4
X$18461 7778 9236 15 27 9509 NAND2_X1
* cell instance $18462 m0 *1 133.76,169.4
X$18462 9314 8896 15 27 9367 NAND2_X1
* cell instance $18463 m0 *1 134.33,169.4
X$18463 6822 9236 15 27 9315 NAND2_X1
* cell instance $18464 m0 *1 134.9,169.4
X$18464 8035 9236 15 27 9365 NAND2_X1
* cell instance $18467 m0 *1 136.04,169.4
X$18467 15 10301 9274 9240 9179 27 DFF_X1
* cell instance $18472 m0 *1 146.3,169.4
X$18472 15 9122 9362 9360 8985 8712 27 FA_X1
* cell instance $18475 m0 *1 150.29,169.4
X$18475 9360 15 27 9269 INV_X1
* cell instance $18476 m0 *1 150.67,169.4
X$18476 9244 9269 9432 27 15 9318 HA_X1
* cell instance $18478 m0 *1 154.09,169.4
X$18478 9319 15 27 9244 INV_X1
* cell instance $18482 r0 *1 140.79,169.4
X$18482 9241 9436 9365 15 9363 27 AOI21_X1
* cell instance $18483 r0 *1 141.55,169.4
X$18483 15 10551 9431 9363 9316 27 DFF_X1
* cell instance $18488 r0 *1 147.63,169.4
X$18488 9362 15 27 9433 INV_X1
* cell instance $18492 r0 *1 151.62,169.4
X$18492 9318 15 27 9317 INV_X1
* cell instance $18495 m0 *1 154.85,169.4
X$18495 15 9246 9552 9320 9359 8597 27 FA_X1
* cell instance $18497 m0 *1 160.17,169.4
X$18497 7319 7489 10853 27 15 9412 HA_X1
* cell instance $18502 m0 *1 170.62,169.4
X$18502 9248 15 27 9323 INV_X1
* cell instance $18504 m0 *1 171.19,169.4
X$18504 9191 15 27 9324 INV_X1
* cell instance $18510 r0 *1 157.7,169.4
X$18510 7708 8712 9319 27 15 10918 HA_X1
* cell instance $18513 r0 *1 160.55,169.4
X$18513 8712 15 27 7489 INV_X4
* cell instance $18514 r0 *1 161.5,169.4
X$18514 8128 7708 9357 27 15 10920 HA_X1
* cell instance $18517 r0 *1 165.3,169.4
X$18517 15 8712 9142 9322 8128 7708 27 FA_X1
* cell instance $18520 r0 *1 170.05,169.4
X$18520 9324 9323 9321 27 15 9353 HA_X1
* cell instance $18525 r0 *1 172.14,169.4
X$18525 9353 15 27 9351 INV_X1
* cell instance $18526 r0 *1 172.52,169.4
X$18526 9326 9351 9354 27 15 9349 HA_X1
* cell instance $18527 m0 *1 173.66,169.4
X$18527 9348 15 27 9326 INV_X1
* cell instance $18532 m0 *1 178.79,169.4
X$18532 9347 9345 9249 15 9138 27 AOI21_X1
* cell instance $18534 m0 *1 179.74,169.4
X$18534 9329 15 27 9345 INV_X1
* cell instance $18535 m0 *1 180.12,169.4
X$18535 9255 9195 9336 27 15 9343 HA_X1
* cell instance $18536 m0 *1 182.02,169.4
X$18536 15 9254 9338 9339 9335 9193 27 FA_X1
* cell instance $18537 m0 *1 185.06,169.4
X$18537 9338 15 27 9331 INV_X1
* cell instance $18540 r0 *1 174.42,169.4
X$18540 9349 15 27 9328 INV_X1
* cell instance $18543 r0 *1 176.51,169.4
X$18543 9256 15 27 9421 INV_X1
* cell instance $18546 r0 *1 177.84,169.4
X$18546 9052 9344 9420 27 15 9329 HA_X1
* cell instance $18549 r0 *1 180.31,169.4
X$18549 15 9330 9344 9417 9343 8909 27 FA_X1
* cell instance $18550 r0 *1 183.35,169.4
X$18550 15 9331 9330 9415 9336 9332 27 FA_X1
* cell instance $18553 m0 *1 186.58,169.4
X$18553 9054 15 27 9332 INV_X1
* cell instance $18561 m0 *1 10.45,79.8
X$18561 4427 3906 15 27 4645 XNOR2_X2
* cell instance $18563 m0 *1 12.54,79.8
X$18563 3906 4427 27 4428 15 XOR2_X2
* cell instance $18565 m0 *1 14.44,79.8
X$18565 4288 3874 27 15 4374 AND2_X1
* cell instance $18566 m0 *1 15.2,79.8
X$18566 4065 4012 4210 15 27 4437 NAND3_X2
* cell instance $18568 m0 *1 16.72,79.8
X$18568 15 4097 4270 3679 3396 27 NOR3_X4
* cell instance $18569 m0 *1 19.38,79.8
X$18569 15 4374 3930 3463 4212 4472 27 NAND4_X4
* cell instance $18570 m0 *1 22.8,79.8
X$18570 3463 4212 4374 3930 27 15 4531 AND4_X2
* cell instance $18580 r0 *1 14.06,79.8
X$18580 4470 3931 15 27 4699 NAND2_X1
* cell instance $18581 r0 *1 14.63,79.8
X$18581 4065 4551 4470 15 4701 27 AOI21_X2
* cell instance $18584 r0 *1 17.67,79.8
X$18584 4066 4213 3147 15 27 4702 NAND3_X2
* cell instance $18586 r0 *1 19.38,79.8
X$18586 3931 4012 4270 27 15 4703 OAI21_X2
* cell instance $18587 r0 *1 20.71,79.8
X$18587 4646 4210 15 27 4706 NOR2_X1
* cell instance $18589 r0 *1 21.47,79.8
X$18589 4209 4210 4213 3679 27 15 4612 AND4_X2
* cell instance $18590 r0 *1 22.8,79.8
X$18590 15 4552 4097 3679 4213 27 AOI21_X4
* cell instance $18592 m0 *1 24.51,79.8
X$18592 4471 4531 4375 27 15 4219 OAI21_X4
* cell instance $18593 m0 *1 27.74,79.8
X$18593 4471 4297 4353 15 27 4535 NAND3_X1
* cell instance $18595 m0 *1 28.69,79.8
X$18595 15 4098 4216 4102 3884 4298 27 NOR4_X4
* cell instance $18596 m0 *1 32.11,79.8
X$18596 4445 4376 27 15 4473 AND2_X1
* cell instance $18597 m0 *1 32.87,79.8
X$18597 15 4098 4216 3884 4376 4474 27 NOR4_X4
* cell instance $18598 m0 *1 36.29,79.8
X$18598 15 4295 4296 4219 2900 27 NOR3_X4
* cell instance $18599 m0 *1 38.95,79.8
X$18599 15 4103 4361 4268 4102 4451 27 NAND4_X4
* cell instance $18600 m0 *1 42.37,79.8
X$18600 15 4223 4294 4293 3685 27 AOI21_X4
* cell instance $18601 m0 *1 44.84,79.8
X$18601 4451 3916 4379 15 27 NOR2_X4
* cell instance $18603 m0 *1 46.74,79.8
X$18603 4379 4108 4278 4453 4476 27 15 AOI211_X2
* cell instance $18604 m0 *1 48.45,79.8
X$18604 4183 4540 4222 15 3186 27 NAND3_X4
* cell instance $18608 r0 *1 25.27,79.8
X$18608 4531 4375 4649 15 27 NOR2_X4
* cell instance $18610 r0 *1 27.36,79.8
X$18610 15 4554 4553 4472 4291 27 AOI21_X4
* cell instance $18612 r0 *1 30.02,79.8
X$18612 4535 4293 4294 4472 4291 4475 27 15 AOI221_X2
* cell instance $18613 r0 *1 32.11,79.8
X$18613 15 4098 4216 3884 4293 27 NOR3_X4
* cell instance $18614 r0 *1 34.77,79.8
X$18614 4098 4216 3884 27 4555 15 OAI21_X1
* cell instance $18616 r0 *1 35.72,79.8
X$18616 4298 4297 4554 15 3583 27 NAND3_X4
* cell instance $18617 r0 *1 38.19,79.8
X$18617 4298 4297 4554 3182 27 15 3582 AND4_X2
* cell instance $18620 r0 *1 40.09,79.8
X$18620 4473 4474 3685 15 4362 27 AOI21_X2
* cell instance $18621 r0 *1 41.42,79.8
X$18621 4300 4538 4555 15 27 4627 NAND3_X1
* cell instance $18622 r0 *1 42.18,79.8
X$18622 3414 27 3685 15 BUF_X4
* cell instance $18623 r0 *1 43.51,79.8
X$18623 4624 2504 4625 15 4306 27 NAND3_X4
* cell instance $18624 r0 *1 45.98,79.8
X$18624 4378 4627 3916 4451 4541 4626 15 27 OAI221_X2
* cell instance $18625 r0 *1 48.07,79.8
X$18625 4380 15 27 4541 INV_X1
* cell instance $18626 r0 *1 48.45,79.8
X$18626 3186 4541 3889 4556 15 4558 27 NAND4_X2
* cell instance $18627 r0 *1 50.16,79.8
X$18627 4559 4379 4223 27 4719 15 OAI21_X1
* cell instance $18630 r0 *1 52.06,79.8
X$18630 3274 4224 15 27 4630 NOR2_X1
* cell instance $18631 r0 *1 52.63,79.8
X$18631 4223 4630 15 27 4544 XNOR2_X2
* cell instance $18632 r0 *1 54.53,79.8
X$18632 3243 3183 4222 15 27 4560 NAND3_X2
* cell instance $18633 m0 *1 55.29,79.8
X$18633 4301 4169 15 27 4455 XNOR2_X2
* cell instance $18636 m0 *1 57.95,79.8
X$18636 4306 4382 4455 4023 15 27 4477 NAND4_X1
* cell instance $18637 m0 *1 58.9,79.8
X$18637 4302 4228 4381 4303 27 4109 15 NOR4_X2
* cell instance $18638 m0 *1 60.61,79.8
X$18638 4382 4455 4023 15 27 4563 NAND3_X2
* cell instance $18639 m0 *1 61.94,79.8
X$18639 4382 4455 4305 4304 15 27 4383 NAND4_X1
* cell instance $18641 m0 *1 63.08,79.8
X$18641 4305 4304 15 27 4478 NAND2_X2
* cell instance $18646 r0 *1 56.43,79.8
X$18646 4455 3740 4722 27 15 4561 AND3_X1
* cell instance $18654 r0 *1 61.75,79.8
X$18654 4364 4229 4478 27 15 4482 OAI21_X4
* cell instance $18656 r0 *1 64.98,79.8
X$18656 4564 4306 4304 15 27 4634 NAND3_X1
* cell instance $18658 m0 *1 65.17,79.8
X$18658 3740 4455 15 27 4459 NOR2_X2
* cell instance $18660 r0 *1 65.74,79.8
X$18660 3740 4455 15 27 4480 NAND2_X1
* cell instance $18661 r0 *1 66.31,79.8
X$18661 4634 4544 4480 15 4660 27 AOI21_X2
* cell instance $18662 m0 *1 68.97,79.8
X$18662 4460 3861 3694 15 4464 27 AOI21_X2
* cell instance $18663 m0 *1 67.26,79.8
X$18663 4459 4384 4385 15 27 NOR2_X4
* cell instance $18666 m0 *1 72.01,79.8
X$18666 4385 4482 27 15 4386 AND2_X2
* cell instance $18667 m0 *1 72.96,79.8
X$18667 3808 4483 3745 3809 27 15 4484 OAI22_X1
* cell instance $18670 m0 *1 74.86,79.8
X$18670 4386 4464 15 27 4487 XNOR2_X2
* cell instance $18672 m0 *1 76.95,79.8
X$18672 4465 4464 4307 27 4486 15 OAI21_X1
* cell instance $18674 m0 *1 77.9,79.8
X$18674 4388 4387 27 15 4465 AND2_X1
* cell instance $18677 m0 *1 79.61,79.8
X$18677 4310 4485 4466 15 4548 27 AOI21_X2
* cell instance $18679 m0 *1 81.7,79.8
X$18679 15 4393 4548 4388 4387 27 AOI21_X4
* cell instance $18681 m0 *1 84.36,79.8
X$18681 4390 4487 15 27 4392 XNOR2_X2
* cell instance $18684 r0 *1 67.64,79.8
X$18684 4480 4544 15 27 4481 NAND2_X1
* cell instance $18686 r0 *1 68.59,79.8
X$18686 4635 27 3694 15 BUF_X4
* cell instance $18688 r0 *1 70.11,79.8
X$18688 4481 4482 27 15 4566 AND2_X1
* cell instance $18690 r0 *1 71.25,79.8
X$18690 4482 4481 15 27 4485 NAND2_X2
* cell instance $18691 r0 *1 72.2,79.8
X$18691 4566 4385 3808 15 27 4639 NAND3_X2
* cell instance $18692 r0 *1 73.53,79.8
X$18692 4566 4565 4640 15 27 4547 NAND3_X2
* cell instance $18694 r0 *1 75.24,79.8
X$18694 4307 4387 4386 4464 15 27 4641 AOI22_X1
* cell instance $18695 r0 *1 76.19,79.8
X$18695 4641 4566 4642 15 27 4490 MUX2_X1
* cell instance $18696 r0 *1 77.52,79.8
X$18696 4486 15 27 4642 INV_X1
* cell instance $18699 r0 *1 79.61,79.8
X$18699 4373 4117 4731 27 15 4643 AND3_X1
* cell instance $18701 r0 *1 80.94,79.8
X$18701 4485 4487 15 27 4568 OR2_X1
* cell instance $18703 r0 *1 82.46,79.8
X$18703 4116 3653 3510 27 15 4390 OAI21_X2
* cell instance $18706 r0 *1 84.93,79.8
X$18706 4390 4487 15 27 4644 XOR2_X1
* cell instance $18708 m0 *1 90.06,79.8
X$18708 3949 4036 3892 15 4075 27 NAND3_X4
* cell instance $18709 m0 *1 87.4,79.8
X$18709 15 4393 4232 4392 3892 27 NOR3_X4
* cell instance $18711 m0 *1 93.29,79.8
X$18711 4391 4392 4077 3871 15 27 4488 NOR4_X1
* cell instance $18712 m0 *1 94.24,79.8
X$18712 4005 4395 15 27 4245 XNOR2_X2
* cell instance $18715 m0 *1 99.94,79.8
X$18715 4396 4491 4315 4316 27 4276 15 OR4_X2
* cell instance $18716 m0 *1 101.27,79.8
X$18716 4396 4491 15 27 4638 OR2_X1
* cell instance $18717 m0 *1 102.03,79.8
X$18717 4316 4315 4396 15 27 4493 NOR3_X1
* cell instance $18718 m0 *1 102.79,79.8
X$18718 3917 4277 4039 4397 15 27 4492 NOR4_X1
* cell instance $18723 r0 *1 88.92,79.8
X$18723 3339 4004 3892 27 15 4571 AND3_X1
* cell instance $18724 r0 *1 89.87,79.8
X$18724 4644 3893 4004 15 4546 27 AOI21_X1
* cell instance $18725 r0 *1 90.63,79.8
X$18725 4392 4391 27 15 4572 AND2_X1
* cell instance $18726 r0 *1 91.39,79.8
X$18726 4546 4572 4075 4488 4313 27 15 AOI211_X2
* cell instance $18727 r0 *1 93.1,79.8
X$18727 15 4312 27 4197 BUF_X8
* cell instance $18728 r0 *1 95.57,79.8
X$18728 4281 27 2742 15 BUF_X4
* cell instance $18729 r0 *1 96.9,79.8
X$18729 4234 4391 4392 15 27 4489 NOR3_X1
* cell instance $18732 r0 *1 98.23,79.8
X$18732 4573 4075 4489 27 4574 15 OAI21_X1
* cell instance $18733 r0 *1 98.99,79.8
X$18733 4490 3069 4489 15 4545 27 AOI21_X1
* cell instance $18734 r0 *1 99.75,79.8
X$18734 3069 4490 4489 27 15 4637 AND3_X1
* cell instance $18736 r0 *1 101.46,79.8
X$18736 4317 4492 4638 4545 4637 4493 15 27 4495 OAI33_X1
* cell instance $18738 r0 *1 102.98,79.8
X$18738 4396 4317 4491 27 4740 15 OAI21_X1
* cell instance $18740 m0 *1 104.31,79.8
X$18740 4315 4397 15 27 4398 NOR2_X2
* cell instance $18742 m0 *1 105.26,79.8
X$18742 15 4039 4277 4491 3917 3822 27 NOR4_X4
* cell instance $18744 m0 *1 109.44,79.8
X$18744 4313 4398 4399 27 15 4496 AND3_X1
* cell instance $18748 r0 *1 104.88,79.8
X$18748 15 4494 4575 4491 4277 4039 27 OR4_X4
* cell instance $18750 r0 *1 107.54,79.8
X$18750 4494 3777 2811 15 27 NOR2_X4
* cell instance $18751 r0 *1 109.25,79.8
X$18751 4313 4399 4398 15 4578 27 AOI21_X2
* cell instance $18752 r0 *1 110.58,79.8
X$18752 3783 4398 4494 3777 4468 15 27 OAI211_X2
* cell instance $18753 m0 *1 111.72,79.8
X$18753 4400 4320 4323 15 27 4469 MUX2_X1
* cell instance $18756 m0 *1 113.24,79.8
X$18756 2811 4469 15 27 4401 OR2_X2
* cell instance $18758 m0 *1 114.38,79.8
X$18758 4280 4468 15 27 4497 XNOR2_X2
* cell instance $18760 m0 *1 117.8,79.8
X$18760 4632 4498 4129 27 4402 15 OAI21_X1
* cell instance $18762 m0 *1 118.75,79.8
X$18762 4542 27 4043 15 BUF_X4
* cell instance $18763 m0 *1 120.08,79.8
X$18763 4401 4497 4129 15 4585 27 NAND3_X4
* cell instance $18764 m0 *1 122.55,79.8
X$18764 4497 4401 4129 27 15 4500 AND3_X2
* cell instance $18769 r0 *1 113.24,79.8
X$18769 4323 4124 4577 15 27 4576 NAND3_X2
* cell instance $18770 r0 *1 114.57,79.8
X$18770 4319 4576 15 27 4632 OR2_X1
* cell instance $18774 r0 *1 115.33,79.8
X$18774 4578 4495 2132 4496 4679 27 15 AOI211_X2
* cell instance $18775 r0 *1 117.04,79.8
X$18775 2132 4496 27 15 4499 AND2_X1
* cell instance $18777 r0 *1 117.99,79.8
X$18777 4632 4498 4127 15 27 4542 OR3_X1
* cell instance $18780 r0 *1 120.08,79.8
X$18780 4578 4499 15 27 4581 NOR2_X2
* cell instance $18782 r0 *1 121.22,79.8
X$18782 4499 4578 15 27 4199 OR2_X1
* cell instance $18783 r0 *1 121.98,79.8
X$18783 4495 15 27 4539 CLKBUF_X2
* cell instance $18784 r0 *1 122.74,79.8
X$18784 4500 4199 15 27 4403 NAND2_X2
* cell instance $18786 r0 *1 124.07,79.8
X$18786 15 4328 4631 3995 4501 27 AOI21_X4
* cell instance $18788 m0 *1 124.83,79.8
X$18788 4403 3530 4404 15 4251 27 NAND3_X4
* cell instance $18789 m0 *1 127.49,79.8
X$18789 4585 3856 15 27 4326 NOR2_X1
* cell instance $18791 m0 *1 128.25,79.8
X$18791 15 4463 4357 4502 3709 4406 27 OAI22_X4
* cell instance $18792 m0 *1 131.48,79.8
X$18792 4405 4328 4354 15 27 3756 AND3_X4
* cell instance $18795 r0 *1 126.92,79.8
X$18795 4251 4580 15 27 4049 NAND2_X2
* cell instance $18799 r0 *1 129.2,79.8
X$18799 4354 4328 4405 4251 27 15 4502 AND4_X2
* cell instance $18800 r0 *1 130.53,79.8
X$18800 15 4406 4502 4503 4051 27 NOR3_X4
* cell instance $18801 r0 *1 133.19,79.8
X$18801 4586 4504 4354 15 27 NOR2_X4
* cell instance $18802 m0 *1 134.14,79.8
X$18802 4407 4539 4408 15 27 NOR2_X4
* cell instance $18804 m0 *1 135.85,79.8
X$18804 4405 4328 15 27 4458 NAND2_X1
* cell instance $18806 m0 *1 136.61,79.8
X$18806 4328 4456 3755 27 15 3009 MUX2_X2
* cell instance $18808 m0 *1 138.51,79.8
X$18808 4253 4049 4405 27 4415 15 OAI21_X1
* cell instance $18809 m0 *1 139.27,79.8
X$18809 4409 4252 4410 4411 27 15 2958 AND4_X2
* cell instance $18810 m0 *1 140.6,79.8
X$18810 3969 4132 15 27 4413 NOR2_X1
* cell instance $18811 m0 *1 141.17,79.8
X$18811 4409 4411 27 15 4412 AND2_X1
* cell instance $18812 m0 *1 141.93,79.8
X$18812 4413 4252 4408 4414 15 27 4505 NAND4_X1
* cell instance $18813 m0 *1 142.88,79.8
X$18813 4536 4505 4415 15 3966 27 AOI21_X1
* cell instance $18815 m0 *1 144.4,79.8
X$18815 4409 15 27 4452 INV_X1
* cell instance $18816 m0 *1 144.78,79.8
X$18816 15 4448 5091 4534 4332 4416 27 FA_X1
* cell instance $18821 r0 *1 135.47,79.8
X$18821 3647 4623 4328 27 4456 15 OAI21_X1
* cell instance $18822 r0 *1 136.23,79.8
X$18822 4458 3216 15 27 4588 NOR2_X1
* cell instance $18824 r0 *1 137.56,79.8
X$18824 4253 4503 4589 27 4622 15 NOR3_X2
* cell instance $18827 r0 *1 139.84,79.8
X$18827 4590 4329 27 15 4411 AND2_X1
* cell instance $18829 r0 *1 140.79,79.8
X$18829 4590 4591 27 15 4536 XNOR2_X1
* cell instance $18830 r0 *1 141.93,79.8
X$18830 4622 4414 27 4532 15 XOR2_X2
* cell instance $18832 r0 *1 145.16,79.8
X$18832 4594 4420 4621 27 15 4592 HA_X1
* cell instance $18833 r0 *1 147.06,79.8
X$18833 4530 4621 4617 27 15 4593 HA_X1
* cell instance $18836 m0 *1 149.72,79.8
X$18836 15 4534 4533 4176 4449 4778 27 FA_X1
* cell instance $18839 m0 *1 155.23,79.8
X$18839 4528 15 27 4529 INV_X1
* cell instance $18841 m0 *1 158.65,79.8
X$18841 4348 4446 4523 27 15 4614 HA_X1
* cell instance $18842 m0 *1 160.55,79.8
X$18842 4524 4525 4443 27 15 4444 HA_X1
* cell instance $18845 r0 *1 149.91,79.8
X$18845 4721 15 27 4618 INV_X1
* cell instance $18847 r0 *1 150.67,79.8
X$18847 4510 4506 4525 27 15 4530 HA_X1
* cell instance $18848 r0 *1 152.57,79.8
X$18848 15 4529 4856 4615 4616 4618 27 FA_X1
* cell instance $18849 r0 *1 155.61,79.8
X$18849 4444 4617 4446 27 15 4528 HA_X1
* cell instance $18850 r0 *1 157.51,79.8
X$18850 4615 15 27 4526 INV_X1
* cell instance $18852 r0 *1 158.27,79.8
X$18852 15 4526 4527 4720 4614 4613 27 FA_X1
* cell instance $18854 r0 *1 161.5,79.8
X$18854 4611 15 27 4613 INV_X1
* cell instance $18855 r0 *1 161.88,79.8
X$18855 4594 4782 4609 27 15 4524 HA_X1
* cell instance $18856 m0 *1 164.73,79.8
X$18856 15 4506 4442 4520 4417 4420 27 FA_X1
* cell instance $18857 m0 *1 162.83,79.8
X$18857 4439 4443 4518 27 15 4507 HA_X1
* cell instance $18860 r0 *1 163.78,79.8
X$18860 15 4523 4522 4596 4507 4595 27 FA_X1
* cell instance $18863 r0 *1 167.39,79.8
X$18863 15 4520 4508 4712 4610 4332 27 FA_X1
* cell instance $18864 m0 *1 169.86,79.8
X$18864 15 4518 4436 4433 4519 4421 27 FA_X1
* cell instance $18872 r0 *1 171.57,79.8
X$18872 4691 4609 4517 27 15 4519 HA_X1
* cell instance $18874 m0 *1 173.28,79.8
X$18874 4433 15 27 4435 INV_X1
* cell instance $18877 m0 *1 177.65,79.8
X$18877 4429 15 27 4430 INV_X1
* cell instance $18882 r0 *1 174.04,79.8
X$18882 15 4517 4343 4429 4516 4597 27 FA_X1
* cell instance $18885 r0 *1 177.65,79.8
X$18885 4510 4598 4515 27 15 4516 HA_X1
* cell instance $18886 m0 *1 179.36,79.8
X$18886 4512 4423 4426 27 15 4263 HA_X1
* cell instance $18890 m0 *1 184.49,79.8
X$18890 4605 4424 4143 27 15 4425 HA_X1
* cell instance $18894 r0 *1 179.93,79.8
X$18894 4511 15 27 4512 INV_X1
* cell instance $18897 r0 *1 180.88,79.8
X$18897 4515 15 27 4600 INV_X1
* cell instance $18901 r0 *1 183.92,79.8
X$18901 15 4694 4513 4603 4601 4695 27 FA_X1
* cell instance $18912 m0 *1 17.48,175
X$18912 5687 9543 6853 15 9566 27 AOI21_X1
* cell instance $18923 r0 *1 16.15,175
X$18923 15 10472 9679 9566 9289 27 DFF_X1
* cell instance $18924 m0 *1 18.81,175
X$18924 9679 9517 15 27 9543 NAND2_X1
* cell instance $18929 r0 *1 19.76,175
X$18929 7533 15 27 9517 CLKBUF_X3
* cell instance $18930 r0 *1 20.71,175
X$18930 9567 9517 15 27 9568 NAND2_X1
* cell instance $18931 r0 *1 21.28,175
X$18931 5687 9568 9492 15 9569 27 AOI21_X1
* cell instance $18932 m0 *1 21.47,175
X$18932 9448 9517 15 27 9449 NAND2_X1
* cell instance $18935 r0 *1 22.04,175
X$18935 15 10548 9570 9614 9615 27 DFF_X1
* cell instance $18936 m0 *1 22.61,175
X$18936 9570 9517 15 27 9518 NAND2_X1
* cell instance $18938 m0 *1 23.18,175
X$18938 5687 9518 9493 15 9614 27 AOI21_X1
* cell instance $18943 r0 *1 25.84,175
X$18943 8624 9519 15 27 9571 NAND2_X1
* cell instance $18944 m0 *1 26.03,175
X$18944 8733 9519 15 27 9546 NAND2_X1
* cell instance $18946 m0 *1 26.6,175
X$18946 8400 9519 15 27 9572 NAND2_X1
* cell instance $18949 r0 *1 26.6,175
X$18949 9573 9618 9572 15 9619 27 AOI21_X1
* cell instance $18950 r0 *1 27.36,175
X$18950 9652 9653 15 27 9618 NAND2_X1
* cell instance $18951 m0 *1 27.74,175
X$18951 7271 15 27 9519 BUF_X2
* cell instance $18958 r0 *1 28.5,175
X$18958 15 10539 9624 9655 9615 27 DFF_X1
* cell instance $18960 m0 *1 31.16,175
X$18960 8577 9519 15 27 9574 NAND2_X1
* cell instance $18961 m0 *1 31.92,175
X$18961 8665 9519 15 27 9575 NAND2_X1
* cell instance $18965 m0 *1 34.96,175
X$18965 8576 9519 15 27 9520 NAND2_X1
* cell instance $18967 m0 *1 36.29,175
X$18967 15 10405 9521 9629 9224 27 DFF_X1
* cell instance $18968 m0 *1 39.52,175
X$18968 9521 9522 15 27 9632 NAND2_X1
* cell instance $18970 m0 *1 40.28,175
X$18970 9222 9632 9451 15 9629 27 AOI21_X1
* cell instance $18974 r0 *1 31.73,175
X$18974 9573 9656 9575 15 9657 27 AOI21_X1
* cell instance $18976 r0 *1 32.68,175
X$18976 8705 9519 15 27 9716 NAND2_X1
* cell instance $18978 r0 *1 34.77,175
X$18978 9573 9625 9520 15 9627 27 AOI21_X1
* cell instance $18979 r0 *1 35.53,175
X$18979 9754 9653 15 27 9625 NAND2_X1
* cell instance $18982 r0 *1 38.38,175
X$18982 9222 9633 9630 15 9696 27 AOI21_X1
* cell instance $18984 r0 *1 39.9,175
X$18984 9658 9522 15 27 9633 NAND2_X1
* cell instance $18987 r0 *1 42.75,175
X$18987 9659 9517 15 27 9576 NAND2_X1
* cell instance $18988 r0 *1 43.32,175
X$18988 9584 9576 9452 15 9698 27 AOI21_X1
* cell instance $18990 m0 *1 43.7,175
X$18990 7545 9519 15 27 9701 NAND2_X1
* cell instance $18991 m0 *1 47.31,175
X$18991 8505 9519 15 27 9766 NAND2_X1
* cell instance $18992 m0 *1 47.88,175
X$18992 15 10447 9578 9554 9226 27 DFF_X1
* cell instance $18995 m0 *1 52.06,175
X$18995 15 10459 9523 9457 9524 27 DFF_X1
* cell instance $18996 m0 *1 55.29,175
X$18996 9523 9522 15 27 9456 NAND2_X1
* cell instance $18998 m0 *1 56.05,175
X$18998 15 10419 9581 9504 9524 27 DFF_X1
* cell instance $18999 m0 *1 59.28,175
X$18999 15 10401 9582 9556 9358 27 DFF_X1
* cell instance $19004 r0 *1 48.26,175
X$19004 8407 9519 15 27 9577 NAND2_X1
* cell instance $19007 r0 *1 49.4,175
X$19007 9578 9522 15 27 9638 NAND2_X1
* cell instance $19011 r0 *1 57,175
X$19011 9584 9639 9580 15 9579 27 AOI21_X1
* cell instance $19013 r0 *1 58.14,175
X$19013 9581 9522 15 27 9458 NAND2_X1
* cell instance $19019 r0 *1 59.28,175
X$19019 9582 9522 15 27 9460 NAND2_X1
* cell instance $19021 r0 *1 60.61,175
X$19021 8969 15 27 9358 CLKBUF_X3
* cell instance $19022 r0 *1 61.56,175
X$19022 9358 15 27 CLKBUF_X1
* cell instance $19024 r0 *1 62.89,175
X$19024 9584 9583 9640 15 9641 27 AOI21_X1
* cell instance $19025 m0 *1 63.46,175
X$19025 9584 9525 9462 15 9642 27 AOI21_X1
* cell instance $19026 m0 *1 62.89,175
X$19026 9526 9517 15 27 9525 NAND2_X1
* cell instance $19027 m0 *1 64.22,175
X$19027 15 10387 9526 9642 9358 27 DFF_X1
* cell instance $19030 m0 *1 69.73,175
X$19030 15 10345 9527 9558 9559 27 DFF_X1
* cell instance $19034 r0 *1 63.65,175
X$19034 7309 15 27 9584 CLKBUF_X3
* cell instance $19036 r0 *1 66.12,175
X$19036 9584 9585 9587 15 9586 27 AOI21_X1
* cell instance $19041 r0 *1 76.57,175
X$19041 8095 9393 15 27 9865 NAND2_X1
* cell instance $19042 m0 *1 77.33,175
X$19042 8653 9393 15 27 9643 NAND2_X1
* cell instance $19044 m0 *1 77.9,175
X$19044 7935 9471 15 27 9802 NAND2_X1
* cell instance $19049 r0 *1 77.71,175
X$19049 8020 9471 15 27 9708 NAND2_X1
* cell instance $19051 m0 *1 80.56,175
X$19051 9277 15 27 CLKBUF_X1
* cell instance $19052 m0 *1 79.61,175
X$19052 8752 15 27 9277 CLKBUF_X3
* cell instance $19055 m0 *1 82.46,175
X$19055 15 10336 8208 9562 9277 27 DFF_X1
* cell instance $19058 m0 *1 88.73,175
X$19058 9528 9563 9564 15 9644 27 AOI21_X1
* cell instance $19060 m0 *1 89.68,175
X$19060 9646 9648 15 27 9563 NAND2_X1
* cell instance $19062 m0 *1 90.44,175
X$19062 15 10363 9531 9513 9530 27 DFF_X1
* cell instance $19065 m0 *1 95.38,175
X$19065 9468 9648 15 27 9394 NAND2_X1
* cell instance $19067 m0 *1 96.71,175
X$19067 9232 15 27 10843 INV_X1
* cell instance $19068 m0 *1 97.09,175
X$19068 9514 9648 15 27 9447 NAND2_X1
* cell instance $19069 m0 *1 97.66,175
X$19069 8752 15 27 9232 CLKBUF_X3
* cell instance $19070 m0 *1 98.61,175
X$19070 15 10331 9532 9469 9232 27 DFF_X1
* cell instance $19071 m0 *1 101.84,175
X$19071 9307 15 27 9528 CLKBUF_X3
* cell instance $19074 r0 *1 87.4,175
X$19074 15 10635 9646 9644 9530 27 DFF_X1
* cell instance $19078 r0 *1 91.96,175
X$19078 9531 9589 15 27 9529 NAND2_X1
* cell instance $19081 r0 *1 95.95,175
X$19081 8212 9471 15 27 9712 NAND2_X1
* cell instance $19085 r0 *1 99.18,175
X$19085 8520 9393 15 27 9588 NAND2_X1
* cell instance $19087 r0 *1 100.13,175
X$19087 9532 9589 15 27 9515 NAND2_X1
* cell instance $19090 m0 *1 103.17,175
X$19090 8420 15 27 9393 CLKBUF_X3
* cell instance $19091 m0 *1 104.31,175
X$19091 15 10295 9533 9565 9400 27 DFF_X1
* cell instance $19092 m0 *1 107.54,175
X$19092 8330 9471 15 27 9534 NAND2_X1
* cell instance $19097 r0 *1 104.5,175
X$19097 8327 9471 15 27 9590 NAND2_X1
* cell instance $19100 r0 *1 106.78,175
X$19100 9787 9589 15 27 9591 NAND2_X1
* cell instance $19101 r0 *1 107.35,175
X$19101 9593 9591 9534 15 9651 27 AOI21_X1
* cell instance $19104 r0 *1 110.01,175
X$19104 9593 9714 9592 15 9650 27 AOI21_X1
* cell instance $19107 r0 *1 111.72,175
X$19107 9593 9669 9473 15 9594 27 AOI21_X1
* cell instance $19111 r0 *1 114.57,175
X$19111 15 10467 9596 9649 9595 27 DFF_X1
* cell instance $19115 m0 *1 115.9,175
X$19115 9304 9561 9474 15 9649 27 AOI21_X1
* cell instance $19116 m0 *1 115.33,175
X$19116 7055 9535 15 27 9474 NAND2_X1
* cell instance $19118 m0 *1 117.23,175
X$19118 9596 9301 15 27 9561 NAND2_X1
* cell instance $19121 r0 *1 117.8,175
X$19121 15 10499 9645 9647 9595 27 DFF_X1
* cell instance $19122 m0 *1 118.94,175
X$19122 9645 9301 15 27 9560 NAND2_X1
* cell instance $19123 m0 *1 118.18,175
X$19123 9304 9560 9381 15 9647 27 AOI21_X1
* cell instance $19124 m0 *1 119.51,175
X$19124 8420 15 27 9535 BUF_X2
* cell instance $19127 m0 *1 120.65,175
X$19127 7620 9535 15 27 9597 NAND2_X1
* cell instance $19129 r0 *1 121.22,175
X$19129 7779 9535 15 27 9598 NAND2_X1
* cell instance $19131 m0 *1 121.6,175
X$19131 7298 9535 15 27 9851 NAND2_X1
* cell instance $19133 m0 *1 124.45,175
X$19133 7980 9536 15 27 9537 NAND2_X1
* cell instance $19134 m0 *1 125.02,175
X$19134 9539 9557 9537 15 9599 27 AOI21_X1
* cell instance $19136 m0 *1 125.97,175
X$19136 8420 15 27 9536 BUF_X2
* cell instance $19137 m0 *1 126.73,175
X$19137 9600 9310 15 27 9557 NAND2_X1
* cell instance $19138 m0 *1 127.3,175
X$19138 6824 9536 15 27 9538 NAND2_X1
* cell instance $19140 m0 *1 128.06,175
X$19140 7642 9536 15 27 9604 NAND2_X1
* cell instance $19144 m0 *1 131.1,175
X$19144 8280 15 27 9404 CLKBUF_X3
* cell instance $19145 m0 *1 132.05,175
X$19145 9404 15 27 CLKBUF_X1
* cell instance $19151 r0 *1 123.88,175
X$19151 15 10616 9600 9599 9404 27 DFF_X1
* cell instance $19152 r0 *1 127.11,175
X$19152 7936 9536 15 27 9706 NAND2_X1
* cell instance $19153 r0 *1 127.68,175
X$19153 8681 9536 15 27 9635 NAND2_X1
* cell instance $19155 r0 *1 129.77,175
X$19155 9307 15 27 9539 CLKBUF_X3
* cell instance $19159 r0 *1 132.05,175
X$19159 9307 15 27 9120 CLKBUF_X3
* cell instance $19160 r0 *1 133,175
X$19160 15 10613 9602 9601 9814 27 DFF_X1
* cell instance $19162 m0 *1 133.76,175
X$19162 9539 9555 9439 15 9601 27 AOI21_X1
* cell instance $19163 m0 *1 135.28,175
X$19163 9602 9310 15 27 9555 NAND2_X1
* cell instance $19170 r0 *1 139.84,175
X$19170 15 10524 9553 9603 9316 27 DFF_X1
* cell instance $19172 m0 *1 140.03,175
X$19172 9539 9637 9509 15 9603 27 AOI21_X1
* cell instance $19173 m0 *1 141.74,175
X$19173 9553 9310 15 27 9637 NAND2_X1
* cell instance $19174 m0 *1 141.17,175
X$19174 9631 9310 15 27 9636 NAND2_X1
* cell instance $19175 m0 *1 142.31,175
X$19175 9539 9636 9315 15 9634 27 AOI21_X1
* cell instance $19176 m0 *1 143.07,175
X$19176 8280 15 27 9316 CLKBUF_X3
* cell instance $19177 m0 *1 144.02,175
X$19177 15 10444 9631 9634 9316 27 DFF_X1
* cell instance $19179 m0 *1 150.29,175
X$19179 9551 9506 9477 27 15 9628 HA_X1
* cell instance $19181 m0 *1 152.95,175
X$19181 9500 15 27 9605 INV_X1
* cell instance $19182 m0 *1 153.33,175
X$19182 15 9478 9540 9551 9552 9838 27 FA_X1
* cell instance $19183 m0 *1 156.37,175
X$19183 9411 9550 9427 27 15 9607 HA_X1
* cell instance $19184 m0 *1 158.27,175
X$19184 9480 15 27 9550 INV_X1
* cell instance $19187 m0 *1 161.88,175
X$19187 9549 15 27 9608 INV_X1
* cell instance $19188 m0 *1 162.26,175
X$19188 9481 15 27 9622 INV_X1
* cell instance $19192 r0 *1 149.53,175
X$19192 9123 15 27 9697 INV_X1
* cell instance $19196 r0 *1 152.57,175
X$19196 9626 9628 9761 27 9694 15 OAI21_X1
* cell instance $19200 r0 *1 157.51,175
X$19200 9623 15 27 9606 INV_X1
* cell instance $19202 r0 *1 158.27,175
X$19202 9607 15 27 9674 INV_X1
* cell instance $19205 r0 *1 160.93,175
X$19205 15 9608 9756 9689 9622 9609 27 FA_X1
* cell instance $19207 m0 *1 163.02,175
X$19207 9548 15 27 9609 INV_X1
* cell instance $19211 r0 *1 165.68,175
X$19211 15 9495 9617 9688 9621 9482 27 FA_X1
* cell instance $19212 m0 *1 167.01,175
X$19212 9484 9483 9621 27 15 9620 HA_X1
* cell instance $19217 r0 *1 168.72,175
X$19217 9620 15 27 9616 INV_X1
* cell instance $19218 r0 *1 169.1,175
X$19218 9617 15 27 9687 INV_X1
* cell instance $19219 r0 *1 169.48,175
X$19219 9616 9264 9686 27 15 9613 HA_X1
* cell instance $19225 m0 *1 171.57,175
X$19225 9547 15 27 9685 INV_X1
* cell instance $19226 r0 *1 171.76,175
X$19226 9613 9261 9676 27 15 9683 HA_X1
* cell instance $19228 m0 *1 172.33,175
X$19228 15 9490 9612 9545 9423 9421 27 FA_X1
* cell instance $19229 m0 *1 175.56,175
X$19229 15 9612 9544 9542 9541 9418 27 FA_X1
* cell instance $19230 m0 *1 178.6,175
X$19230 15 9544 9486 9678 9485 9415 27 FA_X1
* cell instance $19236 r0 *1 178.98,175
X$19236 9611 15 27 9610 INV_X1
* cell instance $19245 m0 *1 14.25,82.6
X$19245 15 4645 3396 4699 3463 4743 27 NOR4_X4
* cell instance $19246 m0 *1 17.67,82.6
X$19246 15 4702 4703 4471 4705 4645 27 AOI22_X4
* cell instance $19247 m0 *1 20.9,82.6
X$19247 15 4647 4066 4213 4619 4209 27 OAI22_X4
* cell instance $19248 m0 *1 24.13,82.6
X$19248 15 4648 4552 4612 4553 4428 27 OAI22_X4
* cell instance $19250 m0 *1 27.55,82.6
X$19250 4552 4648 4296 4219 4298 4744 15 27 OAI221_X2
* cell instance $19252 m0 *1 29.83,82.6
X$19252 4471 4298 15 27 4709 NAND2_X2
* cell instance $19254 m0 *1 30.97,82.6
X$19254 15 4540 4296 4709 4649 27 AOI21_X4
* cell instance $19256 m0 *1 33.63,82.6
X$19256 4651 15 27 4100 INV_X1
* cell instance $19258 m0 *1 34.2,82.6
X$19258 4745 4298 15 27 4789 NOR2_X1
* cell instance $19260 m0 *1 34.96,82.6
X$19260 15 4747 4295 4554 4297 27 AOI21_X4
* cell instance $19262 m0 *1 37.62,82.6
X$19262 4554 4297 15 27 4299 NAND2_X2
* cell instance $19264 m0 *1 38.76,82.6
X$19264 4474 4268 3396 27 4748 15 NOR3_X2
* cell instance $19274 r0 *1 17.29,82.6
X$19274 15 4653 4701 4646 4437 27 AOI21_X4
* cell instance $19275 r0 *1 19.76,82.6
X$19275 4213 4210 4209 3679 15 4705 27 NAND4_X2
* cell instance $19276 r0 *1 21.47,82.6
X$19276 3147 4213 4066 27 15 4648 AND3_X1
* cell instance $19277 r0 *1 22.42,82.6
X$19277 3846 4213 15 27 4647 NAND2_X2
* cell instance $19280 r0 *1 24.32,82.6
X$19280 4706 4612 15 27 4745 NOR2_X1
* cell instance $19281 r0 *1 24.89,82.6
X$19281 4645 4612 15 27 4651 XNOR2_X2
* cell instance $19283 r0 *1 27.55,82.6
X$19283 4553 4297 4295 4649 27 4650 15 NOR4_X2
* cell instance $19286 r0 *1 29.83,82.6
X$19286 4649 4553 4295 27 4708 15 NOR3_X2
* cell instance $19289 r0 *1 31.73,82.6
X$19289 4708 4297 4654 15 27 NOR2_X4
* cell instance $19290 r0 *1 33.44,82.6
X$19290 4789 4619 4655 15 27 NOR2_X4
* cell instance $19291 r0 *1 35.15,82.6
X$19291 15 4653 4652 4619 4713 4295 27 OAI22_X4
* cell instance $19292 r0 *1 38.38,82.6
X$19292 15 4557 4845 4299 4713 27 AOI21_X4
* cell instance $19294 m0 *1 40.47,82.6
X$19294 4102 4474 27 15 4749 AND2_X1
* cell instance $19295 m0 *1 41.42,82.6
X$19295 4555 4538 4300 27 15 4453 AND3_X1
* cell instance $19296 m0 *1 42.37,82.6
X$19296 4362 4380 3916 27 15 4624 OAI21_X2
* cell instance $19298 m0 *1 43.89,82.6
X$19298 4380 3916 4362 15 27 4625 OR3_X2
* cell instance $19300 m0 *1 45.22,82.6
X$19300 4377 3274 4380 27 4716 15 NOR3_X2
* cell instance $19302 m0 *1 46.74,82.6
X$19302 4379 4559 4626 3274 4557 4228 15 27 OAI221_X2
* cell instance $19304 m0 *1 49.02,82.6
X$19304 4719 2504 4476 15 4722 27 AOI21_X1
* cell instance $19306 m0 *1 49.97,82.6
X$19306 4557 4559 4379 27 15 4629 OAI21_X2
* cell instance $19309 m0 *1 55.1,82.6
X$19309 4656 4557 27 15 4564 XNOR2_X1
* cell instance $19315 r0 *1 41.42,82.6
X$19315 15 4654 4537 4220 3170 27 NOR3_X4
* cell instance $19318 r0 *1 44.65,82.6
X$19318 4715 4716 15 27 4562 XNOR2_X2
* cell instance $19319 r0 *1 46.55,82.6
X$19319 4475 4655 4559 15 27 4543 NAND3_X1
* cell instance $19322 r0 *1 49.21,82.6
X$19322 4559 4655 27 15 3889 AND2_X2
* cell instance $19325 r0 *1 50.73,82.6
X$19325 4559 4655 4750 4183 27 15 3243 AND4_X2
* cell instance $19326 r0 *1 52.06,82.6
X$19326 4750 15 27 4860 INV_X1
* cell instance $19328 r0 *1 52.82,82.6
X$19328 3121 4183 15 27 4861 NAND2_X1
* cell instance $19331 r0 *1 54.34,82.6
X$19331 4359 4804 3275 3183 4656 15 27 OAI211_X2
* cell instance $19333 r0 *1 56.43,82.6
X$19333 4804 4796 15 27 4304 XNOR2_X2
* cell instance $19335 r0 *1 58.71,82.6
X$19335 15 4657 4797 4381 4228 4658 27 NOR4_X4
* cell instance $19336 m0 *1 59.66,82.6
X$19336 2293 4725 15 27 4640 OR2_X2
* cell instance $19337 m0 *1 58.9,82.6
X$19337 4561 4477 4562 15 4725 27 AOI21_X1
* cell instance $19338 m0 *1 60.61,82.6
X$19338 4563 4562 4561 27 15 4661 OAI21_X2
* cell instance $19339 m0 *1 61.94,82.6
X$19339 15 3741 4479 4658 4364 27 AOI21_X4
* cell instance $19340 m0 *1 64.41,82.6
X$19340 4364 4658 27 15 4457 AND2_X1
* cell instance $19341 m0 *1 65.17,82.6
X$19341 4561 4304 15 27 4727 NAND2_X1
* cell instance $19342 m0 *1 65.74,82.6
X$19342 4565 2293 4727 27 15 4636 OAI21_X2
* cell instance $19350 r0 *1 64.41,82.6
X$19350 4564 4304 4561 15 4659 27 AOI21_X1
* cell instance $19353 r0 *1 65.74,82.6
X$19353 4304 4561 15 27 4565 OR2_X1
* cell instance $19355 r0 *1 67.26,82.6
X$19355 15 4482 4661 4660 4385 3745 27 NAND4_X4
* cell instance $19357 m0 *1 68.21,82.6
X$19357 4660 4385 4482 4661 27 15 4635 AND4_X1
* cell instance $19358 m0 *1 69.92,82.6
X$19358 4304 4481 4306 27 15 4729 AND3_X1
* cell instance $19360 m0 *1 70.87,82.6
X$19360 4482 4306 27 4483 15 XOR2_X2
* cell instance $19364 r0 *1 71.63,82.6
X$19364 4386 4729 3808 4640 15 4754 27 NAND4_X2
* cell instance $19365 m0 *1 73.15,82.6
X$19365 3809 3745 15 27 4663 NOR2_X2
* cell instance $19368 m0 *1 74.86,82.6
X$19368 4756 4307 4484 27 15 4117 AND3_X2
* cell instance $19370 m0 *1 76.19,82.6
X$19370 4566 4307 4484 27 15 4664 AND3_X1
* cell instance $19372 m0 *1 77.33,82.6
X$19372 4567 4387 4664 27 15 4667 AND3_X1
* cell instance $19375 r0 *1 73.53,82.6
X$19375 4639 4483 4663 27 4755 15 NOR3_X2
* cell instance $19377 r0 *1 75.05,82.6
X$19377 4639 4483 27 4668 15 XOR2_X2
* cell instance $19379 r0 *1 76.95,82.6
X$19379 4567 4664 4387 15 4665 27 AOI21_X2
* cell instance $19381 r0 *1 78.47,82.6
X$19381 15 4730 4665 4667 4732 27 NOR3_X4
* cell instance $19383 m0 *1 78.66,82.6
X$19383 4666 4550 4643 15 4388 27 NAND3_X4
* cell instance $19384 m0 *1 81.32,82.6
X$19384 4568 4082 2942 2990 4669 27 15 AOI211_X2
* cell instance $19386 m0 *1 83.22,82.6
X$19386 4549 15 27 4735 INV_X1
* cell instance $19388 m0 *1 83.79,82.6
X$19388 4735 4390 15 27 4569 NOR2_X1
* cell instance $19390 r0 *1 81.13,82.6
X$19390 4667 4665 4730 4663 4668 4669 15 27 4671 OAI33_X1
* cell instance $19391 r0 *1 82.46,82.6
X$19391 4669 4668 4663 27 4670 15 NOR3_X2
* cell instance $19394 r0 *1 84.36,82.6
X$19394 4569 4670 15 27 4674 NOR2_X2
* cell instance $19396 m0 *1 84.74,82.6
X$19396 4670 4569 15 27 4570 OR2_X1
* cell instance $19399 r0 *1 85.69,82.6
X$19399 4671 4393 4232 4392 27 4737 15 OR4_X2
* cell instance $19400 r0 *1 87.02,82.6
X$19400 15 4671 4393 4232 4392 4672 27 NOR4_X4
* cell instance $19401 m0 *1 89.11,82.6
X$19401 4570 4036 3949 15 4673 27 AOI21_X1
* cell instance $19403 m0 *1 89.87,82.6
X$19403 4570 4571 4673 15 27 4738 MUX2_X1
* cell instance $19404 m0 *1 91.2,82.6
X$19404 4673 4571 4675 4676 15 27 4819 AOI211_X4
* cell instance $19406 m0 *1 93.48,82.6
X$19406 4004 3893 15 27 4573 NAND2_X1
* cell instance $19409 r0 *1 90.63,82.6
X$19409 4674 4004 3892 15 4675 27 AOI21_X1
* cell instance $19411 r0 *1 91.77,82.6
X$19411 4674 3893 15 27 4676 NOR2_X1
* cell instance $19414 r0 *1 93.48,82.6
X$19414 4674 3817 3892 15 27 4763 NAND3_X2
* cell instance $19416 m0 *1 94.43,82.6
X$19416 4075 4573 15 27 4281 NOR2_X1
* cell instance $19417 m0 *1 96.52,82.6
X$19417 4573 27 3253 15 BUF_X4
* cell instance $19418 m0 *1 97.85,82.6
X$19418 4490 4574 15 27 4491 XNOR2_X2
* cell instance $19423 r0 *1 96.52,82.6
X$19423 4737 4234 15 27 4762 NOR2_X2
* cell instance $19424 r0 *1 97.47,82.6
X$19424 4234 2742 15 27 4800 NOR2_X1
* cell instance $19426 r0 *1 98.8,82.6
X$19426 4737 3253 15 27 4765 NOR2_X1
* cell instance $19428 r0 *1 100.89,82.6
X$19428 4799 4816 4738 4677 27 4742 15 NOR4_X2
* cell instance $19429 m0 *1 101.84,82.6
X$19429 4276 4492 15 27 4677 OR2_X1
* cell instance $19433 m0 *1 103.74,82.6
X$19433 4575 27 3917 15 BUF_X4
* cell instance $19434 m0 *1 102.98,82.6
X$19434 4677 4740 27 15 4580 AND2_X1
* cell instance $19435 m0 *1 105.07,82.6
X$19435 15 3778 4575 4491 4039 4277 27 OR4_X4
* cell instance $19440 r0 *1 103.74,82.6
X$19440 3777 4491 4315 3665 27 4766 15 OR4_X2
* cell instance $19443 r0 *1 106.21,82.6
X$19443 15 3777 4491 4315 4768 27 NOR3_X4
* cell instance $19445 r0 *1 110.39,82.6
X$19445 4768 3783 4494 15 27 4678 NAND3_X1
* cell instance $19446 r0 *1 111.15,82.6
X$19446 4633 4742 15 27 4741 XNOR2_X2
* cell instance $19447 m0 *1 114.19,82.6
X$19447 4576 4041 4319 15 27 4579 OR3_X4
* cell instance $19448 m0 *1 112.48,82.6
X$19448 4633 4576 4319 4041 27 4739 15 NOR4_X2
* cell instance $19451 m0 *1 119.51,82.6
X$19451 4498 4579 15 27 4324 OR2_X2
* cell instance $19452 m0 *1 120.46,82.6
X$19452 4127 4498 4579 15 27 3530 OR3_X4
* cell instance $19453 m0 *1 122.55,82.6
X$19453 4580 4500 4581 15 4631 27 AOI21_X2
* cell instance $19454 m0 *1 123.88,82.6
X$19454 4581 4500 27 15 4582 XNOR2_X1
* cell instance $19455 m0 *1 125.02,82.6
X$19455 4585 4581 15 27 4404 NAND2_X2
* cell instance $19456 m0 *1 125.97,82.6
X$19456 4680 4582 3612 27 4583 15 OAI21_X1
* cell instance $19458 m0 *1 126.92,82.6
X$19458 4582 4680 15 27 4628 NOR2_X1
* cell instance $19466 r0 *1 118.37,82.6
X$19466 15 4498 4579 4127 3856 27 NOR3_X4
* cell instance $19469 r0 *1 121.98,82.6
X$19469 15 4504 4741 4500 4871 27 AOI21_X4
* cell instance $19470 r0 *1 124.45,82.6
X$19470 4679 4500 27 15 4501 AND2_X1
* cell instance $19471 r0 *1 125.21,82.6
X$19471 4500 4679 15 27 4770 NAND2_X1
* cell instance $19472 r0 *1 125.78,82.6
X$19472 4771 4580 15 27 4680 NAND2_X1
* cell instance $19474 r0 *1 126.73,82.6
X$19474 4773 3612 15 27 4774 NAND2_X2
* cell instance $19476 m0 *1 128.82,82.6
X$19476 4583 4733 4736 27 15 4409 AND3_X2
* cell instance $19477 m0 *1 127.87,82.6
X$19477 4628 3856 15 27 4503 NOR2_X2
* cell instance $19478 m0 *1 129.96,82.6
X$19478 4584 4736 4733 4583 15 27 4734 NAND4_X1
* cell instance $19479 m0 *1 130.91,82.6
X$19479 4683 4682 15 27 4584 NAND2_X1
* cell instance $19481 m0 *1 131.67,82.6
X$19481 4127 4585 15 27 4683 OR2_X1
* cell instance $19483 m0 *1 132.62,82.6
X$19483 4683 4504 3619 27 15 4728 OAI21_X2
* cell instance $19485 m0 *1 134.14,82.6
X$19485 4504 4586 15 27 3647 OR2_X1
* cell instance $19487 m0 *1 135.09,82.6
X$19487 4587 3647 15 27 4685 NAND2_X1
* cell instance $19488 m0 *1 135.66,82.6
X$19488 4587 4685 4588 27 15 3539 MUX2_X2
* cell instance $19492 r0 *1 129.58,82.6
X$19492 4681 4774 4795 15 27 4623 NAND3_X1
* cell instance $19493 r0 *1 130.34,82.6
X$19493 4502 4406 4734 4682 4794 4683 15 27 4591 OAI33_X1
* cell instance $19495 r0 *1 132.05,82.6
X$19495 4682 4775 15 27 4329 XNOR2_X2
* cell instance $19496 r0 *1 133.95,82.6
X$19496 4684 4577 15 27 4586 NAND2_X1
* cell instance $19500 r0 *1 135.85,82.6
X$19500 15 3299 4577 4728 4684 27 AOI21_X4
* cell instance $19503 r0 *1 139.27,82.6
X$19503 4774 4681 27 15 4132 AND2_X2
* cell instance $19504 r0 *1 140.22,82.6
X$19504 4774 4589 15 27 3969 XNOR2_X2
* cell instance $19505 m0 *1 140.98,82.6
X$19505 4591 4590 27 3832 15 XOR2_X2
* cell instance $19510 r0 *1 142.88,82.6
X$19510 4726 15 27 4133 INV_X2
* cell instance $19513 r0 *1 144.4,82.6
X$19513 4506 4417 4620 27 15 4858 HA_X1
* cell instance $19514 m0 *1 148.01,82.6
X$19514 4593 4723 4721 27 15 4686 HA_X1
* cell instance $19515 m0 *1 146.11,82.6
X$19515 4592 4620 4723 27 15 4792 HA_X1
* cell instance $19521 r0 *1 147.25,82.6
X$19521 4724 15 27 4777 INV_X1
* cell instance $19522 r0 *1 147.63,82.6
X$19522 5004 4533 4724 27 15 4947 HA_X1
* cell instance $19523 r0 *1 149.53,82.6
X$19523 4686 15 27 4857 INV_X1
* cell instance $19527 r0 *1 153.52,82.6
X$19527 4687 15 27 4779 INV_X1
* cell instance $19529 m0 *1 157.32,82.6
X$19529 4780 15 27 4418 INV_X1
* cell instance $19534 r0 *1 160.36,82.6
X$19534 15 4783 4688 4521 4689 4718 27 FA_X1
* cell instance $19536 m0 *1 161.12,82.6
X$19536 4720 15 27 4689 INV_X1
* cell instance $19539 m0 *1 166.82,82.6
X$19539 4596 15 27 4690 INV_X1
* cell instance $19545 r0 *1 165.49,82.6
X$19545 4917 15 27 4595 INV_X1
* cell instance $19547 r0 *1 166.63,82.6
X$19547 15 4714 4254 4256 4690 4846 27 FA_X1
* cell instance $19548 m0 *1 168.53,82.6
X$19548 15 4420 4610 4710 4506 4594 27 FA_X1
* cell instance $19550 m0 *1 171.57,82.6
X$19550 4920 15 27 4421 INV_X1
* cell instance $19551 m0 *1 171.95,82.6
X$19551 4712 4608 4691 27 15 4432 HA_X1
* cell instance $19553 m0 *1 174.61,82.6
X$19553 15 4710 4608 4607 4711 4417 27 FA_X1
* cell instance $19554 m0 *1 177.65,82.6
X$19554 4607 4599 4598 27 15 4423 HA_X1
* cell instance $19556 r0 *1 169.67,82.6
X$19556 4784 15 27 4714 INV_X1
* cell instance $19563 r0 *1 176.7,82.6
X$19563 15 4510 4711 4841 4506 4594 27 FA_X1
* cell instance $19565 m0 *1 180.12,82.6
X$19565 15 4600 4511 4602 4704 4839 27 FA_X1
* cell instance $19567 m0 *1 183.16,82.6
X$19567 4785 15 27 4704 INV_X1
* cell instance $19568 m0 *1 183.54,82.6
X$19568 4602 15 27 4692 INV_X1
* cell instance $19570 m0 *1 184.68,82.6
X$19570 15 4787 4258 4605 4786 4603 27 FA_X1
* cell instance $19572 r0 *1 182.78,82.6
X$19572 15 4700 4707 4695 4692 4697 27 FA_X1
* cell instance $19584 r0 *1 2.28,93.8
X$19584 5237 15 27 5275 BUF_X1
* cell instance $19585 r0 *1 2.85,93.8
X$19585 5277 15 27 5235 BUF_X1
* cell instance $19593 r0 *1 6.46,93.8
X$19593 5236 15 27 5182 BUF_X1
* cell instance $19597 r0 *1 9.5,93.8
X$19597 15 10576 5236 5183 5017 27 DFF_X1
* cell instance $19598 m0 *1 12.54,93.8
X$19598 5017 15 27 CLKBUF_X1
* cell instance $19603 m0 *1 17.1,93.8
X$19603 4979 5118 5206 15 5163 27 AOI21_X1
* cell instance $19604 m0 *1 17.86,93.8
X$19604 5024 15 27 4885 CLKBUF_X3
* cell instance $19605 m0 *1 18.81,93.8
X$19605 15 10378 4336 5208 4885 27 DFF_X1
* cell instance $19606 m0 *1 22.04,93.8
X$19606 5021 5138 5266 15 5208 27 AOI21_X1
* cell instance $19608 m0 *1 22.99,93.8
X$19608 5185 5144 15 27 5022 NAND2_X1
* cell instance $19610 r0 *1 12.73,93.8
X$19610 5024 15 27 5017 CLKBUF_X3
* cell instance $19611 r0 *1 13.68,93.8
X$19611 5236 5184 15 27 5262 NAND2_X1
* cell instance $19612 r0 *1 14.25,93.8
X$19612 5237 5184 15 27 5304 NAND2_X1
* cell instance $19613 r0 *1 14.82,93.8
X$19613 4979 5262 5264 15 5183 27 AOI21_X1
* cell instance $19618 r0 *1 18.43,93.8
X$19618 5308 5238 15 27 5206 NAND2_X1
* cell instance $19619 r0 *1 19,93.8
X$19619 5310 5238 15 27 5265 NAND2_X1
* cell instance $19622 r0 *1 20.52,93.8
X$19622 5312 5238 15 27 5020 NAND2_X1
* cell instance $19624 r0 *1 21.47,93.8
X$19624 5401 5238 15 27 5137 NAND2_X1
* cell instance $19625 r0 *1 22.04,93.8
X$19625 5521 5144 15 27 5266 NAND2_X1
* cell instance $19628 r0 *1 23.56,93.8
X$19628 5148 15 27 5238 CLKBUF_X3
* cell instance $19630 m0 *1 23.94,93.8
X$19630 5186 5144 15 27 4974 NAND2_X1
* cell instance $19632 m0 *1 26.79,93.8
X$19632 5212 5144 15 27 5165 NAND2_X1
* cell instance $19637 r0 *1 26.79,93.8
X$19637 5269 5144 15 27 5187 NAND2_X1
* cell instance $19638 r0 *1 27.36,93.8
X$19638 5148 15 27 5144 CLKBUF_X3
* cell instance $19641 m0 *1 28.5,93.8
X$19641 5356 5144 15 27 5140 NAND2_X1
* cell instance $19643 m0 *1 30.02,93.8
X$19643 5213 5238 15 27 5141 NAND2_X1
* cell instance $19647 r0 *1 30.78,93.8
X$19647 5239 15 27 5240 BUF_X2
* cell instance $19648 m0 *1 32.87,93.8
X$19648 5216 15 27 5319 INV_X1
* cell instance $19649 m0 *1 30.97,93.8
X$19649 5188 5315 10875 27 15 5216 HA_X1
* cell instance $19652 m0 *1 34.2,93.8
X$19652 5240 5170 15 27 5142 XNOR2_X2
* cell instance $19656 r0 *1 32.11,93.8
X$19656 5319 5240 5217 27 15 5405 OAI21_X4
* cell instance $19657 r0 *1 34.58,93.8
X$19657 5319 5325 5240 27 15 5360 OAI21_X2
* cell instance $19659 r0 *1 36.1,93.8
X$19659 5189 5326 15 27 5862 XNOR2_X2
* cell instance $19660 m0 *1 36.67,93.8
X$19660 15 5217 5125 5189 5173 27 AOI21_X4
* cell instance $19663 m0 *1 39.9,93.8
X$19663 5221 5223 5362 27 15 5173 OAI21_X4
* cell instance $19664 m0 *1 42.37,93.8
X$19664 5221 5223 5328 27 15 5143 OAI21_X2
* cell instance $19665 m0 *1 43.7,93.8
X$19665 5222 5144 15 27 5027 NAND2_X1
* cell instance $19668 m0 *1 50.54,93.8
X$19668 4979 5145 5274 15 5178 27 AOI21_X1
* cell instance $19669 m0 *1 51.3,93.8
X$19669 33 5184 15 27 5145 NAND2_X1
* cell instance $19670 m0 *1 51.87,93.8
X$19670 5099 15 27 5184 CLKBUF_X3
* cell instance $19672 m0 *1 54.34,93.8
X$19672 5226 5238 15 27 5146 NAND2_X1
* cell instance $19674 r0 *1 38,93.8
X$19674 5143 15 27 5326 BUF_X1
* cell instance $19676 r0 *1 38.76,93.8
X$19676 5188 5434 10900 27 15 5272 HA_X1
* cell instance $19677 r0 *1 40.66,93.8
X$19677 5188 5281 10898 27 15 5329 HA_X1
* cell instance $19680 r0 *1 44.27,93.8
X$19680 5188 5363 10912 27 15 5334 HA_X1
* cell instance $19681 r0 *1 46.17,93.8
X$19681 5282 5365 5241 27 15 5331 OAI21_X2
* cell instance $19682 r0 *1 47.5,93.8
X$19682 5334 15 27 5282 INV_X1
* cell instance $19686 r0 *1 49.21,93.8
X$19686 5440 5238 15 27 5031 NAND2_X1
* cell instance $19688 r0 *1 50.54,93.8
X$19688 5242 5238 15 27 5274 NAND2_X1
* cell instance $19698 m0 *1 18.81,85.4
X$19698 4209 4213 27 15 4646 AND2_X1
* cell instance $19709 r0 *1 6.46,85.4
X$19709 4803 15 27 4882 BUF_X1
* cell instance $19710 r0 *1 7.03,85.4
X$19710 4886 15 27 4802 BUF_X1
* cell instance $19714 r0 *1 15.96,85.4
X$19714 15 10573 4803 4998 5017 27 DFF_X1
* cell instance $19716 r0 *1 20.71,85.4
X$19716 15 10625 4696 5001 4885 27 DFF_X1
* cell instance $19717 m0 *1 20.9,85.4
X$19717 4213 4647 4551 27 15 4652 MUX2_X2
* cell instance $19722 m0 *1 23.75,85.4
X$19722 3382 4743 4296 15 27 NOR2_X4
* cell instance $19723 m0 *1 25.65,85.4
X$19723 4743 3382 15 27 4842 OR2_X1
* cell instance $19724 m0 *1 26.41,85.4
X$19724 4842 27 4297 15 BUF_X4
* cell instance $19726 m0 *1 29.26,85.4
X$19726 15 4750 4650 4649 4709 27 AOI21_X4
* cell instance $19728 m0 *1 31.92,85.4
X$19728 4651 4744 15 27 4751 XNOR2_X2
* cell instance $19729 m0 *1 33.82,85.4
X$19729 4619 4295 15 27 4746 NOR2_X1
* cell instance $19730 m0 *1 34.39,85.4
X$19730 4746 4745 4744 27 4844 15 OAI21_X1
* cell instance $19731 m0 *1 35.15,85.4
X$19731 4746 4745 15 27 4849 NOR2_X1
* cell instance $19736 m0 *1 37.81,85.4
X$19736 15 4747 4748 4473 4749 4559 27 NOR4_X4
* cell instance $19737 m0 *1 36.1,85.4
X$19737 4652 4747 27 4804 15 XOR2_X2
* cell instance $19738 m0 *1 41.23,85.4
X$19738 4559 4750 4183 27 15 4805 AND3_X1
* cell instance $19742 r0 *1 38.57,85.4
X$19742 4653 4298 15 27 4845 NOR2_X1
* cell instance $19743 r0 *1 39.14,85.4
X$19743 4748 4747 15 27 4715 NOR2_X1
* cell instance $19744 r0 *1 39.71,85.4
X$19744 4653 4804 4359 15 27 4933 NAND3_X1
* cell instance $19745 r0 *1 40.47,85.4
X$19745 4850 4933 4844 15 27 4934 MUX2_X1
* cell instance $19746 r0 *1 41.8,85.4
X$19746 4849 4805 3170 15 4850 27 AOI21_X1
* cell instance $19747 m0 *1 42.75,85.4
X$19747 4654 4537 4220 15 27 4851 OR3_X1
* cell instance $19753 r0 *1 43.89,85.4
X$19753 4934 27 4752 15 BUF_X4
* cell instance $19754 m0 *1 45.41,85.4
X$19754 4655 4559 4751 4475 15 4853 27 NAND4_X2
* cell instance $19755 m0 *1 44.08,85.4
X$19755 4851 27 3183 15 BUF_X4
* cell instance $19756 m0 *1 47.12,85.4
X$19756 4654 4853 4224 27 15 4806 OAI21_X4
* cell instance $19759 m0 *1 50.54,85.4
X$19759 4655 4559 15 3184 27 NAND2_X4
* cell instance $19760 m0 *1 52.25,85.4
X$19760 4860 3184 4861 27 15 4807 OAI21_X2
* cell instance $19766 r0 *1 47.88,85.4
X$19766 4558 4751 27 4657 15 XOR2_X2
* cell instance $19768 r0 *1 49.97,85.4
X$19768 15 4750 4183 4559 4655 3275 27 NAND4_X4
* cell instance $19771 r0 *1 54.34,85.4
X$19771 4807 4806 4560 15 4797 27 NAND3_X4
* cell instance $19772 m0 *1 54.91,85.4
X$19772 4359 3183 3275 27 15 4796 OAI21_X2
* cell instance $19776 m0 *1 56.62,85.4
X$19776 4796 4804 27 4381 15 XOR2_X2
* cell instance $19777 r0 *1 56.81,85.4
X$19777 4560 4807 15 27 4981 NAND2_X1
* cell instance $19779 m0 *1 58.9,85.4
X$19779 4228 4381 15 27 4864 NOR2_X1
* cell instance $19782 r0 *1 58.9,85.4
X$19782 4364 4864 4806 15 27 4889 NAND3_X1
* cell instance $19786 r0 *1 59.66,85.4
X$19786 4657 4752 15 27 4890 OR2_X2
* cell instance $19787 m0 *1 61.56,85.4
X$19787 4752 15 27 4798 INV_X1
* cell instance $19788 m0 *1 59.85,85.4
X$19788 4752 4797 4657 3739 27 4283 15 NOR4_X2
* cell instance $19790 r0 *1 60.61,85.4
X$19790 15 3588 4303 4752 4797 4657 27 OR4_X4
* cell instance $19791 m0 *1 62.51,85.4
X$19791 4657 4797 4752 15 27 4229 OR3_X2
* cell instance $19793 m0 *1 63.65,85.4
X$19793 4563 4478 15 27 4808 NOR2_X1
* cell instance $19794 m0 *1 64.22,85.4
X$19794 4659 4229 4808 15 4867 27 AOI21_X1
* cell instance $19796 m0 *1 65.17,85.4
X$19796 4806 4366 4798 15 4025 27 AOI21_X1
* cell instance $19798 m0 *1 66.12,85.4
X$19798 4808 3694 3808 15 4944 27 AOI21_X1
* cell instance $19801 m0 *1 67.83,85.4
X$19801 4867 15 27 4868 INV_X1
* cell instance $19802 m0 *1 68.21,85.4
X$19802 15 4460 3745 3861 4753 27 NOR3_X4
* cell instance $19803 m0 *1 70.87,85.4
X$19803 15 4757 4753 4868 4754 27 AOI21_X4
* cell instance $19804 m0 *1 73.34,85.4
X$19804 4640 4565 4566 27 15 4756 AND3_X1
* cell instance $19806 m0 *1 74.48,85.4
X$19806 4640 4755 27 15 4567 XNOR2_X1
* cell instance $19807 m0 *1 75.62,85.4
X$19807 4549 4869 15 27 4809 NAND2_X1
* cell instance $19810 r0 *1 63.08,85.4
X$19810 4478 4479 4890 4563 27 4891 15 NOR4_X2
* cell instance $19811 r0 *1 64.79,85.4
X$19811 4896 3741 4942 15 4895 27 AOI21_X1
* cell instance $19812 r0 *1 65.55,85.4
X$19812 4866 3694 4086 15 4894 27 AOI21_X1
* cell instance $19814 r0 *1 66.5,85.4
X$19814 4944 4752 15 27 4897 NOR2_X1
* cell instance $19817 r0 *1 67.64,85.4
X$19817 15 4890 4460 3745 3861 4898 27 NOR4_X4
* cell instance $19820 r0 *1 72.96,85.4
X$19820 4640 4636 27 15 4869 AND2_X1
* cell instance $19823 r0 *1 74.29,85.4
X$19823 4869 4755 15 27 4899 NAND2_X1
* cell instance $19824 r0 *1 74.86,85.4
X$19824 4755 4636 15 27 4950 OR2_X1
* cell instance $19826 r0 *1 75.81,85.4
X$19826 4950 4116 4549 15 4870 27 AOI21_X2
* cell instance $19827 r0 *1 77.14,85.4
X$19827 4809 4082 3510 3653 27 15 4951 OAI22_X2
* cell instance $19828 m0 *1 78.28,85.4
X$19828 4810 4757 4811 27 15 4666 AND3_X1
* cell instance $19831 m0 *1 79.99,85.4
X$19831 4550 4666 4643 27 15 4730 AND3_X1
* cell instance $19832 m0 *1 80.94,85.4
X$19832 4285 4811 4757 4810 15 27 4954 NAND4_X1
* cell instance $19835 r0 *1 79.04,85.4
X$19835 2990 4666 27 15 4945 AND2_X1
* cell instance $19836 r0 *1 79.8,85.4
X$19836 15 4731 4811 4757 4810 2942 27 AND4_X4
* cell instance $19837 r0 *1 82.27,85.4
X$19837 4285 4757 15 27 4955 NAND2_X1
* cell instance $19838 m0 *1 82.46,85.4
X$19838 15 4801 3194 4813 4758 27 AOI21_X4
* cell instance $19843 m0 *1 87.4,85.4
X$19843 4671 15 27 5085 BUF_X2
* cell instance $19845 m0 *1 88.35,85.4
X$19845 3892 4036 15 27 4814 NAND2_X1
* cell instance $19846 m0 *1 88.92,85.4
X$19846 4814 4394 3925 27 4880 15 OAI21_X1
* cell instance $19849 r0 *1 83.22,85.4
X$19849 4812 4900 4116 15 4758 27 AOI21_X2
* cell instance $19850 r0 *1 84.55,85.4
X$19850 4901 4760 4902 2438 4082 4955 15 27 4956 OAI33_X1
* cell instance $19853 r0 *1 86.45,85.4
X$19853 4812 4956 15 27 4874 XNOR2_X2
* cell instance $19856 r0 *1 89.3,85.4
X$19856 4036 3892 3925 3871 5013 15 27 OAI211_X2
* cell instance $19857 m0 *1 90.25,85.4
X$19857 3892 4004 3893 4036 15 27 4815 NAND4_X1
* cell instance $19862 r0 *1 91.2,85.4
X$19862 15 4904 3871 4312 4737 5012 27 NOR4_X4
* cell instance $19863 m0 *1 94.43,85.4
X$19863 4672 3817 15 27 4877 NAND2_X2
* cell instance $19864 m0 *1 93.1,85.4
X$19864 4672 4004 3893 15 27 4759 NAND3_X2
* cell instance $19867 r0 *1 94.81,85.4
X$19867 15 4901 4759 4906 4763 4732 27 AOI22_X4
* cell instance $19869 m0 *1 95.76,85.4
X$19869 4761 4762 15 27 4760 NAND2_X1
* cell instance $19870 m0 *1 96.9,85.4
X$19870 4732 4763 27 15 4816 AND2_X1
* cell instance $19873 r0 *1 98.04,85.4
X$19873 3785 4959 4960 4121 27 4875 15 NOR4_X2
* cell instance $19874 m0 *1 98.23,85.4
X$19874 4759 4764 15 27 4878 NOR2_X1
* cell instance $19876 m0 *1 98.8,85.4
X$19876 4879 4800 4878 15 4818 27 AOI21_X2
* cell instance $19877 m0 *1 100.13,85.4
X$19877 4765 4764 15 27 4799 NOR2_X1
* cell instance $19878 m0 *1 100.7,85.4
X$19878 4880 15 27 4876 INV_X1
* cell instance $19881 r0 *1 99.75,85.4
X$19881 4764 4765 4877 27 4961 15 OAI21_X1
* cell instance $19882 r0 *1 100.51,85.4
X$19882 4817 3069 4961 15 4879 27 AOI21_X1
* cell instance $19884 r0 *1 101.46,85.4
X$19884 4905 4799 15 27 4964 NOR2_X1
* cell instance $19885 r0 *1 102.03,85.4
X$19885 4988 4875 3917 3558 4963 15 27 OAI211_X2
* cell instance $19886 m0 *1 103.17,85.4
X$19886 4876 4963 4766 27 15 4577 OAI21_X4
* cell instance $19889 m0 *1 106.4,85.4
X$19889 4819 4494 4768 4767 27 15 4820 AND4_X1
* cell instance $19890 m0 *1 107.54,85.4
X$19890 4767 4768 4494 5007 15 4821 27 NAND4_X2
* cell instance $19892 r0 *1 103.74,85.4
X$19892 4760 4817 15 27 4966 NAND2_X1
* cell instance $19893 r0 *1 104.31,85.4
X$19893 4964 4989 15 27 4776 XNOR2_X2
* cell instance $19895 r0 *1 106.4,85.4
X$19895 4967 4966 15 27 4589 XNOR2_X2
* cell instance $19897 m0 *1 109.82,85.4
X$19897 15 4768 4873 3778 3783 4962 27 NAND4_X4
* cell instance $19899 m0 *1 113.24,85.4
X$19899 4819 4906 4822 27 15 4873 AND3_X1
* cell instance $19903 r0 *1 109.82,85.4
X$19903 4819 4678 15 27 4771 XNOR2_X2
* cell instance $19905 r0 *1 111.91,85.4
X$19905 4902 4905 15 27 4822 XNOR2_X2
* cell instance $19906 r0 *1 113.81,85.4
X$19906 15 4771 4679 4822 4795 4127 27 NAND4_X4
* cell instance $19910 m0 *1 117.04,85.4
X$19910 15 4590 4769 4497 4823 4498 27 NAND4_X4
* cell instance $19912 m0 *1 120.46,85.4
X$19912 4127 4498 4579 15 27 3995 OR3_X4
* cell instance $19918 r0 *1 119.89,85.4
X$19918 4497 4823 4590 4769 27 15 4872 AND4_X1
* cell instance $19920 r0 *1 121.22,85.4
X$19920 4958 4585 4872 4739 4862 27 15 AOI211_X2
* cell instance $19921 r0 *1 122.93,85.4
X$19921 4679 4771 4795 15 27 4958 NAND3_X1
* cell instance $19922 r0 *1 123.69,85.4
X$19922 4795 4771 4679 27 15 4871 AND3_X1
* cell instance $19923 m0 *1 123.88,85.4
X$19923 3995 27 3612 15 BUF_X4
* cell instance $19926 m0 *1 125.4,85.4
X$19926 4771 15 27 4772 INV_X1
* cell instance $19927 m0 *1 125.78,85.4
X$19927 4770 4772 15 27 4681 NAND2_X1
* cell instance $19928 m0 *1 126.35,85.4
X$19928 15 4405 4770 4772 4824 3995 4773 27 AOI221_X4
* cell instance $19929 m0 *1 128.82,85.4
X$19929 3856 4826 4776 27 4733 15 OAI21_X1
* cell instance $19930 m0 *1 129.58,85.4
X$19930 4589 4862 4504 4775 27 4736 15 NOR4_X2
* cell instance $19931 m0 *1 131.29,85.4
X$19931 4577 4823 4590 4769 27 15 4794 AND4_X1
* cell instance $19932 m0 *1 132.43,85.4
X$19932 4823 4590 4769 27 15 4684 AND3_X1
* cell instance $19933 m0 *1 133.38,85.4
X$19933 4775 4504 15 27 4587 NOR2_X1
* cell instance $19934 m0 *1 133.95,85.4
X$19934 4324 4590 4823 4827 15 4953 27 NAND4_X2
* cell instance $19935 m0 *1 135.66,85.4
X$19935 4577 15 27 4865 INV_X1
* cell instance $19936 m0 *1 136.04,85.4
X$19936 4865 4828 4952 27 15 3712 OAI21_X4
* cell instance $19938 m0 *1 139.27,85.4
X$19938 4774 4589 15 27 4863 OR2_X1
* cell instance $19939 m0 *1 140.03,85.4
X$19939 4862 4776 4863 15 4414 27 AOI21_X2
* cell instance $19941 m0 *1 141.55,85.4
X$19941 4862 4776 3969 15 27 4726 OR3_X1
* cell instance $19946 r0 *1 125.59,85.4
X$19946 4679 4771 15 27 4825 NAND2_X1
* cell instance $19948 r0 *1 126.54,85.4
X$19948 4795 15 27 4824 INV_X1
* cell instance $19949 r0 *1 126.92,85.4
X$19949 4585 4825 15 27 4773 NOR2_X1
* cell instance $19951 r0 *1 128.25,85.4
X$19951 4825 4585 15 27 4826 OR2_X1
* cell instance $19954 r0 *1 129.96,85.4
X$19954 15 4127 4585 4794 4775 27 NOR3_X4
* cell instance $19955 r0 *1 132.62,85.4
X$19955 4585 4127 15 27 4827 NOR2_X2
* cell instance $19958 r0 *1 134.71,85.4
X$19958 4953 4769 27 4410 15 XOR2_X2
* cell instance $19959 r0 *1 136.42,85.4
X$19959 4827 4588 4587 15 4828 27 AOI21_X2
* cell instance $19964 r0 *1 142.88,85.4
X$19964 4858 4948 4793 27 15 4992 HA_X1
* cell instance $19966 m0 *1 144.4,85.4
X$19966 4792 4793 4859 27 15 4829 HA_X1
* cell instance $19968 m0 *1 146.87,85.4
X$19968 4859 15 27 4791 INV_X1
* cell instance $19971 m0 *1 147.44,85.4
X$19971 15 4857 4830 4852 4777 4791 27 FA_X1
* cell instance $19973 m0 *1 150.67,85.4
X$19973 4854 15 27 4946 INV_X1
* cell instance $19975 m0 *1 151.24,85.4
X$19975 15 4852 4854 4848 4856 4910 27 FA_X1
* cell instance $19976 m0 *1 154.28,85.4
X$19976 15 4790 4687 4780 4848 4847 27 FA_X1
* cell instance $19978 m0 *1 157.51,85.4
X$19978 15 4940 4790 4718 4832 4781 27 FA_X1
* cell instance $19984 m0 *1 178.03,85.4
X$19984 15 4841 4599 4840 4925 4420 27 FA_X1
* cell instance $19985 m0 *1 181.07,85.4
X$19985 4840 5048 4838 27 15 4788 HA_X1
* cell instance $19986 m0 *1 182.97,85.4
X$19986 4837 4788 4601 27 15 4693 HA_X1
* cell instance $19987 m0 *1 184.87,85.4
X$19987 4836 15 27 4835 BUF_X1
* cell instance $19994 r0 *1 149.91,85.4
X$19994 4946 4947 4855 27 15 4907 HA_X1
* cell instance $19995 r0 *1 151.81,85.4
X$19995 15 4779 4908 4052 4855 4943 27 FA_X1
* cell instance $19999 r0 *1 159.03,85.4
X$19999 4941 15 27 4940 INV_X1
* cell instance $20000 r0 *1 159.41,85.4
X$20000 15 4914 4941 4939 5002 4913 27 FA_X1
* cell instance $20001 r0 *1 162.45,85.4
X$20001 4939 15 27 4935 INV_X1
* cell instance $20002 r0 *1 162.83,85.4
X$20002 15 4938 4783 4846 4916 4935 27 FA_X1
* cell instance $20003 r0 *1 165.87,85.4
X$20003 15 4919 4938 4932 4936 4931 27 FA_X1
* cell instance $20005 r0 *1 169.67,85.4
X$20005 4932 15 27 4929 INV_X1
* cell instance $20006 r0 *1 170.05,85.4
X$20006 15 4833 4784 4927 4930 4929 27 FA_X1
* cell instance $20012 r0 *1 174.23,85.4
X$20012 4927 15 27 4843 INV_X1
* cell instance $20015 r0 *1 176.51,85.4
X$20015 5000 15 27 4422 INV_X1
* cell instance $20019 r0 *1 181.64,85.4
X$20019 4782 4838 4999 27 15 4785 HA_X1
* cell instance $20020 r0 *1 183.54,85.4
X$20020 4831 15 27 4834 BUF_X1
* cell instance $20037 r0 *1 12.92,186.2
X$20037 9416 15 27 10128 BUF_X1
* cell instance $20041 r0 *1 15.58,186.2
X$20041 9389 15 27 10131 BUF_X1
* cell instance $20044 r0 *1 18.43,186.2
X$20044 9679 15 27 10133 BUF_X1
* cell instance $20048 m0 *1 20.71,186.2
X$20048 9567 15 27 10101 BUF_X1
* cell instance $20052 r0 *1 21.66,186.2
X$20052 9448 15 27 10135 BUF_X1
* cell instance $20055 r0 *1 23.18,186.2
X$20055 9570 15 27 10134 BUF_X1
* cell instance $20057 r0 *1 25.27,186.2
X$20057 9790 15 27 10137 BUF_X1
* cell instance $20075 r0 *1 11.59,9.8
X$20075 350 502 531 15 443 27 AOI21_X2
* cell instance $20077 m0 *1 12.35,9.8
X$20077 349 270 15 27 403 OR2_X1
* cell instance $20079 r0 *1 12.92,9.8
X$20079 15 443 403 406 578 405 27 OAI22_X4
* cell instance $20080 m0 *1 14.25,9.8
X$20080 404 458 459 27 15 350 OAI21_X2
* cell instance $20081 m0 *1 15.58,9.8
X$20081 351 271 355 445 310 460 27 15 AOI221_X2
* cell instance $20082 m0 *1 17.67,9.8
X$20082 270 353 352 15 310 27 AOI21_X1
* cell instance $20084 m0 *1 18.62,9.8
X$20084 354 353 352 15 409 27 AOI21_X1
* cell instance $20085 m0 *1 19.38,9.8
X$20085 381 15 27 270 CLKBUF_X3
* cell instance $20087 m0 *1 20.52,9.8
X$20087 224 27 355 15 BUF_X4
* cell instance $20090 r0 *1 16.15,9.8
X$20090 407 504 311 15 406 27 AOI21_X2
* cell instance $20092 r0 *1 17.86,9.8
X$20092 354 505 408 410 409 533 27 15 AOI221_X2
* cell instance $20093 r0 *1 19.95,9.8
X$20093 445 224 15 27 349 NAND2_X2
* cell instance $20094 r0 *1 20.9,9.8
X$20094 410 408 15 27 312 NAND2_X2
* cell instance $20095 r0 *1 21.85,9.8
X$20095 410 224 15 27 358 NAND2_X1
* cell instance $20096 r0 *1 22.42,9.8
X$20096 508 506 449 15 272 27 AOI21_X1
* cell instance $20097 r0 *1 23.18,9.8
X$20097 275 356 226 15 27 506 NAND3_X1
* cell instance $20098 m0 *1 24.51,9.8
X$20098 208 357 15 27 273 NAND2_X1
* cell instance $20099 m0 *1 23.75,9.8
X$20099 361 356 357 15 27 313 NOR3_X1
* cell instance $20100 m0 *1 25.08,9.8
X$20100 358 208 15 27 411 NOR2_X1
* cell instance $20102 r0 *1 23.94,9.8
X$20102 275 223 357 15 27 449 NAND3_X1
* cell instance $20104 r0 *1 24.89,9.8
X$20104 356 411 451 361 15 27 404 AOI22_X2
* cell instance $20106 m0 *1 26.03,9.8
X$20106 358 275 356 15 27 451 NOR3_X1
* cell instance $20107 m0 *1 26.98,9.8
X$20107 208 365 15 359 27 NAND2_X4
* cell instance $20108 m0 *1 28.69,9.8
X$20108 276 359 364 360 15 27 277 AOI22_X2
* cell instance $20109 m0 *1 30.4,9.8
X$20109 361 356 363 362 278 354 15 27 OAI221_X2
* cell instance $20110 m0 *1 32.49,9.8
X$20110 412 387 317 508 223 381 27 15 AOI221_X2
* cell instance $20111 m0 *1 34.58,9.8
X$20111 464 360 364 280 27 15 318 AND4_X1
* cell instance $20113 m0 *1 36.48,9.8
X$20113 280 364 360 464 15 27 320 NAND4_X1
* cell instance $20114 m0 *1 37.43,9.8
X$20114 208 365 15 27 282 NOR2_X1
* cell instance $20119 r0 *1 28.69,9.8
X$20119 15 462 359 360 364 27 AOI21_X4
* cell instance $20120 r0 *1 31.16,9.8
X$20120 364 360 15 27 223 NAND2_X2
* cell instance $20121 r0 *1 32.11,9.8
X$20121 225 356 15 27 363 NAND2_X1
* cell instance $20122 r0 *1 32.68,9.8
X$20122 279 223 15 27 412 NOR2_X1
* cell instance $20123 r0 *1 33.25,9.8
X$20123 360 364 281 15 27 463 AND3_X4
* cell instance $20125 r0 *1 35.53,9.8
X$20125 364 360 281 15 543 27 NAND3_X4
* cell instance $20127 r0 *1 38.19,9.8
X$20127 275 224 15 27 465 NOR2_X2
* cell instance $20128 m0 *1 40.09,9.8
X$20128 360 364 392 367 322 15 27 OAI211_X2
* cell instance $20129 m0 *1 38.38,9.8
X$20129 282 465 283 366 27 15 321 OAI22_X2
* cell instance $20132 r0 *1 39.33,9.8
X$20132 283 366 356 15 27 NOR2_X4
* cell instance $20134 r0 *1 41.23,9.8
X$20134 260 27 224 15 BUF_X4
* cell instance $20135 m0 *1 42.37,9.8
X$20135 284 275 27 15 392 AND2_X1
* cell instance $20142 r0 *1 44.27,9.8
X$20142 260 15 27 365 INV_X4
* cell instance $20145 r0 *1 46.36,9.8
X$20145 514 27 360 15 BUF_X4
* cell instance $20154 m0 *1 22.61,180.6
X$20154 15 10446 9790 9826 9615 27 DFF_X1
* cell instance $20155 m0 *1 25.84,180.6
X$20155 9790 9653 15 27 9791 NAND2_X1
* cell instance $20156 m0 *1 26.41,180.6
X$20156 9573 9791 9571 15 9826 27 AOI21_X1
* cell instance $20160 m0 *1 29.64,180.6
X$20160 8502 9792 15 27 9953 NAND2_X1
* cell instance $20161 m0 *1 30.21,180.6
X$20161 9798 9855 9794 15 9793 27 AOI21_X1
* cell instance $20173 r0 *1 25.65,180.6
X$20173 9573 9886 9546 15 9938 27 AOI21_X1
* cell instance $20175 r0 *1 26.6,180.6
X$20175 8969 15 27 9615 CLKBUF_X3
* cell instance $20176 r0 *1 27.55,180.6
X$20176 9615 15 27 CLKBUF_X1
* cell instance $20177 r0 *1 28.12,180.6
X$20177 9909 9653 15 27 9886 NAND2_X1
* cell instance $20179 r0 *1 28.88,180.6
X$20179 15 10531 9910 9793 9856 27 DFF_X1
* cell instance $20180 r0 *1 32.11,180.6
X$20180 8551 9792 15 27 9994 NAND2_X1
* cell instance $20183 r0 *1 34.58,180.6
X$20183 9798 9940 9857 15 9939 27 AOI21_X1
* cell instance $20184 m0 *1 35.72,180.6
X$20184 9573 9890 9716 15 9889 27 AOI21_X1
* cell instance $20185 m0 *1 35.15,180.6
X$20185 8373 9792 15 27 9857 NAND2_X1
* cell instance $20188 r0 *1 35.34,180.6
X$20188 15 10544 9913 9889 9856 27 DFF_X1
* cell instance $20190 m0 *1 38.38,180.6
X$20190 8166 9792 15 27 9858 NAND2_X1
* cell instance $20191 m0 *1 41.99,180.6
X$20191 8403 9792 15 27 9942 NAND2_X1
* cell instance $20192 m0 *1 42.56,180.6
X$20192 8969 15 27 9390 CLKBUF_X3
* cell instance $20193 m0 *1 43.51,180.6
X$20193 9390 15 27 CLKBUF_X1
* cell instance $20194 m0 *1 44.08,180.6
X$20194 8402 9796 15 27 9895 NAND2_X1
* cell instance $20195 m0 *1 44.65,180.6
X$20195 15 10335 9797 9769 9660 27 DFF_X1
* cell instance $20196 m0 *1 47.88,180.6
X$20196 9797 9653 15 27 9839 NAND2_X1
* cell instance $20199 r0 *1 38.57,180.6
X$20199 9913 9894 15 27 9890 NAND2_X1
* cell instance $20202 r0 *1 39.71,180.6
X$20202 15 10550 9914 9893 9390 27 DFF_X1
* cell instance $20203 r0 *1 42.94,180.6
X$20203 9573 9943 9895 15 9893 27 AOI21_X1
* cell instance $20205 r0 *1 44.08,180.6
X$20205 7449 9796 15 27 9955 NAND2_X1
* cell instance $20208 r0 *1 46.36,180.6
X$20208 8504 9796 15 27 9916 NAND2_X1
* cell instance $20212 r0 *1 48.26,180.6
X$20212 7533 15 27 9915 CLKBUF_X3
* cell instance $20213 r0 *1 49.21,180.6
X$20213 8009 9796 15 27 10000 NAND2_X1
* cell instance $20217 r0 *1 51.11,180.6
X$20217 15 10519 9860 9859 9660 27 DFF_X1
* cell instance $20218 m0 *1 52.06,180.6
X$20218 9798 9840 9293 15 9859 27 AOI21_X1
* cell instance $20220 m0 *1 52.82,180.6
X$20220 9860 9522 15 27 9840 NAND2_X1
* cell instance $20222 m0 *1 53.58,180.6
X$20222 15 10439 9898 9799 9524 27 DFF_X1
* cell instance $20223 m0 *1 56.81,180.6
X$20223 15 10413 9843 9800 9358 27 DFF_X1
* cell instance $20224 m0 *1 60.04,180.6
X$20224 9798 9844 9846 15 9800 27 AOI21_X1
* cell instance $20228 r0 *1 54.91,180.6
X$20228 6628 9792 15 27 9958 NAND2_X1
* cell instance $20231 r0 *1 56.43,180.6
X$20231 7309 15 27 9798 CLKBUF_X3
* cell instance $20232 r0 *1 57.38,180.6
X$20232 7533 15 27 9894 CLKBUF_X3
* cell instance $20233 r0 *1 58.33,180.6
X$20233 9917 9522 15 27 9862 NAND2_X1
* cell instance $20234 r0 *1 58.9,180.6
X$20234 9798 9862 9391 15 9861 27 AOI21_X1
* cell instance $20240 m0 *1 61.18,180.6
X$20240 7742 9792 15 27 9846 NAND2_X1
* cell instance $20242 r0 *1 62.7,180.6
X$20242 7309 15 27 9863 CLKBUF_X3
* cell instance $20243 r0 *1 63.65,180.6
X$20243 8392 9796 15 27 10003 NAND2_X1
* cell instance $20244 m0 *1 63.84,180.6
X$20244 7309 15 27 9573 CLKBUF_X3
* cell instance $20250 m0 *1 70.3,180.6
X$20250 15 10323 9902 9780 9559 27 DFF_X1
* cell instance $20251 m0 *1 73.53,180.6
X$20251 8752 15 27 9559 CLKBUF_X3
* cell instance $20252 m0 *1 74.48,180.6
X$20252 9902 9648 15 27 9801 NAND2_X1
* cell instance $20253 m0 *1 75.05,180.6
X$20253 9559 15 27 CLKBUF_X1
* cell instance $20258 r0 *1 65.93,180.6
X$20258 9573 9963 9901 15 9947 27 AOI21_X1
* cell instance $20259 r0 *1 66.69,180.6
X$20259 7550 9796 15 27 9919 NAND2_X1
* cell instance $20260 r0 *1 67.26,180.6
X$20260 6547 9796 15 27 9901 NAND2_X1
* cell instance $20263 r0 *1 74.67,180.6
X$20263 15 10638 9922 9864 9559 27 DFF_X1
* cell instance $20264 m0 *1 77.71,180.6
X$20264 9593 9866 9802 15 9864 27 AOI21_X1
* cell instance $20266 m0 *1 78.47,180.6
X$20266 8112 9666 15 27 9867 NAND2_X1
* cell instance $20270 r0 *1 77.9,180.6
X$20270 9922 9589 15 27 9866 NAND2_X1
* cell instance $20271 r0 *1 78.47,180.6
X$20271 6749 9666 15 27 9968 NAND2_X1
* cell instance $20274 r0 *1 80.94,180.6
X$20274 8514 9804 15 27 9969 NAND2_X1
* cell instance $20275 r0 *1 81.51,180.6
X$20275 8114 9804 15 27 9970 NAND2_X1
* cell instance $20276 m0 *1 81.89,180.6
X$20276 15 10339 9904 9853 9868 27 DFF_X1
* cell instance $20278 m0 *1 85.12,180.6
X$20278 9297 9903 9854 15 9853 27 AOI21_X1
* cell instance $20281 m0 *1 88.16,180.6
X$20281 9297 9905 9729 15 9870 27 AOI21_X1
* cell instance $20285 m0 *1 91.39,180.6
X$20285 9530 15 27 CLKBUF_X1
* cell instance $20286 m0 *1 91.96,180.6
X$20286 8211 9666 15 27 9906 NAND2_X1
* cell instance $20287 m0 *1 92.53,180.6
X$20287 8752 15 27 9530 CLKBUF_X3
* cell instance $20288 m0 *1 93.48,180.6
X$20288 9803 9648 15 27 9711 NAND2_X1
* cell instance $20293 r0 *1 83.41,180.6
X$20293 9725 9869 15 27 9726 NAND2_X1
* cell instance $20296 r0 *1 84.93,180.6
X$20296 9904 9869 15 27 9903 NAND2_X1
* cell instance $20299 r0 *1 86.07,180.6
X$20299 8209 9804 15 27 9923 NAND2_X1
* cell instance $20301 r0 *1 87.02,180.6
X$20301 15 10618 9952 9870 9868 27 DFF_X1
* cell instance $20302 r0 *1 90.25,180.6
X$20302 9952 9869 15 27 9905 NAND2_X1
* cell instance $20304 r0 *1 91.58,180.6
X$20304 7050 9804 15 27 9925 NAND2_X1
* cell instance $20307 r0 *1 93.29,180.6
X$20307 9667 9907 9906 15 9871 27 AOI21_X1
* cell instance $20309 r0 *1 94.24,180.6
X$20309 10046 9869 15 27 9907 NAND2_X1
* cell instance $20311 m0 *1 94.43,180.6
X$20311 8517 9804 15 27 10016 NAND2_X1
* cell instance $20313 m0 *1 98.23,180.6
X$20313 8120 9804 15 27 9852 NAND2_X1
* cell instance $20315 m0 *1 99.56,180.6
X$20315 9297 9908 9294 15 9872 27 AOI21_X1
* cell instance $20323 r0 *1 97.66,180.6
X$20323 8519 9804 15 27 9973 NAND2_X1
* cell instance $20325 r0 *1 98.42,180.6
X$20325 15 10643 9948 9872 9974 27 DFF_X1
* cell instance $20326 r0 *1 101.65,180.6
X$20326 9948 9869 15 27 9908 NAND2_X1
* cell instance $20328 r0 *1 102.41,180.6
X$20328 8648 9804 15 27 9950 NAND2_X1
* cell instance $20330 m0 *1 102.98,180.6
X$20330 15 10324 9788 9805 9974 27 DFF_X1
* cell instance $20332 m0 *1 107.16,180.6
X$20332 8477 9666 15 27 9927 NAND2_X1
* cell instance $20335 m0 *1 108.68,180.6
X$20335 9309 15 27 9589 CLKBUF_X3
* cell instance $20336 m0 *1 109.63,180.6
X$20336 8589 9666 15 27 9873 NAND2_X1
* cell instance $20341 r0 *1 105.07,180.6
X$20341 8680 9666 15 27 9949 NAND2_X1
* cell instance $20344 r0 *1 106.59,180.6
X$20344 9309 15 27 9648 CLKBUF_X3
* cell instance $20347 r0 *1 108.49,180.6
X$20347 9309 15 27 9869 CLKBUF_X3
* cell instance $20349 r0 *1 109.63,180.6
X$20349 9307 15 27 9667 CLKBUF_X3
* cell instance $20352 m0 *1 110.58,180.6
X$20352 15 10349 9874 9808 9400 27 DFF_X1
* cell instance $20355 m0 *1 116.28,180.6
X$20355 15 10366 9811 9810 9595 27 DFF_X1
* cell instance $20357 r0 *1 110.77,180.6
X$20357 9874 9589 15 27 9807 NAND2_X1
* cell instance $20361 r0 *1 114.95,180.6
X$20361 9979 9878 15 27 9900 NAND2_X1
* cell instance $20365 r0 *1 115.52,180.6
X$20365 9595 15 27 CLKBUF_X1
* cell instance $20366 r0 *1 116.09,180.6
X$20366 8280 15 27 9595 CLKBUF_X3
* cell instance $20367 r0 *1 117.04,180.6
X$20367 9304 9900 9809 15 9875 27 AOI21_X1
* cell instance $20368 r0 *1 117.8,180.6
X$20368 15 10493 9932 9899 9980 27 DFF_X1
* cell instance $20370 m0 *1 119.89,180.6
X$20370 9304 9931 9737 15 9899 27 AOI21_X1
* cell instance $20371 m0 *1 123.69,180.6
X$20371 15 10392 9812 9849 9980 27 DFF_X1
* cell instance $20373 m0 *1 127.11,180.6
X$20373 9812 9816 15 27 9778 NAND2_X1
* cell instance $20374 m0 *1 127.68,180.6
X$20374 9539 9896 9848 15 9879 27 AOI21_X1
* cell instance $20378 m0 *1 130.91,180.6
X$20378 15 10458 9813 9847 9814 27 DFF_X1
* cell instance $20379 m0 *1 134.14,180.6
X$20379 15 10449 9815 9845 9814 27 DFF_X1
* cell instance $20380 m0 *1 137.37,180.6
X$20380 9815 9672 15 27 9773 NAND2_X1
* cell instance $20388 r0 *1 122.36,180.6
X$20388 9934 9897 9782 15 9877 27 AOI21_X1
* cell instance $20391 r0 *1 124.07,180.6
X$20391 9933 9878 15 27 9897 NAND2_X1
* cell instance $20394 r0 *1 125.78,180.6
X$20394 9307 15 27 9972 CLKBUF_X3
* cell instance $20395 r0 *1 126.73,180.6
X$20395 15 10484 9945 9879 9980 27 DFF_X1
* cell instance $20396 r0 *1 129.96,180.6
X$20396 9945 9816 15 27 9896 NAND2_X1
* cell instance $20398 r0 *1 130.72,180.6
X$20398 9309 15 27 9878 CLKBUF_X3
* cell instance $20399 r0 *1 131.67,180.6
X$20399 9307 15 27 9934 CLKBUF_X3
* cell instance $20403 r0 *1 139.27,180.6
X$20403 9934 9892 8460 15 9880 27 AOI21_X1
* cell instance $20405 r0 *1 140.79,180.6
X$20405 9891 9672 15 27 9892 NAND2_X1
* cell instance $20408 r0 *1 143.26,180.6
X$20408 15 10532 9842 9881 9739 27 DFF_X1
* cell instance $20409 m0 *1 143.83,180.6
X$20409 9539 9888 9671 15 9881 27 AOI21_X1
* cell instance $20413 m0 *1 144.97,180.6
X$20413 9842 9816 15 27 9888 NAND2_X1
* cell instance $20419 m0 *1 150.48,180.6
X$20419 9605 9817 10871 27 15 9882 HA_X1
* cell instance $20423 r0 *1 152,180.6
X$20423 9882 9818 10878 27 15 9819 HA_X1
* cell instance $20424 m0 *1 153.71,180.6
X$20424 15 9820 9830 9760 9819 9837 27 FA_X1
* cell instance $20430 m0 *1 162.45,180.6
X$20430 15 9885 9836 9832 9883 9675 27 FA_X1
* cell instance $20431 m0 *1 159.41,180.6
X$20431 15 9887 9828 9837 9835 9751 27 FA_X1
* cell instance $20432 m0 *1 165.49,180.6
X$20432 9832 15 27 9831 INV_X1
* cell instance $20434 m0 *1 166.06,180.6
X$20434 9675 15 27 9833 INV_X1
* cell instance $20439 r0 *1 162.64,180.6
X$20439 9075 15 27 9883 INV_X1
* cell instance $20441 r0 *1 163.21,180.6
X$20441 9742 15 27 9885 INV_X1
* cell instance $20443 r0 *1 163.78,180.6
X$20443 9742 9075 9821 27 15 9884 HA_X1
* cell instance $20445 m0 *1 167.01,180.6
X$20445 15 9828 9829 9823 9822 9825 27 FA_X1
* cell instance $20448 m0 *1 171.57,180.6
X$20448 9827 15 27 9745 INV_X1
* cell instance $20450 m0 *1 172.14,180.6
X$20450 9747 9829 9827 27 15 9824 HA_X1
* cell instance $20474 m0 *1 53.2,4.2
X$20474 40 15 27 LOGIC0_X1
* cell instance $20475 m0 *1 53.58,4.2
X$20475 43 40 94 27 15 41 HA_X1
* cell instance $20476 m0 *1 55.48,4.2
X$20476 94 27 65 15 BUF_X4
* cell instance $20477 m0 *1 56.81,4.2
X$20477 65 41 20 27 42 15 OAI21_X1
* cell instance $20478 m0 *1 57.57,4.2
X$20478 65 20 41 15 27 97 OR3_X1
* cell instance $20479 m0 *1 58.52,4.2
X$20479 67 68 95 15 66 27 AOI21_X2
* cell instance $20480 m0 *1 59.85,4.2
X$20480 42 97 27 15 98 AND2_X1
* cell instance $20482 m0 *1 62.13,4.2
X$20482 99 15 27 69 BUF_X1
* cell instance $20483 m0 *1 62.7,4.2
X$20483 43 70 99 27 15 73 HA_X1
* cell instance $20484 m0 *1 64.6,4.2
X$20484 101 71 72 15 151 27 AOI21_X1
* cell instance $20485 m0 *1 65.36,4.2
X$20485 69 73 15 27 72 OR2_X1
* cell instance $20486 m0 *1 66.12,4.2
X$20486 102 101 21 15 74 27 AOI21_X2
* cell instance $20504 r0 *1 55.48,4.2
X$20504 66 148 15 27 192 NAND2_X1
* cell instance $20505 r0 *1 56.05,4.2
X$20505 20 95 65 41 148 15 27 OAI211_X2
* cell instance $20506 r0 *1 57.76,4.2
X$20506 111 177 179 27 15 68 HA_X1
* cell instance $20510 r0 *1 59.66,4.2
X$20510 68 15 27 150 INV_X1
* cell instance $20512 r0 *1 60.23,4.2
X$20512 42 150 15 27 149 NAND2_X1
* cell instance $20515 r0 *1 61.75,4.2
X$20515 133 15 27 71 BUF_X1
* cell instance $20516 r0 *1 62.32,4.2
X$20516 71 72 15 27 332 XOR2_X1
* cell instance $20517 r0 *1 63.46,4.2
X$20517 111 180 133 27 15 101 HA_X1
* cell instance $20518 r0 *1 65.36,4.2
X$20518 21 71 69 73 134 15 27 OAI211_X2
* cell instance $20519 r0 *1 67.07,4.2
X$20519 104 153 27 15 152 XNOR2_X1
* cell instance $20521 m0 *1 67.83,4.2
X$20521 44 134 74 15 23 27 AOI21_X2
* cell instance $20522 m0 *1 69.35,4.2
X$20522 104 136 22 15 27 112 NAND3_X2
* cell instance $20523 m0 *1 70.68,4.2
X$20523 15 22 45 76 23 75 27 NOR4_X4
* cell instance $20527 r0 *1 68.4,4.2
X$20527 134 74 27 153 15 AND2_X4
* cell instance $20530 r0 *1 70.68,4.2
X$20530 22 15 27 155 INV_X1
* cell instance $20531 r0 *1 71.06,4.2
X$20531 138 235 104 27 15 76 HA_X1
* cell instance $20533 r0 *1 73.15,4.2
X$20533 45 136 76 15 214 27 AOI21_X2
* cell instance $20534 r0 *1 74.48,4.2
X$20534 23 76 15 27 213 NOR2_X1
* cell instance $20536 r0 *1 75.43,4.2
X$20536 113 15 27 136 BUF_X2
* cell instance $20537 m0 *1 76.19,4.2
X$20537 46 15 27 LOGIC0_X1
* cell instance $20542 m0 *1 76.95,4.2
X$20542 43 46 79 27 15 47 HA_X1
* cell instance $20545 r0 *1 78.85,4.2
X$20545 77 159 15 27 218 NAND2_X1
* cell instance $20546 m0 *1 80.18,4.2
X$20546 79 47 15 27 143 OR2_X1
* cell instance $20547 m0 *1 79.23,4.2
X$20547 47 79 15 27 78 NOR2_X2
* cell instance $20555 r0 *1 79.61,4.2
X$20555 111 157 77 27 15 158 HA_X1
* cell instance $20556 r0 *1 81.51,4.2
X$20556 158 77 143 15 80 27 AOI21_X1
* cell instance $20557 r0 *1 82.27,4.2
X$20557 159 80 27 15 185 XNOR2_X1
* cell instance $20560 r0 *1 95.57,4.2
X$20560 15 160 27 114 BUF_X8
* cell instance $20564 r0 *1 100.51,4.2
X$20564 115 15 27 161 INV_X1
* cell instance $20567 r0 *1 103.17,4.2
X$20567 197 115 187 15 241 27 AOI21_X2
* cell instance $20569 m0 *1 104.31,4.2
X$20569 147 81 27 15 108 XNOR2_X1
* cell instance $20572 m0 *1 111.72,4.2
X$20572 48 146 190 15 64 27 AOI21_X2
* cell instance $20573 m0 *1 113.05,4.2
X$20573 48 24 15 27 145 XOR2_X1
* cell instance $20574 m0 *1 114.19,4.2
X$20574 49 24 48 15 27 109 NAND3_X1
* cell instance $20576 m0 *1 115.14,4.2
X$20576 50 144 25 27 26 15 OAI21_X1
* cell instance $20577 m0 *1 115.9,4.2
X$20577 109 50 15 27 25 NAND2_X1
* cell instance $20580 m0 *1 120.27,4.2
X$20580 15 51 84 52 201 27 NOR3_X4
* cell instance $20582 m0 *1 123.69,4.2
X$20582 85 84 15 27 110 NOR2_X1
* cell instance $20585 r0 *1 105.26,4.2
X$20585 188 116 15 81 27 NAND2_X4
* cell instance $20586 r0 *1 106.97,4.2
X$20586 15 162 189 147 81 27 AOI21_X4
* cell instance $20587 r0 *1 109.44,4.2
X$20587 189 15 27 146 INV_X1
* cell instance $20588 r0 *1 109.82,4.2
X$20588 15 162 117 200 51 27 NOR3_X4
* cell instance $20591 r0 *1 113.05,4.2
X$20591 146 190 27 15 118 AND2_X1
* cell instance $20592 r0 *1 113.81,4.2
X$20592 145 49 163 118 27 15 144 OAI22_X1
* cell instance $20594 r0 *1 114.95,4.2
X$20594 164 50 15 27 186 OR2_X1
* cell instance $20599 r0 *1 115.9,4.2
X$20599 114 82 186 26 166 142 15 27 139 OAI33_X1
* cell instance $20601 r0 *1 117.61,4.2
X$20601 119 83 27 15 142 XNOR2_X1
* cell instance $20602 r0 *1 118.75,4.2
X$20602 48 118 110 27 83 15 OAI21_X1
* cell instance $20607 r0 *1 121.79,4.2
X$20607 119 141 27 15 140 AND2_X1
* cell instance $20608 r0 *1 122.55,4.2
X$20608 15 120 183 140 135 217 27 NOR4_X4
* cell instance $20609 m0 *1 124.83,4.2
X$20609 84 52 15 27 32 OR2_X1
* cell instance $20611 m0 *1 125.59,4.2
X$20611 53 32 51 15 27 86 NOR3_X1
* cell instance $20613 r0 *1 125.97,4.2
X$20613 119 85 137 84 15 27 167 NOR4_X1
* cell instance $20615 m0 *1 126.92,4.2
X$20615 52 84 51 87 15 27 62 NOR4_X1
* cell instance $20617 m0 *1 128.06,4.2
X$20617 89 62 27 15 88 XNOR2_X1
* cell instance $20618 m0 *1 129.2,4.2
X$20618 54 106 107 27 63 15 OAI21_X1
* cell instance $20619 m0 *1 129.96,4.2
X$20619 169 89 15 27 106 NAND2_X1
* cell instance $20622 r0 *1 127.11,4.2
X$20622 86 103 168 182 28 27 15 135 OAI221_X1
* cell instance $20623 r0 *1 128.25,4.2
X$20623 121 122 15 27 54 NOR2_X1
* cell instance $20624 r0 *1 128.82,4.2
X$20624 122 169 121 88 15 27 107 OR4_X1
* cell instance $20625 r0 *1 129.96,4.2
X$20625 15 175 87 90 325 27 NOR3_X4
* cell instance $20627 m0 *1 131.1,4.2
X$20627 205 57 27 85 15 XOR2_X2
* cell instance $20629 m0 *1 133.57,4.2
X$20629 89 105 15 27 90 NAND2_X1
* cell instance $20632 m0 *1 136.42,4.2
X$20632 56 61 15 27 103 XOR2_X1
* cell instance $20633 m0 *1 137.56,4.2
X$20633 55 56 15 27 91 OR2_X1
* cell instance $20634 m0 *1 138.32,4.2
X$20634 57 173 100 15 27 61 NAND3_X1
* cell instance $20636 r0 *1 132.62,4.2
X$20636 206 137 171 15 27 170 NAND3_X1
* cell instance $20637 r0 *1 133.38,4.2
X$20637 90 87 15 27 171 NOR2_X1
* cell instance $20639 r0 *1 134.14,4.2
X$20639 206 137 131 27 211 15 OAI21_X1
* cell instance $20641 r0 *1 135.09,4.2
X$20641 123 15 27 324 INV_X1
* cell instance $20643 r0 *1 135.66,4.2
X$20643 124 172 123 27 31 15 OAI21_X1
* cell instance $20646 r0 *1 137.56,4.2
X$20646 91 181 132 125 174 123 15 27 OAI221_X2
* cell instance $20648 m0 *1 139.65,4.2
X$20648 58 15 27 100 INV_X1
* cell instance $20649 m0 *1 140.03,4.2
X$20649 15 58 55 56 92 27 NOR3_X4
* cell instance $20652 m0 *1 143.64,4.2
X$20652 15 96 128 92 59 93 27 AND4_X4
* cell instance $20655 m0 *1 147.06,4.2
X$20655 129 60 15 27 131 XOR2_X1
* cell instance $20657 m0 *1 148.39,4.2
X$20657 15 256 27 93 BUF_X8
* cell instance $20665 r0 *1 139.65,4.2
X$20665 100 178 127 126 174 15 27 OAI211_X2
* cell instance $20668 r0 *1 141.93,4.2
X$20668 92 126 127 27 15 176 OAI21_X2
* cell instance $20669 r0 *1 143.26,4.2
X$20669 15 128 96 59 92 127 27 NAND4_X4
* cell instance $20670 r0 *1 146.68,4.2
X$20670 129 60 15 27 175 XNOR2_X2
* cell instance $20671 r0 *1 148.58,4.2
X$20671 130 59 15 27 60 NAND2_X1
* cell instance $20672 r0 *1 149.15,4.2
X$20672 130 207 15 27 89 XNOR2_X2
* cell instance $20690 m0 *1 9.88,172.2
X$20690 15 10417 9416 9334 8916 27 DFF_X1
* cell instance $20691 m0 *1 13.11,172.2
X$20691 15 10394 9389 9419 8916 27 DFF_X1
* cell instance $20702 m0 *1 16.72,172.2
X$20702 7309 15 27 9222 CLKBUF_X3
* cell instance $20705 m0 *1 20.14,172.2
X$20705 9289 15 27 10839 INV_X1
* cell instance $20709 m0 *1 38.76,172.2
X$20709 15 10381 9435 9290 9390 27 DFF_X1
* cell instance $20713 r0 *1 17.67,172.2
X$20713 7309 15 27 5687 CLKBUF_X3
* cell instance $20714 r0 *1 18.62,172.2
X$20714 15 10503 9448 9488 9289 27 DFF_X1
* cell instance $20715 r0 *1 21.85,172.2
X$20715 8969 15 27 9289 CLKBUF_X3
* cell instance $20716 r0 *1 22.8,172.2
X$20716 5687 9449 9453 15 9488 27 AOI21_X1
* cell instance $20719 r0 *1 30.4,172.2
X$20719 6673 9450 15 27 9492 NAND2_X1
* cell instance $20720 r0 *1 30.97,172.2
X$20720 6925 9450 15 27 9493 NAND2_X1
* cell instance $20724 r0 *1 35.15,172.2
X$20724 8969 15 27 9224 CLKBUF_X3
* cell instance $20725 r0 *1 36.1,172.2
X$20725 9224 15 27 CLKBUF_X1
* cell instance $20728 r0 *1 38.57,172.2
X$20728 8632 9291 15 27 9630 NAND2_X1
* cell instance $20731 r0 *1 40.28,172.2
X$20731 7546 9291 15 27 9451 NAND2_X1
* cell instance $20735 r0 *1 42.18,172.2
X$20735 6864 9450 15 27 9452 NAND2_X1
* cell instance $20736 r0 *1 42.75,172.2
X$20736 15 10571 9454 9498 9390 27 DFF_X1
* cell instance $20737 m0 *1 43.32,172.2
X$20737 5354 15 27 8969 CLKBUF_X3
* cell instance $20739 m0 *1 44.27,172.2
X$20739 8060 9499 8311 15 9498 27 AOI21_X1
* cell instance $20742 r0 *1 45.98,172.2
X$20742 9454 7924 15 27 9499 NAND2_X1
* cell instance $20744 m0 *1 46.17,172.2
X$20744 15 9437 9226 10666 8313 27 DFF_X2
* cell instance $20746 m0 *1 52.06,172.2
X$20746 8508 9291 15 27 9502 NAND2_X1
* cell instance $20749 m0 *1 57.19,172.2
X$20749 7271 15 27 9291 BUF_X2
* cell instance $20752 m0 *1 58.9,172.2
X$20752 9107 9291 15 27 9391 NAND2_X1
* cell instance $20753 m0 *1 59.47,172.2
X$20753 7533 15 27 7924 CLKBUF_X3
* cell instance $20757 m0 *1 73.34,172.2
X$20757 15 10434 7935 9110 9559 27 DFF_X1
* cell instance $20758 m0 *1 76.57,172.2
X$20758 15 10461 8112 9276 9277 27 DFF_X1
* cell instance $20760 m0 *1 79.99,172.2
X$20760 8114 8887 15 9392 27 NAND2_X4
* cell instance $20764 r0 *1 49.59,172.2
X$20764 9222 9638 9292 15 9554 27 AOI21_X1
* cell instance $20767 r0 *1 50.92,172.2
X$20767 6811 9450 15 27 9455 NAND2_X1
* cell instance $20771 r0 *1 52.82,172.2
X$20771 9222 9456 9502 15 9457 27 AOI21_X1
* cell instance $20774 r0 *1 55.86,172.2
X$20774 7041 9450 15 27 9453 NAND2_X1
* cell instance $20777 r0 *1 57,172.2
X$20777 8316 9450 15 27 9580 NAND2_X1
* cell instance $20778 r0 *1 57.57,172.2
X$20778 9222 9458 9459 15 9504 27 AOI21_X1
* cell instance $20783 r0 *1 59.85,172.2
X$20783 9222 9460 9461 15 9556 27 AOI21_X1
* cell instance $20786 r0 *1 62.51,172.2
X$20786 8278 9450 15 27 9640 NAND2_X1
* cell instance $20788 r0 *1 63.46,172.2
X$20788 6472 9450 15 27 9462 NAND2_X1
* cell instance $20789 r0 *1 64.03,172.2
X$20789 7271 15 27 9450 CLKBUF_X3
* cell instance $20791 r0 *1 65.17,172.2
X$20791 9109 9450 15 27 9463 NAND2_X1
* cell instance $20793 r0 *1 66.12,172.2
X$20793 8557 9450 15 27 9587 NAND2_X1
* cell instance $20797 r0 *1 70.68,172.2
X$20797 9527 7924 15 27 9464 NAND2_X1
* cell instance $20798 r0 *1 71.25,172.2
X$20798 8060 9464 8396 15 9558 27 AOI21_X1
* cell instance $20803 r0 *1 77.52,172.2
X$20803 8321 9393 15 27 9465 NAND2_X1
* cell instance $20806 r0 *1 79.23,172.2
X$20806 15 10610 8583 9279 9277 27 DFF_X1
* cell instance $20816 m0 *1 23.56,183.4
X$20816 15 10435 9909 9938 9615 27 DFF_X1
* cell instance $20818 m0 *1 29.83,183.4
X$20818 8305 9792 15 27 9954 NAND2_X1
* cell instance $20819 m0 *1 30.4,183.4
X$20819 9910 9915 15 27 9855 NAND2_X1
* cell instance $20836 r0 *1 26.98,183.4
X$20836 15 10533 10022 9993 9615 27 DFF_X1
* cell instance $20837 r0 *1 30.21,183.4
X$20837 9798 9992 9954 15 9993 27 AOI21_X1
* cell instance $20838 r0 *1 30.97,183.4
X$20838 10022 9915 15 27 9992 NAND2_X1
* cell instance $20840 r0 *1 31.92,183.4
X$20840 9798 9995 9994 15 10024 27 AOI21_X1
* cell instance $20841 r0 *1 32.68,183.4
X$20841 10025 9915 15 27 9995 NAND2_X1
* cell instance $20842 m0 *1 36.1,183.4
X$20842 8969 15 27 9856 CLKBUF_X3
* cell instance $20843 m0 *1 32.87,183.4
X$20843 15 10443 9911 9939 9856 27 DFF_X1
* cell instance $20844 m0 *1 37.05,183.4
X$20844 9911 9915 15 27 9940 NAND2_X1
* cell instance $20845 m0 *1 37.62,183.4
X$20845 9856 15 27 CLKBUF_X1
* cell instance $20846 m0 *1 38.19,183.4
X$20846 8308 9792 15 27 9912 NAND2_X1
* cell instance $20849 m0 *1 41.99,183.4
X$20849 9798 9944 9942 15 9998 27 AOI21_X1
* cell instance $20850 m0 *1 42.75,183.4
X$20850 9914 9894 15 27 9943 NAND2_X1
* cell instance $20851 m0 *1 43.32,183.4
X$20851 10028 9915 15 27 9944 NAND2_X1
* cell instance $20855 m0 *1 46.36,183.4
X$20855 9863 10032 9916 15 9999 27 AOI21_X1
* cell instance $20861 r0 *1 34.39,183.4
X$20861 15 10543 10093 10071 9856 27 DFF_X1
* cell instance $20863 r0 *1 38,183.4
X$20863 9863 10026 9912 15 10071 27 AOI21_X1
* cell instance $20864 r0 *1 38.76,183.4
X$20864 9863 9997 9858 15 10072 27 AOI21_X1
* cell instance $20865 r0 *1 39.52,183.4
X$20865 10027 9915 15 27 9997 NAND2_X1
* cell instance $20867 r0 *1 40.85,183.4
X$20867 15 10538 10028 9998 9390 27 DFF_X1
* cell instance $20868 r0 *1 44.08,183.4
X$20868 9863 10029 9955 15 10030 27 AOI21_X1
* cell instance $20871 r0 *1 45.98,183.4
X$20871 15 10619 10074 9999 9660 27 DFF_X1
* cell instance $20872 r0 *1 49.21,183.4
X$20872 9660 15 27 CLKBUF_X1
* cell instance $20873 r0 *1 49.78,183.4
X$20873 8969 15 27 9660 CLKBUF_X3
* cell instance $20874 r0 *1 50.73,183.4
X$20874 9863 10107 10000 15 10073 27 AOI21_X1
* cell instance $20876 r0 *1 51.87,183.4
X$20876 9863 10110 9956 15 10077 27 AOI21_X1
* cell instance $20878 m0 *1 52.06,183.4
X$20878 8313 9796 15 27 9956 NAND2_X1
* cell instance $20881 m0 *1 56.62,183.4
X$20881 8314 9796 15 27 10001 NAND2_X1
* cell instance $20884 m0 *1 58.14,183.4
X$20884 15 10403 9917 9861 9358 27 DFF_X1
* cell instance $20885 m0 *1 61.37,183.4
X$20885 8014 9796 15 27 9959 NAND2_X1
* cell instance $20887 m0 *1 62.7,183.4
X$20887 15 10391 9918 9947 9707 27 DFF_X1
* cell instance $20892 r0 *1 53.96,183.4
X$20892 10079 9915 15 27 9957 NAND2_X1
* cell instance $20893 r0 *1 54.53,183.4
X$20893 9863 9957 9958 15 10078 27 AOI21_X1
* cell instance $20897 r0 *1 56.62,183.4
X$20897 9863 10034 10001 15 10035 27 AOI21_X1
* cell instance $20907 r0 *1 61.37,183.4
X$20907 9863 9960 9959 15 9961 27 AOI21_X1
* cell instance $20911 r0 *1 63.46,183.4
X$20911 9863 9962 10003 15 10036 27 AOI21_X1
* cell instance $20914 r0 *1 65.36,183.4
X$20914 9918 9894 15 27 9963 NAND2_X1
* cell instance $20915 r0 *1 65.93,183.4
X$20915 9964 9894 15 27 10005 NAND2_X1
* cell instance $20916 m0 *1 66.5,183.4
X$20916 8969 15 27 9707 CLKBUF_X3
* cell instance $20918 m0 *1 67.45,183.4
X$20918 9573 10005 9919 15 9965 27 AOI21_X1
* cell instance $20919 m0 *1 68.21,183.4
X$20919 9707 15 27 CLKBUF_X1
* cell instance $20924 r0 *1 66.88,183.4
X$20924 15 10599 9964 9965 9707 27 DFF_X1
* cell instance $20928 m0 *1 74.67,183.4
X$20928 9920 9648 15 27 9921 NAND2_X1
* cell instance $20929 m0 *1 71.44,183.4
X$20929 15 10287 9920 10007 9707 27 DFF_X1
* cell instance $20930 m0 *1 75.24,183.4
X$20930 9667 9921 9865 15 10007 27 AOI21_X1
* cell instance $20933 r0 *1 71.44,183.4
X$20933 15 10621 9966 10008 9559 27 DFF_X1
* cell instance $20934 r0 *1 74.67,183.4
X$20934 9966 9869 15 27 9967 NAND2_X1
* cell instance $20935 r0 *1 75.24,183.4
X$20935 9667 9967 9968 15 10008 27 AOI21_X1
* cell instance $20937 r0 *1 76.19,183.4
X$20937 9667 10038 9867 15 10039 27 AOI21_X1
* cell instance $20939 r0 *1 77.14,183.4
X$20939 15 10629 10094 10082 9868 27 DFF_X1
* cell instance $20941 r0 *1 80.56,183.4
X$20941 9593 10040 9969 15 10082 27 AOI21_X1
* cell instance $20943 r0 *1 81.51,183.4
X$20943 9972 10041 9970 15 10011 27 AOI21_X1
* cell instance $20945 m0 *1 82.65,183.4
X$20945 8584 9804 15 27 9971 NAND2_X1
* cell instance $20950 r0 *1 82.65,183.4
X$20950 9972 10012 9971 15 10042 27 AOI21_X1
* cell instance $20951 r0 *1 83.41,183.4
X$20951 10096 9926 15 27 10012 NAND2_X1
* cell instance $20952 r0 *1 83.98,183.4
X$20952 8752 15 27 9868 CLKBUF_X3
* cell instance $20953 r0 *1 84.93,183.4
X$20953 15 10612 10043 10013 9868 27 DFF_X1
* cell instance $20954 m0 *1 86.07,183.4
X$20954 9972 10084 9923 15 10013 27 AOI21_X1
* cell instance $20958 m0 *1 88.54,183.4
X$20958 8652 9804 15 27 9924 NAND2_X1
* cell instance $20962 r0 *1 88.35,183.4
X$20962 9972 10014 9924 15 10085 27 AOI21_X1
* cell instance $20964 r0 *1 89.3,183.4
X$20964 10044 9926 15 27 10014 NAND2_X1
* cell instance $20968 r0 *1 91.2,183.4
X$20968 9593 10045 9925 15 10087 27 AOI21_X1
* cell instance $20971 m0 *1 92.53,183.4
X$20971 15 10307 10046 9871 9530 27 DFF_X1
* cell instance $20975 r0 *1 94.43,183.4
X$20975 9972 10017 10016 15 10089 27 AOI21_X1
* cell instance $20978 r0 *1 95.76,183.4
X$20978 10047 9926 15 27 10017 NAND2_X1
* cell instance $20982 r0 *1 97.66,183.4
X$20982 9972 10090 9973 15 10048 27 AOI21_X1
* cell instance $20983 r0 *1 98.42,183.4
X$20983 10049 9926 15 27 10090 NAND2_X1
* cell instance $20984 r0 *1 98.99,183.4
X$20984 15 10637 9975 9951 9974 27 DFF_X1
* cell instance $20986 m0 *1 102.98,183.4
X$20986 9975 9926 15 27 10019 NAND2_X1
* cell instance $20987 m0 *1 102.22,183.4
X$20987 9593 10019 9950 15 9951 27 AOI21_X1
* cell instance $20991 r0 *1 102.6,183.4
X$20991 8752 15 27 9974 CLKBUF_X3
* cell instance $20992 r0 *1 103.55,183.4
X$20992 9667 9976 9949 15 10050 27 AOI21_X1
* cell instance $20994 r0 *1 104.5,183.4
X$20994 9593 10020 9590 15 10051 27 AOI21_X1
* cell instance $20997 r0 *1 105.83,183.4
X$20997 10052 9926 15 27 10020 NAND2_X1
* cell instance $20998 m0 *1 107.16,183.4
X$20998 9787 15 27 9928 BUF_X1
* cell instance $20999 m0 *1 106.21,183.4
X$20999 9309 15 27 9926 CLKBUF_X3
* cell instance $21000 m0 *1 107.73,183.4
X$21000 9929 9648 15 27 9930 NAND2_X1
* cell instance $21001 m0 *1 108.3,183.4
X$21001 9667 9930 9806 15 10015 27 AOI21_X1
* cell instance $21002 m0 *1 109.06,183.4
X$21002 15 10360 9929 10015 9400 27 DFF_X1
* cell instance $21005 m0 *1 114,183.4
X$21005 15 10422 9979 9875 9595 27 DFF_X1
* cell instance $21006 m0 *1 117.23,183.4
X$21006 9811 9878 15 27 9783 NAND2_X1
* cell instance $21012 r0 *1 106.97,183.4
X$21012 9667 10018 9927 15 10053 27 AOI21_X1
* cell instance $21014 r0 *1 108.11,183.4
X$21014 10054 9869 15 27 10018 NAND2_X1
* cell instance $21017 r0 *1 109.82,183.4
X$21017 9977 9869 15 27 9978 NAND2_X1
* cell instance $21018 r0 *1 110.39,183.4
X$21018 9667 9978 9873 15 10055 27 AOI21_X1
* cell instance $21021 r0 *1 114.38,183.4
X$21021 15 10639 10058 10091 9595 27 DFF_X1
* cell instance $21028 r0 *1 117.61,183.4
X$21028 9304 10059 9876 15 10091 27 AOI21_X1
* cell instance $21030 r0 *1 119.89,183.4
X$21030 9304 10010 9598 15 10088 27 AOI21_X1
* cell instance $21032 m0 *1 120.46,183.4
X$21032 9932 9878 15 27 9931 NAND2_X1
* cell instance $21035 r0 *1 121.22,183.4
X$21035 10060 9878 15 27 10010 NAND2_X1
* cell instance $21036 m0 *1 121.6,183.4
X$21036 15 10404 9933 9877 9980 27 DFF_X1
* cell instance $21042 r0 *1 122.17,183.4
X$21042 9934 10009 9946 15 10086 27 AOI21_X1
* cell instance $21045 r0 *1 123.88,183.4
X$21045 10061 9878 15 27 10009 NAND2_X1
* cell instance $21046 r0 *1 124.45,183.4
X$21046 8280 15 27 9980 CLKBUF_X3
* cell instance $21048 r0 *1 125.59,183.4
X$21048 9934 10006 9851 15 10062 27 AOI21_X1
* cell instance $21051 r0 *1 127.49,183.4
X$21051 9981 9878 15 27 10006 NAND2_X1
* cell instance $21054 r0 *1 128.63,183.4
X$21054 9972 10004 9850 15 10083 27 AOI21_X1
* cell instance $21055 m0 *1 129.2,183.4
X$21055 9309 15 27 9816 CLKBUF_X3
* cell instance $21059 m0 *1 132.43,183.4
X$21059 9934 10080 8465 15 9983 27 AOI21_X1
* cell instance $21062 r0 *1 130.15,183.4
X$21062 10063 9816 15 27 10004 NAND2_X1
* cell instance $21065 r0 *1 131.67,183.4
X$21065 9982 9878 15 27 10081 NAND2_X1
* cell instance $21066 r0 *1 132.24,183.4
X$21066 15 10641 10064 9983 9814 27 DFF_X1
* cell instance $21067 m0 *1 133.76,183.4
X$21067 9309 15 27 9672 CLKBUF_X3
* cell instance $21070 m0 *1 135.47,183.4
X$21070 8280 15 27 9814 CLKBUF_X3
* cell instance $21071 m0 *1 136.42,183.4
X$21071 9934 9941 8553 15 10002 27 AOI21_X1
* cell instance $21072 m0 *1 137.18,183.4
X$21072 9814 15 27 CLKBUF_X1
* cell instance $21073 m0 *1 137.75,183.4
X$21073 9703 15 27 10076 BUF_X1
* cell instance $21076 m0 *1 139.27,183.4
X$21076 15 10309 9891 9880 9739 27 DFF_X1
* cell instance $21078 r0 *1 135.47,183.4
X$21078 15 10471 9984 10002 9814 27 DFF_X1
* cell instance $21079 r0 *1 138.7,183.4
X$21079 9984 9672 15 27 9941 NAND2_X1
* cell instance $21082 r0 *1 141.55,183.4
X$21082 9934 9986 8630 15 9987 27 AOI21_X1
* cell instance $21083 r0 *1 142.31,183.4
X$21083 15 10541 9935 9985 9739 27 DFF_X1
* cell instance $21085 m0 *1 142.88,183.4
X$21085 9934 9996 8423 15 9985 27 AOI21_X1
* cell instance $21088 m0 *1 145.54,183.4
X$21088 9935 9672 15 27 9996 NAND2_X1
* cell instance $21090 r0 *1 145.54,183.4
X$21090 8280 15 27 9739 CLKBUF_X3
* cell instance $21091 r0 *1 146.49,183.4
X$21091 9972 10068 9538 15 10070 27 AOI21_X1
* cell instance $21092 r0 *1 147.25,183.4
X$21092 9972 9989 9841 15 9991 27 AOI21_X1
* cell instance $21093 m0 *1 147.44,183.4
X$21093 9972 9937 9852 15 9990 27 AOI21_X1
* cell instance $21095 m0 *1 148.2,183.4
X$21095 15 10450 9936 9990 9739 27 DFF_X1
* cell instance $21096 m0 *1 151.43,183.4
X$21096 9936 9816 15 27 9937 NAND2_X1
* cell instance $21106 r0 *1 148.01,183.4
X$21106 15 10518 9988 9991 9739 27 DFF_X1
* cell instance $21107 r0 *1 151.24,183.4
X$21107 9988 9816 15 27 9989 NAND2_X1
.ENDS parameterized_fft

* cell AOI222_X2
* pin PWELL,VSS
* pin C2
* pin C1
* pin ZN
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT AOI222_X2 1 2 3 4 5 6 8 9 16
* net 1 PWELL,VSS
* net 2 C2
* net 3 C1
* net 4 ZN
* net 5 B2
* net 6 B1
* net 8 A1
* net 9 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 17 5 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 15 6 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 4 8 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $11 r0 *1 2.255,0.995 PMOS_VTL
M$11 4 9 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 10 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 4 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.31,0.2975 NMOS_VTL
M$19 14 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.5,0.2975 NMOS_VTL
M$20 1 5 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 4 8 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $22 r0 *1 2.065,0.2975 NMOS_VTL
M$22 11 8 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.255,0.2975 NMOS_VTL
M$23 1 9 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.445,0.2975 NMOS_VTL
M$24 7 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI222_X2

* cell INV_X16
* pin PWELL,VSS
* pin A
* pin ZN
* pin NWELL,VDD
.SUBCKT INV_X16 1 2 3 4
* net 1 PWELL,VSS
* net 2 A
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 4 4 PMOS_VTL L=0.05U W=10.08U AS=0.72765P AD=0.72765P PS=13.02U
+ PD=13.02U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.479325P AD=0.479325P PS=9.365U
+ PD=9.365U
.ENDS INV_X16

* cell AOI221_X4
* pin PWELL,VSS
* pin ZN
* pin C1
* pin C2
* pin A
* pin B1
* pin B2
* pin NWELL,VDD
.SUBCKT AOI221_X4 1 4 7 8 9 10 11 14
* net 1 PWELL,VSS
* net 4 ZN
* net 7 C1
* net 8 C2
* net 9 A
* net 10 B1
* net 11 B2
* net 14 NWELL,VDD
* device instance $1 r0 *1 1.16,0.995 PMOS_VTL
M$1 14 11 13 14 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U
+ PD=0.77U
* device instance $2 r0 *1 1.35,0.995 PMOS_VTL
M$2 3 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 1.73,0.995 PMOS_VTL
M$4 4 3 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $8 r0 *1 0.25,0.995 PMOS_VTL
M$8 2 7 12 14 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $9 r0 *1 0.44,0.995 PMOS_VTL
M$9 12 8 2 14 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 0.63,0.995 PMOS_VTL
M$10 13 9 12 14 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.82,0.995 PMOS_VTL
M$11 14 10 13 14 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $12 r0 *1 0.25,0.2975 NMOS_VTL
M$12 5 7 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $13 r0 *1 0.44,0.2975 NMOS_VTL
M$13 1 8 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0342375P PS=0.555U
+ PD=0.58U
* device instance $14 r0 *1 0.655,0.2975 NMOS_VTL
M$14 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.0342375P AD=0.02905P PS=0.58U
+ PD=0.555U
* device instance $15 r0 *1 0.845,0.2975 NMOS_VTL
M$15 6 10 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0549875P PS=0.555U
+ PD=0.68U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 1 11 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.0549875P AD=0.02905P PS=0.68U
+ PD=0.555U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $19 r0 *1 1.73,0.2975 NMOS_VTL
M$19 4 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AOI221_X4

* cell OAI222_X2
* pin PWELL,VSS
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT OAI222_X2 1 4 5 6 7 8 9 10 11
* net 1 PWELL,VSS
* net 4 C1
* net 5 C2
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 ZN
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 12 4 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.405,0.995 PMOS_VTL
M$2 11 5 12 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.595,0.995 PMOS_VTL
M$3 13 5 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.785,0.995 PMOS_VTL
M$4 10 4 13 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 14 6 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.165,0.995 PMOS_VTL
M$6 11 7 14 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.355,0.995 PMOS_VTL
M$7 15 7 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.545,0.995 PMOS_VTL
M$8 10 6 15 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0945P PS=0.77U PD=0.93U
* device instance $9 r0 *1 1.895,0.995 PMOS_VTL
M$9 16 8 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0945P AD=0.0441P PS=0.93U PD=0.77U
* device instance $10 r0 *1 2.085,0.995 PMOS_VTL
M$10 11 9 16 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.275,0.995 PMOS_VTL
M$11 17 9 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.465,0.995 PMOS_VTL
M$12 10 8 17 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0693P PS=0.77U PD=1.48U
* device instance $13 r0 *1 1.895,0.2975 NMOS_VTL
M$13 10 8 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $14 r0 *1 2.085,0.2975 NMOS_VTL
M$14 3 9 10 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 0.215,0.2975 NMOS_VTL
M$17 1 4 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $18 r0 *1 0.405,0.2975 NMOS_VTL
M$18 2 5 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 0.975,0.2975 NMOS_VTL
M$21 3 6 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $22 r0 *1 1.165,0.2975 NMOS_VTL
M$22 2 7 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI222_X2

* cell LOGIC1_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC1_X1 2 3 4
* net 2 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.2125 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.135U AS=0.014175P AD=0.014175P PS=0.48U
+ PD=0.48U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 1 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC1_X1

* cell LOGIC0_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC0_X1 1 3 4
* net 1 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.19 PMOS_VTL
M$1 4 2 2 4 PMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 2 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC0_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell AOI211_X4
* pin C1
* pin C2
* pin B
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI211_X4 1 2 3 4 8 9 10
* net 1 C1
* net 2 C2
* net 3 B
* net 4 A
* net 8 PWELL,VSS
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 6 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 3 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 11 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 6 9 9 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 5 9 9 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 12 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 8 2 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 6 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 5 6 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 10 5 8 8 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U
+ PD=2.705U
.ENDS AOI211_X4

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell OAI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X2 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 12 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 4 12 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 11 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 6 3 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 7 1 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 5 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 8 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.12,0.2975 NMOS_VTL
M$14 5 4 8 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI22_X2

* cell OAI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin A2
* pin ZN
* pin A1
* pin NWELL,VDD
.SUBCKT OAI22_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 4 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 8 3 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 3 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 14 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 8 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 15 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 15 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 8 5 16 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 1 3 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 2 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI22_X4

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X8 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell AND2_X4
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT AND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 3 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 8 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.55,0.2975 NMOS_VTL
M$11 7 2 3 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.74,0.2975 NMOS_VTL
M$12 6 1 7 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 3 6 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND2_X4

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell BUF_X32
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X32 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.729225P AD=0.707175P PS=13.025U
+ PD=12.325U
* device instance $17 r0 *1 3.215,0.995 PMOS_VTL
M$17 4 3 5 5 PMOS_VTL L=0.05U W=20.16U AS=1.4175P AD=1.43955P PS=24.66U
+ PD=25.36U
* device instance $49 r0 *1 0.17,0.2975 NMOS_VTL
M$49 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4803625P AD=0.4658375P PS=9.37U
+ PD=8.885U
* device instance $65 r0 *1 3.215,0.2975 NMOS_VTL
M$65 4 3 1 1 NMOS_VTL L=0.05U W=13.28U AS=0.93375P AD=0.948275P PS=17.78U
+ PD=18.265U
.ENDS BUF_X32

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell AND3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AND3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 4 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 3 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 11 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 10 2 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 4 3 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 9 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.12,0.2975 NMOS_VTL
M$16 5 1 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND3_X4

* cell AND4_X4
* pin PWELL,VSS
* pin A4
* pin A3
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT AND4_X4 1 2 3 4 6 7 14
* net 1 PWELL,VSS
* net 2 A4
* net 3 A3
* net 4 A2
* net 6 A1
* net 7 ZN
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 14 3 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 5 4 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 14 6 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 7 5 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.375,0.2975 NMOS_VTL
M$14 9 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.565,0.2975 NMOS_VTL
M$15 10 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.755,0.2975 NMOS_VTL
M$16 5 6 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 12 6 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 11 4 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 13 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 2 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 7 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND4_X4

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell OR2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT OR2_X4 1 2 3 5 6
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 4 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 4 3 3 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR2_X4

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell FA_X1
* pin PWELL,VSS
* pin B
* pin CO
* pin S
* pin CI
* pin A
* pin NWELL,VDD
.SUBCKT FA_X1 1 2 3 8 11 12 14
* net 1 PWELL,VSS
* net 2 B
* net 3 CO
* net 8 S
* net 11 CI
* net 12 A
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.385,1.0275 PMOS_VTL
M$1 17 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $2 r0 *1 0.575,1.0275 PMOS_VTL
M$2 4 12 17 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.765,1.0275 PMOS_VTL
M$3 15 11 4 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02265P PS=0.455U
+ PD=0.535U
* device instance $4 r0 *1 0.96,1.1025 PMOS_VTL
M$4 14 12 15 14 PMOS_VTL L=0.05U W=0.315U AS=0.02265P AD=0.02205P PS=0.535U
+ PD=0.455U
* device instance $5 r0 *1 1.15,1.1025 PMOS_VTL
M$5 15 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $6 r0 *1 0.195,0.995 PMOS_VTL
M$6 14 4 3 14 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.033075P PS=1.47U
+ PD=0.77U
* device instance $7 r0 *1 1.49,1.1525 PMOS_VTL
M$7 16 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $8 r0 *1 1.68,1.1525 PMOS_VTL
M$8 14 11 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 1.87,1.1525 PMOS_VTL
M$9 16 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $10 r0 *1 2.06,1.1525 PMOS_VTL
M$10 7 4 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.023625P PS=0.455U
+ PD=0.465U
* device instance $11 r0 *1 2.26,1.1525 PMOS_VTL
M$11 18 11 7 14 PMOS_VTL L=0.05U W=0.315U AS=0.023625P AD=0.02205P PS=0.465U
+ PD=0.455U
* device instance $12 r0 *1 2.45,1.1525 PMOS_VTL
M$12 19 2 18 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $13 r0 *1 2.64,1.1525 PMOS_VTL
M$13 19 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $14 r0 *1 2.83,0.995 PMOS_VTL
M$14 8 7 14 14 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $15 r0 *1 0.385,0.32 NMOS_VTL
M$15 13 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.0147P PS=0.555U
+ PD=0.35U
* device instance $16 r0 *1 0.575,0.32 NMOS_VTL
M$16 4 12 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $17 r0 *1 0.765,0.32 NMOS_VTL
M$17 5 11 4 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.015225P PS=0.35U
+ PD=0.355U
* device instance $18 r0 *1 0.96,0.32 NMOS_VTL
M$18 1 12 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.015225P AD=0.0147P PS=0.355U
+ PD=0.35U
* device instance $19 r0 *1 1.15,0.32 NMOS_VTL
M$19 5 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $20 r0 *1 0.195,0.2975 NMOS_VTL
M$20 1 4 3 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.021875P PS=1.04U
+ PD=0.555U
* device instance $21 r0 *1 1.49,0.195 NMOS_VTL
M$21 6 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $22 r0 *1 1.68,0.195 NMOS_VTL
M$22 1 11 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $23 r0 *1 1.87,0.195 NMOS_VTL
M$23 6 12 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $24 r0 *1 2.06,0.195 NMOS_VTL
M$24 7 4 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.01575P PS=0.35U PD=0.36U
* device instance $25 r0 *1 2.26,0.195 NMOS_VTL
M$25 9 11 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.01575P AD=0.0147P PS=0.36U PD=0.35U
* device instance $26 r0 *1 2.45,0.195 NMOS_VTL
M$26 10 2 9 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 2.64,0.195 NMOS_VTL
M$27 1 12 10 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $28 r0 *1 2.83,0.2975 NMOS_VTL
M$28 8 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS FA_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell BUF_X16
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X16 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.3528P PS=6.86U PD=6.16U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 4 3 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.7056P AD=0.72765P PS=12.32U PD=13.02U
* device instance $25 r0 *1 0.185,0.2975 NMOS_VTL
M$25 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.2324P PS=4.925U PD=4.44U
* device instance $33 r0 *1 1.705,0.2975 NMOS_VTL
M$33 4 3 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4648P AD=0.479325P PS=8.88U PD=9.365U
.ENDS BUF_X16

* cell MUX2_X2
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin Z
.SUBCKT MUX2_X2 1 2 3 6 7 8
* net 1 A
* net 2 B
* net 3 S
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 Z
* device instance $1 r0 *1 1.16,0.995 PMOS_VTL
M$1 8 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.077175P PS=2.24U PD=1.54U
* device instance $3 r0 *1 1.54,1.1525 PMOS_VTL
M$3 9 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $4 r0 *1 0.215,0.995 PMOS_VTL
M$4 6 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $5 r0 *1 0.405,0.995 PMOS_VTL
M$5 5 9 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 0.595,0.995 PMOS_VTL
M$6 4 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.045675P PS=0.77U PD=0.775U
* device instance $7 r0 *1 0.79,0.995 PMOS_VTL
M$7 5 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.045675P AD=0.0693P PS=0.775U PD=1.48U
* device instance $8 r0 *1 1.54,0.195 NMOS_VTL
M$8 9 3 7 7 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.02205P PS=0.555U PD=0.63U
* device instance $9 r0 *1 1.16,0.2975 NMOS_VTL
M$9 8 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.050925P PS=1.595U
+ PD=1.11U
* device instance $11 r0 *1 0.215,0.2975 NMOS_VTL
M$11 11 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.405,0.2975 NMOS_VTL
M$12 7 9 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.595,0.2975 NMOS_VTL
M$13 10 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $14 r0 *1 0.79,0.2975 NMOS_VTL
M$14 4 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.043575P PS=0.56U
+ PD=1.04U
.ENDS MUX2_X2

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2
